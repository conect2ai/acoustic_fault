#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.7234378112900065, 1.5716463140444816, -1.3576254081604995, -1.7973098326872836, 0.28886659821558536, -1.7942037856478894, 0.8808499288151963, 0.47669976136200076, 0.6966066477532085, -1.07199593115489, -2.120431791175185, -1.3123128504695292, -1.4241526919153527, -1.2745879337954353, -1.0970072748404474, -2.0222052066264014, 0.0787906121940621, 0.7177031815955658, 0.39010536241584054, 0.6517062178455472, -2.1378891444114867, -0.8867535297954785, -1.4787357748365424, -0.2875324952200045, -0.007416653717577365, -1.856595713325367, -2.367076471725438, 0.12700749148871027, 0.9592328699051426, 0.1869030000915018, 0.7180930229203903, -0.6716957239187556, 0.17180157785922928, 0.2639644854323162, -0.24325949126914956, 0.5674066722832634, -0.5206787519093766, -0.3973245853930097, 0.1412106736982883, -1.018935014806728, -1.7094708627224688, 0.27275474953293644, -0.10196885344499625, 3.003890931769825, 0.7280542518494577, 2.0666174582134715, -0.5154496798444552, 0.5710433167620249, -0.36253523804958554, -0.557551199160791, -0.7128081518715705, 2.5220076138962466, 0.06672527096987275, -2.28974377089557, 0.41936063199474716, -2.1768652796437364, 1.6533339467956671, 0.6833086168084931, 0.8161954951916848, 0.1194544643558948, 1.5861838249441609, -1.1287937514994557, -1.9822214282980875, 0.5063665570588528},
    {-0.020780016748326306, -0.7393553109694397, -1.0106350052471547, 0.008668173949952245, -1.061534058307885, 0.8178238030763129, -0.681610217187966, -1.1400100527091634, -2.409567123123654, -1.3936999044874774, -1.4687653239685297, 1.3721911505309274, -0.5347440969289302, 0.7611066572438802, -2.43008689243449, -0.8852251952565289, -1.4930597552079767, 0.9200156333042866, 1.7374728449554635, -2.858648634695023, -0.19283736201619425, 0.25151770860239037, 0.47170399058728407, 0.29623046090995964, -0.6591504247898066, 0.7461084214365769, 1.2487505110643742, -0.2570010543795325, 0.6601697821491043, 0.10103174462571186, -0.18387617592800481, 1.19304105288435, 0.8815212468857873, 0.07908428589292084, 0.9742515768798266, -2.6050393325171166, 0.8643739071353949, 0.11929461709489093, -0.857386371325642, 0.6251429735001962, -0.8346600282630453, 1.3020797869796306, -0.25739698511657627, 0.6554839591441745, -0.9104637321877765, 0.4132427578618208, -0.9611582608149849, 0.5054997203529011, 0.24696826002589575, 1.3243060167250535, -0.10719567353233228, -1.2093558872335595, -0.1132499212354045, -1.1174959868344643, 0.7191300185105098, 0.7896490673526433, -1.1947112906923887, -1.6564654161355783, 0.6988454890757713, -0.31891165779585573, 0.5912230260090743, -0.34172074598885793, -0.07736830017276589, -1.3015454039289696},
    {-1.7606764683929061, 0.5110678051267437, -0.27141599350083895, -1.9097689741608788, -0.30420832037792767, 1.078345676935264, -1.4372615599270717, 1.4704325237378513, 2.908286992719363, -1.7290317531245325, 0.10992305233636034, -0.0016395123147556027, 0.3196997670261977, 2.6161519311707284, -1.870077475453158, 0.4577057847761769, -0.3352660458978539, 0.8297147722604484, -0.42880959251816236, 2.4172379530867825, 1.4770536455394419, 0.8203860252139596, -3.549564603892635, 1.1522113955556321, 1.2608916310527143, 0.9360278172487407, -1.1786704516932993, 3.159645839007312, -0.3639475807383625, 0.10687736399679873, 1.7064530485954192, -0.8383062324308362, 2.0553852610640146, 0.10366369435124889, 1.943543779925215, 2.367955275345827, 1.4774027213664256, -0.5448310026560588, -0.06052057795667847, 1.5562071378917173, 1.3045078686273341, -0.6547935751008004, -0.8191610156055839, 0.306559616009288, -0.484023026385457, 1.5130261610629636, -0.03683186794757487, -0.9159634570197349, 2.5241203485712367, -0.29743504127055265, 1.8649469189422974, -0.49729897545311563, 0.43802520341085316, 0.25067234211559425, 1.3322091633073982, 0.927093722560856, 0.8602414654357396, -1.3813591208850087, -0.5193357369705458, 0.6078487418392133, -1.1371984556822148, -0.8455026356818232, -1.6346945589238937, 0.45391909335424047},
    {1.7243402819485565, 0.5771976598069769, 1.7560720340744356, 0.2896626015530965, 0.7233627367567944, 0.6012343238545554, -2.099648287241361, 1.7247588949823638, 1.4392376328118355, -0.6970985654605173, 1.3092741818059401, 0.72753799655744, -1.4043588283920712, 3.432000466042951, -0.7322291609881662, 0.9053165656532072, 0.6208270372931735, 0.8399545402448901, 0.3117108634167731, 0.9800058263378588, -0.8367327412980404, -1.1179132537479881, 0.8430043023942475, 0.78753703893521, -1.8501342823890665, 0.23502236913210003, 0.09195883129306569, 0.5890933246554252, 1.3763640145631288, 0.7704413139323347, -1.4938614608340715, 1.7216931786043077, 0.7027683047851815, 0.21648123964940008, -3.163130743333665, 1.6916257879636158, 1.4574972383683176, 0.13093352951564052, -0.5652214597554613, 1.6267264502347782, 2.512151471427185, 0.5892055991434477, 0.792920299616286, -0.08465861486573112, 1.112011598367468, -0.06779087411132625, 2.169187483020178, 1.423406079193389, 0.009754511165258533, -0.30802791854906947, 2.785948780846572, -0.3757961448030861, 3.3146445160175184, 1.57661448475842, -0.8385655760008028, -0.557132401202641, 1.5271390897183938, 0.9952996494555197, 1.7231583060954083, 0.21017218554334674, -0.2496393139520391, -1.1945284669089513, 1.2610625123506258, 0.8555411641698136},
    {2.3150602336259514, -2.091780188628909, -0.4079385081452077, 2.0753631993588453, 1.311390858913591, -2.4015807580134894, 0.8036203937879405, -0.4373653752859766, 1.5406100389214221, -0.2871355839957826, 1.1432482619304265, -0.9522627865307772, -0.2911070426664996, 0.6779892895690954, 0.23832208186734427, -0.3034994136888127, -0.024749894695775765, 0.805290957601362, 1.874864791268674, 0.2931172130040983, -1.2380015753328304, 0.025335373299033882, -0.47017343387696114, 0.8902342166055938, 0.7036918641738833, 1.5046418273155533, -1.918290066880099, 0.787484071046096, 0.6489912893803436, 0.19681474429604004, 1.5173272704429155, -0.5185657378431064, 1.014567196949209, 0.029793662557205197, -0.4403755563519787, 0.760512521977287, -0.6667631721690955, -0.8620361093298384, 2.290494081479167, 2.0181734994051825, 1.1321309506295403, 1.8158571614382744, -0.4222594287547129, -0.8391457341671528, -1.0870910797480449, -0.008463479070790555, 0.15689211068655384, -0.8024120258256375, 1.482141360226071, 0.41253310122281434, 0.4276163548629273, -2.2068962620430437, 0.6221745447649348, 1.716563561662017, -0.9962552998218729, 2.470014313149983, -0.04165711977765963, -1.110142044177644, 0.14699996630048254, 1.1714841287892122, 1.4197255332371066, 1.3013766992778053, 0.5258878528912917, -1.339300767591688},
    {-0.05788674819005055, -1.5585965682428211, 1.013879341423025, 0.873623871037892, -0.10963207349804364, -0.4823051814287104, 0.5846794211412039, -1.5103710318565764, 1.981818299783227, -0.9231073955768204, 1.069531574150037, -1.705636182598065, -1.0825177084998694, 1.9107837327931902, 0.2330771940352615, 1.3997789504904115, 2.259264628383287, 1.9776276018250476, -1.9875753393795967, -0.4934455911351749, 0.7485013464169444, -0.14875637387633017, -0.8564330484303542, 0.9952489991116475, 1.0180124072412111, -0.33634488228695497, -1.109432404731214, -2.2297967097992526, 3.2105884701979135, 0.5813052038752397, -0.4950401289837074, -0.6285223869707278, -0.7375320744050252, -0.7905903173672033, 0.22699957919596161, 0.303256686492904, 0.6847933379679509, 0.5585154950921629, 0.6735922254483145, 2.6108339434144776, -0.5086505706178027, -0.5776176280731886, -0.43796197255964, -0.22837513165664922, -0.5514652458840139, 0.7993738788606978, 2.232997646364005, -0.18497064783803538, 2.0932129022907686, -0.48509387752769034, -0.7695592658776658, -1.002301086822102, 0.21814976760797544, 1.355325002199636, -0.7102045241673232, 0.09443883139563249, 0.1085895199490071, 1.3091225756520957, -0.1953971626310499, 1.5829570608052084, -0.24090400940873494, -0.03455358135154452, 1.853643547140988, 1.06787418428844},
    {0.44040662445324225, -1.601647758842783, 1.1568578511290348, -1.7227555867696147, -1.3429005963299048, -2.2431909624523194, 0.7701206779200854, 0.031040067187256878, -0.8959685886788309, -0.5300993400323617, -0.7943468612293839, 0.8355045690730242, 1.4969540814796023, 0.6555188680423906, 1.574359894726403, -0.7421853978463007, 0.42821559975199697, 0.49952890025150315, -0.7595136018556512, 3.828480263414833, 2.739849087941411, 0.5607791651181431, 2.0811554248512567, 0.18697289673928827, -1.2176829365005515, 1.474888629762486, -1.1003189382768326, -0.2817792780182465, 2.9590404405786073, 0.6890392414295055, -0.5732105939708788, 1.796590949034266, 0.4945642263020446, -0.23190191827958215, -0.9553511583871437, 0.8795140673340979, 0.931838735217155, 0.2551956897427157, 3.1224950511418466, -0.10716384629905588, 0.8032542741475334, 0.040029593986746374, 1.982392827640352, 0.34456778763302165, 0.9068565569437018, 0.11831402228228463, 1.715805372002828, -0.08653694778642, 1.6869199496718599, -0.37012513396272073, -0.7791781640762391, -1.8546538582196777, 1.057810425588828, 1.2489849637630144, 0.4053237797352984, 0.2868066097573065, -0.37564049331845356, 1.0734096013836725, 0.7028161305610762, -0.9770706525918645, 0.08418891151453117, -0.4569785449570231, 0.9276470808521128, 1.5008577442969702},
    {-0.17852645485490345, 1.6800294221385303, 0.46851439676580403, -3.2544267747701494, -0.6844010967585191, -2.154060072347996, 1.2414345235532438, -2.151194000118371, -0.28914406882063654, -1.925753961743467, -0.244245683288824, 0.9011897450493369, 2.239848927185081, 0.7606780425186025, -1.3667913486610705, 0.7690855256887631, 1.3799149821252723, -0.9552439278997483, 0.9401960404662503, -1.3774801934300756, -0.17609160049880224, 0.8408872165349485, 0.7080715522243287, -1.003304529374891, -1.285708927777367, 0.8082260140259208, -0.227389588659986, 2.167072835601608, -0.1157523636652145, 0.21671373975016284, -0.3330983860235255, 0.583113295906312, -0.37828591357976815, -1.4239023455279385, -0.44453115817972527, -0.9613211858016742, 0.1644560940692922, 0.9063862035628172, -0.4962797152382562, -0.10342678174835891, -0.669698617477701, 0.9330769898520559, 2.0886231512475537, -1.090294628912726, 0.29166741886106334, -0.43027993717735497, -0.9015197745813198, 0.922734808829195, 0.07557384207674551, 0.6120664799045253, -0.31685777629012046, 0.9333414452804124, -0.3993548246948973, -0.6412509307744928, -1.6521343916721194, -1.1593445128868112, -0.17744828494737108, -0.6981406128558622, 0.6549637555095716, -0.5585990761548302, -0.5159910934124402, -1.3223791096003887, 0.5159895605181457, 0.7684955841619767},
    {-0.8782441419438395, 1.192388084776734, 0.7074884753966307, 2.2022148212715953, 0.11597132956113249, 0.09667993312909207, -1.3555827427112053, -1.455767451220087, 0.8774685809441708, -1.1346158452344743, 0.4252190333587918, 0.5474663522421048, 0.6478142349976114, 0.141586132901836, 0.7360119895421461, -0.5167995261147598, -1.0401720605391542, -1.1852031336590438, -0.33731237426292204, 1.1660137947568106, -2.2126797507633706, -0.3266696732382434, -0.3640437260695232, 1.238632426039417, 0.06659812396259829, 1.2239169811880366, -0.8212215849867791, 1.9071866998707085, -0.6105084921032072, -0.6313581444664312, -1.2989234345754088, 1.636964909994085, -0.14709123973337387, -0.6026945195990377, 0.3183464005794402, 0.6175984395875115, 1.6335134979255184, -1.1273245838662764, 1.15668158547546, -0.17888863713178685, 0.23388162338212465, 0.9737675336251896, -1.1420834651664522, 0.6586004149650925, 0.12177859914938662, 0.056790840028944835, 0.41297806587897157, 0.3730483878864884, 0.9889292388961834, 0.12976887857050362, 2.553753638518483, -1.2777500903167478, 1.7575777836624153, -0.26754067077877497, 0.34773408580687476, -1.029843911620441, 1.5687232027757998, -0.3907884131909474, 1.733683540143698, 0.3675416035103514, -0.3118922525887668, -1.500726776503271, -0.489768186345394, -0.5484892960876047},
    {1.6532661451090158, -0.18546928379141775, 0.7425986000131886, -1.3728388431423593, 0.8510949975166278, -0.6252671948473529, -1.7321217300782326, 2.0655705260925004, 0.3081565222342178, 0.8288212624479931, -0.6685577092192196, -0.05292921955727987, 1.578309848014134, -0.5472016309818513, -0.1304128543291184, 1.2246662658850436, 0.1443986927365958, -0.6881711668264159, -0.5547015682936814, -1.1492938754464006, -1.7673679599894871, 0.3707504124219367, 0.36392890186503846, -1.0777120861039322, 3.2146956856999216, 1.276516222125983, 2.1882976879223923, -0.647609283178822, -0.7011447111093024, -3.69959824440637, -0.5534404093155757, -0.30946817052285186, 0.3991461440766433, -0.07379324132070379, 0.32289112107146234, 1.4698739457505403, 0.8639573000592715, -0.3330632926305762, 0.819922026598618, 0.9102925437695558, -0.49336775539239536, -0.07711933590675733, 1.2239330195492801, -0.4052788829558798, -1.1022979530194315, -0.44723909901772024, -0.4530251485525272, -2.791516352334464, 0.9184235884382596, -1.069816782922585, -1.7786848369217416, 0.7569191089193301, 0.4226183365470123, -2.3536731369379913, -1.4235388619694216, 1.4682726111967566, -1.0320150863539124, 0.6259535527033959, 0.18959473702924895, -0.06674265277310813, 0.6510590014100027, -0.8858558729496903, 2.1663475655610815, -0.32727014803492255},
    {-0.2559819160397379, 1.6520757307065177, 1.0572243224366524, -0.23421630260557064, -1.3802780545128817, 0.9629345179106215, -1.9693322677867118, 0.24429728717616495, 0.6172431283097752, -1.4061160332606029, -1.6486695128926656, 1.8506275059224422, -1.171262208185976, -0.6876214520765258, -1.045110186469713, 0.9572421024896423, -1.4686276823472206, -0.7960665082127922, -0.24279134585342582, -1.2413873788107084, -1.147567198798066, 0.27711617536751304, -0.422121876143711, 0.7967287178035851, -0.5155232026510159, 1.0919840268482752, -0.8117593211606415, -1.7951685904863772, 0.46265491061091757, 0.6053112113241476, 1.1545045709769723, 0.1659892210092697, -1.8810123791005668, -0.5101958139882786, 0.29253505518882517, 1.0768450518214323, 0.6722207735728533, 0.9798617828935217, 2.3315610473427286, 1.2820025352660447, 0.5511344762779865, -0.025804044643023934, 2.128182157150052, 1.603623175720608, 0.21203435437798498, 1.1038507393510628, -1.2368711146956661, -0.060158987256763184, -0.021860010797505942, 1.181740059421673, 1.844186963941023, 0.03231415132061635, 0.4106008583374391, 0.807101501389688, -0.299901886507336, -2.680282777730586, -1.410829898388006, -0.30522461962118264, -1.1980462762227766, 1.265601143949469, 0.6858163691622041, -0.8076283343671401, 2.786389259786274, 0.11701154391998556},
    {-0.05548813536319957, -0.13222357912335722, -0.7878990217977153, 0.8104312797821308, 0.6861319578531786, 0.3805823383341822, -1.8526754464325312, -0.6693672296750074, 0.7767427850515997, -1.4858639449189162, -0.31870529006523385, -0.14986220381916238, 1.8136912013465978, -0.5825497336356225, 1.5331548901581378, 0.746151232174511, -0.7208575479471285, 0.23115095850892267, 0.7057189871998503, 0.5475629583522437, 0.4041632780494262, 0.26751283028385253, -0.6639371716556696, -0.7107105401134364, 0.34645321846377874, -1.2273276840672867, 1.4735874600832495, -0.5368721652863958, -1.0640610075517638, 0.34183329412561575, -0.805682459310374, 0.12858558293129865, 0.6772348515232379, -1.0688282262907052, 0.3718687279636486, 0.921629546070199, -0.15154112106726486, -0.9692305573159179, -0.776381382165527, 0.6464992459700045, 1.2061078936711507, -0.3517192825747478, 0.015640298247168016, 0.13248716699631188, 1.4901970389104235, -0.41664598555591464, -0.31581127231122486, -0.16902671281708165, -1.373379469155704, 2.271160018432844, 1.0996959868220335, -1.1151544867085517, -2.549842275537234, -1.730096086062259, 1.86873543162037, 0.21470989202109994, -1.1462265705600485, 0.6758031264330906, -0.0876035169467139, -1.655851036008098, 0.0018534718388869334, 1.1552189732556557, 1.1635417701033044, -0.39476191507652836},
    {-0.15901899892582122, -1.4383877055402976, -0.1019745487922093, -2.4148426020108364, 0.1797811030110743, -0.7261984141289376, 0.11334995788127472, -0.8983210261118443, -0.40747414230816675, -0.8269784583669182, -1.1133749906650352, 0.9297794507367538, 2.0356999228297026, 1.2960635170451529, 0.23189045605384004, 0.7300880150499606, -1.6845125491434245, -1.3916707864405966, -1.6867157563636395, 1.1538263397107218, -0.7677521191604996, 0.03002210235564243, 0.5537555889996946, -0.5934856292173268, 0.06275480308459502, 0.5033013139953518, -1.7783555099263801, -1.4061785694734865, -0.6439449378717788, -0.9962450685299323, -0.20823800564881878, 0.942561907422273, -1.9956218999902697, 0.9808023788073277, 0.3806907207644724, -1.3040456160820573, -1.6679793783112336, 0.29934352436115463, 0.7934806121043813, -1.9575875885062264, -0.7216448373399651, 2.299562279774351, -0.540082043482396, 1.5972328205798536, 1.1880072826218702, -0.14314241003833306, 1.5130451578783428, 1.0055967262943224, 1.5079554905068357, 0.814379523837717, -0.47098828145313637, 1.3086049151940444, -0.28329231672417055, -0.8669182547216493, -1.0922295301535907, -1.5741120754551907, 0.2581977683951733, 0.04696436780797917, 0.4162654977808274, -1.0986971052044954, 2.631663318504785, -0.8229773448741786, 1.4326230716127808, -0.384112151080347},
    {0.8844819565801264, 0.25817226092390755, 2.0627757242145774, 1.5985911721457555, 1.1846572143940894, -0.44136033914454154, -0.7699900634143666, 1.0849664548078302, 1.2918244898598277, -0.7391968203236137, 0.24407076235036632, 0.35261954896239106, 0.037158988748485784, 2.1785256649733373, 2.878424056637911, 1.643316430625541, 1.728709190780453, -1.6169207796498672, -2.0725094305106717, -1.7480625691593286, -0.006435329929260608, -0.8402800679488178, -0.6141103813371053, -0.33529353880816604, -0.2292970085736852, -0.2306959005169323, -1.0138907256273386, -2.0295858963808167, 1.052838403663462, 0.5519674310714601, -0.9123675470055868, -0.8745802506271013, 1.0237912558161506, -0.3675006775208643, -1.7517133976278414, -2.1070667996019607, 0.30523821380967026, -0.16955815220241702, -0.57171533681344, 1.882694190535477, 0.4178490890561358, 0.23436083247082512, 1.8264870651945513, 0.628803685328523, 0.6092141829023671, 0.7521644598661507, 1.5748629807789163, 0.3471020386868497, -0.4501074686199889, 0.31480852834729306, 0.6249378691936118, 0.6941989973349367, -0.1018915757886413, -1.8720111378531257, -0.7858631036621949, -0.08756043987479618, -0.02898939063497287, -0.16676980194924423, 0.2873616436317781, 1.9051020733139739, -0.4398200873726786, 1.7083963767683823, 0.37143482360635766, -0.5366240556447449},
    {1.1490979943318866, -1.8367900342680032, -1.15150018237086, -0.4235149053066376, -0.2082510073908436, -0.382889689295326, -0.3831407410800643, -0.4790697608383864, -0.7975019812461736, -1.9821704691835547, -0.9699791481273948, -0.5820818856260045, -1.6622628304769413, 0.8475588703598727, 1.3458641310728363, -0.9814491581772777, -1.5252695000351733, -0.8553381397170305, 1.4032095627763352, 0.43737934932415046, -1.3932303040658849, 3.0960435706779705, -0.48025173641659463, -0.12312516192173524, -0.1852361011270609, -1.0547321789558208, 0.5316439040283237, 0.424174677649432, 0.37248157664325726, -0.9593103447501355, -2.172461049278388, -1.0495267173234788, 0.5508111560627376, 0.011651355030950728, -0.9341185578236257, -0.4031541887650295, 1.1486753539124053, 1.9580736569116362, -0.7576656341258455, 0.2934556136588961, -2.7060097621972683, -0.09101376808156629, 1.3280062582529517, 0.22921068290943872, 1.276007048731993, 0.7628770866589734, 0.5462670968364285, 1.5574819498015582, 1.110768030914178, -0.2067323015996748, 1.1919552006513026, 0.05098532377591772, -0.28185548945908806, -1.2429106663016791, -0.7697727410384348, -2.001502790095353, -1.0947439633557985, -0.45677871919422675, -0.2882435255360415, 0.2133363768471185, -1.6608108559966406, -1.1065699173334145, 0.7403826022215705, 0.38655815837580026},
    {0.7774827589387618, 0.5715417658485735, -0.3667414343527573, 0.5244824225497728, -3.1095348480214695, 1.3128494098499928, -1.2145892688998634, -1.7586929596771494, 1.5887479061247358, -1.2260965267031714, -0.452472450233677, 1.2118741505500257, 2.3799203791870336, 0.498350751088685, -0.1804200005040223, 0.044006999100025965, 0.32817003316477394, -2.6755259291149454, -1.6269810082604994, -1.4449485390467804, 0.15191744564369253, -0.07815148621798662, -0.4001027068338169, 0.358431837515177, 0.10566481135945113, 0.9189667435860827, 0.031419149789340566, 0.08671151089893012, -0.38911850726231256, -0.09035139358261138, 0.5825867698998616, -1.5146395554456802, 1.4518186511317668, 0.41955063177735785, -0.38981817467907587, -1.6591377457277743, -1.4395205440303973, 0.46107510406019603, -0.9083328123317352, 0.34514548681194107, -0.6395712966771911, 0.7227129523510273, -0.9923186482128189, 0.2446564574150149, -1.1323182297482606, 0.36409924456290976, 0.35246863682787305, 0.47964735801158737, -1.164443876600139, -1.3133105049442446, 1.7585127702960643, 0.1784374709221972, -0.22662848658380627, 0.32622799347513964, 0.7544684485453135, 1.3744853607530252, 1.7842624789833927, -0.49584585559275335, -1.4452960324493571, -0.28402365042734107, 1.243163716674546, -0.4449743200514533, 0.534893090109214, -1.7418137527737896},
    {-1.444531813851533, -0.9284013467716431, 1.7574825406331342, -0.7968766548053078, -0.8913284583934763, 0.4301223235858634, 0.578228846761931, 1.1194680195053803, -1.8884907146284138, -0.6962066332757132, -0.19189114556011333, 1.12517514957895, -0.20836594560213423, 0.49265711323453126, 3.01163499696685, 0.4532357380830821, 0.5079919114867679, -2.1605568383638305, -0.8867549907435893, 2.116325653829417, 1.0654387567786483, 0.9165495711130366, -1.463798219227561, 0.504402223964121, -0.2684427232967555, 0.502237435331662, -0.6952847596265921, -0.4358311624717802, 0.6729291316381141, -0.07174907218362007, 0.14054051970479636, 2.2367804536008498, 0.5900917736232428, -0.19954407461592752, -2.401264421713587, 0.06613848885245958, 0.9389499913341175, -0.6041157659547982, 0.2585161478409742, 1.4714198127809794, 0.696056334312249, 0.20741035565396776, 0.8663950469492864, -0.511349001765687, 3.1886610527510904, 1.1274289948609, -0.7055668241912605, -2.12444747779237, -0.4029381627626767, 0.36958096274517166, -1.0414851495318198, -2.0806354822876543, -1.0936219581221478, -1.5688320004903251, 2.096168967995436, 1.0111245828665816, -0.39932550900144065, -0.6039176353210158, 0.0020056705536440986, -0.9993531534034512, 1.1318475561077497, 0.871304391793295, -0.14157518055639046, 0.4169763332427778},
    {1.9642778492659512, -1.6644693242274742, 1.9814301371231138, 0.4633977204992415, 0.1125582991544816, 0.11383544902374473, 1.336897178162629, 1.2981144851242543, -0.36795049696355053, -0.9041149933288541, 1.0912042707115546, 1.8128150733374346, -0.2833922030643554, -0.4874274857993238, 0.33143060965104676, 0.3240419553465205, 0.3579164951134747, -0.844329665025747, -2.50258829756138, 1.487212723145465, -0.36496234743070105, 0.9209419179776522, 0.507334445373141, -1.7043201403723058, -1.4250685525283535, -0.5749421271921665, -0.4673111951183455, -1.6595586574424248, 1.7349862750451164, -0.45204667796337966, -1.5219379891227147, 0.052853987983673634, -1.0864716973785573, -0.6812472282341355, 0.7329584096454494, 0.5909187831292828, -0.8190956747672234, 0.2890200706629694, -1.316046732824846, 0.27322972471576085, 1.5127114981456602, 0.37261967677248214, -0.04080885961199956, 1.8008192330781345, -1.4162861011985755, 1.9005995260307262, -0.684793808738347, 1.1241533995677326, -0.9020040909320861, 0.3633767645867321, -0.7312613037617265, -1.8966133255115645, -0.0517115795761989, -0.6495308444870661, -0.947570715969986, -0.07613988471524571, 0.5340277557379577, 0.2603808508804499, -0.29331179536928537, -0.023545199227665004, 0.9186772209303526, 0.982396747220925, -1.8093545393749, 0.12946496337440724},
    {-0.262277352507727, -0.24714121855940677, 0.2835997386581571, -0.39031876485118366, 2.2907968890271024, 0.311835315415586, 0.8971630886224321, -1.4250881039094434, -0.9040230633745457, -1.392231918608521, -0.14674344880328022, 0.29400937628801277, -0.17134398376929721, 1.290713107551663, 0.3772730594478452, -1.1054462665462201, 0.9574002595514542, 0.1847621866170555, -0.5766041569487999, 0.7502706619609794, 1.0684220783003577, -0.7720615053055123, 1.3670685155184694, -1.3746644959905705, 0.039963713997852084, -0.20566922398539955, -0.14802185502051868, 1.5271744403427334, 0.947041255171483, 0.16609876522038744, -0.9754885147183701, 0.1760926782493268, -0.7356630050577059, 0.5033833657039687, -0.2015606857393353, -1.3671786556419785, -0.43584624538130123, 0.4630830033433837, 1.6997030163784899, -1.6694315312151438, 0.8997820101832892, 2.906592348041313, -1.3822811956688612, -0.5324229569820668, -0.5896268719517206, 0.2679333914805309, 1.183622718186907, -0.006269348821521777, 0.41388173703052583, -3.094480286827719, -1.5394935771611606, -2.010138467618709, -0.9694350027726474, -0.6083788484584269, 2.4498391739594902, -2.3409227963685924, 0.052771679207529655, 0.886432590045562, 0.6457293102577848, -0.858537294628684, -0.7889255845986002, -1.9024123225954224, -2.3351146346946994, 1.17693599526005},
    {1.055202970956819, 0.893616243473177, -0.2548580164199838, -1.6863602814079666, 1.1247807344242755, -0.0640397075878841, 0.12049880359116924, 2.804626710245005, -0.22082826673124567, 0.6452468436694575, -1.6078875889829654, 1.2154426656866513, -0.7079155658421542, 0.20862998492743282, 1.4966354233738852, -1.8397782039873478, -1.3957119020654964, -0.7551158047617401, -0.8586176015943362, -0.964494819258858, 0.1408354254947219, 0.40649221108784406, 1.0354262813224697, -0.20407649630537789, 1.2267736342864008, 0.38366908852974807, 0.3048948477600143, 0.3604295563328454, 0.13585005841792328, 1.2782991851102947, -1.0649784393116932, 0.5563599186752868, 1.026580093441576, -0.05768963229329205, -0.5877039774146898, -2.168778702888213, -0.6180673284959602, -0.15911649127795072, -0.41304021752548753, 0.8321479878817544, 0.42011123995915556, -0.0985452690032509, 0.449513665626281, 0.059660045390166366, 0.02367655811389449, -1.1566472332912543, -1.2327696247376556, -2.3410677419493897, -0.1683306639504526, -0.9262630123105605, 0.538673549388545, 1.3043053812956424, -1.4133469359545856, 0.18931586221162, 1.2650359205656443, -0.8741460678029386, -2.1302243712642976, 0.7805449202033968, -0.7509968056336493, -1.7339334932671773, 0.6505593853223546, 0.40363372766151906, -1.3733436987239689, -0.5070923958638127},
    {1.3956747580192332, -0.008186366477192668, -1.696790861215019, 1.3615558831385053, 0.5039457396222885, 0.4632019665535054, 1.0733335613835135, 0.8137452969711496, -2.372122595982134, 1.4014495487912966, -0.3383587984338482, 0.08602825966995555, -0.30933470153615134, 1.5097176952430853, 2.3407331647722187, 0.4995214394044468, 0.004707465246364856, -1.5035318706004468, 1.386087707574486, -1.1321476479541617, -0.26866611758128256, 1.0885140853534454, 0.23059412746129943, -0.27818792204841275, -0.35265234276080504, -0.9067917934364429, 0.9418177885712494, 0.133633644433968, -0.3070121138291977, -0.903884123531248, -0.055531983202847496, -0.5576357968227554, 0.22566873532180143, -2.597028734743926, -1.7262374111546563, 0.01669173405778107, -0.6904474387918685, 2.0474235147822983, 0.16231384418673456, -0.9183335149280757, 0.29215930524041267, 1.229975598112741, 0.2988267746514672, 0.9596357190910022, 2.05927833413896, 0.050744013623437105, 2.1685401219493596, 0.22987362904973604, -0.7560598978412989, -0.025540482085811233, -0.3708896281115489, -0.6724936517898756, 2.5277664001208127, 0.3659675706665621, 0.829613995638082, -1.7475731371607242, 0.17553580266689306, -0.27503391979596203, -0.8318874722251212, 1.1105441475089686, -0.3476175064840271, 0.31755981886727525, -2.4081553313720874, 2.075954136099548},
    {2.1649336730124538, -1.3498598849263084, 1.172666014726099, -1.1938904338843495, 2.981608233202972, -0.645475381103561, -1.3756234193598915, 1.441642818246869, -1.639183761539689, -0.19004864715654335, 1.4110340772227652, -0.16696123240266295, -0.040159959157492923, 2.219322814035098, 1.2549085130053956, 0.48317167214171647, -0.8022064546396523, -2.276968052017859, 0.7757429838642386, 0.39247673651156395, 0.38274763568804215, -0.0713992291172787, 0.11993914137636999, 3.077645356497202, -1.467721970172695, -0.5121852417208399, -2.480250020782273, 0.9707516942007506, -1.1032323126716561, -2.307142774155483, -1.5398007308724897, 0.5399493428414815, 3.890991490806402, 0.024563784843078813, 0.5053134548978387, -1.0496793694190913, -0.12002609827059757, 2.342744536911242, -1.2761951870423085, 1.7617851731045022, 0.09058872045110129, -0.7265254350065259, 0.05240419198389545, 0.9035587960570693, -0.10146618734842928, 1.7888608121121168, -1.0005801003861579, -1.9504273061481503, -2.2549659349797837, -0.09008957661716151, -1.6175447635271973, 0.1333675695430975, 0.0639776237167725, -0.3085115285174341, 0.5412414553199251, 0.2600435786547294, -0.2411522548932552, -0.5429693805856196, 1.2631370812226501, 0.5871917531033793, 0.5977849527131427, 1.9708454140475278, -0.9128126343216795, 0.7916422752735822},
    {0.8640359531489549, -0.48321624917109685, 2.4175569797127134, -1.1983137341499932, 0.27047606734498886, -0.6330742039763809, -0.7437137630512394, -0.3568774602256135, -0.6436809899656868, -0.5953135606854862, -1.1425959893107984, 0.5840948248538619, 0.03441542526899735, 1.294917760186943, 1.0423043293662166, -0.2807730625960258, 1.1719702774480996, -0.21892478490772893, 1.4535808335658784, -0.3517603667645669, 0.9715785927233477, 0.9590969542465381, -0.635182473174795, -0.8677621762355794, -1.4547819177353734, -2.7669552605070553, 1.1845474694147722, 0.08197389489028314, 0.11868083393722363, 1.7119176717548512, 0.8052983942201389, 1.4987423609233699, 0.333602894106969, -1.846435542200899, -1.5109461096135977, -2.822345334877977, -0.05813261742685168, 0.9586835657488433, -0.2038181312790263, 0.44684349861471867, 0.7567604397962951, -0.25306698786185927, 0.6939707873514013, -0.1119490493831073, 1.2804106642597282, 0.5997774660577682, -0.5467210478929818, -1.538667009389677, 0.5952380761902593, 0.4915536317007311, -0.6651380648866965, 0.5738397307225863, -1.5459748258186778, 0.5814645053881576, -1.3325209781000207, 0.06005085054860536, -0.1991039252134988, -0.7571335564530218, 0.10232433806561783, -0.4301212528398521, 1.2076492558319205, -1.3929070781611717, -0.49796549279901475, 0.7024402748118563},
    {2.034245101261164, 0.2557505327822365, 2.185933502844876, -1.7949308035876828, 0.9459270957899923, -0.08510417088083118, -0.667360011916216, -0.6818863408592947, -0.32073833468604807, 0.5292439826977838, 0.4201346982603947, 1.6014871177540315, -1.6596205196106266, -0.7245834062242872, 0.7058565203942656, -0.412658055716441, 0.26986322986355743, 2.5629456881002195, -0.05346416916485182, -1.1417917714329868, 1.3522344565795843, -0.06330423642407548, 0.31724838510054976, 0.04627349381153933, 2.106181847160204, 0.058454744372134534, 2.2155860074058484, -0.9669000207676718, -1.5878522593856221, 0.11100189866501577, 1.25876458743168, 2.033351680531738, -0.5161300639201168, -1.1265033490417993, 1.2221458541848451, -0.22719510206854288, -1.6697354626178893, -0.7609361336397689, -1.359347473528415, -2.4095384830373363, -0.7014954088030302, 1.3044187463279218, -1.3928272581739507, -0.4276376819923311, -0.592182732125742, 0.35989372632338007, -0.38623284529708896, 0.9777193735684676, -1.591791076240163, -0.9457438580082244, -0.596946061709131, 0.8485490650545439, -0.08502646288120737, -0.6917497579318032, -0.06491174119544806, 0.5076510725464733, -1.9819420375017922, 0.273481234539872, -1.1800833726312259, 2.1496590944089085, 1.6858053014778498, -0.7705922377446736, 0.3246394796305569, 1.9384091702174515},
    {0.7118991517342801, -1.5736273240301095, 1.5123126652052798, 0.6187137124468436, 1.4662410740085214, 1.7496405465616849, -0.047436531102492185, 1.9219069646919307, -0.24819086481394853, 1.8743989248621986, -0.5141169658473418, -0.9987010897645942, -0.4069858683044572, 1.126423817051278, -1.1782183654243568, -0.9278577941970558, 1.197217980560934, -0.09580204967714448, 0.2888393913056052, 0.865734879468836, -2.5444475521897334, 1.2369228887507957, -1.5365274315681863, -0.7675082132008557, 0.292334641741768, 0.03347476790649149, 0.09876420378101097, -0.02803220259438755, 0.6319115323678516, 0.7593015968091643, 2.1693402277586515, 1.1312033248670985, 0.6353365636706735, -0.9640072292625361, -0.07273405029615405, 1.2297540861157907, 0.3222548639082382, -0.49177856709231466, 2.3912128546787805, -0.909554046461674, -0.49291219195764735, -1.4703828563227528, -0.17952589272313912, 0.9821563929244058, 2.773067674529266, -0.3853254384126116, -0.8752580935488603, 1.2781846011046678, -1.5374301265669297, 1.6288742838565937, -1.698873593837555, -0.5876061156570735, -1.06906401116906, -0.22267721762710516, 0.4639381063481859, -0.16430410408702112, 0.2572686117277482, -0.15622037857781368, -0.32033427648330776, -0.28628860130674566, 1.949738046242839, -1.1746070352070093, -2.307426455447523, 1.2435415052411323},
    {1.770508190815224, -0.24775599092955541, 0.5040386866740943, -1.3901029683065773, 0.14160168382886337, 0.4205113512098849, 1.7780058052475722, 1.149117871546225, 0.9113983479077354, 1.0387198415524537, -0.2892856564757284, -0.4408089833879001, -1.542570091077868, -0.5845077601878849, 2.8754003539063575, 0.5251504324904216, 0.5108777529913697, -0.15790925172416062, 1.2785465710430501, 1.139142212727783, 1.730305234488302, -1.4678241468155506, 0.8882053473949021, -0.0036485838797925933, 0.5156561950828384, 0.8700114322392689, 0.4231421615909169, 2.5874344935668594, 0.12311935080181895, -1.1332175036509804, 0.44940786835933144, -0.1445126485624375, 0.8366170323605122, 1.5873388988655268, 1.149788328130587, 1.6724113832028842, -1.1341183884500659, -0.32764300561927323, 1.0604356728236284, -0.5932193829424754, 0.21084884484353072, -0.31466633764674135, -0.4703328420939061, -0.5267115604231136, 0.8873973424510525, 1.3247341358069247, 0.48321691724194377, -0.513276872191035, 0.068185983842003, -1.227679715470516, -0.3320603532710002, 0.07608478434416967, -0.5471812501660516, -0.21484511394094286, 0.22695678850361845, -0.08447200226953713, -0.46615390693165726, -0.4815162039422043, 0.027519859197540453, -1.3237180001692743, 0.9410991697773639, -0.3680940523474129, 0.7340491702248703, 1.9434717592901296},
    {0.42008697586596355, 1.1385004439878286, 0.6337249759063263, -0.670223267533091, 0.0030549249707343784, 0.8254087985865929, -0.2124222905551105, 0.5513094628109919, -0.21791207262202214, -0.3063638767230491, -0.1983821962478485, 0.21897517150422452, -0.72771775187201, -0.851429351048722, -0.12864254394392866, 1.900617866958505, 0.009267720600146951, -0.3478253648597376, 0.24199454529023212, 0.6877518133964821, 0.028294025217973428, -0.3274635911448274, 0.9176521158062775, 3.1855058093782778, -0.22205311976679823, -0.9284352864914713, -0.01150380355230219, -0.6440520516775797, -0.18846500918829628, 0.5178624673042421, 0.8898205471713739, 1.1361033942255852, 0.4669846736837792, 1.3528905024034958, -0.8548240087445524, -1.5103113802374755, -0.8869763434412955, -0.375337584594711, 0.00713116239784449, 1.5461809979569676, 0.9939426762592277, -0.2650067607706504, -1.4431269110427203, 0.9391061764297324, 0.7503799360460316, -0.28181259611107656, 0.544067640693865, -1.116279846170921, 0.887791727578786, -0.4123563326731599, -0.04217432362745536, 0.41306565614977986, 0.08982224533868954, -2.3518470130828395, 0.7774520800157833, 1.3069083451853885, 1.810636897093612, 0.022928122644855116, 0.6176485080595409, 0.36555882010571045, 0.18899017490786105, -0.24454322862512082, 1.4695007476672064, 0.5338018583317687},
    {0.04688536717294297, 1.7693955593973247, -0.5497285086987619, -1.7105108751645182, -1.0362980675347906, -1.8981271098237174, 1.219421076330141, -1.2263745095640957, 0.0785926148652472, 0.7223418959130048, 1.2586286275040428, -0.2613950147955443, -0.1575660420785876, 1.8263913629729516, 1.143563459720983, 1.2548372866560806, 0.1099703384201601, 0.8659685611943596, -1.5571388989128025, -0.7368744295526715, -0.42688726080173134, 1.1760067236440732, 1.5466332211686995, 2.252798315883312, 0.8252551805287566, -0.0021802791341382004, -0.2978262073327579, -0.35463524116475537, -0.956489933342106, 0.021692852735376203, -0.25435911664621647, 0.4203126191347487, 1.107682392870133, 0.0661691460807424, 1.4445861484549274, 2.0670727249993606, 0.4459115757274607, 0.3524720702775034, -0.13472296666931097, 0.3255661981558763, 1.7678292811130256, -0.678929392825989, 1.3690194057067298, 0.9072648787035263, 2.312093396640001, 1.0105833667046522, 0.09314176432475314, -0.67753346028976, 1.4583566104210686, -2.4166983023882604, -1.5652573204371638, -1.0413498100391498, 0.5544674461490551, -0.6148054702140792, 0.016996412079160785, 0.5166733379363044, 1.5606452260872443, 0.5255586837209525, -0.4492656654758093, 1.2372903304164318, -0.5953214710322569, 0.2770341671458794, -0.6791449027371103, -0.26360435262140325},
    {0.8411778933984053, 1.1713758753344896, -0.8538528183077542, 0.7420897939887291, 0.28085991214777534, -0.705993207527886, -1.512455776512706, -2.252541136856961, 0.21891999082074437, -0.947966243687118, 0.34872920203874397, 1.453108252550776, -0.5229604144575738, 2.3521706437386296, 2.4241473368918594, 0.660362744938911, 1.2520366745698481, 0.6503614651384007, 0.41750573476371766, 0.6937801961467749, 0.048540947745266357, 1.3921201639593037, -1.3202790487906917, -0.11225408256215845, 1.2523052921896531, 0.920107070990108, -0.7951458753338188, -1.2477245734170477, 1.6042762805071507, 0.23604928860086805, -0.1619046834524563, -0.48129827180118606, 1.1861347304332959, 1.9222876783387508, 0.7063320092206259, -0.6159064386833327, -0.06059430809545529, 1.1590145881824925, -0.22347952239356708, 3.2204040837463372, 1.387145590303831, -1.5456990036865805, 0.17651659957038465, -2.0179196981192047, 1.7211689114070505, -0.22178435268484187, 1.0468256783007537, 1.2406978385485898, -1.0030250296229815, -0.796725621942101, 1.385477596693414, -0.45828024099474507, -1.5835577068608697, -0.9374025881193783, 0.20243492064179122, 0.041456862577554106, -0.6401786263864208, 2.175399089160222, -0.18815005727426565, 2.8091438887010876, -0.9679966860410731, -1.6832606937246304, 0.8085738123962913, 3.3520511983430867},
    {0.17229021786846654, -0.9705579772576441, 0.3907381633835, -0.12624640560324327, 0.40524417350908687, 1.80274520807217, 0.05144015034972618, 0.7719858840209025, 0.7924702238593921, -0.5186847970494567, 2.8547676434998954, -0.12119478661375874, 1.3778395225708564, -0.7053988240495869, 1.5853379318758432, 0.9117264497785138, 1.36835295632172, 1.1241948206426087, 0.40985189617508166, 0.08756954188083742, 1.6118765770666978, -0.21551344973509037, 0.39598486258854887, -0.13643278154516467, -0.0534693480732003, -0.9819674871254206, 0.5208799623416172, 0.7407068959568491, 0.5866917812693482, -1.254179746406473, -0.8237419644937268, 1.8902393413812002, 2.7023596843858186, 0.08190164292213395, 0.588296635236627, 2.202212510982078, 1.0432630842560178, 0.21132064238925483, 0.8161806256206535, 1.430703623010701, 1.2105936855424797, -0.1984341496243545, -0.23665928243881162, -0.99790314792663, -1.0106170437767892, 0.4622703093055801, 1.008272573184649, 1.1879721025727266, -0.8849323053895752, 1.7088481462282423, 0.650041798141198, 0.481077441626193, -0.7155742848722301, 0.3714527269989838, -0.20747310496199592, 1.7266506080591604, 2.053683574698862, -0.43478463965426556, -0.7596999184818569, -2.154139061731858, 0.033695032282304326, 2.122442412778946, 1.4139369881286237, -0.3178287143422824},
    {-1.1602102438426434, 0.6741071729528464, 0.4163814755204606, -0.688105512498424, -1.435176147805912, 2.113717631227634, -0.7503295774164539, 0.7075028025020954, 0.9025512998142259, -0.1034722912343131, -1.1606701770918406, -0.8677660770200907, -1.5842678295118942, -0.9770328567565353, -1.3239256925425824, -1.1853468767190947, 0.49921558407045363, -0.12957087713484053, 0.9508097411218258, -1.8813175496509367, -0.8250085108941522, -0.23937909479081243, -0.63059865752948, -0.4060939589023451, 0.09450362491161358, -0.37149110964170706, -3.005686155052111, 1.864592156478059, 0.17591790188366552, 1.81044567087754, -0.6123504403373069, 1.914248847506916, 0.03930534957881269, 1.088771579406088, -0.3878085012037635, -3.7190299299252754, 0.24987488452129725, -3.0828808466006388, -0.01978344677763554, -1.3909383475665213, -0.08153930457520588, -1.962315492573986, -0.641668475514086, 0.7199454964580488, -0.7924392654816973, 1.4576173217680188, -1.8107070708649295, 0.11208040976386997, -0.7498655205780115, -1.2756161570653544, -0.08514805869439894, -0.3818949037838275, -0.25113313037268487, -1.3699811941222404, 0.6945826389999743, -1.5744189713933856, 1.859114621208354, 0.20193147695787206, -0.05242130871902501, 0.492165161197109, -1.0726016344327944, -0.102185568245789, -0.17620857489749508, -1.2415657198044336},
    {-1.487891113057788, -0.79103847027605, 0.3054110973384236, 0.9095610899839183, 0.12062028700006158, -0.32501442267240965, 1.6322037370237954, 1.5843785181887107, 0.029501979972700494, 0.0980936703508009, 0.45193331965752237, 0.9499173431181215, -0.6857988750050796, -0.9181521480079279, -0.2616191610319986, -1.5453800501991157, -0.4801360120288412, 0.7053469392619031, -1.1546801815169991, 1.6833930160296662, -0.6735209856730886, 0.5253004470825389, -0.894071142496717, 0.9080471324082708, 0.504441192976264, -2.8468458618723025, 0.4008799235259458, 1.3177127727711548, -0.7951074434206993, 0.28227789779223417, -0.6813262660516146, -0.30317416124908136, -1.3343867526425892, 2.0623110416750183, 0.8906901429303723, -0.07991418790246477, -1.8500214684536338, 0.325890555784199, -0.020472505292452203, 1.9067246045329826, 0.4988383002649199, 0.7540858923737044, -0.3756892222211217, 1.24744177290143, -0.7901557692458467, -1.1061129895011237, -0.5463847082413952, -1.4139729868420818, 0.12631111809029907, 0.03203982066046805, -1.435344220605043, -0.712929262211001, -1.148998401448371, 0.42129374844805945, 2.1240606413857903, 0.22874978695410886, -0.44149056081633314, -0.6672639032369002, -1.082605011748826, 0.34179696286631855, 0.18458946074326768, -0.06573699825711583, -0.9431676111233437, -1.59212293954092},
    {-1.0063348779533319, -0.568988013812876, 1.2008172397891492, -1.8975497342159493, -0.08209075490185215, -0.9401586688362096, 0.5428481792960577, 0.10810477107240321, 0.9356579738465955, -1.4361678162358718, 0.2117492551765752, 0.4649376156642312, 0.7288679410294593, -0.35249783067548063, -0.8548696552649733, -1.672889684474962, -0.769442482946716, -1.388168248333713, 0.45781196826509113, 2.8986657063818964, -1.8238574815016273, -1.7369362656402063, 0.990434029637012, -1.0384188209073173, 0.9966730080357838, -0.011133566830875461, 0.09028019556353949, 0.6303040155777544, 3.2269783708206448, -0.780933697832694, 0.23034995165745928, -0.40271818273923504, -1.2175614582341967, 0.18348463822612046, -2.1895757659923105, -1.7086221487864588, -0.31817324420266674, -2.0598636053333568, 1.1676406395262953, -0.8394819740665592, 0.4090019173047789, 1.417230876121169, -0.21676959335956275, -1.1455496188083412, 0.10336353976200728, 0.02715374256574951, 0.0947470824702806, 0.877141685520365, -2.460289157429354, 1.3417682412365082, 1.5439006305410952, 0.05864837469745408, 1.946850936034616, -1.3032822736188217, 2.1236310125301197, -1.4919962381834257, -0.3851034359846876, 0.3105366996285482, -0.09089803514009598, -2.5280637957079084, -1.0405256501730498, -0.13931080861545228, 0.35943822300038647, -2.182148709730671},
    {0.40923252764796864, -0.37116819334496964, -0.05618978518949672, -0.2777611688445226, -0.9688405934645163, 1.281222327142229, -1.1547868473281324, 0.9586191183087296, 0.1812244000911669, -1.031996172677677, 0.660424011597109, -0.29654121130649896, -0.6794887713433689, 1.3437927876418958, 0.38086351763794274, -0.3395872990949534, -0.1194288783616931, -1.3380393683193472, 0.9341672530917329, 0.3353397422813949, -1.5349564399459785, 0.683485963065753, 0.7674594010776443, -1.3074887985447028, -0.06747679927078454, -3.768605688725354, -0.8562468496970923, 1.8715437756412447, 1.0920750534606833, -2.1011227887232757, -0.03462821723294634, 1.4347913658346423, -1.9661902267414169, -0.770708753325476, -1.5320362303444002, 1.9562005750320832, 0.41567134024716845, -0.2843552728104669, -0.24652542221601834, -2.9172119710491544, -0.5057090191356213, 0.6668073784886374, -1.7298216307090877, 0.7081007612181641, 2.218414892389918, -1.1364543556657696, -0.6154801956880432, 0.7890955515591077, -1.1816555636390735, -0.20367114626600494, 0.007506483414781891, -1.0639242620242617, 0.26879188247010877, -0.9967061950033101, -1.1908011279984225, 0.1592643550783094, 1.3794162066427023, -0.011100301396926193, -0.05821085673730472, -0.43784705004707086, -0.08221976281325032, -0.16946477464819126, -0.4707360251120372, -1.500480946356116},
    {0.4236172378457678, -1.1721834052765467, -1.174602456552563, 1.1613557085027126, -0.5690505240993523, 1.6010397856571636, 0.5188651551732597, 0.07079202245267896, 0.3829254711511123, 2.456170203397016, -0.49055299922161005, -1.1725030396869704, -0.22076574890717027, -1.743361682124913, -0.10837136074409952, 0.48094151546990005, -0.6819643135094043, 0.38025297579570705, 0.20166240818988668, -1.7306610363821606, 0.5130396236595928, 1.3764070577499739, -0.1526518951820726, -1.2573939930059386, -0.6622083162314318, -0.7219323136850344, 1.5995278830815132, 1.2047738865877822, -0.9233356688856867, -0.34165107445781595, -1.527693278878108, -0.468362371393869, 1.3661334591401064, 0.09277121144100943, 0.570407389529474, 1.0381478510685553, 0.7655178711804802, -0.14522550928447278, -3.1135088400460447, -0.13894166085390566, 0.21228880401067748, -1.5293171516476276, 0.5077545109692417, -1.0766138915896502, -0.3366568210272663, 0.5477987940468104, -1.779481963842148, -1.285360174223059, 0.7491389310254715, -1.164720539422622, 0.1320806524354866, -2.293888807421888, 0.5188919326814602, -0.4251608282776201, -1.1184370128122036, 0.7481122812153522, 0.06714262493703327, -0.4109872648186413, 1.0708583908561897, 0.11587832891066083, 1.0987094443537895, 0.42160191663302365, -2.7912188657693964, -0.858573345875972},
    {-0.03541139478825882, 0.05806599607967352, 2.2559238590789943, 0.1324060254068742, -3.7479067473950236, -1.1524145344503776, 1.08406371568672, 1.8611008153721862, 0.026447149800507525, 0.5533852708145284, -0.6094628390615803, 0.06049392515838825, 2.209295620451652, 0.36639885868949634, -2.015339302287923, 1.177292760143866, 0.55900352453561, -0.1477554252331338, -0.9206733395275757, -0.28112288962414117, -0.6424456924781985, -0.2584644950758764, -1.250928038666025, -1.3092558153469982, -1.6074140784104491, 0.193219149359958, -0.517479824361588, 2.10890113204333, -0.29166991922360475, 0.2712266405751888, 0.1900597993480871, 0.7211010920508536, 0.37693767736077666, -0.37671826158031263, -0.891321187738371, -3.2949064647064197, -1.5711108513925944, -0.64456799123139, 0.13331512087811337, -0.30539676710121205, 0.09389563059796144, -2.940441895435161, -2.5922129697553036, 0.4589164464202835, -1.907108082806026, -1.105945995793852, -0.7332811317333282, -0.5664823979674886, -0.12242575497211623, 1.351950280783114, -0.032647751490853236, -1.1191387574991374, 1.2141113998401092, -0.5354622007137811, 0.8716368712435493, 1.145172849413409, 1.2168241414717522, -0.7670554328395158, 1.7882883014285418, -0.5318643874701628, -1.38716674125015, -1.3124564930985623, 0.6468551646311269, 0.5082389637489447},
    {-3.168269171161988, -1.3864987365364758, -1.7114440020820032, -1.178535637941448, 0.16668362138218895, -1.0295011788842945, -0.7354533632599158, 1.2906957483610344, 0.19826679404783906, 0.8420673728699228, -1.3618791752221102, 1.602094880880121, 0.035982257719343734, -1.297865466055043, -0.570897402781786, -1.6544957842873127, -0.42998912933453026, 1.3212563181570216, -0.28280324455685085, -1.1295484695836988, 0.6250838209137786, -0.5468294564865768, -1.8617598997291238, -1.9465630659571072, 1.3933837380807956, 1.0210614430921505, -0.18699825423253297, 0.26187025097033106, -2.622087440799361, 0.07651273772313061, 2.2123642171447453, 0.5439536199503451, 0.6637556014142572, -0.0466593346470665, 1.3448695887791682, 0.5270447344370804, -2.104818846426247, 2.420546715017666, 1.5980492283340375, 0.005320143725841218, -0.11265718879350127, -0.9281325881276614, -0.6928536656542654, -0.08770169189535561, 0.6150832364189651, 0.2593960270320348, -0.1925831184520984, 0.21134904022428, -1.2614021086569398, 0.9712630434620614, -1.151022232912637, 0.43547602404144786, 0.010914959391219779, 2.8613402815145585, 0.2963936454691879, 1.539820306897549, 0.4655738960931476, -0.6102729506150534, 1.1441868946083669, 1.3718239565397636, 1.106323479264822, 0.8679908768558978, -1.124041970126796, -0.18245181604600771},
    {0.81252886345064, -0.9294610796299144, 0.9858904402239725, 0.2829108121357393, -0.04965618522650184, 0.188535896098675, 0.3394379381529876, 1.4940514591739722, 0.6184999109581697, 1.2209638411222168, 1.2454653995425558, 0.0011917749605193165, -0.09438738111399093, -0.7057979058744435, -1.0878009654325937, 2.261761633768054, -0.951405834851298, -1.0551409305107267, 0.14947990235923256, 0.33969265450252323, 0.7021528662289976, -1.5231816430015894, 1.8885901617508307, 0.20380025335901794, -0.23743005495387492, 0.013726069090761604, 0.1627688535107223, 1.1952776756183632, -2.109192677435252, -0.4421308357092359, -1.2135731475874012, -2.45460729605668, -0.49156096198700827, 1.5567249817987714, -0.08511302520620295, 0.20603259802192594, -0.7479398704898681, -0.42793325963330964, 0.7817483255002724, 0.731717639973776, 1.1468001430335952, -1.120924104550721, 0.8609457428677123, 2.313865945144504, -0.4577602313672743, -0.7409390267289738, 2.2998883359795426, -1.3618292537155123, 1.2610595883330686, -1.1198360623174866, 0.565416598341427, -1.5565605407364185, -0.6269703232536715, -0.1375422215452324, 2.2024096658385766, 1.676040099652279, 0.6643935388972846, -0.0032967625665312143, 0.5638309033285367, 1.1449972812563467, 0.9565198711780628, -1.4375520559885089, -1.748299220575982, -0.6880824156767192},
    {-0.5247842826507705, 0.5387858535857392, -1.2332980588373625, 0.3306865291052733, 0.7089469379165287, -0.8399912681827177, -1.0317696077565082, 0.4148710193574075, -0.9113745610801145, 0.9659008623224515, -0.3889376102052099, -0.2169742862561768, -0.2848156550117715, 1.107202809642477, 0.052776223175016256, -1.769392158621988, -0.9993632707905895, 0.12718111348825206, 1.7651287493642498, 1.0260954387135508, 1.3038852570297887, 0.6778224924328111, -0.7444917646070441, 2.5742677961942495, -1.9094922545121293, 0.46978199771644547, 0.20970276194532061, -0.3448537708272835, 0.3578901101396196, -1.0505452967071376, 0.802409954691452, 2.0406902249036594, -0.22283411596719574, -2.3143890738664687, 0.5021499170430125, -1.3512151641022843, -0.76203590835819, -0.6437691914867789, -0.06222782101950355, -0.46849331127160154, -0.46134723392727633, 0.9330343291006592, 0.047360495076393616, -1.529952168469052, 0.9220222026249127, -1.210291738141405, 2.48048893555091, -0.6411291002456938, 0.7936872851864548, 2.3035465327863776, 0.6369827174361365, -1.154863194991446, -0.8109998220205956, 0.2603280259388158, -0.008787462183130276, -0.24699353574920999, 1.8392620799756678, -1.275143247806982, 1.4624145460352418, 0.9532509009560614, 0.16118010000016797, 1.032190135696565, 0.40220044462078824, 2.1677251797391626},
    {1.0911183880291697, -0.3857376917464572, 0.2802351904828366, -0.2633049418901423, 0.3569366886907897, -0.19510844747070255, -0.9655062336895991, 0.7003122205876936, -0.860049881319606, -0.6644620744493088, 2.254946218449795, -0.5316029219814997, 0.5547349571368034, 1.6688778744237436, 0.43587658801138995, 0.5311011908379815, 0.5826510628593116, 0.6073105945155696, 0.3399300755269484, -0.1073243342190359, -1.5349479854487584, 0.024818645841082516, 0.023567779628248166, 0.18934436199165888, -0.5151494422552391, -0.2311977523902679, 0.5110600508157251, -0.9873345719190139, 2.109184006951451, 0.11722020845690959, -0.9882849986873291, -0.5942886960792028, -1.321957240620686, -0.5703853384034563, -0.400219967852261, 0.23760408516672424, -2.635601651769915, 2.0528253770240794, 1.9974632291092806, -2.086043620721838, -1.206047074009708, 0.10922473649915876, -1.6168609698744536, -0.426680093438315, 1.3900610281642711, -2.3950942688804275, -0.2680912750926733, -0.4660343453499565, -0.8095248646742711, 0.6187773908153369, -0.5278389786972111, -0.40872254349309955, 0.8775950236426572, 0.8061935396896046, 0.3934048845930112, -1.1001451371142734, -0.6833917703815922, 0.44959139366336787, -1.2902772137870089, -0.2947158009969668, -2.450750675369965, 0.10254841930784836, -0.08132693442311377, -0.7476291740397919},
    {0.40584595672786, 1.7705547013359515, -1.1818702028380976, 1.320512979887675, 0.7915808225306049, 0.42508378903515165, -0.0568064910414466, 0.7282838892465451, 1.0349814531325188, 0.7883361922425813, -0.6824002038443597, -0.7712898397366452, 0.4220728689871475, -0.013724425644615564, 0.9757682430972056, 0.5631114564044617, -1.5439736199858045, 0.5599346481621554, -1.2793164988580996, -0.19430022071650097, -0.7800443848805135, -0.44491198302053436, 0.2619374482020983, 2.19535230310762, -1.0802083353069931, -1.6907524485534309, -0.44957831248609326, 0.8264387925326752, -1.463337892265426, 0.6615608676583576, 1.1462098246919634, -0.03888697107281243, -0.537838903617975, 0.96023137874467, -0.7889592387067407, 1.531523563131953, 1.5515251662846277, 1.730227215205891, 0.7152763945213433, -0.165372594386153, 1.9526787885411192, -0.8613079461604244, -1.2011809441131804, -1.521301697683324, -0.024459338242369375, -0.22318709974140052, -0.20797797762932338, 0.9241654976813812, -1.0024761571542986, -0.5505823502007868, -0.06224286978607565, 1.648261787391819, 1.2607619830160253, 0.7379719113486871, 1.6840408293756022, -0.1396481660602821, 0.777926114668235, -0.9126802944674006, -0.2690537052192178, 0.3123451469657128, -1.225568469227715, 1.2285841106671458, -0.1471018073131781, -0.5091194989697869},
    {0.1480718007853188, -0.8526251555379232, -0.16183544060145924, 0.24430407138963803, -2.062866033570238, 0.2667482375295739, 1.9576174903599624, 0.3128003474622188, 0.9931004682798085, -0.6880936363934973, 0.12324887801778736, -1.0640764379047327, 0.10267555276867514, -1.1521853219529312, -0.4521134781229362, 1.8305604323865463, 0.5415286236159271, 0.8812232532880568, 1.9969294362793564, 0.7486599342170002, -0.4629045502437241, -0.7107426479799788, -0.37247545258803416, 1.7371251899344131, -0.9786943210553632, -1.7986448741928436, 0.6204617982052556, 0.7608789797429223, 0.023012438808907725, 2.523298447298325, 0.638663040602528, 0.03836986030276558, 0.8063307154410675, -0.14375344067412607, 1.3221939706213857, -0.10894170087577287, -1.3854966922409333, 3.0270381106696114, -0.22016838562076452, -1.2325060921765516, -0.42796447728811315, 2.1570068423309645, -0.6196191846936188, -1.087709352328675, -1.5746374627131006, -2.108824607812933, -0.5875478974255233, -1.4461077072009876, -0.3771396136024294, 1.033068780784219, -1.2138315554255834, 2.2214096671389982, -0.3118464529812797, -1.5515731256792782, -1.1694874497127434, -0.7459532921994777, -0.5899891765472207, -0.6904880584719488, 1.449579837416306, 0.7791822957935103, -0.8409753669409281, -0.28343857563785885, -0.9240674381147533, -1.8526198342899225},
    {0.6147443792161278, -2.1511715719610334, -0.8598475548320549, -1.1593716269998988, 0.1628601238317898, -0.13815826582020305, -1.0614496125337547, 0.5637422019638985, -1.4059766562437996, -0.5528954397329727, 1.357416677847617, -0.18712305105382424, -0.5018541122473807, 0.2835700032698941, 0.23371744630543517, -0.16350660605405362, -0.9495721868603714, -2.495396524730088, -0.2299355712471933, 2.573513225481636, -0.23757691599199188, 0.2174562215048973, -2.5933701776643723, 0.667987598725848, -1.0181636210920626, 0.3802432147150834, -0.21193591536620654, 1.0978180450248725, -0.2644678053893556, -1.1906102466995327, -1.2616658875210593, -0.6520641513765656, -0.4142796683526106, 0.8650011769409557, -0.5932092243959939, 1.276471077774538, -0.11739653500803178, -0.18928273297198941, -0.9780395731542508, 1.5198128212144493, -0.221489310614579, 0.2714745246541232, 0.8284066946510835, -1.0962378838045526, -0.47473675805916293, 0.49978472127763995, -0.563459171121818, -0.4482465376958013, -1.5306669256473229, 1.1807716523747582, 1.5492060468246052, -0.512435277670586, -1.2611058955412768, 0.33040373780475696, 0.385548876823258, -1.2183680310874185, 0.3915596598064073, -0.761363080808299, 0.7439046048314388, 0.6541004565700291, -1.6223005388637717, -1.0356476028788033, 0.9026406299099705, 0.8947639399113131},
    {0.38928930975497306, 0.6601917974902144, -0.4015215426217951, -0.8738978189179574, -3.315295388972843, 2.4557321018003218, -1.795761380643097, 0.9698145830621808, 0.823563067534818, 0.41118825416515015, 1.4730513579192313, 0.1294442504885345, -0.5774894779085553, -0.49131311805328165, 0.8332240677661777, -0.32371719949752464, 1.04963931643087, -1.2272673355887262, -0.1319348756367208, -0.29330925245339506, 0.026265074816874373, -0.27045697148289816, -2.146946795887563, 1.2498473930374439, -0.784200963578799, 0.6285390462690528, -0.4174551801829276, 0.5801488855409672, 0.11871699717012643, -1.180452870256232, 0.24272605194004504, -0.2610229745414803, 1.3080820296781943, -1.8207351863779881, -0.24280236686601128, 1.2880147449081727, 1.9553360389689052, -0.5246881194012106, 1.0271992966172456, 1.8046831053787276, 1.3366869819997076, 1.536096767752576, 0.5079781297260699, 0.49141063864295786, -0.6994441785090267, 1.1971228342513458, -0.48262141960849814, 0.2604982887010134, -1.9166767371557558, 2.0295584882318005, -0.4363020551764525, 2.380310029120092, -1.3956287374340295, -1.3604363724999247, -0.16020812991273914, 0.5373784421585782, 0.4834790425501256, -0.8041443491842767, 0.7257913700665178, 1.3974823088929471, -0.38783811855692396, -1.6422903983922637, -1.003631101741384, 1.2625288344786576},
    {0.6065134019203989, -0.6683508713107535, -1.0166094273503536, -0.49925262157717915, -1.6129918719566048, -0.2508721891649719, -0.16811798310681264, 0.18561479718206494, -0.7411040704083927, 1.8911810844211694, 2.305298412106983, -1.492615895776591, 0.3755069704833174, -1.3330479690686945, -0.9028002781885638, 1.1914062433912844, 1.435438781093182, -0.4729782781840215, 0.5508765791797195, -1.6179449091514966, 0.3350614299367775, -1.65329387189371, -1.266862977277327, -0.045930678100286185, 0.12118304363866259, -0.8308113909885635, -0.6714386586075938, 0.9748425084613522, -0.5455468109794888, -0.577326163340156, 2.0814091216053123, 0.5925876166160041, 0.8152584051677755, -1.4846902537953333, 0.9962545672094809, 0.8637264114681243, -0.626451090663164, -0.006423011236243418, -0.06242935712103653, -0.4775685685996948, 0.7145136908512486, -0.3154477482168314, -2.0813453891973164, 2.749896766885326, -0.7881506045162042, -0.2747476053329566, -0.26639373707568936, 1.573516557749112, 0.1973988362125626, 0.4372597720022519, 1.0870179808808624, 0.029893541454120057, -0.14377262028831903, -0.02257526383750983, -1.3280688293286567, 0.8649051242239115, 1.4661635406919105, -1.084467060246493, 0.18750774592963365, 0.27333498648659094, 0.7597553281471667, -1.0985782469081415, 0.8102284156399256, 0.09669792210413472},
    {2.347368687896053, 0.859143050526498, 0.554919334662964, -3.1553604462115024, -0.7117744915920309, 0.5118584516814554, -1.0910775783531466, -1.7361876407351897, -0.44557694857774444, 1.1460357563778651, 1.86663463182656, 1.1252484529358497, -0.4707265668356565, -1.1412432595290622, -1.3204334061738858, 0.19393949461140544, 1.1856425981664276, 0.006138757652858572, -2.17740582462424, -2.741777239317338, 0.6751988703213038, -0.47740100882231634, -0.6338298105129951, 0.6203229918947926, 2.0622432252756386, -2.4482418200851144, -0.8674094196998934, 1.4040099062339462, 0.5919045907355118, 2.050280115392162, -0.2956588560896275, 1.4958882392923818, 1.2899274806244378, -1.5350865829580662, -0.6724774151766069, -0.531426441300316, 0.51957201915222, -1.7563964417803757, -0.7768738586410666, 1.2768200840148443, 1.973251889327587, -1.5425328260617182, -0.3883400894038351, -0.34450762030853593, -0.932015143371449, -0.8572175698038379, 1.1846831055298044, 0.12050599387359068, 0.6041784425459241, 1.040327517857084, 0.23309329941640786, -2.1801117330647433, 0.21062341201854423, 1.2173426963867375, -0.9619360206647584, 1.9650434214909882, 1.1743945291977156, 0.7792329796229627, 1.4085634729795544, -0.8434832499933885, 1.421641550705923, -2.5426756030360247, -1.3992224101502553, -0.6658142127340634},
    {0.34698756894342037, 1.1988014106371694, -0.11406870067237176, -0.25619029200800475, -0.2668796008173044, -1.4601531993137338, -0.2926693928512715, -0.8306460132141741, -1.8489229445162831, 0.06437343671015962, 0.8694732285911588, 0.055637258709217534, 1.1371404377484111, -0.5275149113182209, -0.14252902755586408, 1.5739583862260396, -1.8284352845187855, 1.5233561305354602, 0.939986780167234, 0.5038271144344267, 0.8379071551429939, 1.2903459589510884, -0.0752219812407471, 0.9170864412882266, 1.2049778085152638, -0.8451267992951529, 0.3181854164550475, -1.2148051016108758, -0.42689181114253294, 1.3973655216662155, 2.4322471119076843, -0.2530671188837917, 1.8513099203575936, -1.4155640010271764, 0.6485814249020834, -1.640830700500838, -1.3598385721558615, -1.681789128936655, 0.34600944391862354, 0.8921690151607135, 2.5502949172711062, -0.7536330923800434, -0.30236464874062446, 0.5694059491656851, -1.1852562446543353, 0.309256401415883, 0.6157151162891494, 0.7123154376699652, -1.060226447443672, 0.2226828410576412, -0.43542482909003494, -0.5380511932787737, -0.4694416499139216, -1.012437270120851, 1.6417941514922194, -1.949489750088468, 0.9854129618597258, 1.7081368159917998, 0.3762120205428236, -0.7804504207464734, -0.4658669382509953, -0.07935275678126048, -0.7377205439544618, 1.5930104221215955},
    {-0.4847716840019546, 0.6441812989272679, 1.7343287307370465, -0.8243660810718637, 0.5743956609878451, 0.9623138078967989, 0.429403525902276, -1.416153155897544, -0.8065153566426877, 0.7529004986372637, -2.0447337588045045, -1.423617235130112, -0.44629651621980704, -1.382207120009055, 0.3995133112108511, 0.8467900763186061, 0.7841882162948757, 0.513985974537146, 0.17682981700457182, 1.2006031115299771, -2.159470479709565, -0.7131014231733742, 0.8789425394241249, -1.8978756457804566, 0.30035014662052967, -1.4771188261704495, -0.8192862182482816, -0.46758419534700274, -0.21270245483712044, -0.5068094808792154, -0.2763217491118229, -0.047208643347954604, 0.19937515304926678, -1.3663335852098153, 1.7515235518861392, -0.2477738413369858, 1.3881949049981819, 1.1293381097037234, 0.16542264880090946, -0.3173425583845681, -1.6570916117208565, 1.3104349599728649, -1.883422887030752, -0.07299932136026012, -1.9343384687105514, -0.0058227377869329465, 2.247444483531803, -0.5753948224143113, -1.454683004342675, 2.0978617778161923, 1.2651390445571211, 1.7056984458608917, 0.35096238420391124, 0.9218528153957771, -3.19696711744569, 2.081545852753329, 1.5253211681256087, 0.3401466033985839, -0.626835472983546, 0.8740978774008704, -0.5258111223195594, -0.30222918180702046, 1.9381479826837849, 2.838814322932875},
    {0.3140236037450014, 2.5149734941721538, -0.2455103412367736, -0.7534362806173582, 1.7533585359708388, 1.0321225985353961, 1.0218929468755578, -2.0464906794535116, 0.31933616338050724, -0.5438496448283948, 0.7707305856710615, 0.8693182899945429, 0.44180740902625365, 0.43362166232636906, -0.4015142659206456, 1.8305888050277959, -0.14461067713818965, 1.400042969986329, 0.60354227582442, -0.9930773787720801, -0.9547792656486735, -1.4782177787543, -1.7819230745420591, -1.1490579437372954, -0.06600667676800437, -0.8797925780437276, 0.38641892880242845, 2.5328674306596497, 2.412905840211499, -1.867276116708082, 3.144315692719044, -1.339520948688049, 0.9819355960056676, 2.480853104715216, -1.5804529219258747, 1.1375519096295492, -1.4025404860436408, -0.29363187673946206, -1.743992014490771, -1.989680106378319, 0.591221432940343, -1.0844698809462074, -1.9114531592611748, 1.0502376814071706, -0.14646431276810062, 0.7317441395017628, -1.9397407972760103, 0.37765442788558834, -0.36404335216949124, -0.3996826621124333, -0.8937057037627699, -0.5691326331493141, -1.323619654613497, 1.604164471623431, -1.6533542179552194, 0.6874398493971916, 0.5893899311477597, -0.020171981394613694, 1.0820569375819593, 0.4253158225284856, -0.46864078748899984, 1.199747036319403, 0.4094496126963447, 0.2726804107945571},
    {-1.964835946484173, 0.50333143178372, -2.998948799064951, -0.7796976687643951, -0.18397140315237154, 1.5498108286485421, -1.6266432597077864, -0.9409928682179738, -2.0789069284169375, -0.7495329603297436, 0.7465049145522599, 0.17106842677194248, -1.0802701772924581, 1.7617285245011913, -0.25925302475709366, 0.9379397837551796, 1.2794060418656812, -0.5574207310321567, -1.326043607510338, 1.393433629347035, 1.361331274667366, 0.4485837288723941, -0.8417631796848244, 0.8750641459795169, 0.08322480739635639, -2.411923623271086, -0.06558352527103276, 1.0895437095528122, -0.6590390565591234, 1.303942074876961, -0.4260077075553069, -0.2988395316433686, 0.06544577508955113, -0.08109388655737834, -1.2962438530490015, 1.6262250135303322, -0.7722828141451651, -0.5214900230286006, 0.8210260781411851, 0.4385455337087761, -0.1251948911389521, -0.4954060188891814, -0.9238286174974165, -1.1226752654450527, -0.7863824699841535, 0.09632952010019388, -1.6878933378237009, 0.07469962367707396, 0.16337643957869585, -0.8861179547814855, 1.1609902962940941, 0.8786630609769983, -0.4919710204224213, 0.777596786162812, -0.11578948313120277, -0.08755737104345222, -0.28498977920580176, 0.3955040101768246, 0.5752232709655893, -0.6014004055829184, 1.1066327234161646, -0.04358936459258973, 2.6586306801707313, -2.590148722510498},
    {-0.05151143053702575, -2.5319174225906336, -0.14241633193108835, -1.1644746317892873, -2.588207206709697, 0.3797242258882686, -0.6021035703442883, -0.994430061043963, 0.9653447959676114, -0.14855306244338484, -0.4167229222726031, -0.1841482006873866, 1.7618435340639926, 0.3552130245120194, 0.7961940822086607, -0.19552293615917654, 1.5346512551981981, -1.612181438695608, -0.45276800468252687, 0.7844571011183865, -0.1964300621124996, -0.6485104459734433, 0.03647827114211697, 0.3508902132017131, 0.6776334133281666, -0.5361444407062922, 0.6257375933820852, -0.09409906641735041, 2.2903625404994608, 0.5605150364640694, 1.2159349991809256, -0.4230482007058514, 0.880468891069687, -1.01829992471918, 1.5819676890728116, -2.4993505701147987, 1.010880075998821, 1.1969054994689943, -0.12795832513951594, -1.881106867645364, -0.46483863706759854, -1.4696774093783183, -0.7036641965050927, 1.8725388534642238, 1.6730632124274383, -1.6768328281287013, 0.5333629583647627, -0.8343943252482037, 0.288098065772142, 0.9601853098998718, 0.495137683213429, 1.005450642723301, 0.34654406507712915, -0.9463294705777895, 2.4446951452379917, -0.44804766426722314, 0.44979606184591037, -0.3984405267548179, 0.1384704793254135, -0.22132627450256795, 0.3483748627604765, -1.1601582553532008, 0.7702837748254109, -1.582137408898759},
    {-1.6300725668372653, -0.963452266665308, -0.052144362969674236, -0.6017420568290851, 2.1205713046722017, -1.4218187008085579, -0.36261065825076455, -1.3033560187460926, 2.4930742215165327, 1.1046666604414255, 0.0457438698419354, 1.9247027013851552, -0.17099068177817933, 1.0258917351174375, -1.510190638149012, 0.7635604932128665, -0.263968754295255, 0.6097598187961816, -0.594901448639734, -0.839569262896857, 1.0411985487905746, 0.7357737487895334, 1.6800834136143723, 2.5319224250192263, -0.011528421458242583, 0.2549425805013532, -0.021137410996521288, 2.3469860945369154, -0.47691323265215185, 0.670523553674787, 0.5873381282496289, 0.4111851672668245, 0.853136690294157, 0.1252200139158626, -0.051512537153565956, -0.3635714337688801, -1.880540911158108, 1.8704662733228563, 0.4252691637246175, 0.27860574621536743, -0.6353264508461941, 1.4512083277118069, -2.2305823244165808, 0.9199048498817781, 0.30500816197662234, 1.6092056196937088, -0.4569411189027692, -1.2718380155482216, 1.0313859355859623, -0.4826798933359077, -0.3974731257393522, 0.5985847816229308, -1.2055980259865415, -0.5632806937526958, 1.5551510916200706, -0.53355446749289, -0.5239037114154773, 0.006548663700906696, 0.03030900942157288, -1.1658504922901276, 1.7317382845081963, 1.0534078973531846, -0.5396062086786453, 0.49493392380050494},
    {-0.604388287819468, -1.5328388830023196, 0.2962826106546237, -0.7820940615783878, 1.4515033465743463, -1.2026069947131646, 0.3962648690204009, -0.007573273506855264, -0.17209174832735588, -2.9761978251053565, 0.679756989562683, 0.08572290460570325, -1.530082482526321, -1.1443998712828125, 1.3595131656646522, -1.5735569496474433, 2.9211216860216407, -1.6168641944274615, -0.38505140502148416, 0.5853109349368137, 0.609110840447076, -0.1624696192355548, -0.6508436566926443, 0.2541258870807785, -0.2174827056728671, 0.6448848516388497, -1.7344207012192014, -1.3418975794008465, -1.9075596385389104, 0.5111715538978576, 1.5068352613460547, 1.513787283789307, 1.005852756153235, -0.0017487096663982447, -2.037100240164296, 0.8851528504511134, -0.04816747936636237, 0.2922643321777874, 0.929352420935271, -1.012543799410599, -0.15570789732374404, 0.37720669780596244, 0.1169652277539866, 0.6864531223914206, -2.477443873316555, 0.5124762254174386, 0.24886686685929837, 0.5122956222450638, 1.152935513147243, 0.9891794061607326, 1.2822403400237863, 1.5335271533859673, 0.7878723785902334, 0.657176634705295, -0.7106077573539301, -0.9800314360896406, 0.9033722507838776, -1.1271129536094628, 0.9023191047610153, 0.06919808493233974, 1.6098637248495458, 1.0437798038683248, 1.0967150302849167, 0.04153382016586387},
    {0.6645000340244628, 0.8892293343546418, -0.20639218684548807, 0.8817067560762308, 1.3200838651235718, 1.4648194379898294, -1.104607991864379, 0.5332539712896417, -1.4317139740750453, -0.357034834371813, -1.0100002938077064, -0.7080550881717063, 1.972560582142208, -0.002547122752908705, 0.22712017200979415, -1.0092841017096266, 2.308274687135747, -0.3583668070791079, -0.8721131834853703, -0.8448720026514661, -0.7244434762658981, 0.41727455125661495, 0.2880599828360115, 0.09277399910894615, 1.2561864302270633, 2.2921492312967975, 0.8449956997354374, -1.249845411093641, -1.8223218005441104, 0.24178884424564337, -1.636183527787189, 0.6970786019154872, 0.5116345575414916, 2.110301314092655, -1.0770617340604087, 0.01911197671845233, -1.7786787925678442, 1.4211119029373545, -0.6842833793300748, -0.4805478414622484, 0.8523707992416641, 0.7957166988087171, -0.8086510144609331, -1.1427156779355119, 1.8518814905144232, 0.8319906708725877, -1.8216402390982047, -0.002806422992350756, 0.1580315183321312, -0.4135668409948359, 0.20203346479571258, -0.09805916802869445, -0.7888005627484452, -0.1329627701022986, 0.9182765581073679, -1.9222269901365017, -1.1496742209639192, 0.9135383576311166, 0.039833544903450153, 1.8584537771053597, 0.04897419220843007, -0.5871377671149837, -0.7310469766764522, -0.7239915039191787},
    {-0.6319850343833228, -1.5508866960348546, -0.09864101706317215, 0.6597767717817314, 0.7254702614559225, -1.4381426560000652, -0.44769039955411494, -1.8101431152236644, 2.321189001451777, 0.23617797408880048, 0.2759141778228258, -0.5856292919598165, -1.2899128129624677, 1.2826332225262267, -0.41571633444626277, 0.5078297710209493, 1.3852915864856863, 0.5750318243783723, 0.46614214227203116, 0.1318422206920658, 1.2321864176462414, -2.881115460177774, -1.6334063539283041, -0.3685907126551891, 0.2756650993548269, -1.9698001836151953, -1.2687844024577866, -1.0125121282445477, -1.0291943217095065, -1.3019890894944306, -0.8320805393344769, -1.9212062362612634, 0.6851108897438833, 0.17862040015485176, -0.18675718153850124, 1.2564877461336554, -0.026661580520805986, 0.4151205907963819, 0.1613884176888856, -1.1470909750621352, 0.4896355698260479, -0.14772488562709768, 0.06909184165213571, -2.1827931189845433, 1.466074477526556, -0.25793822256576276, -0.8239690397226501, 0.3454379093239635, 0.7791898250034041, -1.217046114704311, 1.0118383589406907, 0.35675165319227325, 0.6306092568934447, 1.1600537972366434, -1.0384264342265932, 0.205782673868579, 1.2725726643170894, 0.6259663659497979, -0.3782063343817198, -1.379628287045435, -1.1155809926880005, -0.37479623697386905, -0.7652122971887542, -0.7518101259141976},
    {-1.1371364352579405, -0.46381901192870906, 1.3154412605153203, 0.3750151510444052, 0.03538001522468879, 0.1925421507482999, 0.5917550642898987, 0.2290574399460747, 0.6116760794640242, 1.2968932446430523, -1.3052162285410722, 0.3403472374612843, -0.11393073495549663, 0.21796328782295302, -0.7955272253560539, -0.4392099253998553, 0.3253391593759412, 0.24409732360316122, -2.326077053743051, -0.2473486533356038, -2.838433503077306, 0.35516593178577716, -0.6571716522400821, -0.6720234578104712, -1.6669200193634477, 1.1626768679620785, 0.3467052584831698, 1.0321521686131025, 1.02305257023949, 2.5583079804525903, -2.0677199796366175, 1.8073923708028516, -1.1581774589831477, 0.5538304986553332, 0.5937152382690338, -0.13101877688824837, -0.22233489501556206, 0.06801936647053304, 0.4841868800091459, -0.22323072937483007, -0.891814155354953, 1.825177891952931, -0.2753178617631162, 0.2901263367778924, 0.3726867602366338, -0.02193573763752821, -0.1181837528529814, 1.624331366829184, -1.5476467350785372, 0.7387521775584105, -0.09474362499412141, -1.9300271850218074, -0.24588938720510503, 0.40299023330936984, 0.009962822109454855, -0.5634476805802385, 0.16997022421013958, 2.1304870890885614, 0.10884375032801735, 1.102027972862739, 0.14248939462515872, 0.4344382902713371, -0.5549520864730756, -1.0952390986499192},
    {-0.5299627341551685, 1.8808368562951605, 0.04140279009137496, 0.4714732691904446, 1.4508483419080853, 0.09838594712374482, 0.8834885212046151, 0.08273659630689863, -0.43017863606181905, -0.5174782603942594, 1.2266274435645388, -0.668447481724096, 1.5544432506131258, -0.3825750938727036, 0.4255793823224733, 0.9438503868428337, 1.5143324608567048, -0.5890328924105196, 1.0865609687873237, -0.6791273600400345, 0.4069937032396427, 0.4564036760005139, 0.43402651728789726, -0.18247651520336947, 0.15387385121468597, 0.35760161734251933, -0.35516544460430216, -0.17931465347352504, 0.9711297794748086, -1.1990415686320053, 0.5063931488211386, 0.7422406815198483, -0.08652924504538832, -0.051633229489679626, 0.9085393165479961, -2.8791679078818313, 0.3877716870590001, -0.7242966631264053, -0.3797477602508827, 1.353793505261454, -1.1392717667025274, 0.4231308769793709, 0.47856513169149223, -0.8238705245358285, -0.5689137237142291, 1.0580315971896574, 0.2663467189364023, -1.8337733300671826, 2.1505577286228155, 1.1735378103979535, -0.11700473331903107, -0.49226213681166436, 0.5372982622522499, -1.877074598749147, -2.420687305100686, 0.09806776321890916, 1.0761665154768116, -1.1614331018777937, 0.9839265068991816, 1.320431119815342, 1.6798245541768357, -2.495146172339427, -0.6696080179677029, 1.2839426606258297},
    {-2.9710707553260325, -1.0296920060846397, -3.294570095695771, 1.2659875864229073, 1.5511138470694124, -1.7918246327158405, -0.6669786002659043, 2.1140018037907438, -1.306364986433176, -0.8321131836160169, 0.898006922295571, -1.8242960328390652, -0.600832447266313, 0.15033244557284758, 1.6169850245036865, 0.4360273495026752, -2.1167797017425287, 0.18953702892170182, 1.6955466323191444, 0.14361712671275917, -0.5298576336674257, 0.3342599784609994, 2.2243197166393287, -1.6823961127885116, -1.3923708720796468, 0.3136357274530048, 0.5551065824240844, 0.5764366692056639, 2.175279700955241, -1.5094401127628925, -0.8475546593318563, 0.18350309518238672, 1.0009379092986537, -1.414921150004186, 0.8720515030618771, -1.0876233317987116, 0.9084365977132723, 0.9822840203307446, -0.2382899920336972, 0.44934387533169856, -0.7143862770807409, 0.6531206451665803, -0.7696974079484973, 2.8580094806230285, 1.3285092043718352, -0.0874398613855024, 0.4432046539252891, 1.5392713714675241, -0.0664184878158212, -1.3385360661667525, -0.30498285718611795, -0.5173333838339493, -0.8405493796348034, 0.4325634251647297, 1.1028757872858905, 0.6795138531778483, 0.4011123041295444, 1.2602272429481622, -0.601637762176274, -0.21095170184726325, 1.582533608785211, 0.14800297598274897, 1.1297631674275115, 1.5110135951271977},
    {1.3994027401303297, 0.3794189093828728, -0.6822273564533188, 2.1811978074730414, 2.4575252659117197, -0.16570575508994256, 0.881190254979977, 2.6634747993521577, -1.6243690630750311, 2.193798089098765, -0.08636899183189746, 1.1821445252322935, 0.2536597625941358, 2.44343027249253, -0.5428269098121516, -1.3459288309988777, -0.22740994423945124, 1.6006077230097664, 0.2732171592408155, -0.4183241345535677, -0.430993357486841, 1.427827335061154, 0.24272339264909906, 0.7117143939551184, 0.5089111344678492, 0.19816619761093884, 1.1345561717918833, -2.0459290056748856, -0.07028503966410077, 0.4898580320322717, 1.1084484398635575, -1.449631872694447, 0.7328398707750106, -2.307872327798274, 0.9298366764084247, 0.11541240832721154, 0.6672107367829485, 2.204862686170321, 1.3266843597119757, 0.19539754024613576, 0.1081104663845686, -1.4082147753059455, 0.21802349815890798, 0.02405718697431686, 1.9431387831913678, 0.07958887894406194, -0.39248898160252754, 1.4997785506713681, 1.1118920608273593, -0.47861929131188125, 0.4764469479137005, -0.4785166271206359, 3.2864570673102618, -0.2781807608229216, -1.1646029585972588, -0.8631820169741948, 1.3037005307771659, 0.5849936843010212, 0.5895103325363308, -0.15603973094838383, 0.5084036285343265, 0.6351937236508527, -0.7386643898956483, -0.8665271722044585},
    {-0.21045315824388866, 0.31873163516578873, 3.0566414084905937, -3.7367159126061122, -1.3681670551490153, 0.0367063048574664, -1.2217979730391413, -0.021137347407379287, 2.1580234394837468, -0.3694488446502679, 0.1502720024508244, 0.31697122661762045, -1.102628390516813, -0.9239981842384967, -1.2339087456999267, -0.8452010646610163, -0.055837014818652296, 0.12327591555694203, -0.9262905190024465, 0.29700488147984916, 2.954031298836512, -0.8271909773369022, 1.2713456257849884, 0.09923996848901885, -0.690357463955852, 0.6247951632443717, 0.24864407468399616, 1.0775739513236875, 0.9197223349468924, 1.6864564690702224, -1.4942844147918912, -0.12059746492327293, 0.12495302793507591, -0.6238431595258392, 1.054113161573995, -0.44028035459287, -0.9555983020569128, 2.9223689245333704, -0.3885345806247174, -0.1640862058667667, -0.8855410649188096, 0.09397176991748753, -0.7879037094592156, -0.8309358943327024, -1.124468035024845, 0.6431416791734502, 0.4580621680379217, 2.3637448636551146, -0.37363781042662997, 1.0056519308403118, 1.158360720048812, -1.0394018652521533, -1.751346146874881, -1.2880455449316202, 2.102644618960192, 1.5896744572608104, 2.0246433271593216, 1.657998528932088, -0.7283476282242415, -0.24864465646873501, -1.4955875621197192, -0.27211967146960364, -0.6377990536159923, 0.45409084526596644},
    {0.5748007883249294, 2.495209809221247, -1.4311175975639687, -2.2277717801517287, -0.1943052204550482, -0.24053913803359345, -1.2180255584056252, 2.813803024410179, 0.8706514473801225, 0.7617402568411539, 0.831007389684501, -0.5704806238420721, 1.7452077576658502, -1.9756753865279677, 1.4103562830381726, 0.995098477618297, 0.196869017300754, 1.9732772828996732, -0.5913553762579555, 1.8511266809017044, 0.1826357333601739, -0.32111269682555604, -0.17191906906366616, 0.38969157470054816, -0.045980576506378344, 1.1118476999684888, -0.7767752085131676, 1.5808296019656596, 0.0979158763845272, 0.9454383679827809, -1.6596077931198219, -0.33999279037414926, -0.2669895399389756, 0.16272442456075445, 1.1318272614857543, 0.4093976713478038, -0.7290189364710764, 0.13708580860264713, 0.13571349303049707, 0.6682528281184279, 0.8070692394403733, 1.0139134455606977, -2.600865743679165, 1.9540697181076983, 0.24442754766516814, -0.9461974985001728, 2.048509974401226, 3.181444579601011, -0.8974116016238562, -0.29118304890818236, 0.491841465286937, 0.22940671636875398, 0.4355157596360748, -1.0239583917941946, 0.6625944610363695, 0.3100636325613328, -0.22517857063531924, -1.2512984143982968, 1.3588552513519427, 0.3715266652740159, -1.5866612339333752, 0.9675227742306924, -0.5525898941696059, 1.6553338224170786},
    {-0.3299254847203611, 0.8564707460864793, 0.35502523385198986, 1.5587174669706032, -0.47923162383350393, 0.8830708386156122, -0.3462240780715937, 0.8221629564478031, -1.6730674576738924, -0.8493201640878255, -1.255794472495929, -0.3043838481338507, -0.11990787227566316, 1.1703499008722433, 1.2633992571705623, 0.8971310997957982, 1.6109584012140048, 0.9097431552679088, 0.2556374152574631, 0.6344496085451675, -0.7363509761549561, -0.8865340362919766, 0.4354363186237524, -2.9700618840506605, 0.2365153414779935, 0.9688685530186592, 0.10150326367664604, 1.5548681625732148, 0.4626249600484145, -0.2751899718914925, -1.0804232256106934, -0.3571451533502277, -0.2920232091516603, -0.05064665017505974, 0.624229154495898, 0.9611178354508048, 0.8741618657741097, -0.9780047842150549, 0.8468394230141321, 1.611740460305075, 0.14125358459563317, -0.9844639777400992, -0.6078125730050775, -0.2787848817569199, -0.03643263152517894, 0.3633608490343859, -0.6742518440730203, 0.9627666369770962, -1.2765560766289437, 0.781620801522917, -0.02026642005851115, -1.5002555827394068, -0.7190333054670462, -1.3207910437755963, -0.018371754989132457, 2.1610866869682805, -0.4624867912209923, -0.8370006143579084, -0.002753535534799068, 1.192722011019999, -0.4671353286870299, 0.47128197249949283, 0.9389028077324936, -0.2761006249507365},
    {2.0202686755815997, -1.0361897309334014, 0.25134764981596547, 1.5732162703708252, 0.9281830407442487, -0.6257770487900285, -1.4028321504582937, 1.6593060758038591, 1.3623108442804601, -0.134897830143965, 0.3638844902343087, 1.351238337037679, 0.18032108255813, 0.8765558678709277, -0.5776171055735576, -0.9076660833719731, -0.3069426744868017, 1.1033731675768428, -0.5554452307681971, -0.18827793117226793, -0.020856926941763262, -0.42853912785432274, -0.7590402294147028, -0.28965054285168695, 0.558572956261974, -0.5901626150348124, -1.031973644551058, -0.37196601684478675, 0.18518775457086958, -1.5319194360273125, -0.6187989755013883, 0.09239733174424632, 0.8049199246695816, -0.2783857755299234, 0.48496595522066843, 1.6259736494151051, 0.5397187093508857, 0.7573402633306061, -0.5705988104043099, 0.3828622505361883, 1.0979911115587515, -1.4945155997813426, 0.3677832746822817, 0.9330112434915894, -0.8970807022590082, 0.037742051637835033, 0.8232084125635921, -1.197538623206679, 0.20936067496184507, -0.6567697731035567, -0.4076689700186627, -0.19283931027465714, 0.4439460979608672, 0.5771552850164937, 0.3437589799787104, -0.8319377999422822, 0.7972233612365713, 0.8671542746020655, 0.38253123736460753, 0.0630980287468972, -0.5685026398739184, -0.205207631475656, -1.5980807036719602, -1.4308084626126358},
    {1.5091165681598546, -1.1040793659070682, -0.25958774537017154, 0.4719542946002832, 0.5564018489161907, 0.32783305038724725, 0.08498923809696828, 0.5088525977628313, -0.35005257693233793, -0.21807255826553712, 0.3639104586225832, 1.4188397769365493, 0.9690505716653297, -0.6024198670021856, 0.07941332622514076, -1.4200390331882933, -0.42189098510821516, -0.7894949304414679, -1.2020402299078978, 0.2348809474289402, 2.016252154831303, 0.03040305963099859, -0.49739379557232927, 0.8042224311907038, 1.1939000536302935, -0.20693398978008531, -1.342023885867303, 0.19985326782878315, -0.5328758909822195, 1.8011630333347566, 0.82310909254497, -0.5557949933133313, 1.6808403305056185, -0.018923310677382645, 0.4915667819927523, 1.8693048650685018, 0.4117977887165513, -1.4616980454940238, -0.357279040484739, -1.451877305789353, -0.17885676015132365, -0.012536881397059106, 0.20949858374269498, -0.3867034031247996, 0.03666591113581114, -1.0388512310281741, 0.12511839383401863, -1.4281327101749477, 0.3839178816967729, 1.0588278659703059, 0.8273805020545411, 0.15044387807765977, -1.1160371115235597, -0.2702802952738633, -1.2162601783587652, -0.7084288492803082, -0.9707495607561683, -0.9353022639050269, -0.307540900716411, 1.6961688748145018, -1.9579990695564884, -0.46039953698788283, -0.9803409174948395, -1.1891579952551659},
    {-0.6368946113423575, -0.4518148018515666, -0.6373206090299026, -1.4989091214306784, 0.9455117424038174, 1.359967246396881, 1.03734017106995, 1.0086608013777025, -0.14727788789484486, -0.8886381854432006, -0.3520909299469625, 0.5304070372506747, 0.39284702885968886, 1.1137003877245881, -1.1804362358593286, -1.023575484257753, 1.0121086660860037, -1.7987317280696125, 1.5635370247486517, 0.2833784473076288, 0.1860755482620143, 0.007602963151068279, -0.2741144442436498, -1.1295879419322625, -1.14839525457385, 0.6628348393087076, -0.5303957439390905, -1.534143074341485, -0.5199588856900319, 0.7077568294011565, 3.4565557528253126, 0.36105167097356383, -1.609394892902658, -0.31316957317884936, 0.0466623189740295, -0.3586389239152696, -0.6169298442352119, 1.3723864633081357, 0.48237078230935887, 1.707099456317403, -0.3779286577527458, 0.7401516423919337, -0.28353860102243417, 1.6007465720514722, 0.6526369140785317, 2.16214250066532, 0.5340742249173986, -2.0320693497019495, 0.05670666753061562, -0.8831085106882457, 0.9385191349342655, 1.8651384931003703, 0.2310121723910397, 1.713733571133545, -1.2252282518719992, -0.626899036225953, -1.4515176441588702, -0.8425885954227585, -1.192894533710873, 0.5005984313007197, 0.4227414060751099, -0.26563511916531096, 1.1169710218574835, -1.620453055826472},
    {-2.6376040468769073, -1.2276765195176669, -0.7774471048966248, -0.7084243640519172, -0.8017402087850648, -1.5975163373028363, -0.038640517674199966, 1.259531245397013, 0.025693341307316545, -0.9133139431963049, 1.473111863144777, 0.6474976864311766, 0.7041850737496459, -1.0566246047845804, 1.4011795394679418, -0.5349461188560293, -0.3993721708125927, -0.34098466091395024, 0.5537009773250284, -1.3132102923668227, -1.5589518790579293, -1.1166942469621381, -1.3173633900877326, -0.44526889366261563, -1.5486468815573349, -2.0135665034856043, -0.38141556572501023, 3.6989744259543302, 0.3486278994961892, 0.9652309960207484, 3.0874437700712742, -0.9027702105046636, 0.40373297124478447, -0.11269949848830892, 1.3546970881301792, 1.6896221928373643, -1.1278245594551515, 2.725507252091878, -0.08899529436101487, -1.423326002008152, 0.2326369229424986, -0.5735438373567838, 1.0132282069169936, -0.913917847284066, 0.6406647306830643, -0.19028927137741214, 1.2280170098853123, -0.15914725476073807, -0.0878897786551442, -2.327924342713048, 1.0590043014023713, -0.5055290796622185, -0.24993985187637888, -1.5348155398533698, 1.122745299337723, -0.05603243863772983, -0.4474568679060576, -0.24672965214624362, -1.5186189613859404, 0.5542633955788137, 0.46019269706573973, 0.37875521371872717, -0.5762234998157983, 1.227693015227382},
    {-0.13596898571072533, -0.41251349975116813, -1.1686748048282627, 0.9274488215503963, 0.9996106318031402, -1.853702568585489, -1.8934239775698467, -0.07036279671808705, 0.13224240005123086, 0.7752968491219714, -0.8382198690216546, -0.7290755769283441, 1.6213951522638665, -0.5312645171994576, -1.2503390087394641, -0.921259909449123, -0.7331396760710922, 0.041670763748859224, 0.6192457081936389, -2.20332772632273, -0.4408397623756863, -0.639362359124764, -0.2218906036770257, -0.4879157839779096, -0.9226474780910747, -2.250430957532906, 0.7334712941145138, 0.6166307792388502, 0.20870806210504286, -0.8504008360231019, 0.7156043001687049, 0.6104464286225887, 0.6368733222158467, 0.525725350028709, 0.9753024364442859, 0.05232880961448019, 0.4931815320414538, 0.4545424034087451, -0.8373452140369056, -2.4953242914184024, -1.0928393959554024, 0.5436308473904881, -1.33648598742872, 0.772110540912194, -2.259718248492421, 1.0704030041968065, 1.9583868328173002, 1.1242011483521652, 0.5450260906253755, -2.337720124846412, 0.9568089027660499, 0.30153672472745346, 0.6442272822802919, -0.598491729762242, -2.4587050482027006, 1.4543476114357599, -0.06427739617154654, 0.25722233158325836, 2.6359787830225896, 2.1493161795143307, -1.6149006959403762, -0.4212046735207955, -2.0892885245999486, 1.7332149680531714},
    {1.3395633884836664, 0.06984600905942275, -0.7243323569838512, -1.1435798431964928, 1.1025590849838998, -0.7658719178036875, 0.2518323594607536, 0.6050106443471697, -0.16956226082470935, -0.5807779418466209, -2.257488989740649, 0.02842885540144997, 0.8409572520748149, 1.5369411865911753, -1.7016774698527046, -0.516168167673807, -0.1505690430196297, 0.6916236853625735, -0.2619219966904576, 0.08483102782581617, -2.0784402176831462, 1.5038008465361092, -0.5803383135571599, 0.9686841004011696, 1.0390072450961647, -0.04433615357604578, 2.2858517568219674, 0.17589817587570428, -0.9107577516177865, 1.1437300472948073, 0.9022699279424813, -0.5537574997877428, -0.9553971331453432, -0.07594030521353605, -0.19775938121302425, -0.2229577426109303, 1.3746449307917379, -0.7580115283475305, -0.30863065567678644, 0.24292356835891496, -1.125325190383294, 0.04399076774483159, -0.6291987994476084, 0.07677280031357767, 0.03681792704131285, -1.444325589803658, -1.2076156404337701, 0.424641066013909, -1.8069162091498772, -1.3755093753199115, -1.2435038011558837, 0.4609832007592725, -1.814400247711497, 0.718336053810333, -0.7715146962878754, 0.6042581773630649, 0.9692261577359998, -2.007961641626442, 0.06624367488892154, 0.4515524668373133, -0.008261804688930643, 0.9028501586194745, -0.674299968522412, -0.3243976464422081},
    {-0.3018898492647186, -0.41284197938061773, -0.888643985899764, 0.4659875580299088, 0.615088269439624, 1.1120731300781255, 1.4750884853644395, -1.2999894473178395, 3.2107200043863187, -0.6781154693942314, 1.745808417834241, 0.46545059491686464, -1.3712528982084387, -0.9523744152382371, 0.038074752260902185, -0.18251508299097757, -0.3422781596405239, -0.8142320025883687, 1.5598183173309346, -1.6211343824581552, 0.08426103669737058, 0.8391409958952726, -1.8803867248203405, -0.5010551916739797, 0.6889644248204768, -0.13521214894640243, -0.6031827046913674, 0.14441456482286122, -0.5458643975511195, 0.23074028517406173, 1.3712228912394149, -1.7978124986565918, -1.7224792167495666, -0.8225618216449596, 0.8047795644084461, -0.3376787483073679, -1.4012877840634501, -0.05312483784112757, -0.628664986501172, 0.44664453271054416, 1.9241334960836984, -1.0176153133738726, -0.4922156122282538, 1.1099866640251201, 0.2988941781347811, -0.4813837746629249, 1.165852619166259, -0.6041197109470876, -1.7372193556279119, -0.5004282354841543, 1.2505839623713397, -0.01644733571126892, 0.866540760796669, -0.5437135015098375, 0.9652810590330659, -1.0617912536256122, 0.9200420822872095, -1.5635304115200621, -0.3527707989426415, -1.1955034499821429, -0.5645269340285365, -1.6848548677558899, 1.6711339775180567, -0.45927314365528765},
    {-1.0027494204090264, -0.9135789921350642, -0.5611062304978733, 1.3658528231110318, -0.9568516893908605, -0.18204583907558286, 1.1889398281839854, -1.651453119217274, 0.013089866087662353, -0.8590880882827806, 1.9139799611557868, 0.4414103138928223, -0.3771112209856085, -0.9365416700602898, 0.7980864066818084, 0.8638120998714817, -0.10427908514403322, 0.1742040069081701, -0.8397090961726834, -0.631583541897905, -0.5991508874416761, -0.7653443571389023, -1.1960392457566758, -0.4650597717765542, 0.8945058724646793, 1.4020644904233843, -0.6557623410563793, 0.6315010270496018, 0.3345290148417372, -0.931344386154791, -2.2619078084003745, -2.916009677961058, -1.8166857416731357, -0.7633214859582892, -0.747146968857317, 1.0254918159556778, 1.0496175714140872, -0.4076931203059368, -0.7826545303666684, -0.26678870604673327, -0.2162840473552032, 0.34850441053657166, -0.08473703061584749, -0.34650027205726075, 1.7386455898159558, 0.555845196387765, -0.9956924996243539, -1.0065662899260968, -0.15598175732137273, 0.06699680379926773, 0.8955134634627827, -1.138132753487172, -0.9610445390099455, 0.3371094854673518, 0.7186772680584467, 2.1157814959200087, -1.0641141774366873, 0.8000794058129116, -1.668675403247377, 1.4977556660331819, -0.3836839912839566, 0.8765883520735073, 0.2918033332560833, -1.8413699310397313},
    {1.7579380746379576, 0.7415425779530377, -1.4904193719355223, -0.3820808059220382, 0.46515517232446607, 0.12384874770946257, 0.6923999723822667, -0.09367710278711348, -0.45228308858524746, 0.7574165090963481, -1.1244402648875893, -0.7494023991806545, 2.0089613875323558, -0.7761031441929905, 0.1098384408424756, 0.6334418144588975, -1.1579240695013615, -0.03790512827534584, 0.5176512224615931, 1.0804990131852046, -0.44039509688069817, -2.10998842550072, -1.773361851438009, -0.3886186693202286, 1.2934900166099939, -1.6959710322474644, -0.9080003052829588, 0.6244976317779392, -0.0706138528335319, 2.1931523103610244, -0.6172673488985378, 0.2345913977814897, 0.06123161038654625, -1.0714242253663173, 0.6432440408525124, 0.5843194681252541, 1.3939383759310124, 0.7254585628973121, -1.5657239583669875, 1.4295253804073593, 1.0436643882746086, 1.3658738712684007, -1.199212272457537, -0.27039976637583857, -1.4807022801244343, 1.0812149761684502, -1.9820090511162232, -0.6325622724067894, 0.8725727915983728, 0.45184306173116145, -0.9298244843563904, 0.717804577159345, -1.2467939318584862, 2.402775858644115, -0.7632786995908725, 1.169623680547032, -0.24264055107640592, 0.46046520629813026, -0.705832764479397, -0.12010119329156495, 0.7516156133835821, -1.3436621536053353, 0.05942160894637701, -0.7202002490259387},
    {1.0014598509312431, -2.1854752990521593, 0.7302940326916578, -0.6227982366880518, 0.05707766131557016, 0.16765743722827786, 0.7576258273416272, -0.32783892980432955, -0.9725828028574243, -0.2796825722936237, -0.8410395202160718, -0.49347578369704664, 1.4322790942761452, -1.9538352855344758, -0.6551881689096866, -0.9332988151424465, -0.03412639507206495, 1.739312214803323, -0.670442345700027, 0.20379971343502984, -1.1256373998039233, -0.7700007778495481, 0.5831769635931381, -0.7875074076645024, 1.730731645804011, 0.054532498438877745, 1.1249291043299068, -0.33669011520134956, -1.8836229076773237, 1.0285587522894832, 0.7678718284149808, -1.6757564574987485, -0.6537380379506563, -1.1189160057842809, -1.089173316382325, -0.6614960014270417, 0.05162730264038523, -0.24031802758165305, -0.8788346709463124, 1.0169066958504511, -1.383778379790788, -0.8884387667839347, -0.410548069621375, 0.3557770302391147, -1.09431884519351, -0.38503160794945585, 0.9948664259130965, -0.3157951426922014, -0.7017406525942078, 0.7537110867907678, 0.8002047578715944, -0.8974417933061172, 0.5052141391572994, -1.4675697282509113, -1.3135354276591935, 0.7330962357104872, -0.6529727207399814, -1.5225336472764777, 1.788541166533362, -0.3516193965954828, -0.2928094147102671, -0.3840995585624284, 1.8207086601746685, -0.9110961683325859},
    {1.3951481765274452, -0.8303696608889141, 1.4753747529140735, -1.974997337373331, 0.9189188200267464, -0.3538763301404228, -1.6761942956316838, -0.0714136037716254, -1.2008801605579804, 0.043002626108259154, -0.7293929538654247, -0.10739592741519884, -0.0278516088271051, -0.1615894961269367, 0.6153454591780056, -1.6223497111848377, 1.7345423634867747, -1.1557093922316413, 2.123547531576126, -1.6849241918047821, 0.8379851636761835, -0.14742902316812742, 0.762763109738256, -0.49271723453378763, -0.8239109585152413, -1.1299589545607642, -1.6700508983518125, -0.18904156543139222, 1.8286940813978236, -0.37956160015193136, 0.2292755354770184, -1.37159312539204, 2.3572778609205214, -0.9907633560862799, 0.2834486791441853, -0.35600184626140025, -1.4151573500418706, -0.6834576004736476, -0.8731551723250224, -0.17231610090340216, 0.2034841487458607, -0.4416329008076081, 1.4357931198120537, 0.8233297901851475, 0.5729723615524763, -1.2030248582391683, 1.6799720128894502, -0.3696020782730099, -0.27475498074166965, -1.591750794171618, 0.35592155114976326, -0.13535106836370822, 0.07072817566324001, 1.941475157389977, 0.9100044505290963, 0.05539870355621346, 0.9960417848786463, 0.4213225069120583, -1.555009432722256, 0.23181986362840776, -1.2207410972039745, 2.313904811298704, 0.4840729857289859, 0.22739885603961515},
    {0.5418117883560292, 0.3159580615685738, -1.0645899194923865, 0.0718351110367901, -0.18556651899661655, -1.7461981542085119, 1.2770783292719246, -0.7831133473219634, 0.26132557670243, 0.9488906950262206, 1.1607271489413005, 0.9745628150631006, 2.2945721878828516, 0.6827095107704375, 0.07537783092377659, 0.8673549736149653, -0.3616914086087503, 0.6450219281657855, -0.04197808717049206, -0.8728860569662071, -1.3903567885955286, 1.402222504403095, 0.22903458062673604, -0.3307285208283769, 0.7539936019454556, 0.6943312672474281, -1.1020897329302266, -1.0521681455243097, -0.9818515005379672, -0.7765865897080677, 0.4895254293905929, 1.1941831132547194, -1.8319116843224241, -1.2214826479413148, 0.6366696009737911, -0.8281276286864818, -2.3284572302820266, 0.2922413853411295, 0.507849149451435, 1.2460285317123234, -1.5174407307673354, 0.029877716623238657, 0.48228821919374265, -0.45824311943125784, -0.14260510185151926, -2.088443654889564, -0.7954353367562582, 0.40715602605202433, 0.7345415465104188, 1.4372761597788017, 1.1739660746886078, 0.48860161459585977, 0.22476367232828548, -2.059035874986135, -0.656829268362378, -0.21361385594460475, -1.4646356613563631, 0.5634745458525746, -0.42497505131853147, 1.6667928979860538, 0.13521883130344267, -0.5977370731916765, -1.3249487641598374, 0.6754268478984383},
    {-0.5707175443519853, -0.95890622403519, -0.6704531702989398, 1.0145361549340906, 1.2634253897344307, 0.12349107318479358, -1.082405709147507, -0.21504982564934205, 0.7937092822977986, 1.5407793115363044, -1.3162981889965242, 0.6806464344770627, -0.025282529751519657, -0.563053621277251, -0.992906346836672, -0.4195289724514228, 0.1971000926908288, -0.24209072021265102, -1.2679557883765165, -1.257411040643969, -0.20745547534375908, -0.8336511864296781, -0.28042120019369365, -0.7693454389764369, -1.128318513289925, -1.737581235609752, -0.31274927951821535, -0.6660661451705024, -1.1836548072072965, 2.745706293563763, -1.479087545538761, 1.7579703886806781, -1.2352794035722439, -1.055617894560656, -1.142214025121425, 1.1024702556002064, 0.014703396532610605, 1.2878089225750275, 1.334068297640073, -1.341646504382121, -0.7497913597144858, 2.6604386759695147, 0.55642588070745, -1.4051337088841127, 0.7403250093256094, -1.9204134193259015, 0.9278883426151803, -0.30301076023546436, 2.198620139995935, -0.5276192376563387, 1.083453288545874, -0.6394236309092641, -0.23766022607000759, 0.1985980252002213, 1.5451129277596396, -1.4568846895400958, -0.952140752471814, 0.23006819284261482, -0.9226851277727742, 1.5339857441617706, -0.80493625906524, 1.2541367777161558, -0.3635862172638054, -0.2285784021699848},
    {1.0630654153368366, -0.17784552321089342, 0.7864317554955039, -0.5826687523303535, -1.1298061193924578, -1.761513890461585, -1.8350913156467035, 0.3167023567682676, 1.2846579662202522, 0.670700140164958, -2.1587644207747196, 1.1246852293522005, 0.7536691953064995, -0.0649136782346588, -1.7058126301693521, 2.2208801974812253, 0.020553115360306202, -2.083327878555187, 0.9957806692928058, -1.0719711508867407, 0.30601094898385944, -1.1473579911814542, 0.7952769258917739, -0.5168940283271756, 1.0679123653531377, 0.14003651993326766, -0.228310658967099, 0.7802910877173349, 0.9496313181932136, 0.05316813711606533, -0.7369638782341301, 0.5111916599215477, 0.08382429846759012, -0.2212150624529877, -1.1010920021805906, -0.6006446362892326, 1.863758591322203, -0.14635929247699617, -0.2633085976581827, 0.45815699689728473, -2.580704870026271, -1.1105094008643046, 0.9290054302057967, 0.15588773873996295, 0.33812008350400224, -0.5781096300346087, -0.8157970865729245, -1.8456919034479609, 0.833580833219918, 0.01607984918339645, 0.5182059863908843, 0.49115250609276834, -0.2249381583336668, 0.919630326360095, -0.038371433469842786, 0.32456266770807307, -1.476405795944548, -1.2286617892478469, 0.7539196426596616, 2.2910981391562624, 1.8306171976233767, -0.2002658059071818, -0.635507878856294, 0.6625446496211463},
    {-0.3442604784779825, 1.2302448928403342, 1.5063263930125266, 2.286644471944682, -0.7020637262530973, -0.1772414335361822, -0.01290259475128382, -0.05842445485240335, -0.28056718838819744, 0.3367955232585402, 0.7936901766031277, 0.12347177957212707, 0.25126356401350064, 0.43029030993374273, 0.9500858584483448, -0.035486778407142074, -0.25488352001116954, 1.1935888591191586, -0.6196689896251004, -0.14402971809853587, -0.26803822518551434, 0.5880104798097995, 1.3797122309296785, 0.06429499884626573, 0.8044556566019337, 0.7639125273649486, 0.35260633893101395, -0.25154762813012643, -0.01027204364455745, 1.7219379072265404, 0.7104380803064207, 0.4911845526136395, 1.7231027988119365, -0.5461086838730737, 1.3277016807014395, -1.1411721532825019, -1.0952665652989881, -0.16462317283652092, 1.7614699970418446, 0.22724819396153884, 0.11051275720015809, 0.25680137279619475, -1.5309356515678434, -0.48146103701430526, 2.284944612130736, 0.5975760143054277, -1.0678320107598105, -1.931313848694618, 2.211965019682325, 1.9289804247712434, -1.3846957731503446, -0.6749916568080085, 0.6051397751366887, -0.43615290771594273, 0.1480593485505305, 0.3018787217827787, 0.17320306753400397, -0.617853226192613, 1.58871878482386, 0.28471036826146634, -0.42231065660249695, 0.5479245837190808, -0.6798862368950847, 1.1155849579841823},
    {1.3747402877289734, 0.1632578471993375, -0.019637124393973894, -0.7123787809884397, -0.6066408302363406, 0.7754243482074593, 0.24634872365291877, -1.0634942994013687, -1.9566505554506364, 0.2839580818928494, 0.4071990714011815, 1.949333024412992, 0.5102183329313014, 0.43161646755451494, -2.1185769224627857, 0.6520630460096698, -1.6449562516086453, 1.0008245593924943, 0.10761988100737577, -2.219182653636515, -1.1636263269613951, 0.2263871486970397, -0.9835338087841056, 0.8649673592684693, -1.099964599916839, -1.8302745152017514, -0.13237609444845283, -0.8959006469964643, -0.006923548116975719, -0.2953856804390708, 1.2882626022270784, -0.36688886671662807, 0.38558678318982914, -1.3831594447752318, -0.4811723523759062, 0.3764652196495608, 1.9218698078103391, -0.05700496454557096, 0.2882898483297623, -1.2275276053783855, 1.4631847848649668, -1.4519990606805637, 0.9765844839968592, 1.1118910240580608, 0.8328735483192737, 1.6074723333839154, -0.710990874922035, 0.7640484235920092, 0.10881751529128529, -0.8764286760074036, 1.5975717708824324, 0.5180698019511554, -1.4548134743522985, -0.5073474616698703, 0.8637282999505665, 1.1025000993686158, 0.15562342393594827, -1.287133525724399, -0.4341112864451411, 0.3363558695609125, 0.3748419767382282, 0.3472928080474683, 2.2143896105050125, -0.5277849946876656},
    {1.5049609427383084, 0.050790968288664744, -0.7167253970202604, 0.22295739888537272, 1.196655691423195, -0.08646140217548781, -0.6834623325759379, 1.87877842801384, -0.18864874606565638, 1.018099426437326, 0.7336999131357409, 1.3482022408761922, -1.9489286658873972, 1.3287720578900681, -0.503261898484015, -1.088110424251099, -0.351473377264485, 0.8329229722020548, 0.9297143263937101, 0.3783034207703366, -2.803520658301774, 0.14377881590772298, 0.8835626433601528, -1.4527043456572306, 2.8954047775824923, 0.4750841235202749, 0.23254217443380515, -1.1023171773458853, 0.22602393376542976, -2.150026558629446, 0.20569598724231195, 1.867243180139063, -0.24894444522125217, -0.2560692802039892, -2.350908705184755, -0.4194395681137255, -1.2027584564468532, -0.32448734594842954, -1.2753873323227902, 0.8032535157142664, 0.0447663601328483, 0.3812199025593028, 1.6096030513429185, 1.7675575747415289, -0.4981011672739265, 0.07943271120300945, 1.1199065828199204, 0.7322371302571079, 1.185683361534466, 0.0719902424430416, 0.6277638762020468, -0.8904285287648284, 1.3102689283935463, -1.0707747652324666, -1.1918437523764587, 0.6002262253880879, 0.249289624697899, -0.4293499270282564, 0.13029607857759098, -0.35357821874233625, 1.104071739293658, 1.7517883298065735, 1.2048827949055743, 0.20491799418771695},
    {-0.320463682191668, 0.45813675753576283, 0.26951202973117916, -0.2594143900328367, 0.6908072929421428, -0.020265279473518822, 1.6742076047456331, -0.4304473066568787, 1.5634836066175084, 1.2518601405752685, -0.9834749047469127, 1.4776747766682399, 0.5075473846823026, -0.49370822241937684, 0.28637087449158877, -1.159236254442354, 1.4591919977418846, -0.9086677119525778, -1.476966162779874, -1.2055362587678913, 1.6695862741825906, 1.1332173227986562, -0.7993581359482951, 1.174523169634173, -1.1209120502157883, -0.26086146908085217, 0.20153289802532573, -1.0392957073643707, -0.569280620273435, -0.3935872625937611, 0.062334641123778005, -0.5513808130885071, -2.4205422935671606, 1.1901114568454247, 0.7276528871114276, 0.002137999869029935, 0.056135027418210706, 0.3356706422956399, 0.6685080349830164, -0.29291713618766924, -0.23218793678893235, 1.2288162314190765, 0.4877743642867497, 0.9870789783688441, -1.2202680561337493, -0.28469734313497325, 1.5384715984905692, 1.342236828500465, -2.224168047240887, 0.18686733039259718, -0.9294173575836385, -0.9433895634779705, 1.7473377963487264, 0.35735836346560096, 0.3072144372935274, -0.523831829462843, 1.2811399157776056, 2.1358237265787428, -3.0715836368884832, 1.5539270981716782, -2.064573220007204, -0.12528764238682555, 0.0032668691880455496, -0.5614010655995472},
    {1.652104279680622, -0.8899887349977806, 1.0410716216654063, -1.550149589933924, 0.5521497454497871, 0.9234449824400591, -0.9404050367708252, -0.2922012739053538, 0.5846736300102192, -0.8779714537162943, 0.7696098000061194, 0.11346083809126516, -0.42590255546749684, 1.209611026007671, 1.681274676833284, 0.23450091143968202, 1.0164941333326472, -1.3800618743541668, 1.1313052224863342, -0.19173964439950061, 0.21686527853479434, 1.631843276450412, 0.03086489203465335, 1.1117644278378436, 2.649808303246938, 0.5018108574247393, 1.0562668321857245, 0.24841941229357573, -1.201224890257568, -1.2361701201571467, -0.04574044720063765, -2.749988699405076, -0.7391413959069472, 0.7850664102537583, -1.1667147633832868, -0.9008423906230928, 0.7225749247626514, -0.6441598078878276, -0.7598027502693351, -1.277210032930514, -0.9305369572012069, 1.1523739002674276, 0.8630268707685222, -1.2095864053938847, 0.6188841419272778, 2.219836694657575, 0.3160730378848601, -2.016338512137334, 0.5824170968566524, -1.5583887980122628, -1.8878490530340646, 0.7105614179675344, 0.27539441499045175, -0.4929597225437047, 0.5635016566811245, 0.8807625796147064, -0.8473684976309424, -0.6016443329477211, 1.0739068562502767, 0.041010854775408244, 0.5896723452977719, -0.8202843433710914, -1.2405133745071837, -0.9783819797255061},
    {0.6462134043276513, -0.586678851249445, 0.0013990561365317489, -0.5882235373069721, -0.12207721801221375, 1.0223676101625354, -1.3308365857031264, -0.3345999060763885, -1.119753019221433, -1.4268751788464102, 0.6662897618100292, -0.9306824741929111, 0.02475225403269078, 0.2112952535864986, -1.3830037138402864, -0.5583271320818326, 0.5808758368211303, 0.9594623834693831, -0.09287713225823549, -0.8743738614608996, -0.06790884340921653, 0.3144625565245941, 0.7562552779062542, 1.0716777057916345, 0.5230249006438665, -0.06830995986720675, 0.3206298515130047, 0.9189763211316166, -0.9520347628214602, 3.678029069209215, -0.90118491926165, 2.1364842186939583, -0.6822249666121394, 0.8901698223022634, 0.7016927488489182, -0.21167733618573267, -1.1335402815016073, 0.5116341167491353, -0.09871012244435519, 2.7651647745402967, 2.3636394961629246, -0.43238000140480903, -0.530072838025313, -1.2013926136140933, -0.43672745833661725, 0.1415358191042664, -1.3018224686386943, 1.634753229302577, -1.6113247982941856, 0.4529319558101225, -0.6999146695848628, 2.2802584431155157, 1.4091394322898831, 1.1406241100252408, -0.9351119566979704, -0.21012087853274364, 0.16380897271932293, -0.12506094296546463, -0.360022440755278, -0.06043367660777201, 1.3109630354137705, -0.7049088143183824, -0.8715117589983666, -2.370752645099106},
    {-1.0314551497228903, -2.4378053156465396, -2.5282068561027264, 0.6693698760926259, -0.13206549898052158, -2.7803473883531447, -1.149950392724633, 1.2660833889903076, -1.1271829401353548, -0.2772517909002548, -2.2329856744428764, -0.0670021710640737, 0.9087234580715933, -0.4226366788378339, 0.2668842664285854, 1.8213289698472679, -0.6538750126496317, -0.3638775036718009, -1.3775252827917617, 0.17091895299146903, 0.2909815884901356, -0.07035187379103974, 1.3422415120965105, 0.3332963906016324, -1.441480648430794, 0.4557634560750212, 0.4922102894480772, -0.7335980573799397, -1.3987985288842153, 0.9619515758988296, -2.0606410941408386, 0.6991076225662323, -1.2785736606895095, 0.2219813467864318, -1.2851117120587576, -0.6999559964827046, 0.20698214015050073, 0.33547141386995166, -1.0260176304197268, 0.8578914101848771, -0.38845099979299197, -1.5083146455586596, 0.26192390115888264, 0.7218053035016205, -2.045093484607898, -0.4498037921435174, 1.0337429474173765, -2.346974686394396, -0.6819152532719629, -1.6814500423237786, 0.8481839475244548, -0.6428033372395521, -0.2970087134899967, -2.0230769203737977, 1.1344211236565973, 0.6314655406363222, 0.09919513669363585, 0.05620058926321929, -0.8113574587417741, -0.2413051313814427, -0.9487581033579379, 0.10217048317777312, 0.5386187778873858, 2.1230430604620656},
    {-0.5496248438208912, 0.09225664599674861, -0.038281319501883515, -2.990732484902708, -0.5852400865035573, -2.324343543230842, -0.2815378755771128, 0.2862299090096912, -0.5571695645031948, 0.05872899539438318, 0.28089809130328075, 0.0017069045026449656, -0.9246210395102376, 1.9774396967658203, 0.3202993342363339, 0.0555556524692015, 1.3854698563484344, -0.665702880058512, -0.9089287103154431, -1.7599407317141094, 0.21371651016955295, -1.8409487792372148, 0.03351225503319354, 0.6113790270610372, -0.496996186115456, -1.7636025454460313, -1.0729535233824152, -0.8885513357211988, -1.6695873826209116, 0.5881509756402087, -0.7467624057107705, 0.9277855506361008, 0.2491832331849281, -0.5886288461109337, 0.5129387299117517, -0.6223737192013082, -1.0342475070533135, 1.7737285348674399, -0.7401828848486328, 0.38298976526147055, 0.5003853189954615, 0.7892343214701798, 0.9056978417489809, -0.48715122935751676, -1.322350727144723, -2.023573686612346, -0.8149548447906475, -0.9503347160507079, -3.154820439946547, -2.307300798762189, -0.061785986553551546, -0.06476447721692925, -0.4801538919729182, 1.2051994967298694, -0.772088010734022, -1.3100247259365196, -0.6233255934167271, -1.4534217517389225, -0.8908211506923855, 0.01506574188953367, -0.7728254508186914, -1.438048698995359, 0.15370798205629857, 0.3540768458469192},
    {0.8384092956918497, -3.036695793261096, -1.0510901368287884, -2.5142698966447594, 0.1602594273633807, 0.38988757427935894, 0.42458016785950986, 0.16563925805032184, -0.33571753222069994, 2.8727381378401384, -0.5177364482879284, 0.13240699708831133, -1.8551682248002483, 0.12916239263475657, -0.17826834789339654, 1.0285999741388614, 0.4665143321012552, -1.2773687980677466, -0.6148476957683244, -0.3903586872489556, -0.13596379633686495, 2.5990751856800642, -0.9265526045585609, -0.17224540685810127, 0.6177808204933749, -1.5157780302577293, 0.1546243705334432, -0.9910042987434718, 0.9621475483811448, -2.4060303868803605, -0.36620615456881805, -1.1521850648804985, -0.2374811474415804, -0.24617907866138236, -0.7283826323830029, 0.3093597805281113, -1.8570608607669505, -0.5456921018066045, -2.494038731491422, -0.783425427427095, 0.9958822804907398, -0.8491102789995902, 0.7875094571475146, -0.05234370363072653, 0.2681601709539227, -0.4982568926731291, -0.3392827480337724, -0.23081057358682583, 0.8197320311111443, -0.7630874505077725, -0.7494366651089743, -1.7717960149592236, 1.0835677817902456, 0.7727781496789706, 0.3931583213924223, 1.1112568116625319, -0.8318359791133378, 0.7479020774950188, -0.20235942995767287, 1.1037830507426785, -0.3449780748082027, -0.1148574685453918, 0.13791995817752153, 0.06463647663355669},
    {-0.31107657017361284, -0.5238913719308167, -0.7410404909573284, 2.0201302152539857, -1.0911865429477634, 1.0095906166891253, 1.0374161637265356, -0.05125769861915699, -1.1969935859956893, -0.12125247189904567, 0.47085645061761877, -2.294843661551598, -0.6094953242007161, -0.2395697834857579, -0.8115370435449674, 2.239133049171022, -1.119537036201453, 0.03912148818873575, -0.5743747204067473, 0.8996453543825875, 2.1853073923346473, -0.22519784736652104, 1.7956553269134186, 0.1208458702606326, -0.057784815012945946, -0.40078549729666096, 0.190145051703549, -1.0265976772421428, 0.8960699793552962, -1.5880929846671044, 0.47180115729195804, -0.13697627915548483, -1.6179986920787308, 0.24556790539979736, 0.03354176437213212, -0.5743412128657431, -0.7022698635018553, -0.7026565300866143, 0.6829130000870907, 0.4322845191853331, 0.8623696721833579, 0.8363187216881812, 0.9449801690662385, -0.744625326951937, -0.4668514788844044, 0.7513763453548213, 1.0316418893080646, -0.4361183731698944, -0.7007115591257713, -1.1259993368473302, -1.8121467908949753, 0.31320369381373075, 0.9639173250768022, -0.22672870520073488, -1.2285907987740017, 0.4207659649634314, -0.23425372502920475, 0.0332861980469252, -0.36902429892525446, -0.3546953606135786, 0.5513939567829881, -1.3906777856004133, 0.7293011259786766, 0.1070315953130403},
    {-1.0023029920513993, 1.3819950044079445, -1.7047570695003302, 0.15049617798457848, 1.118249924354743, -1.132992216356249, -2.5297383677255834, 0.8812730002214381, 0.9075065959591192, 3.1411384547028613, -0.555786908658029, -0.8106489724190619, -1.7701981483570506, -0.3794310942080354, -1.0533890742799448, 0.3262304326447547, -0.4818702188475432, -1.4877613786588586, -0.1560909857379142, 2.504988755147991, 0.6408457413427437, -0.7071003528529337, -2.2394089752614437, 0.5482221802284697, 0.6622368109944168, 1.9795320403081602, -1.8212627456151076, 0.5301342931624735, 0.7275479826097723, -2.43373556696967, -0.15531958757550468, -1.3413676936207668, -0.9319114231163033, -0.2979430704112211, 0.4570964560124304, -1.390937676247001, 1.297177272686837, -0.09329635252022626, 0.6802786045038723, 1.9868613622853075, -0.6948558939039859, -0.007784089004995888, -1.0822197619193303, -0.7798051284123679, -0.08049523292473386, 0.9228312586451078, -0.9336491658949099, 0.35307221306875236, 0.41532481765011164, -0.33100366073922577, -1.2138896381039272, 1.3672241078287095, -0.17903313194473658, -1.0013918735054486, 0.6984060385993747, -0.8141420600070961, -0.6748900866645824, 0.07468248930856966, 0.9828885117902628, 0.19692332132831228, -0.4723557770506103, -1.465889006865601, -0.6893323796227041, -1.1512249318413499},
    {-1.4579151369413317, -0.420374709707962, -0.6213744742383339, 0.3816975549116129, -1.3063481484029735, 0.8260563995334931, -0.2664454472651128, 0.7210181820323045, 0.0004010977456671125, 0.4181592998352378, 1.0041423934284515, 0.24335304301785118, 0.7005037450276028, 0.09840884157634718, -1.291423806304923, 1.4106006529969266, -1.5214282163207147, -1.6355445359829672, 1.1055944030545182, -0.9180116769386157, 1.0131762214338695, 0.3021995428984005, -0.7885419683236188, 1.1746999852185949, -0.5473506984835278, 0.49559138031115263, -1.1095118186289679, -0.5619639053415523, 0.7997103205783442, -0.2394799339851263, -0.9244264654944511, 1.1993588116245664, 2.201791368853521, -0.5146506370622448, 0.5431660629269477, -1.6012406271445458, 0.7626459617777532, 0.6889016614318536, -0.5110692115357888, -0.7134835624373308, 1.0853618941879313, 0.5652705985289882, 0.353449501380038, -2.6442730184466363, -1.1393911587401944, 1.0581336315413348, 1.8076994730558777, 1.4622276099063791, -0.43564410929731257, 0.8714089249087936, 0.8308135923044956, 0.1018192648084904, 1.2918467865974597, -0.3238981201445514, 1.1396602547634607, 1.609657547872321, -1.1775854337497447, 2.7389524393168636, 0.7540537418962925, -0.18573602616938442, 1.4012455444403198, 0.4046724689014719, 0.8448291515737623, 0.8206560096069395},
    {0.4676988240634947, 3.6055091475684278, 1.8468242950114326, -2.4180329987777975, -0.3528486077825997, 0.8506397781619456, -1.796223488195192, -1.7036606781194523, 0.799874538785337, -0.06316057653384317, -1.4515543963647277, -0.10289831794680587, -0.44335471527163806, -1.9620142574654857, 0.24798515269185947, 1.4009055158373276, -1.0120153887260757, -1.2154362608186433, 2.4636811793324656, 0.7826525638090155, -0.12369866171625714, 2.1617066142241192, 0.5280107212041406, -0.8501522898424992, -1.7205382676836245, -0.6262781566710743, 0.3161213764752372, -1.0336847153080093, 0.4059615873911652, -0.6721438619087403, 0.7585348996173057, -0.2757719848537407, -2.372778427579005, -2.943319627846582, -0.6695862397631316, -0.08292054779342492, -0.12777454495887075, -3.2843715767168478, -0.8154767596236798, -0.949677050286756, 0.2247044721454148, 0.42757833666191225, -1.108115123405542, 1.31382679205006, -1.3960545235048518, -0.29963276999254873, -0.10922545326529721, -0.7179096655964653, 1.0604237974979407, -1.145204206382571, 2.713650925222125, -3.243940757313961, -0.04105246820608901, 0.3110366414432399, 1.4790329785688905, -0.5661480013960813, 0.018977275017822568, -0.3696752180848321, -1.1831007914711549, -0.14353488910946569, 0.019889596061553834, -0.5155257221021623, -1.0429036690795939, -1.0022742510731906},
    {-0.5545959024448635, 0.5128659138444528, 0.8543104647828006, -1.26152975402461, -0.7251304516672847, 0.5997001993351248, -0.6610906584820228, 1.4829812897960808, -0.9908916500180144, 0.41260371749223435, -0.6452813473020587, -0.30415382547672204, -0.00699433397558531, 0.495464851727255, 0.8335984956877533, -0.01653417000604335, 0.4999123562700934, 0.5899791654247127, -1.4411107346042986, 0.22455805009924734, -0.20405274988814096, -0.13695439642277632, 0.03170378067971374, 1.8199610206991161, 0.6596247712398156, -0.11666006158257636, -0.6960129109978787, 2.16648605348978, 0.8142046898577804, -1.792240251341396, -0.11028185805360333, 0.6451588470936236, -1.0692261735671404, -1.8131418711009317, -1.080000537558933, 1.9964619204541358, 0.06237687765432195, -1.9965112239374085, -0.40052724795370953, 1.6465749468378825, 0.8155016339875087, 0.9873815390992646, 0.32495904601693393, -0.7670729257793109, -0.5722281179196909, 3.738278507454345, 0.7420775682119183, -0.14669518832814402, -0.8107806641881646, 0.16672239612659637, -1.1885890835207296, -0.44662125408394054, -0.565910586083957, 0.9582755120205969, -1.1003953548078187, -2.6127405160113764, 0.35307395538604314, 0.6274982665003243, 1.1551442311122406, 0.5727467713008089, -0.5045822748049398, 1.495715942105472, 0.29177390006324516, 0.3437715812212063},
    {-0.9835701332840973, -1.9560749886312285, -1.341061986162205, 2.8978346616958235, -0.6202022088192809, -0.22140001410221152, -0.7508729832840735, -1.1880287968556977, -2.4491720490958624, -0.24428608745151859, -0.4155991589287504, -0.40857655570714185, -0.5268910371403099, -1.9208267200634919, -0.9125370403507994, 0.9047408845872674, -0.3845659124185808, -0.19273597396567926, -1.1246496178925283, -0.2018995011561683, 1.7333874296142007, -0.6954979128320516, 1.306528819901215, 0.7402515902496903, -0.31906607805515214, -0.0973308955576029, -0.8905112161488427, -2.099511234144566, -0.9676678502484619, -0.8142026858621348, -0.766483694057879, 1.3484272822638332, 1.4893790656215413, -0.47217196752679697, -0.15274591555956732, -1.2808801576887272, 0.06135163647544496, -1.379495740181985, 0.4905998815227279, -0.9073585234104911, -0.5323232875943373, -0.35567890400281593, -0.9861796618261226, 2.8520282011644893, -1.586020877370826, -0.942888210808341, -0.2141576293890283, -1.000844247060258, -0.737246870663968, -0.49561975328003655, 1.4736711255979587, 0.15250364169740302, 0.8480980993322866, -1.5122634246215192, -0.7769666616151337, 0.7051863144666453, -0.9913145225658994, 0.7005416389533697, -0.5100469561166211, 0.23884443247169315, -0.8124510535712371, 0.69714350173044, -0.7441814323131015, 1.0678433585283906},
    {-2.230344469412175, 2.2596292630012886, 0.042293026211000916, -0.4530684108867505, -0.3903191166882081, -0.6180547070679326, -1.1506281392947546, -1.0165388456096274, 1.0035079251381986, -0.6481336607033087, 0.23419677436153186, 1.867501539714896, -0.9314812002057985, 2.6102008562622285, -0.9814493585845933, -0.8143867800118075, -1.1208236906284426, -0.7523981030397221, -0.7130606115968022, -0.4015945046762497, -1.8166084613598374, 1.3963269411560912, 1.0334938204871285, -1.045302679885368, -1.103614518457103, -1.8514163316648153, -0.8814964634139973, 0.016627527780643993, -2.6857507588285707, 0.16353706746689453, -0.8373348329877703, 1.674867304731413, 0.04802113675164484, -0.9738475640774836, 0.004616758925420433, -1.5225981253776888, -0.2585067261654294, -0.16418674853618848, -0.47799293914656676, 0.829542471723038, 0.3630006923258153, -1.8177570827461467, -0.7454132551623286, 0.2979322640183133, -0.04203447848935614, 0.30958995021331553, 1.2289837985597765, -0.38557915553248184, -0.8943183269211581, -0.24945286261876415, -0.10923151741960248, 1.1960614820136048, 0.14163453231021428, -1.203538893826708, -0.9510711019603679, 0.307890031603039, 0.6223605366870373, 0.24725851921846204, -2.805862726615576, -0.4304279812203884, 0.2987523706922723, -0.38903860209077157, -0.1304860336138862, 0.36846509327030996},
    {-0.25281810552148154, 0.4532416811166946, -0.47159705785426437, -1.4115321479824865, -0.4566674201640125, 0.8236690786197616, 0.3336237737969899, -0.17785858519598585, -1.3665583034149613, 0.27535682093669067, 0.44147917888092486, 0.867889461070472, 1.6904095584339456, -0.052177279443978195, -0.621380901212706, -2.4253372580490224, -1.4200459838984636, -1.2572425150729345, 1.8842842597538136, -1.2702465220709436, 0.9387249541941064, -0.15555473254824556, -0.6410339120004956, 0.3233434750811027, -0.3827559062389891, 0.3801866537521053, 0.4976646798050384, 0.5422828492264966, -3.5738724817589125, -2.294430407903288, -0.8522240837042214, -0.10559363408088032, -1.0465300186627677, -1.6342970073565395, 0.2328029542894539, 0.17236282765387828, -2.6409051665272694, -0.41070141858484843, -0.04380562591935469, 0.2285112044173549, -2.1964790465855186, -1.0263862895303253, -2.255598627864902, 0.22402391240677316, -0.17507934447341578, 0.4379807016259491, -0.5191491898851157, 0.5204471508418245, -0.4900804373671079, 1.374067334562816, -1.034656752285338, 0.006898567497439072, 1.0049857237689028, -1.4560552592143743, -1.6536276154458827, 0.8679386184048749, 0.7002282549803692, -0.09700829624797773, 2.2132673846901554, 1.2000639820694534, -2.4441110907949324, -2.3176498494311604, 1.2054705994271506, 0.8851381893517082},
    {0.5208049471359738, 1.3021817143131964, -0.7034936308780182, 0.012003515757422336, -0.657498418316177, 3.3945118719996588, -3.397755986005197, -0.4194120426194998, 0.6001899840179988, 1.5011283903748085, 0.6525531318673081, -0.18187510524739361, 0.17021461455436682, -0.6112506905784441, -0.6838263853446004, -0.26502921317880107, -0.4534887250755183, 0.5023428528516738, 0.2303655666512565, 0.03736948181391461, -0.29127535170482854, -0.13249249587005485, -0.027508618609077454, -0.6469968454759522, 1.8113770157711373, -0.66344371951188, -0.08039849578863596, 0.9128668586313876, 1.6270992376720412, -1.1487357376198715, 1.6830358054317207, 0.6896333515135276, -1.3979732048070481, 0.6330050234599742, -1.5748338739556729, 2.5570492505237836, -0.01893023815161307, -1.4036589894869107, 0.1557477865438792, -1.568951962270848, 0.9485563019225004, 2.6701724612038866, -0.18142838202320616, 0.7526548662503143, -0.06085478273947464, 0.5377963182939488, -0.9050533283199842, 1.019779656060929, 0.006698234840816969, 0.5476810839463512, -0.699892993795615, 1.2266437341576373, -0.6346754502101454, -1.2789148126430623, -0.3202758339298468, -0.041605769212810575, 2.1035293431718625, -1.5721661788009171, 0.49389574114774165, 0.8615690590697154, 1.8970908645411844, 1.260957583524904, -1.018626121988421, -0.3469847934408187},
    {1.633799202909751, 0.587370414000275, 1.3954574251917495, 0.7847912755694807, -0.8572731994944848, 1.5107978802672677, 0.38166156464668793, -0.697200606265416, 1.27206467617798, 0.46373486711421885, -0.0667160622641089, 0.8742005358193857, 0.6392408192228478, -0.2095541853759062, -2.9697527135966726, 1.3027920007962817, -0.8015829951057499, -0.3158644422311925, 1.4219562736961142, -1.482590567317671, -1.2703168594819252, 0.8541227402524453, -1.2985871949478796, -0.11542892316665586, 0.588290245398065, -1.1255524008256885, -0.1517332388533926, 1.0311513205206742, -0.9738282898659982, -0.4832778821787531, 1.4547850867733347, 0.10422317814686582, -0.7117385129502586, -1.1070716179027644, -1.4349534862624165, -0.4112251531620702, -0.5489781273978469, 0.3422119068650494, -1.5905737893840433, 1.1242850752133742, -0.6406142388134162, -0.26011077753480094, -1.3117154235827597, -0.9420399580571548, 1.6894641902714425, -0.7651832633693887, -1.3649461406157117, -0.17733880263211804, 0.19410141090824448, -1.998117195592239, -0.19156310045812983, -0.4109902053043894, 0.2678356148596768, 0.9587424616867258, 0.756547698189797, -0.13550383542192926, -1.2573786653120638, 0.7774977999176328, 0.6567014127125005, 0.17755990508132705, -0.2923745077929151, 1.4369708303273756, -0.3557743835914045, -0.037789515041224686},
    {-2.4059639169962925, 1.5319897405560012, 1.896936830351114, 0.9845963081684066, -1.72052198960731, 0.23200426053947545, 0.2974337404377581, -0.9236198760259527, -1.308135505005958, -1.5456716310724499, -0.17629241800044332, 0.03748150742005309, 1.3681638521199746, -0.45415392362254053, -1.0195256860294637, -2.2327672872331403, -0.8434537880769103, -0.4383733912640654, -0.472619286781932, -0.6997521428279637, -0.7094312659031266, -0.542366639174091, 1.2868931565058057, 0.863297542163197, -0.32535280584038784, 0.057607525081792996, 1.3688166315467336, 0.8424701975625305, -0.5677647960413431, -1.4642177020006495, -0.20123563624427854, 0.47479851998084116, 0.14202885165614781, 1.7839678991013117, -0.887240809142062, -0.9287296520602228, -0.27398240180270633, 0.22862586355594508, -1.5069877657800845, 0.136072124976124, -0.08653790234676952, -1.8127145130672122, 0.4490083080517687, 0.3548844168944837, -2.816052346766346, -0.00792685151885971, 0.4887496304012099, -1.0631522957916968, 0.27459410255002437, -0.2369063483438932, 0.12656803749766302, -0.6129880402206119, 0.9487116669464478, 1.167878405777296, 0.4310439416454645, 1.6705410606402884, -0.3199435213518058, -0.5577068577536239, 2.190609992048716, -1.5798285237289105, -1.014162974437398, -0.9256135278397618, -0.35953219295235456, 0.35353397725520136},
    {-2.5391172679786385, -1.605559322232971, -1.9018216826563974, -2.824684252492715, 0.01603615922221054, -1.7750927757369452, -0.16549389309435444, 0.4183704448063223, 1.645759136469815, -1.6485797539331195, -1.184391569024462, -0.8453776360846608, 2.07376941262438, -0.7117696688284004, 0.23703357650260698, -1.8887189945321528, -0.06352277907394524, 0.37422363609963594, -0.30706621058194916, -2.390302970060969, -0.6466863378297145, -1.2000658458804894, 0.1185571329173345, 1.050188420778466, 0.954405574894933, -2.2981117796829396, 0.18514175421143306, -0.38513475345504694, 1.5804113623600695, -1.6297278276276406, -1.3173516903974651, 2.0442634065532967, -1.3319772815769717, -0.952042900875636, 0.055898462196277095, -0.6995112522843658, 1.4764116276808052, -0.8279060323957292, 1.4671075497197263, 1.8713343897986305, 0.3781964759627319, -0.8339773860371301, 0.7127253579576779, 1.5561394355157463, -0.39076371180801117, 1.7558854858383888, -0.9454491615076841, 0.9110521199135514, -1.8923412112596874, 0.30439325535340794, -0.34289240183112113, 0.5026068332722928, -0.49841054291059284, -1.1098057009954694, -0.26057530138665025, -1.1258503673951556, -0.9585916578092745, -2.0468064868155573, -1.6568175480844907, -0.8897824032089398, -0.875493428626588, -0.4083620184687512, -0.47993561791954936, -0.2287346148377519},
    {0.80327546635005, 1.4249322511050866, 0.6882695036714698, -0.931546402302141, -0.3385119315647178, -0.6000218511770439, -0.6887551970897294, -0.6216860924600234, 0.7111628148819653, -2.01718738711774, 0.19399819391794315, -0.8937212516472444, -0.2523384244185709, -0.29227417120006305, -0.02371986921594667, 0.23958792447280822, -0.1799145040323702, 0.07246327972779332, -1.9716139578815466, 0.75251320049312, -0.7704252477423206, -0.14028087784777013, 0.2259974745636183, -2.697443659340222, 0.0020968148785603523, 0.7219773492483658, 2.666032051558968, -1.0919065511049009, -2.153336562326626, -1.3677471010176123, -0.3369864206195924, -0.9398924547751127, -1.1926815845178367, 2.7302170610069605, 1.2747311867952884, -0.7441150403988034, 0.48794146417307427, -0.13578099635110652, 0.6654732700710246, 2.0245592522846567, 2.0915987977335058, 0.9282674252668286, -0.9389204401431209, -1.5305783896448475, 1.1527928995015528, 0.0630908499588854, -0.7217415427838729, -1.65853562986745, -0.4486889677942519, -1.5673927869590087, -0.7209932573635309, 0.8672386690264958, -0.07197468609654381, -0.28308953092094796, 0.5307448996358959, 2.0750525342151764, 1.5727127409809118, 0.6544113740920028, 1.4129767317733326, 0.43950799102251115, 0.8335452523885176, 0.8796239887446047, -3.7853834226866496, 0.37653058005598605},
    {-1.1214376144277625, -0.9130339195584263, -0.4687953750021108, -0.03699128127649174, 0.9665830424245835, -1.0107649112397088, 0.004773073542239164, 0.9104187077582718, -0.3160027806090343, 0.32155159155427937, -0.03726441440784608, 0.12114896045628157, 0.7263282385410288, 1.057729482665294, 1.5380111292846432, -1.0601089645043975, -1.3183134682432516, 0.6389201911439208, 0.13731006109291283, 0.8782156763329667, -0.41668118180112906, -0.4069432223034608, 0.11486641926289216, 0.5651519861559807, 0.9646494581541505, 2.817028254440454, -1.4026055959701158, -0.1787779162395232, 1.1685955481258323, 0.04169775359699629, 0.4452347238163797, 0.3756761492912637, -1.1412031741006132, 0.04220045587856215, 1.7016748245484734, -0.1954547652747381, -0.21652543462452437, 0.6939831568044056, -0.49005501715621663, -0.3635677784749303, 1.1713730095244645, 0.185420444969046, -0.8106357738927591, -0.2985130125250971, -0.2923130567026212, 1.5570415534392412, 1.6542538551419532, 0.6689651002016778, 0.17598373212571167, -0.21359544978120576, -0.5761852581217559, 1.1645349816928026, -0.8716353277940512, 1.2033255605014024, 0.5554030692221635, -0.04108898768283356, -0.10511044865864025, -0.929205144244328, -0.0010717477021856667, 2.171207441027204, -0.6748478980499336, 0.37674440670364556, 1.2314956623921784, 1.25676487894225},
    {1.5578867662916143, 0.5369117752903946, 0.22434608290515748, 0.6990060391112688, -0.3241183740900198, -0.5651862485544031, -0.7436548377505928, -0.8950698082900981, 0.20049622506017328, 0.00029087500095931575, -0.22688291701649652, 0.45489031296563803, 1.469612074500038, 0.15125059120707113, 1.250527148814955, 0.9215281879805223, 0.802405408893266, -0.16234630300287597, 0.3461171297339194, -0.8735681283207242, -1.9610510239037693, 0.636611879390365, -0.1815095612886942, 0.8310651284104215, 0.09810334996864759, -0.07338361594570135, -0.11549204390690883, -0.6766667073673063, -0.754127449422892, -0.11471861842023007, 0.08523878156435688, -0.3249528482098168, -1.4705306699591187, -0.9530400595242922, -0.5606942490803419, -1.0998770900655304, -0.42508848289518175, 0.054642062426307106, -1.2977555951693527, 1.6040500387599852, 1.0626556203561697, -0.6334843565734026, -0.43101134669064545, -0.9317518681046503, 0.4724059067501831, 0.6800940068017703, -1.0459173852467614, -0.5391792734795613, -0.0374702550684319, -0.6555635897947121, -0.970502628926413, -1.5309735990670612, 1.5157876560567953, -0.29149234993503087, 0.3233967692166502, -1.7723698890059132, 1.5515799213059356, 0.7806252049913414, -0.9742502376999364, 0.22537358304399882, 0.3152627685065695, 0.19748025508624092, -2.1667496566849285, 0.7293711987793027},
    {-0.7713847041187172, 0.5960876267121393, 1.456181779308512, 1.4398572344533986, -1.461843194446126, 0.9928288267054293, 1.2363100365180661, -0.17400792274684096, -1.1125120923518124, 0.1711595077645886, 1.2070136341630289, 0.27547785203538616, 0.43831596025206315, -1.5492182783185624, 0.7981460151556394, 0.9328635636769558, -1.4613226416907348, -0.9075774329224396, -0.16936422697272274, 1.2564096350917113, 1.5516476420960637, 1.1228705307697533, -0.15467226424134414, -0.2542456515274126, 0.27093764803309045, 1.258569148704159, -0.4336610667154401, 1.4858140567327467, -2.232560563297941, 1.4907402703490786, 1.0700099682426882, -0.012865667545143062, -0.9572254764379026, 0.9018950224344106, -0.3699052505467924, 1.2097850596634008, -0.37979996118332604, -0.5480444593979704, 0.05291096535091301, 0.619201971816791, -0.9918168888624074, -0.6965470540154594, -0.8313969413341552, 0.657039638293406, -0.4477467949789598, 0.37201310763772294, -1.289618217975826, 2.064460721524965, -1.1918575537534084, -0.7562259537972946, -0.09902177920300527, 0.7259579269525169, -1.3052893495326143, -1.1206403520495671, 0.17897118095896553, 0.7885310247582237, 0.2555831716615844, -2.887270872592702, -0.5784795429990954, 0.3930055711708477, -1.6203408794457912, -0.1647588084286084, 2.419516028787638, 0.2238323216480766},
    {0.0848277278122991, -0.27413790070605304, 1.083867585737123, -1.2586031445882233, 0.7445576479551729, -1.0118512785185851, 0.6146044836452902, -0.8895753389134041, -0.87617971073765, 0.20634714733829163, 0.9131550666550428, 1.0402157250310662, 0.3874976692791425, 0.23615195477409628, 0.8364439577780255, 0.2717703686913406, 1.1467978453516745, -1.3801740380790861, 0.3666724501167523, 1.7307421943897223, 1.5473311918498636, -1.0411342533744332, 1.721387629257916, -0.5847388924029978, 2.0264266895144036, -1.2397666478351066, 0.9289500510048149, -0.7373738127405756, 0.1450060311762605, -1.78216435371322, 0.17312639483838516, -0.5794442925717737, 1.5346324886334324, -0.12870012899398423, -0.5148182610217272, -2.7152006496118175, 0.5519091062873254, 1.7400952689868547, -0.7104096028211312, -1.2488626762867527, -0.6816004520435304, 1.5511687857425356, -1.302754779585248, -1.123992905120969, 0.7039065292645652, -0.7509930228867444, 0.14946618168382517, 0.27574883101135633, 1.11380337786243, -1.9193892778235644, 0.3139415814559589, -1.0709932447229642, -1.1592640031739254, 0.0486603920015208, 0.3833075508315687, 0.2918204112796385, 0.624788585413503, 0.8760194543205991, 1.607135209123244, -0.325437346150831, -2.9004586694275956, -0.42408675951000974, 0.1491144623355371, -0.695919222638748},
    {0.4109183615231564, -1.475983728278073, 0.4646889858649313, 0.26221258916316476, -0.8246229901293954, 0.08449763117793226, -1.5271459978762028, -1.033531489553997, -1.1072456486381177, 0.10178338911187677, 1.0363235156371917, -0.629164254467051, -1.5849952398821874, 0.11091109447734955, 1.5390463577104778, -1.6484044615491793, -0.6760106790994542, -0.9833714989924413, 0.8516900615818287, 1.1478611291758012, 0.695812368218998, 1.3247199001811485, 0.18097157398696176, 0.6022901172592294, -0.47941063321281135, -0.0766227028719613, 0.4120157650896241, -0.9770069620889066, 0.9542157417396595, -1.5354869585028936, 0.7175849903724812, -1.161030989284499, -1.7460312019854543, -0.1308951890398038, 0.1535941346020563, -0.018836556804278478, -2.3228982319953753, 0.2516621247653037, -0.24046998566889854, 0.2875732973785979, -0.7541837546181483, 0.4789221922681101, 0.6577155190976052, -0.9986760999681557, -0.23898199238598514, -0.808412137485275, -2.9419278275881258, 0.2842804043700427, -1.9596521255109012, -0.14965819502311267, -0.06671066141647734, -1.5069669337159866, 0.868737803145277, -1.1481658993592805, -0.024421270127398132, -3.1924640742596306, -0.23372790120010145, -0.33775659076852127, 0.4956047684376066, 0.1262620591702947, -0.7207928217526881, 0.18514029432532816, 0.7736562971628832, 1.2778817683574122},
    {1.9929873693986735, 0.30756712375857376, -0.9943722116236106, -0.008481357050734621, 0.6405183532104227, 1.2645177264517813, 0.9211836564090393, 0.8079336701631307, 0.5643693396405883, -0.9754433959822446, 0.12767604631049853, 0.6775175278031296, -0.9607251938539435, -0.15583475514848505, -0.25627918976131575, -1.1696296110074085, -2.4253039246389148, 0.13795382754765656, -1.147897194420415, 0.9637346137577806, -0.19724298267083293, 0.2572569513392493, -2.026148405080107, 0.46110608078763365, -1.00379488216359, -0.25238391123723186, 1.6600779995960238, 0.5972282394228929, 0.020341657189093573, -0.22904511200950842, 1.5269980493137467, 0.11510361843029861, 0.28858062681737695, -0.05328442007325574, 1.9955686582260854, -0.1431555328684626, 0.4627400956236533, 0.26250684277163056, 1.1025610169321811, -1.1422724114012681, 0.11980723970177758, -0.48068938849773973, 0.8523185930006439, -1.2800427914910377, -1.2368421191288272, -1.9478518518644818, 0.979965389738648, -1.3734149977762184, -0.0943340496199164, -0.4614264495543403, 0.5511670107850533, 0.8625150793801035, -0.07407475988680011, -0.11122213439068189, -0.41887865898275034, -0.5108424031329827, 2.0165968941664967, -0.2601538993769069, 0.5844028659905359, 0.5759081714520791, -0.5316854997083816, -0.1553374686235951, -1.6084349104216362, -1.4681962259523946},
    {0.14961654475993244, -0.8363260401728924, 0.17528883087955982, 1.2124929343084454, 1.5132904035999621, -0.4792351163445469, 0.5031879897128312, -0.051920693508796814, 0.681058666936805, -0.5286734434448237, 0.22390956607035717, 0.9106932299708174, 1.5633937237146975, -0.8017659122835692, -0.8010165721439697, 0.34336874104156895, -3.0680539219728513, 0.6148634945590383, -0.2594846349603806, -0.13973739610132488, -0.1418958050851008, 0.7436062563797406, 0.06715021197261593, -2.3589397421072427, -1.523421131864788, 0.7703867885532781, -0.15694393137324578, -0.8583440527006966, 0.6411639475989392, -1.599045735650542, 3.3070544308032863, -0.00713487777732967, 0.816711123971658, -1.2067045509593275, 1.0099400292138212, -2.358797435127627, 0.19003395015123467, 1.3228053483615603, 0.034977851041750635, 0.6658678153598886, 0.19984917731589608, -0.2886378753197921, -1.678066405852687, -0.28627807763389324, 0.5641328066017147, 1.2444422260034746, -0.6225118412239786, 1.6950004496180744, 1.1819642901428047, 0.3500836171460523, 0.06743740006410653, -1.3128409473462181, 0.20323587702409124, 0.061149245388410586, -0.3826149407306906, 0.23472904514972218, -2.0763409611320407, -0.5956364194286309, 1.7043319218936532, 0.8273364034226044, 0.709040512875226, -0.7626755027582849, -2.213630820676099, -0.05348241140489343},
    {0.24296516583931316, 0.2971031605804014, 0.41122876667322866, -0.003255877358439583, -0.2346816233369949, -1.3943986937212336, 0.49361347351785617, -0.6807061407975136, -1.8939403697599315, 0.2125022239290696, 2.323044885618214, -0.019202258986433553, 0.9096793587473638, -2.051084140866332, 0.9297215826477183, -0.14423085756532408, 0.8286944029977306, -1.4764184927955653, 0.6063026169181962, -2.8338692638664225, -0.7179028639256768, -1.3092067192563022, -1.0446550139246666, 1.784523675442855, -0.38343688136389065, -1.2778750841488393, -0.59583931773337, 0.4461975454558024, 0.9835031431530494, 1.7406899617785154, -0.6938655832914088, 0.1660529806407653, -0.06865625206541481, 0.1780395623438812, -0.6657654262683756, -1.2343813559957024, -2.0605374626719763, 1.069922638541315, 0.11336775919265268, -1.413552307154389, -0.07177705347100315, -0.08365869873535477, 0.8594513960689198, 2.7099849144066184, 0.9272235423638866, 1.0978658332946192, 0.12987837568302088, -0.38031642534161947, 1.1751717176588936, 0.33739936725801695, 0.8789873886316464, -2.3718188049620426, -1.2923154209336942, -0.9707258518822162, 0.4703012788355046, -0.43025896402704505, 0.23602659672204193, -0.7834068417122924, -0.15570888104347855, 0.35984087217776256, 1.496678757054886, 1.27438132274688, 1.6559560276019543, 1.647392004068923},
    {0.3031195280912768, 1.8837189847336766, -0.07697757295625578, 1.031718996261032, -0.9857666322492168, -1.9681160316893043, -1.236631586321595, -1.4785376669249002, -0.1962049473779734, 0.4130924427241929, -0.7561114171634674, -1.330211956757483, -1.783491638023937, 0.009491368537804159, 0.18681340581457234, -0.5382473288244096, 1.6459740016283138, -0.9378279034114128, 0.8929310366099935, 0.2004360424395161, 0.09963215766452907, 2.077263509304274, 0.9713830500824172, -1.2463433617745887, -0.3325711638005055, 1.363469979005657, -1.9517387620786562, 0.14633669995563134, 1.068337538852618, 0.9034141168385227, 0.7162652321420053, -0.8281968421137557, 2.1034606531382796, 0.24796332810322133, -0.8183618220370954, -0.3759998871678348, -0.9023960159428958, -0.13654949029597852, -0.5645963224503555, -0.002649094834176859, 2.305477011751434, 1.279138358916583, 1.4721638812251197, 0.44779980388016255, -0.6539991556838087, -0.05295842448150739, -0.010467804133922091, 1.216519362761111, 0.3082031428300401, -0.14181940633069226, -0.057796640111346574, -0.4914729997149556, 2.022672941961205, -1.1356052491351503, 1.3089528207518515, -0.5488782637087388, 0.8343648168075803, -1.4911301816982052, -1.0708248690646422, 1.2110278698253678, 1.9051783330570378, 0.07026521488794593, 0.08580664601207481, 1.9231543921914336},
    {0.0416966202080058, 0.7683729841504955, -0.8182115327668487, -0.16085169722984172, -0.5303689793739161, -0.0059697691011248635, 1.6333432141209554, -1.3306730401631657, -1.0556900810053433, -1.5319159342822046, 0.06887142057345655, -0.22855324675736124, -0.8021574351784472, -1.4100547589628332, -0.5625719433108556, -2.471580845518058, 0.8666397732950897, 0.9662696966779571, -0.7125269995816138, -1.6401180832616729, -1.8284822577429602, -0.9532867309037326, 1.1568122983280922, -3.2355040519126907, -1.5248445914599067, -0.35191205108459656, 1.4399425528000493, 0.20432835387382894, -0.8670449253592271, -1.3549402126848733, 0.5762168229544192, -0.8375495962880048, -2.183598747591512, -0.9758758839738397, 0.4074987247105575, -0.6007316185265967, -0.04518247738645381, 0.2565833994211539, -1.379902687459928, 0.0919286774751867, -1.2487347980126269, 0.5919521666381519, -0.4787521134145222, -1.4507127146337764, -2.8003988566340348, -1.153757961894702, 1.6845211396577093, -0.6931602870126712, -0.4532492513541905, -1.7747646580144267, -0.42723741395463155, -0.8719582965371848, -1.0530772963183308, 0.575678598431638, -2.54921235358066, -1.3786819330403175, 2.547460927649728, -0.9810982989444376, 0.6711078565841281, -0.3642831063355444, 1.6069049265131312, 0.5302369748393094, 0.9590561967999017, 1.7719662700700716},
    {0.6141895826179073, 1.3683067992509885, -0.11719544826043407, -2.5419686400061567, 2.606311113762591, 0.7315660074462458, -0.46816416741068784, 1.056903754286369, 0.9398550988878581, -0.9771130692387769, -0.5456767716810376, 0.46958510996848274, -1.2183695663211118, -1.1981561995289562, 0.3861476640959455, 1.488583000794876, -0.011520836014470452, 0.5883281998697989, 0.22290019852051363, -1.0732368089681585, 0.8547834721420654, -1.4060015554373435, -0.9966644786505852, -0.22365053390195447, -0.4607662097693459, 0.8668760548116732, 0.13598143647331434, 0.01075034904099878, -0.22924891863268126, -1.2396993045737348, -0.12838630036330773, 0.4295674982478449, 0.9520504671457344, 2.321902069111173, 1.6194483301791578, -1.2488142386905385, -1.133661114963607, 1.2179819388655304, -0.9486641499792382, -1.4808759183245102, 2.417351669792423, 0.11593281759086581, -1.2526094673819508, -0.2583450163808177, -2.3579267512316373, -0.040399566249285604, -0.8586448493672921, 2.0534639466750098, 1.0148666923882133, 1.6591557502420116, -0.5446619059402059, 0.36518337167706894, -0.042744708218315476, 1.048309618494671, -0.6432161253853923, 1.1035776240779072, 0.383484364491021, 1.4649341792875104, 0.18886321626935237, 0.6964620814071951, -1.9524437891674664, -0.13251653695275598, -0.7604062852432257, 1.670629841576394},
    {-2.518236958287131, -1.893180488921383, -0.533734939372651, -0.10172403278534242, 0.4151950889889968, 0.7392060908668519, -0.01793766839118766, 0.9478774411509119, -0.5836332524103747, -2.1321423639998, -0.3982303456408329, 0.5788877340295064, -1.4214113917567412, 0.8341803640169709, 0.4837856078990744, 0.043270151513734985, -2.372146813982444, -1.452948461651249, 0.6591338960099283, 1.1955928705438104, 0.3049592173231068, -1.7704136292071266, 0.3456601436871492, -0.43139422337979566, 0.5403320729525145, -1.678965738270633, 0.810677325627096, -0.835404435299253, -1.646306258785376, -0.920731351736462, 1.195337193675425, -0.544529487788774, 1.3031762603511456, 2.3845325659496956, -0.4123417267785475, -1.5058746435442687, 0.21084142137264353, 3.2174311255473267, -0.6004299975950754, 1.5156582251119723, 0.1218452392133739, -1.2810070047424849, -0.07914259830082965, -0.32714478320817203, 1.40619747575532, 0.15994900686342017, 0.038310184167839295, -0.5683673356969267, -2.0501035290660985, 0.9317796684818801, -1.1668240696784073, -1.2093038721760145, -2.1064537032337847, 0.4340775064846755, 1.0761369335354356, -1.2854085671249802, -2.2497566136516096, 0.03278369454486696, -0.2194286460069398, -0.3019960163180034, -0.7505762509257793, -0.17925724132415316, 0.49066912100656757, 0.8188756076201116},
    {-3.3612887484824845, 0.04861072153157493, -0.518619520287672, -0.08779077131865723, -2.560082741151908, -0.28937210788047785, 2.5456753274928627, 0.1945317432600021, 1.2237399575616323, 1.456689165710118, -0.48624557082449743, 1.383478889256599, -1.620595028157217, -0.8131482106305534, 0.7122579363014616, -1.4776104474717109, 3.1915090632342107, -0.9471714258222647, 1.6021155248054038, 0.848281705788702, -1.1549315353329555, 0.9146772625749892, 0.4853869339944299, -2.123385980625485, 0.22680449751911147, -2.0792477880516507, -1.1795429853272061, -0.24121851925553542, -1.7862623911016806, 2.97773442870925, 0.9929755375763999, -0.7700540078878901, 0.4349004106982701, -1.0173878902585796, -1.1320208719458333, -1.64128392406864, 2.6586965027401988, -0.17808089660319407, 0.8593063656489742, -0.4162202531983821, 0.5871997167638466, -0.8548713444887659, 0.12034826058405469, -0.5337544816411474, 0.55312821899238, -0.04200321317141332, -0.49916507154508205, -1.8622175655676962, -0.3651495602830049, -0.47457103043795507, -0.23267970559946524, 0.9944660293088695, 1.6790776188293797, -0.711075126910002, -2.692391289140936, 0.3592052343340296, -1.2432828555631508, -0.749641634172019, 1.5796872250032146, 0.7911843706577388, -1.049926624394482, -0.3832283201133906, 2.5861868304254645, 0.7865647237607502},
    {-1.8154985920867255, 1.330731646501879, 0.7093910529072918, 0.5164525883180949, 0.25484160288010477, 1.0829880851703386, -1.4296874952238536, -0.3378854002854759, 1.0951109782255766, 3.0755963925963656, 1.0438043813001157, 2.474045547968083, -1.33493388394125, -0.969635350559149, 0.6415640540106103, 0.6996962988753942, 0.40707874537182387, 1.695787534358686, 2.5278635698587992, 1.5164207049685505, 1.8044288585199986, -0.16535017490572573, -0.5270384757650628, 1.739013078300453, -0.8640934253817989, 0.6896343162754238, -1.045812224574223, -0.06453595295353956, -1.2243220716979786, -1.1948406994625738, -0.03755856643033957, 1.5149929546519338, -0.8727581427317284, 0.0031577705684994605, 0.8796265158951804, -0.8248574329730125, 1.0163662032740608, 0.16950284490992026, 1.2486780726743372, -1.9728714304059851, 0.8992079126666761, -1.9531548702084993, -0.45651383971705034, -0.5263396226055207, 0.14154646041972122, 0.6474859239275481, 1.9035032545655954, -1.1517687134084162, -0.0968140725717789, -0.8966924832935936, -0.38089882763941235, -0.45513575097238157, 1.3449617083846437, -2.2588838267020344, 0.8795262146539342, -0.505458416099871, -0.19919889560793524, -1.1836122011455095, -1.1930440992894669, 0.2708171636734098, 1.0506916196746845, -0.24093131550161712, 2.027075391113646, -0.3246865467766519},
    {1.8465925998390578, -0.5701689383165258, 0.4100448538917428, -0.25312401432512616, 0.45288343930565916, -1.5862478092562127, 0.7673920442188857, 0.45211019347769305, 0.9422541831070876, -0.6781101850538828, -0.020836165821588593, 1.995806287011359, 2.5875870320030225, -2.391735504291773, -0.09934629511726598, 0.9238997897801848, 1.6247593294844187, -0.33911183856141164, 1.3623260992898687, -0.20334678839031717, -0.8375281359622846, -0.9857338270833573, -1.2994658708978528, 0.7753840834721492, 0.8144432896594713, -0.6761645855745138, 0.6727508062249692, -0.342118086390583, 0.8799474772998173, -0.006832410224285139, 1.2182040609522464, -0.9036259177458412, -0.7332351533429653, 0.8167639365350475, 1.2459345613178638, 0.04100216211798866, -1.190040983858312, -0.3299995559698692, -1.456740339177997, 0.026874048168766925, 1.111355743781378, -0.7692772575026873, -1.6578968821183553, -0.651750345108573, -1.0547050229767716, -1.041473769102438, 0.4403589184757222, -0.14184306100420413, -1.265363099766171, 0.20944608621684752, 2.7761306386233513, -0.7730807678999085, 2.104597551480726, -1.305945637180994, -0.2930387645545295, -1.3454184073945779, -1.4270315322197595, 1.3675228483085542, 0.33881987371493344, 0.5150130074396535, -1.0850573617246606, -1.32309297583303, 0.2535735519880002, -0.28544712407002804},
    {1.0478227881511142, -0.023307525698855722, 0.09669168643178513, -0.5659380198521823, 1.3482721650743277, 0.32552174715942694, -0.7055766119303502, 0.7508242056037595, -0.1403975956396244, -2.9698224780568303, -0.1440244310217885, -1.5948366274215704, -0.6329068733568716, -0.38241065158471, 0.994544797687966, -1.0456732053239062, 0.6910395599107637, -0.06022221242802108, 0.17955800205716416, 0.06435663365407143, 1.9401856398654742, -1.4307654142286597, 2.385139326950204, -0.5694556819540326, 0.8342008579900436, 0.35489414902062955, -0.900248445308748, 1.6887427176533225, 0.44373409704516903, 0.9009569225493731, -0.07851760267713924, -0.6402033106072501, 0.9506887380024045, -2.076817225931207, -0.02574783382776755, 0.5413993075696287, -0.32592701881150754, -1.3115405072801412, -0.46205188006835385, -1.6665093736222993, -0.4825757781680948, -1.7937236326523138, 1.8189094648461959, 0.7529967820883738, -0.09114525742210176, 1.2463703198996923, 1.2617306084925592, -0.6252865157726948, -0.12269023784730185, 2.6146351422852003, -0.43690216713627844, 0.1474343004437182, 0.3275977769496236, 1.6283127428679207, -2.1553293892430396, -2.8075605675597273, 1.576308836827579, 0.13461779164819032, 1.1891710275129421, 0.020100225970239704, 0.07576642752329789, -0.40162109153154535, 0.6401860700045627, 0.9751915710135806},
    {0.9184215420978638, -0.2517201066920387, 0.5990944688241606, 0.5665297373158609, -1.293285264281501, -0.39014006363615633, -0.27580821251064536, -1.2196957617954274, -0.343674125253285, -1.6335518656588266, -0.5736802694542874, -2.5886698219245647, 0.07500187185279596, 0.41645880653908884, 0.8968277260951415, -0.6132117601378096, 0.7379367753523162, -0.9922373525147398, 0.035214966254997385, -2.0626940614885867, -1.4519256984148234, 1.0020410686434293, -2.839733732115634, -1.5221285303762093, -0.26220108133066233, -2.1097490057131743, -0.9203778127539552, -2.3176421556994153, -0.5501038066261444, 0.5230922320351736, 0.3192761005110791, -0.7708542013512631, 0.616245277865891, -0.06926745589774912, -0.6820610010488444, -0.32736666278864374, 0.7273869554574188, -0.8136256841847571, 0.4834431897338313, -0.4367271465753776, 1.7113155210104694, 2.039894048468578, -0.09071961156763872, -0.335742646316768, 0.0893620226486268, -0.13885959151270436, 1.68243388118386, -0.08073095418115483, 0.478409518678912, -1.7468634642883514, -0.13884859264986119, 0.9272427088723227, 0.29346736389825634, 1.5136816339618373, -1.6180090703184649, 0.42599106007393656, 0.55631631932908, -0.5475261947335675, -1.5578204077321665, -0.3686734012205225, 0.17083569754671313, -1.4219681731387939, -1.222709178176627, -0.5202013454000354},
    {-0.5329946896543629, 0.17797811598371688, -1.7989784145458982, 0.2523164878249602, -1.3418514724970299, -1.1904890612944719, -2.277402281879239, 1.3450007523324068, -0.3080573934699014, 0.8786852983158036, -0.17586920837534623, 0.9053916808320734, 0.49850447589699515, -0.015006144479358717, 3.324154152115298, 0.19121927225194768, 0.13178820367177663, 1.5845351700942218, 0.5317824754253735, 1.6593272259340712, 1.1827929636782661, -1.407836457344188, 0.9779210770147565, 1.2417358336196793, 0.3957985980048019, 0.012416112393949762, 1.0683182204844914, -1.5301773125923186, 0.32912402603787405, 1.0225157446508095, -1.331233896472451, -1.2450026963329845, 1.3782954776462941, -1.3933409168283748, 0.9415627735388288, -2.2054079410660075, 0.44788614813216693, -0.14364643352183729, 0.83694665145399, -1.8872932989042228, 0.3823461172137839, 0.7865652094083331, -0.7333644785020436, 0.4507317813235906, 1.6960714115548066, 0.2559305763854999, -1.138258112647113, -0.330645783745382, 0.045807904748903214, 2.3874705347336995, -1.5103918525424218, 1.6125657670641351, 0.34248689643780794, 0.36968665105208637, -2.262827300659652, 0.03348572291515188, 2.594591152823394, 1.325612383999853, -0.2954104583825099, 1.4511599075418409, 0.5591827095576419, 1.2626216671053994, -0.12306301461102648, 0.8310074257095564},
    {0.8512793095760169, -0.44136571105671957, -0.03509713794896633, -0.10269034264896959, -2.7663363774067227, -0.34665698936542894, 0.45091120993110334, -2.77756041319685, 0.2016327404774044, -0.08473384699165001, -0.2258589084531169, -1.612694066976886, 0.8367628054978817, 1.1622085014665713, 0.16706998038115017, -0.314937980854263, 0.0328091801106789, 1.223785684703156, -1.656611008460434, -1.2182915963234628, 0.24363511695184986, 1.2480320991262375, -0.18696624790352084, 0.5808792807410337, 1.0821447074100232, 0.5092276509836345, -0.041670760698361925, 0.01267575263594016, -1.0523780552019442, 0.214616816993902, 1.511918868770239, -1.844332062938558, 1.9940295435049598, 0.3519990264782931, 0.4701574943418302, -1.716000011791041, -0.044850252436155646, -1.0677683572982704, -2.0495471508707106, -0.07151899252654889, -1.1835317071533438, 0.5786847896668524, 0.25662384812455774, -0.31625795223081954, 0.4196293358512633, -0.3394451903690253, -0.2536533022889037, -0.9424218447049167, 0.12504364993928846, 0.6417097017730212, 0.9473436414308024, -1.2351490772335894, 1.8107760776136033, -2.5633616191051223, -1.1160899886299118, 0.8059119522422913, 0.38325076134503844, 0.10048392838208485, -1.4512748031952234, 1.3675136227142037, 2.062099069336554, -1.9581873210052605, -0.8045639816861319, -0.5634092937000219},
    {-0.9224605974792998, -0.8157326246897947, -1.0006463024719239, 1.3484279970705808, 0.027895090180102347, 1.2844886097182366, -1.3060803468851685, 1.0482884417833043, 0.06945934107571101, -1.0312207766410844, 1.0056016600928455, -0.6297226754796171, -0.4429184162549006, -0.38302170019236664, 0.09179054587716894, 0.22734800920215398, 0.5544052837502477, -0.11848018029535695, -1.4515415473021018, -1.184138975484936, 1.0614093129602413, 1.0814650410535827, 0.1680659266177075, 0.5604509774227686, -1.2441020960512765, 1.4441081780975384, 0.8693601340144221, -2.3214660922261903, -1.5320249741379421, -0.19007892915846958, -0.20711326550250833, -1.759257762132434, 0.32396618798604265, -1.4983967363284831, -0.04052041139925341, 0.7564531248686595, -0.7880692653724959, -1.2939421118693952, 1.0609978467264747, -0.8785930672750804, 1.5035557689372325, 0.49481282171102026, -0.4001596119540587, 1.1917747678380257, 1.3923339206753387, -0.0675630752996221, -1.785265735134836, -0.27818006077091373, -1.3791259669472702, -0.23243628424028323, -0.25129813893283515, 1.5284077840478594, 0.1490369716878768, 0.45846811022675754, 0.29054273612401926, 1.200854305997902, 0.09559650906316837, 1.7065676166133725, -1.8805455572990308, -1.685038917633743, 0.38156814513442466, 0.7209288909295132, 0.49275802729964896, 1.6844092153938013},
    {0.8723713191672683, -0.4045296302897044, 0.3497024374224574, 1.5763051186507944, 0.7622829291843093, 0.39409924328575086, -0.24978593445097666, -0.5504867657957385, 0.11396133887572236, 1.3036235452088116, 1.851331124307042, -0.9845451676527452, 0.7913276701963864, -1.0354699188699377, -1.2205627292656933, -0.12183477785486777, 0.9395619157886184, 1.9284869572732097, 1.689717606381876, -0.8097028890536133, 0.8991841400874775, -1.3742513987883942, 0.6002767722692939, 1.126030377152527, 4.084918457047934, -1.6554729813696596, -1.0019439802426189, -1.1791718617781963, 0.3886845119171658, -0.898112342881175, 0.31603784749037167, -0.4656449629425746, -1.5287862658593012, 0.15185743393730397, 1.3847108944390318, -0.17718697415930165, -2.093424144921325, 0.5294887852344031, 0.22465285297487528, 0.40067792985274225, -1.7521483361307078, -0.6840464778423955, -0.2752109199792245, -0.9819989756046581, 1.0086055465730126, 0.8010317783769105, 2.1240049299027244, -0.3800840733915676, 0.8216695782549848, 0.4877972487214112, 1.007450006399771, 1.1777521191423936, -0.3426365725153664, 0.15133696653129583, -0.7487323964459505, -0.6677055417638353, -0.4886967505201513, -0.6899563790317887, -0.31147453354104543, -0.5907898173508684, -0.318367924466635, -0.16313370170250835, -1.5877602531016364, 1.034565507812668},
    {1.1871351308136984, 0.4737847018701257, 0.750834787292698, -2.0775438924846634, -0.25773483647787404, 1.493279305686674, -0.46407073784320707, -1.6776734161947433, 0.7232249530409234, -0.4218845043896544, 1.3347148521840666, -0.30420149696664817, -0.5044571990593337, -0.6628730336835266, -1.0961738437140858, 1.95036330093757, 1.3856647006962506, 1.6739060465792546, 0.533082738989124, -0.4334339298980113, -0.8912832802438119, 0.8698996376555785, -0.2053942124371514, -0.983306418150151, -1.5045294795291049, -1.0131784127196597, 1.28670676250085, 1.3179765631247484, 0.6632707046833186, 0.14550268157061594, -0.8226376422713649, -0.6356947276804131, -0.1602284904842641, 0.48328645569602785, -1.001255206525177, 0.6507038713987349, 0.24451939888075, 1.4006815519580236, -0.11188086411392154, 2.7264262469795515, 0.25420438024071856, -0.9641749312446816, -2.577839066567282, -0.19996826771798423, -1.6190106214378288, 0.7136412729027061, -2.2756738241921766, 0.013439110833344186, -0.023633792700125826, -0.3604714809073642, -0.7349471962327724, -0.5416338122190043, 0.10207496774506689, -2.2766343720294975, 0.09572444021616551, 0.7107184661359432, 0.31149436945862946, 0.5658847360447328, -0.6819176092774297, -0.7143126729819274, -0.5228925033852552, 0.8635634907639561, -0.3933689163803721, 0.030865712755870144}
};

static const float b1[64] = {1.9459078684651685, 2.1143440176540884, 1.7087643264817696, 1.7359049870358498, 1.8085659752578795, 1.8065892813437132, 0.7897933849308482, 1.908342459202854, 2.039017666240413, 1.795596103201522, 0.7792183484092807, 1.1615509867659957, 1.3668805662522723, 1.8779396684311824, 1.6641384634145568, 2.060790783451845, 1.884731911269077, 1.6266132895201224, 1.6625069146390505, 1.4855218431913721, 1.8802467256313853, 2.0687942017210434, 2.0108827717050075, 1.7961024868388724, 2.02945060589257, 2.030288054156074, 1.937126385226401, 2.0265868053730793, 2.1877771454436656, 1.957258032903423, 1.9238223718742222, 2.0687389697799206, 1.8912974077716973, 1.8868433824747373, 1.530890644022625, 2.116403381035988, 1.5115488571224263, 1.3987504631733756, 1.579546071628679, 1.9338368362508458, 1.760527228740164, 1.8836421083100605, 0.8242973716452369, -0.28131820184909456, 1.8552438312733825, 1.2200284512500337, 1.8844752823924582, 1.9232624835596113, 1.7903399862817493, 1.5961994460194073, 1.7877069580740055, 1.7966003218469213, 1.4983525476858683, 1.9052863355365703, 1.8829413371908745, 1.9069442993262213, 1.6587156333509168, 1.9668755066108374, 1.3589466123121752, 1.6704018019289635, 1.5563107697696854, 1.1658389159204237, 2.0184671636790146, 1.683039264257335};

static const float w2[64][32] = {
    {2.7439009773116836, 1.3295466241767622, 0.600822820676441, -0.002501808700008597, -0.5990865446234577, -0.308473536704021, 1.9010273976345053, 2.7731254753658474, 1.1648017562000066, -0.5062633329520322, -1.3386650430355675, 0.5385962023996317, 3.118500372294153, 0.6133041994495569, 2.7019082473739617, 0.1881970145150539, 0.9450345887930625, -0.7346888751131966, 1.3882058588306063, -0.043676658788426546, -2.738780741798782, -1.5831325246181887, 0.493682477470039, -0.9804072566423735, 0.3077458384200783, 2.3762309309028926, 1.3267269054816113, 1.6913768860985776, 1.0401272755697828, 0.40332363087394285, 0.31022525840269416, 0.7564618680422214},
    {2.2411660225181014, 2.826493582221917, 1.7417216715719137, 1.5444891482584642, -0.3047705577481499, 1.3738145042622867, 1.7105072314792378, 1.1474152247701626, 0.7473690414287447, 1.0491978648507854, -0.17160702447951603, -0.521726209987831, 2.2247586237846018, 2.09878355285668, 2.940682393418023, 0.208995093124598, 0.7135301379185078, 0.6593995333786015, 1.8384519877667334, 2.130466245767888, -1.3393626482339602, 1.6600766260989916, 0.6898556726271406, -1.4349696473996605, 1.2821256286036182, 1.3129807120209835, 0.38220129370644196, 0.8050897529068625, 0.1507823467497646, 0.10394142400600945, 3.004126975194794, -1.767231710509082},
    {2.09588480474908, 1.066479056564605, -0.6052720620353346, 2.8589373100162887, -2.336914348038824, -1.1975176603139681, 1.7751806585667085, 0.06601268092285965, 1.5042374398772842, -0.07304244136766505, -0.29069210935561585, 0.6830347287138744, 1.2102367509646481, -0.3389658672717886, 0.10284059858344681, 0.41755854721322067, 1.6919471612746888, 2.0547904350395227, 0.4783084476540719, 1.0549530284576845, 0.674495660426184, -0.1843784068246437, -2.1073130012886856, -0.007628140114954233, 1.90140606576396, 1.5881016563052828, 0.9862651877563473, 1.3752967597670382, 1.396577070015453, -0.2953633286649718, 1.692667426535285, -1.162055404078973},
    {2.773064541111176, 2.9998443651897397, -0.12471417942497924, 1.3881158512332923, 0.4231846089445832, 1.3299749629877757, 0.7437414962988773, 1.19708607696477, -0.22905569560397224, -0.9551709096892137, 1.155016600719287, 2.0505961071665393, -0.02568066193713051, 1.492941168712362, 1.2910989354327247, 1.328490046119345, 1.5136511537648105, -1.0931678583806812, 1.8670455376782236, -0.3950779101248483, 0.39418378903632284, -0.7281572287551442, -1.3764079686462045, 0.5834007824774216, 2.306399153933685, 2.456272079773857, 2.3006568130855314, 2.7117909598223533, 0.10508863342745173, -0.7491373992950506, 0.6873450165159157, 1.269342314725558},
    {2.437635897124406, -0.033571805716660054, -0.09568113866436609, 1.5674807882216828, 0.597480682296851, 1.2046330432010008, 2.3002127486857984, 1.2614577507887195, 2.3339486773096425, 0.2842700684130845, -0.9437809465990777, 0.025617994595384094, 0.5295477961794091, 1.956087090951074, 0.4771029473226161, 0.7230110179490294, -0.07873964620357735, 0.2625196761548385, 0.9189563984846894, 1.2955474772481734, 1.0250451339772986, -1.3371791446279857, -0.41587998605174753, -0.5527600696296234, -0.33808346103422643, 1.7816153634146463, 1.4938928395616093, 1.6326709698594164, -0.5404377910288456, 0.6808605922344108, 1.3724372555101843, -1.1372751517605877},
    {2.5028656615235345, 1.6364455069309563, 1.4601829339474766, 0.4390268663501971, -0.9793901161080618, 0.9472491044836264, 0.45156702145881894, 1.8152621695247362, -0.4868352137175887, -1.90116574587178, -0.598977637695143, 1.9174751627470434, 1.9518892414513476, 0.6528964877958972, 1.2649712500167936, 0.7059353519749296, -0.441970528761437, 1.6448107705993038, 2.520126777395481, -0.05702830023897594, 0.31151411839650883, -0.229016101817002, -0.09547353209586705, -1.7306230803997962, 2.3416048338534416, 1.321929068582037, -0.5667059465656831, 1.38928396698046, 0.4202335340787535, 0.4110873681249148, 0.7875175319920806, -1.9663202573463177},
    {1.2114087754002514, -0.6576610024107814, 0.8537454700682311, 2.368421198054649, 0.7443430637540526, 2.101736178213823, -0.15887430876121963, 0.0756058734611356, 1.232850274895928, -0.43273350796029897, 0.04456333954445211, 1.573080241772507, 1.6059793438894618, 1.9737186934889939, -1.1268357671472915, 0.5550626642297228, 0.2668895801541351, 2.2226957579693236, 0.3302088404428892, 1.2245432474887947, -0.0298473392657533, -0.3713837457290094, -0.9818482590097425, -1.1187833799893492, 1.460432320448736, 1.3441650005460182, -1.0464534133924424, 0.1822947157300827, 0.46457466426487787, 1.7380356318386965, 1.2221288251698936, -0.6210057765798914},
    {1.0516456910897685, 1.3889978020357314, 0.434833873260331, 2.0808459242022725, -0.8464004568428412, 1.1681955831827806, 3.0743966097960493, 2.089029501009027, 2.905617622630404, -1.2079037623094657, 0.4335633558462262, 0.7101622733156508, 1.0891959935616413, 0.6271169893607066, 1.5682669801825202, 0.2934287654726515, 0.1911447929250484, 1.7381960928828526, 0.6688875803698137, 1.365267023754707, 0.3281022990227756, 0.12096788338332197, -1.4330306224334384, -1.1363454234948223, 1.3070159769832137, 1.0514643624140556, 1.9789928817076217, 2.7080756014438077, -0.4133417171762989, 1.5867089953410474, 2.9987448202226794, -0.12015859852351503},
    {1.7772916938779983, 1.9896781053721195, 1.5604321050114462, 1.2057173313794856, -0.29909252345297643, 0.9330044467009883, 1.2176938334364578, 3.795298948198392, 1.8189305328812, 0.15388939896574216, -1.1563079587399987, 0.6378874381101056, 1.5381774968675812, 1.9491995706766434, 2.7453305343826684, 0.6795189242226644, -0.8748878904369264, -0.2961201364537283, 2.0829593210663164, 1.3275037658735378, -1.0000157546699533, -0.07484534999364191, -2.351895486928501, -1.1496203172658648, 0.12841627920803234, 1.7298376253093348, 1.4785892084751517, 0.8625718664438453, 0.00955226440306037, 0.9851763114046301, 0.906785617509483, 0.4974940275834344},
    {1.0039368831909568, 1.3846785669917614, 0.7114391067018287, 2.3715349679591045, 2.5423848944496745, 0.7804037987101154, -0.19354002007955248, 1.326222911219261, 0.5754175545283896, 0.08394917775673247, -0.6524716851607125, 1.0137638355869614, 0.5575365069547599, 0.8689777803313394, 2.1341111720005785, 2.06855332160029, 1.312043337260075, -0.4177588182350982, 2.1861680042426688, 0.06923992679147728, -0.2396068330668942, -0.7344898671566265, 0.4880079813435424, -1.347197692801069, 1.0882260271545097, 2.9327055014127734, -1.001515983266187, 2.2981268459807644, -0.021909704340992243, 0.816608686277758, 2.1218549101256414, -0.39964430202980356},
    {0.8196439615972531, 1.1338828103463279, -0.5336811457640454, 2.148638562945324, -0.7175005134653402, -1.0462118292698146, 0.45148249904262866, 0.55758516581185, 0.5022738675528471, -0.3769693771597791, -0.6668635160630457, 0.9708154711195641, 1.2073712494199005, 1.0886856579739013, -0.22784400799645765, -0.5201141748041087, 2.009125322381288, 0.6950167035222586, 0.5634833849532342, 1.6220360703108554, -2.10986917325858, -0.47907149018360906, -1.1849026255837423, 0.2999135211831066, 1.4580970474457564, 0.39382680784627555, 1.010840607425773, 2.2347794668006182, 1.1481938701541474, -0.8330207106069378, 1.1032951963834068, 1.2502222442784565},
    {1.685642313315872, -0.05047231628488241, 1.3885214771668661, 1.6762902427605268, 2.0682668482825024, 1.6188657241404025, 0.7413686093362842, 1.201761149575687, 0.31080571433051973, -0.4855654784696111, -0.054713892344177686, 1.10764344378296, 0.9296631262415703, -0.9083882324608633, 0.11601986750610037, 0.6355149469288279, -1.3610808828507586, 0.6607927236359871, 2.1523218409736824, 1.185408292930347, -1.3209033517540498, -0.21606731209198948, 0.6754093000605909, -1.7679582224115842, 0.3875124720397486, 0.8586848355327508, 0.38236863824615086, 1.5693147709224753, 0.8555763813964047, 0.9677740486778008, 0.7871728625933005, -2.888125273902413},
    {2.5068512034761192, 0.42129526587783245, 1.8002085735749236, 1.6519561878232454, 0.6910690952739219, 1.2287573230215003, -0.30792034313062694, 0.5093412864472501, 1.385568275224884, -0.23899929562602487, -0.6513980460758731, 1.4142430468904552, 1.3748275837418076, 2.599329304673947, 0.7561735738379176, 1.4658921902618653, 2.389577938494851, -0.44136762559434833, 0.7108971964076705, 1.395446125844446, -0.5996115057367759, -2.1472356985039633, -2.4321367071555313, -2.0587878001297684, 1.771327990933444, 0.7358719753877541, 0.20997203333167383, 1.5985934093339902, 0.6111509312955552, 0.6088893292143756, 1.5556104746793924, 0.5182891196512281},
    {3.6696909496357657, 1.9523084410298486, -0.6657575221677956, 2.1844685637076133, -0.5146595086162823, -0.3988209930463102, 1.5506309884923803, 3.164209999911765, 1.5730449173699177, 0.0680904650705646, -1.3729536737560855, -0.5747160981602764, 2.078379156186853, 2.014591577805871, 1.2285807610541477, 1.5581053702762617, 0.1551110342808365, 1.5606764473855457, 0.09710428915123402, 1.9329700193925436, 0.445679588677418, 0.18171236224932857, -0.19655198712953503, 1.8294363919043841, 0.9678339591254507, 3.1497183273230958, 0.28981445582691157, 2.622925300504388, 0.9213109973261715, -0.056720760186205504, 0.40718078722655177, 1.4504048510780472},
    {2.5155242330859333, 0.9433213520424593, 0.10369761133056103, 1.4250251103284393, 0.6976803286654978, 0.6191176819898193, 0.7299223490385551, 0.6733627768175589, 2.0142877602191307, -1.069782520210932, 2.1674524496185668, 3.3135653263112794, 0.8073820152750953, 0.2680292227301862, 1.991341184454277, 0.7682629783145317, 0.2815434383532627, 1.6852829036808892, 2.1248123849403444, 1.4503190839566447, -0.39732819770216876, -0.44755287230332347, -0.6304266921184303, -0.45079059115815856, 0.4529241002397425, 1.0934933957907764, 0.2630197469098599, 2.2725615229968255, 2.0890486975948632, -0.9359420033250366, 1.6559119376714688, -1.0391981356661713},
    {1.9110532388243127, 0.8637964875741271, 1.1858687186377752, 1.634074761613224, 0.7067379868286053, 1.7729949271541956, 1.7560964877430532, 2.007657125330791, 1.8709044137680844, -1.159528034059686, -1.3207483153767312, 0.844472497469691, 2.6201824649731034, 1.579867753512594, 1.0964402127048984, 1.7311192716269053, 1.448436815048083, -0.297938825020484, 2.1036041708047537, 1.3953750005147558, -1.2743610614726768, -1.0688464839916367, 0.20679830235173208, -0.4395430345397074, 2.504314748002624, 0.349522327202839, 0.7238921052986295, 0.51918909115099, 0.8896887020131922, -2.2830672439066784, 2.0323322147939926, -1.7308486862754926},
    {0.7479475431430208, 0.2549030800283827, 3.369320547355699, 0.3425497917470383, 0.36780714494975525, 0.5423458919114944, 1.41626394648746, 2.242108277982538, 1.1508883688119065, -0.21589677060568577, -0.4585641360056391, 1.4518056263038488, 1.8752198040217851, -0.6696395821648917, 0.7724028338384886, 1.0987138064736028, 0.850099333746572, 1.8726356891714115, 2.5371327880390178, 0.28584920320209645, 0.43773483033576854, -1.3609028289409018, 1.3777270664364856, 1.0964565382181684, 2.516631688993187, 2.392110605343287, -0.21332252002759575, 1.7851820834015797, -0.024292312308624886, 0.03376387832264143, 0.7918120241967606, -1.2132917366757296},
    {1.5926256153885352, 1.1943123120932713, 1.4904833992915165, 0.21601304891427237, -0.8600372699329594, -0.23406615552879542, 2.7154935328393903, 2.614743155642119, 1.4328461414129916, -0.04092947739834805, 0.8203979201323832, 2.340257673940302, 0.17774316086694025, 1.2720769744799534, 0.34171005830418894, -0.9506942994259491, 0.6367435537975588, 1.466337015960719, 2.5074291198155345, -0.38941584347354047, 0.42514306152119474, 1.1099172204075685, -1.7412761855159076, -2.954059563969622, 1.465343081891327, -1.2486987114518442, 1.4690750715801701, 1.2759379460251092, 1.1570776940503584, 1.1333095014998333, 0.6197547121897508, 0.2682527283189339},
    {1.4379980927356015, -0.7145980096397935, 2.28095277826266, 0.9698199323238443, -1.9158040193867871, 1.3622293323512484, 1.0134287128130195, 0.48479163989551616, 1.2900675952234215, -1.5996418428100483, -0.5379945705558774, -0.2504117439375345, 3.3002874595124285, 0.6314373169348724, 2.541288382257239, 0.45626344145493086, 0.3185601363632548, 0.7716696285920337, 1.8374366339752743, 2.8508460644275013, -1.0481258004619962, -1.238819044754143, -0.8617822685435503, 1.4016962415801884, 1.8676814904554513, 0.9638813839376145, 0.352236437269059, -0.08989264919812284, 1.117068277487229, 0.35779443089667445, -0.9570934586299094, -0.09548643775208324},
    {0.22961513814374276, -0.18605223175445923, 1.9945296031341317, 2.334276382299778, -0.7013340409710864, 2.0522970523228605, 2.2566306253371597, 2.302619749206208, 0.435454954160495, 0.43149429670889683, 0.09245960364157924, 1.2015010166539724, 0.27694618977067087, 0.7569144246209202, 1.9893653790798929, 2.217858131559362, -0.6540399393597909, 0.10032258279451385, 0.9066818938415117, 1.7386868866315637, -0.7806597328426759, 2.704909967381482, -0.25876722066967073, 0.2099956690861505, 1.7012765727829686, 0.4381211739087196, 1.3456393995072455, -1.5302383209953385, 0.6229981355111974, 0.05813732707508939, 1.443090191588033, 1.306860761903284},
    {3.2441856796468294, 0.6446169959607954, 1.1208242323749225, 2.774995711970392, 1.200182962330508, 0.1234389565452802, 2.8782307110630696, 1.1023811259963512, 2.1579100380217455, -1.0505989298238496, 0.7976676424767657, 1.7443285225628957, 2.464965832030345, 0.8818804245075226, 2.571034404926126, 2.616402431645994, 2.8162991958489494, 1.0956272379882668, 0.6855696988496758, 0.544230237417836, 1.3070625106453577, 0.9318170205064171, 1.3070306769759354, 0.20983327035867957, 3.2757247992420258, -0.03862276475248483, 0.6305409538753934, 0.14260342133485432, 0.6279998454906256, -2.220432577553534, 0.8329829413391621, 1.2993812937588152},
    {0.4302350121131628, 1.2183078233575098, 2.0194012996664323, 3.296702636937851, -0.4236905720850602, 0.7316418078209743, 2.103408644978641, 1.2948935170560416, 0.10016447802606265, 1.2093791836514753, 0.3891942703605231, 1.6103462712932177, 1.2741322093836653, 1.293128667705823, 2.005631483999035, 1.5921755415893897, -0.5676465737741416, 2.7564979734987167, 2.0538118343919067, -0.3102174247417906, -2.222967963923764, 0.18334881253442128, 1.0600105491410083, 1.1787609708207922, 2.916920048479432, 1.8505959901857865, 2.6345213190310317, 1.3984275763394243, 1.4452877843184908, -0.46178357106635914, -0.4639933962076381, -0.21857983315942495},
    {1.349070323633612, 0.11591657826171492, 0.5951403313597126, 3.3668524431533866, -0.8187595214090686, 1.6704854121369914, 1.8282065402260945, 2.5625136990827593, 1.5796565541518204, -0.4442763478602269, -0.09908170367841873, 2.001350019767347, 2.441614700191162, 0.3773779195078839, 0.4204460190978103, 0.8430535975206837, 0.6224564140714968, 1.8393061701519333, 2.2425358524592593, 0.5837654744747393, -0.45325467306888306, -1.0686470792532243, 0.007249646870775574, -0.03347943810402207, 2.393714362307297, 0.03368111075871334, -1.0105087267128314, 2.766100022337788, 1.5836548078645243, -0.2277967602866424, 1.7276814501217859, -1.5030240287669143},
    {2.6802106195910524, 1.0496138179440402, 0.3504363982000208, 2.721194766118819, 0.3429376333788968, 2.4858519450150176, 2.665346466415569, 0.4420016246936532, 2.5577157989550376, 0.5398247624190544, -1.7163067787537847, 2.096863516475399, -0.6740179884898008, 0.4205489235182385, 0.8566362147510992, -2.4673836303570797, -0.03979384360812612, 0.5087782815770464, 1.082448973915244, 0.9306986458515503, -0.4771980658801347, -1.9893425886391898, 0.13283230326057238, -0.49546261963298804, 3.4108277729057437, 2.1045816542903006, 1.0819242125525375, 0.9132854319534476, 1.3271004165507767, -0.29772164968920656, 0.7507796475601012, 1.8830338018501958},
    {0.25495307247446897, 0.929092211096593, 2.906639384190291, 0.30954516566221985, -0.6638754433264153, 0.6396889954969555, 2.927078363789409, 0.855756858732148, -0.48409291653042985, 0.00020106115841145994, -1.2567888498451323, 1.3031695894850532, 0.8397595936068496, 1.0379376270757468, 1.947677409393374, 2.1459101461540007, 0.47821075816428865, 0.4708451900054662, 2.9177700001229407, 1.3055438355337974, 0.7964516834718601, -1.553111282101164, -2.1840110310617553, -0.34488961272242974, 3.217974003096041, 3.0639386693591963, 1.3256095744024337, -0.15026308984191347, 0.5437727587894522, 0.24413096027539793, 1.6108634574455418, -0.3745313362800474},
    {2.305329124763939, 0.33926977343173387, -0.05354059763147542, 2.665353509330681, -0.8217315472016892, 1.8772017347364676, 2.1598599377593692, 0.4395825970206198, 0.11977008650887294, -1.3540684844782713, -0.23431901499538121, 1.5437011254343431, 3.247531404839619, 1.6851111890703714, 2.989893754525615, -1.324051206328044, -1.0213165792241052, -1.4994767294862885, 2.305304221901156, 1.6662703508480061, -0.9071829165877948, -0.18063612955604605, -1.571128213294578, 0.22225359578528647, 1.5688386970141635, 1.4572869414977965, 1.2206353390939633, 0.8765690347697894, 1.695803754305399, 2.055884448248972, 1.4842694191875896, 0.02567123561282784},
    {1.4734616145147565, 1.7520642141930223, 1.4260488599890855, 2.9909688939108166, 0.7539082716512617, 1.306075141551581, 3.5648666508775246, 0.6744104837780323, 3.0950700791286705, 0.5674469854343788, 1.3864316701540786, -1.0706567677970655, 1.8486131660195826, 1.4037354482921236, 0.07715526591373455, 1.6614115621370906, -1.3772094260467733, 0.9240255595615233, 0.8816291379553732, 1.0749792252827868, -0.7595853690851286, -0.5315542792426559, -0.13192974897637721, 0.10104582823253028, 1.857498750392044, 1.7424556773432545, -0.8913087219535162, 1.2195811512625423, 1.892900090258376, 1.4600518827456723, 2.168297132307155, -1.0317728931843428},
    {2.262002304661593, 1.2324369195616869, 1.1679537291518673, 2.5449263885069726, 0.6898476562204405, -0.4258391432844538, 2.6115055636946196, 0.432662740510063, 1.0356461611769618, -0.5732993714182675, -0.27574837627453863, 2.0800128508643105, 1.8134167089753448, 2.1054433486442865, 2.2520206056047742, 0.06950221676305252, -0.18701027454262342, -0.16578467210818032, 2.940860270219095, -0.9939515959160057, -1.1979332339497188, -0.194736151774273, -0.9660822886742141, 1.4856967470225435, 1.8906807805879013, 1.458838011067717, 0.12713609629661235, 1.3727441945376198, -0.07882081613278394, -0.0011851075790492267, 1.204713997201846, 0.6570799476659168},
    {1.841711017128379, -0.19768343072564165, 1.3423169403877, 0.4825614677472469, 0.3598172082806588, 0.5770943867486674, 3.6508729494045467, 1.346990548415228, -0.3004808267536305, 0.9695489602400292, -1.104987845987583, 1.179008937735283, 1.8726426092026531, 1.7340909743904849, 0.698013458657261, 1.4953375684882104, 0.035709956482541126, -0.03794687978580942, 2.4147279479483856, 0.6367812802624734, -1.5784482183309072, -0.7859893606706769, -0.4007521674260337, -0.8253703213484088, 3.3319914680284413, 2.850606508000561, 0.009040441969051023, -0.06388959789392558, 3.0200543140730822, 0.4536680524210859, 1.6870224378857899, -0.3518220207503803},
    {1.31641846451686, 0.9991589059564477, 1.58369271157065, 0.2890014167998042, -0.8926398196476595, 0.07620255737464035, 1.9121185130596277, 0.2784947155921167, 0.024533647827800615, 0.34054956392734326, 1.3405026602104568, 0.9623663834545703, 3.591350689342484, 1.5722507744074872, 2.065132605271745, 1.0235376149193907, -1.0663757119667017, 1.3978787706946605, 2.621227710057518, -0.6975316389265418, -1.2195458486783544, -0.42773423322680404, 1.026813207725983, -0.20001713099039325, 1.9477781705010386, -0.36609094543318343, 0.7548472742176054, 0.5695512866456897, 2.8437040711658335, -1.5906523469536185, 1.7660481294035162, -1.8454993105024324},
    {0.5114423632723094, 0.6567886750821613, 0.5762871718850662, 1.337281220490881, 1.295712032124449, 2.5041213399960767, 2.164715731761703, -0.03962448781088774, 1.9804097181323006, -1.1840236126759067, 0.07110288480175642, 0.8588187003653774, 1.6049577246525388, 2.7062104819131982, 2.482867171400568, 1.5138722592560263, 0.1630184519127073, 0.5372221525785598, 0.5388795341454291, 1.1986204324464367, -1.2678746862502819, -0.5674095843066171, -0.6440750796466482, 0.01990449566237756, 1.3346616649872576, 2.446021026615688, 0.34330682446617516, 2.491146921626502, 0.7901883013120936, -0.7292738489483217, 1.239377896693394, -0.3077281520967612},
    {2.7181924180856227, 3.103910746323921, 0.8124306573662189, 2.2964475365453163, -0.6853458296604499, 1.7441881675297957, 2.570949310876748, 1.2405246508105952, 1.2217462314470122, 0.09044640283340087, -0.03931747538374875, 2.710772530071516, -0.05395247842484213, 0.7486031630470106, 2.560014982391457, -0.21506260388470555, 0.13302677664223722, 0.9767880674218073, 2.390645474385657, 0.6539238908973933, 0.5486372303133638, 0.9297358163131392, 0.13147276392879284, 2.128653929988546, 1.1675636513953034, 0.7337736682971534, 1.5195069051603607, 0.06953694036889327, 0.7251252035213327, -0.6017002280159767, 2.590199526553139, 0.14408343133816343},
    {0.9537575519304935, 2.190626436247593, 0.3324431470889798, 0.8968720292081008, 0.2631963899074635, 0.5002602520700782, 3.5030612608205853, 0.641945538536389, 0.21352081314049998, 1.1886529029534716, -0.759197346095795, 1.0713947371441026, 1.008262424539592, 1.692331248068495, 0.8573380042807932, -0.8722880982714285, -1.3583848116406232, -0.3449764691170644, 1.541940509394891, 1.8967927641948543, -0.9767310888204374, -0.45975732750889187, 0.05391462030273008, -1.9899344881115326, 3.1605771678454553, -0.0810147417286298, 0.1587938179391485, 1.273239019302833, 1.9723542385400707, -0.9622873819050349, 2.252880146032951, 0.9789775670579974},
    {1.7630030914381223, 0.25305864760067975, 0.6374103101488758, 0.3705652952650896, -1.156901893781112, 0.013180161076469845, 1.4683293188771656, 0.07841055338528596, 1.3434607648602128, 0.5131555702262317, -1.90356938848648, 0.7586048996264829, -0.0003121827116635588, 2.149839543484334, 1.1157660852139988, 0.4463532276782658, -0.8318276473622379, 2.9326719995385497, 2.4652469523158627, -0.023649385626940734, -0.3721951352164953, -0.15616376506063578, 0.29197461039770994, -0.3836787248135713, 2.352278114568277, 3.01870255877722, -0.7873149654120332, 0.40624889273521614, 1.311009792237722, 0.24489588653372682, 1.030793904342205, -0.44684415411778444},
    {1.3966895831975101, 1.3560187261700714, 1.9695974251380841, -0.2280491813841423, 1.9343243435914872, 0.8041028930845704, 1.9722062659364192, 1.7140420556374425, 1.1137624627231568, 1.4737686250880249, 0.48266131902361714, -0.5165977755832931, 0.8343090824122251, 0.44139149694884655, 1.7479025296519604, 0.33335355398516386, 0.03305459975507973, -0.9859357077220519, 1.3593742434580536, 0.7502281197580064, -0.7332459147889113, -0.3375877039223974, -0.2897862476490174, 1.3070784370700679, 3.442726604538801, 0.9173863093709045, -1.3531859042226986, 0.3405112313126874, -0.7894260709342096, -0.860393759681821, 1.9036815490496297, 0.300492106404461},
    {0.7688047188580607, 0.7104766118756839, 1.5520865102355335, 1.0031558632961153, -0.22103280342646478, 0.2613482615057429, 1.992384882807543, 1.7330990435035922, 1.4507829819652043, -0.16111454526104507, -0.8525043836401789, 1.545747800544702, 0.4727237337647371, 0.15461444871256694, 2.5553580205325352, 1.8552280759863815, 2.3510420503880707, 0.38585554558768864, 3.1409339040238007, -0.14393749256066735, -0.24998140137981492, 0.06413915653019049, -0.13974270390313653, 0.02500896098124749, 0.143517189236978, 1.978143545681912, 1.8365743980320783, 1.4779997985950477, 1.542687750928836, 0.05284323372855203, 3.248840697510329, -0.6653295645678444},
    {0.583695181988071, 2.344651643471307, 2.057717171666754, 1.1049364321002615, 0.4476570241822068, 0.41105876979748673, 0.23196431342530435, 0.08252594852050486, 1.3207627648082954, -1.1196135239438223, -1.4272027591910144, 1.4042082644536187, -0.8307224822235761, -0.41812855974996915, 0.9762197099599451, 3.1191524740477514, 1.2802197253713172, 1.7731272449406676, 1.1047999060651388, 0.48275729952888136, 0.30599459663317613, -1.2469799579669631, 0.09158538269936801, -1.8218616021988803, 3.1622927122343616, 2.8155297526119294, 1.1068255838852326, 1.486949866301556, 0.12574148454811365, 0.5721673106170481, 2.926135221697395, -0.8761772872856779},
    {0.2416470202876071, 1.1532284448297825, 0.4340237925112556, 1.6131204588706534, 1.6955155930704147, 0.6743703310860271, 1.9813597401131247, 0.2918632866068346, 2.0970567555397186, 0.15496279821074846, 0.7177831013055246, 0.3871052420025636, 0.37551983979866665, 0.35035456752896055, 1.036764982975403, -0.22514052478461327, -0.6683784014751581, 2.0281266563186597, 0.8018870115113772, -1.0436593452511593, -2.164708134435606, -0.6610354278516437, 0.012901884878954212, -0.42956379602711064, 0.7791613442529485, 2.4992542761509653, 1.1119558496117419, -0.11763148378363665, -0.16118747640798312, -0.30807966508099505, 1.2387439894947712, 0.4028167744272119},
    {1.8930995334439438, 1.387744874858982, 0.29089386860611205, 1.279017007030475, 0.32773610858151214, 0.42246579563570164, 1.7884609256293917, 0.8270587525775903, 1.4259871432209652, 0.17374187012830472, -0.10161634313133781, -0.03429320486848477, -0.22620369082944985, 0.2337941053361707, 1.1862625092502186, 1.7345084533525534, -0.8470054164361198, 1.0012225253787068, 1.655052454163408, 1.492888676481616, 0.3219904957289613, -1.5461104220665454, -1.9017271048097055, -0.4754307440768441, 0.4071916446234851, 1.805370464160131, 2.4861455040687113, -0.28488624843986937, 0.6892345525633249, -0.0403383189405407, 1.9395990027057572, 2.004037293005939},
    {1.457118491249122, 0.22537646424821015, 1.1151220151343706, 0.44773975196294663, -1.146479637708654, -1.892915902383092, 1.8257228019459308, 1.5389995609681426, 2.129482307438193, -0.711323821585944, -1.278820485959162, 1.9729504141424385, -0.43328739301752184, 3.1888147130874778, 2.641115456169123, -0.11389229305274634, -0.337625712347041, 0.17184307431336562, 1.4956591976389346, 0.7524213406199206, 1.0069597380226438, -0.8668560399844555, -1.717076918212055, 0.23811483966075375, -0.052879032758525374, 1.4034501917560782, 1.0166558560782541, 1.5000953485497028, -0.6622679571968777, -0.6524613577080297, 2.3914230640813434, -0.9167033107029724},
    {1.1091284043237617, 2.581446166126561, 0.8811841468170347, -0.020012692123080843, -1.7670846138076448, -0.7539052452662321, 2.281978102610547, 1.0744826465795219, 2.2534800037135776, 0.13747346207155944, -0.3795641135769366, 1.2093992921456087, 1.7046610029348084, 3.2562221924286407, 0.5904241861186768, 1.4657628028665493, 1.0872713999922479, 0.6416253155444941, 1.6881582569995606, 1.4331881567652864, 0.8282224885537566, 1.0028348103193276, 1.0464300429450442, 2.022350499889011, 2.722754837567317, 1.9322702268158176, 2.7416845477148364, -1.0789971019267086, 1.2175909241196445, 0.715500722315222, -1.0582215008982887, 0.4952691628551945},
    {1.1495546352444754, 2.396483606253161, -0.03367542927072401, 1.7926974052960871, -0.4960064813433746, 0.6950775117705454, 0.03414798011990296, 0.4628935672799629, 2.142559048802095, -0.3223234187072804, -1.1448599261773265, 0.3071651138304363, 0.6675325127535671, -0.054415743545171334, 1.7305646601044622, 1.379714162871518, -0.04786094304454438, 1.360893293034011, 1.8143420652481947, 0.19203387197440483, 0.23311177736774838, -1.125982613097963, -0.2583728350748269, 0.9919319918161791, 1.0819528297238918, 3.513122418275709, 1.1279689424038546, 1.763419084423033, 1.502097127746624, -0.33550905402400905, 1.2306714109199148, 0.12111678351702394},
    {1.127160949203046, -1.3691917105036728, -0.8388899799050262, 0.7099205324534398, 3.3493913108873445, 0.10524267553777598, 0.9613938232964431, 0.22723070673102283, 0.7524625455995899, -0.6006038936100684, 1.107679348934088, 0.6198660219498907, 2.481636324118962, -0.4174013352373435, -0.5352919998191032, -0.6442698807771534, 0.4249426505608201, 1.2081734952465089, 0.5062864084282828, -0.4393430133349905, -0.8333069405290345, -0.48184428579114996, -1.5818071048497628, 0.38980093772802876, 1.320380921118984, 0.756939555835877, 0.886522846625331, 2.913123754850875, -0.7534415952904294, -0.8418703440374609, 3.2911478545125203, 1.568837525452541},
    {-1.2362994397691471, -1.208333403592625, 0.49452502050995567, 1.1967296151727518, 1.0461125597686942, 1.446588883528963, -0.49323898420024814, 0.05871752616499624, 1.4291105639994446, -0.5360292057830026, 0.5248438551048388, -0.19578568308068042, -0.38970908324391856, 0.7865122376615785, 0.6178184494352471, 1.571355960344191, 0.5009833891966745, 0.529565535015063, 2.0285331997929714, 0.900612943573364, -1.4324740385152344, 1.0894352862315753, -1.3264422029663483, -1.9826820008507706, 0.3033371814003134, 1.3448621048386282, 1.2131166701865124, 0.36828454093760915, -1.482704845827899, -0.4835493059821761, 0.0019089680875147069, -0.6191712162859687},
    {0.9044110687588461, 1.0328972438748973, 2.143675730188218, 2.1035528569628386, -0.23343065585832964, -0.11113394206921152, 1.3880635234827208, 0.6049808869122772, 2.2158448472789307, -0.6536313729612324, 0.1935596356700236, 0.026785070262517707, 0.8716360846499808, 1.6731770252726952, 2.6489795251401667, 1.170768359769463, -0.4839460501918293, 1.5426027320435254, 0.5510557846786219, 0.6866480775065891, -0.5415284752342815, -0.12689679141009808, -0.554658432725555, 0.9311153370069187, 1.4701657886316586, 1.8970667929427873, 0.06773249493207409, 1.3104970928930557, 0.8610565687211224, -0.8856170676912255, 0.4041493051687805, 0.02351238467980886},
    {3.3034659075079316, 0.49546916179820405, 0.06810711185522314, 1.5769686406594035, -0.007357120200401463, 0.3103865835154923, -0.6194526698468497, 0.785888379316274, 2.233221236496814, 1.6393926078430783, 0.8265322504508159, 0.5835667102148359, 1.941814605763573, 1.744488429598283, 1.2192702124633996, 2.004640245727785, 1.1381020004938946, 0.8560693892606919, 0.7846211437027973, -0.026603513659736122, 0.647322933653423, 0.45159207060539147, -0.04821411141248103, -0.5771695894571846, -0.520839090550359, 1.6728300024635303, 1.039696812554031, 0.12444139108112666, 0.7946758771441488, -0.002356079973970148, 0.6920646635666932, 0.3937937353961458},
    {1.3193651769737522, 2.720997262953079, 0.8048618040570955, 1.5876419596787519, -0.5982648511551942, 0.21798782688346569, 0.8888603506063976, 2.861326550514976, 2.351982592578914, -0.8743064029675729, -0.057222746037315406, 1.1047791858021614, 0.9384724074832574, 0.3684660580713123, 1.0268342219676008, -0.04014797053018102, 1.9692335928757667, 0.515509414307984, 2.4877363095406793, 0.9624767307803097, 0.00849922598541522, 0.7544762793280276, 0.2105126167923334, -1.385245643209506, 0.4630972415219925, 2.7486148895944345, 0.43049895478053307, 3.1701312788183023, 0.3616880231569937, -0.18990937825291304, 0.8178441478118044, -2.0822643067775415},
    {1.0243775949800218, 2.8308673732064666, 2.1071818354686855, -0.07618718716910843, -0.2907822718779362, 0.03410128017805789, 2.5413014002700645, 2.3987292597794476, 2.117147609685814, -0.5402306652656174, -0.7446902981106331, 2.645466132620316, 0.07360228734389342, 1.4878648230482305, 1.916676809186133, 2.159813113447471, 1.1756092450874982, 1.2363124082962722, 2.275037336497836, -0.3760619669730279, -0.29643739698797017, -1.7652149531342731, -1.4765553897034918, -0.4120566195440188, 0.872370301547043, 1.5625643170023336, 1.6601002525542146, 1.9167612337874944, 0.6287473209037907, 0.37294798085230063, 1.0683208925993337, -0.4919506617869184},
    {0.023544628463212536, 0.9714897749609158, 2.497332961782977, 0.5559622645127994, -1.5665676687397487, 1.758324226749554, 2.3006785366336118, 0.6729574496617916, 0.9480578104486881, -0.4824406032085093, 0.2605053474419052, 0.8679988188838629, 2.011398059234186, 1.3633049094245286, 1.0580810608230382, 1.8146613583046467, 0.30708323654672554, 0.6319342847799253, 1.4048388606108848, -0.8132533766670701, -0.9955462327853626, -0.28683754118902777, 0.5346154515407388, 1.4075043297384142, 0.8973270314917926, 0.03250520745474732, 1.368497382735128, 2.7049679775581623, 1.902972566520798, 0.6072720894764357, 1.718597595434491, -0.948441171036371},
    {0.7171996060560358, 0.11316380654487267, 1.816285780695791, 1.720657771954932, -0.1395861842128643, 1.8573157466230221, 0.6946159229297271, 1.3679343318348447, 2.4819945928255294, -0.694732833430142, -1.1932977081690128, 2.8092671347381315, 1.9781506695552442, 2.3072974845309524, 1.201207160482629, 1.270748774652455, -0.09570873195460113, -0.2516460277426363, 1.564794865741874, 0.9724652771669738, 0.7822153151823991, -0.8474829829504742, 1.1621727165121782, -0.19903347628783802, 0.5016402687434618, 0.6619112790124704, 1.5798809237848042, -0.8290414587166689, -0.9737033873909543, 0.819158578270808, 2.110783618270846, -0.8137944518692033},
    {1.37624332910424, 0.9351319650870608, -0.8563977133165187, 0.229052419164885, 0.8831228971516463, 1.5859180824960013, 1.3049933682964978, 1.9466603885026266, 1.573684193421351, -0.10568700985609072, 0.1637235104330198, 1.1177679837398546, 3.01847645983863, 2.7281884545973076, 0.5945697364563484, 0.27456164250574466, -2.5161914840205957, 2.8784540061682278, 2.0841406482322977, 1.3768906412140332, -2.2049876861710724, 1.0098445922276824, -0.5081641942346223, -1.4292021764788745, 0.7350768843017109, 2.0297743602126714, 0.9341949354029657, 1.5381131908763757, 1.7617438140369965, -1.3286591479625942, 1.598330170158993, 0.29116967862146076},
    {1.119236494904177, 0.9515907963343737, 0.14581902974406874, 1.877853675536573, -0.9462531276186134, 0.8096602581236665, 0.5365478720775736, 1.447980579131484, 0.4229463641203003, -0.8459607668244781, 0.03169540944909814, 0.5875057213191822, 0.606323969867979, 2.727467100557083, 2.0455579557630683, 0.14363883473032518, -0.6974926037427702, 1.2404121335686173, 1.7443536471943923, -1.0695737309975928, -0.9919612941515309, 1.0050724910078614, 0.8430583908994261, 0.6515205063664806, 0.500990331991477, 1.4334454426557817, 1.550328796868372, 1.2545251034889333, -0.16845263363441187, 0.9165649039234144, 0.9486887076420172, 0.4344451719867659},
    {1.5763396716055786, -1.0874885281825877, 2.071352875750949, 1.237592950274656, 0.3566656100218273, 0.9401891304203804, 2.065280713947285, 1.0646434037399006, 0.8465580423804461, -0.3178754296866331, -0.5617624271956394, 0.4883171639036093, 0.6119614392730462, -0.149745027820265, 1.514399317656487, 1.335032886459668, -1.402023285053237, 1.6356862412869735, 0.9549750691551655, 1.0236920957567817, 0.46054894826320875, 0.9655856415138964, 1.167105511534718, -1.1220745110909605, 1.961611302932884, -0.15601400135388002, 2.159015638496733, 1.39702350191303, 2.5317469367364054, 0.42333931095618754, 1.9696226726910546, 0.23173521975708078},
    {1.972124679464626, -0.3296229256677639, -2.7601677434937524, 1.3488646298374916, -1.3473147767020044, 2.334799860543805, 1.0699758399748378, 1.1463166586788542, 1.8910101917054343, 0.5124446319114044, 0.5346691723464636, 1.5074088719705145, 3.0836936297657496, 2.1349629968039867, 2.36489340261015, -1.127217479313121, -0.4144861966126459, -0.15346103774213823, 1.3024866859454656, 1.6398009291122264, -0.34930601368632297, -0.10327776046382982, -0.8372346069762956, -0.38322042083769176, 0.7363937305074284, 2.08540402803033, 1.622825109187692, 0.4920750235643202, 1.9823885206093994, 1.0326727648194354, 0.9976486114488832, 0.0014855703079594787},
    {1.3365475039038683, 2.334448241697064, 2.4894702072305783, 2.0250155097998053, -0.8538151880432355, -0.32940820605678356, 0.6868936960439834, 2.489673715827551, 1.4482625623857244, -0.22093639140831003, 1.1331648314043334, 0.8152014789989429, 1.8457120006213656, 0.10359532563376952, 0.4535332047831616, -0.26491647560825343, -0.30477575025497666, -0.42482771915239625, 1.8364948613844572, 3.405408819752429, 0.31683774518236535, -0.07406746292181027, -0.6520037558488913, -1.7413490003537648, 1.5239491202907256, 2.3645008820136852, 0.20998481194095062, 1.0131114018268428, 0.3594729579649673, 1.0677306619891023, 0.5682828559476342, -0.5126260674877043},
    {1.1261680715812536, 0.6216370426370154, 0.3980565645696165, 1.493037531330344, -0.45892652931998185, -0.506222555034266, 3.251896175696237, 1.7161658843160235, 1.2101805826315946, 0.5249507997795144, -0.02926221420803453, 0.3683634357563231, 2.189848639464684, 0.33942979733865086, 1.605438530665397, -0.695486755713797, 1.0179151917108424, 0.4565796723359225, 1.2205767550065243, 0.5738357121510816, 0.5444951518343533, 0.40335868171643985, 0.14216049497400454, 0.7948532048990509, 1.6531839591002353, 0.9295056288489356, 0.5280233246430187, 2.1801010362517608, -0.9797859883508271, -0.45419977274893103, 2.1728981389670388, 0.3898888511439279},
    {-0.3971678592486125, 1.2689591658441304, 1.1582900711532957, 1.7599572167392992, 0.8981518244561952, 1.127980390630186, -0.06529081341598031, 0.23383755667570397, 1.926297691823869, -0.11820349887635652, -0.6918853993738272, 0.6546432148404486, 2.445686309460629, 2.1885229339826098, 1.9684797880317049, 1.5776283978042385, -0.15947869448445995, -0.2492106858689785, 1.7329094140182493, 0.14982651341353295, 1.5352188336502333, 0.054985977570680876, -0.6077780881537169, 0.9022214792344307, 2.4282402080972263, 1.5861010676549545, 0.7940639652046448, 0.8694165182376883, -0.6636031621218875, -1.0951577086735553, 1.9027626589173394, -0.3856626654142688},
    {0.2460136783558037, 0.9109500166706047, -1.1898583737711048, 1.4386108036357892, 0.5125599013060644, 0.11180004606450922, 3.193243954966842, -0.4474663580278357, -0.07542896773167684, 0.9927434446145881, -1.2377970024525047, 0.4475164923207368, 2.3292227775357057, 0.2663766665561721, 1.5860858342863324, 0.8375144678079953, 0.6510447115779753, 0.4113649657520254, 1.0898299125644555, 1.2213854932949249, -0.4574498598868171, -0.6963118213999887, -0.3262544518695391, -0.11224709032680576, 2.5884248489094417, 2.255383730525839, 1.352003465272465, 1.7474719433490178, 1.5234383756118532, -1.5558765743934335, 0.9244012590108992, 0.32761308041537196},
    {1.2647586307809886, 0.7193408713700098, 0.07359894025205072, 1.575972788716825, 0.4322065458626373, -0.3044097567373366, 1.795069214868579, 0.7003189009462488, 0.5432431723580181, 2.0374952530502495, 0.4245726027094296, 1.2360809876878076, 0.7676600772039739, 1.7282280173594942, 0.23451144090040876, -0.00887302328108003, 2.056604636603418, -0.5661386534834408, 1.6710158702630864, -0.3596571562613822, 1.449961590281542, 0.38645992856718514, -1.3617609956055245, -0.433613290743712, -0.49497792810067653, 0.716302710896549, 1.528666653533191, 1.3312052776558823, -0.22404209615765142, 0.09104727928022524, 2.2332367114865437, 0.525781578460432},
    {1.4804421796669, 3.7053044171855354, 0.9321762749646978, 1.8896799046697441, 0.40808737409649887, 0.2740040315364427, 2.608537707546242, 1.783761290809814, 0.7794291018758831, -0.664231570883578, 0.34111241725570407, 1.6371076711427626, 0.25466700902284045, 0.08535408159348559, 2.9316069399271543, 1.7682715107907256, 0.7835445316865048, -0.20656264091375814, 0.20471599935133572, 0.07321231020085625, 0.1950178834150812, 1.9151664119064074, -1.156711691016681, 1.4366200531746887, 0.6035428701757777, 0.23981507978420036, 0.6487082233144363, 0.8449379235900425, -0.24509539745839118, 1.3809832117531238, 3.096233225920345, 0.8279331075040987},
    {0.42397579103211575, 1.6382286457830841, 0.3367390787483957, 2.167249639789363, 1.824646146786902, 0.5817959546048992, 1.9377748886123947, 2.005243337330498, 2.245689317144581, 0.5016448585152438, -0.7328212403823398, 2.7139542745167793, 2.377095747291336, 0.45872314528039665, 0.8517887806856727, 1.1275737212068613, 0.3271137778752656, 0.4157127308521422, 1.7993650132182202, -0.37167669610128223, 0.5850622318412972, 0.11491194589761927, -0.5684706106516625, -0.030489246561873632, 1.5899520193457195, -0.6443126844458786, 0.6491214954020798, 0.11708460968064849, -0.17695843920265697, -1.2857608504531124, 1.506630431290288, 0.7699459828555119},
    {1.528326828030442, 2.2078302300095993, 0.6427567707653765, 1.3946549368512333, -0.5706627148715407, 3.71967191614491, 0.231508344969242, 1.6794228661392998, 0.7300185958510439, -1.0955569997020218, -0.2532099984252966, 1.1497318670251007, 2.0260557659871594, 0.9977880660910247, 1.5729140357996227, 2.1615310689164904, 1.7859664462635292, 1.2786075175252503, 0.5887706056897251, 1.766438236929708, -1.8210753691010426, -1.0430332611559876, -0.9336908931085636, -0.6652501901046602, 0.9377293452766122, 1.18867864533, 1.575559282880073, -1.0145729384872908, -0.09170566244033107, 0.404756848316837, 1.3213118979511709, 1.7769768719939718},
    {2.4436241145545363, 1.29574194243837, 0.10563379466174888, -0.9602311218073473, 0.2361759783039246, 2.3213536953072302, 3.111705520208714, 4.015485274934531, 1.6962886173323404, 0.24152909982199153, -1.2319222038290485, 2.6465425973899888, 0.4353715149632141, 0.9723473659830795, 2.6196634125275335, 0.48158246796526016, 0.20489006511420546, -0.41833081970070446, 1.875669191948351, -1.1074710306607654, 0.0005835130437472179, -0.6347567535423759, 0.7561244729730455, -1.03182408117616, 1.7052097169704692, 2.840540959486046, 0.9075048980197008, 2.5589748763057387, 1.369848255428308, 0.3861706796971199, 0.3087271597281689, -0.35105804056994144},
    {1.4458750558027267, 0.19256906344985927, -0.373579634818242, 0.949616542828931, -1.087802199933601, 1.1479935377660688, 1.050381750690972, 2.0523913769503266, 1.0943936592818353, -1.0146438742631498, -1.2218181174220328, 1.3861847779763123, 1.4232080306711459, 3.6434399224842067, 1.7295798860019518, 1.0491621895672345, 1.3418537822697416, 2.6147069249817725, 0.6731888135290348, 0.3286742591223644, -0.637403117381291, 0.019126749523385094, -0.2417338343497165, -0.923634158981861, 1.6075278766229555, 3.070478022905073, 1.4317202898973422, -0.6888095370555543, 0.5876956101829953, 0.7468295972533345, 1.2617100201596685, -1.1432631173765266}
};

static const float b2[32] = {2.2285261039853372, 1.5765442236224192, 1.6691464652277066, 2.228082629458783, -0.2399372193637929, 1.5047640189116518, 2.428899450052612, 1.814482542932616, 1.9665628887784714, 0.09922434125507011, 0.02017447536114625, 1.684120574208055, 2.3672253439401025, 1.9887077586146675, 2.1287741996638587, 1.3501266250169908, 0.2810552796233083, 1.3178369805828427, 2.240357498657422, 1.1456704578353651, -0.1707602204943047, -0.19603532639691326, -0.34759389081379005, -0.2451648154305332, 2.3013600325483665, 2.335568038942568, 1.4249303744391877, 1.729740169026158, 1.2467268439782815, 0.5406931757730894, 2.200220205321571, -0.2694744206729072};

static const float w3[32][16] = {
    {-0.6891514040484343, 0.807419343668236, -0.776155218741316, -0.3603167091947538, 2.984935878431857, 0.6690647410708008, 0.47648089480902966, -1.426304680690828, 1.342115703804692, 1.2319705412183113, 1.7403985107655797, 1.541589060666512, 3.231056104968135, 2.4592139467704155, 2.466643803690398, 2.635371960194042},
    {-0.4738711844264902, 0.6193102352367652, 0.9026831421690488, 1.6120711212228698, 1.9913989428811676, 0.9684856830438677, -0.41667698705500855, -0.19692513760199115, 0.21971144999022507, 1.3217434364237157, 2.8492980298631956, 1.5984721206435377, 3.2969471498771177, -0.7987886482241833, 2.1880090200373643, 0.8795990009756639},
    {-1.086776545528721, 0.1443149313270661, -1.0758833617114192, 0.7958774055949283, -0.09801508197695621, 2.536680238061315, -1.144628839608691, -0.24857437292022144, 1.9373144000518756, 1.1537643735543284, 1.122565962122934, 1.7288086377670906, 2.824088915716482, 2.5326267036532837, 2.6787722655226953, 1.4003863213369552},
    {-0.038139679346912043, 3.481996598443539, -0.3420975456763867, 0.5861207030796243, 2.0770015701003017, 2.6065064849235844, 0.4834200586609828, -0.723154668431781, 2.6122041137901126, 2.578466280668643, 4.088080218362564, 1.971841855052267, 2.5410522056615417, 1.7578205670742677, 2.274377715792907, 0.7105891438221167},
    {0.9679186138610324, -1.3036584635035477, -0.43452145117333923, 0.6014368976271345, 1.2933765979425296, -0.3387344151762888, -1.3891880449013432, 1.147382134335283, 0.5094513496749107, -0.12796348262070945, -0.9679375836161493, 1.012589273217944, -0.14854912800153994, 0.10957380447524251, 1.6583992727349437, 1.1827583824298809},
    {-0.6623021305982004, 0.1442885277080676, -0.17809254109289432, 1.8120061371196634, 1.5938142407334175, 1.4694361761832755, 1.0901822248657247, -0.40175831639676624, 1.3036293041303597, 3.294943430356286, 1.4397208341984722, 1.360169001068587, 2.2824184930072735, 1.3186276767209246, 1.592158024132203, 0.9633776885135023},
    {-0.7507356541505581, 2.2748010886394967, -0.42968503974717165, 1.3893477106858485, 3.0104188330519115, 2.9266895034517195, -0.3845743715952787, -0.09469374993836172, 1.5712502103143715, 0.9544029342988737, 4.187645591429925, 1.871137077510881, 2.6801786879811162, 2.381661432134534, 0.5846430243379367, 1.847642046535222},
    {-1.785335486147547, 0.8505575078961906, 1.0290859195656172, 2.1901078148185067, 0.39097736964285007, 2.2460934926152003, 0.9545570379167297, 0.2982382101162045, 1.0313667076538982, 2.1069163556483708, 3.3615666968614994, 0.711070424364132, 2.7188219597615566, 0.3791856837440211, 1.216710711572139, 0.8423701382199846},
    {-0.947835385489667, 2.7424617163258316, -0.9820035050441108, 0.46448416357238725, 2.4659426956920703, 1.4758432605642562, -0.47995278613058223, 0.2856744618519529, 1.5861903649149616, 1.9255989662859119, 1.5526379650097362, 3.214094954107386, 3.5574426168934714, 0.9502850175390708, 3.1362834158653343, 0.6416981045603373},
    {0.014126761091141955, 0.4444036427029289, 0.35982676322241247, 1.2717758247108022, 1.7024189767042077, 1.3256213635898488, -0.43068028946338616, 0.42231336405382397, 0.0020903062951942177, -0.4297647968035321, 1.6779550888901482, 0.4816997438096892, -0.7176810708786137, 0.09494360859097485, 1.3917527673302288, -2.526663582281158},
    {0.636982305532818, -0.6772060667897336, -1.0728262302204523, 1.0634330949111785, 1.181738002330389, 0.4106708015758914, -0.15162978687600345, -1.1558573578066833, 1.6820569083308126, -0.6501944253848039, 0.519505330664491, 0.6388219447240289, -0.944564555102614, -1.6024696144261172, 0.7321282974379674, 1.0664398865304792},
    {-1.4705644837714893, 0.8585658083749609, 1.2783797230307608, -0.09911966539859718, 2.009463986403072, 2.1159777620382, 0.7071924187686095, -0.6569230147901323, 1.7635418037870034, 2.506327306733501, 2.4837242959171997, 1.144078813576066, 0.24678265230666663, 1.0881622779891287, 1.463066370936338, 1.9971572618771232},
    {1.0047138434106002, 1.2760651380794543, 0.5992352095955306, 1.1004001915309551, 1.4098286133466265, 1.9630948027373538, -0.662762090445714, -0.8006363803351167, 2.1600224735986435, 3.4989236906105177, 2.3818584394220887, 1.7905294272297418, 2.81238668591594, 2.2078702545755937, 2.4281395764064806, 2.272837835083227},
    {-0.03323535931993082, -1.02754236612567, 0.052681370274641835, 0.21689426362253103, 1.0900364288719935, 1.4054389857359995, -1.2919369375212484, -0.587470340981285, 2.382032313231778, 3.7588439909236167, 2.7307823577055648, 2.4149992360731565, 2.3351377318140214, 3.1252646497635945, -0.2634075322210937, 1.4649883106948078},
    {-1.8424727530739087, 1.6698671302824095, 1.5691401989965257, 1.4367169549117043, 1.4684628511094855, 1.7309980432932097, 0.2565327302297893, -1.2939631661346784, 0.8137017886355832, 0.9409273013923956, 3.0915663639608786, 1.6912657952566676, 2.5180913506560505, 0.8225018170001014, 0.4218007687879806, 3.6430847570082223},
    {-0.03384347188181478, -0.0009373032500957206, 0.09535326472040986, -0.506695049828956, 0.6323995574377154, 2.7674540538067185, -0.12415350936766753, 0.2936469214432699, 0.00727783864399968, 0.9937065125702849, 0.5091600045542177, 1.5049381583615178, 3.8704130842562887, 1.2902894407501537, 1.5757879328565971, 1.3015228021194583},
    {0.1728012724934052, 0.4324274240396371, -0.5367044413703452, 0.9198377010257655, -0.6115750474676579, -0.13275570148684723, 0.2033840319369439, -0.03668230224234567, -0.13984764632058028, -0.1929985937765135, 2.7823280728425845, 1.0699851182023645, 0.9767861523636749, 0.5114233095830406, -0.07494838055008865, 0.09669481317833195},
    {1.0339037882444306, 0.3537348764113797, -0.004221300929373434, 0.808448543983074, 0.9064594972860155, 0.12600885789599003, 0.5371552991852462, -0.02433502516070305, 0.4168853050715512, 3.4265412419112544, 0.7839182446328797, 2.6614982249240318, 3.676326838667239, 2.199491231851898, 2.655413443516012, -0.1018005205166841},
    {-0.15344310242511455, 2.2819032044271936, -1.4477399390695145, 1.703378766302711, 1.229089974059593, 2.0375194014994467, -0.3633107607805608, 0.06589333522563653, 3.594022246206882, 0.4957036485852822, 2.504640530665052, 3.4716125323089955, 3.6252096116348502, 1.872595854884965, 0.2675186598884158, 3.7292728631271355},
    {0.30907063811606045, 1.4628818420368006, 0.9276851228691464, 1.079772302867185, 0.8044895263074224, 0.44799049350893666, -0.9441153961817574, -0.10998078261655425, 0.9215843782826039, 1.3990858739015173, 1.2405550760883395, 0.6122474338770891, 1.7401448361616472, 1.589357092899296, 0.24760197308692947, 1.759018771753469},
    {-0.2838916473456836, -0.10193668822915403, 1.8037779067221846, 2.7839025994357876, -0.7659220494227543, -0.9828257900251035, 0.3033215208791489, -1.432831237481602, -1.6470529460160126, -0.2579618757395835, 1.0136725357621517, -0.009556958259890455, -1.2203174868342672, -0.3821461348291901, -0.6783541606344143, 0.5035142915166021},
    {1.3482920254936637, -0.06474828217871761, -1.4379423131689042, -0.6888807104019623, -0.014948181757208306, 0.18515882719753388, 0.03796528743317717, -0.16849913581929227, -0.681060914506859, 2.6947840362388416, -1.0797397057333462, 1.2547178126219227, -0.9254249776567797, -0.7088347371485142, 0.8435566449108267, -0.32250208221166443},
    {-1.9830709760906933, -0.4680292985260675, -0.6512803071673672, 0.5847744208690101, -0.4714242763910497, -0.45184351560181246, 0.04286327712904754, -2.641353267003963, -0.3838607678642272, -0.17440119001081467, -0.9348819882516721, -2.210780319487259, -0.19177910811287063, -0.5932358280707435, -0.5975162138788618, -0.23882287062516544},
    {0.4809353799412712, 0.5613484776766885, -0.10599686788539935, -0.3416261807104157, -0.8794677241762315, 3.2692192749014857, 1.4769115734016454, -0.48423073301140895, -1.3827355321199495, -0.5275201952063734, 0.25093548168937124, -0.9754598812566656, 0.6985410269805921, -0.9817133062593184, 1.2418804337805402, -1.0228722280921403},
    {-1.7950582118827267, 0.6384706702081414, 1.000006162875168, 0.5163738880267433, 2.9907038013531375, 2.389875420423824, 0.5914683492071283, 0.09605696722685615, 1.25187145460281, 2.1411106977396828, 2.3503825391896935, 2.7246231182903085, 2.7073253718511814, 2.435168193689634, 1.737445349266479, 2.094221431964759},
    {1.0455191089461164, 1.2794827195539158, -1.0680679835734102, 1.0949153821750885, 1.8486475977551344, 2.1305623589109675, 0.16585148446450337, -0.4410919179760597, 2.0836534800332913, 1.2883217739555635, 2.5710461572709122, 0.33353030124804517, 3.5435055812573437, 2.2402472465538676, 1.966214740846153, 1.7243151922187034},
    {0.1380413449825817, 1.1066797864105675, 0.022825737209643586, 1.8484087844978558, 1.4435856481730336, 2.3517929077407675, 1.0049508665379205, -2.096962313460389, 2.029771574906453, 1.7906643013049668, 3.636744189723637, 2.592860494848908, 1.084390041648184, 1.674713550641533, 1.0619930844361882, -0.6861207261564918},
    {-1.7478634897383658, 2.1267437511932172, -1.6781072126882417, -0.2108383291211793, 3.3532838896961787, 1.3350318046849488, -2.066855377188293, 1.228672567471013, 1.1411447887399468, 1.7384824181581557, 3.062245640982279, 2.0259581785057885, 0.7875777396167957, 0.20593731201771692, 0.8350289789125209, 1.5484504179098932},
    {-1.9035839290581753, 1.1750736000610953, 0.42694699758077437, 1.5588361963526218, -0.20806507842554753, 1.3424382658606204, 0.12269856676379315, 1.6748396806796126, -0.0730755728881168, 2.3617844031546005, 1.900039446186414, 1.2926366140909118, 1.21601054540962, 0.5745523892638167, 1.3911065021309932, 3.37257270740585},
    {-0.6374536508502242, 0.7404521662086364, -0.5465456919085685, 0.7488016397064539, -0.18874151099087055, -0.3248327079145264, -0.2306129725547347, 0.9560800953411571, 0.4578607143731722, 1.89523802750349, -0.3867114834336176, 0.006202712101659359, 0.8237059384248556, 2.2401016601075012, 1.2399518653525132, 1.3850166122289094},
    {-0.07318620851013515, 1.1739796464536694, 0.10070472959625679, 1.6176059472897184, 0.7379200100284347, 2.6751439226232128, -0.07825855426987026, 0.2885989415303579, 2.467798254687292, 2.4033018088889415, 1.3107501529403398, 0.9894573035481308, 4.199797552708177, 1.4905530360624846, 2.0705867082722857, 1.9506452577048357},
    {2.1634141108399074, 1.6888158610444908, -1.460958327255659, -2.283098866979231, -0.7257427691335513, -0.24815633818434712, -0.268873121773655, -0.19347434407011624, -1.9653290494072921, -0.48234863315938986, -0.12497152402907186, 1.3446664483280002, 3.0136826229189664, 0.8065348852084278, -0.556013689202154, 0.7690083353336571}
};

static const float b3[16] = {-0.03772954918773257, 0.8041757575093222, -0.15041419432627237, 0.8246633536924751, 1.2572852095190545, 1.2966332737949748, -0.05661361516596312, -0.08938663627284651, 1.0123630368252061, 1.577540782678837, 1.9043747765057462, 1.1050647872715174, 1.9225313922883651, 1.2683590944613885, 1.2693568018248391, 1.4711534771009598};

static const float w4[16][12] = {
    {-0.40767497792524765, 2.7508651805310484, -0.5917340340750465, -1.5033121447967377, 0.3619465425516237, -1.1090854636866352, -0.3396829890156324, -0.5103311517946733, -0.8866214198125207, -1.0075160657519011, 0.13190455375258006, 0.5824777623969047},
    {-2.4890570887397847, -0.42089048671073326, -0.08015424751887612, 0.2189561446438051, 0.18225683944104515, -0.6580523210239545, -0.649566632554091, -0.06968667700671334, -1.4785223766535494, -2.6940279468072927, -0.9458041472402554, -3.0145510795045274},
    {-0.7581026076272867, -1.0083159500202044, 1.6364730102772715, 1.0544497211941621, 0.16818902099919913, -1.0622709534132966, -0.36514337338940855, 1.3533205455303516, -1.079006639340497, 0.6867463629188715, -0.6265681989088453, 0.8980411773009133},
    {-1.0542478183414317, -0.6378980754353271, -1.214133280544701, -1.2890043245491547, -0.1931939828492319, -0.455966961525938, -0.8778879925535381, -2.4058637932083062, -0.3910751203552299, -0.37119502235370455, 0.9267395059756128, -0.9162599149135082},
    {0.34532328779030597, -0.8081700933052699, -3.037641167926251, -1.078199760492395, -1.4938261438833929, -1.8267686123152187, -1.5161407740654194, -0.9348389262707516, -1.9825002071919986, -0.7467372129748976, -1.5800350895814093, -1.7076668424330557},
    {-0.717048039171609, -0.9105706288556452, -2.753717436084494, -3.0064853810709278, -0.4104564007585358, -2.423180312218506, -1.5077831707621414, -0.8607342043256099, -1.2218042616471145, 0.4376348742366707, -1.625759901889802, -1.6536601153213994},
    {1.7455612806252772, 0.4121322846700244, -1.741061964723683, 0.5898831667195407, -1.4907330858411574, 0.17338411636915332, -0.5119546538460761, -1.135568703085893, 0.46762087625935755, 0.4141860804512418, 0.9212479068777527, -0.6156536016831362},
    {0.14599041208316382, -0.8113254152426994, -0.4024627292881396, 0.8514292309124555, 0.299817376894584, 1.0949609658063333, -0.23609825447238222, -0.27838532922038384, -1.2471196337686907, 0.23612187968207277, -0.004137350976331307, -2.166561312155275},
    {-0.4228396513741788, -2.727505881302636, -1.0450020658652435, -2.0818394223222696, -1.182579290626499, -2.919797553537341, -2.611882278137786, -0.7137095252312741, -2.296750958590303, 0.7813648317430412, -1.93559190802752, -0.5009529494900969},
    {-2.499668131475312, -0.8561572133322065, -1.4117478537410117, -0.5738625611489837, -3.321305474941095, -0.019229330240546433, -1.4083666626626299, -1.436186532638529, -1.8405825136081742, -1.0354786304549475, -1.9958103956425863, -1.3499805274594492},
    {-1.2587719832158126, -1.8188966152882688, -0.5920452390249098, 0.3787230318084001, -1.752538401118513, -1.8663087587664218, -1.4753393415344516, -2.423330407130151, -0.966345230752203, -0.7882488500544944, -2.670409076489829, -2.73369420824371},
    {-1.1364142174290008, -1.047759111817784, -1.0593652221831993, -2.875032690712086, -0.981436798399464, -0.8025958369772584, 0.2358227332752157, -0.893146099158808, -1.2453359268808273, -2.462282958403473, -1.6969128626484813, -1.4848947140995785},
    {-1.5224105612166652, -1.5941729888000287, -1.631617587709442, -1.9880244035081067, -1.6162807818536424, -1.086653610531586, -1.0958391726926349, -1.8044845272811871, -0.533038292942249, -1.296032467061549, -0.12308618981586449, -0.43058130985529236},
    {-2.6368016680372, -1.6341443088420435, -0.20124359708153566, -1.8059134449012044, 0.17306204695486732, -1.9904306013229665, -1.8620583385259324, -1.552232889475742, -1.1997369891258862, -2.1933325652765916, -0.9709648227077644, -0.11600803661829777},
    {-0.036236530100462475, -2.0469519829512484, -1.4523078526895623, -1.522805246025632, -2.040646983903498, -0.5769056962927707, -1.8565132309796806, -2.2576578492206534, -1.2477257277173746, -1.6734386261459286, -0.5917623533399071, -0.6865499741767246},
    {-2.354232641367835, -0.7504247878101661, -1.1823833261995025, -0.3441241268402998, -1.8598482045629035, -0.8001204149148528, -1.2186476771117, -0.1543314745501652, -1.6947888305478849, -4.123618378054334, -1.4408084740806448, -0.9869866908095957}
};

static const float b4[12] = {-0.8525416794341849, -0.7847335056734226, -0.8061157557369614, -0.5611335753463437, -0.7710549230572221, -0.8490196461119263, -0.809288438627523, -0.8053534144543665, -0.5730350530380178, -0.7805765482931762, -0.5420624330091277, -0.9141441322058003};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
