#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.2590224194008374, -0.0396202458476033, 0.008494778869885249, 1.030873538714227, 0.21637741176840353, 1.42078583326556, 2.24794431810061, 3.0259373659389026, -0.9852997866305582, 1.7114847839118694, -0.5234528456609467, -0.6083256174281326, 2.4593918266106494, 0.1435925099096809, -0.23988740774819498, -0.19441705673086407, 2.5455288998310364, 1.628221225660858, -0.115693439476442, -0.9484272113292523, 1.4635161565891723, -0.32278930297018754, 0.4151853370725822, -0.5755787565867551, 1.0810710764539675, -0.7951663281175043, 0.6549998349832142, -0.14276791782778245, -1.7989002504021665, -0.9036339235324676, 1.521182763580122, 2.007470651047257, -1.5956912754516068, -1.1940121245132007, -0.20411769540568475, -0.46052643042022223, 0.33069554953929625, 1.7468902110708564, -1.2459794160746929, 0.6666117034408153, -0.48719791002557733, -0.10589046024635679, 2.247638073225699, -0.5047068813931048, -3.083320083548868, 2.1088562112304174, 2.194797047212677, 2.356499225879024, -0.8657537862352307, -0.5650141862181005, 0.38869232233907847, 2.0335239939079535, 0.6023634139354587, -0.3784377086268821, -0.45419766850867394, -1.090060365749871, -1.1965510678829645, 1.5586941486620152, -0.6096788047889659, 0.6124684101785163, 2.2096605226084156, 0.7310356346720593, -0.8499139652560429, 1.0001146211006384},
    {-2.469571287455754, 1.7253367284568255, -1.7085925893375953, 1.312613199715739, -0.6953921902021999, -2.3216827531359527, 2.500041267321826, 0.8166219253345067, -1.7049253223276166, 0.9453054461663278, -3.018271995629004, -0.46858412694313534, 1.7858523874339431, -0.598345763561302, -1.7052493455222948, -2.2603703908533137, 0.009894202546765084, 0.006681316725467895, 1.6981181809760095, -1.8273822593348112, 1.341816126892852, 0.692484383851006, -0.9439358273181101, 1.4099271301158438, 1.4408545973707387, 1.1647672672620848, 1.0400321149772627, 1.0115149408329085, 0.8262076762964554, -0.3857516362457859, -0.027656074721038936, -0.05929401337982725, 0.8364918356004328, 1.4347430044411669, -0.5891948672503656, -0.8743522731526165, 0.3294478441898003, 1.7840865929962282, -0.6532098682838835, -2.2988831459362826, -0.061577107976964814, -1.0044773542825576, 0.9836045085425744, -1.405791091638629, -0.00405427823937353, 0.1550788321561977, -0.2977295553050222, 2.276262215102754, -0.17130571578254575, -1.2266196923392474, 1.8395997110883202, -0.4691975701339953, -1.5643840084735938, -0.9345255882947436, -0.8424315683829623, 0.22042779483432975, -0.21663117843488874, -0.4839403266630575, 0.7986696758593442, 0.7355563907604149, -0.08869923362880075, -0.9067191090518809, -0.15644295348349754, 1.3317786027272387},
    {-0.4676742939845356, 1.5662529700972285, -0.3489629554108566, 0.9752612255683022, -0.5358632305706259, 0.01932552637263007, 1.7002458483045337, 0.6584596254666281, -0.872318445415723, -1.6182969507862577, -1.064044920328902, -0.2411982640706178, 0.9227434333117792, 1.034782986289656, -0.7745225781749756, 0.6903502080268303, 1.6061976825585824, 1.0172857127344523, 1.3347634886652613, 0.11577428955543884, 0.8832365091981489, -0.5596142837069948, 1.5129251537907047, 1.6033542829117873, 3.698510332780887, -1.9281996453951216, 0.6346783194014504, 1.309708108833224, 0.8730482449566249, -1.1351882889203366, 0.16004410916166792, 2.8435796889386484, 2.883703082820016, -0.023668152035022663, -0.5847546132997881, -0.43422319956565186, 1.6180536589605492, 0.6302146330252978, 2.768718425659787, 0.18492513017869347, 0.37105862265131406, 0.5345914072280442, -0.1474189074490723, 2.0287511938618015, -1.098337605977225, 3.7025923320563323, 2.739802909852181, 0.8114611533963058, -2.096749085384843, -0.3291293692886139, 1.0014121991719982, 0.5431243994780691, 0.3832245195266026, 0.4708798540341759, -0.25404532950613595, -0.22325985477023025, -0.6632388992611062, 0.9829398669789796, 0.13251253845867866, -1.3465795640330964, 0.14670384364176253, -2.284380107194676, -1.332477665252611, 1.6677700884225162},
    {0.9809769132521483, 1.6609183332878021, 0.20114429616270463, -0.188185988164275, -0.9014050653217821, -1.134012323978057, 1.3270465710652726, -0.14632870456180308, -1.7103509100700596, 0.5795852272571674, -1.7518915416679315, -0.9439625924137992, 0.6393476800496236, 0.07780132542444917, -3.1633430011499746, -1.4837812511742785, 1.8239490342068496, 1.0019895340886056, 2.578521008116735, -1.3873191761147208, 1.2175324335868452, -2.884782334582226, -1.0337204914935079, 1.2709871209161447, 0.5316085931903897, -1.7874898518573508, 0.4731903897466396, -0.8445985622601064, 0.22846868309093737, 2.1937136020824624, -0.28537166066414316, -0.009786668309815932, 2.5423428643333867, -0.8257822638730873, -0.7524933259162256, 0.3524474796018937, -0.15580063838806338, -0.15877077333406905, 0.5417134599010505, -0.13220490253719558, -0.19411106998601674, -0.6846137933233564, 1.5530696434490416, -1.6616994424655498, -0.6833797603247587, 2.4864368124575646, 0.6840558463304942, 0.6097728669175639, -2.7988127129466767, -1.6277942858697074, -0.995764114301519, 1.76074399255005, -0.9519613021780421, 0.14339826015838059, -0.05952933570440247, -1.0969599564339565, -2.154034331371745, 0.7169055607042583, 0.08122250358503842, -0.24425153233984223, 0.17451748258989108, 0.11124736384316182, -1.9129523582170729, -0.3934679886863538},
    {-1.9623418702353408, 1.6444478394863715, -1.6317227844948479, -1.3778803642164232, -3.5894002091567834, 0.8792507394042712, 1.250587656762492, -0.774205401302301, -1.9037622743923082, -0.3760501559391883, -1.387518284028808, -1.144193437223455, -1.7926281137510527, 0.3542574731010826, -0.463780504732829, -0.2933643526040653, 0.5411443570120327, 0.6620376402048057, -0.5001451447089744, -0.25320468489282155, 0.6992548840535969, -1.4376311288343466, -2.279253076818838, 0.4152865281335533, 0.19186192344747033, -2.6572915443294294, -0.5517178042200022, -1.0558170925617167, -0.09741318829512077, -0.21466825569596876, -0.6807303654054397, 1.348535317670805, 0.7904541316973994, 0.397772772908342, -1.5412699755661157, 0.055769522850177465, -0.5049337484791523, 1.9975645773338295, 0.7844979198749333, 1.6137346378387196, -0.0003276377007604757, -0.29844468749990277, 1.9087939778175609, 0.13473869706550534, -2.670671180950585, 1.2430012534775874, -0.6843755056320548, 0.7939621367635818, -0.21028174245033818, -1.4095037535989068, 1.3895720828431963, 0.919138359954869, -0.2077983022091057, 0.31145863336049295, 2.9325475347123198, 2.1854185403754802, -2.2739515450683867, -0.416958686345214, 1.2425460959423382, -2.0470424805761556, 3.4217848005058578, 0.09668808640822549, -2.1055141442551837, 1.6124422497782602},
    {-1.1940419678859588, -0.4763349069453119, -1.5898826401616912, 0.8309864548466402, -0.9839142901941511, -0.9781509705807698, 0.5153033965633591, 2.5747081258168905, -1.767338689755042, 0.29766552440007027, -0.4953962287052513, -1.243502722876592, -0.8955329107880506, 0.40532693658585195, -2.445376522336656, -2.6297666618699025, -1.711308010410045, 0.5742844275612425, 0.32840665680506576, 0.8735562375678967, 0.38343264372554514, -0.26213555983802356, 0.9103615454973539, -1.6275533983795034, 1.6029713866270703, -0.8530819386706351, 2.3055329038636656, 0.9453436564588127, -0.2735290347458217, -0.12141881412414297, -1.4683280201908644, 1.473782393545409, -0.5760436158027612, -0.8275672983200208, -1.8444424898904501, -0.3095156693811567, 0.5650969165110069, 0.29431299162466856, 2.204427043921583, 0.7492948399643157, 1.144019531579158, 0.5949948945786617, 1.3212988063010107, -1.5872763151061577, 1.6568470891717508, 0.20973945363633958, -0.4004750739943883, -1.5981982236249062, -0.2737365310490207, -0.6283014340994314, 1.9736968961172592, 1.394708634641243, -0.5506953911325613, -0.038159765822114854, 1.8573999445559235, -0.49047095554357895, -0.9592050640060814, -0.05806008214303274, 0.5424478641406775, -0.4862223875390709, 2.515720323758714, 0.482971506887634, -2.7985213442551715, -0.4590260092787026},
    {-1.6622181191640937, -0.5868529141398796, -1.614539144097195, -0.06091390515827766, -1.3140018372538123, -1.050216228173371, -1.0150735067081396, -1.0431622528107873, -0.9904090023187211, 0.9448614683080968, -0.24977240005500306, -0.5399930341512045, -2.3345387403747466, 0.9701314196635095, 0.21377205646947564, 0.3939335898463725, 2.9738812653957027, -0.035826333504866074, -0.6659553888343822, 2.1348428585736867, -0.24005759847086464, -0.9418093605106024, -1.6194853490199985, -1.1075420604267767, 1.340825462873461, -2.046093530371455, 0.733174227606627, -1.824558534285274, 0.14430243132925108, 0.3520527887072134, -1.9558911282446803, 1.1496234978192383, 0.029344158773706518, -0.6954843722436654, -1.047586861347848, 2.8708818913129397, -0.1285528214098604, 0.16000860059922078, 0.661913457510049, 0.32449336132498136, -1.1994270882678864, -2.2180806808873847, 1.4152207293393957, 0.4177584682813263, -2.5604677449224855, 0.05809345050487569, 0.3779930188351818, 1.434037608873077, 0.22732260591084727, -1.4750780707252544, 0.04616018898482172, -0.634530951277307, -1.9538283768864493, -0.46080568617923845, -0.33341887975907, 1.8554931396179506, -1.8594578740954304, -0.6630629735276005, 0.5223528080162774, -2.0655041887389114, 3.4773109914494635, -0.7760613622524285, -0.4451649727192536, -1.9056605940424531},
    {-0.7314229046372527, 0.5048855224327696, -1.7600818521177275, -3.4084895611759514, -1.1717428895699407, -0.8982912911040647, -0.30388052849644615, -2.274070591410198, -0.22378065193681623, -1.3467178389409145, -0.9158773964930979, -0.9669497630917567, -0.35298007242150004, 0.24277997761201714, -0.9503403917497499, -0.7641435350506667, 1.350461460175825, 0.44327552325529773, 0.4841181583072329, -0.06865988356063796, 0.49197987252053005, -3.223415689930266, -1.0705549307319286, -0.5588621407179921, 1.649529101889193, -2.199595883442006, -1.0814731670926248, 0.4080449117035773, 0.5156543965491746, 0.4872091500201417, -1.0002750808896512, 1.1130409615597665, -0.3948003512958039, 0.14029245084782366, -1.0673120019235596, 2.0659931205932907, -0.4959713965321977, 1.3125577564087823, 1.7795536136066374, 2.0926984504318784, 0.044332608220409915, -2.4776721391218457, 0.8646464991598406, -0.0468753815360291, -2.5931925751753404, -0.2527692420929246, 1.0958050641054966, -0.36123210276888285, 1.0800626033535388, -1.573426394334991, 2.706479204180951, 1.1992917222090735, -0.18602282071618428, -0.8878177211210432, 1.1666701591327509, -0.8178377570785687, -0.19555012865982438, -0.710273414145927, 1.406181017054042, -1.0276945374872555, -0.13366094795437286, -0.7294413391070135, -3.0832477770402464, -1.626199924839139},
    {-0.3580420091664199, 0.11352878305964356, -1.6461641676128993, -0.39916325718013285, -2.257946286283319, -0.17595338289271784, 1.9327162689778292, -0.635197481554484, -3.1133736918038672, -1.5010340564395799, -1.1672116189469943, 0.49452302379508667, 0.2222205190704797, 0.8014163140973564, -1.5412036860528708, -1.6205591081412425, 1.0273402657770518, 1.5521366980767939, -1.6107446578689235, -0.17831815617506444, 2.4791143128231092, -0.9245026086069955, -0.4807327922912882, -0.6754198209223159, 1.0089760370491727, -1.3177176737509915, 0.05574528383478982, 0.23383959518029984, -0.8665177185209608, -0.11570995996660108, -3.1140174528070332, 1.4945389560536442, 1.5363808620680568, -0.45079703858986037, -1.9868182401608294, -1.2751573581775797, 0.8328923390779392, -0.7986320655016588, 0.4744634605327935, 0.8565342430626014, -0.3626453288538637, -1.2020480689173552, 0.2253975897336495, 0.9669642160575275, -1.439583158025226, -0.9005778163813298, 0.09549702677167354, -0.012469274707436175, -0.752482648495801, -2.808855740311436, 0.5465484131666986, -1.1558365002125162, 0.3112020089139259, -2.456391700495376, -0.3277965740239982, 1.2535715107634953, -1.020784809053737, -0.4937308937090671, -0.4288580466504472, 0.06738410417501327, 1.944791665295008, 0.4410124156530381, 0.5587695824615219, 0.8940149620816795},
    {0.790043550683216, -0.028056552468050593, -1.9910597668882106, -2.159052672488628, -1.2936697739184506, -1.2835888076949467, -0.04923000745721115, -0.8469463999530472, -0.7254473441797495, 1.8862359637587305, -2.149863521822221, -1.457210043153077, 0.4043765563167313, 0.8775216954585403, -1.0107953067792195, 0.8429028850058349, -0.03272721343811529, 1.4068735076806713, -0.505984765410392, -0.872658427723332, 0.02938023303838445, -2.581784677127524, 0.03626829903850759, -0.28073657822796017, 0.4551234689099981, -0.5607751079609793, 2.2714528503572073, -1.1475672773893555, 1.0976742573869467, -1.3959916942715778, -0.6565264948435929, 0.7308411344476013, 2.2012979265641386, 0.032205323144077716, -0.5072377269000894, 1.8172259745944135, -0.02512765804414818, 0.6447510932395094, 0.5352943193746625, 0.2794004587999077, -1.4724986323061382, -3.1085878457003098, 1.7657220741030284, -0.12861187930981618, -1.2043972750124545, 1.0141859022850017, 1.6990587257907257, 0.5695841482238374, -1.2008134446740835, -0.4735344571073734, 1.3623228657884798, -0.13478003474524072, -1.7652388377593098, 1.1694324800319809, 0.2200665538779679, 0.12940027153405892, -0.4570821608716386, -2.076098481244044, 0.4386774149935645, -2.278979916419667, 1.0303111413381627, -0.6437675553760633, -0.7422286322528127, 0.6519602737872593},
    {0.43081708153874554, 0.6392048645253517, -1.4217922990540512, -2.628982970937612, -0.5808799964910671, -2.6471388450800517, -0.0661743669197201, -0.20968494814401017, -1.6752641373252608, -2.281670553600571, -2.034468197624704, 0.10647734316342031, -1.6836248761818102, 0.06718107821644956, -2.5583515759381354, -0.4166459064358355, 1.5906396316176163, 0.06844318793853535, -0.8047504289308657, -2.4625484585508923, -0.10264212848248891, -1.117189949128472, 0.30737370554358673, -2.0289707253896863, 0.5289781820881666, -0.8614054976496591, 0.8729296654113322, 0.4524674514027001, -1.0914894734927258, 0.15291791984267025, -0.520300660169792, -0.9422487401034516, -0.5562463499250949, -1.1424417043421602, -1.8100342862948684, 0.6608339412284338, -1.6074249178316513, 0.8477083167855298, -0.12203034363867642, -2.113205682351627, 1.956723632995268, -2.1957298179425124, 2.0200775728007034, -0.5141690535600101, -0.8036392777832841, -1.633694711548848, 2.277751404439337, -0.3308514206633359, -0.46904427690332245, -0.3040747604831055, -0.4105817161551141, 0.4680702991777394, -1.3147024538064764, 0.5766685308033652, -0.016347937702965977, -0.2686762706551819, 1.0883297279565423, -1.293826994697442, 0.10301312756392583, -1.2291197274262866, 0.6679675241372758, -1.5948641648076378, -1.099786760602289, -0.22333180350872195},
    {-0.9788236138609574, -1.201884770491338, 1.153779279124762, 1.2639945025006605, -0.5834746112779661, -0.38319117581456424, -1.233422843186433, -0.29558841250250445, -1.8753124425523344, -0.8938051563588538, -4.763884713219037, -1.8902812275528156, 0.7361270506232825, 2.045160982275298, -2.2289633818206918, 0.353725763943486, 0.5507271055133697, 0.5614921961650776, -0.21389261019104397, -0.06279084958803026, -0.7174473046459201, -1.0519666209607872, -1.1332200634949607, -0.2018414663623159, 1.58139149211283, -0.6053408092796814, 1.1915114267400868, -0.651937798534406, 1.6448799306630377, 1.5499955937989185, -2.228477745979913, -1.2448560364721308, -2.2138196246699526, 1.4259090141705586, -0.8223250421512975, 1.695208119214009, -1.9825667667628526, 1.1867569396236681, -0.18793017080920088, 0.539005682514338, -1.7397494903720625, -2.1729194580921596, 0.45131078477334824, -1.6435602314447446, -1.2367937132412412, -0.7604798994194326, -0.2201493162876321, 0.4577861644961931, -1.9033189745820251, 0.22760850438336175, 1.292563343393552, -0.2893381638442567, -2.4295531813470364, 0.9605162488050881, -0.11163398210551957, -0.15784306604739023, -1.1298308453557855, -2.2950214153476645, -1.374437520497121, -0.5550381160924803, -2.6822107716379073, -1.9974552531214385, -1.355968064042842, 0.6001780937450506},
    {0.6773871423762047, -0.7628459962605564, -0.7100291979064483, -1.6335677912188258, -2.947684472470229, -1.9688790373913239, 0.22547853680895302, 0.11415656397635242, -0.9193921624698057, -0.07667644329780535, -3.0149898224881055, -1.6073627876128203, 1.0203284100656684, 0.5744716877064028, -1.419332599173755, -0.9456326780748495, -0.3951687806920838, -0.07717206384465802, -0.7890347915976124, -1.4301330267877472, -0.2055689506436964, -0.4050533793156711, -2.575938839895399, 0.14842670778215922, 0.21592669651197932, -1.0365664040626923, 0.9046451810794264, 0.25717489110360886, 0.09641525549746618, 0.27067929562355864, -0.9394587451019283, -0.7788140592709136, -0.11027211544840067, 1.0710298566462455, 0.6523762418500224, -1.0639799782309125, 1.0751176972466703, -0.6012571677777535, -0.35722852024930024, 2.9581740273617223, -0.47566913061069616, -0.24148816597799366, 0.46381871370497596, -1.0510635328145888, -2.3084164862961405, 1.5720602281938914, -1.7224301918194027, -0.1762959124950185, -3.135875027569242, -0.6786226199865656, 0.6155583685930848, 0.025763263722716465, -1.0672865794102426, -0.22582317987978112, 0.36174287745753286, -0.5697583654568156, -1.6067211214980086, -0.6307809256504192, 1.0865681206436337, -1.0653063792671775, 0.02231087611287543, -0.7481153565793185, -1.1141801575218253, 2.742736530175905},
    {-1.6016127437358756, -1.9353176332847932, 0.3774820070176466, 1.4547415970576862, -1.6729720461059125, -1.1482364868928718, 0.261434172452641, -0.7701181956146798, -1.4218773064245966, -0.844917178255849, -0.044659945684586276, -1.4197941299102241, 2.2209335138030073, -0.006252359142765343, -2.487242972471489, -0.3988110295332136, 0.49913888902713477, 3.3236064987293212, 2.7181155199695226, -0.29235861038481475, -0.5912064114905241, -2.6314104216537264, -1.3106687410388487, -1.7513031292612313, -0.6686164489676896, -2.998816149291368, 2.1276552030907436, 1.1640059226887631, 0.09092887794863488, 0.33280398563034436, -3.021443129131586, 1.4274995081604704, 0.8367403517036391, -1.1276126969634799, -2.6194790483454327, -0.3187780429996637, -1.0132162330527432, 0.28955096176905326, 0.33189893424722, 2.664564115503447, 1.726308820798497, -1.5108061256455156, 0.5458936759772547, 0.8336907040580004, -0.7027680807348855, -0.12505951391183662, 0.03133317733317705, -1.0249530195373617, -1.6538763309254727, -1.3956779650681335, 0.528837156909378, -1.0890116084710455, -2.3909782187004174, 1.1627573686468171, -0.9566426378820154, 1.619009357614402, 1.3020719232543057, -1.2375041567496563, -0.5542530577830086, -0.6355537401346604, 0.8697652249367759, -2.7060038823654886, -1.861863817901566, 0.45124944170259396},
    {-0.5537103099010534, 3.8324742964069896, -0.6445639599670908, 0.040703092919265764, -1.4648623271059233, 0.03574460327521114, 1.2659848090144392, -2.2313229267904777, -1.7938045595007173, 0.6447435515341757, -0.15824300910848785, -0.8535966801692552, -1.0849090537053343, -1.439924902570886, -1.7671206036503, -1.364012370899104, 0.3281623025554029, -0.192989732356676, -2.0266937952488147, -0.1997608451208488, 0.6508697582824708, -1.4917023583798263, 0.31415198673049854, 1.0257569183064554, 0.891978612145391, -0.4509846994406227, 0.8251450613097496, 1.8359500907735353, -1.7012278702779224, 0.6721013063861104, -2.3558454242773426, 0.03685459803951634, 2.6053160364274452, -1.3376198262618253, -0.5727763047300651, 0.7999123587026625, 0.5775932916918719, -0.2264987733144034, 0.016944635230302738, -0.48778699521115826, -0.6536212831801838, -2.090298994877573, 1.8369417272874173, 0.18274188503703484, -0.803443219476083, 0.8209698568904791, -0.4926689955966866, -1.2579474320401542, -0.9769378415889649, -1.2713375839307244, -0.3176175276182927, 1.1446152437598291, 0.047451085319118236, -0.907300699571191, -1.0867045319892403, -0.0997279501202457, -1.161129018631455, -0.8950665425868447, 0.7966427011402515, 0.4232183354429043, 1.7969276074643035, -1.4014641316338714, -0.8374827976776138, 1.0693737428955068},
    {-1.1914790282622891, 1.671295462284858, -0.22839336050940437, -0.7670827775708103, -2.050791436287826, -1.822359006139019, 0.8116595921319639, -2.0532685919735796, -0.22038673896431077, -1.6641459250036998, -4.499367933389347, 2.428709051873363, -0.6226012305989588, -0.5173952189080874, -0.8111694640618787, -0.47632037848165426, 2.490290335770775, 0.3688163180990174, -0.9121111603979158, 1.27064361791037, 1.6109947988528501, -1.6839570772604626, 1.1296910741156856, -0.2676037480321445, 1.8617836758116673, -1.4883282131020832, -0.009698767341207294, 0.6136660941291279, 1.7266745252773938, -0.44745231647046974, -2.5972738176105192, 1.4508591813558545, 2.2113318417321404, -1.2670376650443855, -1.6199600191071009, 0.43755256453027197, 1.0627367450400271, 1.4617045896855272, 1.5689511064310022, -0.5868863997443289, 0.5263221531640597, -0.873071480126525, 2.035724166179412, 0.8505682639337585, -0.07850323345502216, -0.17466742892960235, 2.0848674588315075, -0.06829353244254885, -1.2977423975052869, -2.572755298284047, 1.242293225054152, 1.6085593607965225, -0.4648676850632984, 1.0091941462832805, -0.044030590772828726, 0.9624356943934591, -0.5903821873947949, 0.1185651490585263, -0.5002424499698677, -0.8343007831414019, 1.5590777295049736, -1.0526113563226231, 0.13124179572835915, -1.4926684077735306},
    {-0.7609145923077051, -0.2705040141573679, 1.0321790365462784, 0.02438559772472445, -0.320651310491874, 0.6904436829963086, -0.7192507750845604, 0.2428257817009187, -1.6361762509704263, 0.9672521416378798, -1.1321538925478407, -0.02550496507946379, -1.6676992731244773, 0.24798383341921146, -1.5628104720095943, -1.9540224734759173, 2.514036152797576, -0.15336938643705264, -0.07842648949667008, 0.29617771572917484, 2.069501449091164, -0.6798253383166167, -0.43501127757614255, 1.3660012725058313, -1.520366725672162, -3.053068008669787, 0.7107743806988721, 0.5516589884025093, -2.713247979463592, -0.11510091627359192, 0.14214915290677158, 0.09455421033001571, 2.5145206394686155, -0.4738012977499092, 0.6928308308159324, 2.112228625691494, 2.241836861719666, 1.0093069908434797, 3.641711892998403, 1.3675896591227568, 0.2652599822627637, 0.8238009823729476, 2.660370918969439, -0.22999459233185487, -2.062751889259512, 1.3600585801783271, 1.7155973353814122, -0.151057781117765, -0.2377280167476026, -0.4766798229542058, 1.2676597968011545, 0.5961356387070628, -1.9797546600012832, 0.9925832673362002, -0.27020348627294516, 0.13890927733422076, -1.0108942740520326, -0.9521018335196128, -0.810746809796163, -0.3356644187254528, 1.049748616938408, -1.1741495454924193, -2.2149576271233657, -0.45167242840266586},
    {-0.28515215817503625, 2.005785022060188, 0.4209619110207726, 2.3704517865173993, -1.9490600871400936, -0.5431977589435593, 3.1537767436493818, -0.6482361092556447, -1.6429042477269415, -0.6731039691648365, -1.6693104105288383, 0.0338155786825646, 0.9679263636307455, -0.4245167211073216, -0.19430974875609702, 0.5992924910666564, 1.6947753724189702, -0.6311059015613207, 3.325945815790818, 0.12611244336490865, 0.46585575744831137, -2.207420889116698, 0.15836932964611444, 1.3750233572823052, 2.1822408547876786, -0.6793107977643791, -0.4811238609977358, 0.9491462373235674, -0.1099636142750313, -0.4597309981874734, -0.1658695164196214, -0.15116385464698356, 0.7358310160929873, 0.12276159714457724, 0.2714255068295278, 0.6187867915077528, 0.898217694434522, 1.5612152490743223, -0.26247471720256893, 0.9301866001528626, 0.38846997843904035, -0.02745880697842201, 0.516023173188626, -0.27136008859260213, -2.648432727720326, 2.643593778323043, 2.881462367577339, 0.7149540400719969, -0.21776029159941063, -1.1813454242825938, -0.6885883932319696, 1.3382414011276715, -0.38383417517396623, 2.233006836054077, -2.7817617848767915, -0.06929550502509757, -0.4036283926761012, -1.1945547226534456, 0.44930358713382185, 0.24722995064953177, 0.5416187714548678, -1.3327744790131864, -2.412490729823447, 1.1592514368218036},
    {0.960785450161781, 1.0322320628963637, 1.4484240772397532, 0.3835088465362448, -1.2648064086411686, 0.16092680463714967, 1.0889403771811714, 1.2132449328509756, -2.695623162021968, 0.5564943928915727, -3.0714120582191735, -0.6836836522133313, 1.0546232606287738, -0.7295374302113183, -2.6681938101709664, -0.5064696026006595, -0.3451086191866064, 3.592001347727848, -1.0765556768969886, -1.4716738803882978, 2.4764744297509758, -1.8222737881772175, 2.0411556245968687, -0.019044571440410916, 1.6162184126868553, -1.0754395895973718, 0.6992754604244021, 0.3887563865599152, 0.5553960437474385, -0.4455098569927043, -0.1895034336481523, 0.4401877264815658, 2.092955235467877, 0.4882232794820419, -0.04002063920273807, 1.2876750536398935, 1.7259808224815902, -0.4929228300577635, 1.9854945710454677, 0.8128595716781166, 1.8297965035662966, 1.4810955465408113, 2.074330664518039, 1.7061942198231168, -1.2391261244648402, -0.02873803246929865, 1.3598767534679488, -1.5690066448237225, -0.9364383664585726, -0.030615096525762397, -1.243536710458928, 1.2179643129603375, -0.3531383058781817, 2.184072785802079, 0.14973420739223528, 1.4676438939613958, 0.3551686689192642, -0.23874832986509187, -1.2136203799267695, -0.24683021887075346, -1.4617758608288747, -2.1239934941338916, -2.0424655330462897, 0.8330953954448812},
    {-0.1405987434583589, 0.16452689164644063, -1.2490788868947706, -0.6102207794360824, -1.0333200972404786, 0.9414486012300203, 0.27443399388749234, 0.06016119328431657, -1.3066137204220662, -0.1085527073838394, -0.6832108819456978, 0.22227640800427637, -1.0511467418709701, -1.518165352841707, -2.3592993404317784, -0.06765790952910107, 0.4352814434807715, 2.2518140891689873, 0.21012450333513544, 0.7997431221769699, 1.7642502617091658, -1.4933677077109684, -0.06709880891825189, 1.2224608310542546, -0.04398308043727104, -1.7224678203358645, 0.6993682261511464, 1.8289982376273497, 1.2771481666502957, -1.622931430236469, -1.3770338080750397, 0.2495333868081677, 0.8340204718328809, -0.41876573462421773, 0.0066654314555361525, 0.07911733458354704, 3.057928970822711, -2.3079829271302987, 2.3734764385426295, 0.5410795976177648, 0.0985635273191827, -0.7157892343599126, 0.7934468819254273, -0.01778232576525212, -0.7076146252357309, 1.4173693524761708, -0.5879280263085547, 0.9791502690361675, 0.019701032964201864, -1.0953047242580483, 2.2860909173004607, 1.1644320056891813, -0.24170896751211746, 1.018808388360886, 1.9898495287902571, 0.36746985797240833, -1.4251953808809985, -0.4553761121973828, -0.04679781565387208, 0.36667318486893263, 0.9196311243190303, -0.7012204762252822, -1.0264179090408234, -2.469967875372063},
    {-0.8502124561947774, 1.1877015169472696, -0.5429548260394761, -1.3671339957470972, -4.2341158059314346, -1.8949103539377803, 3.0038379779547673, -2.8992705282439295, -1.9342306616129596, -1.2252854721257678, -2.239140628566967, -1.44071212490165, -0.6774687459421992, 0.17380355454677507, -2.0317857022488734, -0.34178799168604923, 0.05373665074736838, 0.6702530302608198, 0.09837185329968424, 0.3150073068901555, 1.926935421014017, -1.959026460519009, 0.5747979416603528, 1.920611638543181, -1.4171667748933334, -1.193621766793954, -0.3565603917698549, -1.5970140789550018, 0.7885002712299164, -1.3842994347818132, -2.6109655052734517, -0.5505653911595311, 0.5883110528174325, 0.15519184739455982, 1.229810377864578, 0.6111769916677618, 0.5173430343817624, -0.9186702815775138, 2.3332749350672697, -0.5045236171783947, -0.4088773380137625, -2.263163401920368, 1.3376987348137197, 0.30464174685500883, -0.24221896405515803, 1.695825114425038, 0.17654979303540225, 0.4637390383257289, -2.1507294207278025, -0.4916903251753197, 1.8443670599286321, 0.21867214832501078, -2.197869275227791, -0.808572283095694, 0.7707237089120954, 0.58154652697602, -0.32460725689088504, 1.073601822543542, 0.004264194757331339, -0.3507981109059544, 1.6436909440291771, -3.4360791583519013, -1.8427639176224735, -0.31250139913931746},
    {-1.0731661364216551, 1.0169955654874432, 0.46289012238945926, 1.1712587645271286, -0.6524693396629412, -0.9056801561341875, 1.9885722396917258, -0.6146077619290937, -1.0659794023523452, -0.9525432189439939, -3.0202513791571772, -1.088285958014537, 3.0317217774627587, 0.018767745455429263, -1.9680830211578042, -0.0942016211172354, 2.4440253618188956, 2.1810075888224363, -0.34530148991617804, -0.5412208121601201, 0.734699404521683, -1.7089671223192904, 0.8041917611202762, 0.31472367939364004, 0.9739766167125112, -1.2871521576112899, -0.21763342822319695, -0.7166506701415698, -1.2963125541711762, 0.4405422880665349, -1.82740162812602, 2.954457015927248, -0.0053405188152212965, -0.5382117873555669, 0.08064615543411877, -1.0144486873932634, 2.848495250615244, 2.336557486470974, 2.6209690375340444, 0.25455809766311915, 0.4271439357433134, 0.14721888425372626, -1.4781865881105518, 0.44549282035600746, -2.308902122701756, 1.0673126137551858, 0.8770684009061245, 1.206327275784624, -1.5422960114299378, -2.0068173053860994, 0.7230144739987989, 1.8734452206284566, -1.0342458862912578, -0.23583877611297388, 0.036730434167384945, -0.3203941040095869, 0.8809838331751989, -1.6570746166012729, -0.48132371009330477, -0.24175271599671166, 0.8143477535879646, -1.7829276298587855, -0.7153038920174305, 0.7869149357103004},
    {-0.16649229754484082, 2.4343460384532745, -0.625929234921616, -0.4904253404237616, -1.7218431704094834, 0.5919051733881776, 3.84704742694228, 2.8353622770007774, 0.191387864455336, -0.42873544210508174, -2.757095967463445, -0.8971914162828496, 0.987729063264408, -0.539177856371653, 0.4284854075112452, -0.07120230946192072, -0.332352660120691, 2.704361938820545, -0.07248859892886228, -1.0425494412813996, 3.706952547530423, -1.8413649831141254, 1.4049994748441537, 1.0022174302676627, 0.756740916809884, -0.550521777485607, 3.054694067934441, -0.47066568153764304, 1.5351353389338582, -1.1945998517553869, -0.2886228022734751, 0.29571378254148517, 0.45826732471419207, 2.487006332252616, 0.09837919958443396, -0.014036108510233949, 2.6748974293642176, 0.8426429397803797, 1.1321781119310577, 0.4319101381613211, -0.0200389504823065, 1.1620744531671625, 1.2693840809453083, -2.3360010359257783, -2.0341227996766613, 2.4285204436046506, 1.9897300685876305, -1.1730166176968495, -1.6502258653310757, -1.9441226911949538, 0.7047661954876964, 1.861262184581508, -1.2479541172841304, 2.25513152505026, -0.5316282830777062, 3.266365857353867, -0.14373499837375844, -1.8696389422439665, 0.3378638950919209, -0.027681070343024815, 1.9739387864619125, -1.074681856925443, -0.07272710519495883, -1.3295201897110709},
    {-0.5380131685780178, 0.7720779210053743, 0.1902372554011681, -0.3246046766444893, -2.1011460408425013, 1.7390087218784702, 0.17049167349639394, 0.3974141940866544, -2.2304610540849645, 0.7065045395529155, -1.1054216321449932, -0.6577251998583435, -0.8119099020814058, -0.6693036595146717, -1.5293460511807473, 0.5218287360864502, -0.019608368166013506, 0.572640689873398, 1.3306407430459657, -0.9246865548127136, 0.8822406636952115, -0.5533687615147299, 0.714711057577621, 1.3289192193539798, 1.4142723852148376, -1.8463753705033417, 0.019844244246010615, 0.1803030963719899, -0.1977606462036915, 0.8794134123974907, -2.408556241633971, 1.9350010708104197, 0.15331336670162088, 1.2140828015029834, -0.9303879438789384, 0.25004293091217084, 0.30080119713474535, 1.5166494447492733, 1.8921317839851517, 0.23837696357242552, 0.7784260193145593, -0.19485366197898624, -0.05269550654048582, -0.37052390828026993, -2.340879597540177, -0.5342307622270108, 2.520716255952993, -1.4622082269039003, -1.1367124304978096, 0.1834450320865107, 0.815633814620573, 0.31056132558279653, -0.0043349236334784425, 1.7121063113520365, 0.2702978764373072, -0.46985369428875096, -0.6904795467722623, -2.3571657905339514, 0.8165447154522519, -0.6990270238795796, 1.830695844549442, -2.7676304677695205, 0.19725912250793462, 0.2927835165219272},
    {-1.8549125217098785, 1.1515366797631927, -0.4936426531386253, 0.021845890236173334, 0.23008562072354818, -0.35127084217840365, -0.16148514785970378, -0.7553320060069465, -0.30661020630073194, -0.2010366188835664, -2.690378364380261, -1.9004728132114388, -0.9508677305793636, 0.16936205466525184, -3.2411292917347567, -2.124558660859705, 3.2392390782936147, 2.0806801226541576, -0.17843300250699556, -0.7923118375328684, 1.8442708289512493, -1.2917850298258307, 0.6967525489949508, -1.3070698287892715, 1.0418459620800036, -2.5265800194543266, -0.7866448950597501, -0.4713428097189297, -1.0961627780315828, 1.7247412154191244, -1.2062573630130349, 0.38404884805182615, 2.1053722955501066, -0.13754922087083374, 1.2328093812140324, -0.4166544229844277, 0.012175204505978017, -0.017617217305735972, 0.6420717354530088, 0.1442870166378981, 0.788948198441996, -1.2995274467299582, 3.4854441936265452, -0.3788679054900739, -1.524264336457387, 2.226407168657009, -0.2671182811679485, 1.0152841904196832, -2.8105027652479317, -3.0364381734787065, 1.847522103004235, -0.7051660309352111, -0.7885198241728323, 0.41735736752851943, 1.1692933115129176, 0.7445148161776021, -1.4495806861806528, -1.6301938283319357, -0.22882309820489763, 1.3001455721318351, -0.31601972521561067, -2.8650050897250585, -1.4388465102127417, 0.4835459209192402},
    {-0.7627201469204324, 2.6290831815636184, -0.3713141003750109, -0.04620651475051644, -0.2895226378725829, -0.5797868697652224, 1.2847118044571801, -0.7857039617155362, -2.2077541628561606, -0.20815080763333205, -3.26632170871347, -0.25433773135729576, 0.11723066159182503, -0.4809393787741788, -2.0383671532371475, 0.19700972352048565, 2.2390550926093518, 1.4983779200302147, 1.416237865390195, 0.07088956836879079, 1.1313112251782302, -1.714364794239023, -0.287738381321156, 0.15312587373129344, 1.0623418469058108, -1.6796399332418752, 0.9103990555363421, -0.7930987118382445, 0.1745859930020695, 0.19529423326773554, -2.605024370343375, 0.8163616747383909, -0.09204445861111375, 1.0348525822699817, 0.23234049066581508, -0.6540686549183025, 0.4404234029319354, 1.9736583305563642, 2.4656616595049825, -0.4195825978632755, -2.5754503138089726, -0.33305093516498724, 1.3779486540383024, -0.8590953653629757, -0.13543786580837544, 2.7122848921715006, -0.12874266988047525, -0.4073243765012788, -0.1473166762645289, -1.6642023027061985, 3.0493060863456023, -0.6404457323043706, -0.8246280362265243, -0.5508544128446345, 0.48477884563246865, 0.2914032028992662, 0.9974571776721342, -1.75379519460293, -0.39383046458360516, -0.7143520931301313, 1.5541387465013456, -1.4349792098252176, -1.237326400360636, -1.1275305402423434},
    {-1.6076215674402745, 3.151892572766079, 1.2631212612533433, -0.28753728271210754, 0.36189223985063534, 0.13016031911147372, 2.4940301099234348, 1.1993276790837888, -1.5013951051377294, 0.761120772673883, -1.933847103552392, -1.5508677590861242, 0.4639072507271032, -0.7355528049774841, 0.9016872249965089, -0.4119121246490613, 1.7715338722144227, 0.8077541584304475, 1.2672735839202134, 0.26982545052857937, 3.6836153303537933, -2.088128156815847, 2.594967011861817, 0.7060004170146456, 1.7821253904980232, -0.9910657833107567, 1.4444487161346111, 0.6843238823833021, 0.7874765637190901, -0.21589392637290325, -1.3936446090278978, -0.9192288728797348, 0.7395351018310157, -0.22248860682711585, -1.0655030922710365, 1.6227087270829483, 1.1797232743625665, 0.1996525089977835, 0.5782744310988844, 0.5626487427326227, -0.587451253392096, -1.1040652791405852, -0.11014031644794002, 0.01981348262634246, -0.2406735565953321, 2.4980084759723034, 1.0847818971677354, -0.9939020046907704, -1.3947242799307153, 0.4125538022987967, -0.3076262751616442, 1.4449987763434142, -0.29514005080320665, 2.0510396250095506, -0.8177424838714789, 0.5087638348478322, 0.12048237481458567, 0.3275932299759391, 0.923892206610954, -0.29081463736935903, 0.9881998628591557, 0.8001666403966621, -0.037435826378829404, 1.0224587735132178},
    {-2.648307499181724, 1.6181782141231928, -0.8339235039872944, -1.18703136707467, -0.49076203813926106, -0.6287079767022805, 1.2555156606004703, -0.5750398141007664, -0.20224179663734995, -0.463326994095896, -2.999514475127796, 0.129149061529969, 1.3400681364227696, 0.6428806731052881, -1.1601825687894662, -0.2179164103220734, -0.1951214399413418, 0.15026184940663026, 0.46035824823030347, -1.5894363770778244, 0.9755259061657661, -1.3103101067846097, -0.14112935288417386, 1.5361779304507062, 0.6374993671744964, -2.522219804720807, -1.7997922588604334, -0.620150400072994, 0.09670898224804125, 0.6182084561616642, -2.0634526460800955, 2.3413437533567993, 0.2565752764418367, -0.038557346483016355, -1.3539709886512845, 0.22613981687451679, -0.5307104199340973, -0.7879082651439971, 0.7308273317063799, 0.5657263053273845, 0.6448487981657343, -2.511791925274889, 1.899823553506601, 0.9058410324096063, -3.5329655011968226, 3.221585718643804, 0.8224369896551412, 1.069324546776329, -0.8357684217681599, -1.1092110167764382, 1.026650332389078, 0.720502498736138, -0.8741410343028654, 1.6284375634892312, -0.35884545695679576, 0.027717670398973594, -0.881278842066368, 0.2226296519193453, 0.04760271323103238, -1.787950159315819, -0.39031337380975606, -2.184984565773337, -2.229650230917799, -0.8485815892536327},
    {-1.6680107593542857, 0.1476899048575121, -0.3906532325914548, -0.10322616713140884, -0.856218681245575, -2.5150848432978794, 2.0700103167808295, 0.704294646129661, -0.3361784014060071, -1.0226281543632738, -2.097308644046347, -1.3190192698666692, 1.1543518824444314, 1.1205373544990065, -1.4098418312337293, 0.6369697958637767, 0.8685190777562202, 1.373784263414328, 0.6432492813621858, 0.2147427095066877, 0.7525263161896699, -1.4700505976029736, -0.1723562900713937, -1.0882735956426257, 2.5784670239230976, -1.8390393975492287, 0.8589815632387718, 0.37020561448969247, -1.402256411985299, 0.7112653346325088, -0.04201146383769019, -0.41828729162990314, 2.886103689329628, -1.3494975006354264, -0.8277049250021488, 0.47953813244744636, 0.20773817944056025, -1.092114586553613, 1.5791732212916025, 1.6532783026631899, 1.7982757672928793, -1.461931132507487, 1.4755011134299658, -0.27616765122188824, -0.8880122934077056, 1.5231303800018097, 2.153910746801266, -0.8386179509241211, -2.5581205054687506, -3.023844424268421, 0.15289799484100636, -2.302384822697265, 0.6618164812242368, 1.4502146424761182, -0.093725493927503, -0.5165522362826982, 0.147245266135447, 0.26752901529375683, 0.06816605051657015, -1.1101494848917361, 1.5646300722518038, -1.2450026298555346, -1.4595750753097994, 0.4281765992805398},
    {1.5224132026086847, 1.2900072175525659, 0.5888320734600259, -1.490114386357145, -0.4672293600322617, 1.1618789750321703, 1.358948977319772, 0.5490344626301079, -1.725231893840961, -0.8053128782131329, -0.7962578438961456, -0.19348594532999866, -0.5971163606732933, 0.8345160205123249, -0.8061877119587555, -0.5753513083800077, 0.010514994872017054, 0.4854290323818263, 0.41880316785502647, 0.5008608423045415, 1.116627649056348, -3.1492068636211448, 2.475790231369839, -0.8822775004180178, 0.27267207436175606, -0.9095460217768174, 0.5604708512499923, 1.2586810614060366, 0.608339109399593, -0.22835224570192078, -0.1863229722582826, 0.46027065644198695, 1.2842031207531965, -0.2848655746599216, 0.8984154260479843, 0.43791793813879826, 0.3924439738702601, -0.03924923286729366, 0.707066192236279, -0.42319266771760156, -0.3820057338627004, -2.0806657665628747, 1.655396936256503, -0.4662194763101244, -1.8303026817071433, 1.167750752137784, -0.6818705291788875, 2.2974214968717512, -0.48950992424262446, -0.7924709943748132, 0.7129963236829523, 1.1468891120300468, 2.432978169771342, 0.3999540539127405, 0.20804556643926098, -0.8139229571505912, -0.14094204770633242, 0.0257627710599262, -1.9387623840202386, -1.2566254809982296, 0.16422731858603637, 0.3375123724478131, -1.8757772730975408, -2.186846028379362},
    {0.2126303657899893, -2.1297892945034613, 0.295188193046123, -1.584251715478137, -0.4957442116557488, -1.0880264169748668, -0.49256184728689445, -3.0297553702260287, -0.43026783258823526, -2.643760691314494, -1.3999653903641813, -0.5965311286040034, 0.36073637879304193, 1.137869792346446, -0.6217192523927222, -0.26303329216100824, -0.8318624434760306, 0.05979279449730174, -1.0827644709762048, 2.4395297591529523, -0.5474918256053226, -0.5450114606809429, 0.5888386334960098, -1.9782000383801748, 0.9223246261770472, -0.09566969847791534, 0.7893155115329282, -0.8867304539722404, -0.18179324168541683, 1.3250859089618956, -1.4045448683954533, -1.413093298357643, 0.9258685708409012, -0.3719291896001937, -1.0577288765286716, 0.7288522502148601, 2.215986050121227, 2.2928270266778426, -0.2362669682798404, -1.2612340682682057, -0.07867500049388923, -0.7711936246453377, 0.43937997258007416, -0.2330203697753674, 0.4165525306102198, 0.04592119416208585, 0.3097199176452226, 1.0750191246352034, -0.7116802449944566, -1.0203950274442029, 0.20405429987309426, 0.17445445500007703, -1.410788704952472, 0.26274124244372676, 1.4435160932685382, -0.7906772122620954, 0.46467818515979475, -0.879401443382886, -1.3110679525835558, 0.1998710559819031, 0.25348222317715513, 0.5517546398999571, -0.5602838738187335, -1.4714834375630585},
    {-0.17934985472860554, -0.7663242589752364, 0.14160611102557674, 1.7084939150833787, -0.24199574942606783, -0.2407398540711635, -1.2853647792498124, -0.6081115501535547, 1.955784191764259, -0.16998811545783535, -1.1319180719976243, -0.8446161637309538, -1.161089550925648, -0.34728980523186237, -2.03653296456346, 0.7859539981591086, 0.7034340702587937, 1.6628381730135418, -0.39032316328502, 0.012063926965929155, 1.0043134443292778, 1.3609394926375176, 1.0142433421434829, 1.1819096743201307, -0.13884922572835315, -1.7010002008992815, -0.22983247411289015, 1.0204118820896313, 2.154538634230504, 0.8904278942687254, 1.7302533626599952, -0.8570868073988872, 1.225535372975889, -0.7819961794663483, -0.777685619902646, -1.5126279601751753, 0.45261761440480214, 1.3019361373698963, 0.47206798553601015, -1.0815419765119951, 0.33146531302708926, 0.8771651923534816, 0.4210538445270094, -0.2679967205120474, 0.2590533424432005, 1.908639577714132, 0.3821256181073082, 1.1422387384845416, -0.6350241808544387, 1.4385510237841292, 0.03509201406353099, -0.708575113390454, 0.3864094890239842, 0.9647346328898863, -0.1531266204939513, -2.075886219139938, -0.932938436371755, -0.2851015936987608, -1.394809047257586, -1.5821290436267215, -0.7223859830283383, 1.293587446743975, -1.0780429574205843, 1.4487895994238664},
    {0.897895036781985, -1.0305616223531373, -0.9072327870463334, -0.6670684461726614, -0.30903764824471003, -1.2764323439714589, 0.1078587857924677, -1.4592008374763032, -1.4121895498227641, 0.6549274280639218, -0.4136329309635834, 0.3906741691622622, -0.3605294453577792, -0.9526212110657977, 0.20633495487349326, -0.8122251619461898, 0.12158963395418713, 1.4202780150978564, -0.9771275931520245, -0.7494533418650813, -1.8403747845007663, -0.08126209593151767, 1.031797079493876, -2.581177777073997, -0.2724189739746788, -1.7215929504495815, -0.4688245456640782, -1.9663406325751036, -1.1234420286027311, 0.764544249298628, -1.0155381697958696, -0.8318569269705203, -0.8485933641614866, -0.14042274757539544, 1.1839227750995078, -0.8363880290451485, -0.023965917485745794, 0.9261895763098197, 0.2277234231134971, 2.5884713927102156, -0.5685767462137968, -1.3798640444995967, 0.7704872928675188, -0.26790667579382754, -2.379010568909913, 0.7444332221553454, -0.587755825212523, -2.670127596898079, 1.0314569508867157, -0.39736136988982773, -1.1640666854157322, 0.5005498593587784, 0.6089532626960963, 0.03250009116545983, 0.7178536265773199, -0.15975409296952642, 0.4196052587689793, 0.23928871329232096, -0.17080327853335192, -0.25766025957374145, -0.4792558165991981, -2.3313487651063656, -0.6922199593128336, 1.2540364737918346},
    {1.8558299787744967, -0.5566513661204386, -2.7033897781782117, -0.9774950532079101, 0.08961401878958569, -0.05038742010346674, 0.4391864965954703, -0.01587506606029675, -0.25106135493066384, -0.28266822083457765, 0.14286396980734437, 0.7044070910353201, -0.7826434945230307, -0.6339328554569001, 0.17981072705266685, -0.9192025945683922, 0.007521442941693476, 0.7133683114189023, 0.14932681350144625, -1.3053321231087134, -0.17080997428932418, -1.156097218442424, -0.12146423652958202, 2.2924277244991287, 0.8693790602268836, -0.44928142589193937, -0.5424112798089606, -0.7635938114595631, 0.24932470371946133, 0.9425991046827653, -0.623716936204514, 1.4644495565505382, -0.1329769626050153, 1.7507042416782228, -0.9540805932765665, -1.3410748309920768, -0.20724920949040515, 0.10011848301608643, 0.5287155012945106, 0.6803466737683409, -0.19265428920184963, -0.8439533251513798, -0.4079954622764369, -0.9377453314947322, -0.8474102243689975, -1.5024665430927933, 0.29919737996900786, 0.44702476804196023, -0.7335698780661674, -1.9607176354386486, 0.2578315835557349, 0.9803791535242412, -2.0102243676330493, -0.3401360915557669, 0.09535401489480788, -1.1598137968543725, 0.62229765318074, 0.6834740535150664, -1.1970186589690968, -2.418341103893292, 0.20413888476982764, -0.5822879975044319, 0.31667864545226154, -0.8827501912503352},
    {-0.3254919444967866, -0.6693531644310561, -0.16895534916393223, -1.023797839320744, -0.8226667683991652, -2.056087394314819, -1.7150426994493422, -1.604464480721391, -1.175431827673435, -0.9683000296384057, 0.9204136818559777, -0.2377973739501244, -1.3157400707726234, -1.156922247119565, 1.0277141881532823, 0.1288600700621854, 0.7198658334348448, -0.8580917177941713, 0.020546650031384155, -0.46541797213289887, 1.7514286488395738, -1.3375228734550375, -0.5462391278602141, -1.3858977665817689, -0.6590840994983629, -0.5205157633470782, 1.6777708124985056, 0.5147783356994933, 1.563468406263941, 0.551282517504156, 0.7929691252113781, 1.3326013218792854, -0.6135480619198074, -0.6967024834670003, 0.04489248800595814, 1.1435395723751018, 1.6497058226754664, 0.25136096654760653, -2.1778244442986865, -0.6926362128696473, 0.5794098402194169, -1.6715052032116509, 1.6961789877089333, -1.2221407284463668, -1.2763924120899686, -0.6394763631233359, -1.3539132905973974, -0.3659425687298379, -0.4933343702904214, -0.3916671815645861, -1.8162644144665299, -1.485306113611496, 0.6743020048942111, -0.6674091926967427, -1.6424015335159527, 0.3809887575080159, 0.14288420467142232, 1.3265842315207939, 0.16150215012834565, -1.9332620544722317, -0.21653919976151775, -0.7565932676077605, -0.3043819252380606, 0.28188809179908736},
    {-0.2258926806750443, -2.6984136408384005, 0.005293690685812027, 1.2107912652304962, -1.514648197735928, -0.3428285547987805, -0.6650347597187747, -1.7210973497748783, 0.26954107698177293, -1.2862399514922156, -1.0494798975606257, 1.4239810451020878, -0.5622608492725125, -1.9114443506934669, -0.27606770587483265, -2.606500435329465, -2.9906114731746554, -1.679925822539674, -1.7453595250749114, -2.1959076386334, 2.5322256898249234, -0.3834464514344929, 0.8964916285016955, 0.7593202481851035, -0.7359623845984183, 0.5316632639236718, 0.9558505805490533, -0.8031644122485094, -0.6819974531829557, 0.46223275825259197, -0.20633292929760766, 1.0044560371901796, -0.49730558523859947, -2.359158968882233, 1.917242412694177, -0.6648111347419027, 0.4260296855026553, -1.7479687204260528, -0.671122506883639, 0.8629908507614605, -0.019406755178622823, -1.0747290569218098, -1.0117015013002106, -1.1389848553423905, 0.2120958057912753, -0.6515810351358263, -0.0412841006138217, -1.6665395584715545, 1.6003889066739372, 0.07210045949970302, -1.2854348036574788, 0.8267520424707419, 1.3314957543561203, 0.309634924127126, -1.0929396169319743, 0.248444581250448, -0.8286216300672983, 0.20522661375233636, -1.6716611948244737, 0.27592224314700076, 0.8216921487235929, 0.29798561067990625, 0.33367257965034425, -0.9782907047165427},
    {0.14947803681705318, -2.641169670390038, -0.41152604253566427, -0.18023788517875242, -1.207815703022353, -1.9494870469833263, 0.1029994825474365, -0.11322755343190073, 1.179795069657745, -1.4582147533325385, -0.4800980443650286, -0.7719705804926564, -0.5102429226202883, -0.9083256777619867, -0.5762999208532111, -0.5360621882729572, -0.04442803374483072, 1.1924659801551047, -2.270620262754075, 0.13942548689939188, -0.5779472739015046, -1.739199577660894, 0.7977065764069292, -0.4644800580201049, 1.0747020579040618, 0.19248479162100074, -0.9589887385718888, -0.5233849449666645, 0.7248671916126473, -0.39743208361799, 0.9183648720243817, 1.2251048327235463, 0.8085126490275564, -1.014075715252558, 0.5911815736578108, -2.524087237833508, 0.0737030129993648, 1.5268010650669273, -1.341075472645672, -0.4710164472232618, 0.4450261693139318, -0.6501290931555523, 0.3038518924267588, -0.27755932371001835, 0.6255473492252953, -0.18450128345120187, 0.4635686109219643, -1.2900880662318908, -1.0931894113677425, -0.021120102407456886, 0.06900737775251983, 1.221808298522374, -2.716644162039946, -0.9375060582985444, -0.6614663792513802, -0.6091870083761336, -1.3002416147260385, -1.8260277071636095, -2.441330409226181, 1.1763225195458087, -1.711655212637713, -3.196005544811675, 0.7730618703587833, -0.33311403003569506},
    {1.0957233722328814, -0.10348164582410953, 0.6564162034463247, -2.425639517167698, -1.5954460773351817, 0.11718249467627792, 1.2337373928814204, -1.2985739488195622, -1.3072463161719923, -0.7807544269728606, -0.03404839365950059, -0.40297727787545506, -2.225178807174182, -1.3237569214263316, 0.9511363539748272, -1.8143869735425997, -0.13610864234193204, 0.7698316139946036, -1.0857894561204016, -2.5575694196187606, -0.5703226283769403, -1.5073606067268328, 1.642528862302911, 0.35346614327954984, -1.9584465467730012, -1.1198746944909086, -1.6498994308271595, 0.6557604315074825, -1.5382418625602878, -0.5865587208959411, 1.0790808722248713, -0.9242896800291652, -0.024749949767240275, 0.6679879754079836, -0.5043506790992178, -1.302142267342144, -0.4828294280803438, -0.019397752781040917, -0.7033099413615483, -1.9848755176594983, 0.3143699219235055, -0.03707982717175168, 0.4908569130400677, -0.7717030945243176, -1.0505869469337052, -0.8130747808770523, -0.6202339050350305, 0.04740492203261017, 0.585827280773013, 1.0485689643860263, -3.3764901884328946, -3.146965634948429, -1.2326531839906227, 2.0023009276790202, -0.11330742129942765, -0.27563902869045964, -1.652855451603937, -1.9039968379135166, 0.553860342305837, -0.8666765800063526, -1.0500083284936956, -1.139051771315348, -0.8877560766377888, 0.8485335072450866},
    {0.5685828885801836, -0.8123670104551276, -0.46674140936219705, -2.3009230736030224, -0.5523517007195732, 0.049155300572580635, 0.22677844107663997, -1.0859888717001063, 0.00773734472395062, 0.7138568366571487, 0.13969894606244454, -0.0987896757786649, -0.492068877270945, -0.2245273741625335, -0.2949410705001759, -1.6201421311367754, 0.9185980351436154, 1.086004877399165, -0.14416664046590336, -1.3789564851545977, -1.9971211173444712, 0.8869555538387535, -0.690436402174373, 0.8146272993205861, -1.9085537034547406, -2.0621692160701266, -0.8998006905860906, -3.352023607652155, -1.2075226822839746, 0.07763630855326702, -1.3914699011222291, -1.580735709524497, 0.2632802410058158, 0.1748158546109236, -0.9636826096017339, -1.560198190666688, -0.29008493045970424, -0.13195171747413498, -0.4254299974816844, -0.40287534204174064, 1.642604934303747, -0.8473597864825905, 0.4370397932201102, 0.05559788597233112, 1.0432061893996172, 0.984117976034795, -1.4353262453774729, -1.6492277541091327, -0.2065090145567794, -1.3190394561647445, -1.0180280738966154, 0.5532124733239577, -1.9511801792078378, -0.2395395240855075, -1.7839179229292874, 0.9412820079270917, -0.6032861184634448, -0.26296993062443214, -0.22574032394259755, -0.33625673928527977, 0.2687817865753274, -2.5693463878462013, -0.5732486393617419, -0.973537606013819},
    {1.334208273580785, 0.6829106754681175, -1.2524399916024853, 0.0021156819252023187, -0.2173483623083931, 0.09074115026393245, -1.0534708540415527, -0.6283554928627707, -0.3144297529942, -0.8631456258393853, -2.461735074244698, -0.34776497733777617, -0.5305168950314695, -0.3600077840047219, -2.3487802208728907, -0.9416960964031881, -0.7561839403590225, 0.47783557062883497, -1.4754910852982603, 1.0990483043629111, 0.18408089529066696, -1.2423499160860467, -1.8025504383912099, -0.25829808045496533, 0.5468927749545419, -0.2783595088040489, -1.2420580613793206, -1.5136917470400675, -1.245160833408812, 0.10014251779174961, -0.4155151299876001, 1.149289833705821, -0.47909242026165183, 1.0697627541984185, -0.33873481477148765, 0.037208595791993426, 0.6549968166593846, 1.4714654003311054, -1.8477431576917691, 0.3080736025797668, 1.0345797270146142, -1.490011503286068, 0.01337685234806736, -0.6670577991796267, -0.290568806607515, 0.22527735086675862, -1.6424183035701427, 0.005385200888367989, 1.5060995201533856, 0.6715058497191507, 0.7909271042095642, -0.9717613946153157, -2.0709117626054225, 0.6099800308170373, 0.9420752856182536, -0.565817747158219, -1.9632015973359283, 1.0687953743252705, -1.1775977515824945, 0.8873236882073127, -1.1350352310165066, -0.5321497515161366, -0.8350971787997773, -0.02237383521190663},
    {-0.30202635268211975, -0.13557687188261802, 0.8133006498200189, 0.7884942350981722, -1.7731528618869645, 0.3789400795392667, -2.132786883888488, -0.09818575531741094, -3.0240043114096964, -2.494690028432128, 1.6862140805794077, -0.5743145488817, -0.03583291766855886, -1.0377165619165154, 0.03823297665349521, -0.4136146617141406, -0.5189614569201764, -0.43595949286144725, -1.0911548708944288, 0.03330590684351309, -0.8858445029275308, -1.8951305012221114, 1.1109507980236872, -0.45872208617682325, -1.6939957612297876, 1.461639879680623, -0.45103230127327626, -1.599194821297357, -1.024987724964386, -0.882142684863358, -1.030330592601068, 0.46738892176707014, -1.7768587331628578, -0.600999510929073, -2.0721525957487037, -2.7214977204247965, 0.5388256602873492, 1.5616454148411802, 0.14985573765772234, 0.8741141783801046, 0.37500287204303767, -1.5800433978913682, 0.7772360205519018, -1.1013115109765506, -1.4725115272136247, -0.20433803715151097, -1.0720302547244425, -2.1735527705563946, 1.5560155526566208, 1.0417658909572534, -0.3704508390103497, 0.8022974880437834, -0.8186207957584242, -0.9273679280235751, -0.11045315547700701, 1.2358504711711715, -0.35365841241727364, -1.065102798525463, -0.8943123415060987, -0.29600580513595576, -0.08435290567266115, -0.6419759174701267, -1.4597108753280816, -0.060669096939799966},
    {0.11664987241051644, -0.662766568266402, 2.1620335155838766, -0.9645670685533839, -1.8921750606562608, -1.0318345334067003, -1.1089454615738716, 1.1839056498796419, -1.973134077587801, -1.3186550481484594, -0.1048214789040687, 0.9681716144652661, 1.1649498573465318, -0.019639942591013745, 0.664685960892638, 0.8741004922008792, 1.354300228925606, -0.21412524715340717, -1.4530808850039012, 0.8009691570678477, -1.6789994109404542, -1.5261787711669887, 0.4146295382333223, -1.294075872902653, -1.0577169263272543, -0.5105723366212993, 0.6167169946702284, 0.3048073506569587, 0.5183794514580258, -1.2102794168757691, -1.6360784865047582, -0.000819051244868447, 1.2095752251298946, 2.412900173490519, -2.5048914284820496, -0.23353824952786886, 0.22807363351869314, -0.2330046010524532, -0.5947348570346445, 0.5531167142189896, -2.2520199303698463, -1.4301305931333101, -1.3217389273522246, 0.3857575130760547, 0.1307239954149874, 1.5688477437198114, -0.45813037247388605, 2.504568712219824, 1.0447278905163995, 0.5597467522009121, -1.7186685966074051, 1.1753046641680924, 0.8139053123568957, 0.5774155241165341, -0.6533732409644661, -1.9396692866256109, -0.3476552601759859, 0.16272193007697355, -0.49598937465471626, 0.5913400169392086, 1.9099469472259396, -1.8556432227925375, -3.0374171533426852, 1.883853481317323},
    {-0.09863690967650907, -0.2425616287631161, -0.4860606378096487, -1.4474581551823056, -1.852438704710648, 0.5230825867540569, -2.5684424985107697, 0.16805243022137942, -3.5132409235782918, -1.4534104312529614, -1.3774886838728733, -0.01361282027851853, -0.47036253894203606, -0.732809855447969, 0.25451643902818405, -1.8789617655448263, -0.7927908752814226, 0.6643279222096081, -2.196230992817436, -2.5128014496830877, 0.22569215188943753, -0.8115640504458497, 0.8385215496815575, -0.27901092608689304, 0.04289382832995607, -1.6660785000045262, 0.8734455939555049, -0.868136373378711, -0.4047808896414581, 0.8853103974445614, -0.07717106155553434, -0.30591879816494, 0.24217788525887415, -2.3405658192193965, -1.198737928509568, 0.700311722809532, -0.07224014199649782, 1.0260936597176018, 0.19744223862295943, -1.4342512782596526, -1.4762329439143227, 0.2507904807140434, -1.1533912088057647, 0.5439525115440199, -0.21541772238857415, -1.1193052642496937, 1.2655722114506478, -0.5767454385456596, 1.008147731041632, 1.00518712371703, 1.054205401194056, 0.35536483649450207, -2.4682046879287696, 0.3369484782821936, -1.5646176634708633, 0.5529016031717782, 0.197922609553867, 0.9654904845808078, 0.08308058406735207, -0.9752402837500571, 0.9170890096761575, 0.014304662008956356, 1.1908720161677389, 0.018223347234495646},
    {0.3904985332731662, -0.3387615314203921, -1.0202333032770994, 0.028635755610581914, -0.8863875961018292, 0.37273206879810294, -1.8837390009851758, -0.061067086609678356, -1.4128263476692655, 0.49957576677128346, -1.587335755902196, -0.08228778278201491, 0.09734421347731628, 1.0764406597238472, -1.6708058468333542, -1.9150253070861862, -0.7930154144323492, 0.40715856285605434, 0.40474063604198074, -0.46117027497519975, 0.23821164108430992, -1.5977566380767305, -1.0908263561883633, 1.5556164564803954, 0.6653173688391687, 0.20351922626319868, 0.38410999170679855, 0.2630932555957147, 2.0155265124308364, 0.3264208386675913, -1.4495329311011262, 1.123328097195245, 0.5741526996951747, -1.780629321371161, -0.5683497819860495, -0.4559425435484342, 0.7192695579638722, 1.3171706820414035, -0.22517112134376013, -0.02398366831180363, 1.8396141322780828, 0.55184741153088, -0.9157178402693446, 0.8805688765571515, 0.857706900451083, 1.9164395470396072, -1.657658511980475, -1.6176109407402952, -0.624754862888351, 0.6686823017859311, -2.013015967171304, 0.23050783752185566, -0.9144708242245515, -1.234155231458612, -1.1595148480044175, -1.0654551168979365, -2.5618961040404127, 1.357171907152853, -1.8785483025266339, -1.4194286101955738, -0.6584031124827606, -0.505590298307366, -0.46488649307683433, 0.9522537658583091},
    {0.33693478289183987, -0.946370416737073, -0.3070130087948041, 0.0950466253568976, 1.9574243820843806, -0.0007550016698167764, 0.6091552814025665, -0.0918990257207721, -1.4714272727066158, -2.74370546171157, -1.5160265451928094, -1.8910872295926744, -0.6928109015606349, 1.8391101905959113, -1.272387391573638, -0.8675627275154777, -0.8667824464130444, -0.8764477434198552, 0.03642721954247399, -1.1347076178147886, 1.2840551930334745, -1.6969788968966277, -1.912820074757124, -1.1057560966648914, -1.1888225169187239, -1.221331245184428, -1.1470775439101613, -0.6537588932651953, -0.5556120258184201, -0.1377727421995293, -1.6659226632601616, -0.5825452768214704, -1.6125269754347982, 0.005591605877656942, -0.8742733298580111, -1.6346491889575998, -0.5110270290232787, 0.4559523814145719, 0.44853246275158926, 0.9016011025586959, -0.642128059731871, -0.83508052912526, -1.4692756232374256, -2.4234845875102966, 0.638093616685387, 1.2522783481861293, -0.17003546322076793, -0.6999250874888578, -1.6210996812436105, -0.026597349459863466, -1.2289502982193155, 2.4140806511882333, -0.5356864390565629, -2.352496365026021, -0.2419870141526378, 0.44544870474711956, -1.7695224740322626, 0.3280804358226977, 0.3834812359450216, -1.1876242349732336, 0.2753009459624893, 1.3322287159042903, -1.8920584240539178, 0.5803124428046935},
    {-0.4197185830934841, -1.4255639865961167, -0.6801945636172897, -0.5796674506124099, -0.4624435469078276, 1.9021271432517428, 0.7304115854899673, -2.932189363228536, -0.9992853209160771, -1.332014242147532, -1.5596028235114616, -2.06028537913111, -1.1392475669395252, -0.03153346018645262, -0.8035517557322425, -0.5021972977197888, 0.22552115295311928, -0.0781326202975688, 0.3558527528917576, -0.5999416098674116, 1.5355819623772353, 0.9146719597223708, -1.9852969053945102, -0.528361416074136, -2.0428788097685993, -1.4540576940716645, -0.6406337749476413, -1.0707843754961426, -0.39084054872746615, -0.11897471828537412, -0.1057520669626059, -0.5761600341919396, 0.8758200042473588, 0.5728772313454139, 0.28656889285579734, -1.3672608844756329, -0.16694435874973884, 0.4522245743675323, 0.38454690485766163, -0.9852195263746578, 1.4414854285212277, -1.002981441156962, 0.7220326662226016, 0.13078678541935793, -0.3879826201199332, -1.2087393333714729, -0.6005791311552878, -1.3344330000660438, -0.5201851219329585, -0.23017699677313275, -0.9552527107385578, -1.1834602136265564, 1.600177083005063, 0.15099331385158962, -0.643130083480626, 0.5669194635224, -0.9921219326353334, -1.5784795894187613, 1.8999773060421365, -0.7546400563972427, 1.5039769221806207, -0.47122288784801203, -0.044882347811524136, 0.7977069003363796},
    {-0.22173616829968137, -1.586315702653074, 0.15086614651484845, 0.6709921023707099, 0.5610941388233323, -0.7725348644332202, 0.5285604870178202, 1.4012718946391434, -2.4311443268089676, -1.5042560936987008, 0.2787843661626658, -0.8037535639771425, 0.14533255862315822, -0.8005078412926101, -1.1392639554222437, -0.7911840268880691, 0.1210316513281784, -0.8466974608398429, 0.1417063343592205, 1.5703063959257442, 0.5856648074139852, 1.3550151830627546, 1.073698549860679, 0.5835469908685568, 0.283351660814415, -2.0833048037018944, -1.2005105892561165, -0.7865303887664831, -0.44161774713791907, 0.6241557529939102, -0.2971584980394226, 0.6331080566972571, 0.00577806343791434, -0.9699701444136278, -0.04829842765313175, -0.013631525549003607, -0.040065059335084724, -1.1397616335942105, 0.1888783274340635, -0.6493224307585598, 0.6826459736660184, -1.251313059252993, 1.168381869134902, -0.005460560018073351, 0.7416068044108475, -1.1078259383378148, 2.807311268764403, -1.4150541925684617, 0.11793316222380366, -0.5216093096449512, -0.9273877236478034, -2.0954626366649456, 0.08155698518099648, -0.0012855449189418204, -1.4398271300626952, -1.2602814388395558, -1.8926416019438024, 0.6056933052377012, -0.4572690643827296, -0.39613112955409974, -1.9254890645232052, -1.7223635487240985, -1.7341770240141687, -0.886459137754687},
    {-0.41009693822510535, -1.192131004938487, 0.07795933362731525, 0.38848496429550106, -2.094099401639956, 0.23572261395827884, 0.9047218922832347, 1.4680093037140403, -1.879656225715932, -1.6305193466574042, 0.5556547484473516, -0.12866355964001105, -0.9331457210627835, -0.2977861189212201, -1.8209461776544553, 1.0849803050957105, -0.11677150754961534, 1.1567523358206095, 0.9041944637488607, 2.550613368021911, -1.824555787450999, -0.051843390917306754, -0.5314375617207473, 1.1833849060286679, -0.7972769732113476, -1.0412417716400846, -0.2866318275442023, -2.8420338838584875, 1.5262791691919824, 0.6909370267985105, -0.735824798512849, -1.1698484954157293, -0.38542922941544905, -1.190181265236332, -1.3700601455784407, 0.1156598132502827, 0.7231981535512613, 0.011369187695450547, -0.20574631452656525, -0.014277899959383712, 0.7372320635186621, 0.9003398886815772, -1.2350471316900093, -0.2151013809840693, -0.5171396554422166, 0.900821518493095, -1.338652802195535, 1.1494038161509461, 0.954856895274045, 0.089637603302448, -1.834013181789409, 0.3538371484482038, 0.748427149160959, 1.704330922033879, -0.4028301225778145, -0.35932323497252794, -2.086466566731878, 0.228857441336331, 0.6050503671037283, -1.9232167150807657, -0.23974092838346414, -0.3089449624645354, 0.08287221534345604, 1.0566179752264455},
    {-1.7057832624031892, -0.544007434865215, -1.1394829609595944, -1.1079640080294222, 0.2028698075596155, 0.5941338574188965, -0.3842086855464994, 1.8446491556525757, 0.3951110131262616, 0.4295376921091647, 0.1810771107109041, -0.297108642839716, -0.8832907807426442, -2.722984775788245, -2.1509130342535077, 2.735524441811526, 1.2185488109554283, 1.3802395499534987, 0.43880438070834155, 0.14097841657631913, -2.1031172382842245, -0.33106795339429507, -2.880990334554813, -1.7607529838592855, 0.07066880624421953, -0.3610325077611049, -0.6979248716706595, 1.194847352427339, 0.988688172877587, 0.150350890343119, -0.14047151501164973, -1.9790234522880925, -0.1336060753894571, -1.4237699920584101, 0.13792933111251743, -2.2775866295909033, -0.8334400991448955, 0.5258716699225968, -1.0976675470038761, 0.6801597964951026, 0.24383236440289102, -1.4491958565684664, 0.4466322456758122, 0.6981606876445472, -1.687701790106349, -2.457929810037921, 0.015692809390013777, 0.2976889490178997, 1.5669886433093245, 1.0167633986857947, -0.5830115696700192, 0.6559696494410787, -0.2728252414487243, -0.23877625813081751, -1.4932374170931235, 0.21613242516190814, -0.4120887574354233, 0.2358480315569099, -0.005946051916425491, -1.2190833789623021, -1.4638554425093877, -0.05705802089455734, 0.025457218597830168, 0.40010754994365183},
    {-2.677310046930015, 0.08344637795936535, -0.019998033442002766, 0.41934046800958463, -0.4818979516673014, -1.0496681725615231, -0.7802211997688855, -2.3490807149751114, -1.8820832153415852, -0.40037611973189674, -0.5945771684531261, 0.7335344377910175, 0.0677358025373211, -1.3894393187328915, 0.421185931928597, 1.0244863402203892, 0.08292022744556911, -1.363636268393585, 1.0515402928879358, -2.651217806648329, -2.1063048402793836, -0.3844487559241814, -1.6181424870836332, -0.6629875029199707, -0.26370568496443086, -2.5710254040799803, -1.1341181057796825, -2.0996039252455754, -0.033089850559971, -0.6200379288794747, 0.5204147039324227, -1.8134875531717352, -1.8801370542726852, -0.7809774388783496, 0.007324358472593617, -2.0583631160114666, 0.7878753397457987, 0.3961409963467522, -1.070591801937536, 1.4452467074207846, 1.2290585775655911, -1.4257649223321358, 0.7543158940426817, -0.1704206429483059, -0.21039957443045335, -1.896234316730508, 0.08413466018262353, -0.6959216289592713, 0.16663247744486323, -0.9469988664365077, -1.6305540311792863, -1.162874849091655, 1.409361808818763, 0.17729316571322545, -0.23196139039224645, -0.2048219804961003, 0.004164050985161355, -1.1669233192040656, -1.7605648861820322, -1.735004829377387, -1.164637515624274, -0.937137917114228, -0.09011091112169457, -0.3564092113919856},
    {-1.5850950046196697, 1.547250661753285, -0.850492930506441, 0.03776024479278818, -1.9596326125132635, 0.9297862281857855, -2.7109229468346423, -1.6655731262295606, -1.1217106609565521, 0.48076846277989677, -1.925458185251308, -1.996130275792978, -0.7835692650424735, -0.11505213166773348, -1.4717907618870596, 0.030717524553319272, -1.9609935897233763, -1.3457061972914255, -0.01855611286105212, 1.553329034981063, -2.314417599705567, -0.5109124534446121, -1.2318583741813272, 0.3808595644307479, -1.8677637926437294, -0.13120570502157025, 0.8117452162545714, -1.5593544898467167, -0.1067065062486129, -0.49357677730542254, -1.275075959304999, -0.011864199371003751, 2.319188944976586, -1.3687552657625282, -0.9312615638194184, -3.185031921370824, -0.3660665315685866, 0.4945201940621738, -0.4249207898548561, -0.1880525597266045, 1.9669435251165204, -1.1880332778103169, 0.1321001794000039, 0.7878086898250223, -0.7239431643862012, 0.12137724079422775, 0.8020570549112027, -0.046077484809448496, 0.6523859487655956, 0.8623889410928998, 0.010130049369352372, 0.11859942275324772, -1.7612296506416847, -1.001231379385641, -1.0666541302252557, -0.12325291575210216, -1.8926426651520922, 0.7406603578548963, -0.6004554011489674, -0.5354059533046165, -0.3201899340113376, -1.7396202239116103, 0.4560254871114344, -0.8468405130324015},
    {0.5956289540102537, -1.1578521824764114, -0.07452146079034286, -1.11092105368802, -2.488095264674155, 1.1548720717699312, 0.27626180071781736, -0.14483990026161225, -0.33978835775862365, -0.03270914729244349, -1.2259436384859925, -0.8320398331681733, -3.257070139389048, 0.9970610536886158, -0.9844177171402932, -1.1354991850494263, 0.008389947780393281, 0.42150176760770874, -0.40738859416121415, -0.6041456860752515, 1.7087894790356581, 0.12243309277855166, 1.089221743612237, -1.7133692682512687, -0.4465164855035917, -0.5002793522448091, 0.6087799985402624, -0.4545320725434462, 0.6910556496400526, 0.09160051427383814, 0.8506009219344611, 0.545548241630794, -0.8641734186870077, -0.08880438386316127, -0.8953044428286037, -0.8642409875131059, -1.6797577070296648, 1.9594419909847889, -0.11010288971807501, -0.843399902344815, 1.1632447005503106, -2.1383554386623973, 1.4554168437073978, -0.7752617518342487, -1.5140586624976522, 0.6010723324134474, 1.476536854873548, -0.6431230927040821, 0.5592904270532273, 0.7593628394428406, 0.14368879953726948, -0.8978081127957405, 0.9101753306082533, 0.3205676126643811, -2.195903081085312, -1.8295128586170153, -0.8618421831472064, 1.8360502493818245, -0.8572528591294772, 2.6259947319883485, -0.9343618423529552, -1.0905797509281372, 0.10835504306117397, -1.2162647484033877},
    {0.8480181262914047, -0.8562107779509371, -1.5492105378644936, 0.4389905742726203, 1.9898514590354148, 2.127531744895045, 1.0644221623311096, 2.6174466244695145, -0.05045393451088194, -1.225985470020442, 0.7478708444102667, 0.12105441028743709, 1.434945877124064, -1.0270464050778618, -0.4973364033477627, -0.3189444227502262, 0.8963347181290382, -0.33271902050912, -0.6523527929333066, 0.7414588076550507, -0.0722114134385345, 2.1819890697571465, 1.618273445750513, -1.8223575337181932, 0.13381998184393673, -0.6747510751673996, 0.05961940440717618, -0.03590660175830626, -1.1997224404524545, 0.16452408182782285, 1.675003073900414, -0.7945804892133099, 0.016751699152735347, -1.0346892661467808, 1.779359851695954, 0.28949413457021217, 0.7241286752039435, -0.26592185623087683, 1.1374747549064177, -0.08336027796938798, -0.058177488640012466, 0.7921208674786548, 0.537080836898476, -0.5710763059193086, 1.112567442673322, 0.28355059909215147, 0.49421995582736256, -0.5996166835741004, 0.6649292426196541, -0.09910589088080692, -0.282164401487055, 1.3100829376904086, 0.09072537968978096, -0.08918499367350487, -1.9153022003573514, -0.6888801826699791, -1.355321864117036, -0.6901006027960476, 0.41647664993317407, -0.4801205921110227, 1.3208625821693123, 0.23782850903930877, -0.2995684246670311, 1.7935112416293484},
    {-0.9590479396096445, -1.8983604326102554, -0.9312660643184161, 0.05265931208187056, -0.8494370470923711, -0.5066072289748665, 0.5661921686304294, 0.36151676652675063, 0.8357071957738776, 0.5844560998977737, -0.01567418873966071, -0.06037140218269284, -0.9223007455822358, -1.3389963552455342, 1.0497307440810693, -0.05352106009479022, -0.8175199496926551, -1.8700770833978235, -0.3799895302997565, 0.9145944314423505, 0.08484096133679266, -1.7950776362510072, 0.23383768156902224, -2.046353624691746, -0.4129131450829982, -1.762780728802765, -0.15142717702570926, 0.14726475624419424, 1.0404527480644057, -0.09266879422445236, -1.4009172889161512, 0.6110245662063701, 1.4549583999838138, -0.28322620496586004, 1.125287719860739, -2.892555154254945, 0.778333481829284, -0.1722995830821796, 0.33949465471075296, -0.5717055215718988, -0.8152418403405944, 1.4326689183801367, 0.13154553684041645, -0.28334093004219646, -0.2564911042330265, -1.2651280957218591, 1.985164058145632, -0.8400613354725328, -1.833546321365381, 1.1855300112397167, -1.4429870682951251, 0.1783128637261693, 0.05163828626384636, -0.7374523196642284, -1.6201303052573277, 0.1646672182861267, -1.0215964662925796, 0.5650647769168078, 0.02451611076960217, 0.6043106104832395, 0.011797113895058884, -0.024854075309360436, 0.42655662777888403, 0.42829565490646115},
    {-0.05442266167044786, -1.3624612474985667, -1.1247676697245432, -1.6394407393413453, -0.611697144547046, -1.7785212533339911, 0.4001339760695651, -2.516675019096291, -0.8820469890773408, -1.4538128980877094, -1.427028768925246, 0.9630980482302268, -0.4590348836553564, -1.440334751837068, 2.5468478072960403, -1.8211697940092282, 0.911797427957974, -0.9767784677618576, 1.273390471757539, 0.041803233776787733, -1.758189257269461, 0.07379355501233013, 0.24984989237239488, 1.4842317296741194, 0.41071857737932277, -1.7953656398969102, -0.8246599546196757, -0.6892999470989541, -0.7761080889272235, 0.9882837848046966, -1.671425602217436, -1.0491170748174672, -1.3421391057686989, -3.000858820770361, -2.2304113546953133, -0.10773524031525737, -0.8725031835921008, 0.6313878276011745, 1.1549450441143903, 0.2467011721459648, 0.4796193584950698, -0.1636890626859364, 0.33638866577223664, -0.7318967351086045, -0.7280585255428453, -1.5599244190677686, -0.18819640208146807, -1.0775236207113048, -1.3955389709691446, -2.3467934594107644, -0.1007441181764187, -2.292543146981981, -0.6870920450146069, 0.9634959372007513, 0.26810924884641346, 0.11196397962166821, -1.1213876917707877, 0.49451414267234184, -0.6612635363891818, 0.8657303113249104, 1.0564004035028012, -0.6110218760901192, -1.1816009206394902, -0.023829543707411055},
    {0.0003309349664190026, 1.4819766362551596, -0.8485422597515138, 0.8557429065212552, -2.035028268951332, -1.3635591214094651, -0.1821151421958633, -0.37942924947198864, -0.3064639086444072, -1.545482875336228, -0.839540233370601, 0.6413074781414165, 1.3019400645312595, -1.41581429615473, 0.7350686639025956, 1.4985676309168465, 0.6066800646011259, 0.04940675047638875, -0.2959128871454741, 0.19422797592685392, 0.5630985243100417, 0.9728510511783118, 0.8776097101497603, -0.18413693810874793, -0.5850065469723608, 0.9321211366732526, -0.17039893577715373, -1.3783226245099405, 3.023692693864726, -1.7290853037875862, 2.3066186283852943, 0.49760345589468685, -1.5572535973450816, 0.31005720287790767, -0.1319686354873204, -1.7569560124292225, 0.9538126191706964, 1.63571919749853, 0.5439130178739054, 1.10064187982678, -0.9916211448295067, 0.5415037508462364, -0.2611657918331418, -0.969318652881671, -1.886773258295075, -1.0097151614729931, 0.37161636057603015, -1.0979049514143933, -0.6486472954729581, -1.1159549462354188, 1.485278142552143, 0.9167879042266537, -0.3142798441517593, -1.007943942083858, -1.7187311780323067, 0.7509691572598779, 0.07517090679512008, 0.43259008062280774, -1.7955562632670556, 1.2290576161004823, 0.1385076465151147, -1.2839339948321162, -0.3415589652467247, 0.34051477166801447},
    {1.4734324721297838, -1.7284671716554727, -0.6841987812793078, 0.7568302148509248, -0.5853773833212458, 0.07093607161742536, -0.3614279499332842, -1.5823897566863887, -1.0573252094249908, -2.576110657099617, -0.7596593501847643, -2.5323727039134907, -0.3356389092092047, -1.938928511819537, 0.12104948994255299, -0.5952467865466422, 1.2687713196137258, -0.5592612080467078, 0.5648593738970161, 1.1848542361653562, -0.6105749123050487, 1.1970974395828242, 3.0490761312368946, -1.2269416010007739, 1.6420495105216943, -0.12835956368830337, 0.8623095712470525, -0.6356648271895937, 1.8712719400245033, -0.1215945778102557, -0.05694826771203399, -0.865933896188686, -0.6725559974848746, -1.0144561658901587, 1.9082356190412082, -1.8613918586737979, -0.021239382284159756, 0.3344626568443639, 0.2254860226387949, -0.11424959911660441, 0.38562563381725895, -1.2897047283859129, -0.5860831898258334, -1.829034438372911, 0.9966743937732392, -1.1219895348708975, 0.20421167899402445, -0.7920384849987249, -0.4272753024124638, 1.2705099119200554, -0.01083982298814375, 3.4874588396367296, -1.4273843731646396, 1.0813661172475917, -0.9251642443760717, 0.5555293580030956, -0.7099692121631923, -0.09833578390410005, -0.3958546928185879, -0.35732937043469093, -2.0892513097163863, 1.1183339743861254, -0.8501967850035299, -0.22393561583742844},
    {-0.14311714467732853, -0.8786091455078547, -1.431784511767152, 1.6665739738432965, -2.8676296877958003, 0.3430130874158884, -1.8092486246823034, -0.766532396468663, -0.9630893318757741, -1.7563596095144784, -0.6328794821343451, -1.4633230663956054, -1.9013437586671218, 1.5272509029002133, -0.9910329480513415, -0.1263627496874408, 1.1036401954541477, -0.4193130368481756, 0.7121858691420745, -0.5500520311703521, -0.7068423909014093, 0.499504495041934, -0.09013717850204248, -0.18432590412893973, 0.1835975741452568, -3.808437664349103, 0.3666501812995123, -0.40979038268487233, 0.6779098447139278, 1.0967627347438098, -1.4274415136812046, -1.8673166588392802, -2.5965670500835363, -1.325002055346917, -0.118315908369489, -2.685091000490228, -0.49023316229854846, 1.6561918419394335, -0.3364078890144416, 0.2067026146264009, -0.15930612170086356, -1.3983942842808545, -2.0409987040037727, -2.3943495812806144, -1.983137824860253, 0.6802614928143585, 0.054216243753343364, 0.5609060605078738, -0.46104523768083405, -0.3945390145376796, -2.3298584948342307, 0.3256232781854352, -1.0123222040046576, 1.1374029118051434, -0.9879933356713897, -1.541331773112431, -0.4498770314118523, 1.103264566806423, 0.08108516948730429, -0.652114063185396, -0.456785602667171, -0.6787900254549695, 0.06354219521626839, 1.4786277645906871},
    {-1.4677345852736001, -1.4026138713200802, -1.108950402970931, -0.8063288323749338, -0.7622771686702992, 0.01892959431791067, 0.15279775962057646, -1.4702446994174039, -3.3786964663679746, -1.1288123162188635, 0.030972813728961223, 1.5302335021186235, -1.3025089506370597, 1.1326610521029805, -1.511404026446412, 0.47335219989062327, 0.5255910554911994, 0.754478404767253, -2.3613595391048365, 1.0204517866860505, -0.29995789307353443, -1.2844390256302063, 1.0209230786678256, -0.39036647925049994, -0.2762872857601063, 0.40739011928063457, -1.8933965369691232, -1.4391763163705846, 1.406569530544706, -0.465056978768123, 0.9305806655276998, 0.36529934005812037, 0.08003055945249735, -3.4688607917641576, -1.399102261084482, 0.37333877547402716, -0.32107696014471376, -0.43696164304746155, 0.3749498440199638, -0.36459273608334475, 1.6113246838155089, -0.33459851412545877, 2.647731804924959, -1.3366663246633605, -0.9491838423669966, -0.24638101828832712, -0.19080992456510817, -1.4457320880226792, -0.9360290326619511, 0.7489800554246675, -2.253478428521986, 0.5944829206454885, -1.3013309607612118, 0.30722963093842826, -2.315359823120172, 1.1622292678910875, -1.628377199531394, -0.28742459538113263, 0.8219372341434386, 0.22438894672506693, -1.0022428871512268, -0.7709839740308867, 0.865102602906628, -0.24953135468516086},
    {-1.0356145005950272, -2.1760580369452143, -3.6600817461266346, 1.3235507275463465, -0.6531688988818248, -0.4658487803627479, 1.1458157149261756, 0.3917152240495352, -0.11786872480636654, 1.1427684887043639, -0.27065378647955374, -0.37588594419057414, 0.03483778150109863, 0.20164064907601956, -0.40133630868791564, -0.5981363205801528, 1.3416559426836105, -1.0058430582948519, 0.17470248006038103, -0.10963443728346237, 0.11287370917666836, -1.037889112197542, 2.089295543994245, -0.16262192152667665, -0.6332762582320377, -2.3130492897840784, 2.0516152924094384, -2.2150463028758174, 1.9806556809403266, 0.07567481877656025, -1.7897717431115274, -0.6577338291636596, 2.3388517133619646, -1.61074378574543, 1.2977287871705159, -0.06794606372131827, 0.20438439518324655, 0.535893555804195, 1.9238352687269056, -0.9478524610469012, 0.2280455437588145, 0.9530382648496122, 0.3989637000760227, 1.2833661837894663, -0.5200113921194757, -0.9856436321951767, 1.2709610287215036, -2.0477197980269115, -1.3318245020157045, -1.916887159192529, 0.30530631688854737, 1.0547026904718035, -0.5806211585334784, 0.5127243850581507, -1.0006465632215378, 0.5367911385139269, -1.160608414484078, 0.8858863211342333, -0.07443056560391119, -0.3306384357068636, -0.009779055726427132, 0.4513801879979699, 2.150888469599583, -0.26241365907660613},
    {-0.934721352175637, -0.10445541776723619, 0.10204812766080162, -0.6388101508526264, 1.4815368091635097, 1.3697413199536743, 0.3944389053910341, 0.6050016648356912, -2.2453684695186356, 0.3879754852657039, 0.8277895333162196, 1.1146625537081742, -0.3329052117647844, 0.24653624796090168, 0.4252979268618374, -0.01084689052785988, -1.5006722175409177, -0.8421904764258002, -1.254588371229494, 0.3467784481039913, 0.25691580842327966, 0.8163846974250064, -1.9737833787346792, 0.6712381433379797, 0.7062932272114925, -0.3531713419448195, -0.823551144621817, -0.009758939806124054, 1.5200510006363792, 2.5145744984023675, -2.817796819872354, 0.24890796992108152, -0.711092891095841, -0.14018377577595176, -2.384925137084288, 0.09270463005549943, -0.6202145486508631, 0.338571711951995, 0.5661993366504368, 0.07168341873298549, 0.7287956056907579, 0.5675284469473882, 0.07561311809454517, -1.6923833920181275, 0.9730704105894887, 1.4571873204468677, -1.1073558689825542, 2.6137434582734356, 0.1627805885248794, -1.8536320070250307, 0.4148943152373601, -0.3898077666346499, 0.7843418217161329, -0.30310422323580527, -2.2309030133269796, 1.5704482559380777, 0.19729973833493605, -0.5947538857182048, 1.512174704761454, -0.9036849561652651, 0.8240189971262055, 1.376208399304806, 0.4013637917907448, -0.4294534523498712},
    {-0.6790950196125896, 0.11760650264621055, 2.075587176227983, 0.09328298795032176, 0.04824639895889263, -0.4330380819179974, -1.6068727409479782, -0.1965210737338066, 0.8057162680846074, 0.27776095245794746, -1.7707831032731598, -0.5673621045502636, 1.0057720255598472, 0.6762516139435151, -0.5754972881351447, -1.4000888418103556, -1.2825793153780176, -2.0711776069861654, 0.5852626344381906, -1.2144015615658956, 0.1644985350665488, -0.7001451037176133, 0.06239109198896388, 1.9251809087611043, -1.3362197811663539, -0.28420830006612297, 0.2783309888136425, 2.005796265215325, 1.2984459698450093, -0.1296857129449137, -0.3243236217970493, 0.1113812266298415, -0.705146455718702, 1.0215016672114934, -0.19260784722482913, 1.1288509162878344, 1.816825058753668, -0.1921800095129603, 1.142958634184038, 0.025592773039708517, 0.6452515302388169, 0.7953362385485625, -0.1938981874988453, -0.21332058797170797, 0.19682227015421674, 0.7181351587834484, -0.4258613221212862, 0.19773359280166455, -1.183254668168568, -0.9443189165084996, 1.1444413355405525, -0.9929195539133068, 0.2703519694545306, -2.5796202410643243, 0.37441899153007013, 0.6404119976243049, 1.277236005038305, 0.22298155531618893, -0.22840606407240535, -1.2869226816113637, -1.180438289944381, -0.7762475209148094, 0.15876072883538744, 1.3404185447182717},
    {0.9347174306089666, 0.47131616698297935, 0.4723875841408147, -1.331892557634851, 0.5832758345888778, -1.3463307189480058, -1.2845543240202089, -2.196868964891148, 0.41647443695785513, -1.0286420620145011, 0.009375668767029452, 0.6131153853781393, 0.08657132054432554, -0.8528926937585644, 1.9908063949967538, -0.015841758005861878, -0.28183781965114557, -1.0429683196041324, -0.8067607917040831, 1.061600080920865, 1.5387177287698464, 0.5873604812399902, 0.41789984870178976, -1.4997274810090258, -0.42365679170897924, -0.6448842882133438, -0.15724851952136046, 0.3383806274071168, 1.7372263992769368, 0.08467523083737195, 0.26383129544367867, -0.12119138744222932, 0.08070061239955129, 0.3862076964271528, -2.4186818112342054, -0.4614890354006827, 1.4521112450298612, -1.5842574765843596, 0.12739375417109433, -1.6538257081168002, 0.9390357517248558, 0.03906200445416105, -3.270364041560466, 0.29776365247487907, -1.3483081735942193, -0.32071075943336735, 0.964545214307181, -2.2793623541833656, 0.19997229463378272, -0.8007004977516798, 0.04234677992994418, 1.5128935064214408, -0.3079412263884282, -0.3498059858009369, 0.923904983914334, -0.6394421359959662, -0.025556258359225734, 0.9490805421309046, -0.9486424860447954, -0.031070425769556473, -2.197129730112987, 1.4408199346203223, -2.2094833489229515, 0.5747580259867392},
    {-0.7032107928127456, 2.2994443281941166, 1.7593316372260768, -0.7300462874291277, -0.01767744868916569, -0.17238123517369544, -1.2088478793548785, -1.1934983460416608, -0.5083602166206944, -0.16547010415965568, -0.4385725915348398, 1.9371971630699165, 0.4836145230426578, -1.2072658302347512, -3.487710889867155, -1.339700789054967, -0.324850985042399, -0.1499351266223265, 1.1324273272999128, 0.21265842091493642, 0.9479741869880034, 0.2587660117358206, -1.2466388621766593, 1.383517265546085, 0.40367609882556327, -0.20543937418488237, -0.14578467644571252, 0.7553126540885449, 0.7193409638822753, 0.22452668258747488, 2.30566374081698, -1.4338777472554716, -0.8917667813222934, -1.9179168835565326, -1.4540572709765025, -0.5442168275683025, -0.2670743724523612, -2.070946190404817, -0.2503689298134053, -0.39783103180285295, -0.8504233923946606, 0.48998257089795566, 0.5940714771614809, 2.4397205010695626, -1.7160067231190297, -0.023229906038284714, 0.11418094754934732, -0.6213293626998013, 0.3417900178540956, -0.10440112391295152, 2.031985009045581, 0.35891528849256427, 2.746937189368503, -0.7857511576309483, -0.6138117859654854, -0.06751247565627087, 1.2626074651097101, -1.3421926168216654, 0.586476043494016, 0.5013963553148889, 0.34755982114672046, -0.31089854112811344, -0.05619984885918471, -1.0125287946432842},
    {0.31741400399743525, 1.8375198322120176, -1.1593120834077604, 0.38940070937666027, -0.05537688217768257, 0.15483530386282832, 0.050715604629248776, -2.523750700311435, -1.5155840929747986, -1.1949799371024412, 0.9563178835997909, 0.48728655473710963, 3.21500638008924, -0.038004335959296996, 1.4341623764995812, -1.6390775195966838, -0.7670360250666954, -2.1786679601654164, 0.9522802461138973, 0.2917729877443461, 2.865512692704626, 2.0014660057888256, -0.8834398588500961, -0.7415775243536894, 0.10017653747757145, -1.1449592584109585, 0.16468198872904613, 2.0998860837908238, -0.39829680778698295, -1.5593721105967933, 0.07052748392799191, -0.994077261732473, -0.5499400100568442, -2.9044972691879454, 0.5370019944356635, -0.8967624075455148, -1.0689117885890742, 0.38893097723661396, 2.1547543182605104, 1.879605738550108, -1.5349216261134402, -1.3592399082548534, -0.5039941169586458, 1.5386824433390098, 1.600377984591227, -0.40230242677375616, -0.9097605767210107, -0.7465699109030984, -1.6868073768705583, -0.27961093201322634, -0.8587939190783822, 0.2340408734077124, 1.6890719355678587, -1.9016106012903455, -2.149889455456957, 1.3167397254136697, 0.1856560466676073, -2.2545601030913245, -1.393539671820577, 0.8490229220725093, 0.9914961041682577, -0.6262847836544034, -1.4871985140608839, -0.2880579302552293},
    {0.3038930730188784, 0.6115165113407284, 1.182981779592198, -0.6282364919826515, -1.1670046084906422, -1.4709507016714636, 0.7585545646040447, -1.955044095303863, -0.7534307132542646, -1.5200422596305048, 1.0545589227557304, -0.4737261439756674, -0.5426199292693699, -0.6352600704169168, -0.31105632000501365, 0.9617865240267214, 0.6727903414191375, -0.6029597684063158, 1.6564031454638084, 0.7344594859745208, 0.12232248954905496, 0.8678483799135516, 0.20497698261427388, 0.24323507343464867, -1.1255672547367157, -1.089703061659639, -0.8687634271444145, -0.30401609764538484, -1.2181858880361331, -0.31793480549117187, 0.09589059968460895, 0.08397099976623691, -0.6803966544332115, -0.305726744849951, 0.42017195681380975, 0.024155571013026653, -1.03766845413651, 0.6356007254726858, 1.118455103303029, 0.3434278128012243, -1.1211609596776702, -0.019557734880241876, -0.4610914959682933, 0.12768471566634776, 1.8062727607157092, -0.6565147270356572, -0.5921143007563573, 0.5281491771089533, 0.4413191890958359, 0.14583368395995175, -0.3306223061521729, 0.29507514998832557, 1.318662197803719, 0.14108508134086073, -0.3041291826214033, 0.015545958505804697, 2.012166914012571, -1.0100688510984404, -1.2076728731145145, 0.8189184253077911, -0.9088670799696514, 1.3094784743392158, 2.202576309348794, 0.6228636717626894},
    {-0.7378407449458662, -0.5971569447238779, -1.482056101881417, 0.26628190790064615, 0.7800731137313578, -0.9092470094641913, 0.1816232268945936, -1.13682095808675, 0.07517647641574234, -0.36826593530327856, -1.2370981458469192, 0.39276867825480144, -0.3541980771455969, 0.4148942307405331, -0.9439663716699828, 0.3791537579962517, -1.2867951474669528, 1.4562847346154721, 1.875458539655305, -0.5547978879438851, 1.1175915298827004, 0.8429207219893943, -1.2269008973014153, 1.207013143668886, -0.9143492859783813, -0.6434427451825581, 3.443435117046649, -1.976644231407985, -1.5213777008420244, -1.3605536857678207, 1.7833439958350465, -0.9490740705935707, -0.7132117684116923, 2.1226976816638943, 0.478450848663738, 1.098877860216846, -1.3464581292846198, 0.458172140629964, -0.3648804430595948, 0.9144254809880833, -0.6645874654991262, -0.7075597031904094, -0.8396136338729774, 0.7584595071513999, 0.37065191322585306, -1.1310745318577866, -0.7454074178785566, 0.12792544111487922, -2.2094635483072995, -0.1883195793354579, -2.966415754400565, -0.10006680760689407, 1.7695679579761519, 0.5747488762694943, 0.3592717818884789, 0.5636498023544159, 0.39918305130712817, -0.519836833507715, -0.27773494098445567, -1.4772823026748525, 0.6287974293547046, 3.550180186123765, 0.6959707188384501, -0.24981681079120957},
    {0.8855689844279468, 0.9275565873047318, -0.309984368615752, -0.3335271594043381, 0.26315207067563784, -0.2663428468328712, -0.1362317578421356, -0.3809136006134349, -0.6156541692798129, 0.7248559628146359, -0.6212422459259939, 0.5785772268853933, -0.8486883772399805, -0.9408995279603958, 1.84047537723676, -1.2343963335294765, -0.6834287265341285, 1.4032898760776393, -2.3636141100177768, 2.4163520016318114, 0.08481355655488111, 0.18741548255426305, -2.2933875681644325, 1.009606912171431, 2.9049424933921713, 0.6215463264828158, -0.05273127643154188, 1.1219426323911876, -1.5974843677265795, 1.5239457397734877, 1.9555498255965105, -1.0650149714959207, -0.9535363834909651, -1.8617891833045077, -0.537287217751154, 2.1219205468364923, -0.35010610577541895, -0.9920478826729394, -0.7162334098463028, -0.021020700207905398, 0.7007142096449013, 0.47087907319918454, -1.8503439300852047, 1.8589668408918483, -0.679046935734597, 0.6156592238422203, -1.847708811273815, 1.6620940305208105, 0.2968202112213022, 0.14798509029181395, 1.2971866033361115, -0.0481719027984168, 0.5766404738165927, -0.14772783857842117, 1.0593674787839162, -1.984351624641163, 2.141191939875793, -2.9910243098805216, -2.3126443545871407, -1.164731692942182, 0.3738597538537159, 0.09719296576993171, -1.4984582847364627, -0.0305189404901346},
    {-2.1962822038623693, 2.143552958601921, 0.8102218887294219, -1.6814425307326022, 1.2788391758217654, 0.11831039917436757, -0.18446046032995195, 1.419436232444375, -1.287984564802502, 0.2765916398475431, 1.5477087609812425, 2.8424035040606896, -1.3576774525577524, -1.582446297040949, -0.016814721526262268, 0.014991596425235043, -2.344206532596893, -1.7029475736440693, -1.0896717557950746, 1.1265273820455155, -1.4591547826484517, 0.05242783647285298, 1.3838630270481822, -0.015844014777124327, 1.1584648613986497, 0.6787225632478491, 0.31854400791484355, -0.968611039981151, 0.08000711023951321, 0.8345240322113446, 0.5844902585402015, 1.0696401201275942, 1.5785185407017215, 0.1642609502575553, 0.8716949727169082, 1.6443254519805166, -0.4657598696708375, 0.07863947745903921, -0.25870107883857585, 1.19067308793817, 0.9950883335207469, -1.0851011320858193, -0.876185206123962, 0.37863787198334786, -0.5663246875450485, 2.1797047958589126, -1.8026466566665145, 0.6107327312616345, -0.5181294738251945, 0.4301835282197958, -0.7689142330668067, 0.834911280678909, -1.8872705771546732, 0.8052673901915215, -0.7548057769223665, -1.5141561621331399, 0.2755009729940548, -1.9407081461683078, 0.00040067606853630335, 0.9961361421151197, 0.27716748975379063, 2.42187631989978, 0.8927972759489277, -1.2642189519640532},
    {0.12950649607276052, -0.7119475462144196, 0.1533122569427671, -0.611180369839624, 2.6162078899486785, -1.2468777719737014, -0.0921704253679353, -0.3420496886194518, 0.7301568029888694, -0.14732665732134406, 1.7400957303408817, 0.10493177391490524, 0.2832193447146, -1.2651701397275559, -1.1002473181582995, -0.22697288860732326, -0.9028354148713572, 0.7013697763679521, -3.1451856010878987, 1.6494106631526833, 1.329026626714297, 0.8217519433616232, -0.25880031257397706, -0.05807631590843099, 0.9504952667894556, 1.3351537403816554, 0.6278587068275873, 0.44333650457136803, -0.4316562292062185, -1.4356685430406404, 2.505102301226413, -2.009749800518604, 1.87828546891451, 0.7536593422987116, 0.3548070807188374, 0.08905549975602249, -0.3447286339468465, -1.833646422806703, 0.5072086937691603, 0.6887727370243868, 2.900993480424798, 0.6670481746438014, 0.658473258416725, 0.750924937606095, 0.8708102647176985, 1.0211181743198674, 1.6435629871042063, -0.1585327411962349, 0.609199686499118, -2.2363723536089677, -0.44280754964423963, -0.5048092996572727, 0.15338053828247894, 0.5353771987806032, -0.1504673533526178, 1.0055994110301512, 2.1741796194460776, -0.3416162004616107, -0.2853047803840261, -0.33846093715134484, -1.4752566577082626, 0.45659759920175647, -1.2623442897346662, 0.7847007789944738},
    {-1.0807234480389123, 0.8694281780081055, -0.5834194781625373, -1.4390379469477126, 0.14069060393848307, -0.5018736258615031, -0.6293623530785436, -0.018960037849352906, -0.17650405862515087, -0.3211844332968081, 0.580060695769152, -1.2513331807018888, 0.2875601103114349, 0.5163939471290142, -0.7492978297042101, 0.13539153195336232, -0.11932219816668786, -2.4248486272812464, -0.9766645424889505, 0.13763183498084552, 0.39811509216062174, 0.5544818170885473, 1.2919941733700022, -0.5888922470933236, -3.2792573846384445, -0.38361159870077327, -0.6450020131546832, -0.9378036582395617, -1.3851301223219896, 0.2430987466832698, -1.7998820048630222, -0.5180682230067062, 0.3400265909602063, 0.4129143781016352, -0.7511612671651037, 0.013872892112002442, 0.4261540500111993, -0.5391890372447004, -0.28103943006894694, -0.5545074225166742, -0.40665161451313675, 1.0713246441412037, -1.1172310232088323, 2.0160241917972024, 0.6673331229894027, 0.06435502204463125, 1.0373641478938462, 0.4556092198529713, 0.7170141784601962, 0.8883355706648003, 0.7407548592558586, 0.27155142657001063, 0.386060959194576, 0.7259258235099316, 0.09885866687944186, 0.9774761441385246, -0.7030644747789334, -0.4579393459778276, -2.038329066075432, -0.7286587876137172, 0.45888776804320336, 1.8396046304715317, 0.30996626222238916, -0.928746824943553},
    {1.586100968805201, -0.20895395440576464, 2.0313395325321024, -0.5821908584370792, 0.5365625558147079, -0.5053508609467213, -2.408778470653395, 0.10805490644153204, -0.6781492692070111, -0.34703929057581007, -0.65242645040121, -0.4967215129058588, -0.33767815978764115, -0.9622781539968064, -0.3222968238038424, 0.5642658680854925, 1.078847439786079, 1.923418753094172, -3.2367297367092362, 0.33504105232576714, 1.3090911983221085, -0.27639604523667394, -0.7262608326558649, -0.3657719888347341, -1.6775459915870752, 0.4132232137778705, 2.203566296647136, -1.7616428944745082, 0.6669771864189229, -0.305031357091984, 1.2718966615338434, -1.0404162458404298, 0.2211964933020923, 0.38177780555517715, 0.2606200643897023, -0.6300934952896182, 0.11607042878572367, -0.42459799565653306, -0.006455954606365053, -0.2720689598734207, -1.0424452868671892, 0.8864569611756886, 0.961640390380439, -0.48603281678779386, 0.033280747528246155, 1.8313569151160038, -0.737960447811222, 0.6288754329679443, -0.8780922306491168, -1.845464571527309, 0.9965551445937338, 0.5322997450764907, 1.0651977579368592, -0.0700619818787764, 0.3533616706192214, -0.13806815216925167, 0.6507348581724661, -1.6181876415602205, 0.24295206566327462, 0.16784675132391674, 0.13682192889824615, -0.13122231469133017, 1.230950179539109, -0.5807347788297119},
    {0.16847160618408416, 0.12960596606728214, 1.8733065346834012, -1.2896775760086598, -0.3140270698822856, -0.988423270181257, -1.3900186358741746, -0.39171829694226434, -0.6678970451941448, -0.2464619268878845, 0.20161411063461157, 0.636053163778847, 0.6632375478726388, 1.5304513486930418, -0.7683500233461287, -0.17338098775473623, -0.8923686600042415, -0.7341139936179345, -0.13642535886078935, 2.4946672702438595, -0.9236162174439005, -1.0703385791395361, -0.7692638890762817, -0.16965732791482452, -1.8864757089079176, 0.8442985333762387, 1.5010061703208757, -0.7270084054022771, -1.8767040240002306, -0.1753391694884324, 1.9795586496039141, 0.11818867900894552, -1.2303363095952895, -0.3765254481445386, -0.12033098048234159, 0.5647630174743502, 0.44096934098953927, -1.9839517627227998, -2.017120612160285, -1.301518621856956, 1.7780257445966503, -0.6568199722442845, 0.49942458226771574, 0.3005363493326622, 0.27728088342656004, 0.008653081976316432, -2.2079204524311207, 0.02964447671945615, 0.3457709022411657, -1.9278905965405275, -1.0197373526426707, -0.27081769194330807, 0.5059827596613983, 2.1463976746249105, -0.9469264192956633, 0.51964242409903, -0.7655485975747303, -2.062106574474996, -0.9173138107387215, 0.6193149656646879, -0.22142783039753827, 2.128611290947301, -0.26828388982945334, -0.49314615941527773},
    {0.7305332486035606, 0.5658973429542993, -0.5412699107711314, -1.7438757659932431, 0.9706179799294424, -0.6258596157955095, -1.9002780934459802, -0.012554954345582306, -0.7964487352681042, -1.9483666778136737, -0.626616597066249, 0.8988997727913923, 0.3560450429221754, -0.7253287487758987, 0.45904077894827133, -0.900224332155465, 1.2469298402801148, -0.30120643088055404, -0.071492590357174, 0.6935343904244177, -0.7677601109159685, 0.6658046146244115, 0.269665965405733, -1.7895714656265926, 0.8423770767067703, -0.17075765589708966, 0.45380868750024006, -1.1407841002568613, 0.9579438794195869, 0.33963784026249755, -0.3812208766905413, -2.3361693843761757, -0.3325353462124882, 2.154284313684506, 0.6105133488081746, 0.5371925276369491, -0.03721631463020278, -0.6367886432466185, 0.7296216150783241, 2.1705181946360677, 2.7055675259142014, 0.551645511588763, 0.317489516827444, 1.2980541312295424, -1.3110466052733245, 2.008945984612686, 0.7927684940300783, -0.18392335025525305, -0.6376593158829089, -0.628353703461674, 2.0132182946009753, -0.5819373574081246, 1.05602768521485, -0.34781122835117967, -1.4858769727774368, 1.4496284903902745, 0.671439805560565, -0.3597668762144953, 1.001518142882272, -0.17450665172088609, 0.6599974542287512, 0.948890148856704, 0.36864775886831097, -0.081884071993145},
    {0.32474854957515764, -0.4688896934780804, -0.1657500924211829, -0.8595946450786865, 0.1392697194836503, -2.284749764484545, -1.424931346426113, 0.00915285613668407, -0.4749583254503735, -0.9009025536374994, -0.3210751123339715, -0.10533934916897988, -0.44352474592738717, 1.026513246938506, -1.9890701077075987, -2.083805083746255, -2.2690454009050263, -0.47007860720927996, -1.8829268182109629, 2.639703335557871, -0.8493318888522716, -1.8225114783616907, 1.1183694766538816, -0.37008382834684334, 2.7482049471874954, 0.70020711021909, -2.302680194744235, -0.609474288548224, -0.43937380494728706, -0.5572518874515815, -0.6518715194358684, 0.9468473758720297, 1.0395041383715966, -0.15895194124371778, 1.3064034256039612, 0.47836686288336877, -1.122754984005509, -0.5513638258986648, -0.9395799493506186, 0.505571178686465, -0.3029353592606664, 0.4384671743278898, -0.9568472043840751, 0.8361515634213359, 1.0210114974335358, 0.22754865202236632, -1.009950505409991, 0.03490255495824521, 0.15522498144716004, -1.0304015064828107, 1.7597551699549654, -0.9435291108834483, 0.9522494085298685, 0.10639483651652716, -1.0474946815366826, 1.7663655966021385, -0.6428064352051843, 0.9290325825141195, -0.5922706419044892, 0.03448932678026595, -1.7693456406414796, 0.0546220604069599, 0.23211423855802285, 0.6473858858313936},
    {0.7744150922563914, -0.408576825982576, 1.4413710023897455, -0.07898204281896654, 0.17088479152046934, -0.7618769832432457, -1.2468579868200689, 0.1318445869014221, -1.4745194231292282, 1.003466883360905, 0.6037529022769141, -0.35021715375379286, 2.209446453291044, 1.4600060122937053, 2.391805445164915, -1.1598388379181273, -1.4089883660666314, -0.22781491165846143, -0.078357947045582, 1.8178238927054944, -0.7529069983886457, 1.0546753358996028, -0.2850372068701535, -0.5376317907280895, 0.6277108517388296, 0.7768060795719571, 1.486440319271943, 1.5098614779204231, 0.9992823351876193, 0.3368016554372855, -0.21850376573667307, -0.1353253010690079, 2.336249927182134, -0.6591008217342864, -2.348444245578635, 0.3022780971750556, 0.3058618354266232, -0.8803757619240061, -1.5081947058498668, -0.8188192391631502, 0.39634959641249257, 0.7018434987338175, 0.597549847046754, 1.06751203099064, -0.14461131096098157, 0.7355880047188231, 0.7835947173676661, 1.321296218037158, -0.023832577578025697, -0.5247247488443109, 0.36047487394035, -0.7981567817648326, 2.6442313998174036, -0.45766721150365536, -0.054000155598417636, 1.508208972554153, 1.6173408143123225, 1.7801894410902932, 0.8386101179417876, -0.571223414731828, -0.3673298383640732, 2.2652943289812137, -0.7381063145840929, 0.24360962996359425},
    {0.4522669130788697, 0.10055959148483089, 0.051784195792407915, 0.24823435345595696, 0.28433672059994725, 0.5499965407262127, 0.37031368861598135, 0.1069721579274755, -0.8385193059669525, 0.28935974524629504, -1.9047805310225245, -0.4035420504773455, -1.055029606743297, -0.06899896665958574, 0.520759229792793, -1.3588767583636905, -1.80647913198143, 1.2602307524235794, -0.40800512183904974, 0.5407468057026787, -1.4054646664127695, -0.19400543473248558, 0.14083967548085974, 0.25029997349639715, -1.0878641512586988, -1.0263476557214621, 0.19275781668542927, -0.608900595949876, 1.510660605632964, -0.6107027291368626, -1.974588045669333, 0.04108254129401987, 0.35905782509979234, -0.5042885601616285, 0.07585283308775151, -0.4564695684372977, -0.5624949933834771, -1.4325951444564458, -0.4542479927576576, 0.6878169568421689, 1.18143975664011, 0.5719335492102318, 0.4133860109916883, 1.832414568442257, 0.009834326063553361, 1.1222937489658258, -0.8881450793158179, -0.17295241489557237, -0.41183557329894205, 0.19658635239159036, 0.1719589061358203, -1.629198364512654, 1.0525572515620707, 0.5244711394372453, -2.618781620449611, 1.19826870657922, 2.042547886306767, 1.1183653042401867, -1.1461692049644236, -0.2979770472633618, -1.4418352171592226, -0.7002039797717559, -0.6757542977758376, -0.25935287549136177},
    {-1.1629308077204685, -0.016054824121909766, -0.4802173000232518, 0.5162888528037266, 1.5136179848069002, 0.39212796730577704, 0.8260881015110617, -0.7160056660821814, -0.4624457857670354, -1.9673733498385655, -0.48282216110930537, 1.4299639791647758, 1.1181272350813174, 0.40940864465704, -1.7113817015674027, -0.2796863520639836, 0.3762275388528221, 0.1601368113569365, -0.8434544349989069, -1.1658263358043206, 1.7849389424407882, -0.38963856283477327, 0.8460191021962047, -0.3209777179078788, 1.3705734913221534, 0.8634809019529369, -0.08019478105988817, 0.013797112956613209, 0.4284585241185859, 0.07150482811708457, -1.4462320100041097, 0.7704555765695361, -0.2493833552199209, -1.4786118562508392, 0.08434044655427475, 0.4146057235295149, -1.5321721319574835, -1.2226336595878209, -2.032161889325635, 1.0723347713209443, 3.6886514457307085, 1.4989471417048945, -3.2379793898756133, -0.538594353456633, 1.097691001744228, -1.0644779471135237, 1.1788668478672701, -0.1386173538384382, -0.3925075549097233, -3.2932795590828388, -0.05239910847353228, 0.5250823218848311, 1.3394460686831142, 1.7553634299479264, -1.1229648370479615, 2.0062743233760894, 0.9546400277141591, -1.5769864562609772, -0.9527898235598635, -0.09519750328208254, 0.28844074651698787, 0.7595683276815163, -1.0191741908193768, 1.955979795887671},
    {-1.6008247843152856, -0.35050482533397137, 0.9680674972732017, -1.2676529981463591, 0.08836596412816178, -0.9765228152818308, -0.007883151784226966, 1.506029667020291, -1.2694774181825996, -1.638092380734205, -1.3570717993465842, -0.44836524626634283, -0.2699305140038068, 0.46178175894124, -0.8522734413141437, -1.1621430707017237, 2.797419103730058, 0.3463516108443478, 0.6309163668296419, 1.3594573451556093, 1.582094167329697, 1.6602807302691855, 0.40090835913925527, 0.8512012766835305, 0.6821828734813802, -1.4800568225823825, 0.5507054097436389, -0.7060254826317758, 0.15651352517373432, -0.6514538059797128, -0.8063233887415668, 0.5941309764802732, 1.5930679038332514, -0.7298025463418487, -0.8432035781089501, 0.19449570916284578, -0.5234022181507136, 0.5374525364677618, -1.5148865630814952, -0.23166295434286396, -1.3331875504200168, 1.8776428146608024, -0.8915066970853908, 1.4256704583576163, 2.140975714041355, 2.4957177958451418, -0.8905288646585481, 0.1352364839670422, -0.15256469653868604, 1.367411682825228, -0.7046175201189141, 0.6477389144938014, 1.622454746683284, 0.03748558196502845, -3.225186249292593, 1.5795661513641663, 0.7242748167157603, 0.32125834297552025, -2.0107769877728416, 2.8862932143735, -0.18226569194135409, -0.5451076070476368, -0.3480986729393307, 2.270854664982659},
    {-0.4112408663114916, -1.0971374077804048, -0.15350672304179255, 0.3147517268558001, 0.2359965135978698, 1.1544645887751646, -0.8856439574513022, -0.3895117540876634, -2.8895738418910826, -0.03284905323756445, 0.0740782016997578, 0.24248352416118954, 0.6129681876975263, -1.0747846520069366, -1.7874779873898425, 1.1876522367148206, 2.009143620754227, 0.5071648551052965, -0.9019002078293706, -0.28392713042556234, -2.100024154028286, 0.3714950220124845, -1.6066709706468723, -0.6183769604785966, -0.6659458461813558, 0.7396606747452911, 1.0151806490301203, 1.0782294058762216, 0.7049909862898349, 1.1035776632772942, 0.7771895239196991, -2.0153292273844308, -0.2533760237920034, 0.34233870640206016, -1.5674884041091848, -0.18616908712116118, -0.9842919831427664, -1.7328947773246104, -3.5344781305192097, 0.8619543180465759, 0.622007523157116, 0.15858596635128616, -0.19332994902951883, 1.830381806360096, -1.869368451683543, 0.1962725668542281, 0.18037594489939218, 0.5722606642567353, -0.10655558798004472, -2.0741900659655204, 0.681045132188509, 2.5394372408547667, 0.5265861815935325, -0.9702470647004302, -1.7702604329249247, 0.2903310662184124, 0.6771132226218377, -0.7161931647539584, -0.738602015682368, -0.530069837863376, -1.970466313179838, 1.761575015770731, -1.9087320390037625, -1.7518055075396626},
    {0.5099122919776201, -0.3357035578630623, 0.08983649724668907, 0.9307259159179553, 0.6424671224835626, 0.1012343148705144, 1.882480211663018, 1.3152856920627027, -2.014675354429774, -0.3492098396373442, 0.4374161219559491, -2.0291619242908294, -0.9364900872936374, -0.24367009844471071, 1.1133477050545688, 1.3189755614081755, 1.5967111543118062, -0.5431952619548713, -0.07005308224942235, -0.6573494564710229, 0.7752152161121646, 1.9041360888219234, 1.44981937992561, 0.8542316058788075, -0.34147211454846277, 0.6038966372176798, 0.8255706391300404, -1.497804922680614, 1.4708025152766657, 2.2697154744654964, 0.33252345977210557, 1.4418530579909452, 0.08600091835208096, -0.41208155042680344, -1.4671089697032234, 1.6990747576075795, -1.8927489557643145, -0.6168000725426597, -0.24413605315465814, 0.015855243599372005, -1.3267604243114781, 0.5913542423301438, 1.1554379280336207, -0.1683688790492988, 0.6976723857508011, 1.4302242994374668, 1.561477859779939, 1.0703083875165023, 1.485686826847069, 0.3964038356262901, 1.6653358180768685, -0.8335433672479516, 1.4668676402832583, -0.2510364220278123, -1.817941073658441, 1.9699071281917742, 1.2415591527547125, 0.8996367277403685, -2.5581265492719414, 1.5981400703670126, -0.7260227521509379, 1.1855170508005486, 1.1871732294789628, -0.22595419909521328},
    {-1.2682395425888497, -0.6208238676190407, 0.20915157479286176, 0.039501863819897766, 1.4426065123143947, 0.4644002988685109, -0.7529375725888069, 0.8964531669626588, -0.880418918662253, 1.013052468039216, 0.0013896453522558383, 1.55794448035944, -0.6544659197776677, -0.8601006282999676, -1.4283188555158308, 0.884056326983953, -0.6689202933720321, 1.0426290161222493, -2.257162597748479, 0.2762582380949894, 0.6636147784577815, 0.05575262643951241, -0.549793474673973, 0.050835762632356674, -1.6924787127705485, -0.5270659907034791, 2.276994537725432, -1.182692848603418, -1.512842546362279, 0.1371533479980403, 0.12863049627925038, -1.8986019754122203, -0.4684634247154884, 0.15962572198296254, -0.5137794663179047, -0.9320774323840868, -0.3525338776711178, -0.11542518359852415, -2.223860842187933, 1.3818268985591433, 0.8947664500037491, 0.4073628033473189, 0.31290327223957215, 0.23908072715522935, 2.9727815817749015, 2.2034556056029935, -2.293441533715608, -0.24287627526066277, -0.9599920708582562, -1.0068374315378514, -0.7912051064089873, -1.292681592266208, -0.5018938137987646, -0.8840817926417901, -0.11444991517131015, 0.2819351290582669, -0.11336093262501906, -0.904757310142038, -2.1019282848027756, 2.0639354428192007, -0.6349853796204885, 1.0366534351180345, -2.012591027356135, 0.7467674094844893},
    {0.7338640652888814, 0.8337227260522275, -0.15695495727225928, -0.41301933319656675, 0.5156371435667618, 0.7098130909738476, 0.33720159354696067, -0.02634071035563837, -0.29894863574367997, 2.335905235161784, 0.25760126866732147, 1.4511096067079203, -0.6160355158126011, -0.17373301015388326, -1.3017120189315206, 0.7398194983005345, -0.7113834595740809, -0.22697486210545728, -1.3417478251880637, 0.35936165811215265, -1.0189647207986712, 1.3043152104666154, 2.54989681467519, 0.4740618136047862, -1.1481981123783387, -0.8619947769661302, 2.554736042054933, 1.187306467776028, 0.19980871388701646, -0.23446272876711535, -2.3139560944700186, 1.6553360686907685, 1.4785061768488288, 0.16688084262385658, -0.09406385449738536, 0.14410423392665664, -0.25133720438375406, 1.4805372798022336, 1.2215549890163138, 0.4577518004905793, 0.46086200346649386, -1.4887716913391476, 0.164941521432554, 0.47357391110682356, -0.20050418240423265, -0.6374069042868216, 1.10486116340604, 1.0032214916930031, -0.5200726284142442, -1.0325617676124232, 1.2082523619081291, -0.6545838190528879, 0.40558896885332657, -1.2086435424649882, 0.07262339623308735, -0.004020265153179629, 0.8092114123476214, -0.8024275875570305, -0.11795658402152642, 0.61554059669636, 0.911243295056683, 0.8163308556302246, -0.9526865610415317, 0.6206444583328177},
    {-0.8169890413969367, 0.7931530203616584, 1.1979751968233352, 0.4757137421794053, 0.4868974956554237, 0.2501435550889605, -1.1563554890232024, -0.2746799771227191, -1.4029103661098827, 0.1070640985239574, -0.8487138152835847, 0.35059005419471995, 0.003075549796919099, -1.608459222888982, 0.472522382894133, -1.2796315692532227, 1.3789379794596253, -1.4655525319859046, 0.5884198481264062, 0.9519596018241447, -0.3718655103198979, 1.9969615676618195, -0.02178662484006248, 0.10015257039234773, -0.7600386490227127, -0.11428161334066816, 0.8531940428056454, -0.6337600895007968, 0.19214784376938576, -0.14175819446317178, 0.6185151586777929, -2.8764452761949015, 0.06579989204306098, 0.1536121087095261, -2.71882275402245, -0.11714977353323044, -0.844062443064644, -1.6706251734575899, 0.6853751134997125, 1.730524516783874, 2.1872851906932387, -0.7723732768004237, -0.1683107066456, 0.8303319534628243, 1.1081971801299517, 1.4677376384675653, -1.8798252781582236, -0.1258640482961586, 1.0214133036880122, -3.496357230899891, -1.9476114059590637, -0.3201601428435456, 0.42977991217176065, -0.5809604163925038, 0.32382978443175725, -0.9674078822945932, 0.5853956036118443, -1.7493563733747235, -1.042093984595485, 0.8354859227120446, -2.2892398576663333, -0.8515704184763646, 0.3799837193376398, 0.18945422996606684},
    {2.4935185463855856, -0.35202982445785136, -0.5916361816044817, -0.7447731042423587, -0.9171555089041099, 1.339557461692758, -0.5846149141905725, -0.6386483699389732, -0.3516090068427157, -2.0635685928976057, 0.36024594212606986, 1.0193085719923671, -0.4436243137067021, 1.0373143421688718, 1.1715182892237717, 0.2320082340042237, -0.19881763570237995, 0.5056026753260052, -1.3513389288907323, -1.5336439685857168, -0.0481686796256232, 0.33246889638861, 0.45607009861439446, 1.2281380759386364, 0.06968605197480562, 0.5953105038609661, 0.8591865719966854, -2.078802728240847, -1.27040355247105, -0.4426530388682368, 1.7782771560899215, -1.7807280345596763, -1.3518764448693945, 0.28735748927331123, -1.3363492908023265, -0.49343438812854096, -0.08529834898859129, -0.0411865688828901, -0.9335234045780745, 2.4415008224091883, 0.1469362045947832, 0.03661070498923808, -0.8310691085831236, 0.510901266514492, 1.5795519601314254, 0.6480767972557306, 0.4512026301508609, -0.41744621576022045, -0.815940525896577, 1.1232939203271626, 0.061841261149085225, -1.2648054030395897, 0.4441525824405677, 0.7400227042768079, 0.09295002122441502, 1.5824073163989205, 1.2014308268505964, -0.22867649252042227, -1.6873973506752973, -0.8530165851761895, 0.5982983163803203, 1.331832802867206, 1.3056233521646474, 0.8917676437517811},
    {1.1428183412323893, -0.010709300260934983, 1.705927278678737, -0.5573909918238357, 0.8974955067681031, -0.8872620385643419, -0.5844336752241855, -0.37434339631430263, -0.2502988640959562, -1.5822653003971974, 1.7372284195237506, 1.973343815563649, -1.584434962638424, -0.8919589811109153, 0.2580654694410354, -1.2249326349324337, 0.7637515109070947, -1.3391491122068895, -0.795201502576035, -0.026372861096554553, 2.253480022514152, 0.158248510334564, -0.3170552426651481, 0.2803257777377587, 0.42058827902072565, -0.27858546052157446, 2.52422928103449, 0.5987718216954996, -0.43185125111035044, -0.5600135292887016, -0.30431405673265843, 0.018889266747684787, 0.5429315042624094, 1.2226342027997963, -0.512025611116152, 2.7126339288491623, 1.6104830421410554, 0.042062409301016145, -0.18339796311926285, 1.5753101359467963, 0.5105745637195477, 0.17395710524986097, -1.4854536046096258, 0.6732575556823583, 0.28663862762760206, 2.592806535201035, -1.0671203407077599, 0.4442550283907485, -2.27741252535461, -1.3181247481287577, 1.3603401427226387, -1.042872629514439, 0.44807379177928436, -0.16198990568809601, -0.3133812484961928, 0.04456158035067986, -0.377488030848622, -1.9091599856521708, -1.2572984693250107, 0.6815847456142494, 0.727550064226128, 1.0584471629387247, 0.34413713072246016, 0.6524229969583539},
    {-1.2260234001406314, -0.7146162445906034, -0.5083071580983608, -2.4926492398457283, -0.3689578585130405, 0.015146406183854134, -0.6485047818484283, 0.19268109732559047, 0.129934691601897, 0.10920215047104008, 0.2632323894742988, 0.5971662065127877, 0.40908695483590474, -0.6322471845112517, -0.5264157464682767, -1.2780629519340554, 0.5808089554976354, -0.49098810045367763, -0.6218538620384668, 0.23930057478102135, 0.3501663295864564, 1.341180210963004, -1.9611379089372951, 0.22878623292804015, -0.42546887865012994, -0.5636799517406914, 1.3310483631502652, -0.20202837212430966, -0.7713092557492387, -0.39163014119873435, -2.0177918287271703, -2.1210983769207026, 0.3804119028169156, 1.7008046226739004, -1.5254819505008468, 0.24004147004201715, -1.1739524469699685, -1.4890551072819054, -0.8297209108855597, 0.6448036613954232, 1.589706839517121, 2.5227899536923806, 1.462078932366307, 0.527417967949881, 0.7474089767024983, 0.4560306032537174, -1.1817171876330113, -0.09113252700625131, 1.37828637371584, -0.7056077870521579, 3.074502214005159, -1.243151038516113, -0.23797303923688834, -0.6466189342581294, -0.7971387363711809, 1.7107074282585242, 0.7904986667992427, -0.0004757904850465144, 0.4254706217670729, 0.006961665553690907, -1.380102655225874, 0.8672851202105364, 0.8521223330108889, 1.235964797099635},
    {0.3535933950900181, 0.8439871357338291, 0.08490911049365472, 0.9957151974209514, 1.2904972929268328, -1.4032104751814432, 1.0048632990124442, -0.354208181409398, -1.5052001255985326, 0.40723345895347646, -0.27313286386173335, 0.23330970515451657, -0.1420669820553703, 1.7805687338779455, 2.1783144771190743, -0.20475476702926312, -0.09136290516189269, -0.07661639153703952, -0.12966729689015802, 0.1687237308692882, 0.22815872403318538, 0.4848499104884, -0.46231495708129366, 0.041862733673364336, 1.0864776825908304, -1.7365276221747161, 1.8695738459615083, -1.3883897000075975, -0.08770092417852268, 0.671193503510471, -1.6495123716926805, -0.0744103359494706, 0.7087929075261624, 2.0132513789470394, 0.42297402990494903, -0.47575722250767244, 0.8918116681063831, 0.12979879851384205, 0.30302332102269247, 1.1771502681593429, -0.6755868021405601, 1.828417343201261, -1.1169933816804574, -0.532292069595656, 0.24992300210475238, 0.6356648193436286, -0.47565847318181553, 0.9177045248668079, -1.5261617872517887, -0.6638628686226071, 0.9401731663048405, 0.0969106837158811, 3.483733182381365, 1.0138072031203011, -0.39613841235602143, 1.8896937144715342, 1.5786620312808384, 2.3086623581515178, -2.3319546853115996, 1.377632944433339, 0.06409379687399898, 1.5428301982116104, -1.6723014214561533, 1.5401816537977895},
    {-1.95515478352112, 0.5173066732090138, 0.06921493887402222, -1.0227037703447681, -1.4428119978891276, 0.63413226874012, -0.9274584850875897, 1.3544024190299886, 0.22545092002182826, 1.0916770516418393, -1.0894710955776776, -0.22249801145191148, -0.6634599024645338, 0.013932957780265745, -0.05909681567285052, -1.8361766994573878, 1.2130800163123214, -0.758607965569771, -1.6632743377328596, 1.1395299917556931, 0.4905830208285996, 2.392962192799469, 0.41028329528076374, 0.2813779232527442, -0.3049873140539996, 0.5372319472821315, 0.6075505866275175, -0.3576946972202141, -1.325178196792114, -1.3529874966776583, -1.2407045312381288, -0.11144568757907088, -0.8015173634004262, 0.31682223062349346, -1.5637242614796938, -1.9726897675073511, -0.2729429338850037, -0.4471310928071985, -1.0236770183549995, 1.5933875107226185, -0.5464648945116944, 1.2870853230830062, 1.6002951560993168, 0.538167374165786, 2.4820062583618827, 0.10288027273287031, -2.1796267535686438, 1.2777629938478985, 0.8943823485742949, -1.9106234707418643, 0.1872409373552218, 1.2158458270379744, 0.6305845237930968, 0.081790060212791, -0.3312477703501484, 0.8862672426107144, 1.4363324628336613, -0.14382404182141278, -0.754713353988111, 1.4085072723586654, -1.3562460132758791, 0.1981399155476571, -0.933662127434297, 0.43310149319471336},
    {1.0955992123206513, -1.113334815803905, 1.4553297492141226, 0.6662942710029303, -1.2767935922554046, -0.6492740382229389, -0.6293144429007508, 0.280791687277627, -0.9481417679827111, 0.7777733522626928, 0.8578761330876638, 2.0278337017905237, 0.5254259603022368, 0.4811887698306934, 1.7541216614530064, 0.4040116522768725, 0.6015039851871692, -0.6097071157762677, 0.49962063381868127, 0.5000789591963116, -1.0375986063234868, 1.3390955724663143, -1.7535659134985448, -0.27533848590922133, 1.3710992447559085, 0.19167505298537316, 0.9352958834071791, 0.7563417350040543, 2.079292931472791, -0.6983040293819436, 0.7679726205911194, -1.9352385960737335, 0.7335075489053078, -0.4925071605229038, -0.9341265645599005, -0.06860797398128347, -0.5316545990197228, 0.5823122980916103, -1.188941682026507, -3.145091180968082, -0.9389005944370348, 0.32255932812568106, 1.6869810406774015, 1.195072769900911, 2.1328319722964193, -0.47606960409873805, -0.3496109323367953, 1.9789414299336943, -0.5398017681912222, -2.096588404930162, -0.14497159676391003, 0.33117920646380206, 2.0256527162428357, -0.09687026681650884, 0.8345531323628131, 0.8328041430074565, 0.012953817715189964, 0.10671252570423531, 0.02046847200756843, -1.3187024576409154, -2.317278994459287, 0.899269046361561, -0.8099145712276983, 1.9781355355431998},
    {0.940137409411093, -0.19270812596381653, -1.8002366691899043, 1.1049520580958245, 0.5166266430195584, -1.6730868717486924, -0.6571932595815564, -0.3549214638361384, -0.08691020669605225, -1.4896331007682124, 0.10222523106350472, 0.28921523314893866, 0.6211373102422184, 1.974357057726833, 1.4115172098668824, -2.2324603948971036, -1.3426052143454141, -0.2395593663702603, -1.9115191051866782, 0.2287734959391563, -0.1455006720273212, 0.5663638497943856, -1.0976950732726753, -0.637519016637894, 0.13755401817271037, -1.478536538987056, -0.8173655177848564, 1.0218553623645281, -0.4607946120466538, -0.45142578963678115, -1.1980066511921688, -1.792927962293129, -1.7350264817819858, -0.5183652723391272, -0.7627111178226371, -0.7042990579179809, -0.2840307549223463, 2.098403757005903, -1.2490090698170673, 0.4149540045261852, 1.5699987483334623, -1.6848932843706428, -1.736934322852266, 0.9940275177838737, 1.051211605119194, -1.956198719632811, -0.4204795893606976, 0.16969953441653135, 1.308824956832607, -0.4522759085331004, -0.9528932777279623, 0.300779015991475, 0.9817172105825847, -0.3040890413272247, -0.36539985916785883, -0.2655512363877213, -1.2606854572736965, -0.4310975669607874, 0.5802602023150144, 0.9335155098356896, 0.30893472578620257, -0.05631922265834092, -2.556906162663653, -0.1715370386329833},
    {-0.31975549419202265, -1.4912279372037394, 1.3187277438757095, -0.8959838713956612, 0.39764825818491506, -1.6574222095937827, -0.7224978852668592, -0.8508544331812414, 0.1412454830547115, -0.5402323344344996, -1.3331358686409387, -0.8668679797049889, 0.03680370480745367, -0.07740823568055794, 0.33178091133409093, 0.15735422222373452, -2.4079598418768686, 0.28711967007737743, 0.7074248444967636, 0.7636148598956553, 1.9154062682665858, 1.558448953529819, 0.3323496795535674, -0.7356455968976254, -0.8427340759865977, -0.7190108786894054, -0.5391904676664322, -2.3892765296831753, -0.8693391107435713, -0.12380360554992634, -0.5769520212912559, -0.4390482512730776, -1.6967818965773884, 1.5111317487873566, -0.5817896913543517, 0.6359833998058738, 0.6940361284244073, -2.264101280352762, -0.4886784360219762, -0.26302009588941955, -0.08001230078330952, 0.5792964563499539, 1.028904938094904, 0.2231778661405434, 1.8671627881260435, 0.6505860573774537, 0.3691950856966053, -1.5272348648778813, -2.998384949474857, 1.2053206680448416, 0.05573039166921675, 0.3893470256725604, 0.6009646437829317, -0.2659362161758089, 0.14094436089360557, -1.0564561298867754, -3.5471031880764077, -0.8231549834655715, 1.2903066664258258, 1.4496298964208436, -2.022213975354208, 1.4523865013101427, -0.23403120352358167, -0.9789729338815024},
    {0.5006213612334832, -0.982652368929764, -1.413710479699629, -0.9599480641044441, -1.276062848086592, -2.056232333956019, -1.3431025902057736, 1.1184080272775507, 1.1870505172221908, 0.2174263289918433, -1.327658584913533, -1.5115603818096819, 1.0080524690052206, -1.2037179375793114, -0.8297304602180907, 0.6899166600111442, 0.2922883041957239, -0.9280100934072504, 0.30032795225922926, -1.1354291719890706, -0.23546772922936177, -0.7325375537634831, 0.9404745241187501, 0.7586161436323328, 0.7152193681985239, -0.5244053665871408, -0.8128238673846583, -1.1842789849576791, -0.7084053602322364, 1.372086895000034, 0.2035113517732565, -0.4100618867163246, -0.5876926614740627, 0.6235465388642074, 0.9892255420970716, -0.2250058706194945, 1.061586614900689, 0.5106597100294515, 0.9545430592913299, 1.380173053378815, 1.601327226453784, -1.8545275369453527, 1.2796055175115602, 0.9216665166608287, -1.056491348777697, 2.9712027021952485, 0.2829733980128316, -0.7885270665728532, -0.48734903080027403, 0.5193717420358174, -1.8514538416080166, 0.7060421446879735, 0.9625742861630002, 0.39277375487595007, 0.18307025310243547, 0.0018371359860915855, -0.2760447699650487, -0.6992243438196133, 2.094841367080343, -1.0700988427582478, 1.5753550745552336, -0.5510167979186319, -0.47582652040120854, 0.22681641732088004},
    {0.5674063765943959, 0.39424450295377167, 1.8392298363544628, 1.9849019121915366, -1.9315590070636977, -0.1932723726063998, -1.0530755283006592, 0.4527073058023184, -0.2349340922354546, -2.8395713969550953, -0.19104255319448674, -0.018426399784824576, 1.6770012605280165, 0.9964543028503181, 0.08578025120887238, -1.2474540752813899, 0.9999073953349399, 2.87968562926918, 0.7892840220019284, 0.1592828043697553, 0.29827430232245405, 0.6913316485305863, -0.3499036029342128, 0.31632949131462584, 0.7907350857866, 1.3040535724295457, -1.4827755162698621, -0.5582415880277524, -0.4664038480847211, -0.8501583946799716, -1.864299957256677, 2.2042993323449407, -0.6185491351582424, -2.30902054303396, -0.8296903423445083, 1.2713383122025526, -0.7752617242339975, 0.08173809107790335, 1.271303238832189, -0.9446390598491401, 0.015143539280648377, -0.7015191881869184, 1.5094571525689089, -1.0710833052285473, -0.231337683290179, -1.5295733204295419, 0.3477208618988159, 0.8908434981330495, -0.23364377838960668, 1.0835616967605146, -2.183591571227645, 2.5960495842490423, 1.2805428753935837, 0.3715970005852239, -1.5893874920796838, -0.7998603537685846, -0.5703948297857969, -0.5305565149009802, -1.131801510542138, -1.1810986019743719, -1.033694404238872, -2.188336480696317, -0.29615242956588106, -0.9631894743888404},
    {-1.3377566810969754, 1.4632700655805468, -0.523702506688525, 2.797026292318222, -2.1837787098801043, 0.052046848889896725, 0.5575551315996492, -1.4636510446346733, 0.9561543641803701, -3.391126722258506, -0.6633052253952018, -0.350659823083404, 0.6641362382439778, -0.850672496893203, -0.5134025847177847, -1.432434287765824, 1.2167546045432658, 0.4470040815452813, 0.5170986601029586, -0.42536186931269954, -0.1994900562586846, -0.8772894729052633, -0.021055174980769406, 0.14808327121735645, 0.007899539405360131, -1.2428724373807407, 0.5600153192895473, -2.0541940035098767, 0.8652802222824771, -0.08746883082487766, -0.5505498826305166, -1.4447389251953444, -0.7540249985041493, -0.3493022155706296, -1.0342487936608897, 0.3082433383503241, -1.7724568881929463, 0.8762676142139604, 0.4468258195511918, -1.159357804500678, -1.1948262441660031, -1.6203793086731015, 1.8830084994930039, -1.1519339270465545, -0.487670860542839, -1.0564632155662412, -0.5844718985947471, -0.5175172268660686, 0.18182447280661493, 0.3961694379189771, 0.039786913785282624, 2.1698738897872096, -0.6051934545941695, 0.6791142002710646, -1.072236710679159, 1.279760550479325, -1.2968855958786538, -1.3869511484987558, 0.08359555998022662, -2.7553592344871594, 0.8693565848774562, -1.6683689549944434, -0.5662869810772083, 0.8014587136731137},
    {0.4052185484151713, -0.4404434920683671, 0.3392011323969013, -0.8042883741401283, 0.04685824557957573, -0.030491435322793168, -0.07533123151517272, -0.7829574983003108, 0.38769147216314365, -0.8413423363651306, 0.8064989571754155, 0.0848115404020856, 0.6698671600959946, 0.4952232418063892, -1.434214403983404, -1.062881644177217, -0.6425467259238404, -0.8564414133988496, -0.45722664965920773, -1.1144169262826205, 0.4507942627172739, 1.5308259314319117, 1.339002110893474, 0.05377077122086084, -2.501868511129667, -1.4008162117223624, 1.5102467060036733, 0.4865544989939389, 1.5784003035907652, 0.11623295742656703, -1.092704550513111, 1.6332235524250578, 0.8524329128334366, -1.3588734975050236, 0.31946189062195535, 0.8651830641051833, 0.43273814009533207, 1.1012367165224677, -0.3222917602425462, 0.8784490351280188, 1.3585991278204563, -2.302141135527143, -0.9042209106770399, 0.8735678862196539, 2.0147963094804866, 0.963860903272106, 0.9293070405479441, -0.6887778167506527, -1.3481117749819922, -0.004378932787206301, -1.021701976875542, -0.4110506212436633, 0.1676065273767207, -1.5510659430140517, 0.380910140749515, -1.2165086068411137, -1.1926977294589702, -1.6340080099177297, 0.48805342525197976, -1.590234414985883, 2.3033878769889884, -0.5674790350186542, -0.03301020810602032, 0.6671790734836466},
    {2.4868501556011378, -0.910221922810469, -0.8182847824806816, -0.9968097615089769, 0.3293843298620178, -1.0150785162753255, -0.08765145221070361, 1.6725294718761199, 2.366348366245496, -1.3567094499429495, 0.10043879452809863, -0.8841748133866543, -1.8525520920122642, -0.010265545499576489, 0.40387585692283823, -0.3478881400370634, -0.8285802502694365, -1.1568641184526203, -2.21913244438696, 0.7556940544563148, 0.7590997873631053, -0.1586058531167212, 1.4545517465195206, -0.5904669890556564, -0.8740129832626558, -0.41618850250700135, -0.5802806655319438, -0.20034908720164468, -0.47038186810824334, -0.1977421303912899, -0.6251908574015239, -1.371997073142507, 0.44642343502058224, -0.33431114531791284, 0.5882691978859376, 0.6097382502245977, -0.8160885879222958, -1.2058809776517256, 1.3016375750979807, 1.8256968872998192, 0.2950508692111343, -0.3621728772577595, 0.7931684658321683, -1.4398171823843704, 0.8508385556627988, -1.538113209858994, -0.010372504195258855, -0.495018603289711, -0.5380578789492394, 1.2746774337045323, -2.028073057435034, 0.7655127117373979, -1.284663682350378, 0.7418840834282197, -0.23934827418259244, -0.19337933034279414, -1.364294978908099, -0.5490435644847959, -0.012322954410711405, -0.7179555644165722, -0.012580787184358478, -0.06923241544455425, 0.49386157395430275, -0.04691047673149396},
    {-0.8027666702446048, 1.0046628684833954, 0.10470098121387028, -1.9021571577210414, -1.2387743173391512, -0.4485221768007909, -0.9295458621253028, 0.7138033348250473, 0.8178563495635439, -0.8217610107955601, -1.9129271997536539, 0.8329549780645238, -1.5822818414523923, -2.029176809019016, -1.4100196894501311, -1.162579062915865, 1.146795471153777, -1.2255320692817608, -1.1867044762002252, -1.1240870617753842, 1.0857123568936222, -0.2838532025131489, -1.2698311425556092, -1.7405510955855554, -0.8239043265791207, -1.7715326414447214, 1.6506719113572204, -0.09010561789370616, -0.8964882745252539, 0.9080065656624683, -0.8454685120692657, -0.4300602230552268, -0.3124165300352826, -2.6171176254843527, -2.045895603785918, -0.2767418404429084, 1.0443574660391248, 1.3164871112217984, 0.0394194955510882, 0.8321358396889974, 0.40136444043771746, -0.7048233566796642, -0.2721214660395927, -0.5987320580059146, 0.30930944916593656, -2.0495410447405846, -1.226976000061626, 1.4681817625155995, 0.38632558453231564, -0.8284085452319824, 0.45713030590724135, -1.8853109266468737, 0.5628144092230375, -0.6708028969477414, -0.34327969679980164, -1.2745254178938636, 0.014421516794482586, -2.081092142247333, 0.5202678869141893, 0.5375420745073338, 0.4636243142012673, -1.0176118385329822, -0.1468681290334504, -0.998023507432906},
    {-0.5832657161096151, 1.6559347300793683, 0.5367987956396497, -0.07017255783558922, -0.779022317217771, -0.27291307612294063, 0.25075021041087525, -1.881512642773983, -2.253044256389766, -0.4839101887436474, -0.07673018998206814, -0.17428337509664207, -1.5300592802958934, 0.10635519071655664, -1.0519600760388506, 0.46772717960214394, -0.9082081185389855, -0.8399532698102232, 0.11182129068995414, -1.331816507566529, 0.5786898070902414, -0.3995656570522344, 0.2698973414805677, -0.6608733669384547, -1.149309485118403, -0.6645250854699971, -0.7227193312231268, 0.5889489711290261, 0.9457596421211654, 0.6403360461331876, -0.8752198755444651, -0.5834745605350573, -0.9380906483714183, -0.9258384861688141, -0.14743341482746602, -3.1805807469136833, -2.113851185367306, 1.7571437215220067, 0.5425245169212349, -0.44366195432494254, 0.35168137082119716, -0.46100500086792034, -0.9707655718862761, 1.1170730538489875, -1.8253706652896293, 1.2026911895612569, 0.2580882425634518, -0.2696852999314255, -1.3326235167808869, -0.9607199370554141, 0.12929124167038814, -0.9427465685653592, -0.2715574439461783, 0.1114647702019246, -0.964105485700825, 1.6472271671651377, -1.6300860864764792, -0.6073120308185809, -0.2016544546952332, 1.0850495394267894, -0.27898252743154683, 0.262645364882637, 0.22420973117222287, 0.9503793792964532},
    {1.766577483787982, 0.5688293570469407, 1.4018538798828055, -1.9458441582521437, -0.6101987245333409, -0.60331591835362, 0.45041676491560617, -1.3175671362604229, -0.5573443361076656, -0.8058220702075276, -1.3934005527916629, -0.9308767906298109, 0.3759517301886335, 0.0802090426495755, 1.7979990353225659, -1.0882627870825936, -0.03706655874110918, -0.6396506338653808, 0.7307318569002687, 0.32042862134755257, -1.1637951095426518, -0.2673408820663377, 1.6387800655763438, -0.8874928125735478, -0.42624466807210715, 0.760403115759482, 0.048161101583729944, -0.3228685981492774, 1.2835892178553585, -0.648259936809408, -0.17461458211084435, 0.09087436313090347, -0.11940566774231447, 0.6001686241236922, -1.6278486368312886, -1.1803359445640087, -1.5295569296544342, -1.5179752765611407, -0.023790323637015106, -0.1769570487756949, 0.5146386071336425, 0.3499913915564866, 0.5398150951335986, 1.5528232736760503, 1.4207783289582372, -1.5907136525695382, -1.8328314524678533, -0.5621130678828261, 1.5838571210770607, 0.850648954718978, -0.7829514805685154, 0.3392018556630726, 0.18319395756579324, -1.450343354696502, 0.4837202681573112, -0.49630019374647877, -0.6588318730400082, 0.01420782624307031, -0.8878834848098651, -0.8527602936863112, -0.19659138379071994, 2.6354089290665317, -2.7219161539513808, 1.2586129085311768},
    {-0.8229419658440895, -1.160942511063659, 0.3314485073259383, -2.1800225063719383, -0.9050474551532578, -0.41005625254070815, 1.4717470258256826, -0.7501178185613196, -1.5732600974895323, -0.3143213778422528, -0.868569436976548, -1.1198822499443586, -0.04707348537665657, 1.7712436859312595, 2.094683749866408, 0.04193988682994957, -2.5336161972150673, -1.1714018535004171, -1.2899208415255503, -0.12723827053652512, 0.4137422389727317, 0.1970197543731538, -1.1745276209533375, -0.5865524009130763, -0.9921215314176537, 2.73806105570429, -1.059168611833308, 0.5624745296694941, 0.5496412434813592, 0.04417446024673035, -0.7065411869576522, -0.4200043352437475, 0.22063068349177692, 0.4096633466502733, 1.051132438458717, -0.6362399208117258, -1.7339536927027928, -0.9994325612979374, 1.8093587179710282, -1.4774679593962037, 1.1537285981713823, 1.7650505676290413, -0.42316093937677435, 1.1441378068564672, 0.6810891231923203, 0.866310962348829, 2.470843835902792, -1.2082629606002158, 0.17789544259524645, 0.629935241436563, 0.28615787612197385, 0.2521077485047656, -1.6485319680005024, -1.1896627205521948, -0.053589285064177726, -0.04586124039520386, -0.9427528421880969, -0.6770489178364736, -0.425925379591636, 0.0752580457726041, -0.5691838572913058, 0.2265970948333596, 0.2570720294394188, 2.8611110030896665},
    {0.47627243537465175, 0.42958026051833886, 0.9287394313122408, -0.6160000981361329, -0.7598476232012121, -0.844643033426716, 1.154691907265751, 1.5268736666397922, -0.5866339340156357, -0.7214154523741869, -1.1868744884027325, 2.563288903966323, -1.7147190204738987, 0.022885843023549575, 1.505855230713569, -0.46558949691465273, -0.20792768558070138, -0.6575117306714224, -0.08444660787352382, -1.4857261811551106, -1.9712339014838294, 0.4850627661584506, 0.8722431396993828, -1.614377076078289, 0.7134348706715058, -0.7918394520104963, -1.7667703109244297, -0.308448607160197, 0.17568476845131448, -0.20428533744286315, -1.569133669300891, 0.34296125170110114, 0.8195985431796831, 0.2719239217093498, -0.05090495684678823, 1.1146162182408812, 0.08532108363408557, -1.9526541400528028, 1.9694633439093794, -0.4299838820057699, -0.23562969583663623, 0.38500954282468575, -1.1577333744585772, -2.2879568387351594, -0.3910611177666471, -0.6731241900803396, 1.5192110757673167, 0.43438429738420614, -1.3261543535632794, 1.1272086416347764, -2.467417024205534, 0.9527828635730348, -0.0003796352365844803, -0.9880624048395646, 1.282841515491657, 1.7098096357463544, 1.4602608189934516, -0.4735749884064443, -0.011158626283429295, -1.204018683691472, 1.605920701197672, -0.8663403935230543, -0.31616922743065384, 2.2882576928328473},
    {-0.5487181810433768, -1.3536928045238303, -0.20209743985003434, 0.1371216374440366, -1.3505636873905669, 1.0434521387564006, 2.0742701938527315, 0.252771298571212, -1.1505522371630692, 2.256474801333181, 0.7435456945992757, -1.047882192525924, -1.9475161018297087, 0.8227726243626514, -0.8689225568790531, -0.8618233332649219, -0.6916455102127727, -1.4896123802788885, -0.8511601853640836, -0.03219432450299061, -1.394788712644218, 0.08660702616087662, 2.403451494083799, -0.2794141903123006, 0.9888517868441313, -0.47595629436357806, 0.4436862207731426, 0.3066949490006822, -0.5660175003379749, 2.3700526807862454, 0.10348201524453222, -0.6322879700309083, -1.6682363614588753, 0.08560486030125855, -0.058963373785951956, 0.08078086458181465, 1.283231144701144, -0.41575098020432255, 0.868460810551491, -0.28654086760549924, 1.1654123290273315, -1.6947451631284856, -1.6990597890799486, -0.3744380931955855, 0.23434437231239258, -0.2730494332749035, -0.11997452279836579, 1.5059630404058302, 1.3546749966396983, 0.9735301897306796, 0.31911134275645375, 1.5456344088222613, -1.1182323833708354, -1.3356394486511118, 1.6437193023548835, -1.07313090550851, 0.30654795712805255, -0.3287676010564272, 0.39523007558632034, -1.0162946773170016, 0.9131112784074226, -0.5754888366687669, 0.2717664209092267, -0.36798221575896856},
    {0.2392851773607148, 1.0228581553484255, 1.4844636315571564, 2.195368862067856, 1.6687939584650002, 1.3554819138060927, -2.3070213765625116, -1.2662782978499225, -3.03691563159109, -0.9013493083005578, -0.3146519539188165, 0.13378406446620517, -1.5300390030146034, -0.6439110106371164, -1.5719306372339976, -0.7543790121525492, -0.3941418037406657, -0.31906943231140905, 0.4670506951988763, -0.6607605012441097, -0.5383714714569172, 0.0634651898802028, 1.350898393691319, -2.5970368137625077, 0.029786494206637988, -1.316132797669455, 0.6768025023901093, -0.8957447880656034, -0.910481195033171, -0.3596206640442091, -1.1426755947297405, -1.9853288550548402, -0.6074240671088041, 0.6117755337640901, -0.2753184038281591, 0.7112656189563158, -0.23321095168850217, -0.4338167316996794, 0.35234847048622875, -0.3237469262529587, -0.09206508965990169, -2.39271032859199, 2.4973934879045703, 0.6314030765505283, -0.5641487367998335, 0.41365649087135165, -0.6612485822147447, -0.803402133682076, 1.0678233671626758, -1.3333135317507756, 1.147150128001373, -0.0035122896727024576, -1.17331018642291, -1.6215548932588997, -0.2196575897232385, 0.10357386394854005, -0.67372480226343, -0.05147735557320979, -0.23867205653181106, -1.0693744885823389, -0.32734737105160433, 2.060996566597103, -0.953746817246027, -1.0096619270073415},
    {2.3831480196844614, -0.5992253854489761, -0.7957271983059376, -0.8607546308641694, -0.4249204295707432, 0.12896805754069468, -0.09396317057791505, -0.8518715358568816, -0.2843749313784387, -1.2890952016055486, -0.6834227383540994, 1.2050254374939555, -0.18015657864239337, -0.10783956342747097, -0.657939966282582, 1.2966432806185417, 0.949259578882195, -2.2742030368950177, -0.24587001054567306, 0.4612151937339283, -0.18266625399659855, 0.30555460864259754, 0.6975391816922674, -2.362343083462356, 0.6491581996193344, 1.0188740255139705, -0.7476311319175607, -0.9115156239575829, 0.17160193027288925, 1.2741045353130904, -0.8742740600044172, -0.0767229377607178, -0.39311894780040085, -1.3673176452593399, 0.7102773694107324, 0.39086338116400804, -0.4929455748105869, -0.15303416603248213, 0.9194576560773227, 0.44919423161557753, -0.3519747661723589, -1.324243767496772, -2.079432490035905, -0.5614215191411512, 0.9963907684419179, 1.886085658355974, -0.39247820887368484, 0.5894279185392761, -0.2746606355955657, -0.45093049400568896, 0.8550071411078471, 0.8572278745124438, -0.2273153962502003, -0.10789704121272223, -0.5032648351733547, -0.3836522503724114, -1.3875680377739497, -0.3892883277263037, -0.019162875751389256, -1.048318232999071, -0.49113066161998636, -2.0714590110419464, -0.8052165265473706, -2.0888548131442874},
    {0.9010770484179874, -1.5448268934467755, 0.21950539852408152, -1.8825008576886295, -0.656207352676523, -1.2635309817511118, -0.9085913512509215, -0.5514991874422205, -0.40324783795456204, -0.7917659249640652, 0.27684436364168846, -0.6011097295122407, 1.1747660620523006, 1.1815120054266366, 0.12155804749903823, -0.7724561838021361, -0.9320089194992904, -1.8162385626188193, -1.490772216542069, 0.5591425570460687, 1.5635029419227549, -1.254334864170883, -0.0891195975519498, -0.6647909643223043, 1.3594046699000228, 0.7854553024799764, -0.029880166721241858, 0.45194601576968335, 0.5569219327660061, 0.38967245144365886, -2.380285028630298, 0.04236020213476378, -2.3872450330629658, -1.19642239375746, 0.8801006358828235, 0.21917569831019834, -2.017878272914717, -1.082766790010224, -1.0269249938434648, 0.5795143956680515, -0.1473055930222692, 0.46747207109831934, -1.121630972643044, 0.20797271181592894, -1.075636734724875, -0.09975080525605357, 0.8023106806310334, -1.5493073844675345, -0.5005625002233851, -2.7682947134944986, -0.5599725181702642, -0.367791800937493, -0.3812034545204551, 0.26659036990248386, 0.3693019349625608, 1.4188862988488449, -1.6298240146019094, 1.0751651468252543, -2.0758155135812935, -1.0083233664188125, -0.08366642252616989, -1.2020828489252304, -1.9973338854645806, 0.7458502495402801},
    {0.726035852600942, -2.144261037329403, -1.5764114962783726, 3.0565564265352085, -0.4312465328909182, -0.18946419306900644, -2.2260959737693367, 0.38906373380761555, -1.5514815365654997, 1.9908928410005544, 0.5979110708979892, -1.5027806495548788, 1.979861719408735, -0.4354793186118728, -2.490706445590804, -0.4335537896797549, -0.3006537232206864, -0.8536417292691079, -1.3797004272826157, 0.021439933410567602, -1.123475707539653, -1.119714492655425, 0.0857082978511655, 0.7671498269485413, -0.01896251885985884, -1.067617601066016, 0.8106860893136705, 0.9760126120297363, 2.0423753031414464, -0.6538497607750521, 0.6960859032440344, -1.8713372705841478, 1.0175526401118953, 0.9193380618118533, -1.168295896230679, 0.8689549623327144, 0.9098887639196477, -1.889713641489112, 0.8524558399232743, 1.023193053778604, 1.7513710427236635, -0.601069776724887, 1.9379324216429012, 1.5196445299741994, -0.684831761453218, -2.4418400284177135, 0.46019347180473286, -0.12889187556912837, 0.6268974471098465, -0.36291822141243923, -0.0057674438736183085, 1.5580379232551476, 1.313341687443489, -1.588847544979782, -0.8680588198798609, -1.4782566811693125, 1.2321415228036596, 1.8295460266732289, 2.757700171736389, -0.8188217743233303, 1.2956011635671982, 0.09247241218955567, 0.751631310655366, -0.24509035328511808},
    {-1.4169222102713976, -1.6343919149252906, -1.4258485005471622, -1.3649657128406056, -0.5182620567096458, 0.815741746612331, -0.037487430525156726, -0.5116779876705364, 0.5694019574148238, -0.8024388152136964, -1.3929239082108422, -0.2677673423915302, -1.6138175433610205, -1.291876760845895, 1.2431281457787924, 0.43984551034847424, 1.1779907688013436, 0.5828442561295455, 1.5316058212458832, -1.073478272890564, -0.13644786300763673, -0.11183614596827714, -0.2921362562774958, -0.6490219567728077, -0.25989887367081305, -1.0800770954865029, -2.7187511114276486, -0.9645158347203966, 0.936563391246372, -1.2049790511952143, -1.6978020121610427, -0.6454364954249195, 0.14772953716155549, -1.8218338189401861, -0.9038819016503811, -0.270050752216742, -0.750324491962492, 1.3939619634997118, 0.6519023955339457, 0.7106257721256563, -0.1305432519514614, -0.9028896831147644, -0.2872514418635417, 1.592083740972231, -0.46662776585253585, -0.4284325783050454, -0.16336988208900677, 0.3209082273504111, 1.4679513862775775, -0.030572463550194086, -0.5770176661466622, 0.9816757251625731, 1.0882494508979783, 0.9566822543846647, -1.4191284381978366, -0.12709243663445347, -1.2727317413743426, 1.4565672472774234, 0.7844955693614047, 0.49666711268791547, -0.26638642695973125, 0.10088251980277271, 1.7578837390042705, -0.5469892369351572},
    {0.631560349333102, -2.9229256471948735, -0.37161613177910163, -1.6720649848256546, -0.15955923569703398, 0.725241416064723, 1.0337107931340819, 0.13149488803287504, 1.8506439839481177, -0.7230953595038155, 0.7927365304079902, 0.1616730149906652, -0.867129770604772, -0.23919889511904294, -0.06594150663264631, 2.5265568596167696, -0.4740628723041287, -0.5111440513948595, 0.13490772237075868, -0.09780786872473163, -1.8726109582007706, 2.821028016355175, 0.7063851278195099, -0.17514948686318854, 1.8112528058926805, 1.0135472261796437, 0.5672133282056538, -0.35699777421271395, 0.6646236294988064, 0.24673557595198564, 0.11508189885499703, -0.6544023226024585, -2.4742824158999404, -0.8217698995718372, -0.8357972551678534, -0.40318974263053947, 1.7060645251656488, -1.1902293237368113, 0.729772687370003, -0.1652775606055347, -0.6970421725850225, 0.18494323592107564, -0.9875898784825209, 0.7405023809964861, 0.5953624713621546, -0.9707829536932318, 0.5407319792707562, -0.54759908995999, 1.2280127789459403, 1.1585181536842435, -0.10960180131337627, 1.9405975587061886, 0.6646596579039796, 0.05596644061481914, -1.900209824456298, -0.5128013860605988, -2.382589416932371, -0.31581637927172135, -0.3944308365432093, 0.6765155978290757, 1.397409373063688, -1.236936842103852, -0.5274692232055738, 1.4372921903279516},
    {-0.05239491945062186, -0.13612064468820384, 0.8786180817579812, -0.19260454781134964, -0.4611607883129694, 0.18414876676085795, -0.7353434443701948, -0.008699906924096794, 0.36375999395494035, -1.1063746809464563, 1.3328658057067342, 0.16286537756765315, -0.6214824486624398, -1.9395035772253417, 1.369896815661977, 1.5066974867689, -0.8535413933120559, -2.0622151364555874, 1.7936402873814257, -0.34792999156158283, 1.2859688292219664, -1.6874939837854417, 0.8556577060560766, -2.1741838607996824, -0.1757437709853458, 2.079282748119953, -0.7429690431222717, 1.1105018807704916, -0.10424646635572242, -0.985306243235023, 1.6103293598976771, -0.3530190278903921, 0.13653243537426385, 1.6024292018187622, 0.518726154442442, -0.6755905048222804, 2.4568190862465116, 0.04290066331671576, -0.830384582675722, -0.32066419728252143, 1.0168415377216353, -0.3622997030325828, -0.5536627032748426, -0.033894320105753474, -0.26896732909453946, -1.2573676349938803, 0.7850823603600623, 0.3597406378714137, 0.3444897496200558, -0.8485377592440094, -1.517199488635034, -1.0159198480110936, -1.104232194194317, -0.5313397340220645, -1.090864303400906, 0.28522269577539006, 0.20534411186199558, 0.5473645304776101, -3.6720182906203274, -1.6793412694779404, -1.2460920929700765, -1.7823310205812937, 2.483085727888499, -1.379084471617164},
    {-1.746911064997873, -0.3901736176797875, 1.0230239212082957, -1.5425556386823043, -2.4839549289562637, -0.2247773809090244, -1.8360050512769517, -0.46920193722776915, 2.1017086167941983, 0.059224343844651396, -2.073913167153631, -1.7769750201523205, -1.1289101573844533, 0.7133376204950825, -0.21965827454792905, -1.6622807843170269, 0.4593905004555231, -0.8598460997330811, -1.3036541329959928, 1.1794197220855742, 0.7637520967938096, -0.18440867398104333, 0.8669768887376231, 0.3322524586558694, -1.4460475048150698, 1.0808258092403948, -0.9209694890517066, -0.7137581049542491, -0.39509534844569827, 1.494679610013054, 0.09030477629784289, 0.304588754691795, 0.07482660619386246, 0.28467917837771256, 0.16126795981385608, -1.3111523990771385, 1.1543548130299344, -0.4974507485456162, -1.6573469980489381, -2.9536307474431656, -0.10791620392878935, -2.122973951851332, 0.4000209974275556, 1.0351485209175015, -0.37738760079113576, -1.2169093535750812, -0.043509530634825454, 0.16645977494254455, 0.7688380955410864, -0.8448095025244492, -0.234876270983919, 0.134338265299894, 0.011867404308443522, -0.6395968959282656, 1.5877222031220282, -1.2692081753439943, -1.17848038644966, 0.014201528236701705, -0.9762497797748235, -1.3127449384217074, -0.0885294561471159, -2.021209180767894, 0.018387492243087254, -0.9966378790662802},
    {0.003329382003412592, -0.37032066904012223, 0.9889260479760825, -0.02672450693712095, 0.11628555692572344, -0.9018682189450504, -0.18380637484694826, -1.4016677309978365, 0.9397438914184978, -1.10233141257013, 2.057972035245071, -0.8894002040359463, 0.5288830233291829, -1.37541867340465, -0.5579806240528217, 0.09200050285668727, -2.6554895333614295, -0.5421561343168213, -0.518706553430101, 0.8616704742712078, 0.8516270644760278, 0.9796198824575233, 0.281716395467627, 0.1356666668685499, 0.6344435422501662, 0.34754696423873327, 1.654914398467553, -1.012092334320391, 0.3497610734029535, -0.14499642716437042, -1.0095276054407214, -1.1622573561201364, -1.241986388954314, -1.9743736163530248, -1.4022989385794662, 0.8488032861798236, -0.08721418042745405, 0.6766810199180066, 0.9115181937026684, -0.5709717689476945, 0.2569325636703931, 1.9900088164543228, -1.3061418801816849, 1.0354583133846396, -0.4458399659835931, 0.9902698584869327, 0.4568811825534891, -0.8009714435694165, 1.3115008386072018, 0.6559140006705502, 0.5925660862915866, 0.7428500847985071, -1.2692656263725128, 0.2496526482462926, 0.1941745016665422, 0.7055572849639264, -0.26807413982726114, 1.3594468140570668, 0.6411991636247992, 1.7196729136684894, 0.27304873688981446, -0.6903254560193833, -0.2802779489348013, -0.40185503070410056},
    {-0.1672433420527816, -0.6450590448012307, -0.3839206607336395, 1.0875804422560047, 1.694408970860269, 0.13121450484934646, 0.5317892736760248, 0.3800739115746595, 1.694119714163062, -2.620373724854659, -0.11787165719038714, 1.1948035930319185, 2.0442248052056153, -0.8462512649148741, -1.5544191458528325, 0.22251620189419266, 0.8752866650382486, 1.8968543955087733, -1.4706738516527826, 0.43421442646860914, -0.6020849518974543, -0.9904581947771018, -0.9200153796676966, -3.0495180991155793, 0.32409876711660446, -0.0021667689579939705, 0.40403030000357754, 0.264625421026474, 1.2305625232614268, 1.3943833616194188, 0.22045630907858474, -0.8416104061373586, 0.0034843879645513626, -2.6439932029895683, 0.9650333981565351, 0.2365824556762917, 0.9447706332149104, 0.0029369493081024037, 0.8383704248976344, 1.0273713776882634, 1.7061348744523528, -0.764726867353739, -0.7134928561799719, -1.0134876778086817, -0.31426641573112074, 0.6729959817299749, 1.6721378554331312, 0.9444503161946601, 1.9554288869278502, -0.6889552271560672, -1.8196673399233196, 0.17829132328835376, 0.14192226014898923, -1.1056469448944353, -0.007113699436805671, 1.9994429383998746, -0.9047316624021217, -0.022657900788238136, -0.5386271819016417, 1.1575157697441465, 0.8702061617244445, -0.3610592081320508, -0.19687492181794047, -0.07233604428562217},
    {2.3649871010864354, -0.40517572085391684, -0.08097509135209276, -0.4992114365433058, 2.1386072583429323, -0.7196014706292853, 1.1362684046888594, 0.20093568163707942, -0.6375002910966912, 0.8941754792106521, -0.07224597845863409, -1.0903125319647045, -1.4590574512275019, -1.3095345925933628, 0.5395661369471608, -0.845234166094841, -0.8274499482024538, -0.1287215995169262, -0.8574284744395826, 0.07189141194838598, -0.6281673356484115, 1.1755063749325416, -0.2690106798750933, -1.913638275689711, 1.486754472709864, 1.2911475043255667, -0.8334797866088804, -0.5725487180372884, -0.21075464066534044, 0.9095564332374155, 0.4353100718121454, -2.6640345228126363, 0.860052729839559, -0.7148375953506608, -2.007934377107459, -1.6261089183097768, -0.14598312622027415, -0.6709889811382413, -1.1378972249868866, 1.849329982917341, -0.5066549913072936, 0.2397536911319531, -1.5161573898226257, 1.0963529992900134, 1.7521619248225406, 1.1214516834325727, -0.8836161194527549, -0.698878537030582, 0.01591279308826125, -0.34767888771750804, 0.0888601718680008, 1.2104843256369624, -0.3925007263613456, -0.4421273279394757, 0.19725061109452277, 0.3093399454225617, -0.9098958464615123, 0.8039241102257453, -1.4556963179792566, 0.46805251489923483, 0.0013168474900719224, 0.202501945624223, 0.0357747387760775, -0.5876850251085225},
    {0.6045843737913912, -2.4993497752988447, 0.022574514063320596, -0.2895273891615997, -0.5114791573202727, -1.5959890250579973, -0.8162067559082054, -0.6541516131955244, 1.2473352282329075, -1.802438527131196, 0.7416375360786622, -0.04332061639041023, -1.0989610773243466, -0.25255644339219774, 0.09506166090126972, 0.7056761071310133, -1.3263526098487157, 1.322652416123334, 1.6197208709209234, 0.3303853692870852, -0.8643394860408163, 1.714532459680839, -0.410803833954191, -1.4870037703060095, 1.4038121988164367, -0.3328223829160017, 0.7873220351786919, -1.0634168977060634, -0.29206998418332786, 0.6697747768853297, 1.08934930439554, -0.7207742634567289, 0.32215763630728694, 0.7469636909481452, -1.6569132506188764, -2.0627697930633815, -0.38643142473441755, 0.8456947855623264, 0.7437633217046887, -0.12261030405842743, -0.5454826883550261, -0.8100153384064143, -0.48463494725277556, -1.15050530255035, 0.10390908457539634, 0.06113091000964834, 0.5630086289413156, -1.4604020646110303, -0.010397305288984283, 0.022962001656095278, -1.566332525568236, 0.14947083388696977, -0.070220298160959, 0.2633976649253091, -0.9035979773892404, -1.581066374071956, -1.9354587957841944, 0.3105653547197414, 0.35591938602920536, 0.22732534983205827, 0.3568811082861771, -0.529863052319245, -0.09937928338574276, 0.7709946549884067},
    {-2.1801872316474245, -2.2564811417002733, -0.1714235131784986, 0.7129699751793682, 1.0644139685792697, -0.949243336825619, -0.5149482946168632, 0.07397087445240552, 1.4598330935472008, 0.15806259369571288, 0.28705964201458056, -0.4775119148570062, 0.6445376129028978, -0.6600082013004338, 0.7410494185084481, 0.9152386634967635, 0.2032337532772801, 1.43792888627371, 0.5767818353586803, -0.002388703301856502, -0.39873147672205733, 0.7360253254540691, 0.5939885479655763, -2.4033943022569804, 0.09307449542328267, 0.5748432468015099, 0.6267888488050066, -1.4293091129385118, 1.5049300961898353, -2.4167247810786363, 0.8161106927240747, 0.7203104632781796, -1.2089265568069751, -2.5598300490014783, 1.2130677795758789, -1.5577800139550113, 0.43304990971537943, 0.622296805997477, 0.8808999428623697, -0.6476024928306986, 0.5716520877741568, 0.6669901609072517, -0.6635688526783616, 0.048928620510157166, -0.7063897471689744, 0.5162758468618099, -0.522346386627183, -1.9535120804162758, -0.011890162884238465, -0.24671089642911814, 1.4158157408691907, -0.8281698573669928, 0.2593637809257628, -1.7495421294016988, -1.7353333541812126, 1.4925427647104748, -1.305096720618214, 0.4194259180971879, 0.517069194436913, 0.3582362104584726, -0.773206616355843, 0.7186334599175305, -0.08170946978621589, 1.0457125981581468},
    {-0.8559144033024283, -3.5353377763844684, -0.23617981595759024, 0.14686177635897404, -0.3358544432516203, -1.323015033002826, 0.2158274584351388, -1.8807614484074624, -0.1917648240184272, -0.1501199056342487, 1.9394651899653197, 1.0993551497671976, 0.819598772001103, 2.9346257427541005, 0.08346572438625498, -0.6451013610618501, 0.3999166379256518, -1.7808384656307132, 0.5092653050243119, 0.6713250705799012, 0.40381106183499715, 1.303925557401294, -0.3961071718412918, -1.0181454292542882, 0.6079608006728463, 1.4964984329192808, 0.039818685362949156, -0.10742109830879329, 1.110121494967586, 0.5475071851812975, 0.8714387374358613, -0.403275443926912, -0.24120555183699594, -2.3726166211270114, 1.3938447193881218, -0.0556362779431617, 1.2430986493503062, 1.6118726965776202, 1.0665841989134823, 0.6368298415588973, 0.6893063011413917, -0.5817052123952758, -1.036450841018829, -0.5004649029208018, 0.06728717303720051, -0.5218724948377795, -1.5485861463155983, -0.6340500615496275, 0.8973320959773695, -0.024476328221877095, -1.5536319769464497, 1.0400642408488936, -1.1900977936254147, -0.5848807057996953, -1.1184945233190737, 2.150605972868504, -1.1584179969733441, -0.3695445883774963, 0.8745471538333186, 1.272002490241072, -0.2770988594743709, 0.2098113926859446, 1.466623283138568, -0.6223557016957341},
    {-0.14810266904127264, -4.168642152810836, 0.3051966164859677, 0.33520530102667595, 0.27458653256931687, -0.7428754532889573, 0.5402084428917581, -1.1931473161011994, -1.3312450094801345, -1.2510795037853015, 0.21862590752402278, -0.7341382654754655, 0.2585514514836131, 0.3451180599220654, 1.046119103472764, -0.9454696495011256, 3.192119078441625, 0.8203918444966338, -1.5313026926832736, 1.401946705093198, -0.6677640460121548, -0.28043927587367995, 0.8384043232411145, -1.2657435189250836, 0.0387621618206864, 1.092639047771837, -0.0238750040707004, -0.7842025829109913, 1.0853951848205161, -0.43657087451334403, -0.7883772493028254, -0.22980584363379813, -0.9070336294887433, -1.3161325508112736, -1.9171582733003854, -0.6511741295276698, 2.7604302228389104, 1.2125485960570708, -0.4852859233946389, 1.5206001801194677, 0.6771202022482056, 0.7047139415041731, -0.029534414354164464, 0.004404493754207155, 0.43671621840390873, -1.0241889995012927, -1.0815785299185707, -0.641151235866242, 3.542073470538799, -0.23202896779567522, -0.14837776182207535, 1.0464030829287438, -0.9922826693367857, 0.4910881742189792, -0.38277457094908196, -0.7717674309443069, -1.4479193443366463, 0.8803637170875892, -1.0003865444458497, 1.4346094623375258, 0.4730384298731254, 2.3581967798164047, -1.7653013595661355, 1.7662348731630297},
    {1.6127492835490307, -3.7568134647350044, 2.033555498402362, -1.1602118999602884, -0.9112228604122785, -1.7407590106541015, 1.1177315555228762, 0.11511335961289441, 0.07134066304912473, -2.4989974590729758, 2.0764093683942675, -1.879464706115324, -0.5449348784430426, 0.36056624272444227, 1.9279697576282977, 1.1777128326915647, 0.33125488001330083, -0.4683052322973586, 0.002182550872932449, -0.423263396531612, 1.1291904326286906, -0.3086977548471115, 2.2665914854804576, -2.3640147836898624, -0.014971508281332181, 1.2234744655355065, -1.7908193721615, -1.4978974825483242, 1.6796850152770497, -0.01648766971786401, -1.979831077009627, 0.196526278852288, -0.39010268752612287, -2.2056732803401182, -0.388117974493827, 1.8386838666671008, 1.1958756230457461, 3.075661386202886, -0.7057803017313651, 1.9843882963537507, 0.554028369746319, -0.5561855843918195, 0.02151501151030125, -2.0904884073745023, 1.4635943423204743, -0.7421876255449069, 0.4707667527991587, -2.3747858252286482, 2.499897152252204, 1.9481883217660934, -1.5419104941310955, 0.8130821680328943, 0.7734390668660099, -1.6570084256187456, -0.8309058690539242, -0.1298060344688634, -0.5157495228400215, 0.7229231207779696, -0.6676992783315092, -0.0023040099232678477, -0.062448453093873035, -1.8252965436044153, -1.536408981302764, 0.3828074046271913},
    {0.18242375594362967, -2.396121986032501, -0.9142388633813088, 0.9498418248701084, -0.6330105777274139, -0.47187012587911725, -1.292673063354424, -1.8558381996798266, 1.1957741833138802, -0.1764453860645374, 1.4043798516901567, -0.658564027726847, 0.9934629285185812, 0.10744950955605267, -0.6158034520820612, -0.8966661905075424, 0.6999061160153609, 1.1065734378093897, -0.6143602205958194, 2.2392915338932724, 1.345363609034057, 0.22092207582083878, 0.3773414558627808, -2.047077846721986, 1.6409040621764752, 0.13607112920133968, -0.36509343670420824, 1.0400893309728865, 0.9481716225993905, 1.6549233406953108, -0.344101708968549, 1.5930127706509276, -2.314190206971491, -2.313562596772696, -0.12026426528332668, 0.7185808674643981, 1.065146598675583, -0.6997990885736618, 0.5652055924861691, 2.375535408715443, 0.8955631924018121, 1.085579775946493, -0.681931621233124, -0.7673920086205811, -0.8953242983258779, -0.8965466915409445, -0.03901323750829349, -0.2910914543497075, 0.1309296729684294, 0.23216604730868753, -0.8643936380387841, -0.34356510807832463, -0.7801064155705086, -1.115985634583332, 0.6034735953475916, -0.46228011579734907, -1.3348736343645013, 0.7070790015989237, -1.1291417325575352, 1.7811978082213338, -0.4057427590386628, -1.1875421093461533, 1.0395756389002575, -0.09470554893093419}
};

static const float b1[64] = {1.6730375638045019, 2.5314032476515553, 1.5253034856944092, 2.074905647770984, 2.247230334405689, 2.068762496012488, 2.560982489423716, 1.875539426220922, 2.240891113601938, 2.332740667228976, 2.473330660667581, 1.215973380809873, 2.124215528862172, 1.176906731004051, 2.001627034957732, 2.1204601933832996, 1.9423232642586694, 1.8672451185851535, 2.0855590283608993, 1.9914350601932973, 1.6398627539741315, 2.4839668152413688, 2.021903720022036, 1.8925286213854722, 1.7467717717448006, 2.2468398479826237, 2.1446815026376234, 1.8943044964136213, 1.4019868397610373, -0.3083388508557818, 2.4685901961915984, 2.173582054968368, 1.2360184283507842, 2.2447666855774093, 1.9924765321322153, 2.084119394010074, 2.2524178573691604, 1.9260883936043358, 2.4470227601812304, 1.9220688861576907, 1.860901448495958, 2.184843201883606, 1.7867869070150406, 1.5600358667597354, 1.9757715669646623, 2.341789619207441, 2.050350427438531, 2.3346395921732337, 2.0010630090473893, 2.072196040510512, 2.3119434617249435, 2.169472131897361, 1.8586027120573985, 0.8332739224611744, 2.129738733514892, 1.2850190008205786, 2.2625878168417226, 2.2290197436439394, 1.7367500753479368, 1.9992380825240907, 2.0606513678413845, 2.288368979447045, 2.1011004350656286, 1.1728184292590431};

static const float w2[64][32] = {
    {2.086082867223791, 0.6037497377185983, 2.7285076948255385, 1.2119902194753551, 1.5025996230678702, -0.09949712255975365, 1.051942858411404, 1.5273105758145693, 0.5465465867921687, 0.02146606874960739, 1.0365342733384733, 0.666978308188115, 1.5535280951859598, 2.536502774930393, 1.6233019448680832, 0.8063252955662902, 1.0572741948668392, -0.7062243362449638, -0.8190787800149071, 0.6629992786920841, 0.4759388327900077, 0.05252122027170301, -2.3120103131876846, 1.4033273188661342, -1.1976864977015087, 1.7624386751369798, 0.41463714308276056, 3.372327433175714, 1.2090281391226978, 1.6412032813026987, 2.4362790634713214, -2.7016600319309196},
    {1.4234658672326244, 3.280228946497537, 1.2353070259704755, 3.576564314138745, -0.24123003821555403, -0.9936197722743011, 2.234001439731026, 2.5577044158453193, -0.45416884526164397, -1.7840004087847354, 2.3149558152081027, 0.8491370405018412, 0.7249628992349577, 0.26704154472351094, 1.0844996531587034, 1.6571933071854603, -0.21483592823198086, -0.7007762733505465, -0.6293083966725462, 0.008488284194635336, 0.656363999053074, -1.8047587123550606, -1.406985542177126, 1.1521089128983684, 0.6203554985764546, -0.5107893304938539, 3.1673489419910874, 0.33753622065011496, 1.730122690908661, 1.0649106879432686, 0.37433168628331437, 2.5434199765390613},
    {0.15139983782542474, -0.20830572790126983, -0.6422280159942496, 1.2085190782374127, 0.4240310538336011, -0.3794793695017754, 1.5010800463540261, 0.7278292439508661, 1.3679763336795738, -1.401917394056416, 1.4783176995218754, 2.3932304244228937, 0.23845067408746295, 0.7891247279024773, 0.9140074400306093, 1.646538232463296, 1.634845737224683, 0.6341406057192376, 0.4117797711837958, 0.5831033633221333, 1.5313971807140896, -0.0431277379622437, -1.7409584744868754, 2.9008910819425027, 0.5075319772983659, 1.5256596843536512, 2.5925029078038975, 1.6250719422668847, 1.175231488494354, 1.196287312062931, 1.526271984856362, 0.9756346016703171},
    {-0.4824615454319099, -0.11316090167655904, 3.799669390239425, 3.011779474822542, 0.8081874815124502, 2.017647095137837, 1.2499944049186387, 3.1779893376882598, 0.3362610855926947, 1.0841604272749377, 1.6812069229925903, -0.331976480831162, 1.411474613704141, 0.008950849455025188, 1.5166898618807414, 0.8424657843619439, -0.47499863785577867, -0.45460252801290785, 0.8815193827083455, 1.004709053007914, 0.43384458236135953, 0.5099290555846009, 0.15852724244393523, 2.2682566473330805, 0.7937803896627386, 0.1344613046373826, 2.6228087426947755, -0.1704477713769977, 1.0271489003101486, 2.814913541772516, 1.4913267752931616, 0.4139147625863839},
    {0.8452389833892598, 2.1006706293415056, 4.075831111832278, 1.9374878605958203, 0.911121255700329, 1.7147126645499857, 1.38622024879839, 1.836368448651423, -0.22481987449878812, 0.2118673599899796, 3.3961780849958214, 1.6716129344991866, 0.8732323228495424, 1.203075683685613, 1.076912456402791, 1.1540610351166036, 0.43135652180397516, -2.4781954749909163, -0.6081934947423672, 1.4825676843411373, -0.8529054615726724, 1.1560775476966887, -0.9065016571251938, 3.162352701382593, 0.7757702787194947, 2.2476292878554913, 1.4588550736682022, 0.6409742724247558, -0.38115755225850273, 0.9353372874651452, 0.8349207671419676, 0.4288163084784439},
    {0.4375958238968795, 2.0369691018745306, 2.2342427112685495, 3.1976817829304447, -0.24066994645280682, 0.24806436914591093, 1.554977125368134, 2.7218298538033405, 1.426601982452875, 1.7032309242265125, 1.472788291262876, 1.6484237692316979, 1.0360332498230709, 0.031676890665533135, 0.041609406110178465, 0.5220430565754823, 0.699416527527511, -2.8262097384408906, 0.3995576359465065, 1.6497745073151626, 0.20076609512480512, -0.08035347583982756, -0.3812156159590238, 1.6471384491088672, 0.7308202248154675, 0.5255228442227976, 3.4062590406753737, 2.4512133062259673, 1.6265748935413822, 0.1826793305217016, 1.3530225469265025, -0.5908828989112607},
    {-0.9529006367350286, 2.961566210961068, 2.2901732362618312, 1.3194866868847555, 0.9925741018325223, -0.11024452830846854, -0.5162953205652842, 2.67139816386952, 0.42376302162911306, -1.8417042820898781, 2.138035601879317, 1.2528653190587367, 2.400573862189605, 2.4575832308735923, 3.0914087373063803, 1.2418567918100556, -0.4446377178426699, 0.005280321098740609, -2.0976881618316447, 0.16886075939733267, -0.8253371755391308, -1.0440307669321032, 0.6043718697104352, 2.289906042950979, 2.9183567406165185, 0.2631107184905804, 0.9770272224127052, 0.06830272848988832, 1.5300565360074847, 1.8414702226112836, 0.9866472672789245, 1.0290439332271815},
    {0.5913985100286792, 0.9404643662092936, 0.8157971859816092, 1.793881686745445, -0.6761642398024275, -0.6080639348346244, 1.907200821976082, 1.079597711299065, 1.9053862083383952, 0.01121966298215765, 2.122972851435632, 2.9910680762235695, 0.9560229807499148, 0.811979307513749, 1.4957809984688724, 0.7996430703362403, 2.0159204858584006, 1.6189516632120373, 1.3418448959737856, -0.15011991062168586, -0.7932320438217975, 2.3045941143329545, 0.29778121751580194, 2.1122351856855666, 0.04334257001292279, -1.0312643170430924, 0.6664490212065287, -0.04295570743587297, 2.4930708391593197, 2.9646455561420413, 2.193587557751701, 1.028039585118923},
    {0.006487714077371875, 1.299318396198652, 1.5834132436996031, 2.3545341038979126, -0.6517788096970024, -0.25444826984644336, -0.5012902331756637, 1.3078263244741783, 0.45162896512906914, 0.2969504637840265, 2.1349793798623034, 1.986989694391685, 0.9078466832426846, 2.4657296260551256, 1.283776564616986, 1.2588254935503425, 0.9148925618371878, 0.17170204141594916, -0.1147535505395303, 1.2709083269513857, -1.2229359395451196, -0.7344615856244209, -1.8391619895845248, 2.263911960494401, 0.8290383712657552, 0.8154047412397661, -0.8486607890870235, 0.6813953039792826, 0.8647486626309956, 2.81542075934858, 2.0027428032184034, 0.4751544396169642},
    {1.223028275902742, 1.7155981436853496, 1.7629403158254702, 0.940538064109804, -0.5599260847044978, 0.502666361203732, 0.2573795312826739, 1.624869627192401, 0.6856924818574993, 0.09681533038912421, 2.1539769149593178, 1.7117059169201405, 0.7227308809238829, 1.3770447714752254, 2.65703137746272, 0.611162114989458, 2.827179001198612, -0.3257467872320066, -2.002003059269878, -0.3340520130395756, -0.1835301289337913, -0.5939750494456879, -0.21886797836682628, 1.212632354318994, 2.10477185610574, 2.660375791852249, 3.4398159688988157, 0.8719331955831706, 1.8961819043212762, 4.095046342502276, 1.5215056791858423, 0.45519551324710256},
    {1.7872012044808858, 2.0988582967342966, 1.6025877240234214, 3.085988244420575, 0.9381584767435687, -1.2018717545119144, 2.359498865693622, 3.1152564396174487, 0.06689060399889941, -1.5675425673911563, 2.748690933357854, 2.327089406272283, 0.2824535624279031, -0.4732130107986043, 0.6077228306420499, 0.8370311769383252, 2.2544268829302356, 1.1905485847309942, -0.6528658963014781, 1.1234748018693996, -0.7069514242006757, 0.9427725459289216, 0.19676859210980563, 1.4700087800606196, 1.8334214281546157, -0.0662526700657451, 0.47872766509454395, 1.8650925433760677, 2.7022000126692327, 2.2465555072529035, 0.7289258953247068, 1.000425375011681},
    {-0.40623098511974426, 1.0538857038177252, 2.191533431744929, 1.0151274465424416, 0.38927130468302423, -1.2876611655264, 1.7297442123668305, 1.122280195094122, -1.0936790401035494, -0.056706492102243454, -0.36173439502253496, 1.2401525231110977, 1.129840577222101, 1.6918860881317288, -1.0919787641642724, 1.66459563439053, 1.1270199635169709, -0.6540213282901308, 0.11292047342948269, 0.5934767621052134, 0.9643374040236836, 0.6709070981668966, 2.0026854358456894, 1.1840753387428051, 0.4755299267865366, 2.314010468577468, 2.413071047038259, 0.4314603603332855, 2.0603238356489966, 2.3453951239358215, 0.4619631016931054, 1.1274559487052929},
    {0.20448689324067917, 1.8817257691228257, 1.6120239566328372, 0.08742101045590202, 0.9005552158873906, 0.7726530420405269, 1.1436203745458593, 2.4576642134134294, -1.1048881736254188, -0.6853648246926233, 2.435018834930081, 1.5424137620214482, 1.8550189400727355, 2.2132586472293574, 1.2853893950009005, 1.9410532838763324, 2.1749060173560935, 0.5612926042727355, -0.2854065228898481, 2.178551542781477, -1.2871999455668532, 0.8692428080923835, -0.9701330346312425, 0.14673874501690587, 0.46905352349773766, 2.41292709296009, 1.5495196742475115, 0.5471471711000557, 1.7599646824810613, 1.344684909573785, 0.3465241424081214, 1.162800554299779},
    {1.5475779458234322, 1.6764579033347802, -0.16931765001017926, 0.6664727214633537, 0.9103236069206219, 2.144357391064222, 1.9605488527300308, -0.3281424542410262, 1.7957218866916038, -0.004914029129371019, 1.531405579937221, 1.6121422817968991, 0.8432327756058839, -0.8326582024703235, 0.9301510363791614, -0.3658620928382772, 0.6017026067907549, 1.4605397741976285, -0.775030336665458, 0.2562536628043438, -0.7859043387424404, -1.3165320253011772, -0.7025874719942649, 1.1721280471982254, 1.5896930591736116, 1.8383175358709163, -0.031415016219676496, 0.6449765705460472, 1.2241179569558573, 2.0320173258063265, 1.0440990474898768, 1.5606521936216482},
    {0.9848393381091026, 1.9388714914592642, 0.9952701823041203, 1.2945002598057904, 1.4582007345340422, -1.651026968988073, 1.470789578166014, 2.2462498888509126, 0.13031185640823745, 0.06198651704266888, 2.8735438234571715, 1.1182644991732384, 2.3145532539243954, -0.9080611276122443, 0.6834586829450481, 0.8480797044858668, 2.0137507789632623, -1.994350339486567, -0.780705533298877, 0.33639202758387315, -0.037317161591069424, 0.07287606512533357, 0.697326491901939, -0.10339094683606967, -0.8462346474404796, 1.650928567893648, 1.1685653097041224, 1.9748882656497517, 1.310146770361451, 0.7916928875952818, 0.039893586458559296, 1.6910101153323787},
    {1.6907204866452765, 0.3011752386178572, -0.38765399250308463, 1.7472396002860893, 1.064890180816449, -0.595571856466099, 1.7995620120946745, 1.2345074183436167, 0.5322141254662837, -0.9736269518123771, 3.292042991237124, 1.1984640571443983, 0.06780788032726198, 0.10960106134796702, 2.366027801906635, 1.8425389712428755, 1.809551250603447, -0.0838892348040414, -1.4930138541215054, 1.343361336850458, -1.3053185262836615, 0.007880178312254108, 0.5206230385071385, 1.823693796576598, -0.2844030000497082, 0.8513844116888141, 2.5471454562202496, 2.693755502887925, 1.445472929913465, 0.8723220866908716, 3.3038072682643835, -0.149490189950122},
    {0.24426786212174995, 0.8401855187077555, 2.695338627831518, -0.29507033961379137, -0.6174257495523138, 0.19600905421928164, 2.65825355056993, 3.4097109622935453, 2.1842368648200803, 0.6924990712734194, 2.434978112625519, 2.053978661569599, 0.12641839893647225, 1.8914567421474524, 2.070298732884989, 1.9067176590827515, 2.136287250516636, -0.3085294077476659, 1.7079484456822798, 0.44498853636485974, 0.8244927239419133, -1.2878682795276806, -1.2407203084492506, -0.39029459836893954, 1.2165089425765694, 0.5270649775249974, 2.534945114317843, 1.7296970838081918, 0.9634555189367515, 0.6889611237132164, 1.738542040542981, 0.600929432375023},
    {2.7376375123497363, 0.38052406257254257, 1.8321380257657467, 1.82590178652545, 2.2452276588652444, -0.7616980882838816, 1.6309759043977363, 3.3180074180098487, 1.9587890852625531, -0.4679729454395539, 1.2079357232404986, 2.2106598275153666, 2.3210230007742347, -0.15902613058513015, 0.8592462188997688, 0.12430489288528748, -0.05373764520333134, -1.4094525570222616, -0.3144238168892205, 1.1246592761647043, -1.5760191758554314, 0.843445889110459, 1.829400199149437, 2.9986279793414736, 0.06510415566718177, 0.052763990638467054, 2.905016569778691, 0.4013692718639948, 1.5045508793301101, 0.7597702043555141, 1.9578099592478684, 0.39496443641150314},
    {2.816807712915817, 0.90636096189907, 4.253844630527538, 1.3876432940369798, -0.5265124094801593, -1.482723911537179, -0.7503597025589813, 1.542264971219318, 0.2629875253358061, 0.9416563116396914, 1.6820739464414685, 0.843071028854016, 2.8157069041857015, 2.9176985219252387, 3.5582048541961924, 0.1957829515591933, 0.9070218852998386, -0.04738573603591771, -0.32258238901842934, 2.3039265751318125, 0.09358344431525034, 0.7713796151329215, 1.0861847931126927, 3.1172669462900755, 2.4540056423080205, 1.0462854059002724, 2.3387790110001316, 3.2770191620226714, 1.1192502613511452, 3.4249471144827206, -0.5400439255730652, 1.6970944484998027},
    {1.6035836713478453, 1.17889607618877, 1.5883324805790051, 1.186331974919416, 0.20487447031513764, -0.8392600658638586, 0.8543776376539154, 2.6043019173771484, 1.015523927885913, -1.5491497200067639, 1.1212037954398084, 2.5305697128814417, 1.635646320348065, 0.9962897747978777, 0.795663373191243, 0.12028536189648106, 1.862091092282469, 0.20179894407149904, -0.8805043410436166, 2.0401261065949443, -0.29621574063774897, 1.6422522032572338, -1.6334480244329501, 0.968869370725794, -0.6547810511812198, -0.38284573456564586, 1.9216854613126397, 2.303041683842281, 0.6613371218596802, 2.5393840671846593, 2.3540168245708357, 1.1637063646367392},
    {1.6316498541110962, 0.8071417675128589, 0.386069465369576, 1.368496916899246, -0.2661400885428153, 2.7463021981076725, 2.4115676279687204, 0.4945277575418545, -0.13891175023119334, -0.6762484972850926, 1.9818875080407115, 2.494397573711518, 0.9514308119884468, 0.19835582099478352, 0.43156019518276617, 1.8468938602733256, 1.8998061462344846, -0.038391174428445085, 2.0656018426952802, 0.10286689811605314, 0.7728923734145232, 1.1575044089115993, 1.027285391145275, 0.8061554639872948, 2.539195638971391, -1.7113585406561742, 1.4387431417323953, -1.317340755020434, 2.6986636225212246, 0.11557714845531096, 1.4700780724684799, 2.313442488383528},
    {-0.1439227749875509, 1.6744738234490317, 2.0566032171671855, 1.6731216472253003, 0.45111417262540954, 1.4556770019910905, 2.259867275800149, 2.5985033179396297, -0.0029954205018334983, -2.239956361580231, 3.186305463951943, 0.20883816511190118, 2.5645846799409244, 2.0295791292212466, 1.614965455026436, 0.014757536035662343, 1.9982483949299872, -1.157043873755585, 1.1547552432777444, 0.23200623931818354, 0.9498948780527106, 1.1559420987820106, 0.39141061351424217, 3.274617140199403, 2.5449044927394056, -1.4905620251656577, 3.1922022985494594, 2.171001401716769, 0.2528049062660292, 2.551505871666747, 1.9122726779021983, 0.2858477969938346},
    {0.10582467903305728, 2.115165575555135, 1.4680876751992045, 2.828187797015973, 0.06978693185686397, -0.9751112939233394, 0.08138970348168802, 2.074844747285208, 1.743464070999375, -1.1976204659970908, 1.6604219949211243, 0.8484519849051695, 1.2488269768794342, 1.2383015047780892, 1.7070935078001905, 0.5841729415730677, 0.1656061422331881, -1.186402402148516, 1.1425359545206437, 0.546401312707943, -2.638734903497632, 0.25041559270967334, 0.7891366398169406, 0.5655307839767029, 2.335024828138089, 0.936866439300684, 0.14106794427482916, 1.4066796352889783, 1.3747517874340722, 1.6228231747083435, 0.06502512174572798, 1.5266087502390848},
    {-0.7699782517462905, 0.7206069355854532, 1.225111870429516, -0.29821878565085735, 1.2108606718060313, -1.3063759078259396, 1.8708739920038735, 2.05206558169177, 1.4909665420784621, 0.05186290785180304, 2.303679096057879, 2.5730076207950887, 0.35525761857677557, 1.0831066403974092, 0.5583968629430192, 1.5422152674771687, -0.21161840294654724, -0.22497832868026452, -0.16550113810396228, 2.1740421014328293, -0.29679075393901894, -0.7708218628225041, -1.3879783231136982, 1.9037084263942716, 1.875801488300246, 1.9729010472329367, 1.611598581365264, 0.9598783888253614, 4.568016753973824, 1.4422713445781905, 3.1464567985797904, 2.006597158849229},
    {1.6137301930122407, 3.3951009984223632, 0.2654691979608974, -0.314208269746325, 0.640824066301882, -0.41486338689329205, 2.3150151137145016, 1.030104464617001, 0.10442887513506927, -0.684392843856427, 1.008512894171996, 1.3718453579835588, -0.33641850769964776, 2.908632162870105, 1.1190266309562398, 2.5814316424815074, -0.7898634944819761, -0.3113548026804709, -3.4669245912117663, 1.7813234954732635, 0.4293165643556681, 0.20590321665433853, -0.18339975959711657, 1.5464286898616209, 1.2253957297922329, 1.8814610666273153, 2.755100120331144, -0.09384546487471726, 0.32321315533269623, 1.438504861354239, 1.4494039008860142, 0.25787947667748556},
    {0.9333247650313351, 1.6315557595680525, 2.534255214069047, 2.829944888147146, -0.4619847935871885, -1.072335555753708, -0.02690999479703289, 2.8398606001240365, -0.16817763592201967, -0.9629023195724296, 1.799807649104918, 2.991517994275224, 0.5391085074460337, 0.30012881133008473, 1.7217268819312703, 0.8541036480702672, 1.202399887105575, 1.6833733214595012, 0.5962374404960078, 1.0715472434514453, 0.16266476438331856, 0.2055615622588903, 0.682250391809959, 1.9023292301077575, -0.29509372730155503, -0.47457029739970746, 0.4984622000309425, 0.9303115918037695, 0.4184548452414214, 3.2169241843305443, 1.5004553203673385, 1.7190201121362776},
    {1.5820353727067258, 1.7074673522504809, 3.371129573527371, 1.3406323073021287, 2.2863242334987115, 0.24703242625186592, 2.4571166566041045, 4.326148522181283, 0.13157205237751907, 0.47233628462025623, 1.8880424016929016, 2.0818890571999877, 1.14450807049568, 1.469429098416025, 1.748662727643723, 1.8085861189332813, 0.7921469519617163, 1.2823210331329422, -1.1159663390050696, 1.7634461778639938, -2.0729872636238813, 0.14364631633337757, -1.5614418909445424, 1.3466462271598156, 0.1253152394170411, -0.41580604758271983, 1.3422729519612273, 0.7855697525852751, 0.4879317076456761, 0.7893823972435349, 1.9566495021446166, 1.3942419607690828},
    {-0.28546450625622277, 2.067235208488535, 1.254326655012658, 2.4054974156763347, 1.784357437327532, 1.4950845280381788, 0.9404123622680864, 1.5562589969468807, 0.4587885251103207, 2.4422919501703144, 1.7133949556121988, 0.5607590134016842, 2.011473004486958, 3.1678987690914355, 1.5608883312955646, 1.0457624101835288, 1.239053661086174, 0.1968488901777118, -1.1926757473803509, 0.4503629132872201, -1.065589582813494, 0.08447595265654335, 0.04998758783125672, 0.6769588337273378, 1.2382256176639956, -0.10999769730135843, 3.3011246061854687, -0.745996454630669, 1.940137168789004, 1.1442146287792523, 2.845157741298787, 2.3114000787483437},
    {0.45210090365830835, 1.5875386301168093, 0.655777242610206, 1.434770020821817, 1.2337258334920918, -0.003883110595340283, 1.4043123970865434, -0.13378470263777054, -0.5184304420464635, -1.1993046086002555, 1.0895900529441354, 1.9130434170843884, 1.602028707130907, 1.0237235618520757, 3.1635100710505184, 0.1964837403122855, 1.3071645901141185, 0.9819183283731583, -0.23060593499352622, 0.8202382301701058, 0.49687694093462226, 1.443033304715254, 0.519990230561786, 1.703148944212283, 0.032442809931442156, 0.9579038172804514, 2.2851759986372673, -0.2627218486939413, 0.15405481802028032, 0.16537075806928472, 1.7995400389084004, 0.41364716611245983},
    {2.058708226546087, -0.8327675101017682, -0.05655400051183409, 0.13590303986943478, 0.45956021707559147, 0.29693887254833995, 0.31136541259652883, 1.4801741159384154, 0.7992021013385854, 1.3575780915577658, 1.1112295292040844, -0.4475218465692646, 0.7075477297739423, -0.11991918970703604, 0.578131418962371, 0.2425516111063512, 0.6543872796426212, 0.09582791226731442, 0.9515434421735857, 0.9141822215299837, -1.6915500057049184, -0.8911417351439833, -0.8062000401143008, -0.08811962233223333, 0.4070003661966382, 1.807147934192416, 0.15606199715151, 1.348165089701183, 1.1450902946207653, -0.6385793143995853, 0.03359224263049763, 1.020106818772723},
    {1.63870682876834, 1.311002647367783, 3.00811225447884, 1.683885218230472, 0.11047811782722901, 0.46259767408060803, 0.2660337233636085, 2.6050471625290754, 0.7152912447051619, 1.1348376025996818, 2.609570813848259, 0.9538736497122631, 2.468232824365279, 3.918091243740704, 0.769081347371485, 1.2201860202244383, 0.9708421898705338, -0.7337227743547313, -0.42448162587687266, 0.4519402116357868, -0.5067602359190592, -0.4487133165649991, -0.746613452697157, 2.718510655374838, 0.07073963362395021, 1.559718160721394, 1.3078295996857259, 1.0900934525352886, 2.806255528640725, 3.6275011529060075, -0.1393600401766685, -1.4320070729632934},
    {2.405997822114561, 2.8189061000171374, 1.4646530652085807, 0.6204059239502312, 1.3438339772767978, -0.28147968175593685, 1.9326703143967805, 2.1060662952190974, 1.4863794874214615, -1.170464046505034, 2.2881091790070283, 1.6849348249238099, 0.03025594829225547, 0.4782307278843083, 2.4036741132131367, -0.31942326853997605, 1.2778902044906164, -1.6037677386471891, -1.1829078652697707, 1.6046057768219384, 1.2390199275559635, -0.21542156127766013, -0.18387851208489728, 3.0844293167638526, -0.5756545303086329, 0.7279536432076049, 1.9386617924078575, 1.4682254589350106, 0.7628050003859043, 1.8283243125527968, 1.0699572374558437, 1.4399561969585373},
    {1.8455855797043943, 0.6850988732517277, 1.2899640526360905, 1.9653571206969418, 1.9739067155301206, 0.6993285901597859, 2.8018475978814923, 1.4586571060220554, 1.163040573111873, -0.26700698616682056, 2.0717361793147373, 1.3684760927358401, 0.3958891374106831, 2.4309419487882193, -0.5643408023857617, 2.5010434403924116, 2.355775172345873, 1.712857694804953, -2.0251266457676262, 2.335072050419248, 0.22262895572012065, -0.041537939481127106, -0.8587590670778288, -0.1432079542453282, 2.2889226777733294, 1.9982720254614224, 0.8196471958499818, 0.07201529923283989, -0.288097227857799, 1.3446549692767247, -0.08901399793895573, 0.01987120304755867},
    {0.5318409316420107, 2.144860846979002, 2.2607544613236357, 1.2229726745469893, 0.24223833021747346, 0.5952611098757311, 1.2731426054045654, 2.4206542625901624, -1.4677985206074227, -0.5169798462937114, 2.7674710924888313, 0.6786310890940814, 3.048792596769406, 0.7746744627974491, 2.211761802858072, -0.39987023691503526, 2.134588495289439, 0.6703835313286323, 0.7879702161901982, 1.794720909557426, -0.937072602052898, -0.6920979201536108, -0.05909764348483918, 1.8323262591114151, 1.734333831670441, -0.4194235178881328, 1.3647901285587154, 1.6687509655488129, 2.099770011833323, 0.49409216827930263, -0.1501954046466552, 0.6142032091783528},
    {-1.1176016006079574, 1.5199343967535865, 3.2302830677470253, 2.4834369109699956, 0.8711678614503556, -0.6722810462302958, 0.8710357505379649, 1.1421024413207461, 2.5926328669971603, -1.8907438498410463, 2.5224130520228085, 3.6426268390861045, 2.940244505246398, 0.9829566404270766, 0.8551372125733475, 0.8251618970387729, -0.7487242489264799, -0.38348949027009865, -0.5773926143442528, 1.0759107601031777, -0.2654453587834166, 0.8144489573789676, -0.5128766361893606, 2.9276390942698813, 0.7484222005802148, 1.3372851124148741, 1.5588437889295814, -0.07238151860813721, 1.9051639729482934, 0.5400022973813926, 3.311672243019386, 2.7391653416320594},
    {2.2638583351491675, 0.2762532667195941, 2.7183137721991772, 3.2787732992637393, -0.7751241443562076, 0.10953741065434128, 2.310136870092431, 3.155276447727117, 1.6055730906584185, -1.349069503215776, 1.3558142284014334, 2.571440012054499, 1.961733469314174, 2.474107685328697, 3.482745506710103, 3.544658679759961, 2.1027656638199157, -1.203660509570597, -2.635928651837452, 1.246502488139658, -0.512412978740817, 0.0010109653082795006, -1.6102028390807273, 0.7272061382936482, 1.0345248181325373, 0.6535060430079737, 0.3034449302564024, 0.014446124127331931, 1.8782609869020184, 0.491614952751287, 1.341566357602618, 1.993974998578631},
    {0.44366746804708074, 2.7325551750215102, 0.5565281934493207, 2.5675082266161744, -0.4421145981448684, -1.0936796446173844, 1.2925021093358844, 2.0298579579750755, 0.6071454447948191, 1.2744543804626234, 2.762330589183051, 2.728509833974111, 2.5947017314899847, 2.2029443157140225, 0.5299960677795286, 0.2833616900013599, 1.7475572746347658, 0.38906931777674547, 0.043905724309892334, -0.6626552240545657, -0.4074215985334894, 0.5739603223665886, -1.5165082211720238, 1.6806519928417605, 1.0063228857597104, 1.4473598407005233, 2.3298334748638507, 1.277285303356754, 0.9615106076329424, 1.8007668458980939, 4.383241862082607, 1.3086101833060293},
    {1.306602116042987, 1.6834239927381511, 1.5571543978579054, -0.018138292041616447, 1.6256946376193773, -1.1237709844219774, 1.0333572020857804, 1.8292681262770225, 0.10389986611952662, 0.0942335435629756, 1.6229895306946003, -1.2586562332498632, 1.8180879059649093, 1.7834635954348799, 0.2860482730503933, 0.3765072376378374, 1.0975981613986112, -0.2758359954287309, -0.36905414408040543, 0.9036696862458015, -0.8626147969959893, 1.1118842743568669, 0.27675438554026943, -1.015256643609177, 2.0382934414107345, 0.7437097166250206, 2.9342059759378514, 0.265279210405217, 1.8312350929304197, 2.8908788562998824, 0.31939291089837, 1.4414601963948608},
    {0.6530389322581736, 1.1644945090905408, 0.2847907325654, 1.5138496858333261, 1.01289574159727, 0.6584016510757774, -0.06532020620167277, 1.618387074156322, 1.2627537119455197, -0.07512434552493963, 3.6675212226798735, 0.9068386084275972, 1.2031336092190499, 0.3840502587588475, 1.8484893845512773, 0.9097713759084466, -0.1440697841414874, -0.5451047027596404, 0.9187191560944431, 2.3368340261435434, -0.38080025495793407, -0.7417742314840031, -0.5482328158875415, 0.7832272345762525, 1.8081133674152159, 0.5803699812966261, 2.5837937557885384, 1.1994771370716273, 1.3503343695314742, 2.3199638354241645, 0.5585819897879463, 2.036464002939025},
    {2.3081163615655456, -0.2463079135451151, 1.3618985932220975, 0.594495238332877, -0.2578022096323873, -0.05003911901342346, 2.3004391559418393, 2.8635895966132203, -0.6740006701690203, -0.45066709713610975, 1.3113782555777163, 0.8692718042882341, 0.9760989614716966, 2.130439645983184, 1.9905330170098112, 1.598840226179116, 1.9434369900421262, 0.39749360963965463, -0.2822767563933227, 1.8746612164248782, 0.2261024115533483, 0.8771637452591365, -0.3728291912372747, 1.8609690488785795, 2.0634707070830927, -0.5560628670201305, 2.3982531555771662, 1.9680211772936878, 2.3062988722523645, 1.9642621967062026, 3.400376892300177, 2.60116457109489},
    {1.0585223562791026, -0.5322604980215595, 0.4230414653662208, 1.9168143407084488, -0.6735508149961598, 1.2448593091672673, 2.207450989643843, -0.2983551892721327, 0.7184880400935594, -1.9252992019749164, 3.2649658263342074, 0.39904899604213223, 0.7727662181784193, 1.6476736904715497, 0.2618792128175363, -0.04791261339245086, 2.235865726314222, 0.9878591258816829, -1.8555564564771154, 1.9846966080018447, 0.2622985618012053, 0.2587592471286814, -1.476047767327202, 1.080914012857075, 2.5623012231481694, -0.08357995923079953, 0.4456259951670631, 1.6792244921596589, 0.8020121805164623, 1.4738210371273024, 0.6579727656910748, -0.8264362833523555},
    {2.128268451936703, 1.6460941511508764, 3.438316559988349, 2.318500307161039, 1.4427287982655363, -0.8281023083630831, 3.2186284601813866, 2.1763520734121613, -0.3347847318188066, -1.1339922577489436, 1.7096001278473505, 2.6364692876441684, 0.6181344826863996, 0.5549043894127098, 3.34578827478093, 1.5218430734654258, -0.31249123191846856, -0.07767767841089283, -1.366553204758028, 1.537714005402008, -1.3416079947068535, 1.189991866974449, 0.7364208701192627, 1.226594463065561, 1.605068926122937, 3.0220786237800317, 2.7210280091169463, 0.41661597560653574, 3.827638993879021, 1.7867926483719896, 2.8079714672191853, 1.2528137116305005},
    {2.0719323766038653, 3.0325261011131026, 1.095110183993246, -0.07047432187248821, 1.0252278616709454, 0.3037323159735317, 1.5447769968104084, -1.474207473509628, 2.2600724609878076, 0.43289745200641705, 1.7572527428151257, 3.8341690182590216, 0.9439116395506477, 2.2349092694562183, 0.6430991165406508, 1.0674271268359883, -0.47352616863363595, -0.19731495389104717, -0.7743688631094529, 1.9612027887896908, -1.9379585149689313, -0.46593020217267095, -1.402491720033218, 2.345900811961319, 0.17493363179452806, 2.609464093875403, 1.9820908038424239, 1.2758575700514414, 1.2513211791848646, 2.656750149743907, 1.8696735199996255, 2.1758579633785238},
    {0.9767450767912329, 0.31864172270577246, 2.700915178247864, 1.4095015179529267, 1.9605319378031791, 0.4735765226929268, -0.4618098903104404, 0.7615021252914199, 0.6926210212223781, -0.8334539409675035, 1.1762681065970306, 1.6405137464188797, -0.006297173030424298, 0.4869202987498406, 1.3155848377068269, 1.3882865840731398, 2.2437364317131987, -0.41283216013919855, -0.18546120550035478, 0.33500199181751744, 1.1010703243777962, 0.305742040357417, 0.6430067590397992, 2.5031375422329285, 3.8580007339952775, 0.6994541778556395, 1.3433740380563564, 1.110812756189451, 1.9095002005850163, 0.9650037854159599, 0.4619249399476051, 1.1234110091664031},
    {0.8202372207338272, 0.8512139557965204, 2.012187368953549, 0.11984822889164677, 0.11032000611757652, 0.06825284518720141, 0.9725436547729063, 1.9787872293707183, -0.1293545654594226, 0.36623910567302115, 1.9968435224640355, 1.7390462216834834, 1.515752874288399, 0.403872655768305, -0.29234979125101873, 0.1850517833874048, 0.7288883119468973, -2.145358412159518, -0.5152081238103113, 0.4376573532931777, -0.12884667512153422, 0.7959754695512676, 0.1328545329486864, 2.2141405608610323, -0.5505853816010942, 0.017781826965556677, -1.1491937192051511, 0.3483605625953407, 2.0258542157190558, 0.5500328137581849, 1.326667267089475, 0.7425669024297712},
    {2.352637272030692, 1.391855247946255, 1.8222019260443136, 2.232416820887438, 1.58042760891587, -1.3795034910087673, 1.444292321828334, 4.635628811334615, 1.3581758929853944, -0.863525983583771, 2.7728449908155515, 0.7737448346076808, 3.4212004318433133, 2.655293072165248, 2.5623453369250515, 1.599761242910946, 0.5552448965063982, -0.8121515994004435, -0.3931381798749067, 2.657938722809019, 0.4059919123409152, 0.5722556080603121, 0.7533143787424469, 1.5460117497640253, 2.1064812191855182, 0.21469394278261827, 1.1779080457679638, -0.3693627790070433, 0.9925825461967256, 1.9607165695778817, -0.1985590357428334, 1.2546329989906617},
    {1.397169367274819, 0.9089130570205057, 1.9100370913470421, 3.571210394737633, -1.2590836449823941, 0.4146873032992357, 1.768778150018719, 1.3052061513461553, 1.374285808148064, -1.5984714808475298, 1.4119372787206772, 1.1081072906912912, 1.4449214881173635, 1.796068945595462, 2.149359785460291, 1.2682869214435435, 1.261610902869723, -0.9675052682125387, -0.22385608802591267, 1.1109894313696795, -0.1767057154153768, 0.4360285885986745, -0.5479370971319207, 2.1138053047071894, 2.053613356865865, 1.1403235603162933, 2.3445521268302008, 1.5547122403078275, 0.6800538549337032, 1.5697418887114503, -0.17567785679690484, 2.3893912441772205},
    {1.1491550513466986, 1.8662283712605614, 1.280530997585879, 0.9814571763898128, 1.1535658600064223, -0.7330503015810937, 0.49219301595000176, 3.2017404835696683, 0.38390504355079685, -1.9980281936849589, 3.068616642588572, 3.743707664261043, 1.957460388587415, 1.245795033966895, 1.7795751087656366, 1.8047937973088293, 0.0490614390900702, -0.759942610314869, 0.7851761470294139, 1.268915609963022, -0.15387409705486738, 1.4899603744504426, -2.037204601214574, 1.3382258183387408, 1.5065400857485454, 1.3534016692225241, 0.7790327368459101, 3.257956111294797, 0.7754756306925839, 1.0064577000402597, 2.517964517009827, 0.5927150906621022},
    {3.8608498229432984, 2.6953980301769644, 2.8386894024094804, 1.2615509805257086, -0.06151937197064257, 0.17207146142195426, 1.0899942586564786, 1.371980970418054, -0.2907038958758442, -1.033371835310671, 2.5092473151840173, 2.014298589412151, 0.5011013592961712, -0.18984224966508992, -0.15313803092787084, 2.7967985324836167, -0.25062888268090683, -0.10583554461902354, -0.8925903192596448, 3.715025410983521, 0.2057654330977857, 1.2445085007735959, -0.5432862256241076, 1.1179611612922404, -0.5786259451584623, -0.22771211506369868, 0.42727721521735457, -0.7147848794930212, 1.6536432187856278, 2.7020222307530357, 2.0509546442933067, -0.8014988356321129},
    {1.9733969025554403, 2.4649150211759037, 1.5686902250004482, 0.126608730743026, -0.5887827164579663, 0.38143873521634614, -1.288593512408105, 1.3381348629644656, 2.379792002975091, 0.4673569178712453, 2.8450298018609796, 1.4672889948587504, 2.4298834391966277, 0.6135772731779312, 0.5247179777391553, -0.1726099302964649, 1.6759814499576329, -1.2049639011423041, -1.7330146809651126, -0.20929299233814888, -1.3026322465063631, 0.6559850618066176, -1.1425170097468467, 1.784279066898082, -0.7197459031588792, 1.0940576340640618, 0.23971709229240215, -0.6039963031931322, 1.945792904215242, 3.1985016112301112, 1.781372758593387, -0.41274776787731476},
    {1.43726530119592, 2.3201932587324747, 0.8938202780383003, 2.3246453297905303, -0.7188284242208641, -1.0479429434738479, 1.981403499506332, 2.351556362829251, 1.2037215392937244, -1.2191413845890788, 2.19603953153431, 2.3330061256301065, 1.1109556428575633, 2.1035722831421992, 1.7446137621917457, 1.3965793180450687, 0.03689654198834293, -1.4730436277692622, 0.386571188614477, 1.3787861116237523, 0.6672480462294799, -0.871703723949137, 0.08266816518073644, 1.8836522096860593, 1.1589675759558973, 1.1325603970443214, 1.5967202227480115, 0.5382808254839814, 0.8721684532606734, 1.4786897174156088, 1.7202524397359338, -1.313316385150628},
    {1.0345918342415446, 1.5441838764812508, 2.646964024463747, 0.2709666529934044, -1.6664990681951581, -0.25241095062706137, 1.0911422632259895, 2.5847556596127412, -0.5716832358194694, 0.5403500206333519, 1.3139941158315378, 1.745710344481192, 1.421292003836364, -1.8242333171085174, 1.6119964966608686, 1.3171485438682407, 0.9402631113422074, -0.027349494233358522, 0.10420080751167275, 0.13321004259478883, -0.1436554800646786, 0.04258243670571394, 1.1137826256143433, 0.3117618697120754, 1.5832459196922757, 1.529223314873757, 1.540830229357356, 2.0221460445890793, 1.0876517912083086, 2.6724879804522073, 1.7271714810307863, -1.676166759542578},
    {1.467601512627699, 0.34264380926407995, 0.5655660454881825, -0.44119081419414097, 0.9835644531759107, 0.10121373341788643, 0.316976589030999, 2.302987675230459, 2.403337700281973, 1.0235300832600218, 3.19847563935565, 2.619459638326211, 0.9594160739645538, 2.150675721395929, 1.1068350986696809, 1.3973661124076953, 0.30450892953097203, 1.6011358861069378, -0.41685861321818174, 1.7247551643423633, -2.3860048740981012, 1.3236936739127183, 0.4115860922268603, 1.112094019464044, 2.3828960031019633, 0.5733856467423138, 2.12822971515039, 3.6687433124515856, 0.7758244063923265, 0.44243012647213165, 1.3895697036018158, 1.3677779265931551},
    {1.8055025910009714, 1.6030668234952279, -0.40003408788159645, 1.1412524519896958, 1.0970038156030943, -1.858016010753269, -0.3789114552814722, 0.1965908248699643, 0.7802804894833866, -0.7594267824631941, 1.4064901684729574, -0.24570617524402424, 0.9692421398156864, 2.3614711646571904, 3.5103492402027396, -0.3557681233024224, 2.0759574537761556, 1.4104595233228603, 0.7560748701694224, 2.1737717057988983, -0.017237799509898843, 0.7070011320435393, -1.186762716957849, 0.31989133562945454, 2.7119787847336285, 1.0558572144600245, 0.7812730609074002, 1.8538341640452565, 3.01545412492372, 0.4142677113494152, 2.299234283685003, 0.9125407266653718},
    {1.1708199994665833, 1.409685465157186, 4.2827268746346485, 0.21717857044863664, 2.377050725217179, 0.10405248990385053, 0.6156994532886605, 1.8785486457395872, -0.8032558888365562, 1.5613680981507774, 2.560557822540082, 2.1363123652921048, -0.00524158448845837, 1.9665304417823657, -0.020502173853224503, 1.2513639789249966, 0.48200254866083764, 2.198102692459549, 0.17297102888444296, 1.3254501230960984, -2.673210975001002, 0.48577678457058815, 1.018473259836903, 2.695959850599443, 1.881653539444461, -0.6145155948536924, 0.9409155178120797, 0.12122731048195104, 0.3982979669978911, 3.3361114789171937, 0.5982169127806809, 2.2890791635445424},
    {0.6932075750729579, 0.7618818422965447, -1.4974621336959126, 0.8345641930386043, -0.5561207631728636, 0.7841190679805314, -0.1406855814926214, 0.4587853675315619, 2.595037974162745, 0.8508009367948627, 2.46314662351182, 0.7427770935136547, 1.7902058824868539, 0.5494995784860206, 3.454599902789557, 1.476644851941489, 1.9915927273680265, -0.8024401720336498, 0.0986687196944272, 2.2959744462962073, 0.5678597873536558, 0.1404470334261834, -1.0511489225666997, 1.7592722159418346, 0.3179052208971907, 0.5392711072234743, 1.547085441976101, 3.4435662021753926, -0.2798799456907548, 1.8201761955882885, 1.4500249400302645, 1.2333218588799122},
    {-0.12436259854593104, 1.393089753655749, 1.7700802297728917, 1.3848764940722575, 1.312217104665266, 0.6732726867984863, 0.6950109316000487, 2.358591163008182, 1.22579443240451, 1.2148517583598493, 2.338984606444203, 1.8349404353256136, 1.2035123215187518, 1.8501945218109517, 0.45045330008360207, 2.478946405637333, 1.8022559036337853, -1.0635071949484938, 0.25481041605956595, 1.405526825466199, -0.06356275532572739, -1.466908612455069, 0.188658281993104, 1.9930535719663338, -0.06719701738819162, -0.06144676583412192, 1.128056428597197, 1.2075809720806343, 1.538352043545036, 1.8582397392187637, 1.5385240117527563, 2.7477195202738196},
    {1.5475305783829496, 3.6454091411261285, 1.1182521718281333, -0.02880235594304646, -0.6608136719269766, -1.052387696390123, 2.8688736254062097, 1.854038371167737, 0.37637733780219107, 0.05945734929707554, 2.45792614903514, 0.9962957442870227, 2.2126713112099794, 1.3034589214847698, 1.514087218473584, -0.07463798813881682, 3.243800807940075, -0.5674171224526835, -1.4735872950564977, -0.7157134864668896, -0.34381947973060306, -0.2878666450572086, -0.13131539556190153, 2.9715636836413197, 0.2651092714210912, 1.656156266349138, 1.808504308263295, 2.1073929843275376, 2.139877020253096, 1.9733308641934681, 0.1986267669219494, 2.1913812240907165},
    {0.7890805843043432, 3.092410811096188, 1.6609711411565204, 2.616474825204533, 0.04030214006903866, -0.854355568408987, 0.3971740606891374, 0.8470700952416036, -0.07709515183220893, -0.829439354454749, 2.0250069577133023, 0.7249883639271428, 1.727640184429289, -0.4031203196077251, 0.01779032411167349, -0.2466119206290571, 0.46600389044539003, -0.12883435194623316, 0.13613947030826465, 2.3240556884356565, 0.3537497886318783, 1.4614999082846758, -0.36400392184317043, 2.1688569432420035, 2.4959140390165317, 1.209799911385561, 0.7556875258059229, 2.0779442510584434, 2.592045538587682, 0.9551962732739954, 0.09821332636591995, 0.2428512177330223},
    {1.3632577175722131, 1.4133796309481137, 2.872511083608474, 0.16556032648404556, 1.3928054919036392, -0.9007392603639364, 1.6140182435527992, 3.530492429561428, 0.39714371101422136, 1.6263520911630076, 1.925896364153791, 1.555896360500979, 2.1531299501068353, 3.285759356457962, -0.11706749070326393, 3.999994307028164, -1.082306597306724, -0.6392110475117085, -0.3812706243697785, 2.078045326849875, 1.746190448265365, 0.6976053979128634, -0.45232005079918286, 0.7426226201099284, 2.646722177156257, 0.1708591678858979, 0.3961641959343628, 2.100321840814918, 1.9954597517610357, 1.6849050351051316, 1.6292569533856256, 0.12984693467404093},
    {2.143773436815203, -0.44972691354396266, 1.360278207533666, 0.8053820219963519, -0.6044826221640344, 0.4215884828401344, -0.4555889837601991, 0.8914488148256552, 0.0802034252251591, -0.05346085425302985, 2.7976233122700362, 2.7116290711033995, 2.399927002686406, -1.3650703336269796, 0.9422519909289057, -1.3469339201499966, 1.9664691832380923, -0.03253770572257487, 0.3817423988367153, 1.3984445618471284, -1.2494152381316068, 0.41513775214842974, 0.2755938800080282, 0.5825811955317027, 1.1550124363551537, 0.9429004285575234, 2.566107149905118, -0.7423747827273947, 0.1888705606979835, 1.9914171347436929, 0.8329755426727524, 1.648334281060238},
    {0.9180868895806761, -0.7613148506698308, 0.8057748612021192, 1.4836076570224999, 1.5261499351018641, -0.33512998480351314, 1.7075777754577635, 1.3854118696099762, 0.7322086690211648, -0.6051742200094586, 2.258175779515516, 5.110557753888246, 1.1473544311390316, 2.0882355278495623, 2.0104074691067257, 0.02929449826394212, 1.8024418221575402, -0.713764717716531, -0.5480341650851982, 1.5788575290790559, -0.6457987860539747, 0.05456911334797651, -0.3907723699729643, 0.41519605541710364, 0.4977582406545277, 2.0981955644141324, 0.7837851722399749, 0.29457544395599083, 1.681420861623905, 0.9257209700540874, 0.09082119576383228, 0.13857018840706858},
    {1.5181682388851758, -0.15230952499365719, 0.6703137667608495, 1.1321479750146983, -0.2609043446449702, -0.9339960740175025, -0.23224208505405608, 1.0649772509013375, 0.21349842265138774, -1.7816221162939359, 2.7866501154213896, 1.7396512581696884, 2.007278990620862, -0.9339164684811312, 1.0373975092644188, 0.9853839551080557, 0.8285181185980366, 0.4695362149615806, 0.14894457500607972, 1.8735914967307064, 0.5492495858953307, 0.1782970839445003, 1.0640689975719684, 2.1280325687650126, -0.5060349408555093, 0.4957472228598407, 1.2528147667800014, 2.0470919490719917, 0.07725167259142814, 2.8859748335434503, 1.8877484070401551, 0.5391890046305479},
    {4.150144036903514, 2.3328824922912066, 2.0534905417616356, 0.8812579291280903, 0.7498357981011282, -0.34435011215504757, 1.3523023956063989, 0.982272009104641, 1.4207917022411984, -2.0698056461644887, 1.2545502810415328, 0.51928380685681, 2.341341173410709, -0.0304745623479233, -0.1873399189255475, 0.4276943450545271, 1.720288505872897, -0.47874014234638396, -1.0908986727955814, 2.61572709805752, 0.40393124251474233, -1.5285140795663734, -1.5076583105305004, 1.640020753001786, 0.6152142122964142, 0.668717137702482, 0.4238729294414316, 1.1669249440542309, 0.8309004523984873, 0.3099462495116974, 1.9693415688202807, -1.4349603669366882}
};

static const float b2[32] = {1.8686283438136853, 2.2237775936402486, 2.176671686762905, 2.1894600796508934, 0.7103831822128047, 0.02963211735584468, 1.8960027452743173, 2.857613024997967, 0.6610134895091281, -0.3428878889650812, 2.7318604503120474, 2.4920208079000252, 1.9174715786013647, 1.928570567257084, 2.121087290615785, 1.5481769622165173, 1.2608501226974242, -0.8369244812043506, -0.5213978004080737, 1.5739818759222763, -0.3688044735279488, 0.45887507825225754, -0.4651045841715407, 2.075393963710781, 2.047230191310454, 1.206268513144817, 2.5035753721319822, 1.4915287873621417, 2.0663225058530608, 2.7347254463639024, 2.001649521870913, 1.687958004005487};

static const float w3[32][16] = {
    {3.6552331552051522, 0.881542894122596, 1.0662777599031867, 1.2259037836637816, 2.5106399242732014, 1.0866922827163212, -1.1040698357367444, 2.5162991239901555, 2.9777542484998696, -0.7479243728457333, 2.15200339943149, 0.6690745170244902, 0.05132977303794303, -1.0382818218107224, 0.9192059803242638, -0.024989402697513877},
    {2.7814821915917602, 3.4183781813446554, 3.235070874143738, 2.5458564705214335, 1.390785357177112, 2.2099739922728636, 1.026403888314715, 0.6168258199024299, 0.8310480448666142, -0.1695678618222872, 1.7574354587945062, 0.4093953817708921, 0.8518655865001822, -0.7900343762259978, 2.6719881475525775, 1.5463173683349258},
    {1.5224700776982438, 3.4408387661604904, 3.0782065057695056, 0.5322571750605993, 0.5680571958981387, 2.185559107732174, -0.5583925594279154, 0.7874214713426302, 1.4040508769638742, 1.4699359776411685, 3.2460336826341436, 1.2024510665800936, 0.33022200168696725, 0.08618373230628311, 3.0179506671348038, -0.47279418599832734},
    {1.392510977350561, 2.751088637723864, 3.7467266667959365, 2.3708095075713604, 1.0663547978348755, 2.476019855896405, 1.0200193242838478, -0.015522683052173851, 0.2619416723626128, -1.7834882124945097, 1.6444634541073682, 0.5226230512322378, 0.44834744417649647, -0.769683570293414, 1.4510132463547711, -0.6618296496399757},
    {0.0953741356614427, 1.207290932021176, 0.26065442951612094, 0.8852466886832334, 1.2643378938160295, 0.9808205810843084, -0.46949962263494555, 0.4180797598997977, 0.048919801269255415, -0.9426051070525322, 1.0550345709808584, -0.2784686140730949, 2.0209900287003655, -0.0557691492009505, 0.915059604787564, -0.23416200026658898},
    {-0.41111218101112945, 0.6715888956343822, -0.363989049563728, -0.6469521323325748, 0.749654670805619, -0.15675886879459122, 0.09309077272117894, 0.1869662685156116, 0.22451426060791072, -0.3294621501431121, 0.47043483919920553, 0.31963176203940413, -2.807489315696763, -1.8086426324623306, 0.4162690179168428, -1.1527758573764941},
    {1.8905860842104845, 1.6176216865187336, 2.26802061185661, 0.22636717151409186, 2.821081520944962, 2.2122622172985147, -0.26107620022383354, 1.7236549502415657, 2.464648987533602, 1.8077803490960238, 3.0756568137131826, -2.4685266569288795, 0.9248636764423138, -0.22926055090044134, 1.3005112066550957, -0.06438305172659924},
    {3.6882584180539384, 2.1991066358401117, 3.7928076366073524, 1.6710077502895735, 1.981803598271231, 2.447913010422249, -0.8304076367917677, 0.957833444390783, 2.4035446468641375, -0.9968568137937691, 1.8610095636785544, -0.24226663973523335, -1.1817250033915938, -0.6081404292362981, 2.6129657735502287, 0.1698772614215777},
    {1.8618461615117445, 0.4709240087833035, 0.8705932014346058, 2.5052106526311553, 1.6686456055112286, 0.9912040246076532, 0.6840590618942807, 0.2699545150929641, 1.25441993448108, 1.913019336904223, 2.414523815682948, -0.29210097745861585, 0.6357736935768956, 0.8354890667144947, 0.2064183682279934, -0.7281347632114311},
    {0.11385458699041803, -1.051816781145765, 1.390683972790402, 0.34322635247472183, -0.05736118665551045, -0.6900619746268061, -1.6282773616775243, -1.2334764052658784, 0.27856592967936783, 0.21839804170334093, -1.6612466237905221, 0.5368655932736689, 0.2725368652448931, 1.3830584842392517, -0.020613304678907818, 0.9750782982704576},
    {3.3439944825008583, 3.7114539510357347, 4.73174471886952, 0.5797760625349447, 1.5733687533610126, 2.742226930462968, -0.48826271751148426, 0.3745368472654938, 2.1318731686640726, 0.3172497488703574, 2.2933345760969814, -2.809912822431718, -0.9115997464605364, -0.029841876251806915, 4.739471031372914, -0.32997973763531385},
    {3.2956389928513277, 2.7298966228035924, 3.891274620506501, 2.0885139188061848, 1.0329424126734623, 3.5497747464675005, -1.7688331292087904, 1.8621212159716796, 0.29286827232996276, -0.5976201764226176, 2.0985475895079424, 1.7891258823609815, -2.0551449271662325, 0.28231816616834143, 2.9547918330838745, -0.6326454534575848},
    {1.4909878594789543, 1.0822061869461486, 1.495228343724279, 2.8988202577337066, -0.49296101674173926, 3.792621854371808, -1.3265072901128125, -0.864249455106866, 1.5480619292027837, 0.13445585504695387, 2.099971112922857, -1.2972032021382316, 1.0316561152606858, 0.6637583115638191, 2.4047908748454443, 1.3633777559710267},
    {3.9047534141057967, 1.1091233348754228, 2.910012256885128, 2.3422385184721146, 2.542747383812514, 2.3893573097495677, 2.3652548075561466, -0.9919033202362162, 2.326844261545992, -1.5984082144031746, 3.419465127220728, 1.0296436973393346, 1.1594127647209613, -0.7917137910022469, 1.7815400788732314, 0.15807532356472234},
    {3.1670045019488198, 1.559672769783022, 2.6327770056222266, 0.4724437775428679, 1.4860874880445947, 3.7685700152027892, 1.3356492381626435, -0.13540114303290268, 2.0420127853870196, -0.8154128717248664, 2.920894580942292, 1.2749943350002817, -2.2312954608504323, -0.035895928850154656, 2.080012086272117, -0.2928956220475224},
    {3.087907076987444, 1.1331204891206696, 0.9976292344691832, 1.0409811975267387, 1.3407586883162033, 3.500767684715611, -0.187896599575122, 1.6968380113511865, 1.0532194566904673, -0.13507047629582367, -0.3784039160619828, -0.2512957812628712, 0.45855079057059406, -0.20764790039736378, 1.6849297906982283, -0.9326268224132974},
    {1.5252347522764225, -0.2524302894747311, 1.6977846479804772, 0.15087356378192918, -0.22344434548819053, 3.6555073058409167, -0.7697035809303487, 0.4000518337070059, 0.6431458288038923, -0.06873745960672956, 1.7933168889425335, -0.4039365520202134, 0.2642175387128744, 0.2496397087207802, 1.6274472333265229, 0.41591338453992766},
    {-0.2527922435515645, -0.9972955855169632, -0.4434256017601961, -1.1371203341921448, -1.17524190622017, -0.9724170335167841, 0.17137611254916632, -0.5016164990298552, 1.1369815084913133, 0.7382729940928151, 0.519444756455331, -0.3083842665759748, -0.9202828683444125, 0.8421542114324035, -0.33190894542235755, -1.429964260737777},
    {-1.2918572288394514, -0.08054625719305943, 1.0815123080916038, -0.660539298822963, -1.1525979289971182, -0.45734405018272273, -1.1423203752412774, -0.00010611857616399544, -0.5150645038766657, 1.122274960937661, -1.3674633107413101, 0.7928990152325056, -0.2096977484654909, 0.5192165717865763, -0.04020273535732987, 0.048664694545124294},
    {3.03826205943321, 2.87556661482419, 0.8054644007801841, 1.7838901371588163, 1.8890357255477594, 0.9013770802402239, 0.5732713080070339, 1.4382966742463064, 2.7873422494268536, -1.0026948896572518, 1.682658674080004, 0.30602861879225085, -0.3951212622542093, 1.6267718138412455, 2.665536009154003, 1.2764990942307397},
    {0.5216845134160233, -1.0205367086883206, 0.34503353522331937, 0.3410083883853355, 1.5185864719954552, 0.06053724525788597, 0.2665043630271982, -0.030660005613718455, -1.2829348071996811, 1.8376055614227909, -0.421357517581126, 0.13530724695736512, -0.5332210647892046, -0.15268045813856473, -0.29152973262463994, -1.2126301102219212},
    {-0.005632379940801708, 0.5995237964734699, 2.047761571136392, 3.1866807352359583, 0.6850249265916015, -0.29275837078134365, -1.1720626044685778, 0.6527067451613366, 1.183961411898524, -0.4548106689909982, 1.5324678168125643, -1.318911741792441, -0.06277216249511923, -2.261228617863909, -0.09485261710292071, 1.0706621233576339},
    {-1.3041030928718016, -0.10146778256061009, -0.34188287812993934, -1.3378453799411119, -1.1793890463900045, -1.4081003171028899, 1.4464887118258578, 1.143030426889302, -1.263082900162717, 0.875120445675683, 0.1904706824078623, 0.2738769965058967, -0.9946680615341577, 0.3549165175460155, 0.7998010900327851, 0.2647897175560191},
    {1.8676615986343905, 3.3886786005416836, 3.3180165088950617, 1.1833006943850246, 2.3801029175996655, 2.9837153761068658, 1.4918433626658478, 3.3636290203471537, 0.7950814564523143, -1.0614954925710698, 3.2355114001135767, -0.21050124318442737, 1.2954707345125305, -0.2655612210364901, 0.575963305510506, -1.296697723770171},
    {3.6822597292497274, 1.1575635248154355, 2.0941102216352583, 0.9554823481368222, 0.9774380422431127, 2.9274407342538034, -1.3522296837082544, 1.4850571894957345, 0.061741878730448924, -0.5607302311701368, 1.339825675681499, -0.8377092181419074, -0.46296173972578647, -0.9176435586557355, 0.8602758618325971, -0.10087733250582592},
    {0.6251875473030944, 2.9210981323847105, 1.693987258818476, 1.4982240276734755, -0.06549351558004657, 1.4865551987300973, 0.7060281133543218, 1.7756370150776997, 3.4167534860311313, 1.5360104893996196, 1.560861377753907, -1.472184566914311, 1.2658819814046642, -0.8124056362291735, 0.464107036336113, -0.26130255206625086},
    {1.4694029802609494, 1.3296530570831946, 2.184549555859103, 2.32379041657656, 1.7987160714379302, 4.0033975660805385, -0.34095192921351103, -1.0356266933489535, 0.06625470691565959, -2.06764950213399, 2.6152965743214414, -0.5844539943911968, -0.4671552886265259, 0.14524995651176317, 2.922315937531654, -0.5485946754317423},
    {2.701377412042869, 2.10229842623075, 1.5614058907466675, 2.6369031331169124, 2.621493069447211, 0.699736942508151, -1.1011764514220581, -0.16813640087492776, -0.3028507122131065, -0.5912472717037524, 0.6468219789266786, 0.7750011890592094, -1.4786437318549148, -0.30882116060892995, 2.324285470645967, -0.46667365811452},
    {0.7770434009167381, 2.8693517338429033, 4.047605439929279, 2.0555990390065784, 1.2250310864717413, 3.143427082246376, 0.2147901780049191, -0.17297981158631567, 3.607434800874169, -2.0626525591786984, 2.6770841500494673, 1.0834961535551593, -1.1669282115848862, 0.4862310090271613, 1.6125737288788509, -0.8554747403603069},
    {1.2613338121877504, 2.5265235148806684, 2.5948854901675253, 1.1194771853669132, 1.9325537703116447, 5.111312714297635, -1.2390693410319207, -0.8737189110100593, 0.07022674717559145, 0.11431988192112072, 2.4374973303313823, 0.0753396865922254, 0.5164666525954744, -0.9905079354438958, 2.846619825214797, -1.2414367898242682},
    {2.48182464719594, 2.4641721340520673, 2.742237553501645, 2.3145359683225704, 3.116477344871716, 2.7950070090211816, 1.2511137522199172, 0.9900221436950779, 2.5041373833689398, 0.6373544297172477, 2.994324829978088, -0.44662023437933607, 0.4776518238043697, 2.2174159534468565, 2.7187519381825918, 1.196123251372561},
    {2.9183247522928677, 0.25547408558298423, 2.987444623529515, 2.071994789270058, 2.6880715230371495, 1.4759107946679368, 0.6019054469699017, 1.2703850258242309, 1.8617505474308071, 1.0040604751620605, 2.286520800539041, 1.1419097523815769, 0.4187821187456981, -1.0529533758987144, 1.8062597496764514, 0.3726808653680198}
};

static const float b3[16] = {2.163038878067241, 1.7309833180420462, 2.0032437397002636, 0.5494170723100477, 1.0219044433763305, 1.9599547777701116, -0.4542847859769478, 0.4945693057202233, 0.9736493851441791, -0.5070355441553441, 1.3681624450532746, -0.4088461195165661, 0.15087584286012376, -0.3940769743830337, 1.8887633903291865, 0.010619947179545734};

static const float w4[16][12] = {
    {-3.1245549410839693, -1.6975599836291024, -1.4831661109160699, -0.5110433621896687, -1.7189390842780903, -1.3257316343303993, -3.043998073485612, -2.479070672994069, -1.9638586713441102, -1.885984084708219, -1.3507685135416634, -0.9565792386604066},
    {0.41857408333764123, -2.916854292038466, -2.4251005715418863, -1.9560099613779844, -1.2814855136827301, -2.4415771606530376, -1.5579662489889812, -1.8961207264612019, -0.9037912541552408, -0.25271253338753535, -0.8453739233500492, -2.311561830581297},
    {-1.0599944796384808, -1.475545838422142, -1.4447265645841103, -1.3493359929529618, -1.7324502857729913, -1.5707565560141286, -1.2683684596278435, -1.6459638174513693, -0.9862015198645145, -1.787650671760244, -1.9576659488475776, -0.9907379800045888},
    {-1.2676921769372078, -1.7270774137148153, -0.12123665448870523, -1.3085600880943817, 0.5018417564943987, -1.1998160830570932, -1.8326459348618813, -0.5637492904803312, -2.1799378921977826, 0.8058785193877822, -1.879828001605621, -1.7743733425493213},
    {0.5374051555617023, -0.9038801200221519, -1.5358900517392575, -2.0069289579723577, -2.5924635768425834, -2.452861688724033, 0.3301015854743923, -1.8162414219870666, -0.7459417054252546, -1.345351350114171, -2.394348852557657, -0.9406039981786825},
    {-3.2344266474048964, -1.687925735064979, 0.02919978321841269, -2.052345581874746, -1.719103610302741, -0.4164049136676103, -1.0889092133300338, -2.082437647249404, -1.997786649123815, -2.7662495647148986, -2.104472536542593, -1.3286234298033692},
    {0.19328277281527803, -0.27134795230136216, 0.11232890356543333, 0.033109964610887194, 0.7125633189086938, 0.08320565600487596, -1.2313148944527597, 0.45964356009981466, 0.43018413245913817, 1.8750498514656253, 0.4376008813513898, -0.29878117306051294},
    {-0.7558902711287683, -1.833768541948322, 0.047356176117585004, -0.038249420409999645, 1.540016998867282, -0.6555162573564481, -2.0045444414026177, -1.4071936278802746, 0.09520695296978966, -1.090669582393895, -1.7599497186816984, -1.821217240744021},
    {-2.0060640483294168, -0.8542150132466761, -2.1204654520625534, -4.218426549295215, -2.689499184220648, -2.3825599403781514, 0.6705084331712065, -0.7387556885416171, -1.9383858177775433, -0.45580140348189424, 0.08836208373197224, -0.9491009573280025},
    {1.9679530651149593, 1.7049288327477354, -0.3450926544067057, -0.03608555126153148, 1.338226969998753, 0.05613395883202098, 1.2596570088968193, 1.0017524279286028, -0.025145137708920295, -0.872508474780871, 0.3155227995697731, -0.06960787586683741},
    {-2.516006047069524, 0.11505510294808877, -1.9581980274555835, 0.21504353795501588, -0.9891631180573108, -2.163666770871593, -3.6292966442002963, -0.5955151086180535, -0.9608348330546654, -2.0339951647105132, -1.6156521804916102, -2.0215066352596853},
    {-0.34055273618349385, 0.5358486287056755, 0.8221828015304682, 0.9755507562554393, 0.2800810710477103, -0.16872958093817836, -0.9835354634263314, 2.8282992267122973, -1.0583808867808886, 0.5233298527333649, 0.2572577273085161, 0.884278971732506},
    {-0.32037823349042194, -1.2551122193222, 0.5857413595917217, 0.11261851012380046, 0.50803148620807, 2.040292504820603, -0.3081364230860355, -1.2747801413895263, 1.1126424186184634, -1.3308223612033028, -0.12348220383907366, -1.3193381444163657},
    {1.7870480822092536, -0.9823654455700482, 2.483758358643831, -1.4594552850524807, -0.6006360323445576, -1.5996279453694389, -0.4151117565988319, -1.0262907089598008, 0.3140112517002878, -0.09473531050656013, 0.14991652932129532, 1.4830511172463448},
    {-0.3769506334851976, -1.7200929491807893, -2.7927932508479274, -1.5296117237389064, -2.009108754125342, -0.41584145341016726, -0.6306821248064531, -0.8755584798786278, -2.3238573587746596, -2.338700787434228, -0.8512036078284325, -1.9290359269099833},
    {0.4986454825669074, -0.8692572559305647, -0.007049343818307579, -0.036931333805538945, -2.236562185482352, -0.049091632630011796, -0.5028710675493827, 0.20680351283704235, -0.1685698614694767, -0.43494361267329973, -0.9539821540265414, 1.1085217254465856}
};

static const float b4[12] = {-1.0714485032870276, -1.41303275743428, -1.0468375144109148, -0.9936576209920636, -0.9974367046978533, -0.9326214473938466, -1.154724877876493, -1.0587210465390242, -0.807004184559852, -1.1041780925107922, -1.0326068396577892, -1.3931327055458065};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
