#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.8043600853450551, 1.8054407749006278, -0.18712404509613864, -0.8829017276837298, 7.249678901520406, 5.5552683343755485, 0.45530161839928485, 6.252095442734298, 0.17522391144887298, 5.94498865506103, 0.369536685688665, -0.1485772109583847, -0.7141447959346487, 7.127901774667732, 0.010157409844574842, 0.9735792655155163},
    {-2.721062384673457, -2.1592016020479865, -2.477562949196943, -4.598765108908376, 5.08163248650012, 4.948784157623312, -3.1741945427142846, 2.669055121714641, -4.952301864275487, 5.102365814727527, -4.489166895356792, -3.402827080350024, -4.174977831299229, 5.116980767678232, -2.0951242617967964, -5.058356710156162},
    {-5.23468991872415, -4.795452695680614, -5.534978201728911, -7.072226990582309, 3.370149723051678, 3.731883115300426, -4.842725068960147, 3.202281771135305, -5.881105599622143, 4.438410664339169, -6.447955398947634, -5.561295274239709, -6.882604676908536, 5.168258348664931, -5.004935598735235, -6.35784428358467},
    {-5.084545138552845, -4.735567295460721, -5.289812625414206, -6.5572894162372215, 3.8375200252793817, 3.5088745986006407, -4.034749712175728, 3.6162551346922522, -6.102228793366245, 3.4249293944076764, -6.173111384412133, -4.832603498162343, -6.102354148348537, 5.090439093384212, -4.936397426170255, -5.538574270065539},
    {-5.589816932004214, -5.1587550006319525, -5.893018721336174, -6.781171109197628, 1.6127828330909122, 2.5718656278343275, -4.531479391646374, 2.8861722714246567, -6.7152021206631485, 2.031584987481153, -6.850308111034539, -5.463636765855277, -6.412481566144798, 3.6319885812372554, -5.5461456190556815, -6.224559366772781},
    {-5.312775582407447, -4.568171514791572, -5.99269500817969, -6.040989395076602, 0.62394220802828, 1.9105452573318904, -4.605378852758491, 2.9341706400076997, -6.514727813458424, 1.1030416152702327, -6.519250012655211, -5.332432219672408, -6.064596738402208, 2.7786003705760836, -4.989555829263566, -6.448658396927204},
    {-4.980382184205195, -4.099154308397823, -5.4932881308553405, -5.462056516512133, 1.0145641867754815, 2.0902552514658876, -3.9981142214670786, 2.8123513545089858, -6.477795032012899, 1.159639240990391, -6.2230962651257515, -4.955730802006372, -5.525457408415331, 2.2544543696901806, -4.764120998059811, -5.720575330363397},
    {-4.5425387859948465, -4.413371520624004, -5.104614192656637, -6.031628790507818, 1.4837625186437402, 1.633537127908927, -3.456920393345299, 3.7637701703045963, -6.039779534181225, 0.8687811866163131, -5.883559289818716, -4.210965186854931, -5.332987737827717, 2.1750812633329697, -4.2765656080358125, -5.359859598216319},
    {-3.9949550146361426, -4.4253268030822115, -4.506926763062713, -6.176675582173024, 1.7492501596886898, 1.6618031070534982, -3.022232044105778, 3.874489459031502, -6.1620362784888405, 1.620106384850349, -5.796557993890798, -3.6023641429548436, -6.0675801630506845, 2.473033317898096, -4.319312377532248, -5.295611074191672},
    {-3.998440890936173, -4.262326401876111, -4.172876406245674, -6.303184594745861, 2.908182161313139, 3.7488090743968243, -3.0907888426362877, 3.811410822649505, -6.837601968587113, 3.405763318409569, -6.292570986400709, -3.8673645040980498, -6.026992264683748, 4.224230764487642, -4.081662678610994, -5.749325215107607},
    {-3.282136241875454, -3.250331710728551, -3.420007964337645, -5.626186719129465, 4.003204407846472, 4.619369945551304, -2.8045537100987623, 3.5675421565589547, -6.513490976877581, 3.5207944019272146, -5.467683682687885, -3.146296666202768, -5.202983611519204, 4.083963056374429, -4.204825030451625, -5.328401793194472},
    {-3.8083400544648014, -4.541366487005637, -3.9428365264252307, -5.912386878938131, 2.7627654710351064, 3.3579626809905485, -3.1801885350158052, 3.6337604531364667, -6.28465774673524, 2.1526941375126345, -5.536457852894934, -2.818332041192909, -5.7138239088789335, 3.025633507827376, -4.8347559532831905, -5.222534830952776},
    {-4.5265229951546795, -5.229785225782081, -4.8448155213550335, -6.454063561621787, 2.510995835302261, 3.1224185876533666, -4.315966825668378, 3.13046394965266, -6.3679868872448795, 2.4424698198795634, -5.950585164303645, -4.001689734738351, -6.111248471610473, 3.143543476240035, -5.2582250823223395, -5.836239567102165},
    {-5.421689379165083, -5.521036503309657, -5.216567446075718, -6.629157702958103, 2.3219646505952003, 3.308076401123945, -4.245546946932328, 3.0269898445848242, -6.372848706722827, 2.301013626907289, -6.477137485412353, -4.065334100289559, -6.460219011864591, 2.839498846120444, -5.707112334193412, -6.298456555834438},
    {-5.147343988220499, -4.854810278469813, -5.149103451103804, -6.392543840121363, 3.2456835376706, 3.938369422090828, -4.273751673137308, 3.440120559645665, -6.402377809594888, 3.167886693296991, -5.995297832691444, -3.8762688262176694, -5.871869763578563, 3.8007771557506453, -5.507778272369457, -6.244328920620481},
    {-5.191036397291119, -5.270999592839001, -5.477525368937065, -6.847245102569374, 1.608444053871676, 2.9695822443599353, -4.3601278471058285, 3.4140989084446525, -6.767695975522879, 2.8750191983236424, -6.769481671818561, -4.502537692097519, -6.51028453854869, 3.508905309265696, -4.837658346672241, -6.348868914201674},
    {-5.191255615206794, -5.150020368056836, -4.955940751228665, -6.711472742228164, 1.7548268789648258, 3.1272125026795314, -4.051261214191996, 3.7582563191190106, -6.1745183920789035, 3.2707224141133886, -6.2245349642824275, -4.209527169087315, -6.321917402155702, 3.9239106853453665, -4.630722781800894, -6.1038049127512135},
    {-5.245771832429107, -4.679529463859012, -4.746220370502911, -6.711010486058853, 3.6920250164335355, 4.17702467210223, -3.7026974140470754, 4.481297170879352, -5.237790721192221, 4.104355571807216, -6.388917564493474, -3.7854174257523927, -6.1942599549879445, 5.260716289382349, -4.728583200224491, -5.73665515020459},
    {-5.386260332555638, -5.142561083245948, -5.178300927905917, -6.540625662274405, 3.057265442707004, 3.1730670892244235, -3.55198508911598, 4.558975090635051, -5.423205234062554, 2.4431286526391562, -6.107446419898484, -3.967411361700152, -6.08821003559151, 4.467785747693591, -5.452487777853213, -5.809521517548564},
    {-5.120131469908153, -5.134244353310455, -5.081344707251912, -5.987700746575651, 2.9253685471822615, 2.94824368287955, -3.381730433169825, 4.243041029977066, -6.160512728040637, 2.4395338438077094, -6.6142887096508725, -4.3985753423404805, -6.364343091969131, 3.7091285600798307, -5.284622434345604, -5.649179754313875},
    {-4.78733169309801, -5.304926912104596, -4.51207276146061, -6.50350364112359, 3.338212029295885, 3.983413003782823, -3.3609869322018224, 3.8842289124700007, -6.407345590711293, 3.2611944232245396, -6.202135455714102, -4.276550612181431, -5.9922869206844895, 4.443141577533617, -5.468684062549029, -5.718438369727168},
    {-4.602875285254285, -4.460498266370782, -4.22084198104258, -6.605946831137807, 5.198006811857101, 5.142383790575751, -3.293048635263853, 4.81257212802376, -5.830807366544561, 4.717295189244453, -5.823130627337934, -3.867183217896051, -6.156523388649636, 6.3608054629297825, -4.862988953663205, -5.342408896071754},
    {-4.66438272870496, -3.7208975284712604, -3.831632263286729, -6.284563272168796, 6.075684144252351, 5.683694615687182, -2.892485659938907, 5.054480921765082, -4.782372016026659, 5.565739811013443, -5.149409324298646, -3.6250686280454896, -5.3569158301673605, 6.579034287520223, -4.289712660989352, -5.260838568438039},
    {-4.323092100976559, -4.5125876365048105, -4.276775416616166, -6.419550412376468, 4.939771867310807, 4.96100075151721, -3.0420540532545024, 4.106289461605788, -5.502389257814764, 4.543221204473541, -5.881462373398356, -3.6457852773655635, -5.81565256330847, 5.6813352499260645, -4.5783084978848825, -5.223929174025539},
    {-4.132132264634315, -4.960684257980657, -4.410947423090628, -5.98478311769365, 3.475315055481464, 4.111442746563156, -3.201473213492235, 3.6474809861969457, -5.600266941675464, 3.9403739903073376, -5.94827619897846, -4.1919288083247235, -5.784741006825834, 4.766768335083349, -4.424473800199646, -4.67709598183838},
    {-3.805591190428306, -4.773250027675883, -3.736262896127486, -5.794258089205162, 3.5493874881218828, 4.47842271876184, -3.2264815127380175, 3.92772854750508, -5.408985071243793, 3.817346666797039, -6.014620247027587, -3.4108125773596667, -5.520788743669748, 5.204546728419202, -4.19191148139513, -5.051299262211913},
    {-4.010395143552204, -4.731792781638144, -4.283848492513704, -6.277444918928805, 4.575589242964103, 5.12475081266055, -4.087794155245467, 4.356221951541305, -5.5082403809748595, 4.865871575911531, -6.135424417278043, -4.365603011108656, -5.968122310800213, 6.1874081200354585, -4.17142229673011, -5.669494129944437},
    {-4.6228926865829205, -5.116968426576768, -4.9868254794936755, -6.257280051305844, 4.5097363293873665, 4.794116369782495, -4.135039003033418, 3.7611110903546443, -5.783034864748066, 4.6124785334795915, -6.1728764626478, -4.698361953337007, -6.057412663914101, 5.536746890143823, -4.966334119043954, -6.0107631321655335},
    {-4.342101759680758, -4.751777130423178, -4.437532490541286, -6.173638461015696, 3.5668968259555722, 4.914953302468985, -3.689857070830833, 3.448827407682087, -6.027664992108726, 4.162568027537909, -6.109111842110983, -4.583246397021988, -5.81574566887472, 5.022446087149605, -4.626027768664423, -5.909151007508109},
    {-3.870128293373625, -5.294390856116278, -3.94576954910469, -6.055358089294198, 2.703268529113987, 3.2377841463944113, -3.4574510869632284, 2.3541528295734255, -5.978149454011952, 3.669294285641524, -6.330316614853136, -4.296243889990082, -5.8093201201679046, 3.8883893087749044, -4.792677862354678, -5.661689087593245},
    {-0.6474421770553007, -2.3636344161824367, -0.41510291418089873, -0.7136816108877395, -1.1543640325128046, -1.1366211783464735, -1.6400235742111537, -1.167764850730857, -1.2690071819841957, -1.047787100123208, -3.0093590186709034, -1.8858036701050047, -2.87407345425451, -1.5896215526758743, -2.0935307002243886, -2.328415433151215},
    {-1.4111015390348094, -0.09398694256580603, -2.8521542654536645, -3.6775952442139657, 3.7912885739930204, 2.9054912846384027, -2.3683432274589533, 2.312950009783618, -2.8324578935210787, 3.250791356299684, -2.77226372831336, -2.4292530613395957, -2.8844408474396994, 3.1427401575641225, -2.526146698338381, -2.6876838999819532},
    {-3.134763802601091, -2.884214082327932, -3.228668433601726, -1.704257962452099, -3.3492929889313316, -3.1457297259373176, -2.8826686090728586, -1.355008568599453, -0.6979557952338838, -3.7752749773431513, -2.1827958825963187, -2.888818936282956, -1.6375355231923732, -2.8476216316072827, -3.129655286313398, -2.485649317548544},
    {-0.37245909097412194, -0.6502657082349037, 0.022980220057317025, -0.11224470101077089, -1.6298409700228862, -1.7145298467947687, -0.5969225174130346, -1.16135739451802, 0.3360013833516262, -2.181229259725958, 0.5301887560200931, -0.2121712565730526, 0.6344188916091121, -2.0281892631387053, -0.5709988403363563, -0.459909527117321},
    {-2.9540262780086826, -3.174274536201403, -3.0760670877125253, -3.7688892032049033, -0.6447447647869345, -0.5540226089789172, -3.3011811990530653, 0.13020266092274896, -3.6334353490000537, -0.7442526762530108, -3.239181332372111, -3.2931994262175697, -3.5918246557042406, -0.12784115146991262, -3.038690900670208, -3.7586886173097844},
    {-2.2742366140396673, -2.5959915856371434, -2.9778779805769244, -3.3363493671388915, -0.48854444461298024, -1.2774583934629185, -2.388965942454208, 0.7866410804135013, -2.9754825881193194, -0.998753511996858, -3.412879114111047, -2.7220563781604517, -2.694751452212283, -0.8147180494013426, -1.9513851431919946, -2.6190660134225476},
    {-2.688043672036218, -2.681578226933794, -3.050273807264084, -2.8557504936132725, 0.9637703326149091, 1.4322912919776045, -3.014444515722085, 0.45545244541826846, -2.9676426702796315, 1.0290824361532909, -3.1323464550047824, -3.190180901673005, -2.636888782441056, 1.0461729323510918, -2.5951944305026786, -3.0253970804145243},
    {-2.91886897827677, -3.018412787297788, -3.206699555080309, -3.4137143386421576, 0.1478049817046779, -0.39923534853847065, -3.4576058716338114, -0.09786876713395229, -2.2259318323754034, -0.19438346324525185, -2.803774398017604, -3.2202108130550955, -3.1723479045082024, 0.14125141600155972, -2.7889187011372663, -2.9298269296916732},
    {-2.751364852724159, -2.442496826036022, -2.832910747802229, -3.439238292922653, -0.5014164521176676, -0.5053358193846573, -2.9444637476820854, 0.062303023410259215, -3.126835363647515, -1.2076396401964404, -3.217451354767089, -2.722936337043759, -3.747898324458775, -0.629330249536239, -2.8871589671445332, -3.1933784131122542},
    {-3.416405259741126, -3.6340887879065877, -3.8155350218666966, -3.944281077924882, -1.3169433714836118, -1.6820206487648746, -3.459606326496008, -0.7932001870977724, -3.414372391759525, -1.7902563795857325, -4.018395585298608, -3.9259059580077675, -4.028142344070209, -1.1074713425960705, -3.2634306813523986, -3.8939040506144607},
    {-3.212941951742176, -3.446428769623107, -3.3820935159960785, -3.3995026100366856, -1.1045671329860023, -0.6050368034353857, -3.6215083226853153, -1.0854753712074556, -3.5767165966995393, -1.3083328206222784, -3.519451487761246, -3.7933137744555623, -3.6034178718386487, -0.703265872581215, -3.3637225916000917, -3.7142826195420824},
    {-2.772406698828507, -2.742651457261959, -2.705621105609028, -3.078507010292402, -1.0910542296806456, -1.2640484539385528, -2.857160298192119, -0.35818304387428573, -3.2329145017918144, -1.0943215160850874, -3.215591587078212, -2.739666173484595, -3.0807462168114372, -1.0804163569564114, -2.59125969018564, -3.161157016055645},
    {-3.9074125249795335, -3.9499067917016544, -4.260800710830978, -4.2943795262881315, -2.1129820222933637, -2.217593258198656, -4.557526904340045, -1.971569970952782, -4.039117469601029, -2.287341377804601, -4.328209673187218, -4.444284411917121, -4.745148823811189, -1.7711068089197424, -4.182245147819357, -4.441887216340516},
    {-3.543508436313304, -3.9300322319313867, -3.90405658963831, -3.717490597008277, -2.048647556463316, -2.2221757231317043, -4.069838634181572, -2.237259526264885, -3.7377711174552606, -2.502088167489998, -4.289597281033355, -4.347006342178499, -4.04121742892559, -1.9930200650941083, -3.3807230209589525, -3.8032180638477064},
    {-3.264310541795617, -3.1668013611993975, -3.7889219483550796, -3.5401951810280026, -2.0598929180682486, -2.3843551647067707, -3.401941029018491, -0.005370780654343878, -3.2406921115399787, -2.7755413157650035, -4.148920373847061, -3.471071786092474, -3.7861118687279283, -1.2602490447850103, -3.1980005909288707, -3.5239180016304164},
    {-2.9578929079400504, -3.4127247265297966, -3.6889144740827784, -3.584675363025521, -4.088996857465417, -4.601984187498876, -2.9480970292108264, -0.23222331585600609, -3.3704651035814157, -4.609757044325334, -4.158415775986611, -3.6894858164900124, -3.0579365246734693, -3.523418609627628, -2.760733921361092, -2.9409990673507926},
    {-3.5974142346529105, -3.857858969158246, -3.994250580635672, -3.9789772489718356, -2.779174413992069, -3.1487979197747507, -3.7347795750945165, -0.6770734152483374, -2.6843299155496374, -3.5699488551142298, -3.1766092694765486, -3.399308511441817, -3.2956677694991465, -2.5116883592801256, -2.8437294707437104, -3.46510985480074},
    {-3.505218622682942, -3.3635735976705012, -3.9760495216526954, -3.7379022823035206, -2.397146384414528, -3.209336903291921, -3.628400536406323, -0.4073524661411178, -1.9049995234862087, -2.922083100723027, -3.548124432906509, -3.4086231185002562, -3.250623216365255, -2.231267329798776, -3.248359494741465, -3.4487083501454654},
    {-3.7600358182120157, -3.8905269546214427, -4.2842811946388375, -3.0130544221437736, -4.0332122749837405, -3.8081786063855345, -4.388971518498525, -1.612844311906872, -1.9418464977513143, -4.145210134470981, -3.5249800818912527, -4.208768310115755, -3.0227038148157495, -2.9649815157065116, -3.1578322721519485, -3.002665779082035},
    {-3.5290077568621543, -3.6209842946655337, -4.103975259009422, -3.2126890514057664, -3.325665923837833, -3.4893164812403743, -4.17267801801331, -0.9272198314920033, -3.1959131290074074, -3.941069687836747, -4.226041132477107, -4.055438497343065, -3.4431402403129177, -2.8381592153949367, -3.1600230330552823, -3.665939269709601},
    {-4.025291037860914, -4.305374180561735, -4.221012431992253, -3.612102837309976, -3.5022692543417637, -2.9347947544917075, -4.667120403958461, -2.3773653307408273, -4.060674945926374, -3.62839655279854, -4.2844564513132015, -4.904746743427808, -3.4949026161365078, -2.7222838846461204, -3.5225988635364893, -4.130616176208337},
    {-4.141652223748921, -3.279709281343445, -4.329732396967453, -3.937763750785947, -0.49933824232646623, -0.5816398863952542, -4.5660989803469025, -0.0551779126747168, -3.6536314717264315, -1.405725226500314, -4.843753655872914, -5.263663654673831, -4.417513167270845, 0.70484443418391, -3.611612799045083, -4.1472466609984675},
    {-3.0689237515234624, -2.067099852655863, -3.838892445098273, -0.4169948498514358, -1.212489613806549, -1.517313466169117, -3.9229763492230108, 0.6143253981332504, 0.07600403944130467, -2.3863121002900973, -3.2031059097973795, -3.9682213602297765, -2.050587019563674, 0.11313073856450341, -2.0118178867971412, -1.5457172062866176},
    {-3.582729138205423, -3.7508434752872484, -4.669965172828237, -1.5227060877768948, -3.4069672165188805, -3.0806157541667956, -3.847727695494512, -1.460142259600404, -0.8757513535675455, -4.0226332060371055, -3.473979750781742, -4.366927330942128, -2.2414828703513017, -2.16234457664664, -2.7921133046032445, -2.964374686055977},
    {-3.969176500943084, -4.210259084987669, -4.890119735105957, -2.919194082604818, -3.155911649383977, -3.604151170817283, -4.2005201634944, -1.7613581619538417, -1.9560065002391758, -3.639501496113198, -4.134857657838319, -4.654013921355049, -3.4581418252547165, -2.6054336700228524, -3.1913252613276852, -3.8262828080263565},
    {-2.1493152657616883, -2.5277647517156976, -2.868871325542152, 0.18065242615084134, -3.0496831253792918, -2.405730693270057, -3.5313383143507564, -1.6908312326583745, 0.4842541039743511, -3.221885394250485, -2.061714629577094, -3.3617680137015276, -1.0450907628709376, -1.6573843004065956, -2.0750473736959596, -1.4170757534741092},
    {-2.6535942011004123, -3.2632642697160894, -4.2237615805101365, -1.5836496669464069, -1.0424643697038278, -1.1728139635761046, -4.318349439046785, -1.0854252074128505, -1.2858809866502279, -1.8783365746235037, -3.6862547284784903, -4.389341532508786, -2.6192828620994906, -0.42492222174563615, -2.429073789327369, -3.214079052138416},
    {-2.563590875660342, -4.224886967202716, -4.9885560264603725, -1.8577458335702346, -2.5970323742725836, -3.157764945891156, -4.677041537532677, -1.5408671813556014, -1.370739280117462, -3.413232913542627, -3.5627443995791874, -4.807195950709708, -2.558021640546205, -2.152811409311893, -2.394747193912213, -2.5780330606483743},
    {-2.9350227513667972, -3.891060852678826, -5.086980129600537, -1.278724824885987, -3.392245293750803, -3.5475125564477916, -4.573410444289774, -1.6733891717339375, -0.7478957755410999, -4.208064985482284, -3.6146417015179755, -4.773793639171698, -2.2570423903716708, -2.435631786729481, -2.5648059825886724, -2.9104044653041674},
    {-2.776613455405829, -4.255427657860164, -4.335077253653067, -1.4291869518916214, -3.4155454489228774, -4.410772700842356, -4.1645492563027515, -1.8430985132822304, -1.4581557212244844, -4.531641730437986, -3.956888833101451, -4.8878547873352804, -2.016282577163807, -2.449512657273346, -2.0149308208563994, -2.2026396775345596},
    {2.0111019943377135, 2.6893408668271808, 2.8451594638277786, 0.263881754901372, -4.029881019743041, -4.242655586559257, 3.2417955355375847, 3.19591738128213, -0.03515338040980043, -4.410465477012722, 0.3421694927362466, 2.995331155424989, 0.8520721956304106, -4.7022945388053445, 2.4942374180637192, 2.197123996544337},
    {2.044491341323883, 2.936883898606596, 2.722031989171346, 0.1553471858351998, -3.9935033964736633, -4.621995491629169, 2.6989398798784654, 3.045779509305983, -0.3615766626754053, -4.358382961524555, -0.07747147669031947, 3.1715350122744552, 0.5533933774062642, -4.868271995945649, 2.3580860160476678, 1.7136042604383797},
    {2.6727265762943424, 3.1327596115405476, 2.981015731011527, 0.6906000691089058, -5.619820123993815, -5.946690050584045, 3.2484984535254333, 3.5240474951599143, 0.3243345354429746, -5.536229697534565, 0.7248046700966888, 3.7115398126640895, 1.3933266828395774, -6.11687997096865, 3.0872341649437716, 3.074444029661239},
    {2.7619441875152337, 2.8621129084520107, 3.063523573222522, 1.013718949654601, -4.824555776814934, -5.541343856441883, 3.339924536934606, 3.5313803362359866, 0.8062884931071336, -5.156656347909164, 1.1538765939004783, 3.8180097289759107, 1.8328759491288065, -5.887303719091208, 3.0044218130999556, 2.926449193030812},
    {2.614313252319943, 2.9727784190360387, 3.070760347295437, 0.5187020996136802, -4.7014466345411225, -5.13218940036231, 3.5599172484687918, 2.934597526760082, 0.23888118433766464, -4.901704236927181, 1.41292577303889, 3.51984078344706, 1.641979769011822, -5.851385285154197, 2.661820444869682, 2.701843801280917},
    {2.8523540113769457, 2.5935510100259362, 3.1601832285524933, 0.7193580305025998, -5.2356395554729795, -6.204426702197433, 3.1609057927834074, 2.1431795259054036, 0.4251122668443238, -5.276843359729034, 1.8596824274292145, 3.3786620168771866, 2.0572140729899964, -6.032482282742953, 2.500704346687058, 2.7727673540163496},
    {2.824989113701552, 3.167984978559105, 3.3178652830082913, 1.2136212079379654, -5.739709671869453, -6.1330505941922, 3.779607963775248, 2.049141991936495, 0.4132713226040508, -5.6925960275745435, 1.4350417518192295, 3.7863839469571947, 1.8508400428590575, -6.4275775283376255, 2.6754550307394354, 2.838413204152819},
    {2.8384639550240456, 3.2551931921480546, 3.350337008332076, 0.4250877635631987, -5.621112813361025, -6.2223411794733625, 3.527686383307704, 2.4930903953542387, 0.1641639006122402, -5.667920720440932, 0.9753437311784984, 4.046283601836341, 1.4911107979117544, -6.57041640188146, 2.68583735731383, 2.3920554537360386},
    {3.26569731746679, 3.8071872325273888, 3.8488487110683254, 1.405983307574428, -5.590313712084594, -6.291402445333349, 4.289517753501786, 3.167203079556426, 0.9530702165374946, -5.693276452192115, 1.8500196692881679, 4.266792228352782, 2.189873593171311, -6.783676469464542, 3.778169254580937, 3.9535519520289695},
    {3.345462994949089, 3.802404885069957, 4.0085387779113155, 0.8235801966154328, -5.393638409751683, -5.711079272982205, 4.326406571276791, 3.9546897546493693, 0.7302548869576087, -5.117111998467071, 1.4027201355118157, 4.524337493633571, 1.9322168630428456, -6.39956221136198, 3.377438072294807, 3.543578951056342},
    {3.01301084999925, 3.7762207295293906, 3.6211391529501964, 0.6031440183999405, -4.781222430053042, -5.101432984918898, 4.201912905726297, 4.00340006410126, 0.408687938496651, -4.893163719476866, 1.2021928413466054, 4.3336870894245525, 1.8397146279416627, -5.78442990303203, 3.2386362877526027, 3.2800969772264534},
    {3.7310743233188814, 4.0309477325435745, 4.109789188719037, 1.253516883619487, -4.872366647433841, -5.401613566952932, 4.308845271409896, 4.296663293790314, 0.6242681868514564, -4.872739560528587, 1.8230506733684717, 4.64533812314201, 2.403810229871529, -5.923229060998896, 3.8959032536566602, 3.937859528103415},
    {3.22973640959967, 3.347386102040126, 3.6260566303569077, 0.9289209366355089, -5.516836875301082, -6.0009461418589565, 4.282867949294237, 3.630410619002306, 0.19016669474732475, -5.552606415547783, 1.5002709396584974, 4.2107618794004065, 2.192346585846971, -6.457022064512765, 3.3793910896619384, 3.6521584386608352},
    {2.7274287905253165, 3.138061494030646, 3.089835283225971, 0.6809024312923372, -5.613624206140982, -6.585307135873658, 3.5698754286011547, 3.388856067736086, 0.4847591637182828, -5.679657457804519, 0.9293374430880125, 3.7308317474041632, 1.5101295926643448, -6.4866779979923255, 3.026045757684453, 2.890431866601926},
    {3.1252494907605666, 3.1832396726352856, 3.4384670745386163, 0.31136467114914257, -5.71945811493875, -6.290023060043021, 3.573201944113259, 3.5482653272265554, 0.22996866423685752, -5.830897103550624, 0.9236021428150303, 3.7616649153927875, 1.7387206375266553, -6.501210433217111, 3.1578732054464105, 3.382504885084151},
    {2.9871220711777693, 3.5416983481832824, 3.385394691633051, -0.2268072454957547, -5.7136212477547845, -6.097699915698727, 3.8350417038637077, 4.193396204246821, -0.5426421866761663, -5.694707737226368, 0.3959751254316634, 3.906419459665366, 0.9751738145402007, -6.484499960837258, 3.102050935736366, 3.011952781562838},
    {3.738629615199986, 4.077798341021818, 4.075139172085849, 0.7874250002276766, -5.62195623690513, -6.313219756345501, 4.377135071868846, 4.402004277117051, 0.35269163850345214, -5.645103295541016, 1.5951783727861877, 4.929971173997898, 2.0621355335172002, -6.0120203734468625, 3.851116576314729, 3.698410216580895},
    {3.419406316822726, 4.067549543441363, 4.0989293916229075, 1.0759254235417086, -5.664146340875573, -6.278188874491329, 4.435706597477055, 4.045492173031902, 0.8588528850910833, -5.983711393465736, 1.4439235678438556, 4.707858728145473, 2.275923136715841, -6.391015503630756, 4.03955824748638, 3.7878379486326},
    {3.3016708015479055, 3.9323290825464188, 4.002673802159956, 0.8904778989258784, -5.728488308708593, -6.124821920327246, 4.01947945435239, 4.226091417014394, 0.5041227463438096, -5.698166393039388, 0.8931267344761873, 4.592388931883818, 1.574736921221918, -6.534552408776321, 3.176450190498853, 3.2587623600477076},
    {3.7099269274830684, 4.345762091992258, 4.1188259308630695, 1.512146831227352, -5.463262752970364, -6.013142609138646, 4.640170697963689, 4.747866226502247, 0.8792600672278664, -5.753929918519548, 1.6368034050883116, 5.106424799250954, 2.5100122307063715, -6.105367389852829, 4.1437074950980435, 4.096405571581358},
    {3.6751119650737802, 4.171549244916201, 4.006156464042288, 1.2472408954472545, -5.78903532205142, -6.554002021214199, 4.367750603586872, 4.5962314659410435, 0.5939786347665863, -5.712131338754384, 1.2651775617336747, 4.676486932076962, 2.377564246353514, -6.4758128597987055, 4.205865209847583, 4.034247557818287},
    {3.3992798563888718, 4.1329222226853615, 3.9202118474854877, 0.5029087999707399, -5.47822075920461, -6.133891249458258, 4.436058924569717, 4.583489994956481, 0.5023899572284051, -5.756821386875454, 1.1337421766330542, 4.50514760060007, 1.7570609680466565, -6.427675542799775, 3.903511873226698, 3.7940091407321406},
    {3.2643564556925355, 3.7546536391114373, 3.6508481020266443, 0.47724109726179026, -5.756086530677489, -6.29164452923693, 4.3191390294367595, 4.242574229958485, -0.14586690173883976, -6.085144107878583, 0.8259039930187899, 4.246991312796593, 1.4161336927895583, -6.2221003316258106, 3.563608326471762, 3.720507947841219},
    {3.45979379868971, 4.3059773532387995, 4.169702407908794, 0.28870825862934935, -5.897325886073053, -6.230066347765764, 4.428509119431387, 4.587258885268792, -0.5329868255136488, -6.008643288028109, 0.4402781275969193, 4.591279465904989, 1.306379381648955, -6.313661065306018, 4.082169647923892, 3.6229696791479875},
    {3.6046105730825775, 4.417419126211347, 4.256123591941898, 0.3871859981596097, -5.58566856031514, -6.071538976403265, 4.557496163602581, 4.911341488688145, 0.0236753915695579, -5.9424822995289945, 0.514346816341951, 4.687006097686147, 1.5220962363715416, -6.340438318534664, 3.9805802242306885, 3.7192356115622616},
    {3.321637143142874, 4.475385929716444, 3.8708861942174195, 0.28783577781199715, -6.08166856988547, -6.365445492515071, 4.613365011426582, 4.207089698531539, -0.3946164059009872, -6.2538491919678645, 0.3289848581734038, 4.565172324106874, 1.3207232600841199, -6.7442316837370635, 4.028867829842196, 3.775648078135557},
    {3.472703391636264, 4.145515457077919, 4.13044099089011, 0.46665675620867114, -6.004954350037521, -6.709477321693406, 4.598365933143176, 4.5790874570893045, -0.08134061158263413, -6.497550684628432, 0.5517866078890952, 4.834204388599885, 1.5669702884391885, -6.9616666324599885, 3.877288373705347, 3.8778306690463133},
    {4.116752616217193, 4.821589389981682, 4.77552681999908, 1.3483035035864597, -6.0668586456477325, -6.443689479066071, 5.148324661864774, 5.059825337127837, 0.7984783644149551, -6.1642203695569435, 1.0417300432771073, 5.356661431971729, 2.3288474624363773, -6.867967214787921, 4.57335934272, 4.469520489320736},
    {4.13413466095074, 4.459103135229999, 4.017794097126627, 0.8136681326403984, -5.80251254642064, -6.284172466503507, 4.88344116118335, 5.112278802837191, 0.19624007260696177, -6.36362002276246, 0.5833145942475815, 5.064475360833034, 1.5383522030145007, -6.40313586323842, 4.22348498192093, 4.160141111525933},
    {4.100959585222094, 4.790154058516995, 4.628959603752189, 0.6105683201709853, -5.975048772975743, -6.350190026596679, 5.13021859759125, 5.362373051948412, 0.03648647020282049, -6.4027560847354765, 1.0245464438845506, 5.390941964051006, 1.6758154209107763, -6.416688524560684, 4.72533831224038, 4.674718739137045},
    {0.26316044997113663, -1.1589725233123767, 1.046268917612177, 1.2886892218439283, -1.6436559680114946, -1.9043531012467219, -0.1502669095958021, -0.48659422821358495, 1.6438696646294886, -2.763388775253182, 0.5826144777763242, -0.1975141748275197, -0.25895539850075255, -1.550680629896482, 0.07823481945970412, 0.578062891871184},
    {-0.6260430381028971, 0.9776402271450492, -0.4932548641719329, 0.46921764409606903, 1.3386851193619345, 2.4563084890965055, -0.8047168575583253, 1.924435543160551, 1.1062855133314706, 1.2107422317772651, 0.767400110528031, -0.3413108172050086, 1.2688862732132524, 2.0158704761235624, -0.12478345565604403, -0.5959697139563016},
    {-0.7015273182351359, -1.307735990877018, -1.1263725211411757, 0.7413647016816548, -0.856577421122953, -0.9624738755975852, -1.0697361256575912, 0.16050613600291871, 0.6395779644298875, -1.0680202204685398, -1.0502686304930793, -1.089500223900855, 0.09701104699201622, -0.7730531657933182, -0.8953706061394767, -0.3042286598895276},
    {-0.10327431731338621, -0.15939687867490873, -0.46342225345692434, 1.4340604006424411, -1.3288259425502214, -1.9982322501144238, -0.13536353004051777, -0.3665077545807117, 1.3689872386500765, -1.8449483746150444, 0.7150649730823884, 0.1895077314415801, 0.9030959081556148, -1.9126558315187732, 0.1404524137032297, 0.9059743066702017},
    {-1.8668964349408317, -2.1387954108304164, -2.4445152849839507, -2.3758448171139035, -2.008390970533325, -2.168051145578617, -2.2798488772946612, 0.09503662056826936, -2.112873723308681, -2.1205109976218224, -2.7866861137861743, -2.298032011995131, -2.3757361532265193, -1.6090063736254323, -1.4086452080440357, -2.0823949559051353},
    {-2.0523883656712605, -2.266399429646819, -2.1581754799491937, -2.6777471506414945, 0.08589546434143006, -0.1520175080755736, -2.219684235851383, 0.6594126250673872, -2.2601049021063697, -0.09917600221725761, -2.6247304782648464, -2.1199802289204213, -2.0973847026039243, 0.12659651113097026, -1.4461946744438032, -1.955606873329144},
    {-1.2263373917873437, -1.7293173667484583, -1.698869535293033, -1.5669328959384403, 0.6641597300378669, 1.0393619545011228, -2.1588589018659103, 0.1820032657458728, -1.8138705007065004, 0.3015260926866687, -1.9028941649031408, -1.9051856491106647, -1.6012335965297582, 0.6456790357522791, -1.1997365464748035, -1.5185657114625781},
    {-2.0111259757188846, -2.5555762617362605, -2.346274681035967, -1.7474029707168572, -0.08989844938722194, 0.0023173088444951757, -2.2650360053980485, -0.5893258707334803, -1.3105388153963777, -0.14683306800294363, -1.689358380113768, -1.8837810621020898, -1.5955151902921947, -0.16116064817394732, -1.6495310556529208, -1.9242587875448303},
    {-1.7936755132581097, -1.807342666379, -2.1096372276392317, -2.3025509415186285, -0.5647691363439912, -0.6404672836725988, -2.206434142130114, -0.20759475197543795, -1.808143577108794, -0.6216104899702446, -2.206384473060068, -1.892801799443492, -2.304576213300322, -0.6893276618786337, -2.2249063876670236, -2.7441789774207934},
    {-1.4923700464307603, -1.4851879022082994, -1.7396287497915244, -1.7675458422128236, -0.37115926949185657, -0.5147386355713512, -1.5366021364691897, 0.21180020281514017, -1.4515704664507794, -0.4017964565529609, -2.548545920166331, -1.6420005775612494, -1.9996791740764361, -0.33681389630785064, -1.4760633494541955, -2.113426840919183},
    {-1.7231325328803886, -2.1014337462300756, -2.169443249401022, -1.5558642296823963, -0.7638312990119189, -0.7155017338152163, -2.7961194801079836, -0.7214379030620979, -1.6541905035774211, -1.0923264663920704, -2.173881853119288, -2.4457505422422057, -1.8425680193206326, -0.27476496022569147, -2.3812945961403162, -2.5150283149134958},
    {-2.0561648100043923, -2.3107409041911393, -2.3496964455284344, -1.7962285814172325, -1.2059826430512905, -1.4853453303399535, -2.5122585827155395, -0.64424721005176, -2.0434489527544955, -1.5613289777354866, -1.8399341715433526, -2.1775100740418156, -1.9333274523344957, -1.159322817093571, -2.1769040881906925, -2.516301998436617},
    {-2.813313730026255, -3.0574689041351144, -2.889260107608736, -1.9005434734295996, -1.2360347118125914, -1.3779570626206032, -3.329405102862763, -1.433751761220218, -1.7616049055913199, -1.2299674642315512, -2.5622381221196964, -3.09036285523942, -2.877514906656091, -1.3879183702537279, -2.258497388038571, -3.012907563875691},
    {-2.4656728294832306, -2.719967932506414, -2.9041654705939957, -1.7948558199664326, -1.4368771613326927, -1.5701131500297245, -3.0958084856973, -2.4465466638701496, -2.184286641114333, -1.9409277852745515, -2.568492404398803, -3.117830733449229, -2.084326927410204, -1.5465635050253241, -2.0006341335548985, -2.2510433785837156},
    {-2.5937156333838063, -2.2761803582235993, -3.089041757931506, -1.953998434025843, -1.606227940017135, -1.58804253363891, -2.6297244018335424, -0.05541630500637789, -1.5118235282944041, -2.336568341995927, -3.094619155933325, -2.7441471165773, -2.1500840149937868, -0.8459774297403684, -2.1978666749764804, -2.559647660190823},
    {-1.8803795804902892, -2.249372941933813, -2.410178755943864, -1.4593316129720508, -2.220487034071266, -2.3166599309329614, -1.8428061446744421, 0.7870579725316422, -1.383665797984743, -2.4340461053658817, -1.8657642522698548, -2.2112666852753415, -1.2391258075563032, -2.0901154087601057, -1.3919664672545866, -1.3410715797808477},
    {-1.98554061999565, -2.102856704447111, -2.366613023226798, -1.1101713777829398, -2.2811183033688556, -2.5924904477939847, -2.321008413769621, -0.5263982662430032, -1.0687317358390434, -3.1129545921119823, -1.6077266831876338, -2.519344241494599, -1.114703262010432, -1.5083011681795035, -1.1056412581340962, -1.7252579168241189},
    {-2.227524606227065, -2.318980057049238, -2.7060014926714895, -0.26025600800835025, -3.3496228914323742, -3.3193674856030957, -2.6637575656074195, -0.22250890766058243, 0.29495469049953477, -3.747865377754101, -1.8765087076089886, -2.813936710635724, -0.8530839578240085, -3.2255023180003857, -1.2132503174231195, -1.1934456623564442},
    {-1.2403076246398825, -1.1283345902847033, -1.7122961689208087, 0.7451732546472152, -3.367908668981665, -3.4191741844068475, -2.095613591627067, -0.22833101416261026, 0.9037669450524204, -3.5822874517673355, -1.3966946157317228, -2.2118033271034436, -0.033533781906152076, -2.982426165071453, -0.708176776515199, -0.7054376804566257},
    {-2.0162346666522875, -2.2497472019381806, -2.705310048305611, -0.8301443046465188, -3.462950447061549, -3.8995151924101115, -2.44952640091257, -1.0825921012737192, -0.8889918277562234, -3.782858509642677, -2.260169235982193, -2.596628344218535, -1.4347621526378145, -3.519203413427804, -1.3663722710239832, -1.7220228917130613},
    {-2.3196967769110404, -2.4932966356229755, -2.5014887107197925, -0.3278865220772468, -3.027231452961518, -2.958640930848264, -3.115706687609684, -1.739297365466617, -0.39871554454231956, -3.609111783358723, -1.4892182578045798, -3.0358692512194443, -0.741385594265535, -2.2779287508213377, -1.2133861223146487, -1.5880198417729605},
    {-2.659628444672064, -2.4769813602287973, -3.1473959429996934, 0.8892650825296535, -3.8316277367578944, -4.300459917087819, -2.766348475880327, -0.5665326005790092, 1.0564765378679641, -4.897000869184468, -1.9697543276239968, -3.7989637633537363, -0.39712630396306153, -2.447201476970914, -0.927044177017354, -0.9024806958081028},
    {-1.103415834704552, -0.805242519957203, -1.0689325954910585, 3.1251980188599795, -3.4447286915142636, -3.8365682861502397, -1.3472067234515843, 0.6432471524345603, 2.997232070099514, -4.444028132836902, 0.2897839206639497, -1.8142097676728195, 1.5332521528760976, -2.4761604721324124, 0.4868052606162907, 1.3015060136539158},
    {-1.551698317017436, -1.9910995797694622, -2.3990676612077704, 2.0740383098813484, -4.028415851631486, -4.036048510503326, -2.3568012941891254, -0.5835407487828965, 2.1464619060957144, -4.831849909005205, -0.5855926764981273, -2.607758023153074, 1.0628183736298993, -3.186689819708516, -0.17655148456984168, 0.4755549010382897},
    {-2.5428322751579433, -3.037105339115344, -3.1657787450649333, -0.47414635474869793, -4.631069112304319, -5.010373655071509, -2.8702949752095894, -1.0606772568013823, -0.2163253759240836, -5.233292293968617, -3.037856551069271, -3.366167796615719, -1.5495001116490807, -3.9465534928202493, -1.8473806651116258, -1.9276622670678536},
    {-0.7023457713763199, -1.0095805089107535, -1.2859059593915318, 2.537291465036195, -3.623836443340523, -3.55449039042234, -1.7389512654346544, -0.5737726971304538, 2.3089526561615767, -4.2315296611229565, -0.3081828834814821, -1.4928216812451738, 0.9722228481531803, -2.756994293709706, -0.24990009756668344, 0.823275502463198},
    {-1.8052361275701079, -2.3920917765173377, -2.8985435498754364, 1.9925455779927952, -3.177833963979384, -3.2216432209102197, -2.9095588490003417, -1.7718010861074347, 1.3632661438782403, -4.1375974212346645, -1.0941826813233544, -3.125987094232841, 0.25091967463081294, -2.5058696035482466, -0.6204341146979616, -0.5079853966083047},
    {-2.0717968923175514, -2.9203209024724384, -3.2674796564440722, 1.3486264161019663, -4.2994114980112474, -4.436755537006322, -3.349942139739672, -1.5475473969513283, 1.1620856100039545, -5.079026480285096, -2.0589628164104847, -3.4767125576090776, -0.2389396443096036, -3.6747166671659452, -0.8921557218938081, -0.5076836433436513},
    {-2.3665904645285627, -2.619212104550158, -3.4262342182236303, 1.3859674932920572, -4.470559417124006, -4.688339887564783, -3.3784420062486324, -1.1074681307873557, 1.51969950931231, -5.350551495278223, -1.7970197296392718, -3.401368307252623, 0.13622043166452735, -3.595828431905201, -0.8387431537135084, -0.8676603162821078},
    {-2.932807664649811, -3.4742934969925425, -2.70719175994276, 2.238588203319838, -4.183687926313374, -4.558657928834796, -3.2019434242560503, -2.4132244553439706, 1.602674763557136, -5.4958662333339765, -1.2185779846095945, -3.9016226946891024, 1.0099765404379573, -3.621447883421206, -0.29758736858124335, -0.6981689927959717}
};

static const float b1[16] = {6.361025031425175, 7.140219508278223, 6.976569670016368, 7.215943836347484, 8.203555740761196, 8.456771909645127, 7.062430502785709, 8.194786450586554, 7.51720687099752, 8.293140919734324, 7.070021751665842, 7.044048388432902, 7.036993591997817, 8.59753566902011, 6.958255663356295, 6.871657068937417};

static const float w2[16][12] = {
    {-2.9335671364064866, -3.3029841075019877, -3.6735506383042345, -2.599539022138957, -2.005869393009398, -3.917304487910606, -3.26782054585601, -3.0983885323083165, -4.033282985005612, -3.0169151339199254, -2.9504244383963742, -3.173236642206838},
    {-3.1237425790455426, -2.7712172832153597, -3.150307547260476, -3.2669309452247575, -3.4119991124568156, -3.597374562620526, -2.7767460065407876, -3.3687279477432748, -2.9137929776453197, -3.086815798544135, -3.9137420197940895, -1.537298702456},
    {-3.6304582345389655, -3.0974380107212265, -2.815412947629466, -3.2960982388481628, -3.314269010079583, -2.5364533784895897, -3.214785064806168, -3.443865895577892, -3.2865635042896724, -2.5533874141882342, -2.261388099097603, -3.5763029870933045},
    {-3.223561486185114, -3.1073682988833755, -4.211894149023175, -3.0530443246712666, -3.482761880964177, -3.3036278454203463, -3.4733700669338936, -3.3072964373434153, -3.3334402227373277, -3.2179905565154963, -2.7190392856096968, -3.066494253600885},
    {-4.000014291217282, -4.448136402155554, -5.064128297763511, -5.397510632262112, -4.860781495659747, -4.053863728408066, -4.336601581073453, -5.997482125127029, -5.513313329631503, -4.611858333885949, -5.526852040726779, -4.522727151395741},
    {-4.716775958826976, -4.925939271017217, -4.783238983987489, -3.9329649973801124, -4.610113638951647, -4.781400015468958, -5.742550908993875, -4.546559363394325, -5.129967421890762, -5.091154390278934, -4.272461731317771, -5.485033752685335},
    {-3.008814296984715, -3.6928520094697754, -3.3376275505827824, -3.1740009643579294, -3.521548027937707, -3.1417204923290423, -3.113261557713697, -3.0945756462660277, -2.142261832262986, -3.1672923102124537, -3.2845703095839283, -3.6133607088077357},
    {-3.89072592734081, -3.8231956064512995, -3.87361626704195, -3.881284023401947, -3.875744425984701, -3.8532684055154447, -3.8506167876274766, -3.8685555394598667, -3.909234316792277, -3.870956654537017, -3.8822970212775103, -3.8337856107766153},
    {-3.681179953370247, -3.731521570996762, -2.9183824668796112, -3.9262515150378063, -3.3141301478128837, -3.953096854244746, -3.572066989302027, -3.836026908105027, -3.376341558632907, -3.6258991859936924, -3.868312101070577, -3.9988059123577586},
    {-5.3043477958982015, -5.367314884482836, -4.534421272320937, -4.639389207282565, -4.500863798389538, -5.602699311426925, -4.51913157212802, -4.364010745799072, -4.881172412305649, -4.51424580001695, -5.14853463113035, -4.885434861571432},
    {-2.935615486051463, -3.3952456939896285, -3.011727681843937, -3.3579923522403132, -3.1697076977017646, -3.1020833858396117, -3.454316530551657, -3.1553665066531926, -3.4547495874010146, -3.2442683615071912, -3.6860709132391305, -2.821252939624886},
    {-2.8677596879302696, -2.913349422792608, -2.818076451123038, -3.1031041543897366, -3.086618056097278, -3.3369692634791313, -2.9691398445532804, -2.6605799115965887, -3.7039654009177294, -3.3280329069554977, -3.0707125621003324, -3.2687320117113785},
    {-3.3656375170922095, -2.93469121326301, -3.208874352382805, -2.652262488138259, -3.606034621344415, -2.6316475682911546, -3.4382885541117023, -2.9506965364418036, -3.510252313520774, -3.509076546778402, -3.0737053401993992, -3.900653276466967},
    {-5.425637512970069, -4.699186126778438, -5.049263543710357, -5.5267925404154905, -5.465890443386027, -4.9486724322280224, -4.764383658084116, -4.60152637307533, -4.034179841943029, -5.160618011622229, -4.569141777788697, -4.504739012865338},
    {-3.838120140808112, -3.5084213920749203, -3.016106959218231, -2.9886755902176634, -3.1049590607779516, -2.5274522745591486, -3.538567690703593, -3.345355654682044, -3.427927438718702, -3.4458922433763375, -3.4433200047316244, -3.509388591936596},
    {-2.762258265950854, -2.9578477940901373, -3.240121692676735, -3.8351523625063257, -3.2267685272161652, -3.3433542412217316, -2.978737863687921, -3.2904614112052077, -2.4124420277330825, -3.213809798042324, -3.131025267733683, -3.1579181269152987}
};

static const float b2[12] = {-3.86482858701637, -4.6131463086695215, -3.6310093729963437, -2.992225597323293, -3.5088952491307914, -3.5112871594170962, -3.8894252137993575, -3.9740140271622204, -3.023320245062189, -4.081358569780494, -3.634279835099617, -4.138663743747938};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
