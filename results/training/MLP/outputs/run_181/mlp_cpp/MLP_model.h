#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {6.962022713366982, -1.2406948327800256, -1.161638446933971, -0.8743140076581783, -1.7612638985782039, -1.628873624195287, -0.768530339785004, -1.80646276251015, -0.45066572116108206, 8.580248108455285, 0.21865657234814168, -2.246251037536262, -0.09405264092690702, -0.9776239397164511, -0.3220117229286748, -1.3824309909911237},
    {2.58108003620948, -5.861145262951969, -5.816226227510694, -5.814307402628003, -5.706678116658329, -5.905068666358813, -6.274715175172977, -5.481488818331849, -5.475693130041701, 3.1559922076415123, -5.5284115121188675, -6.4448974166426485, -6.237000048683418, -6.034483051979818, -6.129765266015625, -5.770810265294316},
    {6.420491551758149, -7.812298582568013, -7.31457578217648, -7.806961842137344, -8.080005189607459, -8.17445126403796, -8.14041113793041, -8.074624861233403, -7.856309626305629, 6.954304083322572, -7.990255127847391, -8.232726825898471, -7.986207407521957, -8.021334392915705, -8.314669077543545, -8.175991220011056},
    {7.451645490280089, -6.908410965383159, -7.284696513121595, -6.783877097975882, -7.865316011363387, -7.74522936008439, -8.092112256621402, -7.735029115467941, -7.72559514631288, 8.152719770418466, -7.665363769577703, -8.436538972886456, -7.69720472738662, -7.868763137903843, -7.887213337909157, -7.674506373532834},
    {7.526126489685477, -7.520108883094441, -8.117323166073641, -7.71009383672407, -8.40249402899486, -8.356004058514161, -8.676579288240204, -8.384535328642196, -8.29795257469369, 7.426622904719309, -8.289152005969878, -8.842419672117249, -7.78447076789941, -8.487682927868006, -8.685371649498894, -7.9117472664411395},
    {6.9514453996759675, -7.65199831971808, -7.648913416519906, -8.03025355624895, -8.471949657610674, -8.509453775125998, -8.748416215526033, -8.073777145342099, -8.364375457655594, 6.4694688504014914, -8.766131618209165, -8.784558861838265, -7.8334315702168436, -8.356953443643842, -8.759790244297687, -8.11277218302212},
    {5.984063317024826, -7.478895714487691, -7.704886773471032, -7.710402892987087, -8.453304076853227, -8.207094469177342, -8.549927286386689, -7.736199421940794, -8.18378349489483, 5.6944513943507555, -8.339325071449466, -8.101682217930069, -7.917961076835483, -8.297785766631089, -8.324002589778905, -7.54073369962802},
    {6.163602077998, -6.545308516142044, -7.423985700772684, -6.922586556669014, -8.025339514527912, -7.332513127677166, -7.997005247642237, -7.3040579673294825, -7.791649336100547, 6.307213852932093, -7.634065866586713, -8.005593174449336, -7.510497720613874, -7.695725907475889, -8.140242816092407, -7.408420383411253},
    {6.590041270570766, -7.024032040545214, -7.541215889879913, -6.889718310734241, -7.8187596583742325, -7.868374996911593, -8.064309874564534, -8.010392469826327, -7.814472887644131, 7.003682192389893, -7.871797188832495, -8.423052991136366, -7.563863122226302, -7.588752601007501, -8.202750464826135, -7.344399884284168},
    {6.229464954094267, -7.6129308489473635, -7.709883105601184, -7.525469063898783, -8.11642569145708, -8.137130843173765, -8.30157245652064, -8.097190152061367, -8.021833959505196, 6.506040415716822, -8.094625444526429, -8.361169230608985, -8.09357598367106, -8.08957501907084, -8.333375280394657, -7.787525400913844},
    {4.78523481343684, -7.096044027194734, -7.203497164013241, -7.305448850859587, -7.856470017291804, -7.929881419549762, -8.073979335108902, -7.509096153646776, -8.032898875832924, 4.579139958268601, -7.605385119630993, -7.90775692477893, -7.651150718130565, -7.718229746434024, -7.772462346637211, -7.28475388243747},
    {5.004433113041213, -7.5309521202453285, -7.884618615146023, -7.2999919222965035, -7.981944741483145, -8.11426318165358, -8.097162253487722, -7.8120960625669955, -8.155540263489195, 4.741671316909258, -8.017209196793493, -8.197539956633044, -7.92391595627124, -7.980893912470151, -8.321764399294883, -7.2468194042170015},
    {5.176210349950227, -7.668024004182847, -8.1975753793235, -7.683882602793512, -8.462877224194207, -8.274981389030792, -8.391652504938518, -8.532128784077464, -8.015387930398495, 4.794680949903638, -8.345467906373791, -8.176679016521682, -8.59716464864938, -8.314955292226495, -8.404392333025159, -7.929643272897766},
    {4.682448961333357, -8.113603811277416, -8.413418685007839, -7.5209194277101075, -8.547050198956198, -8.489670605723639, -8.542602291264025, -8.087345958946083, -8.084008205581389, 4.0749743422638725, -8.424096985594632, -8.473262100169018, -8.679339005725538, -8.061006915067395, -8.530941724157334, -8.239620331518045},
    {4.573026962691482, -7.674116812813607, -8.202468297632556, -7.485531434222615, -8.399100819343262, -8.329636492174785, -8.36441657464775, -7.908712611802352, -8.110604931273077, 5.068439621412119, -8.44666180870178, -8.175677033209109, -8.013775500443844, -7.917528271845679, -8.349104249476348, -7.7720349019555135},
    {6.099022086738832, -7.826379920187354, -8.115057365848587, -7.8213012130091855, -8.612270389049526, -8.353496551936212, -8.55729466929146, -8.27563942920532, -8.368166560645317, 6.3787324030034, -8.271756391425539, -8.50431373014835, -8.669624383476133, -8.477954764905983, -8.692463802201791, -8.240839863214129},
    {7.370691080393774, -7.845399672479636, -8.29715621891881, -7.8397746160414785, -8.45330113593347, -8.454800367937553, -8.385131955527738, -8.319902205344876, -8.293453522049326, 7.635116310867365, -8.392064215763398, -8.435492407968836, -8.551620052857432, -8.454390462340854, -8.580877288092337, -8.155034993478589},
    {7.130584999249744, -7.746876186089902, -8.282969423669288, -7.639931713960002, -8.4524128911549, -8.14841940092387, -8.29771714771185, -8.190108868041836, -8.094102932263928, 7.900151722485913, -8.387641789777662, -8.205439066163919, -8.544463255390406, -8.334700281526802, -8.231647820284714, -8.261646569270987},
    {7.207533256626488, -8.077127470878125, -8.001124405934776, -7.772033112094664, -8.806380430093103, -8.397042406626385, -8.629316972349894, -8.298059554147203, -8.176387968656977, 7.628495650614682, -8.451208748879434, -8.426067893447245, -8.532742833746033, -8.187421017313126, -8.593042746497149, -7.833873688031692},
    {6.887659113816457, -8.03247265542687, -8.065653348804062, -7.483143533593129, -8.142496073545296, -8.19673546828765, -8.63752600323806, -8.359804714686698, -8.170761113014672, 7.3684218290611065, -8.370094621891965, -8.577699343638324, -8.170486533718213, -8.37638011239222, -8.482861963758136, -7.814984915305609},
    {7.028445693228898, -7.635384103309302, -7.887506086141837, -7.083009395247541, -8.044347404521917, -8.137651413319887, -8.453459310675694, -8.099798742792528, -8.065756278643791, 7.169910819550633, -7.85666049672182, -8.650398743728548, -8.389293651755297, -8.098026813493322, -8.10306965147717, -7.553024194337601},
    {7.9299862868217454, -7.233609978910083, -7.2240248319422005, -7.045101596934912, -7.5794915887870165, -7.778684362233997, -7.727736591551881, -7.744984902961995, -7.396424431425458, 8.353923711077284, -7.4941107124649795, -8.08508452099224, -7.731701479100673, -7.42112212082261, -7.541540192287994, -7.375154260231625},
    {7.583863472560044, -7.014641110402434, -6.882915332119647, -6.638420722435039, -7.501759696026096, -7.319118404992212, -7.111523589626106, -7.093667292518864, -6.61835354987533, 8.651386312663309, -7.302325366399949, -7.452763343080843, -7.671560033082647, -7.29035321120701, -7.247563450188491, -7.27929668182727},
    {7.023753733458012, -7.242449995098408, -7.327637106355203, -7.180022905876914, -7.687063171439187, -7.719631076288391, -7.984355405842936, -7.633333071821225, -7.687655495951809, 7.796621704939398, -7.679405540604037, -7.9951771401387095, -7.744084828382873, -7.615345849444371, -7.642084796131925, -7.693802483366274},
    {6.446804291415134, -7.461021443085844, -7.712249548892444, -7.2467651340093635, -8.047170973858965, -7.996148132190045, -8.527190034004871, -8.08517082707602, -7.876059001962236, 6.916261901675886, -7.751364037518017, -8.424721134651875, -8.149955147642153, -8.189373944203659, -8.104345741953455, -7.7623088486730465},
    {7.107674066205438, -7.466143590367186, -7.783357556905726, -7.167158867586978, -7.89210603773714, -8.069221052846405, -8.131231018692315, -8.038827892272165, -7.874737823465035, 7.214263635893311, -7.832862726331547, -8.204331339988158, -8.225419113281388, -7.86837810841384, -8.106477772454602, -7.908119377221109},
    {7.195522630282035, -7.560100667594364, -7.754421685598735, -7.449758071107261, -8.229149313443829, -8.240096417941272, -8.539089091516576, -8.06184038696928, -8.015439235018304, 7.708651257278618, -8.075432862173297, -8.322480112423493, -8.2571114828108, -8.077353446771392, -8.136140967080163, -7.832463932430831},
    {6.71144446000407, -7.881656451955893, -7.554997138083316, -7.601947326927867, -8.177239595555891, -8.181239080529537, -8.498780772167464, -8.080120167923212, -7.714073791148172, 7.36460498583909, -7.937141484893701, -8.280698649392617, -8.088563606769, -8.308748485188186, -8.346030903152343, -7.911364957483626},
    {6.340261823726785, -7.9224782904065245, -7.605154110686598, -7.551247860841249, -8.344029386735153, -8.254974505447942, -8.627112041388347, -8.132467999679772, -8.176151086952334, 6.719589777672306, -8.23673280808216, -8.465180937788146, -8.185211648780914, -7.870245423673644, -8.205013887958783, -8.159588878898138},
    {6.273494332965561, -7.878459029717632, -7.970259147816211, -7.429120579912513, -8.35972957759078, -8.166299926671048, -8.256342801252023, -8.127416846916658, -7.882301092834775, 6.591146193546844, -8.163705380411132, -8.263069307971286, -8.031438810972123, -8.24279487785601, -8.046655563028974, -8.201422370534933},
    {-2.2711252293119752, -7.230170713690668, -6.407368062130493, -6.786849455122477, -6.96086646753575, -6.56198204144162, -7.792331354911657, -7.074363307908896, -6.922650345612475, -3.0601474426566764, -7.0054116013442815, -6.714101584406802, -6.830505240080315, -6.759468329773528, -7.060175091045696, -6.063937786720991},
    {0.3704039876106683, -4.8435830385536125, -4.741066265302423, -4.710700834078628, -4.999133583400332, -4.890138684495292, -5.198611854081996, -5.038846778377071, -4.98703989095697, 2.081779590390265, -4.888574255061565, -5.395685582924962, -4.362929779703421, -4.468014364459974, -5.579117757684782, -4.462425801683749},
    {1.9756533944239596, -3.5088591087038035, -3.95232014734437, -3.9443379393464664, -4.58992029719832, -4.462764928705416, -3.1747865803128015, -4.461250327254718, -4.372502039113568, 1.2019685770806143, -4.500566585261953, -3.0137174813457803, -3.66746510228214, -3.8990730473182023, -4.153994797630571, -3.925536967733015},
    {0.4825452817965063, -1.9142475312518341, -2.142340679797158, -1.6728827401846769, -1.6020540543870234, -1.7463629266708942, 0.5256615773627898, -1.2880264767750589, -0.8773184633176101, 0.41180007346642034, -1.038698248424336, -0.07440794253022916, -1.7112032799668135, -1.3617207802420117, -0.16599048849959067, -2.084731905212959},
    {1.0093255448369485, -6.098036987615536, -5.80725333524487, -5.822429776260346, -6.879534044228263, -6.502850747392646, -5.79885311841578, -6.556680649671873, -6.257268550047907, 0.7274491632913823, -6.513420469381381, -6.483362191699989, -6.0196236715073255, -6.664089971784327, -6.609891261111936, -6.093523600867164},
    {-0.5734711262830976, -5.439338113282923, -5.105877882202959, -4.749218854602464, -5.375764270384907, -5.509642391825151, -4.902385560106098, -5.2555912142878585, -5.557823581036123, -0.5499781231154793, -5.335399018046602, -5.444355267029031, -4.307831455223536, -5.007211933930683, -5.671414447359927, -4.994270694445313},
    {0.577398562869523, -5.936719919006894, -5.920478358414399, -5.833295057247055, -6.052607036787561, -5.781597970099227, -5.945639749681245, -5.728737239569897, -6.225445521574418, 0.4005679175196124, -5.768584954572014, -6.1170751413904805, -5.603302985374979, -5.844234840874582, -6.325487588687724, -5.908270716945397},
    {-0.3267742209035488, -4.718710220386253, -4.776930275179901, -4.76466162650765, -4.475464538745543, -4.426437094424155, -3.4365513666497423, -4.572084404723797, -4.03318872784835, -0.25089908110973275, -4.024513093684974, -3.7215816413473433, -4.517885534494275, -4.443292271331279, -4.108809240058839, -4.502685645710695},
    {0.726653348357087, -5.461018485806375, -5.570607950308191, -5.216744713412239, -5.551960790360039, -5.418665802532357, -5.128728310034985, -5.74063689782699, -5.667087902395031, 0.564268371605524, -5.38236031426327, -5.56993041898002, -4.6021066917935585, -5.235817205614059, -5.920151810589501, -5.4455882718923245},
    {1.4625296437398605, -6.343807674801181, -6.137535035139398, -6.040862032533177, -6.8329644423585645, -6.597953325977844, -6.558012074233231, -6.339497274789489, -6.484494771659169, 1.6176417771492595, -6.833357823278046, -6.612065877078419, -5.988769061563067, -7.103761276692054, -6.411944134854224, -6.038886961169557},
    {-0.6529120768399936, -4.72989291554932, -4.690665670757112, -4.698292619894817, -5.120621774892097, -5.17151956128685, -5.195723257297115, -5.124669273079269, -5.264118425537546, -1.1742180210156388, -5.02019070844641, -5.820844310059182, -4.1970161905068135, -4.988963948693968, -5.21359165982058, -4.753546977487463},
    {0.842760442005321, -4.847491810818101, -4.958027890115483, -4.619340910945907, -5.014530686628649, -5.111214931634836, -5.014312049501402, -4.722420682955121, -5.031506911533921, 0.7321479873364093, -4.827089878755845, -5.013645745798325, -4.223718923995853, -4.8168355747595, -5.387161620177882, -4.989361519273503},
    {-0.431806195592849, -5.862783716564047, -6.074339007520783, -5.915587445125326, -6.386443822387425, -6.0948465873460895, -6.277805983582162, -6.166266732729983, -6.385988090502077, -0.5639520743981058, -6.455082795436685, -6.4949506606978415, -5.266578580611911, -6.385158484034401, -6.671778415620065, -5.687353279873532},
    {0.19787657122310756, -6.039147333710604, -5.998393969010074, -5.645129667488327, -6.764652737341756, -6.379085573220802, -6.187694845184187, -6.251508108718995, -6.2611786755106404, 0.318738711111914, -6.641242219777847, -6.163272759266741, -5.451674552107301, -6.349768613542734, -6.307497376281088, -5.657878680051194},
    {1.290179814539029, -6.4639937487341, -6.613148424621137, -6.327797763987205, -6.943413357828626, -6.78665872452592, -6.676279102372647, -6.7122153727799025, -7.129947562392836, 1.400495660104896, -6.9832199023754535, -6.964156771345203, -5.750761069659721, -6.745622883703545, -7.247585897699644, -6.4487286417149},
    {0.7603079504116503, -6.189876993992034, -6.208273120628065, -5.84359398496322, -6.4086716104058254, -6.341313740520594, -6.1857054901875665, -6.237350037120138, -6.674154685247741, 0.8421345761119725, -6.464429452207992, -6.205902770872846, -5.376990418186199, -6.425631389646938, -6.633955363712306, -5.935263957570225},
    {0.9207079214884031, -4.853509809694976, -4.568982670461674, -4.616055855164094, -4.958675483255402, -4.540312546252844, -3.669467696221823, -4.573911013582759, -4.564648602117703, 1.5394278668646801, -4.62092746183408, -3.87927052783765, -4.364701013028892, -4.339493286475128, -4.721026493687964, -4.757403949312833},
    {1.529076601445562, -6.683436760753119, -6.624543719928098, -6.2180681234371535, -6.562199902667705, -6.588606393423984, -5.530695833747136, -6.584091391742107, -6.143791095531069, 2.416825042256839, -6.577596467167851, -5.585741631223183, -6.170431636406992, -6.423086199092707, -6.040582205057135, -6.579767728046383},
    {0.28485609431093717, -6.678217155318266, -6.75302577580737, -6.576661541538097, -7.013251691951296, -6.967200939770581, -6.057264150882715, -7.090387739761738, -6.993080527232886, 0.10004490951619702, -7.032625151958167, -6.503071438277561, -6.3531774679985595, -6.61870864108329, -7.0644207294106875, -6.590171342767901},
    {-0.1993907240986005, -6.2448921447855525, -5.983344662744284, -5.83209319506656, -6.630474135025431, -6.260956746882587, -6.214051134067795, -5.957088932574135, -6.432061415419059, 0.05645510434342108, -6.394617715416891, -6.0703399171342065, -4.419639153984109, -6.0274662874417855, -6.504976477861028, -5.894517704842736},
    {1.075596446351232, -6.645278021853231, -6.820469289120127, -6.628148873106784, -6.952232250304937, -6.978050210619079, -6.338735883400184, -6.9690383247518435, -6.797225788538632, 0.4299173807151024, -6.687548854711762, -6.9122341997127545, -5.9401507612343005, -6.888549946329273, -6.343924709566919, -6.69327526692118},
    {5.162590240214993, -6.717278097327993, -6.780426990883227, -7.04866005309215, -7.444575189758969, -7.271974017813792, -6.675790093151091, -7.1312434407576095, -6.927848329673901, 5.372358458963799, -7.075841650288181, -7.202693789798116, -5.507968521595781, -7.287491896999959, -7.514734483424189, -6.791711049696324},
    {4.446479655156423, -6.712091871736342, -6.5853850458427265, -6.489295414330047, -6.8411994394869735, -6.530685182079053, -6.085964413629094, -6.436956673305576, -6.67331548958919, 5.418728450284341, -6.623602724765527, -6.419675525270322, -4.896796543211255, -6.634393998645677, -6.786712287697022, -6.175102302936522},
    {2.2537947280694097, -6.6634301745387114, -6.446210743077679, -6.403446452388344, -6.919527335215022, -7.028887066505336, -6.273669072795469, -6.772992189602203, -7.2627218057537934, 1.9813439180879295, -7.086573953068626, -6.500424602405179, -5.63659803340926, -6.735489155407389, -7.163619375479348, -6.41937614114506},
    {0.6942910808405661, -7.284658577183514, -7.147103934837698, -6.876691011255867, -7.575127684115826, -7.673660677321077, -7.048759159714358, -7.504204185542875, -7.541554305212794, 1.1520632405336497, -7.6431358225934884, -7.382545220773744, -6.6382086502050095, -7.218893482718754, -7.550593614233543, -7.154911054223047},
    {3.791897957669234, -7.4262583507307145, -7.206546733253986, -7.149450443088644, -7.769095619931516, -7.720921565717099, -6.468247162451286, -7.646706602216216, -7.579372267547669, 3.548199344206477, -7.39356505203621, -6.5370728513371965, -6.140841849077463, -7.1347985168918235, -7.588467473977446, -6.936959220532796},
    {2.468536573195824, -7.578096333743324, -7.067070920633857, -7.42335163408037, -7.761626676132167, -7.498142879120439, -7.227305535800003, -7.570462091242638, -7.808992999614925, 3.050287049878953, -7.494242068181517, -7.409022242140256, -6.96594721643426, -7.4422630484087495, -8.032089879889059, -7.099451036304634},
    {1.6245642578116066, -7.626516863641626, -7.374310875708358, -6.854891887092627, -7.821235459260159, -7.483457714010213, -7.537303766479403, -7.464909297418866, -7.794609085928395, 2.054129146969676, -7.5207283311114255, -7.517376556961961, -6.573438836566344, -7.461882686441144, -7.480652466627593, -7.1851885585176225},
    {1.9612194027373229, -7.295341106733787, -7.267332015407476, -7.495115158214999, -7.876132890030172, -7.669376050324612, -6.904674827345625, -7.54544295838478, -7.723359364836657, 2.601831067670835, -7.457611488420744, -7.283056538609232, -6.777518690537565, -7.505224364487856, -7.699132935109719, -6.881896977311395},
    {3.2401145503262585, -7.014661463207215, -6.2774894709353335, -6.230199424610585, -6.652521391951746, -6.465885377662286, -6.051286864938217, -6.545446802444569, -6.449500812222085, 3.978330541097794, -5.98027686568143, -5.779367800036076, -4.947844047503389, -6.381970608927212, -6.1988328512370305, -6.004865161442365},
    {3.2180230137876062, -4.368800623467035, -4.170482550393203, -4.660135871031454, -2.8998541306014576, -2.8080450567230084, 0.007662200392451072, -2.863036375446891, -0.9213628207290877, 3.1781889793259657, -1.6151004561183104, 0.40153851125010503, -4.306262267454339, -3.3953296025225566, -1.0790858973211068, -4.476299861850772},
    {2.9335130997273327, -2.8449827606103533, -2.88683141281976, -3.3006691750699546, -1.406578400179371, -1.6801239891891162, 1.5235851068190935, -2.2936753117376623, -0.18650113887274772, 3.210427347561387, -0.8054488182023486, 1.8421322171032344, -2.7196898555392823, -2.5111927350430667, -0.49371948643249286, -3.530597106942542},
    {3.922411981392156, -3.109166372077336, -3.1564874632655022, -3.97427481508718, -2.0070363503590043, -1.7846316168719785, 1.4841802041619707, -2.520396795782502, -0.2260796057788359, 4.023026503183285, -0.9599274596164469, 2.059680465321863, -3.205555510380003, -3.077891079886021, -0.2149080586408588, -3.703649181789988},
    {3.8965634099027717, -1.9371195167936848, -2.196825765982648, -2.7304125405635484, -0.47937497017235836, -0.772035929619569, 2.5751573582469622, -0.9421008545221966, 1.2458690063743054, 3.9326701749434783, 0.871290560077671, 2.681970932536328, -2.313975128268028, -1.6019035004364517, 1.3016371179647002, -2.5146884482432075},
    {3.774679471867193, -2.127682437695853, -2.3120957016827437, -2.7856456304935624, -0.7456668415180618, -0.5147839379637289, 2.570991695895827, -0.6279006887398735, 1.845690400561003, 3.9602468761590086, 0.9331191753492613, 2.730070188221013, -2.1027235490275786, -1.1326258549133579, 1.7438785386872298, -2.5405119207725133},
    {3.821343904683836, -2.4550358560222767, -2.415907611033848, -3.056540724605477, -0.5415707615821993, -0.7257893762916862, 2.393910481542004, -0.9922553688303865, 1.2493877327143628, 3.688944840682265, 0.7998484595395247, 2.8953903666102616, -2.177849011332928, -1.6534832896443203, 1.2974016139299993, -2.774934812606516},
    {2.7923590029391026, -3.56521232330327, -3.579044629207918, -3.9814525289984455, -2.1385358482173062, -2.187522259152783, 1.7872968203467787, -2.696971320822975, -0.0369983795951469, 3.077376128038432, -0.8137405561467731, 2.242700181291717, -3.6247910443372104, -3.080006512851945, -0.0806176256581151, -4.191958902983244},
    {3.4599820475431984, -3.8057085751301987, -3.7516930399902075, -4.243958027498605, -2.1040303552992814, -2.2532714115628774, 2.3371254201458966, -2.1623511871312777, 0.4720670589202061, 3.3237083557629483, -0.41952549309190673, 2.734302122898231, -3.8959236119415213, -2.8781786677172563, 0.48704430433374396, -3.949495659219747},
    {4.04990842367048, -3.133189828427863, -3.3241964420669854, -3.736671407896265, -1.3214772468831737, -1.248712240938703, 3.072203460428994, -1.6858858277634865, 1.5397808903818913, 4.131268044329356, 0.2992273278616424, 3.571968774246955, -2.9987330840822395, -2.1649176919759054, 1.1326095549486876, -3.2610298171610466},
    {3.8394615994151846, -3.8541121752432015, -3.9750437491768826, -4.584874006709621, -2.0861188005566755, -2.0268854151154603, 2.0215761656547775, -2.5561238072874155, 0.035069024036225166, 3.844955620580167, -0.5955879085879265, 2.5108756613972747, -3.8821316695376957, -3.1011882473023027, -0.2554416547434963, -4.188148011492898},
    {3.6883445722848287, -3.2771059224920034, -3.3995893465685465, -4.053803153640917, -2.1226713832767987, -2.1482816392348503, 1.3784918295087416, -2.3109821191758657, -0.03730228917481867, 3.9705815191110854, -0.9052780739281664, 1.8063785157221335, -3.6313635213642694, -2.7316501061604472, -0.4121332274076785, -3.8408201376361824},
    {5.043104864024204, -3.841924601485609, -3.720020012116019, -4.530446735671976, -1.9435937071868086, -1.9126053540755639, 2.2168026098011335, -2.3453199910658453, 0.09713660157200854, 5.412401415831101, -0.5208307801547921, 2.531134230980657, -4.065307012072506, -3.154385507541202, -0.019343401818421976, -4.189475124443108},
    {4.476270077049408, -3.575175749748856, -3.9717517468374757, -4.715274363231039, -1.6066336071701166, -1.5085752368806329, 2.7612595807760623, -1.9836062857061059, 0.6317204026947937, 4.902529477811243, 0.08716989425121327, 3.3090270461398004, -4.381260806072363, -2.9639120687363745, 0.8707530316828616, -4.417497820002203},
    {4.049959920790307, -4.054573890567004, -4.093050881307075, -4.90014996842178, -1.6974430774866116, -1.5725974531231528, 3.005505089800246, -2.042795237988692, 1.1270392069782786, 4.218392102708604, 0.24603208493738493, 3.1729681799963845, -4.0405993285196775, -2.989959495342684, 1.217481670722657, -4.01277428437499},
    {3.692105178355222, -3.8056280147132204, -3.8863703764170414, -4.672533685207092, -2.1318529452541046, -2.1603654398953007, 2.8209294729259127, -2.184173069496131, 0.492544860192471, 4.071683062548934, -0.5088977763664408, 3.206718076930968, -4.153808366122704, -3.325270497095823, 0.2760641169188064, -4.076388112876299},
    {4.8841796796759525, -4.379908268202859, -4.670972795494004, -5.470893134140471, -2.3913377799100317, -2.079829447741817, 2.3615304341193597, -2.7603882794495185, -0.07294565095958072, 5.389112603822498, -0.6628455690763223, 2.7836090883093045, -4.756606802297115, -3.6761570347974772, 0.04869733529395056, -4.765028878079198},
    {5.1699452202632, -5.271128012460787, -5.432571060888663, -5.901069362130002, -3.499385595729773, -3.3600925132922375, 1.2399856142896386, -3.8895126824998636, -1.2628046981793584, 5.409732716547598, -1.9558691982888483, 1.5621194165829466, -5.275667249554007, -4.718848425387629, -1.3385504823435128, -5.70835197102944},
    {4.919466656364455, -4.809141752363932, -5.097387811741608, -5.719511175901618, -3.231741039703343, -3.0124123421029023, 1.514269340623294, -3.8334713743293105, -0.7689018924658051, 5.338422670869244, -1.4787988500491223, 2.197268232043954, -5.250641220862075, -4.188125409130862, -0.7839256722749661, -5.662765775088362},
    {4.671496938103309, -5.122886989381547, -5.366858425682915, -5.865907278485644, -3.7499075707937615, -3.9002077547309684, 1.252029165707203, -4.237711056849854, -1.1074185542974604, 4.550377786176236, -2.330945166994639, 1.719370115655758, -5.445134038030938, -4.729016655414062, -1.242929283690926, -5.652266591296995},
    {4.924093986901582, -4.6098764966734205, -4.8343299060445535, -5.438198324931586, -2.3961258717982394, -2.6938058725764917, 1.7849560671576286, -3.239565353315338, 0.29719932446243125, 4.9205377927003875, -1.058786966644925, 2.1430062942212187, -4.850752497032897, -3.858208072148116, -0.2607531046230344, -5.4335831689492124},
    {5.324718935871137, -4.768467159117745, -4.629759622332353, -5.239733131622197, -2.8937106066115024, -3.1715442648347514, 1.6464259743476488, -3.341438252634795, -0.38427822162238634, 5.7453123082664925, -1.2489771390630222, 1.986485131762339, -5.183312348357796, -4.157456137054827, -0.43869678474338963, -5.27360308016763},
    {5.984289362820089, -4.810046926899876, -5.024407458726219, -5.649652372569962, -2.5725942061424316, -2.9551451707586907, 1.90125504394102, -2.7866023302570992, -0.09639807012096695, 6.29203590732289, -1.0734177067632802, 2.1376566978879863, -5.00034028310286, -4.28795547035874, -0.4307674546470159, -5.110936387619251},
    {5.28879713103268, -4.497140452557064, -4.704749468453123, -5.3394745743973795, -2.250018464565315, -2.379506439532446, 2.7227086157103964, -2.5355187401818244, 0.45170891841386096, 5.917510620722208, -0.6032404104137937, 2.7483840573741434, -4.4512033156474144, -3.8593591670663474, 0.09154001199408496, -4.797748859099077},
    {5.750707142193093, -5.204018042485501, -5.173748276525246, -5.654351226703699, -2.9652763714640598, -2.7468179198866887, 1.733990053075459, -3.2136981390795127, -0.08637875475473668, 5.708373948152506, -1.1023000817358495, 2.3171763053104253, -5.15756552749573, -4.193596073371962, -0.5054738677623354, -5.3392329349845},
    {5.8507106640833095, -4.476386553569044, -4.899719044483409, -5.329970286987974, -2.5256950380388865, -2.6852473674494117, 2.1158934177117765, -2.7236916400268028, 0.16891079373265838, 6.153916387261459, -0.9354722629925369, 2.437589278951479, -5.061030034594671, -3.6449838768196545, -0.08656948609296171, -5.077245268049588},
    {4.93558137522088, -5.064523628106264, -5.034169243460547, -5.666147070303062, -3.0571416571605803, -2.967743666051811, 1.5503739301976973, -3.2561699374013227, -0.4104409386384929, 5.458482243436494, -1.2804128142475406, 2.30014315936276, -5.431259169988498, -4.280286120054513, -0.824506670209241, -5.419187900913122},
    {4.948894004972753, -5.075814808226471, -5.387893038137654, -5.973990456320708, -3.093378047431596, -3.471305434427834, 2.411239936999072, -3.8181544243858903, -0.18519799366296838, 5.316074648845695, -1.5878669049669651, 2.9979408760486783, -5.320210646829632, -4.351948945011039, -0.5193488149552794, -5.724187257593154},
    {5.761173074547119, -4.872847146935285, -5.322951088179283, -5.915569340590232, -3.1181923667685667, -2.8425017011102227, 1.854461049502171, -3.281086450144048, -0.21360479616927863, 6.309854851456177, -1.4109365933528675, 2.852656484571871, -5.210934639543517, -4.016931055551647, -0.2694545563084927, -5.318720722076617},
    {5.724481248987284, -5.506796763815872, -5.656217873057393, -6.3767692735895105, -3.8050918228465487, -3.4881575394624256, 1.2969710582675715, -4.349642626601723, -0.811266552997339, 6.424080870960695, -1.886300175300602, 2.2834454204748154, -5.49698342432654, -4.788142399750401, -1.102657456935319, -5.876951470732961},
    {5.48812320979896, -5.141585488209684, -5.618111296697786, -6.20885684568258, -3.060228735861438, -3.3638186003514203, 2.3389079823322407, -3.4314863463465746, -0.09838488427392424, 5.690762556960399, -0.937438436306124, 2.7623827221294226, -5.346708934773921, -4.645528247141825, -0.20998925346291877, -5.634189568185452},
    {0.49156594721320185, -2.0025456880084733, -2.1091802529724193, -1.5383047954693045, -2.027171513771176, -1.262777215898657, -2.1269767169047507, -2.213143075499369, -1.804326921553307, -0.2893642152777433, -1.4748960834696223, -1.6945605680433875, -1.6405728734549805, -2.074839107619126, -2.016799497941707, -0.1986853449486562},
    {1.9104100671940019, -3.7002118271554485, -4.233848580888047, -4.996202892658258, -4.085218921683197, -4.676538367378166, -2.986681999857368, -3.9274884063408955, -4.753181600008437, 1.8279024842507976, -4.766423226596298, -3.365545488677168, -4.729400959018696, -3.5994644113664087, -4.33691295343021, -4.4392063518493545},
    {1.1130503108120735, -3.3594090240035577, -3.545978069102494, -2.6376006521773383, -4.035046321952746, -3.7749851280816027, -3.4860026985084955, -3.813607755789561, -4.161949173171357, 0.9289493781202125, -3.6959543663805126, -3.2130410385677193, -1.837965044328507, -3.7194616162730005, -3.8253799517589124, -2.8601908920047596},
    {-0.5957977332255211, 0.9135826578910137, 0.5026924085136588, 0.9075934344736443, 0.6081900550956392, 0.3433500367442665, 1.3518763683592194, 0.761208408954974, 0.9330115854884476, -0.7714011393978152, 1.1029776843180896, 1.5812994414292174, 1.0992848973653375, 0.8319974863407923, 0.9408081153665538, 1.0048413627981132},
    {2.267102554401147, -4.674439510640179, -4.765019838743241, -4.241043937719454, -4.9326087777947105, -4.627076374120215, -4.509245690226671, -4.758726744406489, -4.938645440517262, 2.4626731477814756, -4.986875005676762, -4.635775131378235, -3.655653960624217, -4.876745905692181, -4.929553477920015, -4.823200329301794},
    {0.606005740680761, -3.4858927500777206, -3.364990216824149, -3.030920461678494, -3.489413040187281, -3.4557997120275985, -3.274955437515387, -3.403368864133851, -3.715946886729256, 0.5094013774047839, -3.5865520727020637, -3.5505821189769895, -2.9576595268032717, -3.307818437858451, -3.5720798539328387, -3.1763347429176934},
    {1.004578107154461, -4.628095676008523, -4.664983169489317, -4.459653894821589, -4.648297802019856, -4.021752263580616, -4.019399736333923, -4.449148246459338, -4.4741636729116685, 0.6099107535202252, -4.207065778357817, -4.0119871579117286, -3.6979979441527844, -4.315683199422525, -4.4778710645468465, -4.025876496456032},
    {-0.06951539892631657, -3.3703027456687997, -3.5387019226336554, -3.427612894399836, -2.5079836845019976, -2.525209030968155, -2.063823112866985, -2.508940483349731, -2.396476139528727, 0.25452829368452884, -2.2988309651736065, -2.245697427411903, -3.354416962221135, -2.8035236787556705, -2.6057392863597255, -3.2194567327271346},
    {0.9445989839877479, -4.683076930742404, -5.008014850032921, -4.889028337986076, -4.381497828637192, -4.42513832946997, -4.581817938277563, -4.534013631633064, -5.000587444478726, 0.9563831477133631, -4.7683983924373905, -4.538558724731891, -4.103556253255873, -4.267737943350176, -5.301038511375788, -4.38141517155796},
    {1.6349859955444779, -4.9893657044423945, -5.037113408237718, -4.8754216281499625, -5.680766036476963, -5.45966510494721, -5.7433404383866575, -5.171557282885157, -5.824600320205194, 1.6725032509926303, -5.574456043103149, -5.941482763801728, -4.624423629921858, -5.253548437286545, -5.702788235026302, -4.628596209442315},
    {-0.3620660610336839, -3.299884930683898, -3.1504224989743217, -3.048368246994286, -3.690582961435178, -3.5173533847724774, -3.2729243521605245, -3.5831915953962246, -3.6223283807999134, -0.7425113751560831, -3.262928350886075, -3.3959737401209837, -2.6088756196944507, -3.79483434644116, -3.638876681780507, -3.090987437877487},
    {1.0199405825469356, -3.6599256452934177, -3.947864995146104, -3.40960587294058, -3.8932515998759563, -3.6496511244094934, -3.110606428776771, -3.602688018968663, -3.7757240913829513, 1.129735441922711, -3.6179936620347872, -3.101755214423349, -2.9785730786994633, -3.6650763819429657, -3.739247331696334, -3.445245754432014},
    {-0.0023228597218729013, -3.954580394213262, -3.978142565361774, -3.3726662102404537, -3.6514115135604577, -3.5980505840110686, -3.5099401685948943, -3.1610425888821383, -3.611516729097458, -0.2741365946578711, -3.9256907287531595, -3.907457464769835, -3.2141856931485835, -3.8662508805726623, -3.7758673910023757, -3.3603177320888578},
    {0.5722719592144268, -4.032393203630971, -4.059945067286902, -3.680110349144745, -4.424315235562772, -4.302910304838218, -2.920612077683732, -4.124550697519109, -4.147693338826986, 0.44102551417441666, -4.203768643956369, -2.913014723004643, -3.0305868583942557, -4.40036992081136, -4.2903243244288, -3.7870915309916864},
    {2.441988149299692, -5.065512326234689, -4.931990899516246, -4.835249795607037, -5.903952218002764, -5.656275360111756, -5.251072193279427, -5.565323283002581, -5.619992289493204, 2.36616297118498, -5.735637368610154, -5.225397514500769, -3.6856047675369243, -5.442096943082738, -5.527119890615795, -4.81989211037358},
    {2.358459144724121, -3.8397375319758282, -3.854571029689662, -3.404510349785924, -4.328902568088673, -3.9145660874948898, -3.139843702505118, -4.09097143732721, -4.362452170403732, 2.3263685698821917, -4.065453240242356, -3.272456150193822, -2.320734788003539, -4.293474255913467, -4.087878150953424, -3.7879288888433504},
    {1.8802486156248448, -1.731886408985731, -1.7468006104758367, -1.1958971142958872, -1.6502314588233193, -1.3464462697720743, -0.6687318995215306, -1.0568466410566444, -1.051875565160622, 2.123041423862633, -1.2574586829213894, -1.0108718395021006, -0.2628978167307191, -1.3910007308634518, -1.488410602581448, -1.52397527927211},
    {3.1616298732720125, -5.263785567272442, -5.399935740812772, -4.898717816815664, -5.534210605419717, -4.886937773527788, -4.146626563254415, -4.9465415806990904, -4.712847731581937, 3.002928319935169, -5.0647381701159455, -4.277681466636164, -3.4992274012080578, -5.030698952933658, -4.830684264735143, -4.868666899470345},
    {2.2408157633569705, -5.370606764549249, -5.552173735619099, -5.241099076353487, -5.30298137921959, -5.431381333067631, -4.860114966400014, -5.610867988771435, -5.5982900639683315, 1.954764741967392, -5.578636690460771, -4.951177488127136, -4.2303072424164245, -5.450138170294251, -5.666758879399857, -5.322524517507774},
    {0.4666346816887665, -4.606792180740946, -4.249474150262143, -3.9274377420574127, -4.634931781918178, -4.165404873482955, -3.2021238782328734, -4.317853167668742, -4.5103176196143435, 0.439443931227347, -4.602216633556039, -3.5916354136794424, -2.3094295515918857, -4.27604558406308, -4.5185266951726835, -3.8531795573308667},
    {2.751277253455364, -3.9870931140477244, -3.8209040993136774, -3.2070475186495324, -4.095919655012818, -3.46460269970455, -2.450118089075887, -3.6600078453925744, -3.274555703004376, 2.5220843198849288, -3.8713274819231667, -2.6079591277955894, -2.023927269852098, -4.016287672936857, -3.5051808883342517, -3.6069532451755744},
    {5.081049505148497, -4.135695493516969, -4.0132972015961075, -3.3929112906183363, -4.676866191618061, -4.4373570279007994, -3.246904269178498, -4.132319746962904, -4.485295113196241, 4.89259324246105, -4.105287619360636, -3.1279105953726862, -0.7689580055575717, -4.645421928305184, -4.345918245459779, -3.5158527973041016},
    {5.280413716194147, -3.098162360851464, -2.989751075722436, -2.4403660088112047, -3.8994431463900043, -3.2201476905369453, -2.094034151686366, -2.8624754927430955, -3.6073866636076346, 5.3565836540967275, -3.4623400238703765, -1.8195737325619468, 0.5504118501181785, -2.986697132017878, -3.207516913965423, -2.473622934145881},
    {3.6119486310716677, -4.2427655476026835, -4.167261582245314, -3.6222133065842295, -4.433274631181109, -4.3893079189179565, -3.335609615258429, -4.379728961052858, -4.6622648790704595, 3.438186510862007, -4.694503095264804, -3.3941452357612163, -1.8165736943936652, -4.486135150901367, -4.499669727769758, -3.6618248252667303},
    {2.000084111742102, -5.7024714134957115, -5.684567041917636, -5.309375195123041, -6.289169273184639, -6.238362133121235, -5.06434176610959, -5.8472387610720356, -6.410788628984405, 1.6711306882244077, -6.222918342635626, -5.472764129554755, -3.842055629234276, -5.919996232205198, -6.337278069858423, -4.963735267868948},
    {4.40610055286012, -5.898830877395691, -6.026511054903031, -5.711515007047982, -6.217381213093388, -6.129234492105037, -4.795879566341661, -6.132772361435803, -6.155543467421394, 4.091126173588769, -6.16533902028484, -4.7240125128777635, -3.3902275991663005, -6.132791968527644, -5.796505222563507, -5.089801627789143},
    {3.507371026746003, -6.5451402058669705, -6.66762036053955, -6.300019593210079, -7.040730683071386, -6.886826171350535, -5.95063521185103, -6.85917693981975, -7.113739545017839, 3.223782363501155, -7.122104443349864, -5.676373393067373, -4.663237150844304, -6.828984819005388, -6.928828699821922, -6.064267775428768},
    {3.157102950078319, -6.310698846650594, -6.138782920551065, -5.8421866447012105, -6.916078484350041, -6.407420275567196, -5.634143067627959, -6.1645798805528065, -6.5534661015281905, 3.050358977784914, -6.36632642616905, -5.306190935739765, -3.999770160293773, -6.543499315672071, -6.327411134116758, -5.686443675040692},
    {3.5404419384861385, -6.091362384362668, -5.66404055045152, -5.612844138203146, -6.086357043367115, -5.8747469322622905, -5.247428684416178, -6.0595566964680385, -6.049947147896014, 3.1871670307096975, -5.941220372755102, -4.95974651566924, -3.481259361668596, -5.878316897753609, -5.923428678274223, -5.535337652701681},
    {4.760384431909727, -3.2769702762182136, -3.047644780504358, -2.5313348658097667, -3.315208428247383, -2.774324760314935, -1.8281991534173974, -2.795534828459173, -3.0274853131836235, 4.5590155584529315, -2.663410910514297, -1.6680807249440681, 0.11776366582873567, -3.104088936069759, -2.594522109509381, -2.4236773427457114}
};

static const float b1[16] = {9.153695283589556, 9.264072988600917, 9.112677575588464, 9.217284045501396, 9.23926868948292, 9.252497843337336, 9.193828712020505, 9.177095828537302, 9.268487525808563, 9.735489512351267, 9.157543020408434, 9.354477147495023, 9.314757610772848, 9.180143069457316, 9.336584967140906, 9.117174824875098};

static const float w2[16][12] = {
    {-6.582335287266196, -6.916481559649976, -6.4911845136809525, -6.497023736209238, -6.688718933163694, -6.664420428861434, -7.533463396080179, -6.4660736168612765, -6.453175711818104, -6.738974924532471, -6.055150115021908, -7.081400254886432},
    {-6.877443011548556, -6.514000418966717, -6.535719191578871, -6.7591196557992035, -7.364852390951459, -6.261309977802761, -7.13286915967135, -6.128690665934576, -6.598627019751445, -6.685193871333917, -7.289597139533813, -6.156431294968427},
    {-6.597798916680414, -7.0268043819623935, -6.3111545210237985, -6.184678854753873, -6.733405127846889, -7.095877076824765, -6.68326164243504, -7.3695047793117565, -5.988812447408438, -6.626051189032152, -6.153973732966663, -5.778502753177574},
    {-6.1706854296010984, -6.727705405607453, -6.569447521993685, -6.947544157621651, -6.2144905489419635, -6.701839748569176, -5.952026634877355, -6.175846251752046, -7.089266394211375, -6.453849262434807, -6.836967205813995, -7.637025440486167},
    {-6.3452498622009665, -5.914973202634518, -6.743999243848607, -6.0808225122974955, -6.479095805474505, -6.58957225017429, -6.363559260325915, -6.879376782163473, -6.384810593025123, -6.7391310468421395, -6.168144269974828, -7.066104903488812},
    {-6.775589657263313, -6.984617114190481, -6.374403820007344, -6.280620347934666, -5.835198850607378, -7.003771339319439, -6.879701065117482, -5.988159282269358, -6.598594505724146, -6.651102311433651, -6.480462122002957, -6.493337510375673},
    {-6.438461733226664, -6.60160711540663, -6.221441533046021, -6.909166759952894, -6.338739990793604, -6.798829447016307, -7.335160638829625, -6.610483669695023, -6.672280364051356, -6.834892336310652, -7.273906699221466, -6.364420254343661},
    {-6.067377262454115, -6.827014839909679, -6.698953959201546, -5.583673920318697, -6.884384389302521, -6.18115030970576, -7.163924994611521, -6.555726794673012, -6.734549583406076, -7.0295714939989065, -6.7295394603556264, -6.582066794576368},
    {-6.594471366291922, -7.036584182278069, -6.490704501967452, -7.234247769808967, -6.710382873403812, -6.879554665732622, -6.734439302255842, -6.199936575073796, -6.687399029013031, -6.192230535951071, -6.554905864513223, -6.255814940796377},
    {-7.025021168280046, -6.649379403728154, -7.042395321475376, -7.067984704632466, -6.876523962349427, -6.883821154633277, -6.037976012967366, -7.026985780835726, -7.056219578051543, -6.802991315755938, -7.480663701183126, -6.446228061353515},
    {-6.415879433171429, -6.7008992745276705, -7.139903033898454, -7.150765839949521, -6.665664613323195, -6.16523597210579, -5.770105350193952, -6.596931541926951, -6.267704727978421, -6.036558036358545, -6.805296665795264, -6.247398145785101},
    {-6.646489565717151, -6.548297537678301, -7.00037161613168, -6.273472392381902, -6.821334636343, -6.524742987726914, -6.27108684611453, -6.919320484963719, -6.5694743420164325, -7.100024798597743, -6.020136563052617, -7.098200484409965},
    {-6.964829509165617, -6.49931422034156, -7.181119067001408, -6.673166045309453, -7.059282046535653, -6.939673635628195, -6.869641273550069, -6.7251764646993575, -6.31040426287342, -6.700325276660573, -6.644700933853161, -6.456663053034269},
    {-6.8074449823597485, -6.399900283791399, -5.9739286961582305, -6.536903541893726, -6.4433234128422665, -6.4041208054230045, -6.176719975004798, -6.7187804915762435, -7.107420181363883, -6.438201932229496, -6.893629526067907, -6.207102028321558},
    {-7.092191146672551, -6.297594302952144, -6.3726313686334946, -6.486673969600105, -6.71418912071432, -6.507867922623898, -6.520025096257613, -6.666296074364857, -6.893502167128853, -6.169603011018245, -6.572918886560459, -6.976810152776294},
    {-6.652673072057517, -6.289759497160987, -6.766680445556818, -7.310257762129434, -6.100841803921803, -6.3354022349140555, -6.598312016158192, -6.812722302115476, -6.556649726242732, -6.709625960380787, -5.951680985527782, -7.0444267967427905}
};

static const float b2[12] = {-5.824354583582496, -5.738142659175072, -5.458055615013948, -5.467191192591657, -6.0532130198858205, -5.528322098827087, -6.0376803492900954, -5.798855227670416, -5.946046214164188, -5.561885501516602, -5.615903277489736, -6.060926250924156};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
