#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.3425406877079726, 0.3451396356338379, 0.8631288504697741, 4.140185803158327, 4.042425626467833, -0.17015816763693406, -0.6516722589640651, 0.4565997577003632, -0.4982673627765834, 1.845745384854293, 0.4676918499535671, 1.0425953246032962, -0.3133780702916043, -0.4396711230289068, 0.7125901510198973, -0.18127993860033376, -1.1478589520196063, 3.880578627096076, 0.49279053451268184, 3.5895931734427773, 0.25648670347768093, 2.145973350458021, 4.669153141007835, -0.10362625585832932, -0.4792607601560821, -0.18088897234578277, 1.7504403222097267, -0.0611340323882316, -0.05227598527113706, -0.34985145066638157, 0.40214612857062704, 1.5935600344879128},
    {-1.1866071840607657, -1.1704951591896837, -2.131461211378157, 2.1159714360790276, 2.796798858013927, -2.691343197925772, -1.9496969440209977, -1.1364225200533131, -1.6587926055266171, -2.0614713189625835, -1.4137524117130922, -0.39761249012550914, -2.548336386959322, -2.4744193327048727, -2.3466874494523524, -1.9500526377639793, -3.057949107143634, 3.815885779672917, -0.8669663755121307, 3.331107296626339, -2.0447277503684615, 0.30520703020667717, 2.9776378440297044, -1.947463792130671, -2.0785910873914326, -2.5071025769590998, 1.0046656725686236, -1.0974036929825306, -2.181134305912536, -1.0369660939525414, -0.9120192912482317, -0.9068719101709954},
    {-1.2756078488107372, -1.6229588656136047, -1.1873220104357105, 3.7690878969120187, 3.9044912288413824, -2.0704640891946196, -2.154436381469712, -1.1820281818569918, -1.7884186790281038, -0.57897524402313, -1.5508893557119314, -0.8884690096975937, -2.0108076479843544, -1.7538572704692237, -1.3519749610892164, -1.8522133621961419, -2.7026300115244726, 4.205929219922793, -0.6464675175442469, 3.5608489257865026, -1.6918921296511678, 0.48419077730304594, 4.4422526492547245, -1.9902361622562343, -1.8245486839148009, -2.170599917451957, 0.1971524433594264, -1.3654791267882838, -2.021023247146953, -1.8184543232803398, -1.1966177045764939, -0.048641413696409765},
    {-2.6916611934677723, -2.6641712481404696, -2.442289140115573, 2.9603847777588648, 3.1304802351486445, -2.925321401222286, -3.090364234355588, -2.4644372079262156, -3.0763918871276226, -1.527963222698837, -2.832984187842151, -2.2833021012656216, -2.7732749024795984, -2.8478965730128585, -2.3249048829368, -2.95239943387029, -3.294396263433777, 3.3962572311678585, -2.1348742989218636, 2.6673563345181917, -2.634340102226703, -0.8252420384259097, 3.9671528526396402, -2.8089913670784545, -3.24377811486675, -3.153681665203283, -0.9691098975201106, -2.668575097561579, -2.9311067161641184, -2.7785396518684538, -2.362357671809417, -1.5040732886964547},
    {-3.078236706685847, -3.0638566987659375, -2.742029657788061, 2.53192653246794, 2.606135587301574, -2.923588883781669, -3.204523351419578, -2.8779351132644133, -3.3613214809836673, -1.7138820907076968, -3.1132820652767195, -2.813122334162989, -3.013465052163354, -2.9851473942063578, -2.760602434828434, -3.232153960643294, -3.502914572621752, 2.1393064638560717, -2.7741619764442884, 1.14290788705581, -3.0768473920065884, -1.3954430524018833, 3.42030526338822, -3.4070984220518303, -3.66285962049996, -3.5553798832132926, -2.2875020426800887, -2.943067129394437, -3.3457709063547525, -3.795572219968292, -3.213447843472097, -1.9273647501851534},
    {-3.388424742380555, -3.213258518623817, -2.7694880677188767, 1.9684251466588258, 2.5852312698065005, -2.6640991319090013, -3.585059538494423, -2.855845471247069, -3.576233278294811, -1.6210880943019481, -3.2535226992104938, -2.7682332527746802, -3.186282708683737, -3.0458237678375437, -2.6583668211789666, -3.712894153353197, -3.60356793897725, 1.024633993443415, -2.9853107769344307, -0.0020334226580209246, -2.961445934483016, -1.2040213569922513, 2.4383651236367117, -3.6336041150318548, -3.4691603685812495, -3.709830581043727, -2.999140532727575, -2.9322900848341993, -3.427704470676484, -3.800403317158357, -3.1737371532138994, -2.1758910638838413},
    {-3.040521673540661, -3.0315491299111117, -3.1769244962786996, 1.3586905167036571, 2.2540797904124164, -2.98939076946132, -3.7691826078906376, -2.8754647164000873, -3.335166373241695, -2.199609130227549, -3.3521191062972586, -2.88619839222486, -3.185871040369199, -2.983093778769478, -3.136984514443908, -3.7991601408153546, -3.8239025247193754, 0.3541152832192086, -3.0236317427511517, -0.4034849934365498, -3.429985285395187, -1.5811215858938616, 1.966094472277708, -3.874073193050953, -3.446281202440288, -3.519932716166018, -2.7670075377033347, -3.063268125053912, -3.4846632534255417, -3.683450709400481, -3.177358964510865, -2.254936261168445},
    {-3.249371411293355, -3.034539493200586, -3.322914229491251, 1.3558353406539647, 1.9792635523169122, -3.208647042289932, -3.590810041700499, -2.9955289678966337, -3.5806655968645633, -2.263986522185734, -3.371354736757456, -3.2104995579710676, -3.1201961249296715, -3.2863520216375144, -3.2738536108877345, -3.894302533256182, -3.6177742114812683, 0.38109659734097434, -3.2154839099314834, -0.6464842526892579, -3.4657866172364864, -1.862316799990993, 2.008405380895392, -3.7747811989783195, -3.4166789326251017, -3.8938020794489394, -2.7389422715929705, -3.0366904082183295, -3.789367966249916, -3.6930453793160343, -3.3981311906102167, -2.6501072021503522},
    {-3.2862999242948887, -3.1147169947319906, -2.5706980799426105, 1.2650229219078568, 1.574478913035196, -2.964461161554294, -3.5382666339507276, -2.9097609805543034, -3.4652081213578976, -1.6163098035482124, -3.269841123887802, -2.909712307188105, -2.542537975782036, -2.7746436886228047, -3.1908239282719686, -3.683789159642739, -3.6382986433712787, 0.8929065680098034, -3.0904408003039876, -0.11451496753750029, -3.441730312727784, -2.163600026127798, 2.2683929378937537, -2.995721528333238, -3.8327575180952396, -3.657935402165045, -2.558966189772201, -3.1671644423860865, -3.2773184564608897, -3.5427116695395053, -3.2749483713759306, -3.124832668164531},
    {-2.823321125313996, -3.0593441839292863, -2.42949561721131, 1.443037336344723, 2.0035254953109685, -3.326321513176089, -3.2715464674924295, -2.9830123076951565, -3.2436646275841903, -2.162366691146095, -2.905228566614665, -2.7669692754802897, -2.864761383148252, -2.606328122760711, -3.3070251185437294, -3.5128372383793622, -3.7498307417847037, 2.0177320581547833, -2.6694677735878294, 1.1030394785166866, -3.412499314516445, -1.898379691209795, 2.240607056969618, -3.056258635833307, -3.4863491274936345, -3.435882092822403, -1.7307944341400054, -3.1789906617302264, -3.4112702180470844, -3.2032572369557366, -3.1229178654363614, -2.6815658181916198},
    {-2.7923275516203527, -3.0882464587466827, -3.0805903734080764, 0.005132467163217511, 0.44590113897725214, -3.6384428817205747, -3.104131984856224, -3.2247257095636193, -3.191910345862728, -2.7926889029280124, -2.6989547751067167, -2.69548845049921, -3.474414463812027, -3.1738023167072487, -3.5852282958377404, -3.3027681745287842, -3.625759218653495, 1.6816660955248126, -3.0452233610169634, 1.1906294802047412, -3.272063860345528, -2.269131752309759, 0.8697694324684695, -3.3218811662127288, -3.6725052906733544, -3.656669070291022, -1.422978585557277, -2.8259764805569367, -3.2532190787889563, -3.104865121339431, -2.8459838196892897, -3.248005866912277},
    {-3.0958597448762184, -3.2647910474057653, -3.1381117980343585, -0.6642001730400968, -0.16936084517534303, -3.3353140467424818, -3.2286477580813275, -3.188819474972508, -3.2692960328512553, -3.020675067145731, -2.8914642642778485, -3.0417242741405506, -3.4025596431314873, -3.2723533053309937, -3.6484685292028867, -3.3410455968605, -3.8655608762635123, 0.1451700343849001, -3.2369182756917874, -0.5530593559200093, -3.248611057842301, -3.0676733894164014, -0.06400459733337892, -3.374589122013867, -3.4854434899865705, -3.680415451125378, -2.3611897436802005, -3.1203307706288173, -3.540108190124999, -3.0934484358310175, -3.1907573978424475, -3.305335474383883},
    {-2.7528680022700933, -3.0030234052915805, -3.189603564573905, -0.02543641482223638, 0.21140106252961535, -3.5107401337347977, -3.1861737091120714, -2.8486403329955423, -3.36328843407316, -3.1081064119497226, -2.762947734539718, -2.9192531793274394, -3.4198882779376665, -3.315990393339381, -3.621671045523704, -3.585476621621026, -3.6919266579766186, 0.6677361905447817, -3.024704126198082, 0.21983887125748963, -3.385333522109122, -2.6201327203676166, 0.5592725813908547, -3.342675290593779, -3.2411884405681834, -3.4682073158053526, -2.0836730814478264, -3.0239443893548748, -3.6198093224501173, -2.914535935386286, -3.063085905483736, -3.2691088314767445},
    {-2.930902092063867, -2.9692858024210116, -3.055946035689896, -0.3925254766051702, 0.2860879636094031, -3.372885089109637, -3.1788568312937415, -3.1240539681246413, -3.413795109108601, -3.350127135081303, -3.0448313332762162, -3.1117549166890655, -3.29172397752932, -3.4089202930609925, -3.700863650872512, -3.30677236038282, -3.911010436734539, 0.8642518898951567, -2.7141533311932204, 0.031773732701612406, -3.351270471667379, -2.4810023289402596, 0.34525623970732616, -3.273218245707301, -3.5624977499047707, -3.43536298283721, -2.289748976942397, -2.9232119660816336, -3.4065787223544226, -2.92813092638113, -2.90378054960431, -3.164765231866731},
    {-2.905276835490513, -3.0978800236835133, -2.800577721466445, 0.9986961998058528, 1.3784260622319053, -3.2258573631010603, -3.0081635707652676, -2.8393389856554765, -3.109507222741507, -3.0690582972926315, -2.5720040190369486, -2.7293582358874113, -3.1500763441883293, -3.1325023615560643, -3.401674518705947, -3.349305908761849, -3.8495304460604753, 1.6349852444706605, -2.7606658443081136, 0.9121719067461372, -3.3269863933196424, -2.0975631847889624, 1.5504309171571093, -3.3152416581568764, -3.3545185916441063, -3.3333602871479573, -2.014309604605934, -2.647357175108291, -3.206927805104051, -2.6911082652607625, -2.854069851056358, -3.0173957000287723},
    {-3.102839285012891, -3.2486167946462476, -3.192727186156734, 1.8573819717771762, 2.1494971784179673, -3.3181298245779014, -3.2954730518431257, -2.909466215068776, -3.353987571740683, -2.586417329106869, -3.076811514597534, -2.6657466246703527, -3.275187530311252, -3.042134631754114, -3.2482567743680177, -3.65666358208278, -3.7805114474116266, 1.9633404623747157, -2.7860462628331963, 1.3552236817636194, -3.4220334569124087, -2.1671086534300446, 2.4829917753692743, -3.47622432856476, -3.5367823216648913, -3.554536806856329, -2.0126124458755545, -2.7454402272522915, -3.473521523950841, -2.9919729129619546, -3.084239628977654, -2.725435097462792},
    {-2.7532794193057164, -2.8984600348619076, -2.355493706736339, 2.7078828361331313, 2.8635292350663093, -2.8956928740692662, -2.8747460819173933, -2.6494788400939626, -3.105533436981504, -1.8478834863856535, -2.695840146203268, -2.463472311606729, -3.0899246219160017, -2.8464796268306274, -2.562016488503297, -3.0618667658378658, -3.424750788338094, 3.3110521943520657, -2.1625563144247457, 2.0872668308729017, -2.890001578527535, -2.060630982493644, 3.835445995809925, -2.8941157726376443, -3.287107830647421, -3.136452343830272, -1.5012292910523715, -2.6947313364267678, -3.090134036559619, -2.7542779988079893, -2.4807754546588754, -2.1716019465937055},
    {-2.1903466526911237, -2.0763894643551413, -1.4777570798813344, 3.737657386694688, 3.2189270288046017, -2.429049743533649, -2.233463630363135, -1.8709719586131468, -2.4668178531296756, -1.034057874029514, -1.9785316149588221, -1.7547172937759934, -2.351107460766579, -1.9154288825260322, -1.9896142208131884, -2.462928293820641, -2.729845574055075, 3.759942746377567, -1.4846688619544763, 3.2017438440015136, -1.9804449824303751, -0.9425260854078429, 4.268798080410044, -2.4059629275553838, -2.752265357971969, -2.496815572626107, -0.8243326811837322, -2.224714451641351, -2.412872281651852, -1.8779257686943587, -1.7953508257345723, -1.4217620039738572},
    {-1.9221834160268614, -2.214685672337246, -1.4980141807746112, 3.382157841342673, 3.009621901027794, -2.278398938289225, -2.5939822748870474, -1.6846720340405654, -2.5054652330171607, -0.812110561479427, -2.214363201023667, -1.7441847929839736, -2.3774019928634167, -1.9768950948809152, -1.7958872834782258, -2.353918657022423, -2.737391764575501, 3.615461270502603, -1.8746133207822302, 2.5295944626847944, -2.4324088950196017, -0.9113289955818151, 3.6813448459636917, -2.328927299327269, -2.4282546254401107, -2.506358856023906, -1.0025647226739063, -2.0949362792124786, -2.293123862164915, -2.330983959010338, -2.163834842225795, -1.1713193054622688},
    {-2.510119357188126, -2.673729269024356, -2.4769159945574333, 2.616748746816988, 2.921878320811457, -2.9598151120496583, -2.817906718057105, -2.129427653846745, -2.959644755583284, -1.7760769157000276, -2.2926743740728837, -2.2852087726625685, -2.9586690428099502, -2.74311666964764, -2.8025940870663404, -2.9286935789682467, -3.4222974791626366, 3.179303344085043, -2.1563854394550375, 2.441247679262478, -2.967681408637594, -1.2697987417434007, 3.6640613544564764, -3.0994792568689555, -3.043630463874319, -3.0758217305384363, -1.2240878389366765, -2.2721969031747657, -3.186901717966616, -2.4895025709018164, -2.19535241327789, -2.069726433937585},
    {-2.525025902557637, -2.6837370354524865, -2.7945433138823335, 1.9798206997360777, 2.4274377214619527, -3.115123163870068, -2.8131561378686656, -2.3945701007589966, -2.860868311499729, -2.354581565560411, -2.6407690564751207, -2.13778578135737, -3.184604395187581, -3.083421731286202, -3.019845589714404, -3.10001942340276, -3.6867409776341535, 3.462571472218824, -2.0423575005273453, 2.6009729721174937, -2.88084761581213, -1.5263377995729375, 3.126237994019803, -3.19670154874298, -3.2373508634591075, -3.3086002872573803, -1.3041144168184065, -2.498784482668431, -3.0900853355686526, -2.5120234848098795, -2.559926721433518, -2.4434099038829538},
    {-1.9168548445693092, -2.0531175139266806, -1.5673494952658227, 3.753203447820258, 3.5662705336894236, -2.3945719049454053, -2.3538109154254028, -1.4500931181853272, -2.0031308618762558, -1.330466236125781, -1.9148617909250853, -1.3037866940914564, -2.307276128115534, -2.3282187479853755, -2.1331636944323624, -2.4160755800736595, -2.690094547045018, 4.28895588247441, -1.0727291140566708, 3.4934496055647792, -2.028778817036197, -0.4850830251307366, 4.604360925161262, -2.1251627119680516, -2.3775350351930613, -2.2783333523963507, -0.09629047947205233, -1.9418127666873959, -2.125811116048086, -1.7672434847025524, -1.7592298517574287, -1.2014964844908356},
    {-1.2395438359585467, -1.180965005771023, -1.0456836149162936, 3.9915490764153008, 3.6764997537242765, -1.9202056449430085, -1.6034936197186116, -0.9493905556745689, -1.3561013385559835, -0.6213965993359581, -1.019984706646885, -0.7830173397292705, -1.7774075802540374, -1.5855622918322387, -1.0046552000528104, -1.5827856884381442, -2.430729672377886, 4.2040717770530796, -0.4790020540135439, 4.079464241018202, -1.3756477529679412, 0.48266901904184467, 4.622566999739097, -1.4931335982044602, -1.8174677256640646, -1.7778897897120547, 0.8968568922634047, -1.4547801062069454, -1.6363787611872993, -0.8515810551005055, -1.0698539429955567, -0.1710184868264775},
    {-1.7033010739002672, -2.0527843915208113, -1.703816401235599, 2.978911061771721, 3.1587914297274624, -2.684114384925899, -2.130616681648664, -1.742458775115336, -2.3478941892567695, -1.4589521855743404, -1.8636604418662128, -1.3384333167978089, -2.231178777555851, -2.2986625038603803, -2.177683607490031, -2.0758000886177244, -2.8683980166296847, 4.041695145975523, -1.2481465555296585, 3.50167164320042, -2.1650198503606948, -0.9147932447269961, 4.045901975137578, -2.10646047529538, -2.426111131129473, -2.289882472872713, 0.026864685751090776, -2.0300029732690166, -2.2495079764036694, -1.8243986545126163, -1.9279514730364034, -1.5201438675410994},
    {-2.31071604123095, -2.421756898127431, -2.372132534747667, 2.013295063952248, 2.4481319183067165, -2.9778192805844097, -2.662207470689341, -2.3314983111543373, -2.5834784790474146, -2.1575842773689726, -2.11290117339883, -1.890863191554131, -2.6852270152401183, -2.7404376007530797, -2.731907446160627, -2.4869725637952986, -3.2547329627263, 3.6020737527516697, -1.802882533454007, 3.1630666827319547, -2.5492656973818644, -1.2694684963391616, 3.3330700875390793, -2.605772461030767, -3.078765316111189, -2.8773142087032597, -0.5588535967596878, -2.2785132715095124, -2.9255840702577207, -1.9597264452383811, -2.315731337925588, -2.0993533396621973},
    {-2.1990259299956008, -2.313675895667504, -1.8642028753856692, 2.3217172120314222, 2.7956336091089353, -2.6684098096192606, -2.2438868014078586, -2.0188717457683123, -2.568255143101761, -1.8142180342245762, -2.3310360758249566, -1.906356734966846, -2.5679521121232893, -2.580872794479425, -2.4547436152411146, -2.705167249092448, -3.1004754485130985, 3.487658430834554, -1.6242327607056128, 2.7936149798223218, -2.3759064133551124, -1.445807614970778, 3.7082581365612777, -2.507653519094987, -2.831322060623402, -2.791786453451128, -0.8580447208493586, -2.020928389600131, -2.4626326972738304, -1.822587960172202, -2.3161960775882626, -1.7865805225806537},
    {-1.9142513944015476, -1.9589169955544063, -1.887641845823298, 3.136792487850688, 3.396614762681751, -2.474403060938255, -2.422472435237631, -2.021887354122041, -2.4872933242425788, -1.5789899494023676, -2.0324795600369003, -1.5644809016757255, -2.6124996021967144, -2.4644828134203154, -2.035997615746782, -2.3668879058944814, -3.015864844999676, 3.900749070425343, -1.5484247726682647, 3.3428645736377764, -2.4837375943008095, -0.4939946065842964, 3.830134142273903, -2.2403282798446487, -2.666437292468802, -2.676643767717368, -0.04489506724990969, -1.8700681193268585, -2.532037535048958, -1.6723821347885652, -1.9302264887528304, -1.5119413181259738},
    {-2.1366091031547225, -2.1762765314503256, -1.9665346844379599, 3.198400928820128, 3.277483801674529, -2.8225658243140552, -2.420848008639828, -2.0586410296595545, -2.3965691100114506, -1.7409287963173152, -2.2922572114503055, -1.5121733069799528, -2.9044173811241625, -2.720464262012849, -2.3806694361696987, -2.7795121369180364, -3.1985042516032163, 4.253480802083919, -1.439562157665761, 3.541272712033166, -2.5612446278103307, -0.563701629426559, 4.191050912231584, -2.647766668214285, -2.9891867626121176, -2.956110017006973, -0.32462430440392853, -2.232290849442612, -2.5147996864922906, -2.0022297681381427, -2.0730285882283246, -1.343514467290467},
    {-1.9396694210542396, -2.22550042424564, -2.2416852244096876, 2.6059956413149865, 2.736364699173884, -3.0452386676070984, -2.7111938497673878, -2.333179625479674, -2.5829205933799613, -2.2122507998504686, -2.1606611139313703, -1.5921296532633082, -2.8072891900437935, -2.8607182899535317, -2.3753924578127545, -2.8145277792531176, -3.300966737445804, 3.9788806210201346, -1.5867603890210256, 3.4534087848286124, -2.544575646880778, -0.9280626611686855, 3.617689970825405, -2.7110022088331305, -3.0478934859887508, -3.0159622335547422, -0.36266457493065485, -2.0789194756250455, -2.9071454222731683, -1.6883762240049083, -1.9836884172293008, -1.873251292441173},
    {-2.0375714816360326, -2.3840636066439846, -2.01838947188092, 2.6614685627698065, 2.743456987272343, -2.9007289156697107, -2.3663392900719424, -2.196413615184531, -2.2963416944114745, -1.8602335195025113, -2.105957715225106, -1.6069591468846494, -2.931321217107319, -2.6349767202041816, -2.3430504798771805, -2.6235178798962924, -3.2943382834301738, 3.72430973958761, -1.3553346259152153, 3.295778115399914, -2.5375974073271483, -1.0623746908857095, 3.751124378420219, -2.3684343651256863, -2.7530006420734066, -2.847816453650553, -0.2482838025929992, -2.0028113065874242, -2.472030141207679, -1.4918706899515584, -2.089472174543699, -1.9600510657666692},
    {-0.320234763992988, -0.5943645500168132, 0.3438732317669843, -0.5055677640683047, 0.0810827900532435, 0.07639968250577664, -0.09697391559401851, -1.0089163778468457, -0.006163339733643391, 0.12557109793895063, -0.9254816290745206, -1.192569925368636, 0.2303744141459103, 0.3922711621123096, -0.17439656247953084, -0.4167785127818512, 0.16560703230944224, -1.697788973483395, -0.7314773653798529, -2.108229564995014, -0.14047114802202088, -0.553966424506904, -2.0359207654326004, 0.21569078860487212, 0.16473051793677432, -0.33414047796083995, -1.833427933422529, -0.23386614054737184, -0.0783135902014622, -0.01578512731047394, -0.31649683573082077, -0.47670872642769313},
    {-0.845974823242734, -0.7982137418094918, -1.2158026212048005, 2.246902906876837, 1.8381246615379132, -2.0233325554878507, -1.43520724440988, -1.0417697572646578, -1.6134814859857527, -1.329714493469984, -0.9047824002378514, -0.445467804007837, -1.7396337878943644, -2.1213028424650573, -1.1906057972951143, -1.5436086743337825, -2.4899494762066614, 1.9568777938005197, -0.6575831867283943, 2.2734260467589884, -1.2585176480066032, 0.427682065810642, 2.5459286863116732, -1.6465392552548321, -1.699479967431988, -1.9451611121208194, 1.0011332268749922, -1.6798331362973224, -1.2796407105485923, -0.6752104688507956, -1.0266324328879535, -0.5252222695622853},
    {-1.8820346045487986, -1.2875492169780638, -0.5091549318212361, 0.24851473575240707, -0.19650970897866085, -0.4447592055980891, -1.008897585210853, -1.1493980541792685, -1.394833401325411, -0.3295841377921253, -1.633186129621207, -2.2517393903491874, -0.5207886618125251, -0.8882662936429382, -1.0670577395968768, -1.3943258825543858, -0.5168080605665216, -2.1761829606891774, -1.7151665177979551, -2.0622805409744105, -0.8946843898116632, -1.4396452725470277, -0.38701154532338744, -1.8907749335306647, -1.0832757144224212, -1.3690622681616982, -2.618262449525812, -1.829514683426743, -0.8162446791228551, -1.92025334223178, -1.8811617018735547, -1.4972417087653025},
    {-2.152580588238835, -1.5444478472564, -1.448385013036458, -0.8053895910317608, -1.453051475787973, -1.4608410373746106, -1.2105150111408434, -1.8993243118609493, -1.5912588627870827, -0.8828848778851561, -1.407553665467625, -2.282566591254514, -1.1824117436253923, -1.5494241840844407, -1.8622396259196639, -1.5716941279006267, -1.5114460407600518, -1.9027334104089586, -2.200867380618045, -2.3300793814469536, -1.220030397289619, -1.6892375530979507, -1.412719745250099, -1.7182350291122872, -1.9906830141049727, -1.3089689209213053, -1.9534631567115726, -2.139173422492381, -1.6056582049667578, -1.795453774817351, -1.906358987641179, -2.6112909416548824},
    {-2.351865588324923, -2.0481271416190436, -2.0439350607377698, 1.1011604771032124, 0.5469455863799847, -1.9681830093203105, -2.1526667651231732, -2.315483813758067, -2.3898391789321587, -1.0161233783823276, -2.50733981240863, -1.6579865950728596, -1.8037700234790237, -2.2075597040197192, -2.1735729741106153, -2.509878184048196, -2.74316579923197, 0.4516725617885992, -2.356770371884657, -0.15178221172264153, -1.8532169142532542, -0.7181493620373189, 1.210157623892481, -2.360504098795842, -2.549195328405807, -2.592397499378904, -1.6024140662270296, -2.5581630446027237, -2.4830625827361508, -2.574781880255793, -2.1572574282350816, -2.021330128502329},
    {-2.379942144443916, -2.1178935542109927, -1.2241870868459686, 0.5008578630078528, 0.03223392975053742, -1.482453637918432, -1.9499995063237383, -2.53087644703991, -2.615267638712676, -0.5263549967745328, -2.239606102213436, -2.081426735284198, -1.634535120175437, -1.3186041116290053, -1.806758086847186, -2.1907101284813977, -2.1486179306391184, -0.259712451178756, -2.2582901807974562, -1.2357565360743932, -1.5038707059999379, -0.6325428385236105, 0.4005312303968024, -2.1010670241208613, -1.9806232411583666, -2.051435105828228, -1.6256844521106075, -2.4829230344906383, -1.698611588560865, -2.642226594689549, -2.204611111532657, -2.184514986556663},
    {-2.2783497393121928, -2.4587317235110433, -2.10679162472106, 0.2360107106120759, 0.228220087516982, -2.293504688076436, -2.4867760416326665, -2.5099466039610414, -2.486090129737113, -1.2721727344883345, -2.632441759081968, -2.300611115351891, -2.271258417053555, -2.1866636090940106, -2.3145462503739576, -2.6619964956745945, -2.6532870349138387, -0.3718236373885376, -2.673653331093133, -1.0274598202390255, -1.9055011714408956, -1.0722431134444186, -0.07385958031679567, -2.513224583552233, -2.4131520419166668, -2.511163917935174, -2.075961939555484, -2.7405594470892227, -2.100694278325153, -2.6091916718385018, -2.1615168608105764, -2.47576007446062},
    {-2.105822398340072, -1.3583205531129656, -1.883345072293861, 0.3267249368564177, 0.14787383933738732, -2.0271075829935277, -2.387702868720435, -2.107422008411231, -2.3657627026675576, -1.4576754928709568, -1.9941835253236917, -1.491806585002927, -2.0866228191506417, -1.9187518896098246, -2.419215360822138, -2.41798359705005, -2.5777718728450205, -0.18412695619039915, -2.168473270373249, -0.29579024335308757, -2.122970070798807, -0.35747227894774863, 0.18882673818226187, -2.2498018639151285, -2.163190824043283, -2.234589762588562, -1.2189085631271546, -2.0966970402446563, -2.2810227957211517, -2.213863085662114, -1.7874831521393935, -2.3625030533905416},
    {-2.4976126645013226, -1.8668143978977838, -1.9869179793276355, 0.37006867358675644, 0.05327186645083912, -1.8093714914369645, -2.278025942485096, -2.3069153624059364, -2.60501574830557, -1.1113807736093952, -2.0410152410721496, -2.02494932365399, -1.8091661084730695, -2.117197024601958, -2.730391264946323, -2.554699945092989, -2.840956296754093, -0.36744932673024033, -2.241838909466962, -0.7039165869427915, -2.504376481268095, -0.7455462652072202, 0.1980841725995741, -2.119264141828057, -2.4315570379651716, -2.4852651863447925, -1.9184227950642505, -2.3898411907000296, -2.5058875895981743, -2.5694948119601553, -2.0225972095844353, -2.815988538953789},
    {-2.5690868947960084, -2.124706223739379, -1.7266718958892437, 0.7879619036580372, 1.2094724199703808, -2.156030717430087, -2.683728283760492, -2.3276381053948167, -2.9222578181104972, -1.2388479739696325, -2.5269854022523583, -2.280175786037312, -1.806289539474865, -2.045921099191397, -2.4255232368124995, -2.8632681185752547, -2.6586541716846583, -0.6364193814648709, -2.311577687793086, -1.4855384027385357, -2.320264772096765, -0.7253002121580598, 0.3886831964913526, -2.252480822014921, -2.40166804916278, -2.5481907968356743, -2.407248181798291, -2.3978982507436415, -2.2675678416593574, -2.7149409375958427, -2.2284041165320096, -2.0015060180938806},
    {-2.1138965956716946, -1.8729626281791516, -1.8516239208009106, -0.37060272884078904, -0.30734022674800776, -1.8324545940504429, -2.12739441757987, -1.9293763623463374, -2.1148084560235794, -1.2181145377633786, -2.1450997297048304, -2.1728301494136693, -2.0769157575560344, -2.305901632774255, -2.2395767510757603, -2.4040913162660935, -2.171383412223999, -1.522420094959283, -2.0934226909728024, -2.0244485109549553, -1.6811301767950682, -0.951836367627929, -0.26432492565388765, -2.223577571332445, -2.362117797088824, -2.3743692870752007, -1.9196917076094737, -2.030956258867041, -2.0088340008090286, -1.9193453201890696, -1.8220326992500306, -2.065482235269821},
    {-2.527088310203559, -2.498419439783763, -2.139760742372709, 0.215174554776793, -0.010084489481962515, -1.9839238144910403, -2.359971506453647, -2.6133341447953433, -2.8055724727453137, -0.88957561677894, -2.147054175892246, -2.3637045485065755, -2.02707365334148, -1.6891732094924625, -2.176466395164523, -2.5754927120064632, -2.3537866487783803, -1.4148761455680334, -2.5050429427841974, -1.9182241298410807, -2.3301756804482645, -1.5656849441431344, -0.18509779562150147, -2.310410903464983, -2.4025928762050026, -2.599039736967762, -2.753539449850841, -2.571203845264894, -2.357714489075591, -2.9114216327038687, -2.1715661124926027, -2.329661044717563},
    {-2.4566682785316107, -2.3728247924642045, -2.672918158975541, -0.4659529205055435, 0.43148430886759964, -2.359982079762387, -2.5548868181761164, -2.5556268195958887, -2.962147336760245, -1.54861148456357, -2.3864499111058315, -2.6176705344750704, -2.5554306179221524, -2.338671232417627, -2.56010708095085, -2.8860461857274715, -2.7606035720120157, -1.6090785721222034, -2.6061032694237145, -1.907591505491029, -2.407226411409707, -1.061739021126039, -0.3041317269014658, -2.808777643973631, -2.4932581535958693, -2.728370760401047, -2.9225832368066795, -2.5591210799867206, -2.4654181939487287, -2.808978511973331, -2.351915928836814, -2.3327821353358607},
    {-2.6905343752335504, -2.70041582296793, -2.5504111367532576, -0.36237384057863997, 0.4259243557150218, -2.1882303895231634, -2.7235914373769226, -2.584656112008417, -2.7657136304308607, -1.4435602545202153, -2.624495353168921, -2.6074414493818034, -2.415049091848331, -2.2751264091518353, -2.2820768945649657, -2.6889367066506713, -2.80000833138531, -1.5147623201167546, -2.493665296086093, -1.8002242024029034, -2.5530485509084384, -0.9788123765954182, -0.2650749134850043, -2.9686986693641395, -2.701508761882525, -2.4327033465862717, -2.632307768834178, -2.799697751902447, -2.436544795300989, -3.2504959650724223, -2.6385184414360507, -2.2493428989611117},
    {-2.341263318444416, -1.9416265252948777, -2.102426175118325, 1.1178940291619188, 1.0855231797464444, -1.9614876133193617, -2.560246070185604, -1.9531549096593315, -2.820158593299627, -1.1203507761134972, -2.5411460783582833, -2.02038124447248, -2.0020563347721643, -1.8254411600213707, -2.2903500353996837, -2.899714192328775, -2.382772068707068, -1.1649514946231918, -2.244709580525234, -1.673436471156859, -2.0910624330872043, -0.5097532913801021, 1.0811054346622055, -2.4752891473966283, -2.27924108696743, -2.6877465804985885, -2.757732116724128, -2.3790897874998285, -2.414696723300224, -3.2138347441451836, -2.3190098861439403, -1.8887315853106204},
    {-2.7353751746325248, -2.2748123821595674, -2.0821567171738082, 0.7967193123346745, 0.5276367224547445, -1.4420932034733909, -2.1792084613760894, -2.42505616316594, -2.8685839540263594, -0.8949439752258752, -2.7889481789214297, -2.541622212923927, -1.7621718743976487, -1.8257679963925626, -1.8349862854120405, -2.2097718739991303, -2.2891217635908676, -1.7131756536601157, -2.517673672255149, -2.4093944413577586, -1.7539383065092478, -1.3575816078082201, 0.30664845771521404, -2.431764592498147, -2.3387226161739894, -2.446981920488984, -3.0511779427197965, -2.3054745911030303, -2.2372049020126608, -3.002336025783323, -2.269879550912507, -1.9750139974186167},
    {-2.2488644320150453, -1.7498118715984414, -2.0919642815967974, 0.853676255802991, 0.909981372864368, -1.6072519971033945, -2.217519492835738, -1.9569695784938759, -2.2304152468137985, -0.9593564867013927, -2.189864275007773, -1.9373484769171427, -1.6499283830236682, -1.956301059058407, -1.8167635905675976, -2.017243288017508, -1.8091395994286588, -1.2397563272880683, -2.0269421834250436, -1.5509384151286345, -1.8088466334308138, -1.0692836683784297, 0.8511912500115983, -2.1830124595264406, -2.0301033480212705, -1.770377891210657, -2.4591711279311532, -2.0931623419394425, -2.1826166601200323, -2.567532589653959, -2.1792320232974554, -1.7114777793088092},
    {-1.9089721456243125, -1.4907272079597993, -1.0354273467164945, 1.983725436498866, 1.0902554495012295, -0.6717472715548501, -1.6900729323636299, -1.4040736262969187, -1.775969779940473, 0.07151859659846357, -1.9815098486848872, -1.7262008564681273, -1.2681122880578628, -1.3808674509618224, -0.9519365016035081, -1.4395612263098638, -1.165410818623235, -0.37993289256611257, -1.6984529195447848, -0.6528242284145727, -1.3866610064742273, -0.9715139191777952, 1.3306680107401148, -1.7678486604470933, -1.6143328017120278, -1.3968330324771019, -1.8941072874675764, -1.8896200899320517, -1.7409952545057015, -2.2594690062158103, -1.829753365931475, -1.299677565532886},
    {-2.661418214751791, -2.239483677256262, -1.4508816222389402, 0.33806561316539774, -0.14223349927425813, -1.534083935336638, -2.119983468344446, -2.479211303502054, -2.4832273201554282, -0.5334002193317607, -2.531009656577676, -2.7121917635025756, -1.5774164517924325, -1.7788435629766923, -1.7991208462897434, -1.8055103504819536, -1.7944865439030895, -2.0366109207593754, -2.693607596199233, -2.423130351222685, -1.903837652401977, -1.6805711831321983, -0.10582907360522932, -2.2429188448100974, -1.98829471466812, -1.7715379373443447, -3.0155630542251246, -2.6378066866549092, -2.2050227653185255, -2.955099465214458, -2.61065900277, -2.1150242287896694},
    {-2.8493767856876864, -2.5688648003008696, -2.3766579279958893, 0.17527531464693752, 0.3355197317742662, -2.002039479541265, -2.8515727920648075, -2.8831425827670056, -3.099356925936019, -1.3581778124505886, -2.5661651822137577, -2.7629977965546044, -2.1305448807682774, -2.5992688795945043, -2.2799262102871896, -2.874919859853193, -2.4813942582986805, -2.132954790960184, -2.837551593703758, -2.4164458446197097, -2.182799039885441, -1.5055207365323091, -0.3175852441493485, -2.9029761937363934, -2.3806097451768737, -2.656393924270005, -3.0653422045964684, -2.8560500691982433, -2.4880483890539185, -3.6170895913980297, -2.524475783239332, -2.3925864957144403},
    {-3.264942832820204, -3.0541603549041407, -2.749985166122324, -0.5203648918836147, 0.2725846543076227, -2.037655924800454, -3.0228152026831117, -2.950240495048062, -3.2173024977102815, -1.9288191225287314, -3.0416464680779502, -3.1279223607771125, -2.5248377356421283, -2.34636177751085, -2.347441030044596, -2.921658607002028, -2.6913892283110186, -2.2321972034256654, -2.9655891167363295, -2.8554329555141007, -2.4575193660245596, -2.070181848886118, -0.462337953848552, -3.204842305116482, -2.6988384361877835, -2.9485172943411646, -3.149131413303476, -3.113519431476702, -2.67526322555804, -3.4743115833406346, -2.9786379805916345, -2.451746001778099},
    {-2.4642864188617932, -1.6608299848324717, -0.9540112197777798, 2.815429705891716, 2.574229618777838, -0.609482639569357, -2.173897907600468, -1.8633862623703659, -2.365663820950246, 0.5297416184176714, -2.220643421850913, -1.9928027521446101, -1.0898467549641873, -1.2139434022027304, -0.688292626633144, -1.8067765358650991, -1.4037233162969593, 0.510374606675491, -2.2421642217456292, -0.30688675234127416, -1.4000300741386082, -0.1453239068888346, 2.8562478313059447, -2.2909352622120274, -1.7762570984197414, -1.9456067423217527, -2.1755391947896605, -2.1518139963193335, -1.6983524922711761, -2.8901554799378792, -2.381307165145089, -0.3615498972856073},
    {-1.6493594926876929, -0.7990667788825978, 0.5245745566105627, 3.0594516331635475, 2.9001844258133103, 0.6350867412173566, -1.3663906471087144, -1.023273618274688, -1.7746391946567739, 1.8423948488608444, -1.7224609568863272, -1.5516548934901622, 0.5532792829930899, 0.06491843431677405, 0.7016579568331017, -0.9214994169750377, 0.22887050615438498, -0.6740769624115054, -1.326471890625384, -1.851098127393831, 0.04105043588814049, 0.8330571715800777, 2.9211164293413057, -1.2861998991509824, -0.5120013833316233, -0.419726472811015, -2.926750857425718, -1.7292196828386255, -0.6845645846667047, -2.7257656536283363, -1.6922701190357796, 0.8995826146605141},
    {-2.867342805764993, -2.128154339203257, -1.3304246237118962, 1.714291827304319, 1.6030146236624985, -0.19347511922276395, -2.2835726858812104, -1.8286763865636098, -2.5898738249397737, 0.22224547819942964, -2.4198581314078673, -2.518704237698813, -0.6382401267464843, -1.2431166050210871, -0.7196595652250084, -2.1366826075392704, -0.6675533619986583, -2.7631868875988883, -2.578049375653206, -3.3400681838465847, -1.2213995185732616, -0.8283693443809331, 1.2698968437666946, -2.565998013544087, -1.693791017662034, -1.9025306139644296, -3.7417399409463266, -2.1941825384012454, -2.1131195181296762, -3.5091841625728235, -2.3477999957281868, -0.670156011660109},
    {-3.0303189155914523, -2.420735794934883, -1.9632003448688993, 0.5924321280850519, 0.9123929531912514, -1.9014855095768177, -2.9076409338822917, -2.4479449508369084, -2.86922734470812, -0.7179311599156522, -2.8799584879752564, -2.8360612482461236, -1.8654750259980133, -2.281977166612451, -1.941541172501188, -2.808898615239567, -2.35092782323091, -2.1698294929390656, -2.711677671091769, -2.740669879116389, -2.3124007274599427, -1.2243264543727417, 0.7176084642003617, -3.195491308985112, -2.499248297426924, -2.719604927453694, -3.355648236166266, -2.842977207819016, -2.7160769389425328, -3.5962749220501986, -2.5577416964542063, -2.282181132858559},
    {-2.4339902896242918, -1.8933021126120053, -0.20756746252424635, 1.936599298809386, 1.057240422616889, 0.2914909683879249, -1.5377828851114255, -1.7634223569942489, -2.0732072828863055, 0.6949369797198404, -2.3447621187195393, -2.485020245051014, -0.1931968757535159, -0.6208850762187433, -0.34351217091249103, -1.5220932152817817, -0.2811839652353886, -2.6721982584691144, -2.5538220203442483, -3.256938064855434, -0.789600080807208, -0.8088168727971675, 1.161461682478836, -1.766972797999719, -1.7791313347024482, -1.2304738826949617, -3.4743323343184187, -2.441575901176571, -1.18527132565948, -2.8086404476470235, -2.4979154942029447, -0.8114180399152814},
    {-2.471902049263435, -2.2348531227636896, -0.9337397316681203, 1.9382254627589226, 2.1639923334369557, -0.39935226965645193, -2.119755228233486, -2.27801991609835, -2.3157539634777833, 0.36304774950740876, -2.6822560318847697, -2.225840670327012, -1.1833623573185945, -1.0990135646530683, -0.9093544706853779, -2.2642896988017953, -1.2154648922582685, -1.5768997770499076, -2.1463156494150146, -2.485532291978728, -1.4282283093936494, -0.15152098476661774, 1.662274504040594, -2.3169623354191904, -1.7608515370132631, -1.9880011061349099, -3.1628464216933185, -2.2205313685179986, -1.4571972257483086, -3.1418350718016224, -2.30530340454333, -0.6943036976106653},
    {-2.9279601470926417, -2.614752167398476, -1.4327530368410037, 1.3714927556379868, 1.7951162534007146, -1.2286797181591085, -2.2737964395344874, -2.690823761306208, -2.8087679337605884, -0.04996758236245787, -2.6563789407445633, -2.7779708231036864, -1.3793381736735484, -1.519905384990185, -1.288466112762762, -2.517199072936744, -1.7306785822255861, -2.4506195899042544, -2.858723760460205, -3.160730050722096, -1.7130503257340315, -1.098993340874216, 1.089549904452959, -2.442962925720248, -2.072593745658037, -2.555594578865025, -3.587565049553738, -2.7123220010073275, -2.2679934550427654, -3.351688647577087, -2.707217806078419, -1.351494893497844},
    {-2.7674869906385573, -2.1938405871542415, -0.8589905215137063, 1.8447875912625469, 1.8160736513346196, -0.44105223291079726, -2.1691559192475323, -2.3214041995131462, -2.695295624156192, 0.5628938833653411, -2.8072578472282124, -2.5203117997406856, -0.5896903313331037, -0.9663456284265179, -0.6948489876413563, -2.257292936264824, -1.122164698582207, -2.4228593806066203, -2.7099743414240334, -3.0463395554923416, -1.3887156059700765, -0.8046166613650587, 1.677568125861139, -2.1718836798403944, -1.8603395393828697, -1.817614710253039, -3.4828010314003164, -2.58947774893213, -1.9189844764774515, -3.2903416732162047, -2.6770172587424166, -1.0986954452913953},
    {-2.1190790121544, -1.5726740883736916, -0.4774996016972167, 2.645813030514151, 2.627368499025724, -0.17274485658644242, -1.7921921487244374, -1.844557516904206, -2.3217433085224184, 1.0268546720553893, -2.1584462488683354, -2.518106752763935, -0.5124535413220611, -0.658815832097614, -0.4605001965251803, -1.6195362868639807, -0.8446056836096543, -2.043466375497977, -1.9646744764266388, -2.967557995190368, -1.0217115709950306, -0.2345801860470232, 2.1886086309868658, -2.2061786288456826, -1.267875822685505, -1.5104076975382366, -3.0927367225075857, -2.145475488426229, -1.2129719395826009, -2.947592956928732, -2.172995465625207, -0.08771685738102557},
    {-1.089822100579498, -1.4870921873352712, 2.0667649047452135, 1.5145787592791413, -2.2353126209312673, 1.2631472212016914, 1.6115486230504539, -1.8922020511952247, -1.323448320141467, 2.025738741519888, -0.9906748375060006, -1.7635626208807247, 2.1034124217655603, 1.8684670710949558, 1.5615831371412785, 1.9516989081003175, 1.0986899695991474, -1.0481485284269383, -1.8833507395339395, -0.9413045664267015, 1.774052408035775, -2.2319981091961707, 1.1769084257702638, 1.9743617686905564, -0.8349489849761338, 1.464236898290468, -0.07516498933060405, -1.4229507348698618, 1.7750705841751049, 0.9129924701865987, -1.691373785459767, -2.3780757162058164},
    {-1.5663278575852329, -1.4147698635420203, 2.3296923645894556, 2.3076810296517585, -1.612798583523755, 1.3715343710908523, 1.5322668298165676, -1.480497219923473, -1.3226264994071466, 2.533653851649106, -1.4799837771896105, -1.368606492983235, 2.115673537649936, 1.8167872850353879, 1.6655973419591918, 1.850476654349949, 0.8108874500711292, 0.1231780690749618, -1.5465484300035186, 0.01450105524986921, 1.7827989606570944, -2.468041077859248, 1.5510459393275917, 1.9068330362800459, -1.0418643866014987, 1.5144387219356246, -0.08909439460064947, -1.4739204778710862, 1.9634556582864284, 0.992899738327645, -1.357406859442982, -2.263690656963421},
    {-2.103826453499608, -1.9716891616732497, 2.896304424991065, 2.6758488145165433, -2.458938104761904, 2.0764232324748035, 2.1066914743503906, -2.1251908433901447, -1.7489132576199036, 3.1007870901350274, -1.9461568679254193, -1.9216243375809487, 2.047819160590226, 2.3479819228479566, 2.2101791007016396, 2.492357872583926, 1.2377607152439467, -0.5676295315344536, -2.465128694844252, -0.6535955706761102, 2.245474303994461, -2.893168334226029, 1.0602682177135592, 2.023707003605466, -1.5411213046180154, 2.015083443893085, -0.9436257567892924, -1.7629342517825812, 2.364045079204417, 1.2568164239623028, -1.9673495969506085, -2.55910932245878},
    {-1.8960624432453155, -1.8210299908728216, 2.6055236502144816, 2.573406858171963, -2.422230349140771, 1.8953841761210732, 2.187190771841767, -2.084601080442016, -1.7219678162140264, 3.074738302775339, -1.6508605048394844, -1.8845920494892834, 1.9843914181455613, 2.235246057606785, 2.528848895575152, 2.575581468198317, 1.404133212804709, -0.16067987927059937, -2.2794611077911284, 0.1687368302632598, 2.5275688121412783, -2.650121804500761, 1.0104075601010274, 2.448249745876707, -1.4244121281786588, 1.9211401505446315, -0.26677756366575966, -1.8943971447109913, 2.327152092626149, 1.2032137616622582, -1.9585177395517754, -2.5243514597429866},
    {-1.545370461801262, -2.0912552724248434, 2.4673435668910195, 2.300724663813579, -2.015044180764665, 2.070548484060964, 1.7334318011903016, -2.286858112985377, -1.0149881390967466, 2.7264825373030726, -1.405575034936024, -1.3937746497146744, 1.6396739232427648, 1.9045885117266774, 2.153598717763106, 1.9604689313012666, 1.6064806095142465, 0.3150159803357459, -2.1382701294911732, 0.2914778771616849, 2.274198813836532, -2.438180595052839, 0.8420442915878912, 2.0671515878239233, -1.630552402141025, 1.9534263834508763, -0.009066047198538187, -1.7779994743830876, 2.4206032702191203, 1.4166257106772615, -1.6373091888123632, -2.2667788182978583},
    {-1.7774998041214671, -2.147277393833617, 2.299189785425748, 2.243075303290958, -2.580417346722548, 2.2406324768872565, 1.7860536964432099, -2.3122306591978004, -1.2315927820765131, 2.7234069822169404, -1.6794375858790098, -1.8104884381281663, 1.8379033531131628, 1.887707519244248, 2.432695836158932, 1.8869762995010277, 1.769327196708404, 0.01125900711962398, -2.0993827370062954, -0.006460115088683997, 2.2512070548342296, -2.7149470380236704, 1.2226581270439727, 1.9760453814008418, -1.757551774685306, 2.03515329954918, -0.8645128539088363, -1.988047812862023, 2.3237308494570876, 0.9832722579152385, -2.2448161732702805, -2.2229301587714843},
    {-1.8831732813953173, -2.4511317904974903, 2.8184504707618707, 1.9233212972281735, -2.8797780480583026, 2.464923422986671, 1.9877736883847534, -2.6042563861640122, -1.5164988492105045, 2.797670547326718, -2.0174133696271177, -1.9915383960225281, 2.4063982168221107, 2.1970252909948513, 2.6546536127422464, 2.368203949426069, 1.7798827388684169, -0.47381312848511914, -2.3657663655236854, -0.39371095439306675, 2.521582093169238, -2.993185462147311, 1.219614226853849, 1.9659776620849276, -1.9303911259887978, 2.21465171911543, -0.9919751931020755, -1.847849353400005, 2.72068722413401, 1.1287356626303866, -2.4051478699276263, -2.4390092810605477},
    {-1.646431316565815, -2.2455274512521166, 2.7603907519856654, 1.994240426431972, -2.9518088687046276, 1.7960606413526439, 2.3301484454258525, -2.3359858771354656, -1.5437444347499485, 2.651320786285138, -1.7100734692081618, -1.9229840536633864, 2.087353012692697, 2.342857838977929, 2.451067587468479, 2.3841669725428547, 1.8810691766480363, -0.6327763215678179, -2.2117148330723215, -0.06674386817594448, 2.7976206333405966, -2.839714549248937, 1.53124264054297, 2.6229739120135274, -2.031967320815672, 2.2245289996189657, -0.5017753321819117, -1.907895159559438, 2.8591539094295864, 1.9193233921387303, -2.071354668187029, -2.623896869717436},
    {-1.7812965881406082, -2.57467564722211, 3.0325633745950262, 2.186635960364554, -3.019151366339651, 2.0572184748512843, 2.4876138166400774, -2.735744070172582, -1.9165848753208177, 2.828129185966924, -1.9796165120020706, -2.1831310045918983, 2.2048541990288912, 2.6366036114401705, 2.731835724372038, 2.831562159556937, 1.7744132163830553, -0.7821742053863001, -2.227804448678192, -0.4754754509790223, 2.972691768505117, -3.123147928121419, 1.3408390291820225, 2.238204399959214, -2.1110911629764617, 2.3798460156512067, -0.3495137978522807, -2.038631787268012, 2.9794958358065666, 1.6114961255470175, -2.3468237022657843, -2.6605590197494062},
    {-2.1067398270174764, -2.53673231729783, 3.135562932129976, 2.811918842521663, -2.543908504175796, 2.185045711816866, 2.1790012745606586, -2.453134605222729, -1.9333214216369445, 3.256384810448488, -1.841266283354391, -2.0819551932493727, 2.615062160279912, 2.6650135772402916, 2.3864958357658845, 2.794793741482493, 2.078977906952617, -0.18674135906446523, -2.5090100012615846, -0.7296607878293198, 2.8090877639409673, -3.2604184626274506, 1.670721345739235, 2.4992988236928166, -1.7546080952909537, 2.4738515363021882, -0.2965227491103257, -1.9317156250997496, 2.8361873224861673, 1.5682614921789144, -2.2064280210318756, -2.7316722684009926},
    {-1.816167443754617, -1.8808379736315304, 2.65406501205978, 2.50240493423517, -2.441263600668208, 2.175677623984633, 2.1106694799520445, -2.4868232572577624, -1.617538354643063, 2.75681497972279, -1.7727792916739384, -2.0491516583380958, 2.1699813177623337, 2.2173125184557385, 2.176693197407662, 2.272715097102751, 1.4906366890210798, -0.19869712664921205, -2.2536291837284876, -0.544176536549774, 2.8218065203160356, -3.0505662325152367, 1.7368946837403132, 2.1037390704039334, -1.2766415204252337, 2.035142966918452, -0.6595940286079373, -1.7618527935690458, 2.4570253673955893, 1.190607268994361, -2.1817717552628557, -2.268875286351478},
    {-2.0352144576672386, -2.1933352724562156, 2.8586747331892237, 2.679115457362694, -2.7000220476143237, 2.3780569631115407, 2.1893012135893404, -2.7176882111418474, -1.6945860614374288, 3.0887068965514017, -1.9873467679873562, -2.24661382894773, 2.2777817689808106, 2.635184260727112, 2.677085779240109, 2.5251896642801297, 1.9510812506858504, -0.10145860719283051, -2.1635233257127258, -0.2898420797812729, 2.7250152634058975, -3.2807521108543654, 1.878208373997122, 2.5396090455142364, -1.551334197955328, 2.3333583650427285, -0.460036466667383, -2.2505603061996093, 2.8917720790110106, 1.2807003056483346, -2.1109482978427905, -2.642874020103024},
    {-2.210552071488473, -2.1424409443343757, 2.8957810595269518, 2.759942451368398, -2.974402265964261, 2.080198827980869, 2.687652573172808, -2.5496989228024156, -2.040899855009978, 3.2015302927868445, -1.7313968338380088, -2.184463287119752, 2.280166792333904, 2.6236301094373293, 2.4833135727473326, 2.9219402348724874, 2.107041990301242, -0.27214979461015376, -2.573724942140022, -0.5367741302486285, 2.9012784170922403, -3.156365344421874, 1.630217518179772, 2.3733042140177187, -1.75971718819336, 2.710338457491786, -0.48535386890138016, -1.9850116952157573, 2.8320000336053206, 1.6755103047354727, -2.2647968043496776, -3.0915378208079014},
    {-1.6453554269873956, -1.9334824438020435, 3.0644460228184247, 2.6691794107721662, -2.599562334305375, 1.886364605907431, 2.432080983580098, -2.222948083659156, -1.789846193633254, 3.0029598843357, -1.704399526153288, -2.306456449067171, 2.1370451238422015, 2.834110402478205, 2.574080917756675, 2.835758293520355, 2.1472994741664593, -0.45165124087323777, -2.0029007913801644, -0.4741097523484961, 2.630251582398041, -2.9174096157869918, 1.7264052522426712, 2.1103465843544664, -1.918528430206398, 2.695788662662229, -0.3850802439966656, -1.7807705754125744, 2.9144585113949715, 1.610590834079444, -1.8941117872974067, -2.9463588082562517},
    {-1.80460969248669, -2.1661241822247477, 2.74109085009039, 2.174774953276404, -2.7074881812825122, 1.8171503106776832, 2.348263147857824, -2.582538686336983, -1.6428534833649682, 2.7409472600398366, -2.1138443781906413, -2.234847192568226, 2.285597212456123, 2.8009929402376184, 2.5685819794318556, 2.51285506550506, 1.6204187630824631, -1.121220711483522, -2.37884754755447, -0.7468768881441601, 2.900885763899356, -2.653500560846003, 1.5009956170154892, 2.045937263965577, -2.0395597109284402, 2.6617415704955567, -1.0177820499907075, -2.2574015602293103, 2.9461392805563, 1.2066049150580027, -2.0338297912725434, -2.498997379515217},
    {-2.023424644881242, -2.537695179072866, 3.0261784470760977, 2.56572210036988, -2.657600793635312, 2.2446718023006174, 2.1912750303369295, -2.576354842467218, -2.113409984142078, 3.049703919396754, -2.406843332943705, -2.290175171532746, 2.544673194627326, 2.7665745600381366, 2.2901009957586718, 2.4843175242343785, 1.301398564194281, -0.9806862824296316, -2.319147990376362, -0.7156986143142983, 2.39727996237059, -3.2892755175006707, 1.5728804877581959, 2.04037434577599, -2.438167241178227, 2.258367388897662, -1.3191149368780837, -2.2790887970833666, 2.613872266545598, 1.0932850865551742, -2.41826578212174, -2.662680431874205},
    {-2.4784818400606787, -2.388659566077546, 3.0955879993487945, 2.8273041451529077, -2.2682441763163137, 2.132449458572436, 2.295457712241764, -2.626213279374592, -1.964091546260798, 3.2347331268402, -2.2737930510479147, -2.3666689685092703, 2.4120132110516064, 2.6118855551806814, 2.4296704794650457, 2.477281883190586, 1.6024851342030304, -0.986533842404244, -2.544099643733649, -0.24779665248366026, 2.705783250991584, -3.357249036941637, 1.9985239271520954, 2.2942836993566806, -1.9611714417947939, 2.205400890343447, -0.7397663877538074, -2.3233210005059637, 2.3727520618097557, 1.448142200467971, -2.5816499299966122, -2.592342534358045},
    {-2.428925318703745, -2.481572124211707, 2.8162502389477972, 2.731150639049617, -2.3970385359006516, 2.157282681410942, 2.0451067116804746, -2.512034969918978, -2.1857651851582323, 3.0085958705274627, -2.2381533019497435, -2.726511226737052, 2.3502253053348103, 2.3606086336188765, 2.807259461149014, 2.6172651645791105, 1.4767608365613667, -1.4657030904825379, -2.881012077453382, -0.8593861453716458, 2.5960882380671273, -3.5389136661972427, 1.8574013583697448, 2.5439044932809654, -2.118713578573634, 2.4280767102934937, -1.0497273083628191, -2.331253304209878, 2.453882003678183, 1.40836704501198, -2.2531664673267553, -2.921441462107134},
    {-2.2082935793443403, -2.2989413158209255, 3.171977969802167, 2.5946803164264245, -2.645555891594915, 2.190683676929552, 2.425224148223511, -2.3153166545708266, -2.164911920244251, 2.8065191821615096, -2.068216309806019, -2.5790790472092144, 2.3639021284658446, 2.6473365716344217, 2.7394850529090666, 2.4877331728842953, 1.6988248411871207, -0.8541690635452266, -2.384626843371141, -0.3183157217210969, 2.902236866110875, -3.29240594082069, 1.5492353857074046, 2.410887194601916, -1.7664409779666495, 2.506848152325653, -0.7826570990102661, -2.326590604778486, 2.5948144562598463, 1.6063960977221445, -1.933030192625686, -2.6963672910969567},
    {-1.7517764400940612, -1.9008504724618123, 3.3930004843763566, 2.970941238960216, -2.512735600195805, 2.4345248237144, 2.7273591265685297, -2.463178459902438, -1.9485588390048096, 2.96538675069425, -1.8135409423753122, -2.453311742990281, 2.6527384274273764, 3.0793591744139355, 2.7748636358421566, 2.9715167940528917, 1.8109051173263202, -0.457403322828229, -2.214542845700496, -0.12602303563875825, 3.0066294707236407, -3.0817511994506424, 2.04376056129813, 2.4947574820907135, -1.8398293691222005, 2.772279022876755, -0.3971229902456753, -1.8458972835212093, 3.0663048268539383, 1.9259408723072033, -2.1502180520525696, -2.928711894537871},
    {-1.868405868687131, -2.1465513421830518, 2.9072382391125373, 2.5506298651747272, -2.8321563047025102, 2.63992655223276, 2.425307938489713, -2.2720172317282694, -2.136108531542645, 2.8311157839969456, -2.1418151775171514, -2.6012407180852324, 2.5197844421153155, 2.7833830846924825, 2.4648725111409795, 2.7417053282638078, 1.657997509957178, -1.240598475926309, -2.4461204558481433, -0.3149346558994021, 2.9214342557341704, -3.134572584571732, 1.7790203542049905, 2.6436433311471528, -1.6285709496697667, 2.666363419409165, -0.6443019060604177, -2.251167394544338, 3.009004641251999, 1.7625314174526827, -2.2299536403373814, -2.854464429146803},
    {-2.215868432646528, -2.438773481363495, 3.4799021717684075, 3.1190926179637963, -2.346364646665612, 2.5890809098846264, 2.3825595917427362, -2.420234584549009, -2.3490488094257373, 3.22647210548275, -2.200428614466301, -2.7150664680104017, 2.7580027664359474, 2.7442947862161815, 2.7904270463796808, 3.1234811099037767, 1.7538816028233475, -0.9651811515313041, -2.4002074730051386, 0.1714405164506512, 2.845082804743004, -3.0325484986666282, 2.1153968273826824, 2.673342506271968, -1.9278015312577668, 2.7956126817603795, -1.0332977929733214, -2.12548415929219, 3.0570731951589845, 1.8481297887875654, -2.1338153830968856, -2.5913902828798676},
    {-2.156525112457288, -2.493169220714492, 3.220290678771345, 2.6587435941839357, -2.8061919964195203, 2.5434040397498863, 2.6273919931748178, -2.664054588177861, -1.8549821737644823, 2.9358540937272357, -2.5005729182743233, -2.6244911867436, 2.9053139704840647, 2.841411669257688, 2.7688898224530116, 2.949100552528264, 1.8305902412449666, -1.5653466062530645, -2.755720206394675, -0.5227238388044968, 2.978693806541408, -3.1027511959931613, 1.895244098879933, 2.6480990882264956, -1.6017446621241784, 2.862932794513307, -1.1750153796424785, -2.2264545255719774, 2.9835968500539702, 1.9616611436666553, -2.236758626977143, -2.5678180678448514},
    {-2.2914726587517236, -2.4089511587830397, 3.263579813516362, 2.866609881910084, -3.264426430986991, 2.304887812624177, 2.5896117611047638, -2.9471313754607538, -2.480778437780748, 3.072974871176549, -2.5413256172048473, -2.9091329774477206, 2.6695632461423924, 2.9695180949759883, 2.6417014966202177, 2.8651666118289887, 1.824469962986697, -1.3274753119405827, -3.04553935060346, -0.7348106446249616, 2.993501176377886, -3.5375997760383617, 1.8878999570527801, 2.617673905001845, -2.3094508698268927, 2.9122756805799317, -1.0613976229924063, -2.476071277233128, 2.807387573695133, 1.6518089317129532, -2.7116534044416167, -3.1622928748159165},
    {-2.26485803160308, -2.31972470464041, 3.32025279913343, 2.998975148098834, -3.0403181618978046, 2.2923036469312112, 2.413367010908805, -2.8162899534391674, -1.9938120962749868, 3.49512858348167, -2.231549458654518, -2.4979741279331718, 2.582625492173689, 3.1614458841280655, 2.711199619332492, 3.0405555735306136, 1.7705275731647008, -0.8235733569071415, -2.5126480175170642, -0.24522369740509692, 2.8494481785828376, -3.1667884256196084, 2.066307501564698, 2.6826788734080163, -2.446796548156191, 2.835086305238567, -1.0359718807957443, -2.2997425777730025, 2.700342605406209, 1.5734293857638315, -2.232247021116389, -3.2520769960074984},
    {-2.4452731140313393, -2.7577339983565237, 3.2493644081346744, 2.9400363553896542, -3.1020945282355212, 2.428123296733188, 2.6880207437684986, -2.945558302650063, -2.2472004218805313, 3.4889634671239227, -2.7038062213561562, -2.835587172686246, 2.9050535516611977, 3.0726842371057566, 2.9346161775787416, 2.911599971726174, 1.6837306641924383, -1.1912903265639871, -2.79728900826209, -0.5730646667866247, 3.0190777389619616, -3.3772888251298996, 1.6776419600016017, 2.9892640703428244, -2.3571406325302915, 2.7047028005358404, -1.3991584597240194, -2.5474402381905876, 3.160650652292535, 1.7983972931595549, -2.490840305978889, -3.1258680234352947},
    {-2.41273807169368, -2.8415856888239537, 3.3966414304599644, 3.0094442538565525, -3.045435288593964, 2.297040293589463, 2.7061657243628514, -3.0563308773830355, -2.5366288223502935, 3.2504651859864726, -2.672010988465855, -2.7845409882183874, 2.9648178214768834, 2.9236432064699303, 2.765060306682121, 3.158161745265133, 1.7999139961308608, -1.2541947025515665, -3.1482404254703833, -0.7109500793672753, 2.912737367550343, -3.505732546667265, 1.6073340856831526, 2.5875355131506184, -2.377210301675726, 2.7578196082021456, -1.2041882616491584, -2.7101783310348, 3.2555553688098855, 2.0547282456170417, -2.46265072822394, -2.931645082411198},
    {-2.390020028552927, -2.5992336738693194, 3.5358024025355, 2.821068125267542, -2.6894132478801027, 2.6404415728232915, 2.684273881919436, -2.806452673429113, -2.348935419165208, 3.255434738512713, -2.295559424423258, -2.7467992328082773, 2.9382022266438157, 3.184025254097095, 2.9867618495856036, 2.8003733289555597, 2.106254979929666, -1.6244508040541714, -2.6251433621968854, -1.0160757574513628, 3.003606494093096, -3.1330581134995112, 1.5603414160073492, 2.888146261580544, -2.2589359038322403, 2.8940170886629515, -1.496884087106703, -2.3274249442644432, 3.0827378766682427, 1.6430187828367702, -2.4821292129937524, -2.6911655883567693},
    {-2.687556092379762, -2.8136034540668136, 3.3987841077417054, 2.8040837024653884, -2.40967599093375, 2.274992569017341, 2.524934124016555, -3.0893958122142418, -2.5291679110317156, 3.338910053928439, -2.4412026219118323, -2.8574898109957547, 2.920360109598838, 3.1909060357487267, 2.686688622448828, 3.2193824224578336, 1.800760145115945, -1.7209389151849446, -3.149499974516245, -0.8322034120657767, 3.01896283013088, -3.260136936935406, 1.5079876922091697, 2.8388716185793847, -2.3894385290255844, 2.6454559785545495, -1.8909258643756428, -2.688957679090087, 2.8699246708458657, 1.6080375658232218, -2.6305949803314315, -2.956752569181496},
    {-2.6207674314192846, -2.7872253287054485, 3.399912293436586, 2.9830309048004957, -2.4978137496133477, 2.411898286284162, 2.3633607111137733, -2.7982129180925623, -2.736683549615152, 3.0511252811008087, -2.4043599746511783, -2.9601482030296307, 2.5249161359728256, 2.8339011735860966, 2.752085714992606, 2.9821788694843243, 1.5597495743723704, -1.6040433149794087, -3.143910352981821, -1.0322525157998481, 2.8069486220186484, -3.277050347313796, 1.8083067843598761, 2.820092745589146, -2.3452119648679273, 2.6022375229606665, -1.5698224732505086, -2.7285574334653933, 3.05934948278717, 1.8222654360174093, -2.7953683710074855, -2.8939567590777746},
    {-0.43095054971047714, 0.3853134421148515, 0.9196728645206576, -1.0288968384924173, -0.22722607376678278, 0.8565876227606092, 0.4987870288190853, -0.04571991905240051, 0.5135160128311188, 0.8605821698635182, -0.2783196675958801, -0.93821727020256, 1.0526517170539567, 1.1496782227799085, 0.6007580402035744, 0.09762261618748358, 1.5826383852951051, -2.748909353397302, -0.6582535900748149, -2.917965403971418, 0.4896331527946476, -0.431319254767598, -2.6392975761658057, 0.22536845782798312, 0.8999779450253618, 0.45087748870318667, -2.2286596946856583, 0.07679370921157556, 0.26698992522408727, 0.03738667998266881, 0.051376137652062344, 0.0876480667414204},
    {-0.8835906764026945, -0.20933899975467946, 0.09277059988143985, 1.2259835995968669, 0.31167106490721447, 0.28052382551908683, -0.16941848782920665, -0.3402083310543309, -1.017606868035014, 0.026446350848309645, -0.6417312040530598, -0.5886178780859657, 0.30728942783843766, -0.19191551703207319, -0.09307844881181929, -0.19331439653224328, 0.5091966739869999, 0.21442101653206835, -0.6733052839275355, 0.40978885111372526, 0.42328898296444256, 0.17552366024741897, 1.0001917353903127, -0.6120464001047234, -0.8446997039218807, -0.05064335682239244, -0.45480917422862266, -0.9614605707133289, -0.06321580432041957, -0.014684020171101651, -0.9341321096860543, -0.14394312999963912},
    {-1.435545787913454, -1.036254500996604, -1.3132270862278916, -0.005469033914862771, 0.6710373401462526, -0.38129457992530646, -1.4153399576283887, -0.9400905157760868, -1.3786353652725478, -0.5974044774009087, -1.26500372664766, -1.6808868421742091, -0.7714400665002861, -0.9658710005969652, -1.2129241625751326, -1.6344911675730185, -0.877478043569693, -2.4931292354870487, -1.6257936720369306, -2.2501973874643935, -1.1133051684377209, -0.7585518006956093, -0.6666525006488323, -2.336233390724483, -0.7343519949275154, -1.6318293167166245, -2.4006290428006523, -1.0787148190167255, -1.4910134777698758, -1.9728317061622491, -1.5780351462900497, -1.143915915298491},
    {-1.211079255779244, -0.3154956619740502, -0.8006802446910929, -0.21339689298978168, -0.11354469238190774, -0.11076147478044682, -1.0353834218953597, -0.6148450557083451, -0.8477996075623818, 0.22307833259698495, -0.7797333358175585, -1.4390315515170633, 0.06964043647537067, -0.4287407283010604, -0.9871870035385562, -1.250560755489978, -0.8233353556577245, -2.208016748542073, -1.3140700749697247, -2.3565396891157206, -0.6359913824226766, -0.7377852245498665, -1.052847116010816, -1.3367665746201514, -0.6309961328826251, -1.0660256504638723, -2.004009913420153, -1.2138482696236117, -0.8527833209792274, -1.6087728792314233, -1.0845798520030134, -1.5006099911867203},
    {-1.8740098989834122, -1.2126582317649062, -0.6255870060912418, 1.4753592978767778, 1.145792931617197, -0.4891589799163682, -1.554686944895287, -1.5917710318522857, -1.9461451560926193, 0.32671457835165835, -1.778351999699112, -1.4659709483747259, -0.6008148133604364, -1.0147565032243953, -1.1286183473269567, -1.4083570106308525, -1.311076042000715, -0.14043143517774354, -1.8418196069620238, -0.8318427512097316, -0.8149133020384242, 0.08814531911243527, 1.6748684729969834, -2.0695211941579106, -1.7263164052518596, -1.4862083841377731, -1.6093279386382269, -2.091836509176739, -1.2093922418149685, -2.3784284943734453, -1.8062401182071273, -1.3567448497487928},
    {-1.8941898830656072, -1.3950621446687324, -0.9335036320637596, 0.7699547182545212, 0.09129992493428571, -0.4665905820868525, -1.2977794660711321, -1.5669364625797966, -1.726009819265041, -0.022399047212729478, -1.5452643078754067, -1.1499982402873192, -0.552086175929066, -1.105219482465523, -1.0445002788552002, -1.348197783178052, -1.1942007461668236, 0.01347024001710613, -1.3956030428627626, -0.615009036685805, -0.7614489937289391, -0.22212081912498657, 0.8709536925758491, -1.7803700616579294, -1.3041995064317908, -1.4253773444416171, -1.0198510188184995, -1.8254320666246229, -1.0001076643997178, -1.849491416527654, -1.7630553538572837, -1.3168683627889843},
    {-1.768703037300334, -1.5380503453358036, -1.1207588210171628, -0.049762056470878974, 0.13479621879619216, -1.359839330068935, -1.6856922680167647, -1.7099552965911304, -1.9730188532777782, -0.5333591844802559, -1.7485136373685817, -1.5975253717891873, -1.5058063176108751, -1.238064985728279, -1.8619510306467248, -1.933936026871696, -1.6746343749540233, -0.6165722698144637, -2.1175709917009558, -1.272148126007732, -1.2336857843352047, -0.6074969095739299, 0.05328804586138601, -1.9308618549505614, -1.5850663638051519, -1.5985362061629518, -1.6632573872482068, -2.1249605852079627, -1.4606056477919374, -2.0545962256912547, -1.613129396411947, -1.4114552215779155},
    {-1.098647229313612, -0.8058042765378574, -0.7538558049881308, 0.16152971690839044, 0.3696314419862421, -0.6092766556545982, -1.0617517513082873, -1.1339646386979407, -1.2980948560388805, -0.6314129383567122, -1.2040491242191835, -1.1503124700405882, -0.7895355480694363, -1.017489177876166, -1.7057676458983215, -1.1481199013102554, -1.0935104013910244, 0.1334759715186161, -1.119009904684832, -0.07657270928188055, -0.8814998352171397, 0.06336322044775858, 0.23064429240787054, -1.0669633093730797, -1.374621812440555, -0.9984278762622779, -1.010284738332976, -1.5395487937324845, -0.9446064049098462, -1.5896002924337056, -1.2018909792917591, -1.1710544441881725},
    {-1.7503595255405662, -1.5977482444022806, -1.1449793168540572, 0.3682192347507547, 0.4652596637527895, -0.8849975904014276, -1.7767356501361458, -1.7308720425123802, -1.9394138579102482, -0.44861608339832376, -1.6976402321841366, -1.105093244991146, -1.2082799064098777, -1.1143736813100962, -2.0891351681804404, -1.8713062528548583, -1.9728439795216428, -0.4357409026115891, -1.61468467555498, -0.8092904719511935, -1.757659290780482, -0.5554043264506824, 0.049645376660549995, -1.4936820929968897, -1.7424124605763587, -1.6802395716967442, -1.433285252910286, -1.6286832798120363, -1.9161733356437496, -2.3381011666166356, -1.5326614289362586, -2.0821522382500257},
    {-1.9852042393019995, -1.56832991782569, -0.9414429180480957, 1.1551703637176516, 1.482673083410086, -1.1879129181327523, -2.136972549464607, -1.618385543054217, -1.789402068441821, 0.19754546091114566, -1.4166518076775345, -1.5435369260806528, -0.8841477666410057, -1.304377902935829, -1.5941883481610064, -2.1519902988835686, -1.8290218969069645, -1.0652825602190836, -1.1897622018528, -1.5046464779909476, -1.3863259758353292, -0.3596631442187744, 0.3557253547181344, -1.8218744613581122, -1.2655244303537243, -1.8835851544023396, -1.917898370228845, -1.3056425425377833, -1.7333917549171562, -2.4823127185370533, -1.737189515174337, -1.113555012582592},
    {-1.5391071533792304, -1.2566952795259643, -0.7754976275743569, -0.19338277710348326, 0.3307620647737253, -0.885361737411889, -1.0854219009353923, -0.6718226416719937, -1.135096881190652, -0.16830716195810658, -0.8440503125341751, -1.4035744809902126, -0.9005297759838227, -1.185353172631308, -1.090103541868795, -1.4690306572658367, -1.0221362507370262, -1.6844050724887658, -1.4199142502915354, -1.921174408150947, -0.8641898283171903, -0.41237793938318607, -0.7259149288529361, -1.1669503013024667, -1.2340019247298921, -1.20188349160148, -1.69747606803003, -1.1667141838642774, -1.0221740191775741, -1.3326473696155772, -1.2969562838816826, -1.4609110157144474},
    {-1.8305342569582057, -1.3637649579143991, -1.238513061198262, 0.5360387344161452, 0.5143301807881607, -0.5930106217254641, -1.6187749613296754, -1.6445648387964333, -1.686729136173295, -0.18876367317450182, -1.6100722881136982, -1.9258789212997878, -0.9784007264809926, -0.994067056718355, -1.1891182726594498, -1.7137791777699851, -1.5636491175745473, -1.321342083265815, -2.0369333195617965, -1.9868236544408764, -1.0161744652043598, -0.8773428789271914, -0.18924696091192392, -1.758052369994715, -1.4147083650950094, -1.53910130957081, -1.9873360743825306, -1.6431418014205041, -1.2681334886581093, -1.9440010542097035, -1.7102354540660665, -1.6116914087640173},
    {-1.4515294477508969, -1.3492709173185804, -1.3804048465925556, -0.07442285571580272, 0.5629460615299381, -0.9054178204612112, -1.5210957330659312, -1.757523510803988, -1.6823421050289113, -0.2869112458589284, -1.3059242038412926, -1.9383579353398235, -1.1891032485146618, -1.1763141874562166, -1.4437695243700384, -1.7355190606963782, -1.4840503717209632, -1.3335347595854636, -1.616068909826803, -1.824411553036415, -1.3233804321965756, -0.7279127795244541, -0.24400943688257948, -1.5269286600669156, -1.5457239203081146, -1.776102497499396, -2.2544378039765514, -1.5745277779701483, -1.0328987748176262, -1.932514121687799, -1.6241705783363805, -1.2852606154051904},
    {-1.831856341926218, -1.4665417322176415, -0.9774367611379038, 0.3896726797212703, 1.2640218790273083, -0.7515018795271027, -1.7550508704933194, -1.4561742070451253, -1.8971294687559566, -0.4515781451951901, -1.7264737493672415, -1.7387395025003294, -1.1218422773592258, -0.9302799241703422, -0.833573020785008, -1.6980794261847056, -1.0802297527798834, -1.3206729952622651, -1.4569259835074895, -1.479932397095074, -0.9672804454759171, -0.5294110028394386, 0.2012264791335814, -1.9579131917593968, -1.5868524016642869, -1.2323366210167312, -2.05655323812757, -1.385693806230976, -0.9461178047244617, -2.3985796074048675, -1.3250015454771948, -1.0308916429655521},
    {-1.732239738715311, -1.0502563908848026, -0.766842301246541, 1.5102325263731708, 1.401812576078956, -0.20557530120331466, -1.702490744400716, -1.2025147179880975, -1.642438424128368, 0.08969851747365885, -1.479176734780687, -1.3283966723027414, -0.6136225749081425, -0.4496151320818342, -0.9977375859262605, -1.7444078545466397, -0.8605958414532615, -1.054119963350397, -1.5516062062472544, -1.4975102741418957, -1.0547417490196573, 0.2951723072358901, 1.195209808202125, -1.937772708972164, -1.124273424511157, -1.6799473050825218, -2.7078550129391954, -1.261908382275084, -1.4178321714666071, -2.7769011934905663, -1.2814872695856374, -0.44433979300698695},
    {-1.7269568730028266, -1.3873949269052102, -0.6798487402722726, 1.2095729204590335, 1.1989736677738168, -0.4386999552025847, -1.30097071126524, -1.3140936381456907, -1.9768571132946662, -0.1281854592584623, -1.9512826755079151, -1.7220077769673887, -0.35100292006972805, -0.6299799423187605, -0.8957579625488437, -1.047600644091513, -0.8044743306338767, -1.6346503227985512, -1.8023733657847496, -2.6022713185502644, -0.6587833265115522, -0.5014876115833382, 0.7214824103643405, -1.1681005494235521, -1.014376784805562, -0.7772752875354523, -2.5500396557720992, -1.6429693330542916, -0.7810012888611632, -2.3818499108806006, -1.4163650732323918, -0.8605172720482069},
    {-1.3266184318470422, -0.6791362897787199, -1.2247038142723785, 0.8140988105877056, 1.3796612495505838, -0.620077073077715, -1.4012069943862027, -0.8046192625617569, -1.2445862715098808, -0.10300457866129409, -0.9998237922316481, -1.5913128189541117, -0.7725014478214673, -0.6616714293877929, -1.2723072502085717, -0.9811572596594927, -0.7434170399784784, -1.631527463782343, -1.2544618237040037, -2.424246074250149, -0.5797393694232525, -0.37686309700264714, 0.16192067795875392, -1.2961724654931364, -0.5587947554954723, -0.6295458140384765, -2.0973376914606336, -0.9999621169568665, -1.3701744428145832, -2.2620467013718364, -1.032952349051029, -0.224548825321997},
    {-1.8694344881050393, -1.0121381264286338, -0.26285208995336123, 1.786840905574897, 1.6251284822571932, 0.5935037221170625, -1.4176604398654697, -1.0882177347402813, -1.5953954278962141, 0.6162808662537159, -1.8446398752091797, -2.0313890715222076, 0.17569051397198507, -0.13439350790471835, -0.06432854754712079, -0.9213654493858919, 0.19033525882739655, -1.9269970373505054, -1.9673647765240203, -2.220294866276972, -0.2834250745243815, -0.21209493169937282, 0.9440613536813259, -1.5647611420379943, -0.5806354722565399, -0.5835025817734146, -2.8967326626143715, -1.4374665559523483, -0.7628301384122528, -2.654705707620819, -1.8008631986640777, -0.4492310524609208},
    {-1.945965284995827, -1.1261094128620872, -0.2928113179544346, 1.0677201035374002, 0.937248873310569, 0.09758966089615634, -1.1339572351599352, -1.2448867322520267, -1.8215802746320693, 0.6403116846095914, -1.8761817225325859, -1.9172031044507891, -0.17003743996915133, -0.17587356026945955, -0.4199255294654459, -0.766568406665847, 0.02804914881071119, -2.352385121276607, -1.694502527628016, -2.2726318152504152, -0.8380627479447826, -0.7558925192223146, 0.19310783299973547, -1.4506736393382247, -0.8366985522390805, -0.7799092067241865, -3.070452926169089, -1.784201693921239, -0.8278717138679323, -2.6196152169922424, -1.7826229041403983, -0.40826311884735295},
    {-2.019574355184339, -2.0403889578932843, -0.8573525739590722, 0.6128796703666268, 0.7547510130844787, -0.545811093513004, -1.886523617193163, -2.081921000990902, -2.3762199703563334, 0.06454727494966306, -2.1908782991092304, -1.9943350605758006, -0.6629247008029945, -0.7609388848922707, -0.9302606160484098, -1.8851348587625543, -0.8681965126456737, -2.5503378924534292, -2.0326832383620057, -2.5932401235809794, -0.9254818444522823, -0.7165090171267814, -0.058883340368502526, -1.8787073358706126, -1.3495892493421184, -1.531070005578252, -2.9205639758794555, -1.9271713531458492, -1.4186221680019815, -2.6343960119066874, -2.0811589402218402, -1.4027747640746773},
    {-2.494559388215652, -1.8263826641607324, -0.8676852776883739, 0.9101679056008002, 1.1728202677787365, -0.201666532171845, -1.598492807934039, -1.8432656299889207, -2.0130685931338688, 0.22037045027070376, -2.2576150894070603, -2.654134229818945, -0.5165377568361156, -0.4427505783101632, -0.6679947611885515, -1.8644891684245546, -0.2790404586600356, -3.048273850028252, -2.1123721490002603, -3.0532666556825623, -0.8817466577549823, -0.44068426433034863, 0.298598930132378, -2.299352671801648, -0.986284548207071, -1.0011955435898123, -3.321536702285287, -1.839779894102596, -1.3622155375686416, -2.9864495540212106, -2.1707581805364393, -0.8607869967065946},
    {-1.9846998299853935, -0.7026449096180571, 0.7572668351050962, 2.4963371426136214, 2.65170166544327, 1.297427537490616, -1.0305249755181478, -0.7300234267300524, -1.554289838654538, 1.785435351697457, -1.6830341160610387, -2.178700348426763, 1.2095658238723628, 0.8988678152935764, 0.940725642685855, -0.8848893910013477, 1.01400767671389, -2.9151722492636654, -1.7691450624501373, -3.3703435328163147, 0.25665028233019893, 0.31396521807395605, 1.8397033885635297, -1.5873535863737582, -0.11025283317102183, 0.07355610954776516, -3.81144244004761, -1.3684437992766267, -0.03987945770804339, -2.878611524537854, -1.9614500300680258, 0.7186206000305455},
    {-1.085693802844806, 0.21870531830884496, 1.537616330386315, 2.7868871441184266, 2.647901195169326, 2.0267819157240408, 0.052467115361612034, 0.24959038227122482, -0.7324243843849775, 2.5321471877644903, -0.8528652780168028, -1.3748024406475328, 1.8479932719294687, 1.4608731612637957, 1.8409881445135414, 0.4474477450101103, 2.1524115564901027, -3.6410916944643543, -0.8726002128285545, -3.9489297175092077, 1.297784200475183, 0.8449523424270364, 2.009508432848253, -0.7094966753749486, 0.674314173583108, 1.0790961179704124, -3.6521640851776245, -0.7113770524365108, 1.0212040441041268, -2.219604407830732, -0.7660851295535586, 1.5422073375777166},
    {-1.7413090906816946, -0.5973375768609359, 0.10398020451956778, 1.6805137698612778, 2.1738820423890832, 1.4387528917819479, -1.2109191489832654, -0.6771658556170965, -1.0754895299978775, 1.572382488715549, -1.3651761756371308, -1.9527513285794433, 1.1384384572702682, 0.5501987124503519, 0.6139464692103923, -0.8840600159593353, 1.166901650579662, -3.563743549294775, -1.485265612376137, -3.7787834856092126, 0.30350958730769184, 0.08084759836731695, 1.1494703445943637, -1.7209247607002465, -0.0004710143627974061, -0.05578112804194289, -3.8510937591190397, -1.138451702979398, -0.5598298910709567, -2.775889219901013, -1.451544304902967, 0.613748254303442},
    {-2.6051302561686476, -1.5495420953266632, -0.7110287486061624, 1.1515457411264571, 1.3703765128702179, 0.0707420695313218, -1.6558287389672366, -1.7490182207766685, -1.9050717571825986, 0.568396522819564, -2.2946146236223965, -2.3466884679799906, 0.03186095193553763, -0.7291504145175006, -0.11854469621370803, -1.593244227368943, -0.42860468722911027, -3.3630825736018153, -2.0076420631670344, -3.427895591181619, -0.758611822025231, -0.7848288433253818, 0.5054072492068687, -2.330007643659986, -1.4655352397612496, -1.3311842347647684, -3.4350522902869236, -2.0788119549880255, -1.2404664400230556, -3.127571062718427, -1.9324925395600068, -0.9915685542577712},
    {-2.2603201742895833, -0.9772202022920221, 0.8120970207031233, 1.9177932516524, 1.5747788448859477, 1.4365345836228738, -0.8858516551565755, -1.1695221691785183, -1.3389774641945624, 1.8111946310680793, -1.982863277608839, -2.118194657061656, 1.2138789520704623, 0.7339576295941823, 0.6706162556698666, -0.7248047576030875, 1.2400739916925687, -3.983464916928074, -1.948512603851371, -3.984949116143118, 0.14702249921604962, -0.1565329815203246, 0.7968847998795956, -1.3288858066642917, -0.5072382004813728, 6.782344942304678e-05, -3.6080995645244096, -1.5541718304199064, 0.1584841894041071, -2.5359487743043596, -1.7070657164988394, 0.053807980220815295},
    {-2.253903838225208, -1.032258543200406, -0.045498628313606945, 1.7870541761545367, 2.2125832949516586, 0.8745626747802704, -1.1750574685676798, -1.0629384728512554, -1.3562985297124523, 1.442433663897355, -1.869213093372353, -2.3437380717256553, 0.5898130715587341, 0.4847101025710055, 0.3233365513991115, -1.3346585150518495, 1.0454360321070073, -3.5335236563560173, -1.6642019799683871, -3.8147805099025964, -0.29575619478201826, 0.07267096902624147, 0.8627954420398255, -1.6825741683848465, -0.21057633204722565, -0.7837417149652458, -3.9389818100501244, -1.2865954461069027, -0.17916269114088262, -3.1267491242941867, -1.500796203409598, 0.6221346304877975},
    {-2.3228935367673476, -1.1935216164685545, 0.08087127679342673, 1.567244475856317, 2.1011084192437828, 0.8220030631977766, -1.4114358414523478, -1.2474878649626762, -1.8556072153936536, 1.4541275083657859, -2.297209310190237, -2.5081484709760264, 0.6147972915478007, 0.17859492424449336, 0.05314012674216424, -1.5233168620732727, 0.6265906018555599, -3.6615133100090804, -1.8547790974959404, -3.925045741014893, -0.4905262992738045, -0.14429013816968586, 0.41516804162587906, -1.6891053809746452, -0.7146901783544114, -0.9381656815580407, -4.093190850257955, -1.7657308423159734, -0.8654926466267241, -3.054062107055853, -2.061072943335711, 0.3326821580891516},
    {-2.13451762743741, -1.0031165254308831, 0.522350003515703, 1.8444516130862068, 2.1682446424864708, 1.320354798323796, -1.0856554853692892, -1.0637222045640689, -1.7492152270734798, 1.6217100145485392, -2.005002893898584, -2.3535137009130804, 0.8624195282037198, 0.49398042637816175, 0.7912099933464672, -0.938227172429933, 0.9290284209640989, -3.840798824917858, -1.7551399486104222, -4.021341662537637, 0.3005091588816697, 0.06359455508415005, 0.8881634936624546, -1.4028403052225165, -0.5425930804156779, -0.3237162355824174, -4.133590396687126, -1.7229899612073016, -0.2231112902182554, -2.9454686346184666, -1.8779403371971988, 0.3236924332364041},
    {-1.5552876221375713, -0.7329498335686305, 0.8082684000596344, 2.172335655026153, 2.349199475210525, 1.6933180202943834, -0.6345578011138004, -0.5193765231391015, -1.1922945795648838, 2.102090467436539, -1.4327832950281876, -1.9429120453349542, 1.4475993386883153, 1.2629692255433076, 0.944164146645943, -0.44271707445475517, 1.5423122125972726, -3.6852026005757295, -1.2227225040750664, -4.112795399948385, 0.6865816491464365, 0.4354582698907451, 0.8552871919629594, -0.7872753557077532, 0.22777923406682793, 0.30808498486317626, -3.931493965609095, -1.0489359312247806, 0.25956383896529434, -2.7076284541095172, -1.3955646204512813, 1.0361840392323955}
};

static const float b1[32] = {4.487036314693698, 4.5741927421768, 4.707204376797712, 5.0749046517184455, 5.099668629366386, 4.4779451877439085, 4.31102835552602, 4.777578251995557, 4.709079786000884, 4.77330763219119, 4.606818293900779, 4.578916323857214, 4.5151058878655945, 4.632711144867582, 4.671718948448332, 4.69693815256832, 4.599851484898784, 5.004154477390008, 4.754671944485919, 4.994988083544121, 4.573596480827169, 4.770031677442471, 5.060952888737459, 4.660888008498234, 4.71044102353336, 4.5813203013551, 4.840916004906543, 4.527736349072216, 4.674624331408777, 4.705174246709678, 4.554326091285547, 4.849099059054195};

static const float w2[32][16] = {
    {3.9571059768570827, 3.383787396832448, 3.4167299245464533, 3.7065582777088, 4.054759505884964, 3.4475824745014205, 2.0883836286947695, 4.1231602400694065, 3.8309376745147, 3.3917893473430833, 3.703637015454147, 3.849943871698163, 3.9867812442068353, 4.295039160170071, 4.32754134258269, 4.047543280146106},
    {4.078407036019362, 3.351669435719001, 3.2181945732438346, 3.8973001118652095, 4.19041028892996, 3.762903748325002, 2.2662959176929656, 4.258559233249245, 4.105365960054114, 3.104551540681699, 3.8396504324044374, 4.173239350057582, 3.8744204605059895, 4.4921126554363076, 3.8073405366490336, 3.9317882405822466},
    {4.246610273289907, 3.8944385421272494, 3.939563064032429, 4.208410334736165, 4.008593400671754, 3.680086617185048, 2.809267818047761, 4.1948475873553415, 3.870394854747012, 3.5681930309586267, 4.471558338337189, 4.276947202207177, 3.9924339021846413, 3.821780127739137, 4.015000394787875, 4.1116315298239146},
    {4.059717991372331, 3.6915544005203254, 4.017155942427644, 4.426205401002289, 4.263967157014413, 3.774714996269375, 2.3904888086774907, 4.172807198174886, 3.991437276651506, 3.2271782314101776, 4.634543928801226, 4.3972534628043105, 4.287463575706696, 3.9448800580490757, 4.177474930515379, 3.9576536952083323},
    {3.9105254885733185, 3.777926182113868, 3.3192518004823053, 4.569036456957227, 3.976400122347111, 3.7204111513061284, 2.722115937538811, 4.0342279931045635, 4.03754281628309, 3.3348300682655747, 4.55859076772264, 3.974198171407365, 3.9380336465103456, 3.9227153912804646, 3.7939282172043036, 3.8163197276675342},
    {4.224879271808023, 4.071599920459345, 3.4048802796760733, 3.859390777368768, 4.5610573461065425, 3.995900687315347, 2.6012288534120667, 3.9469143096020725, 4.485133827743863, 3.2333675062062235, 3.8961704454219754, 4.342131438644384, 3.5839185679302976, 3.9044398885298355, 3.8429210874517987, 4.21983375873078},
    {3.9678577388112495, 3.621287129290437, 3.2059664278442352, 3.720416690243086, 3.785464014513255, 3.656038524500617, 2.7175720462131676, 3.8819979379047, 3.707689869302374, 3.2365138149398063, 3.723596770859787, 4.256103763695714, 4.164368594802677, 4.0793104395232085, 3.904892113544035, 3.7441499944767935},
    {4.502939196482566, 3.8061625270140667, 3.275516225142481, 4.131331223117478, 4.058595009612925, 4.300714456518405, 2.6631676396455988, 3.9603572482884744, 4.120937011088095, 3.244333436111594, 4.190517799929076, 4.098364189991844, 3.8096022570744585, 3.9505469295919853, 3.9191242415772916, 4.126005388553528},
    {3.9097035834500407, 3.6889532467126704, 3.192412064565905, 3.6492981011485806, 3.768647786191373, 3.6353922836699657, 2.6028158410542446, 4.249235277348865, 3.830978358989893, 3.162529731288526, 4.184016652885819, 3.657619265466678, 3.872094759064522, 4.001641961892308, 4.2308020082850195, 3.816262634613089},
    {4.301149537119166, 4.031217794961945, 3.7335513058594585, 3.912095007137735, 4.437709490652569, 3.737081543525552, 2.4619434453803013, 4.499232656769323, 4.373306976091439, 3.249267000012456, 4.050488805716916, 4.201082343634989, 3.7649636285184207, 3.8344382758050286, 4.3762259403797135, 4.420571676554854},
    {3.8209044249625275, 3.7046957267253866, 3.293530689400343, 3.78670789621825, 4.254511940902276, 4.050326182334426, 2.5150080159221235, 3.8823317924712293, 3.8144112992996964, 3.3030198101833834, 4.286731988898885, 3.765925149132362, 4.0896671021979305, 4.382600761886121, 3.7710366515529037, 3.7021154598144035},
    {3.8177584608760275, 3.4974324199992495, 3.809213685960141, 3.958569474695235, 4.008101744639878, 3.7933309494519203, 2.5057796500832588, 4.198440156113717, 3.985918375861208, 3.1548958817740154, 4.052920737439802, 4.00177325264163, 4.181007370557963, 4.432467766251271, 4.39636550999467, 4.366647632221466},
    {4.160852983476905, 4.088219575813242, 3.6013344022396514, 3.82217182800841, 4.296856959924213, 3.750773249716886, 2.721123152640831, 4.158379431939435, 4.1614859712962495, 3.4501885015613762, 3.9566912497426965, 4.299362288891174, 3.865080712018497, 3.938370225782386, 3.8627356082091393, 4.275238302112211},
    {4.223477142416751, 3.73522331212228, 3.641011453117274, 3.9849539816853543, 4.108325888012022, 3.874168758226185, 2.406105643152293, 4.420338562609217, 4.418103589341194, 2.9825597653022973, 3.738032088232659, 3.744509269453793, 3.5558746524755884, 4.050538404653998, 4.071693175487983, 3.810374374475437},
    {4.008206044216215, 3.700294460767366, 3.478373411734807, 4.392881354043512, 3.9533963937048253, 3.7527447736080823, 2.48801194389087, 3.858961683543435, 4.424797542727277, 3.4224133534330057, 3.9073218224404096, 4.089399496604771, 4.173092402933536, 4.217513162664291, 4.430810585263215, 3.7243820613967142},
    {3.675459669462387, 3.7603743351477394, 3.427266065044452, 3.8870914274331567, 4.154434225880305, 3.826062170089039, 2.5688156159436066, 3.7046143698170595, 4.135468741047979, 3.271327115749569, 4.05052489514971, 3.8447052801359685, 3.727261235902569, 3.7170058249080586, 3.7067355589134956, 3.610985001440664},
    {4.1876580531330045, 3.4840373150508155, 3.3393335856286095, 4.066222635066821, 4.019546534168939, 3.575219672711901, 2.440460905940239, 4.123915095428293, 3.6757863598678147, 3.4500391242037356, 4.133665177613067, 4.034748977679932, 3.6009016384798613, 3.639250678060785, 4.033963691393034, 4.030520173936114},
    {4.386161208067949, 4.580123635929631, 3.8730112712079725, 4.549497476222731, 4.506559533966562, 4.535320604556378, 2.8961713699094656, 5.09043908803299, 4.99731762980386, 4.127818426475979, 4.907935702410125, 4.595814093652999, 4.586654636510456, 4.463368461974616, 4.583196761894199, 4.367069540163014},
    {4.327590304360293, 3.808183296112712, 3.5658945606092245, 3.973697195593343, 3.9998984601424805, 4.0625945026390395, 2.464829895770233, 3.99599661139635, 4.484492107490256, 3.3649473523518316, 4.190123207489805, 4.122042988656903, 3.9499140262639223, 4.211404319563207, 4.306999298826724, 3.8941768604683165},
    {4.699646977800289, 4.68671555546694, 3.8014350248478244, 4.836131998275822, 5.052850174797607, 4.408520353824287, 3.255580298988371, 4.612967781571097, 4.973188852197343, 3.8818318872635396, 4.708397436035962, 4.549353965861257, 4.389842587096205, 4.5397148903869295, 4.864385046501978, 4.455010244283417},
    {3.735948097546355, 3.700032317045115, 3.634777443525152, 4.223549664509049, 3.90788516790422, 3.380656305584426, 2.3874695256554523, 3.8806522093783977, 4.401936666676552, 3.307161751458589, 3.791654977980745, 4.082635054828639, 4.046774793160569, 4.320222146499798, 3.8474929638924182, 3.912943706627622},
    {4.546981983955659, 3.605040651222709, 3.744736388128174, 4.103137606379779, 4.389618986537595, 3.9218258341876253, 2.354281611155245, 4.14447365164254, 4.188325599230952, 3.3960240133998396, 4.450577856675708, 4.625359089815858, 4.25059983152159, 4.319351214516106, 4.338505435642275, 4.543930192335842},
    {4.201057226780335, 3.900929215922981, 3.577407212712475, 4.3628547538813605, 4.208447728187712, 4.308590348182005, 2.7454018848139583, 4.714529798603269, 4.492201975674105, 3.3215535174431214, 4.6648743190972874, 4.6011694088632975, 3.8954689994245073, 3.990145165041956, 4.167226875124237, 4.038721460497318},
    {3.8413856196016134, 3.6890790728193146, 3.4306980610865025, 3.9206785721578634, 3.7557152059187544, 3.5416069682033204, 2.3346679458624555, 3.647999836778664, 4.306087435635526, 3.0656441565938586, 4.072298955762562, 3.7760735656798055, 3.413643369830356, 3.775812379200815, 4.12176690131949, 3.8515963883416573},
    {3.7898746295026102, 3.2337263980287623, 3.5558943327435375, 4.120401765559163, 3.722353836226066, 3.6735230669404584, 2.1400307827057508, 4.081858229444142, 4.0081198467842345, 3.2430779883428906, 3.8455789144458636, 3.6525992256717816, 3.7099985338401784, 4.1689504604102146, 4.319055636576017, 4.296033231419425},
    {3.607855342400999, 3.694655052755247, 3.526718998489272, 3.9591010624216043, 4.239811732225812, 3.264123392697666, 2.3317801289153515, 4.158945369818013, 3.9314865115731186, 2.933575393903871, 3.869929256665416, 3.908079167341416, 4.038211350384292, 3.7957556567560666, 3.793713709895557, 4.115605066099217},
    {4.488946826514679, 4.204630154257245, 3.6772681408046117, 4.110797824159161, 4.268781213087483, 4.443311280585246, 2.209254140477055, 4.1342086745719, 4.4639596442952545, 3.328393096504306, 4.631698356090903, 4.219816685168421, 4.16864470581503, 4.544561510274542, 4.447491768659785, 4.254060354390349},
    {4.393468549901785, 3.722828470895857, 3.6172944861810046, 4.102528616188291, 3.7949069301481972, 4.089000013857676, 2.3413643949218557, 3.8092103204194085, 4.198687333548098, 3.490864954200778, 3.721668903893489, 4.089788180959002, 4.030745954025007, 4.270209442095194, 4.021685202605949, 4.079635665886093},
    {3.7029764229960738, 3.5029275724083284, 3.3508474976018103, 4.196342398444742, 3.7664817134271655, 3.773912612037895, 2.5493183396992, 3.8798828957055496, 3.9614217464748274, 2.919392217451377, 3.981668061288817, 4.1328893961508575, 3.6525843120053896, 3.872654932213077, 3.791309680066463, 3.8698652967416023},
    {3.6915353605939814, 3.391766826521111, 3.5960984516769283, 4.257025356487103, 3.645286883236691, 3.66090450275683, 2.6351758832626118, 3.6671779890994802, 4.306650902385435, 3.3282919726498688, 4.006163454576912, 3.841884074084982, 3.634583087162119, 3.7704942581256935, 4.262510813562191, 4.047492981518364},
    {4.124784463064687, 3.189913679098795, 3.301776852671958, 3.7600165688178735, 4.377034049803864, 3.5796470785819468, 2.1997205181230446, 4.125534938690497, 4.036675799015102, 3.140749180317445, 3.7643097238986076, 4.0394450366388535, 3.5894167179177354, 4.2975598312214025, 4.087053472978658, 4.300437400825879},
    {4.386415218118987, 3.9229491441103805, 3.8082980555160337, 4.559878567698133, 4.027055224787736, 4.166859795797824, 2.88842708969078, 4.205083529368723, 4.077231031600772, 3.236552869430731, 4.391140650442908, 4.214022225807693, 3.9170377417059132, 4.40524122149244, 4.270839079583744, 4.431311847453057}
};

static const float b2[16] = {4.009644870326172, 3.9615157155908456, 4.1994428720841395, 3.779171429183779, 3.894683377803255, 3.8686994392391383, 3.417139835253122, 3.9922928510617717, 3.968013065984585, 3.887930741949096, 3.8007214796431343, 3.961562183451572, 3.8858626397152936, 3.9927787099943073, 3.9281982386546335, 3.8682030305828907};

static const float w3[16][12] = {
    {-3.326555755803031, -2.914559995965946, -2.96666269797556, -3.4275810492690852, -2.7868840778665955, -3.2817625957254952, -3.241303397069661, -2.9609173937162145, -2.8299416502117043, -3.0425089981494957, -3.0351130475568433, -3.234890255081491},
    {-3.096412066411965, -2.590179495376895, -3.1122820576892622, -3.1881623237553356, -2.9043435088527945, -2.890244218829737, -2.6869056512759304, -2.784363081088531, -2.9173174774191772, -2.9306468298156836, -2.6233878017638177, -2.797848623814569},
    {-2.5596702490322536, -2.789186750256583, -2.7131079793676376, -2.4393457390005104, -2.975482257095561, -2.414620203515455, -2.4454661610191333, -2.765867061767908, -2.324165884347584, -2.303462874009172, -2.437211637616189, -2.1641371853310525},
    {-3.10736416899444, -3.1790492647833903, -3.1570779518091894, -2.9847607750357166, -3.5564740200276304, -2.6184351831204418, -3.3301278932055998, -3.150301847509557, -3.3432087817845244, -3.365660174445377, -3.2453972943376606, -3.504438818277428},
    {-3.1693263589716336, -2.9988472007177456, -2.773284991168096, -3.5418684567815384, -2.743380067231811, -3.0494778233272464, -3.3672977831145907, -3.2394261919398795, -3.3544409540744504, -2.8510818847910704, -3.328919011062581, -3.079822868991826},
    {-3.0922556660831715, -3.5192345230427384, -2.4847904962226695, -2.633471434062276, -2.909531101134548, -3.3191586764074947, -3.1862907498512754, -2.8926865606883645, -2.82143575765016, -2.476745972547189, -3.4145060627897585, -2.7224175245215743},
    {-2.2765461316484585, -2.2707104489643153, -1.5730079756070783, -1.9477052133418244, -2.190769837587169, -2.165858981738053, -1.65333261983357, -1.8735712484730824, -1.1544259172771625, -2.0979189176646083, -1.8874077236562963, -1.8075241776717261},
    {-2.8132093650320367, -3.092730460646783, -3.4529448706824772, -2.996909320731928, -3.3853733168631996, -2.6088201556896964, -3.5119830674352754, -2.973430962396943, -3.4876708211908385, -3.2299091773171726, -2.9171840082074953, -3.5024266804743682},
    {-3.232866754758883, -3.2172541736560025, -3.264813128419025, -2.63516255795578, -3.1360539297971806, -3.281082590603855, -2.7866766979580673, -2.8102327956667055, -3.3942701244462614, -3.2673853988869466, -3.125782742581048, -3.1174513663843677},
    {-2.671622943598506, -2.3940896376411795, -2.1943778605055035, -2.2102778000752448, -2.2858134134451977, -2.772539289585667, -2.0247030934695878, -2.4530940014624765, -2.1890896351035405, -2.395441960204129, -2.3118907842852487, -2.284234330174335},
    {-2.4041393519316205, -2.7798515378339284, -3.246873495749917, -3.573607089941464, -2.9722651498585533, -2.978459653964472, -3.502825912939499, -3.190295918174019, -3.54909840513534, -3.2127844439174873, -3.083882314974329, -3.257499510132859},
    {-2.875000191534669, -2.841675313051653, -3.4103788428282518, -3.123148935413802, -2.8834112796151303, -3.333707561613059, -2.8546461449066594, -3.1883892158356897, -2.838515229217737, -3.0465308721952304, -3.1435763837471136, -3.1068908193623193},
    {-2.360209917384899, -2.7183237520129286, -3.2279611146816167, -2.774573607762555, -2.9269791216226198, -2.3100106732255217, -2.413712082328066, -2.91339478796892, -2.89260639598394, -2.8397441687128477, -3.1562310729787058, -2.355834936707635},
    {-3.3205881507922577, -2.7890121318498027, -2.9922347753400005, -3.05690770375873, -3.3112258318376333, -3.2283616403154562, -2.7919189958705375, -3.318728914720366, -3.1084064877585447, -2.8345707221507586, -2.8276177183538933, -3.4446950152666207},
    {-3.2459393547445403, -3.488590153708777, -2.779304187179304, -3.1893820293697046, -3.0072963113514986, -3.3525734945886474, -3.316750268215741, -2.801838704083818, -3.2235661237147837, -3.2593508121032837, -3.15852305015563, -2.9504956212701323},
    {-3.2447742039173226, -3.102414031872543, -2.952335638157554, -2.6615219365707015, -2.67960471605859, -3.1996512699071533, -3.1431849919015042, -3.200436193493603, -2.6372507420536158, -3.3130491098343895, -2.6084049610918836, -2.921334153180839}
};

static const float b3[12] = {-1.4287152776098826, -1.5919365051240773, -1.7313988384059482, -1.4489766283158774, -1.5107888245946135, -1.686989853898249, -1.5915461400263125, -1.1138068185824264, -1.6876399523409689, -1.8190706351421693, -1.6875316041807733, -1.7743778165711424};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
