#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-5.536774257126698, -5.133276200491135, 0.8419322980306007, -1.0377927461118723, 1.1116949680026451, -5.767578055173887, -5.123338479888752, -0.3563374576099142, 1.7730161732014134, -1.9458192230351208, -4.529537941740554, -4.617601042130753, 1.8372666319315627, -3.559289699641622, -4.880948766006816, -5.990287801834879, -4.336923305104342, -5.632504536032468, 0.9979381179202214, -4.592083381574803, -5.172817309638696, -4.995559836939902, -4.644171931778935, 0.24104570358194022, 1.5469602922312713, -0.23725290803251992, -5.437086745081134, 1.2516774835138387, -5.038576004022544, 0.5139644412141049, -5.279024602012617, -4.3802236827359255},
    {-0.25555135725523925, -2.0577101934337727, 3.590471785017096, -2.8460386161674798, -3.408856339198032, 0.5465746299636018, -0.4020905711505059, 0.5005775839048227, -0.8733041796352079, 3.22009528156235, 2.9154737853834782, 2.6728775699976923, 1.7919569601871543, 2.080011184940214, 2.71480144059815, 1.243620246070026, 1.7360313535263925, 2.5939318098112287, -4.807119477920974, 4.362195367260802, 3.223796287996765, 3.8902850423637614, 3.1412243177038204, -5.010059803638096, -2.8186642534578854, -2.5197457549179663, -0.11401915126332889, 3.401117400567006, -0.9062351253355945, -2.771860545565829, 1.2638730174317034, 0.6284531856970944},
    {1.3876635853161103, 3.0409871237369597, 0.15579172208308723, 1.1575158146910474, 1.445316072805456, -0.3408606973242477, 3.4833984929611814, 1.362289837678836, -2.3438258535776084, 3.021402241418558, 3.8579658008750806, 3.6640670329299887, -0.19946898154643186, 1.3493550514829065, 1.6978349102002566, -1.009636841100077, 3.754265057030003, 0.5925347776406683, 0.1503040457542295, 1.523124052260508, 2.7922269626603584, 3.5498225443519815, 1.7570434051607218, -0.2224934118274126, -1.6683731655806073, 3.1093441396960504, 2.394760249194333, -0.3876094529774758, 2.4866847696876047, -4.161878028828892, 1.9986605677083014, 5.064443071772201},
    {2.0631146935164453, 4.799772124148709, -3.721040283928255, 4.345485164160103, 5.371252290751684, 2.7025370263077595, 4.0046556833872895, 0.568500934895459, -0.6272080940491229, -0.4472675623349163, 0.01885955957705603, 1.321486067082844, -0.9362462059790847, -0.4750952667502909, 2.2334468538004173, 1.5327986843321073, 2.640761840178507, 1.8070385520994785, 4.43075200191393, -2.579102485128741, 1.5641324617636654, 0.8677428809762826, 0.7524067830161109, 4.553625910553308, 1.01671955066468, 5.5061035559486875, 3.7578411352682473, -4.175812623596699, 5.1430124920268705, 0.12629269749926142, 2.8779971139396534, 4.42392639073927},
    {4.836726934338144, 5.658935927764545, -1.7585642173020424, 5.3806243776550975, 2.639038268751699, 5.8930526056067585, 5.5370573807604515, 1.2586896198638462, -0.2951512897238413, 2.0730761316565363, 3.598273633849484, 3.4338833820706194, -0.5653493519876691, 1.652709780419283, 4.815995633754948, 4.671772673472479, 4.673858548342368, 5.030439437462334, 2.6707982156330696, 0.9116127563219981, 5.971234024148135, 4.294763747700193, 4.563509181819626, 3.2847050767559574, 0.5762045538146067, 5.0256129014233535, 5.978511405940231, -2.359434735907331, 4.79752875240013, -0.16873845855900796, 5.901195280432094, 4.855573350368423},
    {6.9721416803355565, 6.691905804081841, -2.7333865729308386, 2.926011031689315, 4.3170315458491615, 6.168576974436053, 6.646424367737001, 3.9369647355866393, -3.2117520605590273, 3.242752621885205, 4.556416378582483, 5.685242523250858, -3.1716477281285043, 5.971993172928698, 3.3485910107109325, 5.896306777306673, 6.0911941615055065, 5.380197507439565, 5.705407224450345, 3.579910157953253, 4.2095429421502155, 3.158362911091044, 1.6187081808116588, 6.351014746053188, 0.20832123973588015, 5.711768949787186, 6.575059795529756, -3.65584759917579, 7.634849164067358, 2.3767649526723753, 6.48117783738251, 7.098662568614276},
    {6.6439827205627715, 6.64179432072839, -2.917729436708744, 2.7639935330438288, 3.3772359515675534, 5.44480997393027, 6.481180423655454, 2.8166428235793055, -3.5809857860080347, 3.213382415354289, 4.2751651153887344, 5.554999410370702, -3.2598590386735653, 5.8533375364854585, 3.0053951248745077, 5.60458614231747, 5.403454197695638, 4.2046292734220785, 5.520620784924853, 2.6574031310251094, 3.6470352009298614, 3.038915020584881, 1.0770207984396487, 5.986555253809823, -1.3730629232818694, 4.904225106309988, 6.032814796844468, -3.461205602450358, 6.933956125551945, 1.0306474306863416, 5.895718768473523, 6.550910328854181},
    {2.180447378421513, 0.6687147585387605, 1.0400254103498743, 0.7334464899431101, -0.9920002870072484, 2.1729318733910756, 2.054815430072141, 0.7814982300185569, -1.7951979888506973, 2.6000206157605246, 3.127387932975996, 2.5405765501782085, -0.28545933357524905, 2.693257623194231, 2.4229261948433263, 2.6845013083073286, 2.8754263857701154, 3.295191915278537, -0.6816144301875886, 2.4367647646586756, 3.535241687700561, 4.019366491504678, 1.7521821199874685, -0.4770068775953272, -1.2273367894697238, 0.5767011594372868, 2.453163842053407, -0.885268949181296, 2.6254547933804364, -2.658578723990641, 3.1058425947682067, 3.076469808804286},
    {2.2488183844914063, 1.059406856380531, 0.5452641935615682, 0.7425933434870595, 0.9142578688990446, 1.6831963233186864, 2.833144689450561, -0.19329772814832405, -2.216273750268019, 2.9613490152193283, 2.9293666363584174, 3.8645682275732156, -1.9440575946221934, 2.758277980111861, 1.6313708736559005, 1.7122114294638582, 3.0190622541621397, 3.5401959536698078, -0.7584565981715701, 2.3391545955164323, 2.636270607133712, 3.4990731484044537, 0.0794290911095671, -1.3338019622835213, -1.1019545500827754, 0.4221846278936888, 3.1401722822026095, -1.3352321857227423, 3.66012997233346, -2.987469719822052, 3.79836329146431, 3.587549294982199},
    {-0.2754876472630785, -1.8084192529748442, 4.862217352164943, 0.12000621079575166, -0.46165330962737666, 1.8467881495826426, -2.389564054294899, 2.926282480496085, 2.545479598867802, 3.774370214228002, 1.4522791752460866, 2.6343923705477366, 3.2316943910633027, 3.875421962387418, 3.2806306027535954, 2.4017202741035155, 1.9661364674779938, 3.2651582168728006, -1.8475481493463874, 4.788374440306909, 3.0562123108234553, 4.490943413276067, 3.464635713890177, -1.5127620630807324, 2.0050962084656287, -0.2778993871935729, 0.6431009676265046, 4.909941113719559, -1.0828152602512844, 2.816136559144221, 1.430210964777788, -0.8982496217017695},
    {1.6331617289710887, 1.888915021860267, -0.1623092385913045, 1.9790665089543384, 1.7386055022805096, 2.9469781953353755, 0.35423978482256907, 2.5103200968733357, 0.6110487079214779, 1.2319053379929292, 0.48314300514415875, 2.3072906224817884, -0.7624214170469704, 3.572130271933542, 2.1864184898259587, 2.5416161066537697, 1.9401528012876728, 2.595680734057952, 1.6177746258304302, 3.829220381900254, 0.5224035935377626, 2.0439920561186935, 0.2676009232499358, 1.8913133906457358, 1.0346730448438157, 1.74595354189944, 1.954522270683096, 0.1757805049018428, 0.7502793377015089, 2.4897852406742103, 2.347537889898762, -0.06660087746237564},
    {0.5395128734209244, -0.2621017724584118, 2.8009147169687596, 0.7488459305608981, 2.780088201586734, 0.05879085087629286, 0.11096746256361673, 2.6163275167580955, 2.5867472613355402, 2.2525260767469293, 1.316324970976877, 2.9832679058227853, 2.1244731209783785, 2.0767677192463583, 1.7097817494178538, 0.32887672914785265, 2.4811402512902574, 1.9412267233007068, 0.36617285882743394, 2.253783660560888, 1.2526103229639602, 2.5685537215583114, 1.99118271377969, -0.4937736427524658, 2.0379374615777985, 2.6213923504074828, -0.3521230600777848, 2.803381707777434, 1.1538455299739567, 0.8605028324760046, 1.0327592215515484, 2.5452326700950354},
    {-0.37859741899802574, -1.9228559746485165, 2.0419735141493978, -4.586818850585956, -4.289808510405076, -2.061764672294075, -0.6389882709632503, -1.116931370022376, -3.642595767762669, 1.8328749222544112, 3.0960693347704065, 2.4819457359771886, -2.747846844724692, 2.8550222398531866, -2.744910141352144, -0.6822688965432723, -1.6449761170004644, -1.5645667307057702, -3.287512218613467, 3.8267433128226047, -1.9448674603190383, -0.30920920406086455, -2.5459548093308637, -3.492438900673368, -4.0297234512773485, -4.335588799654196, -2.157561688520871, 2.1212020845927984, -2.050100347278718, -3.3713488278137884, -1.5140992210869184, -0.3788824744390451},
    {3.330286849972305, 3.5821799038181528, -5.010266083788614, 1.0360163453665583, 4.144372660631917, 1.9701356170526871, 2.818146925856909, -0.28343401269868723, -0.5961808557633996, -1.946403776867043, -1.8749807803327592, 1.6056479070268819, -3.0331888327011023, 0.03064495852888991, 0.6625460366843985, 2.2403450756031136, -0.3409059932546693, 1.0637945505675295, 4.692351987543351, -0.8243050344038925, -2.5897256857631046, -3.1552471542519185, -2.6532270912752427, 3.4034533212493865, 1.9469274428421488, 2.5394297621886994, 2.530880443003813, -4.300258385998128, 4.930913847928662, 3.4589716024525057, 2.97207041417349, 3.7584169282179314},
    {1.1824578098182463, 0.5717881703127238, -6.052336554649949, -2.292880306917204, 1.2635492108293578, -2.0993517190537982, 0.4037866355453222, -3.896220629810696, -3.6146026023125315, -4.614984926611971, -4.166427347049514, -3.0168475370181422, -5.675019271784612, -3.176001144206693, -4.302174211726651, -2.2142985478128985, -3.757406297629683, -3.824258818556996, 4.404812727748132, -5.12907172605498, -5.636648251937566, -5.7882549978839934, -5.642599633553355, 2.6427881340642867, -1.660524730205714, -0.5335943934415612, -1.6175534175974957, -6.159589355363588, 2.768086125669352, 0.2733873784437842, -1.6831511280347256, 0.6053891812204301},
    {-0.10903689935739085, -1.9982678890165184, -4.669562647509411, -5.187749065656953, -3.032137615033533, -3.8186562452939055, -0.739200010784733, -4.45366908248458, -3.8704663782853093, -3.542341701680465, -2.221639201869041, -1.6339414415238256, -5.020956624721175, -2.166251755841858, -4.968631320912532, -1.8537254332168946, -4.293429395070458, -3.319514906992423, -0.8072701618288548, -2.0491358293950643, -4.992580972168151, -5.268658211489965, -5.396040292730056, -2.3676040998752357, -3.0058615280618364, -4.360890450668406, -1.8291470790594235, -3.7805702470462017, -0.6589866220072321, -1.5995060360332922, -2.426193714358753, -0.8315024384233357},
    {4.937805031702724, 3.449653450378351, -5.028130604545076, -0.13310549599387755, 4.54337949319568, 3.126589811364318, 3.3355020970055045, 0.11865370218281132, -2.777135003641749, -1.4894863557925688, -1.8912689540905043, 1.4040442911102178, -4.685880045861595, 2.279031077007858, -0.40143418337381565, 3.2936486346866936, 0.49800123597550316, 2.0352981013635203, 5.61143078978127, -0.6977599354628821, -1.7840456779872216, -2.181699596707687, -2.9907765149712677, 5.835763277963494, 0.05878170692983635, 2.959598943249608, 2.5792948738202544, -5.246921193100693, 5.645742354443698, 3.872544145083238, 2.4678448409975564, 3.829793990703932},
    {4.794628802497811, 3.9502251804058783, -3.973943020355663, -0.5990305817807647, 3.8271724486083474, 2.713298890319468, 3.4246624951281315, 2.01437011214437, -0.9806035179914775, -0.6051683826591031, -0.14856928160950428, 3.1517001807852254, -4.465316684390378, 3.9388629476135497, -0.2619696139196282, 2.9818503844484563, 1.0899233808364885, 1.8158298666376913, 5.116361135182738, 1.1065200495295855, -2.111134717810558, -2.2862360040782814, -3.3489442820933513, 5.095958429628855, 1.0500449833327736, 2.589881053386461, 2.8826207665068564, -3.5770498487532, 4.881604109599463, 4.009195955985569, 2.8637878662570255, 4.203010456730404},
    {2.5508553798263995, 1.0311737257730842, -2.992235533905033, -1.6877248963495346, 0.7495184123499544, -0.3571281467242217, 2.9336882370998283, -0.10492107894236015, -1.4149875501524278, -1.3051042164313365, 0.18957276573344403, 0.8377230926046124, -1.7127892328797925, 0.980984695904144, -2.4500799627704626, 1.1655810808728828, 0.19680518684931758, -0.4659604570615063, 2.7002434382081866, -2.0964278000348755, -2.1949941264370962, -2.582004238060775, -2.3975742852148128, 2.2172688246691115, -1.1606002326067533, 0.9278402172001581, -0.7423274064539507, -2.5105145349600084, 3.4916833719249873, -0.020026388889473213, 0.28767758288843825, 3.8167330792238476},
    {1.2044481437447505, -0.671114612598452, -0.3077339673416205, 1.9014270708540257, 1.4032235927809107, 1.332500895512837, -0.1199832173448764, 0.4135652269608688, 0.2594559378147049, -0.7743329696156476, 0.04710400826379844, 0.03341475784317053, 1.1625311440931418, 0.09783796533423234, 1.6673803701403371, 0.9972986938465034, -1.4498885549755416, 1.1027335347735117, 2.0946535345222417, 0.4053630425010065, -0.47129884294571533, 0.054831467369783796, 0.38331209130687466, 2.925444491989901, -0.09897600549190921, 1.1363866969868992, -0.8585463340601988, 0.6311321151637157, 0.13675514580573517, 2.0130139090821086, 0.6062764861918166, -1.2018728433989398},
    {-0.780434481644299, 0.04800024754028146, -4.3839190164574475, -0.06419240142475674, 1.8887085022188879, -0.9673546272475889, -0.2734600605629813, -2.612191557854688, -0.13329006527806914, -4.014635446949606, -2.4290276936397968, -3.624093173298714, -1.3750880462647947, -4.158400084741493, -1.6804941124943942, -1.642000728347607, -2.2342282008199894, -1.8255629624290621, 3.412743046549242, -4.876614730943978, -3.311275837165776, -4.208998603420534, -2.283231657007115, 2.9041990747842528, 0.6031703391646368, -0.21108471452700697, -1.6282214512548987, -3.6288836784403142, 0.07544493391906562, 0.8253079358528657, -1.634208211063713, -2.02692540196092},
    {1.6104859403500025, 1.6833026983824537, -4.874413217743384, 2.2043268391216055, 2.101627545178493, 2.394930568399053, 0.8171801705019639, -1.8361337859293947, 1.9198028946313341, -4.130742168674739, -3.7810798430710157, -3.3868495473431364, -0.6302387961099766, -3.7542418320203783, 1.1544525053947108, 1.9050453730467243, -2.549696603296307, 0.26363587823140355, 3.485392641697991, -3.404285865090365, -2.2414636421084153, -3.43480166282682, -0.5629187949668998, 2.861749014618382, 2.411111848523366, 0.5608466084414417, 1.8595760291989798, -3.6665379505086055, 1.705241251495093, 4.153879031521936, 1.5172025265863016, -2.2291678705965774},
    {-2.327814493486777, -1.90016863632002, -4.506512571476725, -1.2020880374449592, -1.0283089083369923, -2.155381109920704, -1.7030556407238728, -3.381684847622415, 0.5753686000385219, -4.958862548366858, -4.390987618054424, -4.716346747350973, -1.1321698869504573, -5.210560646581422, -1.7749528078396928, -1.718745798419851, -3.723283618952853, -3.7809345585144523, 0.8595550908488918, -5.235277376044435, -3.823903398689764, -4.593286335885068, -1.7966572869947792, -0.26769711977448774, -0.19855089376994353, -2.2896139296646014, -3.3405925234201894, -2.715415563373558, -2.117211118541073, 1.0800231360814745, -3.7787503275810987, -3.325075560941483},
    {-2.140753891566451, -0.8182373270847153, -0.3867380145123634, 3.00207276973436, -0.4708990575051171, 2.3758554867034842, -1.701258487050171, 0.62990701400276, 4.473919441396341, -2.9083927595620223, -2.2841797161988344, -3.7714823899880634, 4.5548120416449915, -3.0395485881507156, 2.8187265109882294, 2.4095173934706273, -1.2059225702956813, 0.66475975402142, -1.006822232077391, -2.583050715427484, 1.444481378813984, 0.9382571129052026, 4.792226504814759, -0.4590163624464276, 3.1462544217364035, -1.0394278922286408, -0.6703258707461627, 1.1252247002499778, -2.0246923506008314, 2.9780009669896987, -1.6515548286925106, -4.453941878519109},
    {0.9536215408452983, 2.1593908415919914, -0.3281797803802147, 5.965334366551336, 4.975514504249313, 3.5007172552289134, 0.24383632717620332, 3.1700554277372905, 4.698802613075312, -0.22134952635332197, -1.531818508763178, -0.5798227233185909, 4.783017429102048, -0.145277065031478, 5.107505026298654, 2.6908436603904304, 2.778907692779303, 1.9565400410116154, 4.437184989042146, -1.912371067673807, 2.7266204069784292, 1.8695483486200457, 5.027223614564778, 4.3848906983226525, 4.983787490968987, 4.844933169335037, 1.993627070561574, 1.3590423610322018, 1.402694040438332, 5.090314224932196, 1.196810868451837, 0.32962223519995665},
    {-2.9690692989350795, -1.6587939523343167, 2.7571992738539426, 4.63591646253482, 3.1666072258535194, 1.234240497911573, -2.4810233408068045, 2.820603984997155, 5.333372065450985, -0.13453202899826663, -2.4403172049474, -3.182143659788428, 5.7634944712176015, -2.012816881971225, 3.503738479483937, 0.5001905286961431, 1.9216798695423116, 0.030152111012776994, 1.941975372244907, -2.1803160729175994, 2.247084078864798, 2.4378745911166644, 4.915906926464267, 1.7878366859249217, 4.651676508391913, 3.2105133980584504, -1.3322023438553183, 2.952536942470539, -2.95245870472445, 3.409095275554869, -2.6042074100348906, -3.437489911881161},
    {-3.628675651324962, -3.3079941049031962, -1.785008487555, 3.3648044314542616, 0.34011190957391857, -0.19574159073693226, -4.49035293036006, -0.39541802519778124, 3.9838657249440392, -4.531464957694455, -5.656435434230156, -5.320147776063616, 2.4213980370735806, -4.287304062907266, 0.47736423839215675, -0.9181548060633855, -3.1751532740250483, -1.916197976289475, 1.4359510115934035, -4.563556440464798, -1.912935069477228, -2.394075992133567, 1.1447999456266382, 0.9624291493090135, 3.3779397881507847, -0.43106748592881106, -3.2292015027452745, -0.8706690424068982, -3.523259438838824, 4.523404475062125, -4.099585927043494, -5.695269340033345},
    {0.2915964442054088, -0.2840566090498048, 0.9812576535714373, 3.87337049605446, -0.9525469278123496, 2.0446170752621375, -0.3679188195985628, 2.088602339242618, 3.3848251788038, -0.05107995493827156, 0.4666494989157097, -1.3925314991882494, 4.409216578485016, -0.86868887942915, 3.151911464151889, 1.553498562779411, 1.122791872809053, 0.1358160535213988, -1.1488438159018657, -1.3281355614172214, 1.7852317749560453, 1.2072201533273912, 4.396627935894824, -0.6515945744690067, 1.975616674736085, 1.2558334233811028, -0.27498925930140256, 2.2225095599365514, -2.426283837037806, 1.3725955509517385, -1.4180446091781318, -1.7884930313920258},
    {1.0478578077732132, 2.48938857091694, -2.8955675622952883, 5.932366459846233, 5.205091927569348, 3.4991821424736704, 0.22200560689830007, 2.8680125065959325, 3.7125951038588973, -2.982434579810537, -3.5413827196695613, -1.3562702446376498, 3.0067971976608696, -0.9481965211003478, 3.7409850471600654, 3.276241052954255, 2.0588933273995518, 1.5297310025297923, 4.894411462740669, -2.3959077966857985, 1.0299866261530586, 0.047298501368759786, 3.627077417140846, 4.511638051699792, 4.827488982617219, 4.859739508867521, 1.2946554495094833, -2.1820965217801955, 2.3978685880726482, 5.39736546987157, 0.6336558405281487, -0.23430339250757914},
    {2.0411010143949255, 1.5310509301747792, -3.9764385681010777, 3.858207655825872, 2.4285457299361357, 2.9638565685231613, 2.0525246177542464, 0.15756691833096978, 2.764582434338286, -2.5454264639275337, -2.137741932175979, -1.4005010903932926, 0.4852871483973337, -1.6660475022862107, 1.988178846736407, 2.7229975844437817, 0.9402866556617565, 1.1085415989864367, 3.1548806884894014, -3.147702203799411, -0.0520702904265997, -2.2507152253197655, 1.4817667394816016, 2.821973082852644, 2.42856906896595, 2.988613471025419, 1.151485178821582, -2.4003479211963805, 2.279746712004715, 3.5392136383981003, 0.9912993614241081, 0.657125215642444},
    {-5.214797111427177, -6.110560742787866, 0.9885293586164686, -0.43911409817904934, 1.615460383042496, -5.468948581333806, -6.304907101127537, 1.6940574096365253, 1.5200859675054181, -0.4248843964182292, -6.343951136098539, -6.177168110812228, 1.514157063782171, -0.33902043992475606, -4.41182324633684, -5.874634656096837, -1.072602902337806, -5.295494671497954, 2.0551860243549926, -3.4866690016560553, -5.845757879810986, -4.268410502200209, -4.648975911213151, 1.9433202428503078, 1.587466333534094, 1.3564116748470731, -5.913098637110922, 0.9442762735430319, -5.962426726673228, 1.8057193065156956, -6.471539991602671, -5.83014997009024},
    {-4.744293054142678, -4.017682099768042, 1.0893545553334292, 0.5848874199476953, 3.6283826430199206, -4.4733887442239135, -4.401919326628956, 2.457664791597325, 2.381652119150385, 0.3051584793465795, -4.1544991932309925, -2.6317576758430357, 1.3549210925627984, -0.18925266763496307, -2.671773555016648, -4.935972118158099, -0.6280907040540206, -2.8536679824494358, 2.888950363895402, -1.4895042251905388, -4.1639841678923855, -1.4893258642393485, -2.452574157516444, 1.9536878768442896, 2.9389713558239836, 3.0289490329855946, -4.584703561775605, 0.7064010249619853, -4.1876407644021, 1.6598806366727537, -4.500127594612102, -2.4087425286008988},
    {-3.417539260588019, -3.803463262579071, 2.913401890263, -0.9453693278766272, 1.9727341412509276, -4.92224571628682, -3.8207174831638016, 2.828539444632964, 1.9958015204717188, 2.352199208924366, -2.3771986938150738, -0.6707249537029497, 2.581129998343725, 1.9359307719469874, -2.5204186646901285, -3.870215929386311, 1.242848613812615, -3.4960122847449733, 2.0509738195673113, 0.8954251488871593, -2.469439508060994, 0.215323870103211, -1.4819649815778828, 1.1370433133243127, 2.6702037331958364, 1.8549975321869772, -3.823818741059951, 2.57924619389829, -4.199152902944601, 1.5949915254271416, -3.311189334448214, -0.7949513617026756},
    {-3.456008239322396, -3.7606227077879333, 3.056421302898308, -0.741755890117629, 1.9891084428921628, -4.017812978344368, -3.7724551739154744, 3.1264174022918767, 2.9318220388892002, 1.8084549561206074, -2.0100238279503144, -1.1563047316943664, 2.421412614782344, 1.3594088418660655, -0.7997665953638632, -4.6742457968182896, 0.9677575726733997, -3.937352251016507, 1.2981791556716855, 0.6108069254022744, -1.9591670220103736, -0.506136850317399, -0.19073578428755497, 0.7898893043283195, 3.316726769907166, 1.6523275761539937, -3.782615198958646, 2.8504520738705335, -3.990312834805759, 2.236226331677842, -3.0149937145119816, -0.5535879839718983},
    {0.04248527684020333, -1.5860225947256463, 2.6091898686361037, -0.09420009116064126, 2.713228743069229, -1.4967005576514947, -1.7786535979562748, 3.465221762412847, 3.2448465207858956, 0.8708223794261678, -1.0004084588974578, -1.6762685383732985, 3.415335356669326, 2.2333147744339734, 1.0620466679864407, -0.9686434756003063, 2.818265206980114, -1.6867481468208672, 2.7559617747417375, -0.21759180872268705, -0.779335179236025, 0.9706691412627915, 0.6461428096867758, 2.401931502454211, 2.90329718486129, 2.471678293076376, -2.570685916996162, 2.5982275913343797, -3.2738865437719267, 1.985838243837482, -1.8423275572959594, -0.19925923588965758},
    {-0.3346632716534667, -1.3031059195406143, 2.437462929637016, -0.1817234987645749, 3.006308506763415, -1.7554182275426387, -2.4678465978130797, 3.992408577138062, 3.5837083822059954, 0.12104118411914955, -0.6181778481084008, 0.891509112284167, 2.4621821883051043, 2.5060086995747963, 1.062574146516803, -2.4741585728650963, 3.077369224055879, -0.8145083689464729, 2.2046161428347437, 0.8887526382958691, -0.4641207411842768, 1.9902325240540482, 1.3179758300543998, 2.2955959858575468, 3.2748507326869962, 3.41437275689506, -2.3233830864063028, 2.7132317516675393, -2.971245914737029, 2.9163186538294417, -1.850223718504356, -0.7662357649899728},
    {-0.7845244581248128, -1.8427329773236483, 1.4533365468321664, 0.4620518586488125, 1.6938599557155951, -2.9510708302452, -1.9818164715784357, 3.7896872003729434, 1.3790243880781576, 0.5765485717429387, -0.4389334216444834, 0.4110861025899613, 0.9699024262860865, 2.3054087241559618, -1.4654265349789037, -2.169171202074864, 2.546740853058794, -3.225808699418667, 1.012067824035083, 0.5049432020864759, -0.9497342935854174, 0.3906288856201645, -1.6253573176699563, 0.8755472814967385, 2.606123653881165, 2.326258261233361, -2.927372939956222, 1.7651266540424566, -1.4475612967369365, 2.0831421344844134, -2.8279653384740286, 1.0606556558427291},
    {-0.87886444552901, -0.9103424296292485, -0.9621512657739779, 0.007213047919107571, 1.48331164421359, -0.8837614112160848, -1.4942920690529993, 1.0661210203120823, 2.4912618395187565, -0.8643866419860765, -2.8825138380681934, -1.7412779852343252, 0.3876381403458087, -1.3085054288239557, 0.3863376420303867, -1.4741949469896083, 0.8660352055004965, -2.3680718006825625, 1.7492976953779902, -2.5630374367065714, -1.054182335462163, -1.786064392452202, -0.8574867871946921, 0.6024726721659132, 3.1356778081076557, 2.308526668190846, -0.2984917864193729, -0.9018769573987497, -0.46821791003121604, 2.1284527936034343, -1.3238117657948878, 0.638451660884621},
    {-0.051290138099092455, -2.14731760177508, 0.30089636792401764, -0.9006900684299819, 2.381414468519867, -1.7079803815741823, -2.6423551519146216, 2.2629948807919833, 0.9415027821450015, -0.42357840223095444, -2.4148268374016477, -1.0116862339768595, -1.2332980541272682, -0.6827442498448812, 0.7108086636239922, -1.6279411006382436, 1.6655646149658883, -2.4605357225370885, 2.4877235841545686, -1.6103128572779672, -1.6147990034617359, -0.7681500795751317, -1.912066438014497, 0.49927134720263344, 2.108693813523437, 2.9767991176932194, -1.9733839342860355, -0.4727102096068806, -0.7380732098399018, 0.5330567919841741, -1.3008006451473753, -0.2518167870191054},
    {-0.3754481635447356, -0.994323748824507, 0.530062318961726, 0.4460660302607214, -0.2709881323153933, -1.5575339620673205, -1.481526573305423, 2.1843139581082065, -0.8970546799022147, 2.1703053639758334, 0.3932140333117248, 0.2442718665219133, -0.22684860928613912, 1.9608369810317747, -0.02915621552345089, -1.5954726816428646, 2.044697661125763, -2.235459815020429, 0.7650403713923376, 1.096226414455139, -1.4297738231686346, 0.9452100953492708, -0.9607531730960689, -1.5542600279443044, 1.7841743572179893, -0.05952742293524171, -1.5614942626247814, 0.021529616338611182, -0.3404901958022688, -0.7027148934375006, -1.1237444621635408, -0.3264540708083534},
    {-0.2229707926377793, -0.4940529846227946, 2.627126330807292, 0.7497490966649821, 2.1319959580501795, -0.6153612725643277, -1.25736408342834, 1.743245718908101, 0.3367704687896546, 2.233126437136454, 1.3105884328703619, 2.2990360193654995, 2.3062214230982527, 0.6289449706763555, 0.3822431231335647, -0.37322188898947173, 1.8544182251581742, 0.7321474277393362, 0.13562628540621685, 1.331068225385293, 1.3620665990972474, 2.090342619654091, 1.642397465570775, -1.8106096334902753, 1.731210957322719, 1.750953152516066, -0.5815906688507143, 1.6146659357235411, -1.8861470117211865, 1.455428213969826, -0.07601089248610705, -0.9273342898553772},
    {-0.5245296085728661, -1.6297209938560835, 1.905597444815076, -0.9764036077584654, 0.34650095685916504, -0.887489261557772, -1.2013737235563309, 1.9227734483421322, -0.7347791043646041, 1.178720250881659, -0.2476059192168601, 0.7327226485739271, 1.9686544486180972, 1.8252060777117542, -0.6754066664403123, 0.377609443600731, 1.221686359675727, -0.25074809166427225, 0.0957864236578453, -0.1693811903060544, -1.0241170938706914, 1.4752053429461813, 1.731134199619885, -2.0068451480530607, 1.9420911178320046, 1.2541963225421149, -0.2374949503017637, 1.3971522776687775, -1.1870991552056116, 1.1612734828779518, -0.3673437620980582, 0.42889825725498115},
    {1.3732506798258328, -0.2438268802174195, -0.8310435450055059, 1.6020385505036294, 1.9043729393346887, 1.034665435130662, 0.46264822404039124, -0.2683585550981547, 1.3444678369557463, -1.2434624089732325, -1.2637539047335427, -0.24405341035521222, 0.6289908130585272, -0.5168084556348368, 2.6468465561725494, 1.8208416302417643, 0.3058960945005561, 0.9413545495679185, 1.18673476820773, -1.4935678843131457, 0.5388852379988983, -0.5946997606258041, 0.6715803926450368, 0.12102822595662353, 3.3561481760243055, 1.781888878968705, 1.7952668586667049, -1.3782146994325009, 2.6418146317237166, 3.420351488487987, 1.2862910240363539, 1.9168205738324928},
    {-0.503057881288205, -0.6067437283666124, -0.8448383303006805, 0.2539297982965972, -0.6950612501121084, 0.4372433909308571, 0.045741206357504074, -0.13954589676692486, 1.055490650186934, -0.6847905357655009, -1.2729194561737027, -2.3614013582502933, -0.27845347606172766, 0.15234631159695267, -0.5424621061688221, 0.07166207990350269, -1.923873208837582, -2.4051439249432534, -0.33227520111042075, -1.1293297123952935, -1.7236624693781224, -1.216782059822001, -1.6405588690929374, -0.39524720805050073, 1.2946233587111375, -0.9638427850334399, -0.4895612074182369, -0.6922647168115444, -1.053716897784997, -0.09862971571248211, -1.4271296124571629, -1.3202346277507184},
    {0.746207328814612, -0.004765160043650694, 0.24558414976047654, -0.6226941015899814, 0.7132575279055756, 1.1939580334323283, -0.43517736887841024, 1.4506421227877448, 0.4270783845816323, 2.603826219774455, 2.9915629151400194, -1.1632869880873533, 2.42907113565621, 1.1559766833915692, 2.298917668946209, 1.2657172568636141, 0.5483688940852965, 0.9356658496186209, -0.04921024230423031, 0.4590117818676728, 0.531317672262643, 1.64938035787194, 1.4999559309733277, -0.16946882279111147, -0.1349902928295991, 1.6179574664940177, 0.31722133661774865, 1.863450762639493, 0.7064582880903383, -1.0320718694786895, 2.0758045992772374, 0.24508873176197402},
    {-0.14154589479930518, -1.141031696449909, 0.1953711314242366, 1.9222888945251428, 1.642260174552819, -0.5725004064308844, -0.49190833383991406, 0.5156743064086132, 2.2310156155395835, 2.187735759882951, -1.6671995165758298, -1.531204082897719, 2.4577995025915045, -0.38982171436125307, 2.4805941269263365, 0.03333781845441875, 0.8116748689362637, -0.3739162932159398, 0.20554895502612924, -0.291561897237418, 0.9623514049260867, 0.4581188023475558, 1.9649854803546067, 0.9020692412072947, 1.3411263907138102, 0.5720731666014625, 1.0431824130076697, 0.8513599225178146, -0.43919638608018774, 0.2216409861656191, 0.40903432409545604, 0.1832569845387506},
    {-0.8330382294509122, 0.711011367804021, 0.18179593436903083, 1.510629576503122, 1.0043328181556983, -0.3425046344722028, -0.727279085962024, 0.16410901336232878, 0.4503988396063445, 1.6598764099693504, -0.34844788787991143, -0.27968597561905495, 1.6841100092297934, -0.3619660094436624, -0.7052835868512217, -2.020129902828842, 0.2480976553863193, -0.30787705805435395, -0.4406895767680683, 0.43787779452625736, 0.8424515054779552, 0.6442463726033264, 1.220489731329227, -1.8546906334768656, -0.9580687914605392, 0.06850078437811997, 0.16171607187651066, 0.7618302188327041, 0.32658670606076023, -1.1736057378056817, 0.7022502000708948, 1.0297934402912252},
    {-2.5054882192025967, -0.9942724393741401, 1.044098055474851, -1.279262089583991, 1.054631073309114, -0.34690872962413066, -0.455103251062736, 0.9024155060184537, 0.40134124954928563, 2.769087840992146, 0.8505584608300194, 0.00993355268373315, 2.576194735101609, -0.12672673152057012, 0.4049101858827814, -0.26126896000621147, 0.5782142404596823, -0.9718912246065595, -1.21107798046465, 0.47573135086885066, 0.7653576056180891, 1.9375260210162648, 1.04661854248662, -1.175584267233575, -0.2858536473464405, 0.722705938493256, -1.9160652066009147, 2.120953410104921, 0.30918120958057943, -1.992541068765908, 0.7361036869122761, 0.4219366840181801},
    {-1.5776003912919554, -0.5136464611020046, 2.55264237426828, -0.8255545643969059, 0.696735736959364, -1.54794798807637, -1.3176977658533553, 1.330337676618047, -0.6484471852993028, 3.4415520386096365, 1.7046078613126416, 1.0969175446012127, 1.8737800223589416, -0.5376460354204754, 0.8616254557883273, 0.17674609024706023, 0.8101687350067382, -0.38599531748427607, -0.9937835313733131, 2.2611891887997095, 1.6886423782926618, 2.049487083851611, 0.7063658177152957, -1.12041438998371, -1.0412779936315075, 0.7481396243691979, 0.31291162027859265, 2.5969216913423963, -0.5523759922268814, -1.0527795341252097, 0.9165939901804032, 1.2917088091910898},
    {-0.6078159390496822, -1.4175972096085414, 0.6059042466388782, -0.14284311440072078, 0.9797972876494137, -2.1804876449367163, -1.0615895533644293, 0.6715692958949113, -1.3118000322612442, 1.6722204189178702, 1.5709306290227532, 1.495077897995297, 0.9759198336755982, -1.0799108806150757, 1.0080434595342447, -2.030911449123958, 2.2030922477877763, 0.26615360765358675, -3.046515849683751, 1.6871456021357176, 2.0397599485269997, 1.7880390158752633, 1.6123969506038585, -2.948030628146296, -0.1925552270095851, 0.6763440314736233, -1.010463827027142, 1.392826278457402, -1.4452176971417048, -2.7293072475213656, -0.8162603494650743, 1.2451393507876765},
    {-0.8286001049579241, -0.5745695771678727, 2.0357451307778613, 0.09453571481564414, 1.9793119454951755, -1.241089309732879, -0.09864638987453414, -0.2168152033680549, -0.15105286386410732, 0.8275184485807406, 1.5735728700785552, 1.827335997589367, 1.3654531201968452, -0.4816319425700898, 2.1938028743192355, -1.061705700089191, 2.577881733190906, 1.2199727854454276, -1.1445438189545736, 1.2749961673619699, 2.1022597745430547, 1.7766193450483116, 1.2028370783944702, -2.408217636380135, 1.0796017854279802, 1.1167110639022766, 0.40551916710971325, 1.342147112928471, -0.40847936805265134, -2.8577473097781994, 0.5670299729448595, 1.8761669070727647},
    {0.13946024018592354, 0.40223215508969495, 2.05933468156174, -1.2488929334824859, 3.120447262924449, 0.3908178308646282, -1.0388984557305518, 3.1461941492795082, -0.33027073707291793, 3.0166760310022114, 2.669988234445775, 2.781738032321688, 0.6239159878191687, 1.317697266383886, 2.0870574952109564, 0.7546676394735092, 2.5667958958626778, 1.9270476202783524, 0.16555970393148883, 2.0073519196760254, 2.6928284567807346, 2.844780559734523, 1.8043412027121368, -1.0984756387199208, 2.2108305018779295, 2.9904459621920085, 0.6152565375088245, 0.2001281259112216, -0.6142740026378789, -0.566773497482737, -0.421852069913512, 2.393472379234223},
    {1.116682783244528, 0.4264505364741618, 0.34726313816400256, 0.35007975787427326, 1.7723422524115626, 0.8486057962413834, -1.1952896860110647, 1.2949756569116158, -0.0965883523958988, 2.1620374242021474, 0.8880767126224431, 0.8956388298054879, 0.6357886133766251, 2.469039171311901, -1.5673746677723164, -1.729497236913515, 1.2510253033576837, 0.003513887886572337, 1.5755422859833579, 0.0268303267675616, -2.0959815477766615, 0.9826789457309237, 0.9451964698780058, -1.2467372748767098, 1.5740397549594283, 0.254249262296057, -1.1077763318001552, 0.6135668639410511, 0.10122524843181202, 1.3721286604693246, -0.05577129915514403, 0.6810876469228446},
    {-0.3385926362655337, -0.5422043216404379, -1.0032021014623853, -1.6036795496368952, 2.0957686191056997, -0.7914729787066797, -0.7361726151090999, 1.1879097722451404, 0.7298096265524436, 0.876412659489132, -0.5427474867968477, 0.006923136710829893, -0.36624524001528935, -0.03652089496973549, -0.5545172064346106, 0.002602154132745546, 0.9740965704303073, 0.8474570709049427, 0.25715400161834373, 0.10724604403271185, -0.05142320260024412, 0.002189233470939981, 1.108632215937804, -0.527550384801569, -0.14489626117859225, 1.6556411202493928, -1.0354467742025504, 0.057547736330056415, 0.9322812478913909, 2.04699293321781, -0.1510986862088495, 1.6471811055078491},
    {1.672399027544301, 1.0972951457127704, -3.12613108194552, 0.8977782576389821, 0.34769514880558733, -0.18451121275404997, -0.6546026657206151, -2.5797722758926076, -3.3832518314760573, -2.774552490476608, 0.16461381762763483, -1.7295853525049978, -2.3702787342264435, -0.6857526929816343, -1.3653769279471275, 0.37449647197322833, -0.2815087042513548, -2.022462240747925, 1.6196554467693773, -1.1781155798566705, -1.678893971615369, -2.884501254627202, -2.0234461374938943, -0.6343149520043584, 0.29637087684327057, -0.5062136880655774, -1.7343172165940075, -2.7310453123220313, 1.0824352684094725, -1.0456059368386301, -1.8536068161879837, 0.48063747723325073},
    {0.7786369781945576, 0.5153387833107075, 0.09067062775054181, 1.3019413240163615, 1.4967815662754458, 0.38485175695030677, -0.3228334340953914, 1.753033753527511, 0.8818688398625021, 0.6115291560264466, -1.4680350864667269, 1.1843645318428866, 1.128114768464668, 1.0679216428277736, 2.147544177988697, 0.09278060745429974, 0.9059437950626851, 1.9766056577010267, -1.3935898566100842, -0.3474754331883421, 0.3974261423021053, 2.214557074939279, 1.3526560118229964, -0.995713411985054, 1.8283239991682978, 0.6440063475796558, 0.11861754289145134, -0.10819930775537398, 0.4373698498646272, 1.471948521395136, 1.489238439134648, -0.6794788936811483},
    {-0.6988225522470575, -1.0881768085809893, 0.30449205368815513, 0.6461266114247948, 2.264755640688025, -0.8853644431935996, -1.193511700623237, 1.4783990382796373, 0.054359302277600836, 0.5181767288598325, -2.1826232334927176, -0.19118347122586224, 1.025732285950872, 0.8599672313949098, -0.3516104868009632, -0.3681561812288966, -0.4303809053602976, 1.0537967327395044, 1.1998029319574293, -0.30198397516016473, -0.24458091874065988, 0.5490367760464282, 0.8742595742341779, -0.8313896369479197, 1.7814882524757936, 1.5126873751293923, -1.9529636185771995, -1.5361199473158542, 0.3709147247976983, 2.222727059432078, 0.34741560153474793, -0.4061009982538672},
    {0.6832608297121741, -0.701126351085934, -0.4873462684845347, 1.9992658916385284, 2.1146852211326386, 0.7112614670500718, -0.6448136381656466, 0.009035929389686182, 1.1106576641021548, -1.187798153617541, -0.6715523574031479, -0.6553186882575857, 0.4581211239591788, -0.43027999322189625, 0.08537714291877047, -0.6451876476644823, 0.2525500564848834, -0.5217160643395741, 2.213557816373783, 1.4090866406333842, -0.4084034879230951, 0.10021691983801959, -0.3574022791465963, -0.9944689537667804, 0.14362623868615132, 0.7736988824236501, -0.42027955126729377, -1.1830950217680887, 0.837229857419738, 0.024915319631691, -0.15488275618356412, 0.8033362944071837},
    {1.2024893257166525, 0.4419271854312688, -0.6917319780141944, 2.390885878206299, 2.8699384226893274, 1.297643851351366, 0.4842052126969816, 1.0978420724065678, 0.9460422855510079, 0.3173731747899012, -0.5937873152831601, 0.6280536218142306, 1.2550693936336954, 1.5444313171987716, 2.8439849895077773, -0.4302820634251466, 2.1877272935081917, 0.29506741009893833, 1.6878059582215421, -1.291571592040089, 1.068990117538545, 1.318208087231063, 0.9898253709413264, 1.9261835470091107, 1.672713659248866, 2.7677295214245436, 0.4328569957744263, -0.053123203585949415, 2.9818922264052294, 2.1233611500358784, 1.388152620445525, 1.3197203933133805},
    {0.08015675848548612, -0.20657041530188955, 0.3192482963966873, -0.7287256286007321, 2.388890960784485, 0.6375405012628917, -0.4515810160766408, -0.1681528463376948, 1.0533889981845936, 1.8865913247126245, -0.4041808845748797, -0.2310985761590327, 0.06496497805470595, -0.30886587205479515, 1.6382000339915375, 0.6081433102525098, 2.692407930183872, 1.2523447504314962, 2.1364338048578615, -1.753532411011981, 0.37059675749819576, 1.3243118161216036, 0.995986368633475, 0.9144870022599769, 3.0172482724833287, 1.6749955310344546, 0.330129606047581, -1.8456704323990847, 1.741854626566091, -0.199289196168846, 1.1708185177176755, 0.6295981029276655},
    {0.22663804355056155, 0.5784235932041238, -0.9203057428390835, -0.8279071606580511, -0.19881162528832644, 0.3466942562502972, 1.1483905610534104, -0.1289316447775398, -0.33655316188829104, -1.6533280637594348, 0.48510751734617247, 1.14065166496713, -0.7618606985583412, 0.5930254309274113, 1.3898476726925937, 0.8725937973109197, 2.982596936343021e-05, 0.6849911977030667, 0.7559150426091983, 0.14985218314619964, 0.8738164692150155, 0.6676806315783956, 0.7249038813166172, -0.3162571701365808, -0.7378491066542217, 0.09150217964785286, 0.29278904281743034, -1.274741285188441, 0.3165277306367703, 0.07067168550580655, 0.5077987650526977, 1.2167572444644694},
    {-0.16610844389670326, 0.9890654550557868, 0.6848572752450144, -0.3663974223423057, 0.13992070659335964, 0.14470068609884237, 1.894973946775743, -0.13822614311463682, 0.6641884052768702, -0.27262467178967315, -0.38372955584540636, 0.35328323840291553, -0.21831785240178542, -0.10260147321318171, -1.657008654212121, 0.32003927144986927, 0.6537706975095542, 0.36954723858287014, 0.5187811621279823, -1.111235936406388, -1.1629511084699284, 0.00993797036277209, -1.0236570735636967, 0.8764071415942546, -0.24510476338351286, -0.35684403254844005, 0.5120626829799991, 0.43943442614542805, 0.2507231100749369, 0.8469951877273414, 0.48310044058993, 0.3262931710323291},
    {0.20280719194560634, -0.6769053219690871, 0.027393676155865573, 0.10121179867476546, 0.6768124015530294, 0.03364473046981261, 0.5499658622704695, 0.19265898376012375, -0.661285719743844, -0.25935339676319547, -0.2047958565033373, 1.4484694744108757, -0.8496486629542256, 0.8570708199828039, 0.1369909395056145, 0.4747000529894885, -0.23474308053950135, 0.8887984338560396, -0.790302567840339, -0.6722041399871688, -0.36740392248438186, 0.20778962909688262, -0.5882011057162474, -0.12655728471100353, 0.28526553426577583, -1.2470552993718507, -0.010013459633732551, 0.23545694197189163, 0.7437653019233272, 0.027528850319910366, 0.5845247291772889, -0.24732607194157738},
    {1.1653399131743876, -1.0288077440727632, -0.3541037852846647, 0.5325112135768196, 0.24034164864876376, 0.7118284614019086, -0.6914756073916648, -0.6078562789762626, -0.21697259416068215, 0.28209132429136335, -0.8811803634996392, -0.5411756016351458, 0.09477141018520126, 0.24428520082532895, 0.9441072330456263, -0.36814115073296416, -0.23611767241258724, 0.20247638620829353, -0.24559129880119962, 0.40715187245977463, 0.7844598421388792, -0.23571230095905318, 0.4005910234649969, -0.0023838211142245816, 0.3174809974898106, 0.4591104759232948, -0.520138767327994, 0.49584085895614594, 0.6704242576346925, -0.7122202049083447, -0.660944526780661, -0.35827443836714323},
    {0.6290890248107088, -1.5063375635128011, -0.0849484960530655, 0.15352225623943644, -0.8652794050176198, -0.5924298059924193, -1.6288266131318707, -0.7369927094791727, -1.3084308245452494, 1.2048229876698835, -0.058924260287933704, -2.393714756741297, 0.07191921906000573, -1.1344238578994468, -0.2094740270780681, -0.6104668329594632, -0.7207711669959029, -0.11104371420755513, -1.5259708991553436, 0.6994981760100372, 0.656795716843135, -0.6654767501122546, 1.0266327423904764, -1.989042604960261, -1.47970823903736, 0.9666062712358551, -1.467294749637166, 0.3332461910026947, -0.3519175815082113, -1.412039822033491, -0.40438789645502593, -1.0850392562069175},
    {0.8169766551622071, -1.3355142935322224, -0.9031243110109305, 0.7058423214479409, 0.0542045324446918, -0.35215642760887084, -0.5434231440071566, 1.351264531241776, -1.0584536113845187, 1.4022660895696313, 0.8742856488089085, -0.499490291217662, 1.4405284851652251, 0.45408853199829996, 1.248196393701564, -0.20237843458470556, 1.018718257502609, -0.2747001750078135, -0.20493222675986486, 0.4199718146175017, 1.0583031651691595, 0.2486343011564927, 0.4573633340220517, 0.9864602553209088, 0.45283705038586275, 1.6504308539079504, -1.1056118251021902, 1.3922596661855788, 0.21814700222998884, 0.30417081686392083, -0.01682967039672871, -0.009072884317952805},
    {-0.26597604114377105, -0.6951701776646985, -0.049340766078077684, 0.9263548574811883, -0.07447431257660711, 0.19241340654471054, -0.6594826515750621, 1.9109861279904643, 1.2080784217532428, 0.5479356981310507, 0.038332926008121264, -0.26442947341074075, 0.756137403574831, 1.007388107016859, 1.6545030146494342, 0.430627821202091, 0.8777265352047644, -1.2426927237229857, 0.27991966987786887, 0.4957836168005574, 0.21379065022308075, -0.17630310226116425, -0.7277778348430916, 1.0549369298215459, 1.812406181064808, 0.4188797212449481, 0.4618815445002517, 0.40119863880269346, -0.20445113830950734, 1.798899247415886, 0.43697643227339245, -0.46227308516960103},
    {-0.6854787394460087, -0.7909963201001151, -0.26719332810989843, 0.016175910258981022, -1.0351185912224385, -0.6237077780791704, -0.9064178208693631, -1.1828388616931143, 0.4161918427620563, -1.0337665245397036, -0.2536847341759984, -0.26483607909738105, -1.0089012707251366, -1.5533304783470185, 0.1661096104397968, -0.8179393008934048, -1.398938242863297, -1.2296595381224682, -0.7117605958878711, -0.006934430714458734, -0.17374187566361468, -0.8798544587676347, -1.092175849933434, -0.13719084665735035, 0.38390607059890286, -1.8889955616934806, 0.3509415158855648, -1.0127425146527242, -0.4420903388343909, -1.0396090909346343, -0.7019958794211308, -0.7185103995627713},
    {-0.09457413743026473, -0.3348785884883664, -0.7489736693702234, -0.06383076607460995, -0.1828186906138351, -1.0457195052870674, -1.0804523248601037, -0.6478940642359101, 0.877605845703283, -0.17990475130182623, -0.16960229747716019, -0.31735873696475947, -1.5354961946104047, -0.7755047442141714, -0.5267508133862578, 0.08856146293977621, -1.1839201735510485, -0.40935254898938617, -0.7590687682033124, 1.3614199749002058, -0.27214993638083823, -1.6641401982371575, 6.875288549543094e-05, -0.01134994460401694, 0.42301587851919337, -0.4744514906736313, 0.29631763687470963, -1.1170718626161522, 0.19977261941020236, -0.887993220230112, -1.5417989624893433, -0.44863197900276264},
    {-0.5385441561996754, 0.31693547662195437, -0.27639564795894334, 0.7615807035679169, 0.019649055352928445, -1.2856773826655423, -0.09000886306499652, 0.7945538987094736, -0.09296157370499956, 0.6867983754679311, 0.4274878627188814, -0.03427121097742766, -0.5033872751411452, 0.20417080795761924, -0.9549870731212886, -0.3711534467651321, -1.1355576774817322, -0.5182440926843092, -0.06612606415239934, 0.9691115547415511, -0.20112462179036125, -1.1414718369722063, 0.22756562453844048, -1.162335425587557, -0.2700910689969063, -0.7929973795915964, -0.14244519674779552, 0.020759919088825636, -0.3228556415690235, 0.6886388919455175, -1.1324975068114314, 0.2952075364295072},
    {-0.782122967091234, 0.23443729553237594, 0.2374122607571223, 0.011204887689804752, 1.3929632733471522, -1.8163843200437442, -2.7259052778428347e-05, 1.6067860846331912, -1.4663426325279552, -0.11599992184282044, 1.2001328115588168, 0.5417751793899933, 0.46986683392428497, 0.22291743915746476, -1.2211843141576657, -1.3052747630823032, -0.33907798924140614, 1.1877825467643643, -0.7055537977423105, 0.6551799381952904, 0.8097597169602635, 1.0011517716079952, -0.15688651791272953, -1.5608789487799564, -0.047069707367418466, 0.3410141523336876, -0.2938485287947492, -0.007607379279962811, -0.7197010246217671, 0.3173424425530479, -0.28909438206809873, 0.10989443482575528},
    {0.2560093868354103, 0.02086896516221777, 1.230414213941994, 0.47922217815738305, 0.4194086768451622, 0.32829183350787866, 0.375186135327929, 0.7410595344328327, 0.5368503092692541, 0.12380374091739535, 0.2991308040988834, 1.0143882353636628, 1.7526348318304623, 0.5227879750185902, -0.8253682043571601, -0.027034292103416423, 0.5622478797609003, 1.3167891581007984, -0.19632958701395567, 0.4817901808167086, 0.08771829833947131, 1.7894862312235666, 1.281335916787193, -0.9895175224186246, 0.33633157032458383, 1.2095188161246058, -0.23214504532154212, 1.0567198394403348, -0.8280601663808528, -1.3830359445844858, 1.4597362363617559, -0.8141751635291857},
    {0.3174158214374014, 1.5114391727480887, -0.15220461168769886, -0.0356129653928261, -0.272949865226481, 1.0903242158983886, 0.9346255633545083, -0.5535231062460494, -0.16328701254369718, 0.5334196891912734, -0.5933468538848851, 0.2521887674062321, -0.19569531510279584, -0.9465667022504662, -0.5927795005117414, 0.01971513410210315, 0.3978335057517844, -0.11906802834308215, 0.6359183710786751, -0.7934593559391904, -0.4007092028041729, -0.20320948352327514, 0.2008145254032259, 0.4375588134738145, -0.9470948225171574, -0.43132811997891823, -0.03196041404862672, 0.832142639029227, 0.11485587140936634, -0.05057287299253027, 0.7939604069087574, 0.08860894116517247},
    {0.15787009079991723, 0.00862515201591087, -0.4187577003292402, 0.658759814250874, -0.5492044013556701, 0.4158716531781762, -0.08148335169723189, -0.21686662933725345, 0.38865640592820727, 0.7285590902829552, -0.43175830215260297, -0.32000507680858115, -0.12808257132076645, 0.40234470684340207, 0.7563899141617719, 0.704651636143357, 0.6150545373925563, 0.1275434180685287, 0.4681758790563355, -0.4200177488134376, 0.7601033086222334, -0.2842850360575325, 0.729189888101531, 0.9017171457886412, 0.111509151331129, -0.09024961147380482, 0.2404639163171779, 0.4585332441840033, 0.005943647966709056, 1.3888675701356492, -0.3471404169701834, -0.1446220296595414},
    {0.43136715397459097, 0.17075549384408445, -0.10820717500889829, 0.5130653004685749, 0.5584815081879313, -0.3114938355499501, -0.2546778540697747, -1.1697278236711475, -1.11180816285231, 0.4401611082008732, 0.5332107881062527, 0.40397649668299174, -0.4577524196298427, -0.406813031180615, -0.10115390363548142, -0.0020505781613151808, -0.342881145838553, 0.6437425622603337, 0.023798452319625938, 0.11733212668364876, 1.2090316079887313, -0.5427992627854655, -0.3601694447462381, -0.05821675415884232, -0.2231825071619115, -1.400818066547241, 1.5447749547922371, -1.5965937751033248, 0.8084827969291839, -0.200881259767921, 0.11240531981139967, 1.1468458779387107},
    {0.526817305601355, -0.1490104917980701, 0.35781595516265147, 0.941426307612721, 0.05537869322179889, 0.1653668783734638, 0.6681808179867585, -0.265629786510415, -1.0978980056111873, 0.6418820173965185, 1.3799543243766377, 0.4817995786091643, -0.5063789792508502, -0.2375064765472275, 0.8002170224754589, 0.08341606487721581, -0.5957846314377744, 0.3731021523448167, -1.6577366730459586, -0.37040178329313495, 0.7681279808830556, 0.29461960741032234, -0.9637640706840381, -0.313364113071227, -0.27378979136867815, -0.987343139133652, -0.31465252641038083, 0.19797057507065866, 0.05243892025719377, 0.9403861822258985, 0.16182504119576122, 0.7922658112600837},
    {1.043604511437761, -0.06514066729249418, -0.6864021293225132, -0.32491415543486535, -0.6395454340668342, 0.9681200733070893, 0.20378462675365253, -0.1886676684218033, 0.6655259104867842, -1.5638190619610026, -0.9362746522625863, -0.6585771867086904, 0.04977149934475824, 0.04631465699873734, 0.7593696097491793, 1.289571036552961, 1.2192249193854625, 0.32862001609355157, -0.7022425330632618, 0.6295846776335444, -0.25288153500528016, 0.8205086303486154, 0.19344043118304977, -0.4577872870484861, -1.1345867716787537, 0.34294914650552705, -0.3891610314753212, 0.5635481910618894, -0.34831599462162033, 0.04398352628338985, 0.302353937664549, -0.11570900089385588},
    {-0.6283977768423402, 1.0826727496535191, 0.36133422079842636, -0.85016819435627, 1.1110981143058567, 1.3412091403985174, -0.758691350016051, 0.6817580006185662, 0.7643443306103791, -0.5423999972563649, 0.17912279525950003, -0.216936027813175, 0.0806403540297326, 0.24370126187770216, 0.004932446348230895, 0.2309103418823561, 0.8300809995236735, -0.34168400447921904, 0.9250958920844369, -0.8424136218604183, -0.8689688122774227, -0.27564994578820745, -0.6045766896224758, -0.6303274431823181, 0.284265889700964, 2.5454041044095295, -1.2319998606527156, 0.08153282164257299, 0.10919516638150671, 1.093436486557156, -0.6514674309761276, -0.09016366293979682},
    {-0.6290810047840399, 0.7145937566171009, 0.14479881524616262, -0.5131654374356635, 1.4829286676528812, -0.05481041891028212, 0.7057440745216524, 1.1601423251684644, -0.34632712515407216, 0.060414650623631494, 0.3957930279806658, 0.4690738388942623, 0.8736447947448447, -0.11502623316455418, 0.5886093021683798, 0.6158773784419146, 1.1575354817481385, -0.47041449568273463, 1.3017500516135148, -1.869455387569327, -0.019919040984981776, -0.5141237971234526, -0.6185145390036686, 1.5355700186515118, 1.76763484434196, 1.6755110860271947, -0.27585186574121184, 0.015271537919667509, 0.08199212281554305, 0.0049766475480761165, -0.13265965432855042, 0.36027620500065055},
    {-0.7161176606675163, -0.3185814846667829, 0.7015150876543036, -0.28014515145423596, 0.9898615405818503, -0.20572976404022464, 0.2140087963864157, -0.662739348823986, 1.3396879033668947, -0.788359703685051, -0.9617830055917373, -0.4872504870657276, 0.2750483057603886, -1.1176781831751088, 1.1880439413959027, 0.4802667726304469, 0.37324960664760837, -0.15948793332753028, 0.6153019340845286, -0.8439430054534751, -0.8412419687839167, -0.13228957728648105, 0.037962875289154915, 0.5329230007632945, 2.3731766157348044, -0.04091775919362923, 0.5698552015866045, -1.2690412133552706, -0.281771521896003, 0.04709789969605609, -0.8028354258691193, -0.5455639757585644},
    {0.8872770967739274, -1.0367532843663219, 0.7234640605842374, -0.16047169179489254, -1.0617578394164764, 0.06830300686769819, -1.2612953933915012, -1.0443631904164548, -0.6612359416724538, 0.469369225293435, -1.3380579628145568, -0.3419442987383725, -0.2429289414420289, -0.8614172446425679, -0.7225330815312478, -0.8214329915540213, -1.1180959845126308, -0.15231206908130468, -0.7854764937576441, -0.15331384249199506, -0.4845925691990349, 0.049967853201705326, 0.18455089473091188, -1.0524889820005765, -0.4040762145146007, -1.7364651881255762, -0.3765913286803555, -0.23905030923551265, -0.47956339503796147, 0.9729462236081191, -1.0892460726059958, -1.280883432601141},
    {0.04943436538581897, -0.1894053030667884, 0.29817506101884467, -0.6332864913055603, -0.11994325043113632, 0.39770349227925333, 0.3046387488578522, -0.7861877710799785, -0.24798737960417905, 0.190608731336993, 0.4102163441415517, 0.9947579641838363, -0.2986162405569205, -0.8902414686604972, 0.006684714331872169, -1.0484171985364117, -0.6462586199585121, 0.5937510614202083, 0.26647705144793143, 0.9038553730930224, 0.6193445424809048, -0.7403334431719345, 0.4583058424703183, -0.04779240505907183, -0.8698125060795027, -1.2791278874309504, 0.4437804277918446, -0.6087174452998251, -0.44699060902348753, -0.22948629872623977, 0.25113294577286976, -0.1609335806111393},
    {-1.034998889283644, 0.33454246544471467, -0.6033329876755528, -0.7443383753031557, 0.7852422179797846, 0.3171855164020892, 0.5615586919295705, 0.008198319012072922, 1.9076476433425869, 0.5757623043228656, 0.32732676861316223, -0.4112780609602581, 0.5681854237871407, -0.5451923836536062, 0.121792942192531, 0.3168404579651783, 0.5410375897909476, 0.23490545335396415, 1.1241827532528548, 0.5724774823177501, 0.4839824594322916, 0.6451469586406671, 1.2100816486754467, -0.9071153394134455, -0.9063800285123884, 0.37937489770333127, 0.8257935912413197, 0.01638701514397188, 0.3580293622249164, -0.41696661959122194, 1.3391229108360163, -0.14388725373101918},
    {-0.2711329592234306, 0.02577095452037171, 0.021343238197852082, -0.7780721608258657, -0.3900832218418186, -0.6732031431953485, -0.9123686417331077, 0.5584627699520092, 0.6315705590673788, -0.45369523575181486, -0.6905401770170444, -0.8316130351551323, 0.8426144657335154, -0.5808120909630218, -0.6985182416324709, 1.0919192420291046, 0.33954730072327594, 0.17007965851926377, 0.12434651710301274, 0.24502066393411293, -0.2936829988976598, 0.7248502104073854, 0.030981314775525844, 0.12112960910650099, -0.33484084550459875, -0.1377001241756795, -0.22695278338179606, 0.20737098892309927, 0.1776395611900228, -0.34571884556743576, -0.3462019125854535, -0.7383108051823931},
    {-0.051686660903511775, -0.04228860295570234, -0.6511175177385358, 0.5188307841402258, -0.05209328849347703, -0.31044879511679146, -1.0219249817270162, -0.31432082204827566, -0.9367795889885374, -1.298542880358387, -1.0948410716005295, -1.0317510606417535, -0.1348358541265753, -0.513094743882677, -0.5021271932565301, -0.8801178206032261, 0.759497287645506, -0.6417777516693678, 0.1815624115336935, -0.2662406351343875, 0.42407834305257275, 0.09799340419719671, 0.40214207864101403, 0.8430176481486928, -0.23143079532299007, 0.31210126977847064, -1.2887762877915225, -0.5634495583923738, -1.1505140357754384, -0.2185242477878071, -1.647611735737137, -0.3218812756195393},
    {-0.16972334467048403, 0.8933094426524589, 0.1955751860100352, 0.21958874501480316, 0.4303033834604083, -0.1657297187412568, -0.5743933949627721, 1.706666668840429, -0.47378265686589516, 1.197751671642619, 1.6595963618551157, -0.026298039944228406, 0.4851593777991165, 2.3605391051309734, 0.9634197882880705, -0.5316658355429044, 0.06520361677163229, -0.7445494711889468, -0.5097960011998477, 0.28821800219327587, -1.1172683072984677, 0.15358136071714526, 0.4676049845838156, -1.0887075685218561, 1.246707250046387, 0.7656037145929855, -0.7747160513472771, 1.0424925956127309, 0.5065372526892048, 0.6476114479373883, 0.35196567572916826, -0.1857076473648419},
    {-0.4065953638627314, -1.7839569113679046, 0.6990162275876204, -0.6789721943979141, -0.5681827508341998, -1.1390083013592622, -0.15630681561457913, 0.11535060785983414, 2.0119005970951056, -0.7746509751563514, 0.7264692742484332, -0.5555127529282827, 0.9711105102677803, 0.8163443190294236, 0.14490410796398728, -0.5813384342960923, 0.019221906275946946, -0.14949420875101885, -0.3503733933378216, 0.7037656170871256, -1.3887841455558694, -0.5763267582575796, -1.0253194512402943, -0.5644738908491648, 1.855147411849857, 0.5449726372685224, -0.7265132602513308, -0.033040835549601015, -1.0687951099752357, 0.07280525290817752, -0.9666916974924222, -0.3322041263925688},
    {1.4781559560600372, 0.24650112467757399, 0.13708788680712192, 1.1115978352316291, 0.051922812126244514, 0.7320019993686728, 0.25477000372990793, -0.2641743734299187, -0.22997702110715812, 0.7938205469761742, 0.7711156759395218, 0.22121794600929331, -1.022683513282861, -0.3585239745336527, 0.04541941179040855, 0.5564774941507568, -0.1833409722414647, 0.009534324663467205, 0.6990568126948921, 0.6118385781064972, 0.16285531558899785, -0.6405287422882799, -0.44040853597400453, 1.005744876240964, -0.2791487475679271, -0.8819803930308533, 1.3294495151785597, -0.9291367127619715, 0.1687598422846739, 0.26023982284401737, 0.02227088924857787, -0.22057972315792804},
    {-0.9085949816371942, -0.941662466408172, -0.18770657552619469, 0.4550116287450858, -0.168966129671676, -1.1107564778456624, -1.2705531442064362, -0.7106908030227257, -0.5691541431285384, 0.19005028897022058, 0.19341621231644504, 0.21620736438795135, 0.6528148047699404, -0.35812269456908, -0.35004244616844815, -1.1160215474871242, -1.2580411727771048, -0.4708340029888499, -0.75214271720782, 0.30122494768864805, -0.12097210706593034, -0.18982883253851637, 0.820654498077153, -0.7017604062606659, -0.31411075708185293, -0.8669564195086675, 0.37224094218535386, 0.9802460149823642, -0.2775042577685439, -0.5317039103543661, 0.5504797377381291, -0.9509960231364087},
    {-0.5486776090168597, -0.45909476538816996, 0.6505158500555169, 0.19932775695624785, 0.0434969755826287, -0.7746417038540511, -0.5920121507389049, -0.7102278339010533, 0.6404036536865166, -0.7116442536015545, -0.744659704719549, 0.5750799088571841, 0.43884375723166197, 0.3572963432123134, -0.8461409292886903, 0.02301182953392317, 0.647109684764335, -0.5144175136981542, 0.6596722969634955, 0.45636428798535905, -0.04995056256720237, -0.2167539452503995, -0.6412908966256242, 0.15120561765180052, 0.46512901652697125, 0.25670678759222165, 0.6242978348744463, 0.6930472311306011, 0.587389510517118, -1.0760394642303253, -0.16512169039445873, -0.4166482387831431},
    {-3.6223506245734742, -5.012213800980658, 1.5516545768344974, 0.45902597279956386, 1.973827018795371, -2.957659448592347, -5.8888478173577115, 2.5689868216429383, 2.33629969926879, 0.5570458949785644, -5.22388364314023, -4.407722793581235, 1.0227788898078276, 0.8978528745050257, -2.349775682886977, -3.4274343620263648, 0.03668259000479175, -2.1994358903761926, 2.1293063131543986, -1.4434576075953187, -3.5281482949235814, -1.5212420321333875, -2.5367387494442135, 1.91393972696677, 2.337685750539039, 1.5942654553428142, -4.604136512497064, 1.0549741052662145, -4.624125456956109, 2.992336814748166, -4.42104906648423, -5.010666145409773},
    {-4.516919465718951, -4.523525524671058, 0.6292110219434371, 0.6837568422510443, 2.844751304340212, -3.4557232449449016, -5.356964341249944, 2.758544288073287, 2.2494657854706848, -0.22294517801523756, -4.428049948083078, -3.013053210151979, 0.8215935140578512, -0.6892276538559194, -2.0058086830657462, -4.129397089939296, -0.9072749585932284, -1.8230571750996303, 2.114392759978023, -1.6509935612286462, -3.3648371737171963, -0.5974795335105264, -1.9178922753127572, 1.060056483541808, 2.8800139646272527, 1.9337871144158263, -4.6639108583356474, -0.021828819469456872, -4.158849947215775, 2.534000110851919, -4.213830105640875, -3.429590793375607},
    {-2.941625551839869, -3.9003827150892634, 2.614222253511458, -0.7781210578696659, 1.232939270756907, -3.7784156675565628, -3.837210706004744, 2.914630137805079, 1.6032486927710323, 1.7624445803137696, -2.8007950685828575, -1.5785483552367325, 2.4479183678375716, 0.9741297436114893, -2.3711804184327057, -2.3495820927106967, -0.06314193901646621, -2.600045778422906, 1.3808082975748086, 0.4165693210031754, -1.9494920970778675, 0.7055752802055187, -0.7388049561497119, 0.8895015321229918, 2.277755007896084, 1.0990487900481531, -3.847576711564114, 2.5423792484069963, -3.894128482569865, 1.7341193826962111, -3.179585178550176, -1.5262208681916754},
    {-2.337905061539149, -3.2105925870356136, 2.628910883936029, 0.07367678951871093, 1.309331729540844, -1.8858538520402492, -3.2376741823867152, 2.869249126084146, 2.680808081196385, 1.8033733802358898, -0.6056103900003569, -0.9413383093514273, 2.96471786854074, 1.913917828003889, 0.6517483215955906, -2.5403831841637863, 1.3090253635565494, -2.8714454782356933, 1.260408144633596, 0.9475757891793865, -0.8100758171898038, 0.2140330561922581, 1.1965161712127443, 0.6062429672988813, 2.9153812334045437, 1.4331695856778353, -2.3606300427253433, 3.1519071452300347, -2.7100224825834562, 2.221463357439139, -1.8712372066381007, -0.5989196777134663},
    {-0.03169931198077453, -1.2359319137679727, 2.2735186475798974, -0.8718348168364828, 1.655428886453201, -1.059749665083159, -0.8124417250502501, 2.562714548187143, 2.8946262586236706, 0.25074229090643047, -1.6614690321671228, -1.3608850233276686, 3.366265346242062, 1.3064057001378333, 0.8050482061718099, -0.3100914022383964, 2.034118569984963, -1.702693574842683, 2.2308722124853966, -0.18252911827387247, -0.8194621004379489, 0.3994500221967364, -0.34103720998874354, 2.0202216024760955, 1.9983557996017127, 1.4406504984386446, -2.338529602639918, 2.6055432216293655, -2.9227275375250787, 1.6772637483234334, -1.038374738787816, -0.22230915922169858},
    {-0.24723874891447595, -2.0540070722764048, 1.477439350355004, -0.6910944269146766, 1.8779918154717377, -2.318420762610851, -2.6149067837713704, 3.378587433319714, 2.791288601993021, -0.6978012306026669, -1.2234276172679452, 0.11274465146452169, 1.5535751826516733, 2.343035988464516, 0.3630112996770574, -2.231866925476318, 2.28720465104943, -1.017356460653361, 1.6807631037321764, 0.3571629136021417, -1.4929688717648741, 1.408263979999812, -0.1991544521092092, 1.7755791000313879, 3.2547142597867915, 1.6823154470801451, -2.1250628104448865, 1.6889003456789669, -2.6557737763567184, 3.1572940528562907, -2.2262656658625306, -0.6929665496599501},
    {-0.6209845292677558, -1.2410489206125614, 0.42558965465660886, 0.37202572826452096, 1.5283815366887021, -2.0186041763720053, -0.9183192135046276, 2.828138649603289, 0.9837700335747831, -0.5228584464082145, -0.8974823666722727, 0.11454846123836783, -0.2179633496998222, 2.1575520612891816, -1.6655241074717388, -1.1911577025200162, 2.2683185373238284, -2.080243185907481, 1.3925629228949667, 0.3525264680353022, -1.5351300386207036, 0.03845098900753845, -1.6848088748206576, 0.08735887934039649, 1.6800438692758752, 1.4309910604689364, -2.286629653765174, 0.5172896233459569, -0.05663740652607892, 2.3535643029660975, -2.048805363989542, 1.7051457885592487},
    {0.007088174308098369, -1.0938174064684008, -0.7452802319776244, -0.27667630493143447, 1.311756964151837, -0.4703135089875153, -1.779866486546743, 1.390050751844029, 2.358667804233258, -1.1365729190558458, -2.6692391501040023, -1.0994268535551612, 0.1412590353411636, -0.21282427327374534, 0.9523138106959398, -1.2075702387676048, 1.503021535902625, -2.0622035887547843, 2.0127434110206726, -1.664562558150825, -1.159255865898203, -1.7253447175201089, -1.2575780248234616, 0.4318589549027111, 2.611651034093878, 2.033964229569194, -0.4969133739813797, -0.7305254379023469, -0.2586728693125286, 2.4625353340402434, -0.9150032140978905, 0.9991258234191923},
    {-0.6135989452974772, -2.2447644398080873, -0.5498037359429098, -1.5605973476568995, 2.1033607172327415, -2.2454159095464212, -3.0973506521895997, 1.8121899735172757, 1.725665712784691, -0.4158485236749486, -2.663544223164322, -1.1754189144464915, -1.7207906836509617, -0.36933803947076294, 0.8303053534256026, -1.9285282407619055, 1.177575210351381, -1.8421418811087733, 2.413935151391565, -0.6278375360190424, -1.7022164262257824, -1.3892874059402514, -2.3988156423712734, -0.43208363042068165, 2.2025394781022336, 2.786766230008845, -2.2655977150399806, -0.9036701065160215, -0.9582641614640712, 0.598236507462507, -1.554853317556183, -0.40638524362104095},
    {-0.3149089002192114, -1.6207174167658336, 0.6891813361994974, -0.387649180011407, -0.09959816747128586, -2.1844225261667045, -1.717847150376354, 2.4068701310938843, -0.5695063289785061, 2.607522580200685, -0.1870746537205373, 0.8307530755158765, -0.07525694459876849, 2.14164908299737, 0.04467965997416358, -1.467431434105765, 1.2131586227789628, -2.3020654544041386, 0.34649689867923694, 1.3761280360587613, -1.6717287566787673, 0.3161651424686389, -0.635913225557242, -0.7440759671859276, 1.7258523963825065, 0.011372385261173425, -1.4791196243003821, 0.43075611285831944, -0.4676282662109563, -0.2802238330347572, -1.5306205333284173, -0.2486610997339038},
    {0.38929276772185684, -1.3579503036960716, 2.012087348858403, 0.7840447050024201, 1.7805442528821984, -0.8149081256812334, -1.491542761409338, 1.6723931017296647, 1.1259289741271934, 1.4983665061354823, -0.11314176416398597, 1.8455626367321607, 1.3330933954918913, 0.6662511588243473, 0.16314587399106226, -0.6219786479539401, 1.5779423685684033, 0.628009165549186, 0.4208009993863727, 1.410187768657725, 1.182827892494605, 1.390062476222083, 1.2449864215058764, -0.8273762797293338, 1.6193603919952864, 1.8316231875847697, -1.871399807365337, 1.2782596142154767, -1.6115222535509548, 1.8455097480706997, -0.7136704674765095, -1.4592702834815618},
    {-0.6468047344454031, -1.2046799159687978, 1.073626375899192, -0.5054903301515613, -0.05870652037924549, -0.14000309566559338, -1.1297557975776822, 1.6866627310969537, -0.7954925446472854, 1.1986663311399308, -0.1429137745195088, 0.22778519318642915, 0.8959068566212497, 1.705716240968461, -0.663129147079097, 0.4013779347434298, 0.8243212318435389, -0.24872821409452883, 0.14322002376736093, -0.546913513320027, -0.984078729372023, 0.8752548036068091, 1.0146325304792976, -1.4144850687914392, 1.5382637235472765, 0.4918577372167611, 0.05273898768011952, 0.7222253561751173, -0.7573973396179583, 1.4948204353439978, -0.41665253775905037, -0.4314785917503827},
    {0.25070902613795215, -1.545166263636321, -0.31867445268063904, 1.2496986415007443, 1.5366274987224111, 0.335270703214623, -0.644723268124156, -0.33480613691326355, 1.5401469449550955, -0.9283429046468551, -1.5533138746261588, 0.5471596159465165, 0.7164452992228086, -0.053123013004037586, 2.382507771756133, 1.1728319197248487, 1.1091723562066524, 0.9073100158879005, 0.634174894899957, -0.9838665081389065, 0.3298972536174268, -0.6113511684074723, 0.7078916745131821, -0.07873164123338545, 3.4658280087711693, 1.5526542075048175, 1.7722326056696034, -0.3449634748509579, 1.4166119808498996, 3.2185158777343963, 0.9386246525949401, 1.8489428535332544},
    {-0.7299629994466568, -1.2790002681104506, -0.6163276458467931, 1.0147469504459796, -0.9643972811152435, 0.6978375702678642, -0.05377877024907106, -0.2366269749220048, 0.5475286873374235, -0.6243571204486122, -1.4015683054524817, -2.370270487948337, 0.5387598260972402, -0.7571390239330563, -0.4813580424941943, 0.06955319118812674, -1.9545675507277491, -2.288953408474001, -0.46087290228117156, -0.7633296109306428, -1.4630678514586597, -1.4273891721503453, -1.7785561183740168, -0.891126366063756, 0.6917802847428555, -0.8019409120980363, 0.2156283611150909, -0.08765894327365573, -0.5718271757529012, -0.1591706673564784, -1.2547054580366097, -1.8292725756761543},
    {0.04077266712452216, -0.8909869116902481, -0.19201278038249947, -2.1961995288633935, -0.33971613074194995, 0.36940034890216017, -1.6061667258583308, 0.4970463634724968, 0.5221504197155337, 1.0421316119523818, 1.3163534152013325, -2.32052950247144, 0.8095159174580573, -0.009992794864407037, 1.110432235895454, 0.896028707720096, -0.7957815849243944, 0.12749066519875657, -0.1091461952510744, -0.7427221380343118, -1.0575292257110882, 0.5104568039529317, -0.6113047272252132, -0.38988217317166735, -0.7305140948978285, 0.028012173695936202, -0.5687387447531089, 0.2911411790047922, 0.10751680355983587, -1.0154827290054587, 0.9466200886475735, -0.7117782503088136},
    {-0.03299731310564261, -1.2955464456678336, -0.6749242018809266, 1.0724434560569223, 0.8132814282556222, -0.6121661796816937, -1.2081039250539276, -0.3024792488535103, 0.5108080587424929, 0.9957237221660444, -1.9751220907501466, -1.9331117716845456, 0.8603834969589302, -0.6718549532256799, 1.7356368021525557, 0.00958204970738227, 0.4494757254650527, -0.17981371170968186, 1.1320720740250676, -1.3231818517295735, -0.03015408428780501, -0.4767535395981703, -0.31330534708874147, 1.318521733913058, 1.301440243659899, -0.3806089867268079, 0.7132105018016929, -0.19055638196049043, -0.04859279046907329, 1.3450376143967266, 0.256318044094243, 0.3345425479115051},
    {-1.4225118895197122, 0.06767231985746099, 0.5601151082808891, 1.6082201574722348, 0.4417252377505937, -0.237677845458918, -2.0033286326907302, 0.2770597747500081, 0.8671200562681314, 1.4490257533765827, -1.0568771250622384, -0.8317517949420202, 1.944298521823471, -0.09404037224646723, 0.06897678788801503, -2.1571657979420187, -0.3772267823125121, -0.8485518415272231, -0.695639716617241, -0.025209854747463532, 0.19994780748352273, 0.28125379249862803, 0.8644421388961115, -1.962811392174899, -0.9540655994632513, -0.4989391232174931, -0.5551708592383914, 1.439258138999156, -0.6909601618995298, -0.17967554196896268, 0.20378183213748927, -1.0860810499300884},
    {-2.807932145608909, -1.4973755834407343, 1.1060853074941135, -2.0989146938173113, 0.2401845517458624, -1.0891676264816534, -1.1575328959885738, 0.6314182157453391, 1.5383356390164553, 2.035942894368157, -0.635051227989224, -1.2391189019278714, 2.7413369416528903, -1.0481987247752613, -0.02587365826700299, -0.671298204720956, -0.3140892496446655, -0.5721308666505583, -1.1200747201694212, -0.6410762090205963, 0.09185853777606931, 1.1868983224493375, 0.8023477901354125, -0.9726043913589717, -0.6566309257575772, -0.028034125287744717, -2.9466755105403375, 2.0942800135956676, -0.644101273655701, -1.2493092968002972, 0.6542707041942203, -0.7202192678350033},
    {-1.622529205478705, -1.1397128191697605, 1.7167837779547719, -0.7880363369205083, 0.8296224344316762, -1.4702173623597548, -1.9264035167355864, 0.7908882710802679, -0.534249890416818, 2.8747972542602653, 0.29294345549688333, -0.1057079390346856, 1.4889383802183658, -1.1165558199193129, 0.39567269254567283, 0.130109383278618, 0.21395026294141878, -0.6891611745773866, -0.9460789072980751, 1.1147067155512869, 0.47457997704332966, 1.4576139089089717, -0.34321651185762037, -0.9220393383307727, -0.14724432674407295, 0.290382857106518, -0.015301830269005622, 1.7264015698953217, -1.172874111350798, -0.40188508045026655, 0.25490821476693776, 0.13867993602934736},
    {-1.5887728546675213, -2.07136540640942, 1.70864071535276, 0.25591478740922163, 1.0074984549945878, -2.2083071997130106, -2.492740253198144, 0.839233569363138, -0.7050911387185751, 0.9813165027958743, 0.4333168054847068, 0.5629670972279727, 1.4567050447952978, -1.1484080119061053, 0.3361628693837097, -2.177027527516523, 1.8270917677666163, -0.493304837377963, -3.1346473466140132, 1.573960160656652, 1.4526039741354118, 1.876926887232184, 2.190300123731797, -3.1224030712926365, 0.38308853505129853, 0.05062492238546738, -1.9653663372313013, 1.563238660291871, -1.5657049216663164, -1.3970216248106655, -1.3207893238080013, -0.029748551531622144},
    {-1.1506934897586658, -2.1912973367389763, 2.6097829125608163, 1.0054842158508814, 1.9218633486068641, -1.472169087667142, -1.6533496610585454, -0.32884933415986106, 1.4496260224644162, 0.4431139403493712, 0.965543508159323, 0.7823557492866295, 2.214929884734838, -1.6940996170522824, 1.91840143627579, -0.5686178710971905, 2.255494238701896, 0.7760920130997332, -1.6064804987157009, 1.618069978010784, 2.4873097085373232, 1.4902043105166072, 1.4609767186934386, -2.4974001898848877, 1.4786300227511113, 0.8937606095798876, 0.21790568122119824, 1.8049211902049096, -1.7558086258751524, -2.916123217015493, -0.23482606191713878, 0.46151005240777243},
    {0.05280039206855691, -0.7559379232545744, 2.715463657659031, -0.7740745762814764, 2.5715279698072866, 0.37523959475952195, -1.7776821056151002, 3.183793575584895, 0.41759112854896946, 3.1854584850873526, 2.392440632777766, 2.1386670791801894, 0.9021646291213742, 0.8620477569367174, 2.0172465568842397, 1.3940888727859084, 1.9215100901755, 1.005181187610387, 0.36095037818027503, 1.6535078469813198, 2.7764770802952743, 2.9940735491602517, 1.2489357783530108, -0.4413835617012322, 2.861824340628169, 2.1814049330209784, 0.3163227711617832, 1.098972040271727, -0.7821621423074067, -0.22852741944825314, -0.9631623462153158, 0.9517094536375192},
    {0.5233323064229269, 0.5165805808705649, 0.710496022496513, 0.25840382308130444, 1.4921288043872076, 0.15974627685169474, -1.257663583086625, 0.011533745429676617, 1.1866052919502377, 1.6512611844604033, 0.6178765632974165, 0.5834929323639141, 0.8569219403624662, 1.2247583543769962, -1.588373881898394, -1.6516532503142107, -0.7841205927880252, -0.12858998444482017, 0.4349528186422865, -0.048792585019798045, -1.7071029233396655, 1.2102929827089335, 1.3643282337362364, -0.7315076391082997, 1.582423576771335, -0.6643177869700174, -0.7156763719612326, 1.2248458905625206, -0.7025083094538905, 1.3948274575880364, -0.07397211775731499, -0.1834660428805572},
    {-1.1257738057839324, -1.41516396539543, -0.46966331661060384, -1.4443419827605308, 1.4634076831381908, -2.057679625695045, -1.7132715438007775, 0.47756955206402457, 0.9971650522481116, 1.4393226543235491, -0.20786970706137475, -0.09612322719636467, 0.23987519800657114, -0.6080742120304906, -0.26058909099886046, -0.1626522652350897, 0.878489948678027, 1.1644225406334403, -1.0655223327108163, -0.037451095808660725, 0.12315919381219366, 0.01614805451370094, 0.9021068096704247, -1.5182271548419868, -0.6944198152208159, 1.175404630767675, -0.7238662520586076, 0.5565583219026695, -0.07077546876292987, 1.7262268984048732, 0.19066863374290016, 0.06941438362666137},
    {1.0780886523386082, 0.3987037242247413, -1.9405842426020365, 1.3739386187004685, 0.7713886009318071, -0.1655602119842313, -1.7852421686022157, -1.311338672372627, -2.4132594184762, -3.1568551106677214, -0.3497871633449827, -2.228863960710134, -1.0975372243316652, -0.7377411775594298, -0.7680115189948498, 0.7817408205003442, -0.1963785979793753, -1.874054860934003, 1.1838369517528262, -0.5810661392756298, -0.595511819646122, -1.941525470947611, -0.9667454624336516, -0.793915063994144, 0.6561103163154423, -0.489778006138847, -1.6040881083158318, -1.8916997720240514, 0.5313940965060433, -0.08521587643379692, -1.9727447351764333, -0.30667486644629915},
    {0.05996811740648335, 0.19279188152196075, -0.000617223759487959, 1.4821718480117487, 1.14447208671906, 0.6302134133445763, -0.1554890155897642, 1.4115602645067071, 1.2131285617832215, 0.5830436934872977, -1.0166532310483811, 0.19369245629239626, 1.0897406771812692, 1.1379462880199565, 2.10201839563574, -0.04047894571178283, 0.8391917692908395, 2.1131366370986258, -1.0668338267871766, -0.507886302001649, 0.032006926927857504, 2.2931343730256475, 0.8238275464294971, -0.16853904267158765, 2.180109222466268, 0.6719041775524626, -0.6061922898749401, -0.07971219169307683, 0.3045202758024465, 1.3442418613010496, 1.1977051246501842, -1.2916880751452549},
    {-1.5815023160621242, -1.6354024578077082, 0.22641461790969175, -0.03986780209086648, 1.7459723052759781, -0.9335838365651022, -2.3212510727958064, 1.3454972720231768, 0.08594169644522019, -0.8089646568472805, -2.8155809836921994, -0.6796365101660653, 0.9795083748648811, 0.6359436075626477, -1.3325495273651027, -1.3325185044212349, -1.5544992116438365, -0.010616367410669597, 0.37686683848605784, -1.4203815399829218, -0.8782408895522237, 0.11036435327291584, 0.2995265236093694, -1.879262740466864, 1.4786324202974188, 0.4788125018181266, -1.9838234308061335, -1.0268811516550265, -0.48924262006319963, 2.1011293147697727, -0.7724620742664884, -1.6212007781288482},
    {-0.2983002602004057, -1.4248296395402331, 0.8698641679002357, 1.3536863383913278, 1.2938451152576849, -0.06997953178977515, -1.1860179077174196, -0.3745435607449523, 0.7949726059659763, -0.5434926220582794, -0.027717960726085785, -0.44708618643216663, 1.098540603989514, -0.6328529135440395, 0.22044518436522983, -0.818727299373194, 0.45466565783314905, -0.1383781488916387, 0.991921076174444, 1.6315947243818216, 0.5621759288158344, 1.091324619922571, 0.5644536063908404, -1.6961000331537175, 0.13944419738753994, -0.22375837097116055, -0.8425704735184637, -0.2802835597276978, -0.3479821714076903, -0.049798347304525654, -0.7777028428175371, 0.29534760034589636},
    {0.9517740963098653, -1.0819788508669284, -0.9000450679638909, 0.5401808329454826, 1.3762756222555061, 0.43608864940484815, -0.3875589607436489, -0.05646808500607404, 0.7361354527296201, -0.05736014376742697, -0.8478996818915452, 0.14112897793356988, 0.6405312261753582, 1.5546246966735477, 1.6174505757200743, -1.496070564847477, 0.6894986561198131, -0.3987602044794803, 0.607714817373819, -1.3297462851025716, 0.2668252409900838, -0.1615034765615657, 0.21389320793965258, -0.02457363562474585, 0.776733411578849, 1.3695857259120505, -0.35717539825310374, -0.4345247126541552, 1.4808843164877037, 2.08854927580531, 1.3772370123918294, 0.6433685048283441},
    {-0.812347187714533, -1.1806625731461693, 0.30066706519227726, -1.3152868695079363, 1.964565886678542, 0.10370275447302625, -0.7746271967294686, -0.23303514340787895, 0.45151932402822975, 1.3538856630200413, -0.6004115294155655, -0.8084594794198279, 0.2687472676108051, -0.7244757446000349, 0.6072286136396041, 0.6883226550499564, 2.4636731634282527, 0.6359628925371874, 1.6465483359333966, -1.490610060211867, -0.24264361572248655, 1.0995620589946333, 0.7741715586476545, 0.6143397587431094, 2.3663280257480364, 1.3232925255244012, -0.0765916012908209, -1.3057878586165095, 1.5737122999395052, -0.08713600983654529, 0.32130918770567213, 0.15872819306611693}
};

static const float b1[32] = {8.536549476598156, 8.606466611757723, 8.075438005116233, 8.591839994467882, 8.47080113783152, 8.705708348998572, 8.71196577100627, 8.178323718834822, 8.368316456039471, 8.363880297552189, 8.458573796069723, 8.594833131086036, 8.246977798866562, 8.583591840688081, 8.644331671600408, 8.648343586786266, 8.38831142344864, 8.450619920262142, 8.588142134022855, 8.56621038872057, 8.429762265591082, 8.24697741804832, 8.171816301951857, 8.515953854582229, 8.456840940857303, 8.647293625545734, 8.720101467224504, 8.123068034856777, 8.644515298183222, 8.503727774401955, 8.798451820614892, 8.52590917087418};

static const float w2[32][16] = {
    {8.207404891421278, 7.925372588907377, 6.834828554811571, 7.741030774052799, 7.4009231399665465, 8.119796934323777, 7.820753781967225, 8.112113407601901, 8.387253781127841, 8.476654007346202, 8.228325080196628, 7.380694409623769, 7.537720383453452, 7.916741262937568, 8.21158663628734, 8.12245602895703},
    {8.030760139679924, 7.765618159731649, 6.520751153325658, 8.093524855458222, 7.720530082419309, 7.642690803921464, 8.133764603977584, 7.51562068925939, 8.043041508000828, 8.076502473800547, 8.293227657482294, 7.581258846528672, 8.05793596175897, 7.8833390380638555, 7.992969559134104, 8.507220058559128},
    {7.397551922578928, 6.771718612088648, 5.961224794591505, 7.381798327972388, 6.158335174374851, 6.8041178961722455, 7.154994659473551, 7.358347496098589, 7.024170644789535, 7.078546993005868, 7.317560012334573, 6.472901667130737, 7.1751414290632045, 7.386647079318812, 7.238135507515903, 7.333921563656057},
    {8.019249476699196, 7.665103864383223, 5.886538706426018, 7.5809383363595755, 6.923547092497069, 7.840668501818697, 8.1877780648747, 7.949003584174574, 7.444772188214997, 7.278531552691835, 7.713862647201427, 7.033282033586376, 7.628790177926647, 7.734430345293927, 7.373237317140828, 7.712394196679271},
    {7.741953127290961, 7.472380122118809, 6.529029449547283, 8.074041268247543, 6.817305212960231, 7.846169412243353, 7.727940866280106, 8.141342320562194, 7.603763905813185, 7.809425455256708, 7.5503332527852995, 7.340491676522773, 7.838230512105935, 7.790584059090536, 7.480828312162513, 7.95303974708021},
    {7.881070264729124, 7.304592077422696, 6.389616770743787, 7.8940988241460435, 6.828856860024214, 7.743510831232851, 7.552103270151094, 7.485274703233965, 8.575841517713485, 8.049847888234742, 7.852034695916168, 7.025135070658816, 7.785946250977404, 8.274247523594537, 7.660892360556978, 7.8711149036573875},
    {8.042114196370076, 8.014304422982553, 6.619954010088236, 7.980979420016496, 6.951896404789703, 7.588319253260763, 8.135975562766477, 7.923202396726888, 8.214266716675452, 7.383291031264343, 8.476196736149175, 6.889164457582443, 7.694180712720616, 7.718287585345001, 7.951327994325745, 7.93049911269978},
    {7.490870673400003, 7.205606037445055, 6.390351981721419, 7.398179163892705, 6.34673389163567, 6.660279142923066, 7.00084950974156, 7.5234333089480625, 7.270803545082578, 7.539529001627317, 7.648557527323449, 7.089612945610523, 6.9901322252646105, 7.223797637595317, 7.404468665499385, 7.157655940760565},
    {7.902866441237179, 7.092188328857246, 5.9748072789240165, 7.160777411375111, 7.132283273665915, 7.456637583403882, 7.648642718127026, 7.456201743400755, 7.553570276887163, 7.484678926738962, 7.508891003589931, 6.485433677936125, 7.592368701499833, 7.408401609976202, 7.193537899340319, 6.817902759639298},
    {7.333234680153276, 7.104993631840022, 5.966638142203328, 7.393158934355694, 7.038483560296795, 7.504927641402212, 7.673845240529337, 7.189876519025078, 7.627963808988399, 7.454939007378194, 7.666246552405935, 6.79722246777578, 7.2359266023419435, 7.257590738837608, 7.346860674265251, 7.6696876923685835},
    {7.91326724578999, 7.224082871978596, 6.6619619359482645, 7.832016740810054, 6.955556930249064, 7.4427382875399015, 7.579670878051234, 7.856148473932275, 8.188384106484389, 7.319955939103699, 8.078898170521667, 6.357836329329523, 7.602729804474594, 7.6711194947846995, 7.292839607075123, 7.517052689433287},
    {7.637350835894602, 7.5720247650901475, 6.033320178693939, 7.545274398478288, 6.956364791548873, 7.655044390105641, 7.760859199022861, 7.817199928542095, 8.190960318507244, 7.9548138787349325, 7.706923502290442, 6.690562757711025, 7.64982500232958, 7.698441493822264, 7.416023473366378, 7.718168821940153},
    {7.0427754017893225, 6.840246465166896, 5.790022085938928, 7.174978694835882, 6.570202580042774, 7.003481122403767, 7.671985435257809, 7.304667995179525, 7.3211622192607155, 7.387723109052063, 7.407723278014059, 6.806099771904187, 7.260697003875101, 7.386313810968718, 7.555215152170741, 7.3146074555977245},
    {7.359038891898967, 7.453865271193384, 6.2688322183771925, 7.768671927813978, 6.772757002709071, 7.832780314321654, 7.99386495827178, 7.249492673747081, 7.905047697048271, 7.758198133521241, 8.419202789671854, 7.315804500749254, 7.577305527733599, 7.631786449776048, 7.7064200001674115, 7.857980565431692},
    {7.835645438297805, 7.258270070961333, 6.398389604544101, 7.542958304189283, 6.6841328700710285, 7.1361467228417865, 7.982445740507015, 7.343016462380653, 7.54396469429246, 7.851639477336903, 7.377407237755173, 7.016466714706231, 7.44067463560771, 7.314327659991046, 7.470369198029862, 7.6652297995746475},
    {7.872242137433401, 7.394187806788659, 6.360288768753836, 8.671311264702288, 7.410550772167845, 7.87338880851886, 8.030526324045635, 8.074832983856222, 7.668263156942827, 8.051953268605834, 7.595413019700794, 7.314758356751151, 7.6351862425595804, 7.7982331429983605, 7.683275617454116, 7.945654564298564},
    {7.550154387156264, 7.673894435203368, 6.4985185224068855, 7.96719535000382, 7.086426739262456, 7.3584751980911705, 7.355368000785588, 7.276599625715873, 7.667084978399355, 7.407066869075385, 7.885305418693748, 6.946888837400861, 7.6320766553365935, 7.666192044610418, 7.973251823405694, 7.528772017514857},
    {7.515680275260043, 7.4036240122070645, 6.397197031540117, 7.879921627578502, 7.045615078760493, 7.629332383133455, 7.609445132105554, 7.986781247675662, 7.478608655126821, 8.072300909592302, 7.872839610414748, 7.515497974623668, 7.757064060232433, 7.6471021804429125, 7.880774590441227, 7.573100851819485},
    {8.061006761814143, 7.301119638421813, 6.513866981349029, 7.796669610257333, 6.589807366372043, 8.242352021270058, 8.178547485377655, 7.866947535386064, 7.447356194699476, 8.03790363454755, 8.177831008504091, 7.1596417167742485, 7.739099707236997, 7.954761635574691, 7.748360449703245, 7.8211999114045705},
    {7.4219379150427605, 7.263779033003989, 5.996926115570339, 7.476570116108325, 6.5935100379371185, 7.444915349383052, 6.762624904440333, 7.552224501899932, 8.03272669216582, 7.739888413583828, 7.526619385301348, 6.955661852033097, 7.837308181397354, 7.655474839468207, 7.490134711843573, 7.4671766668973465},
    {7.40222407123021, 7.022862255555155, 6.4126541745818395, 7.817288818547306, 6.806902845865344, 7.599166771872594, 7.502335262343519, 7.7992812897435, 8.108783668091963, 7.147747179672526, 7.786312947295287, 6.85825444703246, 7.877794874322112, 7.2678935535017075, 7.350538200917976, 7.558372201269748},
    {7.598538482414306, 6.906583195943473, 6.388894993893589, 7.267506403531144, 6.694605859230804, 7.405582005039612, 7.6734824567018585, 7.1717700701144045, 7.655453435656431, 7.37354160696909, 6.795018755016896, 6.210102031669247, 7.324879855513577, 7.459941697988614, 7.1779756888604, 7.042540694166311},
    {7.3348965007762885, 7.39401785106699, 6.535523183199834, 7.427295249875675, 7.221539751250256, 7.09608302644662, 7.396944017250418, 7.588632647757536, 7.082303565010197, 7.719582741446058, 7.641497497201234, 6.8061195820990426, 7.456541729731995, 7.0655118691996215, 7.455642044915149, 7.464463632957106},
    {7.589289127665759, 7.457169025691235, 6.436680700740479, 8.047901572682276, 7.1534482886399235, 7.9648289997556, 7.880414188495755, 7.854080931617331, 8.114941420675539, 7.915607813552123, 7.780573624762299, 7.589098732953987, 7.827876612010973, 7.851013662869202, 8.139265041692656, 8.042975810857998},
    {7.143079790259056, 7.033424772905156, 6.248659687454774, 7.268932380762714, 6.438743305279143, 7.246014522166475, 7.566567072835511, 7.276078708030966, 8.158950753409817, 7.757842171764546, 7.5377761270598596, 6.798651863939415, 7.5619548410695385, 7.143899683637388, 7.126197992571144, 7.684268343256546},
    {8.03980589994301, 7.836994030134186, 6.1398325519421295, 7.382960203327325, 6.944697819880576, 7.794468618199816, 7.818876732457523, 7.348994641260037, 7.734266154171386, 7.514959280722736, 7.975387602762051, 7.043983119881281, 7.343907288295308, 7.710674590669531, 7.58824877419153, 7.512505956972514},
    {8.004452255797776, 7.623284813537301, 6.62837069875488, 7.935195856714715, 6.615230727999988, 7.4452741909584965, 8.269105610385658, 7.457232784193652, 8.05260109220635, 7.460583969803046, 7.617062294305478, 7.513219543807219, 8.183367824289833, 7.727292177287155, 7.895771157009069, 7.953117650774586},
    {7.238195486186211, 6.618173687939726, 6.02550753255582, 7.266609621333103, 5.930330200272803, 6.826095169244781, 7.372146249653332, 6.94788423715186, 7.301261548198573, 7.230557129939907, 7.651274899417165, 6.175698300238131, 7.02792937934344, 7.5041405783954716, 6.683075540571089, 7.5842063282652585},
    {8.214088506073164, 7.4568464771068275, 6.577447356110421, 7.702636926246142, 6.733220058855126, 7.407714578318008, 7.800142517360068, 7.89444649979265, 7.863665622095366, 7.841662949797894, 7.890688918044839, 7.2231170384359755, 8.085177478419883, 7.756028379849689, 8.229873036673284, 7.69486646678344},
    {7.451567065194675, 7.372387817229896, 6.397295117829612, 7.369335480597977, 6.452917614413421, 7.703500775179591, 7.396831173061902, 6.998211366706748, 7.648308108126952, 7.687589962285435, 7.6797680370674035, 6.757351298530086, 7.698180573234521, 7.982147107715267, 7.135178939187803, 7.651817494888732},
    {8.03505368354429, 7.812301310085896, 6.359122055241163, 8.13055222187408, 6.893204049584607, 7.6998991057291875, 7.471561075682225, 7.711093792989383, 8.223355314298098, 7.91417059686486, 7.689579354233974, 7.3176549872955, 7.884530341342508, 7.444070750094467, 7.7312797844237, 7.6771020002869275},
    {7.852044103095645, 7.721713447786772, 6.299433299539307, 7.812629866337002, 7.398461016751326, 7.619614713761952, 7.800937085392044, 7.813610068660958, 8.039495002417784, 7.806844021505787, 7.913488478637713, 7.154996099014406, 7.614883684091037, 7.87896173106323, 8.204556288320966, 7.928370413740872}
};

static const float b2[16] = {7.114940948359663, 7.240863059184048, 6.263494629197572, 7.276326589128095, 7.02730916004819, 7.13297412947107, 7.1866871702024335, 7.283831589806793, 7.2453608112618975, 7.172891103068649, 7.310608294485642, 7.104932027991426, 7.041986081254545, 7.243918599132958, 7.1731129754903415, 7.18070079624297};

static const float w3[16][12] = {
    {-5.226859381672505, -5.363624490927382, -5.106436491171454, -4.872246109535647, -5.641188605224183, -4.989426184941663, -5.657317439322679, -5.433695759497902, -5.171091637571164, -4.991133729523709, -6.263228395744841, -5.344119666652777},
    {-4.5630107535717634, -5.90171874881767, -5.253295539149412, -5.148245215626226, -5.195583237390103, -5.2885556464983265, -5.37558664996503, -5.78902418065918, -4.999803699817759, -4.712586068439983, -5.385132997253321, -4.485987656385973},
    {-4.734750283197377, -4.230595787720586, -3.8624556206318426, -4.90018703063413, -3.8266946512638356, -4.263413132747233, -4.067424598016409, -4.556150707267944, -3.9607797690152298, -4.934056710305957, -4.410692749191835, -4.335145791425971},
    {-4.553969846380831, -6.010169996918444, -6.138193194926166, -5.657250382356012, -5.28084481819038, -5.62252261325142, -5.413392022663815, -4.990247168023492, -5.604953589501551, -5.791720745572215, -5.258627047900826, -5.5157603406801785},
    {-5.2056603748305, -4.722912102504841, -4.761571321536456, -5.0631023570876454, -4.381849823828345, -4.672114470478941, -4.693292119468627, -5.372836242048776, -4.983897541428963, -4.33769034775051, -4.748334019565959, -4.757743785602798},
    {-5.857107676433504, -5.110326964317411, -5.733416198210286, -5.094824074792497, -5.970938329143211, -5.0875181752941305, -4.898894217266799, -5.740443416611334, -5.116178716496381, -5.4649942086382195, -4.31593667355003, -5.36448782190207},
    {-6.231192448927011, -5.705895614958431, -5.412213152237443, -5.632473819020888, -5.619934316682547, -5.789004204390036, -5.12843484751198, -5.5470035919049465, -4.698437774678677, -5.346341137385841, -5.347168304191766, -5.042496478812246},
    {-5.416027079118684, -5.112202208537233, -4.834865798848124, -5.486786152935598, -5.5085223554728735, -5.453548756938492, -5.562974713673556, -5.199057343512679, -5.222161506294235, -5.123564416825938, -5.482247325085345, -5.5415329676470915},
    {-5.43026755879952, -5.48828955943712, -5.366464021658231, -5.037175174334121, -5.143577841955255, -5.525809778118744, -5.2618068540539165, -5.294850591624127, -5.815828888957614, -5.2722221577631805, -5.294613651359078, -6.1802664902284},
    {-5.250415533523273, -5.587783062390764, -5.448530736245421, -5.703209363088584, -5.201935791714441, -5.209579451400806, -5.85025257689645, -5.789678603632244, -5.1121520775348746, -5.488667141607125, -5.136270342899556, -5.180429270048839},
    {-5.764145513006343, -4.992200854682038, -6.034688737987173, -5.162636621084914, -5.259290452334323, -5.457009113214722, -5.368395278848627, -4.708262296721256, -5.440245187659525, -5.3115875797252485, -5.507791504283462, -5.612249423106452},
    {-4.670090308698011, -4.549927898880987, -4.395515324202335, -4.346672490317734, -4.71016841798885, -4.930683477857395, -4.607756077640434, -5.121152609945317, -4.607977639143622, -4.659681873836824, -5.031041092731631, -4.9087619520139185},
    {-5.201171571647462, -5.434208413060997, -5.6763444471078905, -5.4920487821025565, -5.497401766574074, -5.314829907592102, -5.53007894657382, -4.839229504291458, -5.997416536873107, -5.9176912488485955, -5.569022912129667, -5.742999707615767},
    {-5.288246736924208, -5.56806853365892, -4.686956079333256, -5.716177093863593, -5.625645686537321, -6.028984067349526, -5.334053000579269, -5.052600944458649, -5.314397930104256, -5.920053684436743, -5.834014199093965, -4.91572899156967},
    {-6.0985185260045816, -4.771050675569364, -5.419669067551501, -5.007651467986983, -5.189340683881459, -4.634898019834981, -5.365074589074202, -5.545744706522013, -6.038920028162759, -5.403757773149072, -5.130946450383231, -5.3894973327241535},
    {-4.3650957049680335, -5.192056107776392, -5.516636412218225, -5.542545480580675, -5.619498671991579, -5.504687653710153, -5.597893579376609, -4.9641583632728015, -5.655344759773405, -5.149440564151693, -5.080529057541075, -5.443158050047372}
};

static const float b3[12] = {-3.300827807541977, -3.7931021106035483, -3.5215854232718287, -3.3251398844243933, -2.1762513638907297, -3.2141589718006918, -2.8174466260385365, -1.8292985507072927, -2.52826635896707, -2.7456008602629693, -3.6931453413693416, -3.975550615493823};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
