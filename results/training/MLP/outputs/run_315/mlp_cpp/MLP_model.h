#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.7127075280623909, 0.4034379255631768, 1.7273682818061622, 1.8990660378854656, 2.4012416716452116, 2.8927691290829176, 0.629230031771365, 1.5000059756520485, 2.9181153947300476, 1.9979899749466503, 1.0462171656946482, -1.0981766528631178, 2.8283648010578006, 2.49926422341301, 1.696028936669112, 2.511365850794324, 1.2618654165421255, 2.1315601477317325, 3.0191177301856347, 3.4224767658265183, 2.6758601236588264, 3.355226512795997, 0.543548940243479, 2.9037226355370587, 2.130091261349956, 0.8348965989881908, -0.13630625710644673, 1.5915564498675352, 1.5526226395019445, 2.706291607740343, 0.3643143701887416, 2.484325547154127},
    {-1.5536917579126301, -2.0390293247732907, -0.45342760249489084, -0.23536597363117323, -0.3656990609459022, 1.9210533019412075, -2.1815206494345762, -0.7518096352967164, 2.248624865985093, 0.6225073600449299, -1.0665482729778522, -3.1333566620551814, 1.1655297955184294, 1.233211751234217, 2.1602755370389017, 1.4749787620477184, 0.02649844354683079, -0.06395825949909785, 2.7140984357902487, 2.4951249096570627, 1.8187961077814114, 2.835875494263802, -0.5633893528627397, 1.710555373559565, 1.343846622392688, -1.5061249620045332, -3.1648887551552507, 0.9246700384217205, 1.0370542312262507, 0.22231139411192427, -1.1594790251890577, 1.466094277257371},
    {-1.4982767314930976, -1.5469077549518668, -0.3105114188573852, -1.277427331267662, 0.0020328742730864706, 1.0913765017437924, -2.425891171957332, -1.0289076281655358, 3.2694400888146165, -1.1199084085124495, -2.3218671663565407, -2.740471817301515, 0.258789365408963, 2.360661860235475, 1.171053646514507, 0.39148429396117446, -1.6433110323890512, -1.3739868616700786, 3.6456752425849177, 3.5162457257323863, 1.4886375599003803, 3.4621392188226854, -1.788672955536931, 2.575291154346861, 1.6083960655123, -2.099741786815322, -2.774202624129413, -0.6788099811023348, -0.20445441214676469, -0.6182726744593023, -2.7155611436408695, 0.8913554107256146},
    {-2.966987359979532, -3.0522428700053177, -1.9979916210151643, -2.0963974838166233, -0.7464644502200213, 0.643906836103323, -3.203163388329803, -2.485329911944073, 2.415818873242007, -2.075827848549944, -3.144654020907785, -3.623187862611286, 0.1056995339740596, 1.0863455548296965, 0.43741676548311453, -0.5969059065096645, -2.3335239504375735, -1.6026780425780633, 2.685115895690862, 2.8395770635491226, 1.3158332487355666, 2.8766747693457138, -2.9655722536862763, 1.328336792928538, -0.18728582317834588, -3.0014559494093294, -3.670989114506943, -1.9486002235310094, -1.3149923535686596, -1.0481093470985754, -3.6516686158924236, 0.7620253857118601},
    {-3.5980698782117866, -3.256606340228305, -2.664805161502516, -2.81651913783598, -1.2018616052864295, -0.7823451803395263, -3.5454119826610677, -2.69026502376523, 2.013409164851487, -3.3242630302761045, -3.5230267051960134, -3.6294198743512047, -1.381244485486651, 0.8303053575410896, -0.8937381018488731, -1.9297045140444136, -3.4906490458711277, -2.7713544351205863, 2.5239652781838653, 2.24724296890658, 0.3037350585566885, 1.7429772028982777, -3.4042666086175437, 1.1593424284736933, -0.9165495645817529, -3.4240251549249714, -3.7584706197149003, -3.324586168069155, -2.340109489819963, -1.6104742647603136, -4.15928074571438, -1.0102603131088068},
    {-3.2548784790212375, -3.048157081428565, -2.81152733682368, -3.0245833952148233, -1.5555727600031837, -2.0726876259087152, -3.7863205424598965, -2.450706501408381, 1.4835562988485087, -3.6664702658323187, -3.6729739972032243, -3.2877826236893384, -1.996765226807452, 0.6154102033285765, -1.6647274232634743, -2.2084988421416027, -3.533116836822588, -3.2680070272370623, 2.098163738121709, 1.9504641634084665, -1.059301588852288, 0.5010100687076589, -3.459069622829201, 0.5855454417848863, -1.2656742529968996, -3.5140243806071174, -3.623895782786114, -3.496008758912185, -2.6406300701378655, -2.3667948601249753, -4.060907751542551, -1.8403197834273757},
    {-3.4053657071185666, -3.174984238717571, -2.8678780413970095, -3.1049191552490107, -1.508237050092937, -1.9070154309051566, -3.743868013647056, -2.32410611757249, 1.1369292757854546, -3.413495912688919, -3.6969502104231258, -3.7230835723147133, -2.402744229173043, 0.14225185791647066, -1.898931192211749, -2.40120335104126, -3.4021798377264933, -3.119453449528149, 1.9124594254584648, 1.4370719073293905, -1.4179502991202917, -0.23317241838905178, -3.3464970058440473, 0.4306003437432827, -1.3730495478816171, -3.402741251040138, -3.916432183208301, -3.282702863820132, -2.8680040597018155, -2.6764574780034347, -3.86382298753348, -1.9805981197821922},
    {-3.432212157503475, -3.5785084893133714, -3.2452189696393483, -3.2441521564182043, -1.760502373863273, -2.002303032241048, -3.8886033678403082, -2.861266348951794, 0.7812503429858287, -3.335895998218696, -3.686884250955879, -3.6997838179360083, -2.086568850191454, -0.6225748987426832, -2.072479204048611, -2.1327832973177583, -3.4237749590996667, -3.296591988553744, 1.654305475591558, 0.9037718801194548, -1.3505702290518422, -0.26590461333723503, -3.904269874012551, -0.480741874324908, -2.295996573360412, -3.2827477958011095, -3.9929146988053534, -3.3177491878495875, -2.939778172490255, -2.6144927141957233, -4.415524150541269, -2.033748951196891},
    {-3.6661460688733856, -3.7013066677864357, -3.318465965188666, -3.048119844609106, -0.9456823115112688, -1.3374913603897935, -3.741092110430964, -2.9105789009092327, 0.820303246906591, -3.1034964090139048, -3.5065877872083457, -4.071398816892262, -1.514252138597942, -1.0274613063162032, -1.4541820756302386, -1.3166562891580322, -3.143922600965936, -2.4385106862160475, 1.2131779263213227, 0.9375374862153745, -0.34146095580295865, 1.119635098158024, -3.9896040996124547, -0.7609953863499046, -2.5117331289229385, -3.3011002288579956, -4.044326139558019, -3.3989421416465575, -2.4636479170937515, -2.6663405114125864, -4.1437204187472405, -0.9238333297420406},
    {-3.680248259369643, -3.322767557951939, -3.152466985374779, -2.626132598190887, -0.865731292796828, -0.5289112259068177, -3.25855182715792, -2.8137194383973907, 1.2627245017873245, -2.7135448141274483, -3.730242921201212, -4.167066365201184, -0.9728610324680705, -0.5829245610098245, 0.025469735196916227, -0.5266551648776893, -2.690703611363508, -2.5182349546625065, 1.8876174334220825, 1.7482168186755482, 0.5889256398761176, 2.325937295168704, -3.307161437620551, -0.33633982017231623, -1.8001141246621728, -3.2889936046106607, -4.031447231861338, -2.495011621029076, -1.7040992610874988, -2.382110544300713, -3.868528522106477, -0.7782658847773007},
    {-3.7508329316202436, -3.403178973749767, -3.0763681914094203, -2.2774763034895327, -1.505228228863739, -0.3138846850674823, -3.4360032047584146, -2.9373500208957086, 0.8946289363568382, -2.208416575474165, -3.291935121735492, -4.207449539935138, -0.55340995996728, -0.9830776410728871, 0.5644862709163055, -0.9663096750866081, -2.318001205322758, -2.2386659603027845, 1.1789591515744913, 1.454939627784964, 0.39655973630895563, 2.2202001666496947, -3.2691905692402097, -0.5598631383588373, -1.9074017287993124, -3.3868415566021013, -3.8609672175511887, -1.8382598779085675, -1.6749248732885977, -2.2959829455884546, -3.4150093811945643, -0.36201648149127325},
    {-3.3667864694254503, -3.554691497151025, -3.0356974459024877, -2.954437633105362, -1.3577014029940444, -0.5850987094387964, -3.3751511732916226, -3.131287297900077, 0.21715256300996144, -2.1569267858755468, -3.2879458699001933, -3.9024132689644446, -1.060248446057288, -1.4042247587784564, -0.41788213536490315, -1.287333055596459, -2.4231782394376764, -2.158105438273976, 0.7396300850567391, 0.7567594427700275, 0.5023771648842039, 1.8207911329867263, -3.5267056318823373, -1.2109744372837337, -2.3425646976037027, -3.2674841671166592, -3.701446408182988, -2.230724689760918, -2.0699399796604325, -2.860880125087718, -3.2273821271762553, -1.2200413854033063},
    {-3.1521704928954675, -3.1241874027072347, -3.056525432308678, -2.9711988867432124, -1.4121936201221594, -0.9501437596008029, -3.6738798776364168, -2.6821582893918854, 0.6896945608399621, -2.341925515125877, -3.320450165940238, -3.856538209144545, -1.3488212848132215, -1.0751409807344436, -0.6359810283035581, -1.6208853003937975, -2.6667191593961315, -2.3373148279225204, 1.1245416048379389, 1.0236530837050177, -0.05533685244769808, 1.8312765437025373, -3.2943362113838544, -0.9524869001498881, -2.172891855457225, -3.2360165224416755, -3.9594769888317245, -1.9110371417280174, -2.116150980891348, -2.6141307895690535, -3.23240679802229, -1.3498693011181264},
    {-3.4491248698027785, -3.305550054532413, -3.03084423766006, -3.2012893687008654, -1.66340918563845, -1.6018243396628824, -3.723177031061682, -3.287572539627021, 0.1294918168103969, -2.871603676617169, -3.546551825329264, -4.103606270950163, -2.017730464539597, -1.579219900880365, -0.816621742491243, -1.9064977234944502, -2.8109314571324973, -2.76179875321981, 0.7530886048809631, 0.8431155108601195, -0.754404789016283, 1.5041521915139164, -3.23320509710264, -0.7167420390405956, -2.2372648338198045, -3.304276075155775, -3.864927644030186, -2.3509234563180867, -2.632169101227168, -3.1454248401789466, -3.5105143082103405, -1.7441617615274903},
    {-3.316064405534016, -3.3106334647502624, -3.1325930359387972, -3.1214165131603977, -1.5327800411115489, -1.3764274907330163, -3.6744505132823644, -3.1154398404996257, 1.2898667442190292, -2.770801457107034, -3.359476722820185, -3.3747292312312984, -1.816192678197032, -0.6684081957569615, -0.9463129846008688, -1.7138857399773118, -2.980841794731483, -2.6308917924779154, 1.4386317800681832, 1.327520172589538, -0.3402358999458415, 1.4230278890230326, -3.077653940434491, -0.21231247223619654, -1.9961979123795368, -3.4308136834160368, -3.8018569624047327, -2.4552596690206245, -2.045291795769758, -2.721707646096697, -3.422612117943153, -1.574658931455714},
    {-3.7046020388784293, -3.3870280512841773, -3.1280796421943604, -2.909719473367544, -1.8999935895288853, -1.5916807537757982, -3.5661525484715226, -3.390423961984528, 1.4256519834455765, -2.845456392252083, -3.4881664690947214, -3.9063894373244707, -1.6682908672152654, -0.21745393679003217, -0.5276678162222801, -1.742954790092398, -2.9696938079667152, -2.645911411788182, 2.0855613888195723, 1.9501655965000861, -0.12753857259342494, 1.6842189651872574, -3.560548740857442, 0.05058271257243404, -2.018005175926239, -3.507015634934751, -3.8838290901572248, -2.6796617801416827, -2.0425979600013418, -2.741871377165212, -3.821007311127054, -1.4118716836693421},
    {-3.3919421186631897, -3.288681718507609, -3.0708372818119583, -2.4416691032611606, -0.6786587768194372, -0.7464333660330548, -3.3064201987116704, -3.2442135117955933, 2.182827388339568, -2.3145440319189245, -3.2230329061818823, -3.860572860076832, -0.7391804590433275, 0.6723210899984833, 0.14366472226141977, -0.9485107828510795, -2.5603281296695926, -2.134769285497592, 2.536742092976527, 2.49768684650742, 0.501751508678985, 2.5659339072819005, -3.476630922649868, 0.6031661468972138, -1.6573425962509274, -3.303288341131501, -3.868381873714166, -2.538679267046065, -1.8346452348815043, -2.0877938432391567, -3.7756130903616225, -0.4622238865632274},
    {-2.525732418107179, -2.4036460728871565, -1.7581961560342074, -1.6931319557107618, 0.21036069154026654, 0.5979551254685601, -2.5784382398856436, -2.2854130956742855, 3.118140163180769, -1.6329473206136, -2.6478897359315274, -3.280511422996168, 0.08499460254013319, 1.7617966284839293, 0.5632130913816142, -0.22125598551844622, -1.8134198877262853, -1.0185943310453691, 3.2733021674638634, 3.470234555917818, 1.8395057710827878, 3.628976315308703, -2.5979109276818604, 1.5209542267785923, -0.5368386840789462, -2.289352007270066, -2.6958666429559095, -1.1552829210417375, -0.8001355869228846, -1.2216843859639608, -2.899243785243501, 0.7534190016753026},
    {-2.20003330124394, -2.477854785535834, -1.9323666801464754, -2.1676183984480626, 0.2508178666897817, 0.31034336255356626, -2.6904249349774774, -2.1995801750712234, 3.0704417707050924, -1.8557198109763027, -2.821616543350485, -2.969423258033414, -0.5788757943232253, 1.4596609646372352, -0.07558482676775548, -0.7534685346172398, -2.2868720316706486, -1.7275367444148058, 3.2587214283736365, 3.090258097489355, 1.1999035101070654, 3.063152847154159, -2.4478916244718594, 1.8890792576581412, -0.3703216573126574, -2.73562996362131, -2.9943936800622257, -1.7279633593819532, -1.2338677273909757, -1.5435931271157541, -2.904250400281667, -0.18401431996164344},
    {-2.9751194891148005, -2.964302821903731, -2.4303041751000127, -2.6325941215659117, -0.567315969387543, -0.32983383518226506, -3.2002488938594102, -2.8154809312153355, 2.4944725733408473, -2.1650172790082403, -3.1773025240604507, -3.5869008499485764, -0.9684083021833926, 0.8299015028183375, 0.0011697678017553981, -1.234672001721022, -2.607149665811586, -1.8783553901655259, 2.8301196911969475, 2.7846409491431108, 0.4887284451632436, 2.9486594489961457, -3.023009282400566, 1.1285280701174427, -0.9636295831630776, -3.1904674546037324, -3.697749882015123, -1.9258604723050885, -1.551082757523183, -1.9009947009458514, -3.349366372355458, -0.3952279058997303},
    {-3.029112897098804, -3.1320775626689064, -2.533037860166342, -2.421891008609025, -0.7945577182947324, 0.26575610523122795, -3.4515673095711836, -3.162421350598475, 2.6234838033286123, -1.895156728813951, -3.167728028292255, -4.092955638849169, -0.670318965880033, 0.840938303688386, 0.8674597278580272, -0.8633005603093041, -2.3541189525485304, -1.6628929715203138, 2.9754536849305446, 3.1994462647019137, 0.9131560514299437, 2.940477700669655, -2.982233527640251, 1.3216942205985387, -0.9001877847229952, -2.8029495578524215, -3.7552314624813463, -1.6543557318227573, -1.2766503346370297, -1.7703856441459944, -3.2157851541639904, -0.09762175178362402},
    {-1.9941751059371247, -2.2014843601191263, -1.60975314273425, -1.3005758397536813, 0.3456204758877039, 1.540938792553334, -2.7299708220201437, -2.2390172619621582, 3.6909282937118566, -0.5922984483295121, -2.2488206517924842, -3.223448384251664, 0.8653536499781753, 2.032230488945694, 1.4530800424822958, 0.5649252537158599, -1.2607715330925382, -0.38600260927184243, 3.701673486480614, 3.47359599139063, 2.6217355966973126, 3.7281591372885496, -2.2672103427187413, 2.4544908004746264, 0.4478818532812407, -2.536628155032704, -3.328974752258854, -0.38609016254463835, 0.1430616915960989, -0.41532953744350465, -2.404560440550528, 1.422333449360027},
    {-1.1639018010838, -1.9960926979890283, -0.7544699361717637, -0.1590781972609689, 1.4187938623263352, 2.2884413039784595, -1.7801156424208475, -1.3219078042213626, 3.728303427359805, 0.47166100481268847, -1.2338743965337826, -2.6678869053842074, 1.5999460956859684, 2.3635712073416024, 1.9614613406935963, 1.2867404198663364, -0.40751603427856276, 0.6168911009800969, 3.8358815005857703, 3.871070175034599, 2.8295110804042145, 3.9040690802365403, -1.2250737158808198, 2.5462828693972677, 1.123779040486264, -1.2642369777184852, -2.6608973151340822, 0.3304356877484813, 0.7870658421098082, 0.6962287741301834, -1.428616358541257, 1.8838902633894792},
    {-2.5116725750601043, -2.8065615104141313, -1.8298341527868585, -1.1465592658036041, 0.3704779012824045, 1.450667550949403, -2.4310010981900008, -2.438682657122011, 2.9260948332347083, -0.6433791726196761, -2.238239803106868, -3.326557788134246, 1.2016451050559445, 1.6850589988336597, 1.722656179845743, 0.5163984382865473, -1.382329993566009, -0.5095009194470871, 3.154402441165178, 3.5437942037666375, 2.2802579817769697, 3.400578858588129, -2.1911259344850382, 2.131056112757359, 0.05336427992565004, -2.0626427896488546, -3.0958024406745532, -0.21258429004338372, 0.30958744144177847, -0.4725867238749939, -2.5375854959172415, 1.0461125831046578},
    {-2.7064740458531675, -3.0729714700315225, -2.358030783373199, -1.0799646134501986, -0.3974779038217801, 1.1315841018740562, -2.7423713167337542, -2.983943184388387, 2.756536955577502, -1.1815603820956513, -2.238630677908859, -3.486091230451935, 0.593971422041882, 0.9231764168575581, 1.6410635888000338, 0.6959502001903632, -1.4497660061376103, -0.5109533709153914, 2.9206562858459253, 2.8343850200288845, 1.9044076522684963, 3.70348105496825, -2.5889460838336014, 1.1491991672443467, -0.4360081312278872, -2.17428353232897, -3.421150989216464, -0.6897708579313889, -0.12888857670127374, -0.8471258517648174, -2.829451894277292, 0.624034165952823},
    {-2.613722469712428, -2.2983250664842902, -1.7778035831888306, -1.2550407341145675, 0.37957568798302377, 0.9858227433799263, -2.458374634854242, -2.4848693786093015, 2.9529962007005404, -0.9029587613426036, -2.1498678219895377, -2.843358181884171, 0.5211930024253122, 1.145887299608596, 1.250974756842381, 0.1483291478047257, -1.140631697915186, -0.11550742330095216, 3.0595379063603096, 3.019304818735429, 1.6288822168665842, 3.413842723795758, -2.4683312037994014, 1.3607942707014127, -0.5626168404665192, -2.1055794718072236, -3.0416315457228764, -0.6066345356879476, -0.1856128362686118, -0.41909928697158205, -2.3181725279259773, 0.8021937520581937},
    {-2.571802585095607, -2.523595941543116, -1.8052360173781465, -1.4777740921967268, -0.056072837332493186, 1.1346879936844485, -2.7408242018300233, -2.822268887231642, 3.4117549598250494, -1.1523014542593097, -2.4406705962940864, -3.648304657335527, 0.33710814141786627, 1.9324902360250593, 1.565139414069116, 0.15308593512082241, -1.7150191709301765, -0.7871944423419853, 3.2595485844410663, 3.5848391789125014, 1.720817645785961, 3.8277624212638344, -2.3859499306170755, 2.1569707311034008, 0.05126357122326376, -2.318343186167546, -3.3785809867196233, -0.9210819238608453, -0.5375179484101924, -0.8952183791478203, -2.797918962511077, 0.7980220322432459},
    {-2.6765738973562927, -2.758919732075152, -1.8025989503889033, -1.672547424027648, -0.012909318809596783, 1.1904199952701202, -2.7664622536926182, -2.521054910299827, 3.350816018712102, -1.1485548751378893, -2.6329072355991125, -3.653320559364176, 0.24236742080269288, 1.5978670075230534, 1.541435284063573, 0.13225643118490052, -1.7693012748551062, -0.9535176080130985, 3.2327511483748568, 3.5793519776980083, 1.9735238784972788, 3.699590551500581, -2.6996795254802706, 1.8256206371578807, 0.10359633616229612, -2.780462622931954, -3.6463108061728007, -0.9615244226721551, -0.4168770611166594, -0.8043737580317915, -3.079047984934866, 0.9122093052650778},
    {-2.6064830134372925, -2.8408595340445015, -1.907346496803697, -1.3250295002285304, -0.078273465890899, 0.7371364352981298, -2.886621084743717, -2.591483995407733, 3.0449800154586146, -1.0169047333025458, -2.869252866760765, -3.777932090946028, 0.29797392536191286, 1.2184314955951772, 1.7000667906544795, 0.3397279080697776, -1.2754367710703196, -0.7402730051126413, 3.105366287304478, 3.054678482888178, 1.895183372893424, 3.605174780006651, -2.495489072968825, 1.7312790058146632, -0.2423787095037567, -2.62100278331874, -3.2720099200382977, -0.4496032899764395, -0.1570775412914235, -0.7536878191549466, -2.638146144348934, 0.7250246936877028},
    {-2.529136605983754, -2.7652330427145766, -1.908024641728399, -0.953479991630827, 0.10679430922913288, 1.5973119641242903, -2.508405456072837, -2.511182554076332, 2.5513521340186425, -0.10225015221630297, -2.1592171129411133, -3.5331836894372803, 0.6745422828030525, 1.285641205824523, 1.812916157836549, 0.7129233370315304, -0.6342614574787714, 0.09803726784077992, 3.0319331086656995, 3.1229642725384332, 2.300196682081127, 3.471381842054015, -2.454821864591314, 1.3992760880679578, -0.04322881142025554, -1.7505272918659909, -3.402345570017064, -0.12218760366804365, 0.3130780674097229, -0.2004680548838865, -2.143154258567203, 1.1529705173042468},
    {0.22247715807224797, 0.7208560617140879, 0.03620458290412385, -0.7230981656751282, 0.1497741588470348, -0.610225188309055, -0.562398638090418, 0.3910012615630237, 0.12141699145734704, -0.4062125023438255, -0.571717271484788, 0.6943386953585916, -1.1374942972249018, 0.11087963477620943, -0.5316063812561654, -1.2297925153389007, -0.05480539330591003, -0.05336553044062341, 0.6524156352740257, 0.0346305510452462, -1.290844095318432, -0.5834909090623053, 0.9743295711524359, 0.4952715950822046, -0.12174802432814211, -0.09304575907859734, 0.2574747492367494, -0.341903939842702, -0.4173117674654567, -1.17328465815746, 0.9987633305755993, -1.0112446985856243},
    {-1.654673819992845, -1.4157650854496906, -1.3289095285758563, -0.5242056649959095, -0.7398968229638888, 0.5077509660986899, -1.788895991651249, -1.180850663145189, 0.19476195303014726, -1.5084280375139567, -1.995588612891379, -2.48285208490258, -0.2958469379890748, -0.04188841743658358, -0.2948424782564523, -0.3950438062112087, -1.3331719956249035, -1.2529983972531076, 0.6332954283461348, 0.6092861721147859, -0.17601586497135277, 1.0835982095780108, -1.6411607013665586, 0.31677151708485257, -0.39806471440533353, -1.9460338093742948, -2.612496337369112, -0.7952966690413423, -0.5777015691031384, -0.6423230727602893, -2.3790158044899874, -0.21471006748779875},
    {-1.7565691883831003, -0.32408171320897955, -1.1317159216758037, -1.8123500301425814, -0.4207965883529168, -2.76644242285679, -1.2358814766017077, -0.6388883706078383, -0.8619308716114876, -2.538269550905921, -2.0122038280079253, -0.3221254913768695, -1.9723961826279754, -0.7370014321966196, -2.9773015109620835, -2.551628702377916, -2.464784273855393, -1.7513138953198955, -0.42327769536214244, -0.8305169449679543, -2.4363116047379907, -2.5117893764857984, -2.1141594304620277, -0.7368189988678605, -1.6573013615719026, -1.4854183231076943, -0.5011452966640546, -2.7455242394422372, -2.3840059955410617, -2.0645963126820455, -2.583255352251559, -2.389066699096422},
    {-1.7084889622235098, -0.9541773982252968, -1.6098523263968005, -1.1557306606801416, 0.3383591717620677, -1.8621165237864756, -0.6729510291300502, -1.3772241515821422, -1.3548410110183646, -1.334656439129997, -0.8135238139670723, -1.1505943027807923, -1.3225909069715827, -1.2789064320504515, -2.206171954988318, -1.5406591154271547, -0.9685839946529685, -0.6717008957615823, -1.4490527720262845, -0.8302557388309143, -1.510006821145103, -1.8599037623445325, -1.8789215967917787, -1.116166360150604, -1.5590254740144514, -0.2999303759143542, -0.9076351592140238, -1.7235060719875026, -1.9595052518813998, -0.9593601681922629, -0.577668420498692, -1.7268333682108188},
    {-2.4447900067458535, -1.396494667074632, -1.6251499311638438, -1.9529315206806996, -0.3814288831122944, -1.816644663013044, -2.113454396885395, -0.9669324461116313, -0.5568948027984331, -2.5363478936164765, -2.3676149409134313, -2.377410381757073, -1.956035403941942, -1.0490128007037598, -1.9561407693600068, -2.069115365947777, -2.505217800370216, -2.079440181036233, -0.4899864789445019, -0.133985777440194, -0.9996056910077115, -0.9198632096385527, -2.4077989406546765, -0.4234823796634668, -0.7499326511473178, -2.2156239867093297, -2.141380674971926, -2.314067752225795, -2.403318183540116, -1.4626156133382118, -2.5635765248939832, -2.0095259987889476},
    {-2.045665857660006, -0.965482829760327, -1.5161065015443, -1.748894871651516, -0.2725436750234512, -1.7324270584199095, -1.653730314079421, -0.3467557124738158, -0.7101197228507395, -2.4472216349289093, -2.0470615135007937, -1.6551872084769803, -1.5536751021336326, -0.7457728854540617, -2.107044733369685, -1.8012003589534473, -2.541566816077128, -1.9957854246627376, -0.6628640664512615, -0.6020071446758043, -1.1571445528227768, -1.119890797260622, -2.1722072441519127, -0.17458959213915431, -1.3174159439466857, -1.9650284018621105, -2.149385435611912, -2.4093800789175233, -2.049396531398551, -1.3543452486971086, -2.3215200279298713, -1.8748585921052787},
    {-2.502960933958308, -1.285538986665944, -1.7150519668762, -1.5625881238514365, -0.7065834820024921, -1.6977759584968994, -1.9042169285895028, -0.6292188887373817, -0.6862576895243502, -2.464748063715129, -2.5235322608857964, -1.7060216538397852, -1.8485135118952942, -1.0639563447060567, -2.325407149956716, -1.7765485621530308, -2.648379481736493, -2.3923711467691913, -0.36550596492799237, -0.25245736037304806, -1.278701015254625, -1.2681402039749163, -2.4615251931316395, -0.5466858617043292, -1.721104983299289, -1.8344577117297005, -2.212991869566652, -1.9807815522490966, -2.2155696658254542, -2.106582817385655, -2.5806238121091476, -1.6880802294225772},
    {-2.0057788493802096, -0.9887401777097836, -1.12383716536696, -1.8885192091668415, -0.4074304919314211, -1.6475653173402263, -2.1053181631205193, -0.017903415386141187, -0.827750193239278, -2.573838536381826, -2.619813355186482, -2.2981393725948527, -1.6180448327606594, -0.9186425881782724, -2.4559571927767605, -1.8147074213284544, -2.58921245890702, -2.5476845726626407, -0.7426102617401206, -0.642002361186931, -1.7309874877393965, -1.3026343821556083, -1.747128178835605, -0.5812046151601237, -0.9052973694513359, -2.0323440951141287, -2.3386575104081486, -1.9581991143266635, -2.2255876885749415, -2.1453353594125417, -2.0269931851268983, -1.8913694175919444},
    {-1.859777068283586, -1.1271219625097542, -1.1807870277987214, -2.1506192030593407, -0.29048855352785424, -1.6938522822721924, -1.8908043384201036, -0.2954261871164086, -0.814547924932793, -2.512843063454733, -2.3177591589252935, -2.328742754842423, -1.5206517905294985, -1.0398167449192912, -2.5406554030607413, -1.824251941483836, -2.437942080543751, -2.2277128128247825, -0.5414348683131683, -0.5813271473676446, -1.6228642400470044, -1.1035229818242085, -2.607141832906582, -0.9978625114732196, -1.3057702369514324, -1.6723505545359667, -2.694988192653775, -2.691856266774405, -2.4529040153065034, -1.952926959242704, -2.8899723498420453, -1.4926369034072897},
    {-1.7191988149819293, -1.2228495859095574, -0.7755188318494969, -2.552044927230774, -0.7616166822485213, -1.9961842935977645, -2.1402770354506484, -0.299850978495828, 0.011910365406794307, -2.488113701426778, -2.65612119393083, -1.8408927020225103, -1.8939746651206668, -0.23835712484611066, -2.6015460228216036, -2.166176104448723, -2.4219201687375778, -1.9823235840162676, 0.40439054807500074, 0.1098521878979221, -1.97591374634839, -0.8813487887664897, -1.8969724614201968, -0.03671603293726145, -0.4707253899803624, -2.226272534714265, -2.7283719116590865, -2.5868569461024977, -2.496751385551046, -2.1598994856264007, -2.852497672661579, -1.882217464322539},
    {-1.844484915723027, -1.1510831153347454, -0.9096208685798225, -2.124172603708065, -0.5715168767728004, -2.1164127780259876, -1.46193177735477, -0.46451563535409585, -0.7897464939609365, -2.138272075231949, -2.38653362157639, -1.7965069985103077, -2.029888761363558, -0.7614574004806332, -2.077380974766928, -2.1260553934999757, -2.044003687791074, -1.886106127014448, -0.8837153600635389, -0.2662192166387239, -2.02108293717147, -1.6145337929099675, -1.7788377154104438, -0.3676574711338464, -1.1903127695136733, -1.681016938315324, -1.9509592712734647, -1.9024051845300427, -2.433273532192331, -1.60126994108991, -2.201094857501914, -2.450777045860603},
    {-2.4613714806573186, -1.321578776244293, -1.5877617771187515, -2.302454313491884, -0.4230686277333757, -2.724632944040658, -2.131407229587551, -0.3946420063699833, -1.098014877357415, -2.517480776455618, -2.252170273557487, -1.9405399897551059, -2.5365875471491015, -1.3407169871675055, -2.8530662894865166, -2.424058121399639, -2.563858887502933, -2.447966297456293, -0.7258124448679287, -0.5077568969265859, -1.9838635377224907, -1.7014452189936735, -2.5630045139156743, -0.6507637849471428, -1.5018830047722496, -1.6901228390481406, -2.213941490676833, -2.5143632655990436, -2.4674208079882542, -2.2280901389462544, -2.725742378736602, -2.4967148667986185},
    {-2.3389863012476244, -1.4451032108076214, -1.5900687321593603, -2.4493284624138414, -0.6512219801438524, -2.555674053196877, -2.4614663729206883, 0.08001252773303778, -1.0387360858786685, -2.9637644667861265, -2.699634404645105, -2.2053520159432254, -2.6438674250690237, -1.0021442769705713, -2.8445800605663396, -2.74949955940778, -3.020263973714041, -2.284234927244894, -1.0130342697365853, -0.6065065115168421, -2.5898669778109182, -2.066948999960429, -2.610720142546982, -0.5782021234428867, -1.4734947829013374, -2.219382348997706, -2.9699892918192803, -3.083642652805522, -3.0655611743739155, -2.3757944937027253, -2.608468151841963, -2.69618189066127},
    {-2.414222154851347, -1.7445878487568427, -1.6086492755495156, -2.770987796775653, -0.9772831236013928, -2.7883187786207255, -2.4218595606887914, -0.5702710250929377, -1.2460214291999998, -3.044890836345509, -2.969006112970965, -2.6814566992224913, -2.9137910380258414, -0.9881122884685781, -2.840294546146501, -3.004668325548358, -2.9803081572776913, -2.7498597862646115, -1.0272417468583106, -0.8824500693599663, -2.5717118007559834, -2.3459929223975684, -2.9131935003296174, -1.045782680564519, -1.3845777054502069, -2.519665119496104, -2.859014097671891, -3.216087211305174, -3.2421823570209884, -2.6280631972123873, -3.1412399394249317, -2.8719036564324703},
    {-1.8293837781461697, -0.8725151948553547, -1.4405613529629495, -2.7391145971559325, -0.6053640693728184, -2.3390031231585837, -2.146410235550155, -0.3559758680762713, -0.32378773573463693, -3.254781762616977, -2.8728370864459936, -1.7576384154561506, -2.5892243884237107, -0.6614888906686768, -3.1079023926801552, -2.8895061620565574, -3.0216672022591204, -2.8237365001081356, -0.13066685289435978, -0.18515107309784667, -2.3923335017537903, -2.0682127124079313, -2.2516652850409984, 0.03819575944369022, -1.011140663843984, -2.0278155258496224, -1.9344426792061737, -2.940477366312663, -2.8128057667357194, -1.9868937548362835, -2.8046886075889246, -2.5951956639758573},
    {-2.10396379103711, -1.2346538640962672, -1.2464378934859188, -2.362724766879385, 0.23753384999333674, -2.5064164519901486, -1.6305884452752162, -0.4695956600976202, -0.8678761220522421, -2.9393588792811416, -1.9331179665503768, -1.3425260179700043, -2.401020522063378, -0.904406697088597, -3.1286341764616132, -2.728069049980062, -2.6864842859672153, -2.2083154774574547, -0.6028054877720987, -0.7811202257116552, -2.4368264584519994, -2.410796008479837, -2.5562282685618336, -0.6128476426048273, -1.5858752782262466, -1.6018751003469593, -2.0750218729979197, -2.896896355426459, -2.7959383032647853, -1.8871409154772831, -2.4642578668172357, -2.553301755647481},
    {-1.659914212047695, -0.8623043233441988, -0.817669930760938, -2.288227990229504, -0.40696408762913777, -2.2508724135710474, -1.4632877181914006, -0.6641196784075963, -0.48814184906635266, -2.346594234634613, -1.6978227707460187, -1.1282196507047295, -2.2923867321859994, -0.527795129433923, -2.6824722818943125, -2.4564711913283994, -2.4191448558803446, -1.9655658554584734, -0.5599254447100394, -0.7318966182372116, -2.249507712137989, -2.092792364180797, -2.3222932022777583, -0.26909488010663546, -1.2318891195493853, -1.601310647555019, -1.5444782797502992, -2.533950212181101, -2.682383103497364, -1.8585079277765408, -2.403150043138773, -2.4300465563406064},
    {-1.2811677925562064, -0.9450721975338005, -1.014284946104894, -1.5568884994668997, 0.2059885766129652, -1.714253887201927, -1.0682760504282323, -0.3728427721765206, -0.3315701381859232, -1.793449516063539, -0.9860088932057866, -0.8926163796322221, -1.2419239790422136, -0.37671526596371996, -2.355115546121518, -1.805528897578467, -1.8406883550750317, -1.5719298711766827, -0.006771308913710872, -0.11266225061761838, -1.4214748867552485, -1.1145513730921917, -2.0174147517992234, -0.058383801703925285, -0.8390999860294558, -1.3800119593390285, -0.6026463399420969, -2.1396313654813865, -1.9988277716101448, -0.7706187200688737, -2.2179023683260106, -1.373801683645371},
    {-1.699282512191592, -0.7358244458161964, -1.472883276111273, -2.4563743271912766, -0.05929811819439283, -2.6244530450677015, -1.550241710956874, -0.25789390102209275, -1.0607707575599568, -2.6449429082309255, -2.0213007272050203, -1.079360923252492, -2.6477161189590728, -0.8014821180790966, -3.1808896275041683, -2.926127633973148, -2.5150619144016515, -2.1041032672269635, -1.0173267224994265, -1.0298025730713858, -2.9292651826375633, -2.7116178087643985, -2.48840683336877, -0.4578851239548316, -1.3668045507169282, -1.5598156568897326, -1.8903234696991673, -2.606914945304013, -2.8592342538632813, -2.334428333746164, -2.701927987640094, -2.7650704338050907},
    {-2.1341496016498156, -0.9784677303220298, -1.416988981738106, -2.731484752120052, -0.29308566673206937, -2.8476470685469764, -2.016916540338376, -0.2209825228104656, -0.6087431258767767, -3.4288330383689964, -2.631229930771649, -1.6625170094565884, -2.9500550557764136, -1.2169269805561187, -3.3964441553432034, -3.316855962737687, -2.8086684708617957, -2.8919320665150763, -0.7291221596546251, -0.5100973827827662, -3.0400497250143275, -2.8458435426509907, -2.806580957616556, -0.3443638468743902, -1.509422787220609, -2.1243541630161102, -2.5548506961637223, -3.035307564168781, -3.3846996301844516, -2.5496744622765064, -3.291967416450422, -3.122947928875132},
    {-2.5963111536317376, -1.604935622248967, -1.786443041786069, -3.063470274553205, -0.27321261930928026, -3.1995769005115156, -2.2396832094173456, -0.7308578072434669, -0.8169415000829313, -3.3850415855520866, -2.352458111551977, -1.7487942788801778, -3.0474770315436666, -0.9019042195876773, -2.9879590666909013, -3.184774633052389, -3.2271170615238396, -2.8516891906968738, -0.8951325838633989, -0.5340187118902973, -2.6203850302925575, -2.4798918628279716, -2.8526947226436565, -0.7275134034137538, -1.6079107091481908, -2.349616544550644, -2.8550928160394298, -3.1658562975778892, -3.0003361448880628, -2.4921048902537373, -3.1998694026531487, -3.1792616113480747},
    {-1.6414266054791644, -0.6017949754369099, -0.67404398961572, -1.395313324057431, 0.9042421394459714, -1.6129575529009028, -0.9433412111400321, 0.054896751765578254, 1.38589869119344, -2.704708898411579, -1.8107168743343622, -0.9921343654131467, -1.5458271011935618, 0.905672990634211, -2.4797132156291415, -2.4469896737807604, -2.195061320750012, -1.5875929878991544, 1.4595996673366136, 1.579565885797695, -1.1812100780968002, -1.1380612326821427, -2.242670116215765, 1.6808856643195242, -0.1183112277427254, -1.4907483448043757, -1.5962916931630478, -2.8770945750196417, -2.113113176974595, -0.5172909810503125, -3.047118544444572, -1.3992677564765368},
    {0.5832668873243397, 1.2760809832227897, 0.9931651277478651, -0.6238391525766734, 1.5100633876692304, -1.146455410495487, 0.5880955050217438, 1.6432406345327504, 1.697404721176505, -2.0129375929935756, -0.4095634192152232, 1.8096442316009307, -0.9262559525899084, 1.7452645042771286, -3.1258073336615895, -2.050930031852827, -1.9081906847490615, -1.0400225272932364, 2.0890545096406727, 1.6804301493383367, -1.4020560414254992, -2.165549686252854, -0.6073245221403765, 2.1380809157381804, 0.41670494780998435, -0.12288517098793864, 1.0931081180243882, -2.403328752175624, -2.0292494595333332, 0.7696180223516995, -1.6293337232142158, -1.0583909715206887},
    {-1.3116972775499163, -0.0006501740815643945, -0.5679867845785986, -2.268841685649304, 0.30972681561242804, -2.7403384499923424, -1.083137631544465, 0.6248575437727217, 0.09776253077982523, -3.2616981299444383, -1.6758648284113056, 0.7482611089295179, -2.3958425127247454, 0.4957268298739451, -3.63675664967244, -2.96632467752685, -3.0874439477846853, -2.201954091030856, 0.5478001279687141, 0.1815675209585543, -2.7934102772163616, -2.957896415322047, -1.737098438694876, 0.6670585717678228, -0.8471907168519605, -1.2249381462371525, -0.5069046720536953, -3.2158282609236633, -3.154287798717338, -1.4715048834437088, -2.7135266860414378, -2.6102150253099827},
    {-2.414131221813612, -1.0534184860223603, -2.1019948170259464, -2.511514577213769, -0.5606160295011378, -3.1686376568337677, -1.8891992843757968, -0.5659243501398568, -0.9552357977008764, -3.709577089060239, -2.7386043705624656, -1.1960295640585943, -3.044246075105266, -0.7598260579321073, -3.435267909652551, -3.358820817495546, -3.349459714798059, -2.5858754581132493, -0.47708489993496644, -0.38603023453433366, -2.9661927137671773, -2.7674310795492962, -3.073799920974678, -0.08331224762573355, -1.6796276217734287, -2.10415863839678, -2.451247127570265, -3.413807914261316, -3.1971081683693763, -2.0602079441825856, -3.653808683646639, -3.2475111232574574},
    {-0.879912572374094, 0.24245646587932684, -0.697166396952794, -1.5634800453850002, 0.7863674269597434, -2.3382290232401792, -0.1557903052141181, 0.3665515049382469, -0.4270275296456266, -2.94685845721921, -1.1611477957789542, 1.079061238544327, -2.309016339925306, -0.3315570132990388, -3.69670629735234, -2.774169343825372, -2.1617534086726398, -1.4407640901237637, 0.09174980000858016, 0.1906554095253732, -2.353059087296034, -3.031778078473182, -1.8356596500435602, 0.4256610868573889, -1.2685392332290177, -0.5463148718874904, 0.439902295871199, -2.648809833864998, -2.7319994993443486, -1.021515027119935, -2.147028348867485, -2.568054951927756},
    {-0.9926972713735626, 0.42424802701053665, -0.25932698605220245, -1.7053223873733083, 0.2818044486835466, -2.637852347243785, -0.9300614299012893, 0.4291455050182598, 0.4149455145309865, -3.176703478736896, -1.581112536469343, 0.5469670030576529, -2.742734897726137, 0.5782156298824418, -3.642146890174982, -2.9647146455330975, -2.767341464527326, -1.9864841418549795, 0.8444457479757637, 0.7815971489188773, -2.728204427403856, -2.459037147724459, -1.5937796225401306, 1.129084637837693, -0.6000743096032408, -1.2074314288020556, -0.6576174812124258, -3.0225638047551775, -3.149131771965491, -1.3137873154698734, -2.379082698423369, -2.5941303399578377},
    {-1.7939120779453586, -0.3080237348941319, -1.3217500341337256, -1.9604750932694834, 0.10966675389900465, -2.9907366907183475, -1.243523091991154, -0.18792590714312213, -0.08564888489582057, -3.316989803633944, -1.7066007789684805, -0.5940915644373571, -2.5273660688426722, -0.10280061130324544, -3.9565512234656857, -3.229556349775114, -3.026284361382364, -1.8912516088450315, 0.4997230512470324, 0.3873968833512788, -2.904233913127856, -2.9131404190655714, -2.5374859609820555, 0.34835834187445475, -1.3232275526137716, -1.4383765911409272, -0.9758188669781893, -3.1927952756922044, -3.3072602460156557, -1.3672021349501158, -3.0206282181741937, -3.0744571024417815},
    {-1.2447952739696697, 0.41617740359168653, -0.8256749713252574, -1.8368062897050519, 0.7716955487920489, -3.0323494961717814, -0.7636701220028629, 0.4382583936380442, 0.3713851605879009, -3.2018388588017728, -1.4726258794215104, 0.6255315977704121, -2.3276001542565856, 0.11976031329028873, -3.8206768812393817, -3.101040990416146, -2.801458728575158, -1.6466647982767024, 0.6205864908108506, 0.350374762586657, -2.655608559922507, -2.882114057226995, -2.3380652497625634, 0.8757690730536279, -1.0317085352915665, -0.9352933559914651, -0.006523407075966351, -3.1823282111267237, -3.211649550957299, -0.870644470707213, -3.141440843625025, -2.72352450500512},
    {-0.5720318252964588, 0.8769233900507397, -0.07577707839056469, -1.0144611823016285, 1.0688333495401867, -2.24500647120549, 0.15933799582767763, 0.5541102594305815, 0.732389732332771, -2.619843553096705, -0.5698766830935567, 0.7943846444757318, -1.630516246939878, 0.6655842834258618, -3.563117279022733, -2.246232504408996, -2.1966350401210555, -0.8800287931226392, 1.0740622859047646, 1.1448060593718934, -1.9910489725803957, -2.5282620025395244, -1.1878924449492583, 1.1540823740750232, -0.5171077616206783, -0.4674263275019876, 0.3892679924669698, -2.4221894676881286, -2.535588986982684, -0.02223358935320595, -1.8946361814337396, -2.3762258721498726},
    {-1.7534115442433413, -1.595568839595627, -2.2714805678761687, 2.0163737466259435, 1.8780435890087723, 1.896487397147618, 1.4081945845707273, -2.104139386189142, -2.3738388145669584, 1.2334428279834762, 1.6082040698023259, -0.4245982929362653, 1.6470362493288082, -2.5843659620862587, 0.5366525168757412, 2.0656953752093714, 1.4120105785134436, 1.834162180019913, -2.1667167174117523, -2.437856115310778, 2.174449276443438, 0.8100310982750362, -1.5581209188890202, -2.4290768911087866, -2.611841593024877, 1.7301927184986436, 0.6751515436694582, -0.8661056983184819, 1.567028873455484, 1.8858049320568462, -0.0015736746703130606, 1.7008849317300534},
    {-1.4895378017862853, -1.5976348097724837, -2.2395466249839364, 2.4904810651292624, 2.4284292685180926, 1.795260350101629, 1.8910313998663242, -2.1738582914788407, -2.0486946043283836, 1.304253373994395, 2.0564384316820554, 0.09155428234971671, 2.441876459312775, -2.5950310248905213, 1.0410701283982704, 2.4437995752787653, 1.86168587544096, 2.052181866175477, -2.120723176746158, -2.147014852938393, 2.0115146799753285, 1.1928813851325684, -1.171042568261659, -2.0440276410851275, -2.3815578398125727, 2.0785161055392947, 1.0264808325875034, -0.7204578192266202, 1.675272199570972, 1.8418338483353807, 0.2320094367946317, 1.8943531770146673},
    {-2.2815792309043172, -2.5036146211569714, -2.5558978833593855, 2.8042261141453997, 3.188153643523762, 1.9350829493424164, 2.422922865391253, -2.525232610306145, -2.519673396604791, 1.3813413413905968, 2.7170125588270473, -0.07619612256763995, 2.723438527616683, -3.2977377090633455, 0.36390342667750564, 2.351392972401108, 2.008340707387617, 2.7426493835436894, -2.488956290008933, -2.182499987518579, 1.897618257653085, 0.5270994705755015, -2.2077596988708805, -2.6478799928263226, -3.1335182702656423, 2.5208781090536436, 0.7834174859025391, -1.5464379884310835, 2.124464138016615, 2.3576209267792216, 0.13598768533736552, 2.529884693892527},
    {-2.4741553611732376, -2.429859298167, -2.853872622092097, 2.4511805351381852, 3.2568431351737464, 1.92573159422537, 2.026812563376797, -2.598119512538884, -2.3061942834284346, 1.4572625924444822, 2.3515249508043294, -0.18703526065774198, 2.376795857200644, -2.8874083126239114, 1.0496545856536432, 2.1005377188061223, 2.3498263039740452, 2.5689090559061865, -2.2996264435208342, -2.4528091664569587, 2.012054896439164, 0.7557753219846798, -2.0805684519952545, -2.7081634414497415, -2.7116967402468775, 2.500780090980745, 1.1835972008814002, -1.4831504753384488, 2.1259754701632105, 2.438844531063812, 0.6155830092409293, 2.331927620428566},
    {-2.1503730227697684, -2.2950999402930163, -2.4488465100112333, 2.77862145572364, 2.7925784643981983, 1.7816427629047742, 2.2397488357944937, -2.481671209921452, -1.9941276645107946, 1.9226507321976598, 2.1689303854303033, -0.33659673550522895, 2.777602302382594, -2.8186179832349216, 1.4426865048113995, 2.1181100123176932, 2.068524943619277, 2.2222446845965806, -1.9161401977641208, -1.994990619614717, 2.092191844243527, 1.6072141800857067, -1.5066498576063478, -2.368231003746282, -2.6271947379165486, 2.1600631204848786, 1.4665016269083484, -0.9442120234860794, 2.165129877473744, 2.611821349704362, 0.6418062124507354, 2.458504228987697},
    {-2.002337156508855, -2.393217054834546, -2.752102668525712, 2.6484280379180376, 2.9919561703682613, 2.0401992894937124, 2.339760707523647, -2.8573648188216296, -2.2215858727008504, 2.028181469701502, 2.2706535683984588, -0.14425649592129566, 2.552918345290766, -2.740225485236185, 1.021877036649973, 2.2366586771190438, 2.564813980734811, 2.205106996567669, -2.4296472968084624, -2.1001730119531565, 1.742675758840759, 1.1710893484071907, -1.900686812611046, -2.726792474393122, -2.7191890757550103, 2.2134189257783508, 1.486478381897172, -1.0576254770261568, 2.1160782659955286, 2.5891538199716173, 0.7095663647833955, 2.150131085612382},
    {-2.3098140053965373, -2.332443349094082, -2.8964720127333288, 2.614455676093454, 3.1601525333530516, 1.9809297009284192, 2.285265648691628, -2.771570355614232, -2.6838964636986486, 1.7432604687923317, 2.0541278564604952, -0.3439374560940382, 2.4085144534910765, -3.096381960994708, 0.26400395691247097, 2.4439604262718597, 2.298720037995283, 2.431145650135837, -2.85588559755211, -2.593931344702702, 2.0196466830388218, 0.4749027815868694, -2.0082489519948856, -3.2296876303222692, -2.57686154200375, 2.188550317486495, 1.5192549652012382, -1.5309303057521828, 2.158862344456363, 2.171248756058894, 0.1778283137650333, 1.9243306696543372},
    {-2.2366310801753606, -2.6041162638673123, -2.901746411477327, 2.8069055458786623, 3.075256930936109, 2.0418077125078544, 2.3274419873590255, -2.8355988630441553, -3.0353884130077096, 2.0787680426915114, 2.2266841497038348, -0.246678199768097, 2.62804347536674, -2.8729710799828805, 0.6076880428250291, 2.5651612433355586, 2.299509101719694, 2.735206068401806, -2.8101001443147475, -2.737469100856249, 2.3448433057739226, 0.979600547134487, -1.80309659235086, -2.979134242816199, -3.0691217232276626, 2.580395746588867, 1.253043876247404, -0.8683269641114284, 2.1787899635944905, 2.2421187134656306, 0.4408926023838216, 2.2457469459693655},
    {-2.4018970693300288, -2.68071077527506, -3.035737297234913, 2.5988067157260457, 2.959490897760337, 1.9302082263683746, 2.2325665435703868, -2.8204258593857787, -3.0860324929903067, 1.36690759758734, 2.6808768425440137, -0.12074840269385073, 2.324333671258497, -3.3682442350504176, 0.39081566142966234, 1.9923595047332092, 2.0763610328455915, 2.3635922699519925, -2.754042556686809, -2.7215843093420453, 1.7894700865380142, 0.7674651927298369, -2.2721345303323535, -3.4070607421231816, -3.5313106742482483, 2.448046859214526, 1.0538064124161448, -1.3204960509700556, 1.6504722553871665, 2.555268207191037, -0.08953140012438249, 1.8298573884456029},
    {-2.7569719553740284, -2.9809807058662656, -2.888009498070184, 2.6756591683721065, 3.11325703223552, 2.2415642982981194, 2.058327681405513, -3.073430693378909, -2.672135344997473, 1.4844904487765718, 2.532336818593487, -0.37070848103340126, 2.482552690946427, -3.3192676307676376, 0.5010338322622478, 2.3340754877858294, 2.550908343852197, 2.572031042757229, -2.7137527961986736, -2.6438341892385706, 2.217335254850593, 0.8845089341853303, -2.2174148112027265, -3.039417258603241, -3.4035951471475494, 2.720306349002793, 1.4191079414309076, -1.169243777864282, 1.7711343443582543, 2.867704436368872, -0.2151154289761948, 2.3045724851750133},
    {-2.1741854794123707, -2.145768585250737, -2.689480661392738, 2.607417285853897, 2.830743493163043, 2.1451557845688587, 2.474501769712082, -2.888128504392854, -2.782242874296318, 1.892670325273901, 2.43719747424984, -0.4158213077441598, 2.37150192760215, -2.875112442747186, 0.4876821719623659, 2.1147352895897074, 2.000868242691421, 2.6226215211603185, -2.75637007946599, -2.5322291283637903, 1.724567488408339, 0.8548344856275706, -1.9057303294119678, -2.863229824783027, -2.6927083453670266, 2.365888396250688, 1.005376719052138, -1.1112394568391266, 2.1391050138670695, 3.0892065016766925, 0.12992497041758327, 2.646741265984178},
    {-2.15994452382554, -2.421630782830625, -2.9052025019162646, 3.1206839499726784, 3.3783557392383625, 2.6599164415447385, 2.638149797940594, -3.2170945026611752, -2.736489482091791, 1.94175338691543, 2.702948205154098, -0.33530024968781014, 2.660863633116346, -3.2817500834656474, 1.0249172247096137, 2.703835194692212, 2.4571040687045764, 2.9921473962955853, -2.6539703381584903, -2.792847504943188, 2.1118241318642297, 0.7983341665794873, -2.141629028755995, -3.2543807955019957, -2.998891785885717, 2.7791006493041817, 1.665211982907529, -1.6589948911465442, 2.3090095453764663, 3.050041102720619, -0.004966565029975801, 2.839241623073591},
    {-2.5538991972065386, -2.6773144261952835, -3.3169430643910998, 2.702887192684305, 3.243049748195077, 2.5822951517192254, 2.449884471792264, -3.1843411833003445, -3.0746295903818135, 2.059002663661097, 2.686667523906025, -0.3308998112100647, 2.62306806436996, -3.2417387582782293, 0.8045264065585783, 2.5693260384532914, 2.370442041129865, 2.6236875132243553, -2.6741816620522894, -3.021120755676888, 2.215160249859582, 0.5303487742267521, -1.860982761745079, -3.255513117775614, -3.2416175484155194, 2.871246522986425, 1.5457790882243734, -1.561735106992469, 2.063833677019477, 2.458226949634997, -0.060583361507016244, 2.414133464945206},
    {-2.3654614003264025, -2.5194501898063613, -2.8697332180251185, 2.770875527396524, 3.1799383568875137, 2.556545500016885, 2.7698277827377873, -2.6239127582528847, -2.841940661056642, 2.2235281239382148, 2.8146573873732774, -0.3513336134503245, 2.9606466271657053, -3.254135586094111, 0.4283879722902476, 2.4555194148081014, 2.3126259283346777, 2.611677066349064, -2.6410361624137386, -2.6637841293961473, 2.390724234993285, 0.7769097862128693, -1.7878608410929284, -2.9444395901040963, -2.857907062336889, 2.610670525177522, 1.1888133857504222, -1.0221515996691006, 2.015098129693186, 2.413764930204962, -0.13040553515791858, 2.396764638419635},
    {-2.4790032339290824, -2.479483653522313, -2.8475289210388266, 2.7334765372023058, 2.8966801202361743, 2.3844778143257117, 2.4936569302073326, -2.5754695318439857, -2.9032826888277246, 2.04403758643182, 2.6624266499525113, -0.886970742976052, 2.7406884300467067, -3.1690644550548903, 0.3067896861420785, 2.4440877505277894, 2.38041604068182, 2.5264510669515654, -2.530258000458563, -2.408831468394904, 2.689259756386716, 0.08742477592342954, -1.8139226044534207, -3.0601792126036016, -2.679689370522321, 2.6024490221044476, 1.2674884883325905, -0.9989718952346748, 2.220940887169573, 2.513089360130389, 0.025654309413350358, 1.8648860866097117},
    {-2.5993020274057907, -2.7394233377611434, -3.2032583495645746, 2.875647400630412, 3.386542125389339, 2.455002325408339, 2.5006685709347707, -3.169205024855758, -3.101844024032282, 1.5959591970414682, 2.3892958651224427, -1.36343964208212, 2.8182702379404816, -3.176257530354591, 0.5578710324478003, 2.742536906873258, 2.2873632957962453, 2.7077152502001356, -2.56925414060499, -2.77237270411508, 2.6367390513706237, 0.8472481940369134, -2.505098869272763, -3.197035511295384, -3.0307732357509183, 2.723902261375526, 0.9808800629303405, -1.6319361390183522, 1.7797924085456889, 2.8575277105706554, -0.38066732869250486, 2.404909792690329},
    {-2.7603356742351717, -3.068927723523555, -3.0449103905492705, 2.8453522833651843, 3.639549464006028, 2.8337628249964064, 2.7315095061638215, -2.9001048623336034, -2.6369550072808625, 1.8962419097010965, 2.7763977214563464, -1.012737239043638, 2.9584012890582403, -3.1379557464196757, 0.8407315681859349, 2.9909193951621766, 2.3903743561082575, 2.9271711714242787, -2.2443227625419984, -2.4193883999522408, 2.7225065818197898, 1.3878237777964653, -2.182750994175201, -2.9264038672916803, -3.391264433570341, 2.49036268845111, 0.8792483302109684, -1.7791452804437955, 2.034166958774116, 3.063863372419298, -0.40324043895397765, 2.995171600330842},
    {-2.871700062641141, -3.0258127160693085, -2.894368910618582, 2.740836059546304, 3.4003969365333324, 2.6446053750506837, 2.664075498561603, -3.0609941352051067, -2.614209223762266, 2.293423480625786, 2.6358619505926058, -0.6628410708278906, 2.74378156333431, -3.1655785469733546, 0.37883479342397963, 2.5841413235508175, 2.4436057849185118, 2.713942013598491, -2.472048543100445, -2.845194535471392, 2.283424936643009, 0.5466708066513775, -2.499347842750704, -3.099698846317489, -3.4165710683156285, 2.997517986757388, 0.9629411061808624, -1.63952417439696, 2.144625416269016, 3.0040712634042532, -0.16977155513890643, 2.4701342152915697},
    {-2.4275040737504416, -3.0384787709357157, -3.054516090101062, 2.809752959721358, 3.3742958098921476, 2.1680611335416002, 2.354472395839221, -3.0626492916052035, -3.0040120442828093, 1.9939543928133319, 2.678525655069907, -0.5579116336216039, 2.69525088171276, -3.0411304652644064, 0.37200068170326084, 2.326701407540242, 2.423524242555785, 3.0113655278218987, -2.7040080793260968, -2.984279011865379, 2.154593359195932, 1.0107699939589536, -2.2198212065688168, -3.42653633961146, -3.026174043165885, 2.7147236190699355, 0.6494380812006795, -1.683257741106942, 2.1428861064566243, 3.0084504257916858, 0.04999277833094698, 2.352561254339897},
    {-2.3003300228030574, -2.6961129391798466, -3.1800890218573095, 3.0866165055064223, 3.5128675346287133, 2.773650227615903, 2.72698560919722, -2.937723552867865, -2.874790143937044, 2.28558230618545, 2.944610100994325, -0.6863405618439508, 3.1197278735601865, -3.410565505962464, 0.9109351164092587, 2.591573683336869, 2.560063905314919, 3.2998474605179635, -2.760477205202757, -2.888528679437787, 2.4373926727354585, 1.1680982467119068, -1.5750018343774974, -3.191162479714887, -3.083342768404493, 3.044870963459746, 1.0135716508952768, -1.3424936174198792, 2.255894565073016, 3.0873759907738645, 0.09716147359413602, 2.642678549076516},
    {-2.59184802684054, -2.7578972979429746, -2.9721367306489745, 3.101947928581236, 3.252330737990068, 2.5588118985451653, 2.4410309529183865, -3.3593388546258636, -3.241783984968375, 1.9909385606988532, 2.6353208958984164, -0.8064911973314894, 3.1002720526381506, -3.189948413972678, 0.6598692252156987, 2.8016256021628134, 2.600732481397656, 2.846302282424083, -2.9478832206414918, -2.9066882188431755, 2.6079429654961106, 0.851838338138344, -2.255744774003002, -3.2982664074163566, -3.232792807763379, 2.730045332627102, 0.9495713462815596, -1.4958969080139017, 2.5072856404171353, 3.008901595053493, 0.459840955602309, 2.608317891358692},
    {-2.652632014208945, -2.783864133433757, -2.884485936894615, 3.2689629684948254, 3.3072930768003728, 2.8564502042637625, 2.6179195123405505, -3.1281388049143626, -3.230315474725861, 2.3768264163737025, 2.6974060190294002, -1.1015098477076557, 3.148228773752888, -2.860553815499806, 0.8760834993935571, 3.2851619052680037, 2.7783967585623546, 3.1258031550047467, -2.8014904005619616, -3.0370392073108747, 2.984996465507763, 1.2093554578612324, -2.1687570165402525, -3.1756907092612763, -2.9222976437435517, 2.7202050834343323, 0.5863376017002897, -1.418571021407101, 2.658160745957622, 3.0163296398986503, -0.24766987274408514, 2.8902384019085865},
    {-2.4960348217380184, -2.9137973508272172, -3.2919495002373207, 3.1636230333376196, 3.6697303025603594, 2.9141217697439887, 2.816299009773782, -3.2918502869991593, -3.233572430462729, 2.050016724436792, 2.7140932251690737, -1.0422556313196434, 2.9292063896473715, -3.573046348992846, 0.31468666691859637, 3.2607337559797513, 2.6997400691382833, 3.2765974506828233, -3.2012307102348134, -3.067495290573978, 2.7076341663462173, 0.791711075038796, -2.3692568991907623, -3.4194936967501346, -3.5768972663869003, 2.693344515892528, 0.9837282827041289, -1.7724475052805484, 2.793840075512676, 3.0572365726252126, 0.19531102211216378, 2.8413575525514494},
    {-3.0929586764819503, -3.147989850518113, -3.163513257124401, 3.1973766925384055, 3.678451087627921, 3.0267816319752567, 2.6920495507622437, -3.3977295114077304, -3.455952095405838, 2.212048986106786, 2.7913368756382075, -1.157276382015576, 3.217997999031279, -3.2535165901223047, 0.6393100112195351, 3.071844110717191, 2.739411120444286, 2.7523315727552204, -3.2413142769794354, -3.082310782580289, 2.893628585624935, 0.8131053207246405, -2.821894108784499, -3.212178805439366, -3.383295527322034, 2.9127146043438863, 0.6726190070818496, -1.7488435014681665, 2.725685446819668, 3.1913883413276265, -0.08009635678426948, 2.8543333934861557},
    {-2.754403892312886, -2.7083851082736228, -3.1081416624526943, 3.358443414846613, 3.485821907448761, 2.9015953569721944, 2.8300699654289914, -3.2695484267323227, -3.2418317732676925, 2.0335458970799527, 2.654248103536955, -0.8822437231553257, 3.197773727920856, -3.453295650193422, 0.6229533480961684, 3.053329928109908, 2.8025063068841947, 2.949813769214643, -3.0782782525974666, -3.0378100718300742, 3.017945361370747, 0.8301553719510056, -2.3415762413024104, -3.289897298430941, -3.373255291881696, 2.9706184341798356, 1.1564092327405775, -1.9460076470323024, 2.567588316732688, 3.3930599930395533, 0.0959053106876384, 2.878631113238932},
    {-2.7878872905636976, -3.2000633796820996, -3.512969680291087, 3.075105534739618, 3.613439063655291, 2.903815445382814, 2.792995407614505, -3.417128376825524, -3.3947654250151156, 2.066298650904752, 2.7458295187256896, -0.8812862190420181, 2.983319001359137, -3.805212573463062, 0.3496976292574459, 3.095182427889397, 2.9112991241544286, 3.2071507578403415, -3.1713575777108285, -3.3730081754724797, 2.8773376476513692, 0.962412415763225, -2.564358683540227, -3.428830636739198, -3.6677887540654766, 2.8716587759533807, 0.9347787871425933, -2.005247900106212, 2.8073929720868325, 3.361073216446487, -0.032013377871346, 3.154215468900344},
    {-2.963272507458997, -2.947902009283003, -3.268985220005351, 3.2548271544823577, 3.4230440811592295, 2.6720643458305724, 2.7443554920799746, -3.1557800582189515, -3.201459709215678, 2.1849367971633837, 2.6429432564452036, -1.2500652738074909, 3.1889229311542233, -3.446225217633755, 0.7854218338999432, 3.1680661247576096, 2.9935603778604145, 3.203781412772085, -3.0178118115842163, -2.9262165790825665, 2.9343975728989395, 1.3305682236764504, -2.8904529752266463, -3.4047154298470534, -3.490651699175137, 2.9902238629003093, 0.6974249282231837, -1.8563468474154332, 2.637818572979485, 3.2023704148639927, 0.25956209072838343, 3.2061696229105987},
    {-3.0654062790372003, -3.151814215857095, -3.1732495008386765, 3.30333817160671, 3.401937238750741, 2.7992605018108017, 2.907846268313577, -3.29663283216107, -3.1262438370497048, 1.884289295284053, 2.920120067508994, -0.9706428062149619, 3.2900113663629136, -3.3535724194826297, 0.3244705810975594, 3.035094535287699, 2.7160335979913297, 3.12593205030803, -2.7259062339763465, -2.827186878180128, 3.188144147573843, 0.9826470522926593, -2.575158809359653, -3.3312334750900683, -3.6324045057843475, 2.6996871827109836, 1.254383197373053, -2.2982639044562827, 2.5390454811560805, 3.082141989583932, -0.4000436955940126, 2.932251794301431},
    {-2.9387197868970056, -2.89156254346124, -3.3565295206348043, 2.896156613313572, 3.426650964546097, 2.6577242334364923, 2.714246790679099, -3.1885207218605047, -3.2510908346475387, 2.169043129406221, 2.8055291322429907, -0.9132554802278922, 3.287020340653316, -3.4711208405799456, 0.415628805112546, 2.912914298339702, 2.6821394982459057, 3.2867703375257724, -2.8189047609619595, -2.952590418740359, 2.941511521510635, 0.9528335051306989, -2.686732025956029, -3.2390304949941857, -3.66245331945899, 2.8596774085340035, 0.8583048145854039, -2.238533624063796, 2.6644971636988224, 3.0841057046307787, -0.5046802701160399, 3.170796678875454},
    {-2.9061256002547706, -3.2045666442338314, -2.987370198608088, 3.2452561485162805, 3.654064994076082, 3.017655158715866, 2.4398342734299026, -3.209011512842336, -3.293362207975571, 2.101847003721055, 2.942361194729204, -1.1491774877125487, 3.2559475413014356, -3.4444925827316193, 0.09329269236323309, 3.092587962922784, 2.8189408654501404, 3.095016069913296, -2.9757690897951545, -3.2485961783972126, 3.043539723872764, 0.9769637674062159, -2.7085300331611695, -3.4083974603293936, -3.31175370909882, 3.0027311414158984, 0.39916577483286275, -1.938256104245054, 2.419239427916654, 3.2544023866809693, -0.14092446746496523, 3.297676585782879},
    {0.8196512222892398, 1.2546925598260505, 0.5716449845006195, -0.0056893025187340455, 0.5148380867017293, -1.1938315900138428, 0.7019087197969024, 0.3730330624295806, -0.10471840585960059, -0.5769338730843258, 0.23184390822623915, 2.2098010235169485, -0.692015511174055, 0.0695070819580823, -1.0885707792927328, -1.4955186975046093, -0.027243361646958866, 0.042157871416902484, 0.11947238272684532, -0.3622657385066558, -1.214198867136699, -1.8233852485333535, 1.0560975001892445, 0.1596005609204552, -0.45368040570056767, 0.5121265956767918, 1.375567654914144, -0.9659658074460769, -0.8227182848250036, -0.7213346648489076, 1.3963396840418116, -1.117053358776327},
    {-0.605620530863618, -0.12781937141038124, -0.9149978235818604, -0.16672893916497666, 0.15113585214867478, -0.5293325833515232, 0.12474732146118148, -0.30432327590987424, -0.1753544400402925, -1.5267631130722366, -0.530284778213307, -0.0025337936723263885, -0.126262007592804, 0.0935605308346698, -1.3676882995893371, -1.292008487777397, -0.9909586784286765, -0.690069302056441, 0.023163372526319687, -0.010422025680737248, -0.6063613590204728, -0.663420548556962, -0.5734748185368679, -0.2215796031496775, -0.7738758433054552, -0.43551951569973635, 0.37698370912198564, -1.0556943207379381, -0.862046817138786, -0.36358205949171263, -1.2902143702602098, -0.6738429418149554},
    {-0.4359954054495, 0.8415376389352894, -0.29187245798400574, -1.6055559531032193, -0.08255845677481076, -2.419566930774124, -0.7962397557712274, 0.38549957110770383, -0.008783315446420532, -2.121944104076653, -1.29654403249515, -0.07235824479464104, -1.920112721393168, -0.08243673348904776, -2.3907909828209633, -2.2550836873556754, -1.8068307958653977, -1.5819884723957576, 0.3972437775940616, 0.5457656554598116, -2.5689175968608997, -2.539637154759972, -1.3765749093157227, 0.1641236730421916, -0.8037306949708449, -1.1755657199727498, -0.15468285605263263, -2.064239373016243, -2.465204126636028, -1.7206501387064432, -1.7873750097669416, -2.1769320436365382},
    {-1.0813758662481068, -0.19078578412165986, -1.0936148386266804, -0.8897434271483791, 0.755101453026456, -1.6077264285853412, -0.2727958302805328, -0.2763828890051811, -0.7411118713877, -1.2238895569924368, -0.44891987238348063, -0.5409530160804129, -0.7658317891964906, -0.5765402298386944, -2.4877466134710478, -1.6742039715374264, -1.0671536908821098, -0.853750946366187, -0.804091355516764, -0.406862467046087, -1.5331846528048632, -2.2063114307112004, -1.6447526020325585, -0.9919095538570251, -1.1928172656061016, 0.11394352934706976, -0.023895811046655353, -2.0384912548621585, -1.7581315199162744, -0.7361367538911577, -0.6019132140661198, -1.5675461910551394},
    {-1.6351550215619266, -0.8044009969885986, -1.2273257842911842, -1.2092941644150719, 0.5941241819758899, -1.5493951809441036, -1.0118820979441245, -0.5068096847590005, -0.4894177273957699, -2.5694596336692643, -1.4357262137104676, -1.0403684164973912, -1.006411908928881, -0.587337231449794, -1.8937285331597202, -1.5551021103103921, -2.0142292523075573, -1.4668326298050642, -0.31380126434276123, -0.2930988623110125, -0.716131850133987, -1.5547963476945346, -1.9422518548644867, -0.02190676804348931, -0.6856856547882233, -1.0102925353895487, -0.9461866210036619, -2.254387296323804, -1.9153445827829203, -0.6914790379789184, -2.03764299563091, -1.249554213143965},
    {-1.2847375140110913, -0.8181033378843587, -0.9040719532356335, -1.28085563034091, -0.30223001004203204, -1.238135001332616, -0.937862657457413, -0.002822882432821107, -0.6702746684666258, -1.9850920038237765, -1.4192256124527407, -0.7025868551661677, -0.9436257328994396, -0.5229259167589002, -1.5625929063116533, -1.5802468606440978, -1.594829268532781, -1.4110492149541662, -0.5184104137969948, -0.45605298413731005, -0.7127870123201241, -1.2598493836168256, -1.4453397205180432, 0.20686209920074167, -1.151009972429227, -0.8963642386467197, -0.9641503851230024, -1.1063821844344954, -1.8214667312718724, -1.0577969897678052, -1.3301954267412668, -1.538835016648321},
    {-2.130604200068255, -1.0367509742669034, -1.1042516726787577, -0.9435585957467018, -0.3565725582718428, -1.0243892910228396, -0.7453048442907849, -0.14089470757974376, -0.46049532334916116, -1.9570019199339361, -1.617676384676065, -0.6359364304522541, -1.590521868909019, -0.5306146407218403, -1.3647592590831719, -1.4227273530599842, -1.842820197368145, -1.571082970217791, -0.08073731068498588, 0.24663391481181732, -1.0579992216934286, -1.2354477768477536, -1.8348052094824099, -0.7306220453736758, -0.9353671338517214, -0.9576677737902448, -1.3239296963173262, -1.5022575772159568, -1.5063573219065387, -1.4127405034596083, -1.5653067353015147, -1.3871621487109276},
    {-1.2493630881636753, -0.3937877918556139, -0.5399519813881026, -1.2890134976131686, -0.4478902231178076, -1.292788673227673, -1.0115482075259505, 0.5917266125733273, -0.30782973945294256, -1.7847926281832318, -1.7446675218478187, -0.7341787996214888, -1.0384037743749932, -0.36592110033933006, -1.9551934288538355, -1.0927835744260452, -1.5732096607953887, -1.583270707719913, -0.37733681928719925, 0.001784752631518804, -1.3305841123656597, -1.1947248901245913, -1.5799354224792768, -0.0563229510630882, -0.37752543516828857, -1.057598266954872, -0.932125522331794, -1.6845436092969364, -1.8111276974834432, -1.425463481219738, -1.5895228238081156, -1.2768680018287475},
    {-1.4737209208138762, -1.1649649087864253, -1.2103704439384335, -1.1988119409290943, -0.11367055328296109, -1.2399626932384273, -1.2585973281560026, -0.4074880720592706, -0.873927144207915, -1.6980285481259627, -1.3764296754651137, -1.4029816064710166, -0.7122768917848664, -0.7848839777482218, -2.2045311830126817, -1.0009537699895659, -1.8533481430711825, -1.4026126786702282, -0.5553378676554159, -0.7422353843914838, -1.0519992948655146, -1.0849182072178698, -2.039397490700707, -0.5290841385013835, -0.94101047374376, -0.998469756624361, -1.4448584026044926, -1.956922754125211, -1.9782027762048828, -1.5806689758387886, -1.7714790476989943, -1.1161332319120498},
    {-1.2223627400283188, -0.10229596914734783, -0.2109235678638648, -1.6269902212210632, 0.020007904568347234, -1.5140007828846476, -1.293531144891972, 0.4110311216214383, 0.17536827397104499, -2.154063948586622, -1.9455086667833572, -0.533347700225912, -1.4563775553648932, -0.03259511403547142, -2.326802230851222, -1.503295302757342, -2.0248227268982704, -1.1870847073621822, 0.7328587052256079, 0.3704871758758304, -1.4098388932693033, -1.1427717199691438, -1.3588862691160066, 0.6334755053179498, -0.5117197853031, -1.1699463133522299, -1.412272783765967, -2.192522212049395, -2.441505680387603, -1.3622700801343306, -2.220584396988008, -1.5576676518611867},
    {-1.2382714698949888, 0.36049780234347906, -0.46740630897749336, -1.638008175909617, -0.03697654896117262, -1.6222081540521172, -0.8889761165961155, 0.4508580211640001, -0.398165906159927, -1.5693759226418018, -1.251553677665827, -0.39093186255374934, -1.873525205651297, 0.2953876769300778, -2.004648557086233, -1.5815060114527681, -1.468520913836532, -1.4161301409864104, -0.27203746153198227, 0.09191719655719698, -1.8691907315911127, -1.4815350419269382, -1.0392608074990244, 0.22645075375714882, -0.8467390693257657, -1.016547986399765, -0.6053848589085392, -1.595506143842704, -2.2012772271195025, -1.3228184089168131, -1.28989252571087, -1.661941134733705},
    {-1.5540603835667697, -0.5076109760180102, -0.931931673192064, -1.5735778168966263, -0.18356225646852053, -2.212430343811668, -1.3501589997160919, 0.34181807147525156, -0.15603105407437004, -2.1764027591921353, -1.8429585976592102, -0.6351927334811122, -2.106725584483586, -0.4788619259505201, -2.49500217003593, -2.125839463279551, -2.1489313517421724, -2.0052889142909573, 0.04731707408669748, -0.06254319947783119, -1.9071964423972219, -1.8986409581556365, -1.6238814340938468, 0.04554391498320115, -0.8671281497918, -1.202250044930597, -1.2273102462574261, -1.9285875481377086, -2.230005679155188, -1.6053122005995413, -1.4453671593766082, -2.101998138304566},
    {-0.8493191074677872, -0.22348031931934625, -0.817381787130962, -1.8101205284094304, -0.38071749265548754, -2.056875494823903, -1.0641918954860798, 0.47040187322781946, -0.7127213163956274, -2.053642649390722, -1.5159446421709957, -0.649003006276368, -1.7794279326401714, -0.4093533509971831, -1.9428153632785945, -1.652778567581557, -2.2008637240435216, -1.7643311726957742, -0.05760989241070299, -0.45977551777815046, -1.5898884666824564, -1.8848140697480174, -1.3279243930290665, -0.36621677478420805, -0.6408078593727023, -1.173968204745253, -1.6111548672101579, -2.571884631724249, -1.9114369022115547, -1.5298294995301753, -1.1743411352373265, -1.8727586095050124},
    {-0.7233250584630792, -0.014787069287868921, -0.58419488631149, -1.8760668539170882, -0.37394642144336815, -2.245616635972813, -1.4291893504350077, 0.36223190055052545, -0.328410685162598, -2.197747607994062, -1.5759550274144662, -0.6127522499532044, -1.7758379941774645, -0.19602431853749122, -2.7240402139403908, -2.343845769704098, -2.196040837860595, -2.27547991312746, 0.11117714905602905, 0.10958618761452982, -1.9118931608432101, -2.1214487847060526, -1.7759605673826842, -0.05630656924590282, -0.5898702086134786, -1.6155063061916939, -1.115804426634411, -2.689864244238732, -2.430757557456537, -1.228973064316921, -1.815197056902975, -2.278871381204276},
    {-0.25453069822954927, 0.30034386545796704, -0.12381139715539033, -2.1118623621605352, 0.20241842022622258, -1.6885284426048308, -1.3528767172882084, 1.0244306565238694, 0.06851217702633673, -2.6040508117860237, -1.5649370254130421, 0.4481855144517675, -1.6373599824300578, 0.15318670046290583, -2.7118041508010844, -2.3885305230451355, -2.448928702523514, -2.346309413269863, 0.4335761637420398, 0.4794824154001017, -1.895374226282515, -1.9855495841034463, -1.4994013087823206, 0.7554591101587976, -0.06422850186891724, -1.3048295546606419, -0.10496742210584198, -2.301523693025821, -2.2501424288741303, -1.2943406699609772, -1.641165195743418, -1.9390462001604232},
    {-0.7204741743247983, 0.07953580520974578, -0.43149018674542894, -1.0607564267128324, 0.7705311377646683, -1.5216389541730238, -0.5003519197556502, 0.06389799721808019, 0.013069667755660411, -1.520757166177087, -0.7583027646397023, 0.45344517486631225, -0.8451616302697789, 0.222128811355741, -2.6814296298060896, -1.5120084095411752, -1.4507677367778509, -1.2177494206926558, 0.18071075851616922, 0.032194570501305614, -1.675515398780517, -1.824678430790342, -1.3829920848277162, 0.07535193822205395, -0.7198948068141215, -0.41828073402906046, -0.3337362631023069, -2.3465329283976137, -1.9580191465974102, -0.2963550685595298, -1.3125792264996958, -1.3477960790244403},
    {-0.18334132314569637, 0.5807909328092585, -0.00018281499858003894, -1.0500473529809546, -0.004960857902475601, -1.737332433819328, -0.3743917366681185, 0.784089314431009, 0.3601115046557121, -1.6604209483456485, -0.6533911124724106, 1.2611965773384917, -1.3491926101655687, 0.48472985001086283, -2.3286206009171493, -2.238641295727104, -1.686318811035714, -1.5282301780738665, 0.26540619471248283, 0.09308925542134758, -1.7143597137439879, -2.203459818000572, -0.5849568550920644, 0.5522641060395775, -0.4664875941570068, -0.35280203289037926, 0.5094394228218745, -1.9289966087516703, -1.826042108887707, -0.5075822431434194, -0.8375370805764327, -1.8237888795998694},
    {-0.15469843600514427, 0.2008261812885622, -0.181070192376867, -0.8811674622814999, 0.8472670642186129, -1.7397580669277226, 0.1980092696800861, 0.9803287719392347, 0.13283620704159013, -2.089014057520828, -0.41223988397962164, 1.226972604668546, -1.4008486889885725, 0.24271833410918864, -3.0775791133278614, -1.8061000136527114, -1.8279016358039644, -1.1749559305043298, 0.1366706139771533, 0.10009406803041755, -1.510273134342752, -1.9387401281682135, -1.1766229693609978, 0.5413830324889441, 0.030106481121078252, 0.18336414020854114, 0.64594090701547, -2.7917843496333705, -2.0387728808997263, -0.6178389250389643, -1.3855605180570851, -1.3664607233273756},
    {-0.6101882676660654, -0.04819724009780946, -0.14189180633169182, -1.1975719512593257, 0.6354772187947775, -1.9040662975422304, -0.09549489325110899, 0.5367729274040032, -0.0025756078062140184, -2.094124568556032, -0.6830746332034666, 1.2979173421291041, -1.5076275076973282, -0.0013575755328343938, -2.7351990228543794, -1.8957217511507247, -1.7802748581788257, -1.2487507985413902, -0.048557223526397325, -0.288406109914086, -1.770597211914288, -2.4145674529783743, -1.2828722107633654, 0.4330125839727906, -0.5858200878873897, -0.47845341379834627, 0.3628306948392218, -2.2500109651221893, -2.1515770874699465, -0.7831601701862964, -1.7083320912654674, -1.8142679791808363},
    {-0.7672734856652756, -0.054901319529542136, -0.5333107770573812, -1.7516374494799718, 0.2395711406851426, -2.482767886555005, -0.769826143482699, 0.8174683507151822, -0.3459701468998442, -2.469773964498685, -1.3274725886641154, 0.2831443213497778, -2.3477192609280353, -0.17153878791847385, -2.9908133633124474, -2.5029452706504323, -1.9324815079499957, -1.6754364171658402, -0.43247543910034536, -0.24296572403522346, -2.6396861163944605, -2.462109010677541, -1.4598476394258528, 0.31847967571807695, -0.9696272895364286, -1.1033731418307973, -0.2864191060510026, -2.639516780013427, -2.6191601435653262, -1.6339313219611733, -1.737745636287794, -2.5707247475875405},
    {-0.7353375202244627, 0.5572632783501628, -0.13614595674101085, -1.5553005400772624, 0.6625297503850701, -2.6052896758353454, -0.530970867157703, 0.7804622268508739, 0.012518033445653862, -2.620916764218319, -0.7838942200327798, 1.3633214919655248, -2.4396413338461294, 0.5240737342138966, -3.3283036141450935, -2.637097105434663, -2.693494399690892, -1.8257758923831593, 0.162930514603446, 0.40161745605932375, -2.6523779884761858, -2.896072546739453, -1.531104457622916, 0.5477535358216651, -0.8545574970887497, -0.773351883779252, 0.04409810102143161, -2.9549799777326604, -2.6107846457839545, -1.0997412204686474, -1.6069225368166677, -2.362687472831424},
    {0.501092291089614, 1.4108813732256247, 0.6568387682177137, -0.6776415784444328, 1.4725988008184356, -2.0605125760320173, 0.6738390275156243, 1.430486077926048, 0.7715897667878587, -2.8939191919981178, -0.27748275169117287, 2.3012114553508676, -1.585442780262106, 1.0425091820954273, -4.018682322042445, -2.262488272796246, -1.9116387424541528, -1.4011368372026156, 1.0258172134601113, 0.5887894566630065, -2.080589572623263, -2.9438654143575866, -0.4812064856265849, 1.3780638068489757, -0.008846045731140168, 0.16746440938689283, 1.3223328817988607, -2.8586665302708725, -2.573879218001424, 0.04326558475440996, -1.594448536888612, -2.106680498817226},
    {1.5969199012397637, 2.344432989430661, 1.5705102014081318, 0.3184198176353488, 1.9197272667133367, -1.6677742069797907, 1.7540907624265443, 2.2831609929838175, 1.3241882860100256, -1.6858769603780488, 0.9744932642576211, 3.135099595962459, -0.4964038297616011, 1.7034458519663838, -4.127337600183192, -1.965513616329021, -0.6031154324126047, -0.6537145021791054, 1.648522137105592, 1.176899829196394, -1.3476839834531464, -3.5712598824747244, 1.037348937291735, 2.316753564395542, 0.6963331580932325, 1.484976678519963, 2.851325836470298, -1.9655042246625067, -2.0885156893875063, 1.0061579753518874, 0.25493269330046103, -1.501890195306531},
    {0.7263978234860603, 1.557334784533997, 0.5482632549849412, -1.3398483154576164, 1.0159566056770029, -2.3677450032660388, 0.7969627464569397, 1.7137133539782516, 0.3626805743944801, -2.2641687934461663, -0.2611980064762793, 2.524499726271378, -1.5215161305793128, 0.7928197522480139, -4.098337998459849, -2.9112166713133627, -1.8342561518857448, -1.5927586863590613, 0.9313668049033117, 0.5202072112919642, -2.591265390360673, -3.690896738432473, -0.23253283550363554, 1.3692001336619766, 0.0700312385651951, 0.10616860292185201, 1.744841666017275, -2.7740759466751412, -2.6300118316482846, -0.4739187596297686, -0.9144861227359945, -2.511010390991114},
    {-1.2764127099858071, 0.1684224826133471, -0.5495213697708441, -1.4167347040180656, 0.4153104998193265, -2.768007441667054, -0.4359395322991531, 0.6139325222629304, -0.5726127191997945, -3.0777810870547535, -1.1985426356115645, 1.095454800068929, -2.3506668165817115, -0.2661124097537191, -3.8488264937382746, -3.0729756991769777, -2.9413535022644512, -1.9347868399874788, -0.16730863656061815, -0.1269585096952344, -2.7702929984681766, -3.2839206941469437, -1.8048468961935278, 0.5064934819382122, -1.0475584029894363, -0.870052459607991, 0.13065299334955555, -2.9207106852033533, -2.756012648452642, -1.0265308812930887, -2.5540387160443347, -2.65189029608519},
    {0.6230923892079392, 1.5772111166652087, 0.37744064235695196, -0.7968100782927225, 1.4361535514786987, -2.165144506432136, 1.2495759931470765, 1.466040890921482, -0.04272914298748208, -2.4318369549560512, 0.06427135531348518, 2.466598889759316, -1.6318559644052706, 0.1446826025836422, -4.0967439775674634, -2.3321830779823314, -1.3088874341864571, -1.0256625334970286, 0.27798722367462575, 0.2861751346647292, -2.435474125005918, -3.756441911063414, -0.09760797625379618, 1.2126398689384807, -0.447238200665278, 0.8626917969697356, 1.927009643137201, -2.735057500096226, -2.276051587649488, -0.15796555189780448, -0.5986295649371582, -2.2912751966119},
    {1.0064760722921835, 2.1164132504515196, 1.2393050229139146, -1.2378961451964903, 0.9235118639005488, -2.8309889797726906, 0.5455706921834302, 1.8321325873572356, 0.5312004878919475, -2.69198206978953, -0.17514031925637852, 2.809886588852896, -2.011441975616519, 1.3287400411897896, -3.9916918304247666, -2.9780511917892634, -2.2440708756099865, -1.94010442242986, 0.9660330149979449, 0.8748734405998027, -3.0116279966481514, -3.6298208191750643, -0.036562921526287574, 1.3270383318467671, 0.004505898106234275, 0.045183347276269784, 2.0029813144826942, -2.7168741612080525, -2.9427455273391927, -0.8274236381062835, -0.9624204411944103, -2.653392220715793},
    {0.3472427087781012, 1.8530613129447207, 0.40641294874693645, -1.1108379946921045, 0.9382100810458966, -2.9063439702202953, 0.4639178314736001, 1.7033728462687194, 0.3515915622670944, -2.8681110326952153, -0.3880187959851238, 2.683567696299832, -2.346604235278233, 1.0120456979437866, -3.9817125541912493, -2.7157757289893714, -2.323662621099093, -1.534639037907606, 0.6937879764060249, 0.6398818570743761, -3.117300570275799, -3.3401038869121633, -0.38429555285693445, 1.269705290538446, 0.06078077467957007, 0.06405616930129804, 1.9456637764800138, -2.906270806371902, -3.112059764621309, -0.5454959933574884, -1.299288985236701, -2.924510262268484},
    {0.5342162517795996, 1.9453741701697158, 0.5711956132762835, -1.0821006094376284, 1.2208819619812097, -2.7950512821384277, 0.847788513282431, 1.8084939619641058, 0.5016651438985991, -2.379531139188746, -0.16581336943279582, 2.633925076116204, -1.8685771903531005, 0.6137245744245751, -4.232953828363047, -2.830364969315629, -2.1646110236646527, -1.1638464758488962, 0.6265754272871294, 0.41276073109948996, -2.690055790475035, -3.75735014767448, -0.5758808508984377, 1.385934804825127, -0.28119650101304866, 0.6338775830606614, 1.827257522339139, -3.2064487579474443, -2.8559125743048446, -0.429167806243356, -1.0718578504272107, -2.5037286251736237},
    {1.2667100661278745, 2.095056323376254, 1.334270200280835, -0.40672809062275256, 1.7859563896473856, -2.5816896806919747, 1.4068875062748418, 2.0730463383244015, 0.7789782623279976, -2.0930613726572345, 0.5274472702986776, 2.965751989958443, -1.3681787598491995, 1.38255019068565, -4.0562979405163855, -2.3269651757761487, -1.2417286392855647, -0.48703266568928055, 1.0805014004851763, 0.8408115419507289, -2.1422741506079386, -3.866058521280491, 0.7376313838653494, 1.5726028736586255, 0.32735170203864344, 1.1245495440453033, 2.44535882215643, -2.3053562556923337, -2.7672143601272947, 0.5398206392364469, -0.011282981392510608, -2.2372625027164856}
};

static const float b1[32] = {4.751564106013098, 4.855806971119731, 4.74651276380886, 4.81333985355393, 4.734548991465561, 4.831620342743838, 4.528496506186982, 4.834057188194364, 4.85273837682008, 4.766871353242544, 4.676764802495845, 4.733562271854398, 4.7934485539553755, 4.688415154950944, 4.942951419541391, 4.917427647217627, 4.799133463792119, 4.865122464684124, 4.949369207765429, 4.9181436382140635, 4.878841531714999, 4.710091509030699, 4.795281679672132, 4.652031347366812, 4.781894063635505, 4.5677344721443385, 4.717645566085999, 4.739480710615391, 4.729493486737146, 4.84670071825596, 4.840237857359228, 4.7751473773536075};

static const float w2[32][16] = {
    {4.078182192844184, 4.120442926512758, 4.082620598505694, 4.516053222094942, 4.211677305881259, 4.245777610841314, 3.700668464974059, 4.766149291779233, 4.668313392366318, 4.2240553023606005, -0.12604522941727042, 3.783284765557382, 4.321791885137438, 4.384433603621211, 4.168238746348656, 4.202542295725467},
    {4.049985596537284, 4.230482044598148, 4.161883572769587, 4.098693415594565, 3.5994247636563648, 4.623326376213437, 3.842776024829163, 4.254330042649271, 3.9855416759567976, 3.801851346229242, -0.23149653673983064, 3.1200610471260286, 3.8430954394983567, 4.305424920220268, 4.257224091168675, 4.12805902776188},
    {4.18836584567743, 4.069280818031353, 4.453886888817616, 4.702530227294868, 3.8564906419869893, 4.367667556038247, 4.458155610530567, 4.260302543804914, 4.4089928275449815, 4.231770884642789, -0.12514552036405135, 4.035615520666436, 3.7445882568681603, 4.27030600578288, 4.657526767110498, 3.9361290889387828},
    {4.183383565997037, 4.072084506636991, 4.2324446846467305, 3.8555343952480636, 3.7788144070480008, 4.385496795679939, 3.780573517782815, 4.180574131629292, 4.222762840049289, 3.759978666611137, -0.1772125391213995, 3.857806215325204, 3.462016279767982, 4.031600134551807, 4.430742263137952, 4.502882413768878},
    {3.97324604956503, 4.321610862704755, 4.418226651331958, 4.032538197178462, 4.059336776531115, 4.572170585394938, 4.837672550395288, 4.32231166649101, 4.516457127573432, 4.659983809879991, -0.13939016733485635, 3.955626231465825, 3.8158214280781944, 4.567560294449201, 4.303431889383185, 4.395229355214278},
    {4.246668146245782, 4.444644964315377, 4.2352949210283795, 4.221446600505999, 3.827580878094056, 4.414934552100041, 4.720174493175385, 4.581579912251759, 4.054035972477032, 4.176983618932721, -0.1517665351447325, 4.176652820056898, 4.031902867064475, 4.639695308236634, 4.816878207984857, 4.5028414987159175},
    {3.7338188248532402, 3.9989380348374457, 3.7817732282345093, 3.988947238098039, 4.021990521032746, 4.251451676350972, 4.313663807551159, 4.131328367506952, 4.265012610341056, 4.312005123165198, 0.22124710138327613, 3.644156000114298, 3.7165080871835023, 4.0536496123226105, 4.071629055859042, 4.149368487490401},
    {4.21702697446326, 3.8755185776118206, 3.863047285544966, 3.89934652238511, 4.045028229845623, 4.092323091977196, 4.2558158806912765, 4.040751210378776, 4.340800181300591, 4.04578444214387, -0.10962645272537413, 3.7788352187735583, 3.639917465179725, 4.196512255257223, 4.045071232294387, 3.9551180003890605},
    {4.559360371912309, 4.467093711502507, 4.15263646582146, 4.464246622887764, 3.8632586431668487, 4.144994216838179, 4.307054664481557, 3.9029191697288423, 4.019188195281043, 4.399702242636698, -0.019284598430715363, 3.8608494568441434, 3.785706448309922, 4.671100958016458, 4.146792300661787, 4.17282121773293},
    {4.5564964217281005, 4.0985895276521465, 4.276176192756111, 4.27448186562443, 3.7897992230096165, 4.452087484061995, 3.970281053039878, 4.6324714869362795, 4.111817814494908, 4.027944040143847, -0.3940943489103097, 3.8285206100615152, 3.530559515970601, 4.1183617220078155, 4.56028903918708, 4.408139744266068},
    {4.216431954040887, 3.957902993552586, 4.233213703219016, 3.568850835546298, 4.020021561577309, 4.52819848756452, 3.999611520441593, 4.0583886700069165, 4.600823045340412, 4.185549112430755, -0.3889643158691523, 3.62530576840535, 3.518004820290718, 4.075233768993946, 3.774645907278903, 4.2037645024996495},
    {4.663947562786064, 4.343580974392303, 4.08271915081178, 4.081344955665731, 4.173470673064045, 4.350437726426295, 4.344886766861725, 4.208926008960463, 4.45834023111263, 4.208385284983728, 0.1065240001949123, 4.1768536896875545, 3.851970103929912, 4.390861012271577, 4.216932596921115, 4.148880178342911},
    {4.062247387655763, 3.9981018041333556, 4.422080077933701, 4.321467306669014, 4.116475659717021, 4.679899967974819, 4.287089264235599, 4.054571977100249, 4.578455114017648, 4.357601542111133, -0.031036602665175318, 4.262929492809232, 4.036030465965278, 4.368167908737387, 4.135376388758744, 4.579138892427923},
    {4.493115321324727, 4.124227557239587, 4.023667199668053, 4.232611969118916, 4.410847671420699, 4.0648972008903534, 4.0521644864493345, 3.958088391700399, 4.21524258189346, 4.301288218715224, -0.1927256477337867, 4.232016310307125, 3.8527733721495987, 4.590368770629298, 4.259083920509149, 4.421676179720562},
    {4.613281889209871, 4.474757196008396, 4.234632110491752, 4.464903295690392, 4.130467992694396, 4.229857351702825, 4.763511690978544, 4.008334705050559, 4.480198540157563, 4.591130926836562, 0.05611546428532303, 4.069938461537492, 4.03276136649174, 4.2701268092141795, 4.092865016882249, 4.310160352457481},
    {4.188500132334132, 3.858355234473986, 3.9377329544888147, 4.044440452168664, 3.668131917834807, 4.23367437563686, 4.519944057335, 4.2924425658021725, 4.402808770124227, 4.645318619681241, 0.05574875971377526, 3.911095355739, 3.947675962800582, 4.289435859465485, 4.155618786705664, 4.375999198453317},
    {4.419825284736129, 4.1072001064167685, 3.8634459327234896, 3.8300570450002716, 3.8224781420991776, 4.189741311877519, 3.7553550158412783, 3.8167652052236036, 4.524186868211853, 3.9657538881509375, -0.2268952412021657, 3.871926207226225, 3.5436377779926196, 3.7761059674742743, 4.268638232247974, 4.268337950395854},
    {4.1913183111043, 4.043402989408612, 4.067034223397652, 4.285229764914443, 3.8162011144254664, 4.210468297150733, 4.550423164775466, 4.614206515409033, 4.281140921513804, 4.207495261121353, -0.25436156579830904, 3.8863820357743006, 3.6558927933300414, 4.298899907865221, 4.363352788445371, 4.153659812215807},
    {4.525175570319808, 3.6384914769234946, 4.106999201804782, 4.268104154897207, 4.093732373730347, 3.9046152861891645, 4.574918200222516, 4.44256921087912, 4.177671626523024, 4.180527323862285, 0.11431617458059995, 3.9375726942751488, 3.543077580557191, 4.428337260784157, 4.124758953979006, 4.421006021249735},
    {3.9583732487813528, 3.8989181695879416, 4.217143092869975, 4.698609415027031, 3.7831976257447693, 4.050645596729487, 4.299685575793728, 3.7551969557883456, 4.6824403480602825, 4.52215559999082, -0.518471429027128, 3.5172260047104027, 4.248252172728904, 4.347006719803598, 4.29524576800827, 4.0822760917027665},
    {4.603628562331126, 4.694116434515897, 4.152299358039786, 4.397833499364233, 4.175546162760773, 4.5019693754160555, 4.338595070457206, 4.5266189338275105, 4.260533018722456, 4.387032304728215, -0.20976577465674653, 4.037704073219333, 4.369322836303407, 4.686037120644115, 4.192107658828038, 4.291179095683906},
    {4.18005864381971, 4.690182337045292, 4.326967750754984, 5.019040076734236, 3.8288694631901348, 4.179977499757748, 4.570229336688888, 4.334532267964425, 4.433684819148263, 4.574802049018319, -0.42848192701966914, 4.14575431135812, 4.200862267411971, 4.534381155416061, 4.639470190259925, 4.795159150007802},
    {4.334343044929305, 4.232543088051705, 3.939618449421137, 4.319422561301781, 3.894110249778686, 4.277963749458126, 4.204311966510106, 4.251688979858385, 4.442577324885536, 4.3203766083653745, -0.09636878330525916, 3.906116765972669, 3.9110323784558467, 4.1178401547882535, 4.134412417988857, 4.513104570714546},
    {3.700527300058464, 3.70512615756852, 3.7962586383395607, 4.0939524893528, 4.236237809279872, 3.918101861507674, 4.714673055002006, 3.935535158384736, 4.119875247027361, 4.243895545757349, 0.23292062434409289, 3.567544419045477, 3.4488927883982297, 4.408030471307559, 4.457269777177253, 4.409244977291936},
    {4.7745005997111365, 4.519858764265485, 4.339370012102868, 4.152292013929448, 4.029534029218375, 4.174322876590399, 4.622151527031113, 4.1289181267828425, 4.523740234046954, 4.501176591055719, 0.19160029266139192, 3.9734973606678885, 3.946817494724879, 4.2032211377692645, 4.291236228029762, 4.382955133509563},
    {3.703533903664667, 4.151952294739838, 3.3159728232170735, 4.448500962169558, 4.115054692396036, 4.183210064291614, 4.148315739226434, 4.445744678876086, 4.303045999978172, 4.1496465068309725, -0.522230774360459, 3.6978851315494228, 3.6278290876439034, 4.284707477500345, 4.2555909960278555, 4.226638551894129},
    {4.155554932240627, 3.5399513197089143, 4.044564596599992, 4.131919869384242, 3.4486607553708204, 4.132025802402867, 3.9804522774475495, 4.721875567729839, 4.21913318614463, 4.2525124649403505, -0.1485146912567846, 3.7886315911880755, 3.631136996700186, 4.035959636724073, 4.599701290729051, 4.616152066621514},
    {4.550909862231497, 4.3648973358563055, 4.634111776345611, 4.276056106332743, 4.440353589602923, 4.567164143716695, 4.4121784456771325, 4.633353897684758, 4.741892324939799, 4.590983356488789, -0.27096952916497685, 4.040909448234646, 3.894066984250956, 4.331157266760393, 4.530881180686247, 4.240064595581287},
    {4.271741084468629, 4.3209497274433, 4.062090369334872, 4.517693342194858, 4.017215804957356, 4.527889340654376, 4.220731329914243, 4.354121590814126, 4.651451665409074, 4.7790412139660345, -0.17838004491368584, 3.394355722707747, 4.016356198487034, 4.180137223501994, 4.530503106821446, 4.026194144780915},
    {4.3476047037117675, 4.0080290576349835, 4.68237917735969, 3.8566669447712134, 3.6844424588461964, 4.493100566460727, 4.156452898727183, 3.880084320866674, 4.552559725120026, 4.27563513297339, 0.09411296238695366, 3.874223259257133, 4.0630726593341135, 4.270897683364354, 4.572889440228439, 4.090664818441834},
    {4.153602985614051, 3.881579555928663, 3.8921537681150133, 4.263080760629391, 3.4686452760778024, 3.904937789501801, 4.115426830433676, 4.193543868856106, 4.199191350613712, 3.491041763690197, -0.04966827198683217, 3.7375181014115113, 3.3642299038217858, 4.410827455545656, 4.076283970523089, 3.848123651568423},
    {4.6942029313096265, 4.378770331500965, 4.412318007518762, 4.073408748872607, 4.387272279378887, 4.170989029302867, 4.208674658673619, 4.169036027593565, 4.43980934991611, 4.3369616128605415, -0.10352755619714457, 3.956464632427556, 4.1993462736941085, 4.316629044037299, 4.845877185376068, 4.794921127851674}
};

static const float b2[16] = {3.62119889234964, 3.763789218146638, 3.8545560338320546, 3.706914583272734, 3.729625301496816, 3.5789243516884834, 3.8517683215530445, 3.8390645079973984, 3.8332694449648845, 3.80396427714598, -0.0749441946074026, 3.867188852886378, 3.9931120400914493, 3.913273421917425, 3.7992718633638116, 3.746711154669636};

static const float w3[16][12] = {
    {-3.119775695728209, -3.734259086157057, -3.247824170944563, -2.924134069578847, -2.689675958156529, -3.1513594113295778, -3.6550381171872726, -2.7376051539411437, -2.9899605539913794, -3.0109043274758185, -3.6673605458953027, -3.0624090356394067},
    {-3.3669650571063943, -3.307981826324377, -2.636313203793382, -2.5491243288442393, -3.09087046631519, -2.847052101990501, -2.496572823455766, -2.3925032540184574, -2.9416987002291006, -3.189587507274773, -2.4290946268910587, -3.223475563900036},
    {-2.6871457675907378, -3.193054660246495, -3.0251747289099744, -3.246845343750014, -2.830888903005849, -2.6999817398248878, -3.4473857274656154, -3.9407090707466215, -2.8350179194866545, -2.884995724535686, -3.730474443401629, -2.990230068714003},
    {-3.239330914088494, -2.2905235881920873, -3.1582762511701525, -3.1097681794589547, -3.3807948781247754, -3.1435567553732295, -3.362052310819754, -2.978105583350539, -3.7378793583082324, -2.2207272637919204, -2.949578153876358, -3.1366934704622103},
    {-2.71646300528974, -2.464181058002905, -2.7368035829761856, -2.684661228450561, -2.882865796261874, -2.654740653463289, -3.019303749656693, -2.4404221991593764, -2.0638930069951584, -2.69021456632141, -3.005381071350647, -2.8554673314719294},
    {-3.2296867285128172, -3.3519171125745344, -2.95079043440302, -3.0097807687075115, -3.3316996675628108, -2.5954758130852715, -3.4523627003503417, -3.3482538811744855, -3.205366441222533, -2.6667651811871944, -2.368391230308035, -2.792146394198376},
    {-3.2171268811197464, -3.0060572704606763, -3.474719171853913, -3.411986777828842, -2.6304245796504437, -2.876062894613421, -2.958172814431887, -3.2607420910908282, -2.910895980772258, -2.7269666844934988, -3.0923290568265243, -3.2411381346795345},
    {-2.470114441127133, -2.3033579041289505, -2.9898130042638944, -3.35827754622338, -2.883742493299541, -3.686026679901652, -3.1879998848406057, -3.29292987322599, -3.0100150809242616, -3.3896688953332226, -2.9197394653271096, -3.9991329473328903},
    {-2.859141500400331, -3.006888416224492, -3.39302594587786, -2.4392870180652104, -2.819207553735104, -2.892274960777962, -3.2799361558325066, -2.9615807025750556, -3.2222374571371715, -2.962598611135515, -3.12094521710792, -3.072677678667126},
    {-2.682640046069633, -2.77595689891449, -2.5248084952021386, -2.7333351416824447, -3.5159570583243984, -3.2912672453815692, -2.556041757056098, -2.8437358368057613, -2.950499566410842, -3.096621013526203, -3.410106646708158, -3.0092846134674334},
    {0.2961828765337516, -0.439639769783945, 0.27477588753043297, 0.2949194682501021, 0.34975223566794683, 0.5040984040115087, 0.17256232961107826, 0.31220793723330886, 0.5237320830184466, 0.13776834137047053, 0.1411612654338202, -0.5642735469090141},
    {-3.1323757083036674, -3.459710888849004, -2.679779683516785, -2.404012695208584, -2.7780336926060354, -2.7498529874359505, -2.63360232894209, -3.287372870895082, -2.700644643859253, -2.8015824030327865, -2.843914387352897, -2.3650894219092726},
    {-2.5810492685368422, -2.8259971269546136, -2.775137650159447, -3.1900863807656394, -2.6232703289827684, -2.6999295820356632, -2.858484140260725, -2.1876479047087356, -2.9602074151868583, -3.014219927210059, -2.331618106738515, -2.408714249819407},
    {-3.0409018432075916, -2.932135075643535, -2.757461153788451, -3.152724003301926, -2.9030245388640328, -3.10653264181184, -2.633734243536388, -2.9054501312745415, -2.9307374483976103, -3.5269970525046785, -2.5544007802053827, -3.2506734955631837},
    {-2.7518030193221485, -2.8690149717635167, -3.0142050093253845, -3.133361534863615, -3.0247231135083514, -3.1884258549505167, -2.155705800287236, -3.348183632684378, -2.8915215567366226, -3.088933149999458, -3.017156792839088, -2.389640314412942},
    {-3.311465766347403, -2.7045394808989074, -3.081836374136398, -3.0081534159412247, -3.031717991003714, -2.869589853514008, -2.821500271301571, -2.487155528908869, -2.9662006312970224, -3.16788226385362, -2.943006083173582, -2.6056436104615623}
};

static const float b3[12] = {-1.2016228470855261, -1.5926762880199836, -1.2485981087397144, -1.300815225684272, -1.0506869093889337, -1.4170846812818187, -1.7298166058667306, -1.3804911768959596, -1.1738683177445288, -1.2420889814122353, -1.5114886197878143, -1.5245693264856144};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
