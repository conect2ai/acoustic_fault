#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {2.9954524693252726, 0.547398125433825, 0.3244760376707428, -0.018073566914920153, 2.471339078259659, 4.398485714872872, 1.1924966303864875, 2.109546120798211, -0.5780509158416394, -0.46797221199732497, 2.9382053052538275, 1.19582758149874, 1.7757595641019615, 4.291554210087745, 0.9387292099327293, 3.962443281750872, 2.2502260376216916, -0.392782043486159, 4.1467038474508735, 4.476549536411983, 0.8382886132938496, 3.1161720842008833, 4.602248083504285, 0.04905541802888691, 1.2654268931772594, 0.5897259009864463, 4.090361691815248, 4.054499404590211, 3.9016686352834187, 1.2469388068381249, 3.6018436410368224, 1.4025507846891376},
    {-1.6578739888458338, -1.653240210263758, -1.1065965362342365, -2.927243565395719, 0.712693258714587, 3.5632297240652933, -2.212442738716899, -1.398349216714633, -3.762404833638146, -4.00504355853, 0.25946273839193973, -1.9366373987802374, -1.7036366121252131, 2.2211054935788006, -2.0609868373372775, 2.051357583385211, 1.3962553373976672, -3.724851191557275, 1.6850167302425898, 1.0763630391194654, -1.5604076789221557, 1.2584472881658084, 2.1660688648402124, -3.7170168103362156, -2.7337885515609432, -2.8561596112779957, 1.689152814496115, 2.6463046282576705, 2.29790454433889, -2.5486535629440015, 3.177281995921948, -0.07456805944417058},
    {0.8219634873877434, -1.9269704479297913, -0.9186853598190571, -2.4491030797223923, -0.8467146146055117, 4.531253060672774, -1.9387998943957399, 0.06355713277908517, -2.8195238550142006, -2.7338370017308127, 0.28613271794663353, -2.2278775596069824, -1.9096640362128392, 3.964906887233411, -2.2225319949959963, 3.9109387054573883, 1.2977728304692533, -2.745425637110395, 3.2328895732862253, 3.1038601319057517, -1.510572110282302, 0.9270378962084609, 4.01208983844617, -2.3515654391954706, -2.2144307994983725, -2.14310604556141, 3.4273156821885, 4.271710741405366, 4.3045226035637345, -2.116589079703355, 3.8023206452318137, 0.18494079288048873},
    {-0.07462189534338176, -3.091625045928468, -2.1840069897360572, -3.478083895044409, -2.0613480354356035, 3.856539198665696, -2.983622648539622, -0.8334567107125004, -3.7914495257041616, -3.4030739557965126, -1.0745216294585986, -3.1197507718401174, -3.2770401883826366, 3.5264215660298235, -3.0578672530648543, 3.434193128845367, 0.4484460785866912, -3.6484432990147426, 3.07055382154648, 2.887427335371307, -2.93409163590804, -0.3221672823613749, 3.837444732330711, -3.6682924790898106, -3.27852511424285, -3.2681211329695854, 2.878365223374224, 3.632771992330062, 3.419152527574069, -3.0771965953626177, 2.9368190511744108, -1.1236040588044667},
    {0.1466843252171027, -3.8484862882827158, -2.7508025089212618, -3.530903365396179, -4.103617911656627, 2.7615840692459583, -3.77750445916307, -0.8920697242200895, -2.954010719941898, -3.0094273416751367, -2.011902869926817, -3.674200374992272, -4.190268865583526, 2.7414418386315518, -3.4415404303316075, 3.0435684597833084, -1.3056428340391026, -3.398052190370981, 2.3959239947102557, 2.0810987431154437, -3.496399533626686, -1.7214907689947556, 2.96233353849729, -3.504674164310796, -3.5162108598112445, -3.660107694902044, 2.503255754281091, 3.050633219646109, 2.8393832527533793, -3.250136908134208, 1.673525211236146, -1.6653107621186964},
    {0.4698067837246643, -3.9827487402617416, -3.270883176016807, -3.305290438440848, -4.409569398437967, 1.35890411037631, -3.769896278729685, -1.3370531651049955, -2.713842974236281, -2.4769199204820787, -2.31152296770055, -3.5848155601729546, -4.673204620583874, 2.1038277969868657, -3.5386463313434136, 2.4116348698483696, -2.176484413608855, -3.226332791622312, 1.5130573476380367, 1.6751819804880457, -3.7451992186270586, -2.575775475464723, 2.2028406336366526, -3.3546342526272666, -3.5528568577771336, -3.5083436712723386, 1.6290515949665128, 2.152053077986614, 2.12679543833613, -3.2595618249017115, 0.34652208773052834, -2.1205538812827203},
    {-0.07418323553263696, -4.046314991479659, -3.132028978366241, -3.733572071979968, -4.070424102325858, 0.45521106603458866, -3.964969678679275, -2.206617037793196, -2.961263293718381, -3.417255162747296, -2.748209136952431, -4.074278792340904, -4.764756425604696, 1.5749775094856724, -3.8416783695148085, 1.6205614655672487, -2.5838453359268434, -3.7442809222242217, 1.0184508681290543, 1.0496522002208932, -3.5224771484272805, -2.9275853988815608, 1.6347541723285415, -3.900085318923383, -4.141113064236014, -3.868760107444877, 1.1165921369333882, 1.288646619320629, 1.4912445020653768, -3.693493230733659, -0.5453766146477574, -2.4109417388045205},
    {0.06063029783507658, -4.311618749369377, -4.1615974430526705, -4.275161396944959, -4.360629497517287, 0.1435783314416945, -4.124957154886576, -2.648196532038614, -3.906483434486491, -3.370208944979199, -3.3548302311955043, -4.27802604156722, -4.773418969580907, 1.9070004361162811, -4.110769094395298, 1.2009899929704757, -2.63809218228188, -4.301207635532123, 1.2693314358898524, 1.494465716111417, -4.291579896880087, -2.6690922261514363, 1.7444829916987936, -4.42182174947428, -4.0853734410636005, -3.7676804979963725, 1.633727286459276, 1.0442158968456012, 1.1937866043344094, -4.320478551679238, -0.18515687809068093, -3.005646308347708},
    {-0.025770358165709155, -4.358716489615107, -3.893672111419065, -4.124748616968396, -3.7755220273318106, 1.6939038232104775, -3.898305564853448, -2.592201451724431, -4.041335629166629, -3.5509390741375535, -2.7203313719202735, -4.2100234027330865, -4.303240557295477, 2.285347318162398, -3.965004608163272, 1.9537452613265598, -1.8858975979123074, -4.1982878512051895, 1.8581524021363884, 1.7668755809238295, -4.028098737472314, -1.5002717581118068, 2.5385627464714617, -4.342108081852181, -3.9124370706274525, -4.128850225389268, 2.4039749956183227, 1.924658259290545, 1.5659890385605226, -4.113965740101114, 1.2165486047296907, -2.619867980426059},
    {-0.7693177388363428, -3.795284297459656, -3.097853817780153, -4.140083464125753, -2.8412424695955196, 2.8681367616171007, -3.8990136597831495, -2.4408186617426715, -4.357129602624058, -4.157950635637729, -2.014255790377314, -3.9997105312984815, -4.001649759483757, 2.234676263332713, -3.8849292754594194, 2.4212204503533057, -0.3109512265926585, -4.86340663112563, 1.7357860912520604, 1.311405680712545, -3.5582773761686908, -0.9119666328854015, 2.288404325561098, -4.695101630467608, -4.240370035566046, -4.260573173108086, 1.693634706239039, 2.517375564662245, 2.1152540079786983, -4.374894072069075, 2.351116982420561, -1.7124013751089115},
    {-2.050094448998591, -3.3165093400020202, -2.6859221633119024, -4.228694979509211, -2.2535179007037622, 2.2925526051315526, -3.5479918304731943, -2.423296637735028, -4.6628319181028886, -4.680183083728183, -2.6307116264885737, -3.7949294685890735, -3.758684048595241, 0.48269849264119236, -3.615939021353737, 1.1444221977229494, 0.19502465769051097, -4.422882371707381, -0.025049486746370486, -0.4123738776604106, -3.201016937505738, -1.746140377655913, 0.6001905687642216, -4.498348485610424, -4.185868465486719, -4.2487614612253894, 0.05014362011656625, 1.4195968001964367, 1.0641695493790293, -4.2816304527927, 1.874092483007218, -0.9557238773934156},
    {-1.432536032562784, -3.8250009695366156, -3.3433666146326733, -4.357615153004794, -2.904232132787393, 1.787462980087175, -3.6627476107904378, -2.883093756028203, -4.711238035482269, -4.339908267319082, -3.499425153755061, -3.9238525040985137, -3.6802300347150583, -0.012703621842968114, -3.8609927321013644, 1.1178956969893605, -0.9157183119730221, -4.424584792048022, 0.15691062037471745, -0.0025511698485075366, -3.3113061062971765, -2.3240263379435895, 0.3800074227819071, -4.480304752426835, -4.265456588186644, -4.099434517757714, 0.06347893898526233, 1.1993953489702318, 1.125625680675024, -4.008057363156468, 1.1009808455296832, -2.0436223246603027},
    {-1.5654494907192757, -3.568600175767637, -3.354364906401407, -4.2656398391913575, -3.1603192868469745, 1.9185510289582697, -3.7067805200146986, -3.1236479797528203, -4.4201108308407955, -4.250135008226961, -3.697038987791871, -3.7216766057227653, -3.4654768573745107, 0.35540220368935704, -3.7747356438500503, 0.7697189739243121, -0.9869947749957778, -4.389126269576483, 0.5578541319983005, 0.15183765769270188, -3.469962066787415, -2.4949181332263453, 0.35255530566883775, -4.257809923751149, -4.121671258116919, -4.1021798015955735, 0.3172844427230206, 1.177288603059782, 1.0233110017523797, -4.066876316499315, 1.0523565970707383, -2.1531571220636985},
    {-1.8207020576866224, -3.775924696409504, -3.362593326372626, -4.238708435928443, -3.622019071528535, 1.8973825745369413, -3.760569534753757, -2.921814636594982, -4.5131047050100115, -4.108349710703292, -3.3449096377983416, -4.279085591473688, -4.081469280006192, 0.5596978712909914, -4.1070304310014905, 0.7962523572060406, -1.1590423528536424, -4.395709394097904, 0.17958367475755693, 0.057989315826646536, -3.824424785159397, -2.51862639922896, 0.0692699237734612, -4.430437321046678, -4.37101038834741, -4.387499411998495, 0.1251034190818857, 1.027522887361279, 0.9243191929324752, -4.2335867995722944, 0.26278095323045375, -2.6128030405076106},
    {-1.3244476689736333, -3.9039507685575257, -3.042912664275835, -4.329352262379626, -3.132655281670054, 1.839904813477793, -4.117521484468777, -2.9176825154761987, -4.389222736678506, -4.191274098275222, -3.118416986427405, -4.064592840880712, -4.008630361577062, 1.613201264504751, -4.013736474642658, 1.3492771755366053, -1.4039969827889802, -4.788214829195249, 1.1225471356598027, 0.7832261720251431, -3.616781963294139, -2.17928387293512, 1.3633333968742292, -4.350670422891371, -4.278525787029113, -4.4566911009442025, 1.1690738735091748, 1.5936406279864535, 1.5195055453684778, -4.098868807755711, 0.9834603739956772, -2.3266570173064087},
    {-0.8372485758236174, -4.053815930296952, -3.3660864205913095, -4.301888086876247, -3.9465505015737796, 2.3889386963621795, -3.8420542024361777, -2.796223123345616, -4.167161840709591, -4.28844746146772, -3.2244247298210555, -3.865253391212199, -4.2251295476865876, 2.0302458079984325, -3.795483860477995, 2.119216549257657, -1.1855421677163116, -4.896229835520903, 1.8495023498111092, 1.5242773238491114, -4.047987669772201, -2.007003916484562, 2.161731289864748, -4.609086258109804, -4.115044016289442, -4.297560629487833, 1.917626563338065, 2.2764388597674743, 1.903246132771166, -4.198928246416148, 1.5249971749543432, -2.287759858199519},
    {0.02037832722564893, -3.8175272869221217, -2.8645122940683487, -3.842454788284569, -2.9020527008549144, 3.2543351484960357, -3.6752181381610805, -2.106012031074471, -3.8401507982734078, -3.5417567906784044, -2.367272473192415, -3.4406329654063086, -3.5611288307155617, 3.0107767716057694, -3.485445302754709, 3.033404411785547, -0.4525521646541556, -3.9403986676688305, 3.049724269712807, 2.832170413121696, -3.4503447850275455, -1.102152423746024, 3.2346676032225523, -3.9464300149221874, -3.426514938558482, -3.8819464135053847, 2.787911627279843, 3.498872646778408, 2.7971327488433912, -3.4198316368253394, 2.6997349884121546, -1.7926142023589242},
    {0.9967105585837003, -2.525861371587097, -1.8242690324582185, -3.035543907659652, -1.6600686121424484, 4.3094446842695415, -2.4327282522178884, -0.8877377132039166, -3.4576487233098305, -3.0701908478312627, -0.9398654660153004, -2.454043117149599, -2.2866791806004247, 3.886168663051476, -2.804772202805779, 4.0104441130190365, 0.711998140993203, -3.119218633038911, 4.042016125342804, 3.7708315658802225, -2.455094210566661, 0.37608329305481025, 3.9619754466046486, -3.0952082389320346, -2.829590548570845, -2.804411803613786, 3.6147303988783217, 4.086632746598463, 4.051612288844663, -2.381261268578818, 3.4504859662036824, -0.8282082391067567},
    {1.1399140441841744, -2.714953620866181, -1.6662152797942944, -2.9204304291034306, -2.184659422801479, 3.871930988010561, -2.9183186844711266, -0.47069415694480754, -2.8909370418059357, -2.688524161282998, -1.5974673848162018, -2.56411500050573, -2.6891236070931672, 3.63977023667174, -2.8367702946751643, 3.8205569740883885, 0.31756234869216926, -3.0876881209508453, 3.3239533169998463, 3.011054633278447, -2.4228307187468734, -0.23097512710742021, 3.531177489980249, -2.784245329271387, -2.9226641599246097, -2.8126079829064357, 3.1862279536793148, 3.9909744372720115, 3.9674284540670395, -2.966091184873691, 2.6247434277413415, -1.0079841075014695},
    {0.10083907192098787, -3.1853131990340917, -2.2307193209229026, -3.6470763574344685, -2.4548933241787756, 3.7105306019687547, -3.3525280039676137, -1.2403728624846284, -3.559998984072585, -3.38051955378631, -2.0098523840512756, -3.2416830267195675, -3.7028654208277842, 3.0920328611370573, -3.5549824072407024, 3.5340640704201185, 0.42080190591294186, -4.039545662629232, 2.943938970842404, 2.388546657348436, -2.7890053427794994, -0.5668562116069247, 3.116600349370997, -4.04468784744237, -3.692088741326017, -3.6429682642076338, 2.5543756749492212, 3.9564434406166633, 3.589771043577986, -3.2725837119776156, 2.6614014995841324, -0.9811079995958207},
    {-1.2501643739223802, -3.146059200643175, -2.0290144807442005, -4.059720477456516, -1.7099231711417726, 4.103672052497737, -3.2642151486057167, -1.5173455981962654, -4.288720840152523, -4.219812675002623, -2.2578017007816253, -3.3373928677600198, -3.0266573503047614, 2.9254048547814593, -3.4904791090517757, 3.3720075786110755, 1.1844606100443882, -4.163160626097153, 2.593925883935283, 2.168995501747024, -2.695883633678632, -0.597104457623391, 2.8859720033444125, -4.2582935426074915, -3.864406100378124, -3.9255957118998976, 2.2232092897447306, 3.8793495058649343, 3.590746744759358, -3.8156350972975446, 3.47139491044452, -0.6495578001154076},
    {0.5410300062390725, -2.1278674821342998, -1.1309980853564572, -3.014350060190131, -0.2397964853483105, 4.822192021596041, -1.86420428724921, -0.260755772616118, -3.6293873765141194, -3.5390637350753127, -0.29893616149280666, -2.2313507137423576, -1.5956450313229344, 4.075434799724204, -2.4386372091122293, 4.316311498046582, 1.964919665239184, -3.387084492808274, 3.793875240717319, 3.6169774636496803, -1.666870877081243, 0.9171311635690358, 4.264703750849814, -3.470069622345621, -2.8157001480795163, -2.999985880543427, 3.5180316687473248, 4.555709201256146, 4.262936108970872, -2.6656463250719566, 4.299354836008409, 0.23791991250577577},
    {1.1999117792554064, -1.7337630980985472, -0.9651073282313996, -2.329353236617483, 0.6038838287755283, 5.089202738670771, -1.2344301510714701, 0.5392735511413049, -3.462975637995283, -3.05367302605706, 0.5076971643161213, -1.6220611316407583, -0.35958584797207976, 4.322189669111723, -1.5910186079117041, 4.169152919725698, 2.3649403824926725, -2.8560359653776004, 4.00251947052655, 4.094386855279873, -1.072946553926017, 1.5932637586402405, 4.414189594695046, -2.506432902146575, -1.9409655390139506, -2.1397512431432686, 4.027029053548406, 4.729903145887306, 4.38493716183121, -1.8203306871457348, 4.291227108280035, 0.3102362029794135},
    {-0.06070035091093081, -2.5816892163478165, -1.8660301646629742, -3.320328000604712, -0.8379546158473274, 4.455283629618835, -2.251812045400695, -1.232546269762699, -4.039661199317618, -3.785909049566961, -1.020319911194416, -2.3884234450923723, -1.6262716158150996, 3.1506416628823533, -2.6901315339629432, 3.5072424169804286, 1.4959713541517379, -3.659483373158358, 3.3837084635567156, 3.0767825389936787, -2.167807256364785, 0.5426345959138346, 3.4458499069061546, -3.3537236307267864, -3.054290898636567, -3.1352189662409224, 3.1790617079144985, 4.196317897223932, 3.80009112164069, -2.815085000323741, 3.9603249832700698, -0.6931794330892914},
    {-1.3119814971711654, -2.682008115533546, -2.0062555557281243, -3.602375026084307, -1.1794400453182747, 4.10369328867014, -2.6565734933193075, -1.8235084995409083, -4.170223129905072, -4.002011619798639, -1.4217733878821661, -3.00452727280992, -2.1437482759074675, 2.3619792439396696, -2.9072174175593037, 3.114285593290301, 1.6010037842143723, -3.9148770685992162, 2.1850208872821395, 1.8822633939678004, -2.486375420495776, 0.01000637630134183, 2.6517830057266325, -3.8061720360485904, -3.334698909298181, -3.378445165558278, 1.9108583253487892, 3.617040384765335, 2.953615221245693, -3.0190778749946987, 3.683025021226961, -0.6328204259629597},
    {-0.06836652514945209, -2.217067867034162, -1.2857699540085632, -3.169789827045481, -1.0850015534755242, 4.06900153784961, -2.289213677520886, -1.2253454510912603, -3.6731112577227343, -3.670473462657825, -1.3806363557501917, -2.4692163014162882, -1.932527398930563, 3.0454667129398034, -2.848116158606684, 3.512388000411691, 1.427783198626862, -3.466628520839128, 2.9651180136586808, 2.796431296482757, -1.9492684283159787, -0.1758568273603741, 3.1977849143870576, -3.3470158724220385, -2.903851405523504, -3.173650534939491, 2.9156689541648095, 4.244332595308124, 3.957302975244324, -2.937520875465324, 3.2263689955418537, -0.39222170153237174},
    {-0.27597502769717674, -2.6880779813191937, -1.707187371236674, -3.272370245903733, -0.9999243851344944, 4.694007230964084, -2.5541609444135567, -1.1584062669176447, -4.071080792341801, -3.591366111912919, -1.2965926330352957, -2.7249566627851647, -2.2322399587340103, 3.4803555268750306, -2.923959336097331, 3.69024090724123, 1.2916900905421453, -3.8395261116554136, 3.4089946429748794, 2.9989287114704637, -2.3082615830809208, 0.12416514542811888, 3.435846568751668, -3.851156458737836, -3.0239517060389294, -3.2545815153400866, 2.956418200718388, 4.298522459797261, 3.986636781279298, -2.926294695583628, 4.00310703492887, -0.41830051301719273},
    {-0.4261120627831238, -2.972316218658818, -1.459549862900609, -3.148977122900605, -1.1729692106234948, 4.6698033272180055, -2.541869636387987, -1.1731883738632964, -4.243387342124612, -3.885080618951621, -1.214093428467646, -2.7602402892743436, -2.2392637169286127, 3.4247444504707913, -2.731252436517909, 3.9860039637002944, 1.4846380146530966, -3.9431510280221986, 3.188795639584689, 3.0122660400618977, -2.253472845697216, 0.11500921350838234, 3.5292683381370327, -3.6700021066258084, -3.326852377703944, -3.286067051615432, 3.1956808432613633, 4.292712337622145, 3.842317430065402, -2.9382384300829414, 3.782658571098905, -0.7391171557455913},
    {-1.0850406682467637, -2.533615669506092, -1.781461084170064, -3.325798619694558, -0.8610312093132607, 4.488795543284757, -2.5979592431009344, -1.467783267184186, -4.346084921564882, -4.161703272464801, -1.2546632265616495, -2.9682118160324173, -1.8597365412926603, 2.766679780731559, -2.896225345407352, 3.505393806684237, 2.0174108013591003, -3.9807281253606024, 2.8398928692142253, 2.413978720455451, -2.403677457122984, 0.2909847244323806, 2.909695238400366, -3.8489962082769242, -3.169716486353023, -3.319074420557843, 2.5212066866367673, 3.9717498686239283, 3.4514578190837564, -3.0247087084272724, 3.9477046456750915, -0.35032345820444394},
    {-0.8488514817754228, -2.1531714440954928, -1.6037993489371778, -3.3352513391100844, -0.29688963484788894, 4.490918699473785, -2.1450092012620376, -1.3812818567817113, -3.9360057532484944, -4.023410732796389, -0.8795831861169259, -2.7904063869844857, -1.4742695620543953, 3.125116394072322, -2.5877669830144865, 3.503859907840567, 1.9953793903310089, -4.284014235308798, 3.055366440078101, 2.5320965612001833, -2.067471432443118, 0.6953912955802626, 3.2154124865472586, -3.920386798490493, -2.9731999300261145, -3.279067651922984, 2.7609733149958138, 4.08604922721739, 3.629380617997572, -2.7643374754978547, 3.7183761227763497, 0.01926419536495911},
    {0.11494887065432859, 0.4507211426319052, 0.983918985919916, 0.22892345627714902, -0.26203663990661635, 0.032624171869762776, 0.17241539966334005, 0.2238456086286346, 0.22219132818043855, -0.2842292731044524, -0.5781632478487271, -0.44519973753778685, 0.25078029011915876, -1.7300681997382314, 0.015484557268900174, 0.5989999507422151, -0.051441301993472244, -0.10733068571096364, -0.9729470264976271, -1.064206484375158, 0.21852616302760713, -0.9303615958531186, -1.1849041060834218, -0.2372883156282506, 0.006790861562409963, -0.3838211467225542, -1.2970929236236994, 0.2282018186262429, 0.9595993929971025, -0.5339043042302928, -0.8342948002896073, 0.49940660166400086},
    {-0.5130989706077703, -1.4244836235095772, -1.0349199560928697, -1.6125752872697523, -0.01665069029686387, 1.7637416504621464, -0.49674155479741094, 0.07342179193174844, -2.1733606965711543, -1.931425610347137, 0.25079920524617705, -1.425397254227694, -1.2561065541434426, 1.4970395070330962, -0.9625858236096718, 0.899720801155963, 0.40339883477087274, -2.623601806366789, 1.0816920963845964, 1.3746591742694596, -1.2455564807885162, 0.5438810472212414, 2.3317101162871094, -2.5743110371432363, -1.1969327204875382, -1.2000930029066634, 1.122722036224726, 1.6757833028412081, 0.9708927458624625, -1.3171728993927994, 1.0946403031637844, -0.32853703683761903},
    {1.491459706557744, -1.9362292125638212, -2.2868936848498915, -0.6773091607727921, -3.0424724552609823, -1.4936558328425593, -1.3575540385463263, -0.5843660806538837, 0.40809723083938637, 1.1432659391540931, -2.04203888129531, -1.5285039141245158, -2.635043548539927, -0.17531931188508793, -1.8750663495664668, -0.31361491405778424, -2.8033618623524257, -0.32979733874609457, -0.031847135664408076, 0.7181318927880442, -2.016468150420012, -2.1414127031042236, 0.03684209249083812, -0.8953537094953252, -1.38837806399756, -1.2271472209022785, 0.49560154824109126, -0.24171904791362048, -0.3963178851418355, -1.214757956131641, -2.8342842563854154, -2.57077430425205},
    {0.21112273279173838, -1.5713690124346578, -2.51030405442503, -1.7414242136826537, -1.5935071365690623, -1.2397199278874358, -1.5347703040671954, -1.2454892783623, -1.5147397833396286, -0.27762234269567315, -2.135083142772744, -1.628246485362281, -1.6405963212096075, -0.8304011095311744, -1.7692837132485508, -1.193239304664793, -2.3336931432406445, -1.6140981764372104, -0.7524058513138051, -0.6895346702502716, -1.881906423156816, -2.1076018669933956, -1.2759264800673569, -2.088969257583078, -1.5606966748517566, -1.6668450114335849, -0.5553633936865124, -1.2437367659743928, -1.6571782345707746, -1.8160674288272614, -2.530498777696211, -2.6514002060861057},
    {-0.534031701193031, -2.1654581676194966, -2.3093456647765223, -2.7984345198035925, -2.43198281921218, -0.034546952159272074, -2.852035757940295, -0.7641964128142521, -2.5908667500112075, -1.156258685985084, -2.4037517770147714, -3.1209386479430847, -2.7152734481798793, -0.23604338327280114, -2.867504448601114, -0.044750412016856214, -2.3119971834702024, -2.615334891183309, -0.3407274416636597, -0.5025744348355564, -2.519552779703684, -2.7416131349099007, -0.36736328108243727, -2.6936921231272906, -2.912257089769858, -3.0192778425397977, -0.13471908620691322, -0.4749313719504064, -0.3558721294396474, -3.06333511230279, -1.6918735361193, -2.782082096581315},
    {0.5438754704491036, -2.9132446240180982, -3.039648170702914, -1.961014499213059, -2.4796103962809366, -0.5501459905740993, -2.241106675898584, -0.9972006372186416, -1.8300367172907095, -0.3297979443835873, -1.6621283312887787, -2.2022178599655655, -2.7910566237905523, 0.46809395731148323, -2.0571556101772064, -0.26997388339974493, -2.1475139795389286, -2.481366580479298, 0.205635213946857, 0.3523668944230061, -3.185985562245745, -1.883307606230169, 0.4013196322162833, -2.197962654501853, -1.906996657317381, -1.88665661669158, 0.9271007090411684, -0.5467294559938045, -0.30810249139660584, -1.8560174141137296, -1.7109315760708785, -2.574497852314388},
    {0.2995007102095413, -2.222853392101187, -2.8821395165186816, -2.6596511904699347, -2.2717190459117766, -0.13135134419900513, -2.433922338135347, -1.0609324587597593, -2.2640394717879, -0.8157496319758455, -1.8666002564901034, -2.5744645703224944, -2.818922953448247, 0.2091025110674505, -2.2476810827281213, -0.07359861474396086, -2.7010279164369013, -2.6662320684674063, -0.24481437696062835, 0.003471471954794692, -2.6230281107424425, -2.046865011964716, -0.04457055213956371, -2.4926523695929106, -2.5461110890039835, -2.375937616270992, 0.32849006352758403, -0.40423033317189133, -0.09988390377831222, -2.458055762367256, -1.8124218862305508, -2.2506676448844725},
    {0.11553409139766843, -2.575622693602129, -2.6887552113313, -2.1886604250655086, -1.8955003459528021, -0.25457435805102524, -2.0418899295227164, -0.7412703481832893, -2.182277673274602, -0.9980643575632832, -2.0432724780868226, -2.1685616806124535, -1.9808893812915835, -0.21412498559273946, -1.810586934944359, -0.45513858125358597, -2.4629112913379894, -2.61110929836875, -0.6375685417383266, -0.040185272921043805, -2.8128656937914793, -2.0258770029887665, -0.6536224482037462, -2.827914767046117, -2.289233497408414, -1.9776001677456134, 0.0582327201077643, -0.6643007277322597, -0.7210364169042907, -1.8817880293250373, -1.9257893848837881, -2.708438158631415},
    {0.14217680685398734, -2.8695398629947517, -2.901453344435051, -2.611677082430452, -2.2651769202348935, -0.4740509584246964, -2.5459857319244916, -1.0214890526933431, -2.50362976206864, -0.46834192198669117, -2.604980105640254, -2.4704839532362097, -2.8940030036997015, 0.3045220665280415, -2.81188933470607, -0.10926012446030606, -2.54305018300813, -3.2298254836224696, -0.26630759074999993, 0.3779413449828726, -2.887711844265476, -2.2387054185069015, -0.0951177081637763, -3.0717302912455335, -2.4807659565661475, -2.5788516862307764, 0.11744552321580701, -0.3422614827344048, -0.8021362747476521, -2.7637369682668576, -1.8531754589075717, -2.958162716999114},
    {0.30351476042362674, -3.0640132295204743, -2.450462049904028, -2.6576566562844137, -2.686608162476503, -0.07083132385553526, -2.5602972452909647, -0.712866370518169, -2.2411080863897364, -0.5754700439926506, -2.216548141990759, -2.8131589923306066, -3.0074744475123536, 0.6723136260329079, -2.858052758913584, 0.8346815508271646, -2.5241187306774955, -2.822349806868186, 0.14360696154997163, 0.44765713511801797, -2.894471301673575, -1.9279468988229567, 0.23219751790648727, -2.5221108122644313, -2.5391366457638496, -2.6533231682280984, 0.546772440573862, 0.5050415045726111, 0.3756490500326696, -2.6353784099630975, -1.5372665773173964, -2.443789050845845},
    {-0.4587305376460608, -2.2435245358126092, -2.4709345202810034, -2.5477866298156697, -2.2409378992523803, -0.8083364949217171, -2.687551474368581, -0.7718541758294846, -2.362014481060163, -1.1546747467503242, -2.5504801368038685, -2.7420296419294514, -2.650035432299356, -0.8552227358071566, -2.433628764843235, -0.5513152378881543, -2.430569505588666, -2.5892683463228225, -1.1396578200135765, -0.7092096848284715, -2.4381581142667326, -2.5207551446032452, -1.063658540564991, -2.503707316455393, -2.6560192330033687, -2.4102299607625146, -0.8039903719842273, -0.6421453032669857, -0.42149723208102696, -2.4111401736129374, -2.178840628051901, -2.7115584436896665},
    {0.5057289278273339, -2.7665748590299386, -2.9076254145419407, -2.944692019216459, -2.830614411350673, -0.48905272524598503, -2.8532774070553057, -1.1725132247047845, -1.9716937985592997, -0.5333166751923494, -2.7447852597196056, -2.6338796154440685, -2.9246406569331413, 0.1789279383845424, -2.6192085319628187, -0.18586182723280018, -2.5340164167326242, -2.659673394166706, -0.09232503261581113, 0.33018970750023113, -3.068855370604735, -2.4343132502519635, -0.1220484917680596, -2.668812452890849, -2.7558180743393836, -2.772627240081164, 0.27828084259115216, -0.6087487071587787, -0.42790571534943606, -2.5417741177770465, -2.087592448114293, -3.0809589186437285},
    {-0.22180703026522047, -2.911289398252807, -2.8455960476469864, -3.240679273448526, -3.1822344247287186, -0.6358646914170344, -3.3096659769020063, -1.5454894855155126, -2.6802261007569252, -1.0084972661312726, -3.0157348529084738, -2.979465491364658, -3.3012408379380784, -0.6961438982697292, -2.5162371939693, -0.36136225104549574, -2.9714889977233407, -3.0691413475382308, -0.6832394537860326, -0.48127341480885794, -2.9368253033230656, -2.72491061188324, -0.9142866151976915, -2.9512955076775245, -3.175338098530637, -3.4022643700966944, -0.22564332831617082, -0.7448044946325377, -0.575137145885739, -3.3163885873752026, -2.546935023396966, -3.059495389237677},
    {0.5067000065357153, -3.1886075541142627, -3.285583755706524, -2.767862435995881, -3.1487835836904674, -0.48471947414239397, -2.991845814511489, -1.4327500085320843, -2.3138074499410233, -0.91642247694222, -2.641574895986972, -2.7789981244503754, -3.168138441567253, -0.09755267828934744, -2.9014644619568455, -0.054536206069442365, -3.0950018804933137, -3.3560448179949214, -0.21456615704570473, -0.3338017172684817, -3.098626926476925, -2.7523732158482423, -0.28537174122957293, -3.217979785274258, -2.5204157025422855, -2.923712609594047, 0.2740484673888417, -0.47057699579776635, -0.4251340800402185, -2.5165507987990394, -2.4948601480555457, -3.0865024070872473},
    {1.142149322252508, -2.9718497727170914, -2.536041109554758, -2.2208140095263005, -3.3558462195760472, -0.4105031001877001, -2.4248925338263616, -0.7479426142333749, -1.4727426481146375, -0.287875601895687, -2.2179212845245324, -2.909201444292442, -3.1705405259382724, 0.7694076528870626, -2.766688082008659, 0.6537805085753028, -3.0354059427731035, -2.160014818298411, 0.019075548971689494, 0.7351856815730087, -2.743818611516819, -2.4223350566817277, 0.5085627531606594, -2.197037467114637, -2.4271417552187624, -2.569213826144273, 0.8771066807220949, -0.058801652037414893, 0.28156792692072885, -2.3407694613600687, -2.661598240294367, -2.6601169169201664},
    {1.032040667799873, -3.043406845479384, -3.076990301716925, -1.8310669596365898, -2.975337994640498, -0.7524969563626941, -2.208461067441745, -1.2499409794076308, -1.336741621338657, -0.47206210845138835, -1.8914635086178493, -2.1770923841521284, -2.6569650004976735, 0.5832808748221432, -2.175728579385758, -0.15462207118152774, -3.2445426325815125, -1.9516042927200703, 0.1163504637282365, 0.6166433815092581, -3.163166780696819, -2.0571994683923647, 0.44498733224879006, -1.7650635766303864, -1.8414545136084202, -1.973951637912937, 0.5951854945062182, -0.45315606138116893, -0.2710429097641147, -1.9287119226194958, -2.607227829822047, -3.38260910310585},
    {0.7011202003958454, -3.0471855043093408, -3.2872425002985666, -2.4136451538424515, -2.337411539241947, -0.9274547882310784, -2.163458510819611, -1.5909075105080555, -1.7101357313442045, -0.6660489082950034, -2.15190243051305, -2.0018050991391574, -2.6959832041888876, 0.7417873276554777, -2.2837957167295873, 0.011751598494710124, -3.1809804392912833, -2.4862751191657226, -0.0855059365896671, 0.6415723985627819, -3.0465429075231403, -1.9413040208869439, 0.596081617924419, -2.1988220238786362, -2.1239644412679555, -2.394152883526055, 0.6517532360667116, -0.49249224398822283, -0.17301810030537637, -1.7851126578970258, -1.9571447192406235, -3.274355836907437},
    {1.6279492886387226, -2.944315216407483, -2.6718422360386533, -1.5198278425520386, -2.0267091411282654, 0.055901959121027606, -1.6126807014573057, -0.8651493034263362, -1.4449244278574211, 0.008673771479188805, -0.8609089842998483, -1.219951617116427, -1.9936059624074602, 1.3391332688912665, -1.7327629203892727, 0.6819228329229398, -2.709995111456299, -1.8509278093446635, 1.416162129744659, 1.4379993425841306, -2.4853179244733554, -0.9476713451158341, 1.3806412733186169, -1.9043761222285045, -1.3706879201259177, -1.7052932911958933, 1.6254644533022462, 0.3848064236454646, 0.31600613332348215, -1.0824345908580333, -1.5073965091130677, -2.5975712125595605},
    {1.0292630237199945, -3.1968201597259474, -3.0333892998714163, -2.1699124729547203, -3.019713622854343, -1.1042101007937921, -2.46066456776856, -1.1561523594480796, -1.2121146122521134, 0.16926537037451597, -2.6689636009588824, -2.0483704740118447, -3.263827379082844, 0.0005311650605947899, -2.197724536903804, -0.052072535154324404, -3.4934813926344286, -2.2774936145993783, -0.46082099637507873, 0.3400667170578836, -3.1235428935272362, -2.548339522047846, -0.11808709612001736, -2.0719732855164676, -2.131429249232185, -2.029895936807454, 0.11861397659570319, -0.6722881090244864, -0.4388579447049338, -1.9111703134584457, -3.0062032681759865, -3.315439026119583},
    {0.3737888101527967, -2.702623353580372, -3.0165565231425746, -2.5904836580764936, -3.529966846363479, -0.9018064409909013, -2.9316550454255035, -1.4594587034869966, -2.3594881898591535, -0.5133093793747611, -2.844005777856029, -2.8971215282330935, -3.8537269559973093, 0.31085620691100835, -2.6878667640625142, -0.0346853026962847, -3.26308211241735, -3.331478091976132, -0.3569564043302911, -0.1223444818057561, -3.2169671826503534, -2.913558242212246, -0.1433646042576959, -3.2686968374098906, -2.698578446639717, -2.9926226188376144, 0.12439683009934777, -0.9168288397603409, -0.3058647416503737, -2.6084430155203053, -3.0935061526795016, -3.3314949996461967},
    {0.12646636196176148, -3.2226960518115675, -3.4367547795202427, -3.1066433063204997, -3.575434348908843, -0.4202900784273235, -3.4224670466247358, -2.018491703915543, -2.9579964662070983, -1.7877583226791995, -3.415244032603978, -3.3128989036605647, -3.6235770364829527, 0.13644138287484564, -3.1198329140919308, -0.17923291480530945, -3.3606736413759903, -3.3189631049772066, -0.4709532507952334, -0.2747854746010949, -3.2846843893523707, -3.2583969433386923, 0.06166019399115364, -3.2389156182621694, -3.310201790145823, -3.1770927482526403, -0.2721555648928881, -0.4064737749205425, -0.3982484066628688, -3.0986567146761548, -2.3140000628500714, -3.5074024751609114},
    {2.174430403543657, -1.750456951994167, -1.9635528162936755, -0.7798609831638236, -2.2282525801318624, 1.633558167200221, -1.3440920468505468, 0.44472138401613287, -0.4335405411571317, 0.3437204542517495, 0.044715778984064175, -1.4231028689106662, -1.81736054099872, 2.5841667119072835, -1.4366309276516898, 2.1639955748053468, -2.228090460642123, -0.9745342190453624, 2.389254000117683, 2.7880297157412253, -1.8980477021658388, -0.2592951908888076, 2.8838351606226107, -0.8977817258512955, -1.0896415220225548, -1.1713535698242443, 2.5188090319098166, 2.1324535718953705, 2.146635226077122, -0.7709706886460304, 0.12879105629380427, -2.3038582961559477},
    {3.4376279447314273, -1.0400414754737595, -1.4468481522581957, 1.2799186880076006, -2.6270139119277833, 0.5581388785963605, -0.3165673710084676, 1.1145746521087239, 2.1244510095888653, 2.468649859456833, 0.8363022636228994, 0.5028323773617015, -1.0923366275132282, 2.8922604949502717, -0.2830692594141386, 2.2873210346812303, -3.122555286589636, 1.4044370456330082, 2.547866600005007, 3.0683823598220665, -0.8922147208177179, 0.25701600299682503, 2.7657166137134266, 1.3084867362806358, 0.8825671486320076, 0.8669650651869159, 2.920225488553938, 1.8569260452911467, 2.313185948657665, 0.6529857930326286, -1.2820614406495077, -2.445978388032134},
    {2.3367278742690183, -2.886617372141834, -3.016218771503739, -0.7025004149388965, -3.61543445471564, -1.1766654473307339, -2.0522122200975423, -1.084216067896871, 0.6688990436975031, 1.0718117145656807, -1.4904111322032143, -1.5465132112430517, -2.7986203172639392, 1.269888239999743, -1.8013259773763408, 0.49352779950280196, -3.775567051903727, -0.0980304686417179, 0.9401672121682803, 1.7991346253734806, -2.8425828589465416, -2.214204160020183, 1.3043139102278614, -0.3272619724833081, -1.1544972341309092, -1.2988147701391748, 1.3877076959868502, 0.0398373355655514, 0.46467792736585856, -1.0717931964206742, -3.2435301989642675, -3.511732678592612},
    {0.9674677132172987, -3.7103313798834248, -3.415896976631817, -2.813336509321686, -3.848834412413705, -0.9177607065973695, -3.112779506238431, -1.876425731255674, -1.838286831964848, -0.7956367932925283, -2.8251079079082975, -2.8441417262598363, -3.5966347386718356, 0.19853960850082694, -2.9131639708580828, 0.08377020138402695, -3.666757324785728, -2.729011484620684, -0.1604255893297161, 0.31052549716104444, -3.4737533805251424, -3.0303929110415164, 0.22612266131713685, -2.4060221217643, -2.8128340833528336, -2.9355211134556582, 0.27715573863376725, -0.621353414064212, -0.26674544249127563, -2.722265583997274, -3.4076901905858943, -3.8549457413286343},
    {2.3498807440294076, -1.5890696782603588, -2.357046215539442, 0.0966341469216993, -2.9942899515149612, -1.0526268093206677, -1.2850507776186342, -0.31940211586675193, 0.9822919944836069, 1.4683376051350348, -1.334823342549742, -0.8564238811728785, -1.8161707256523913, 1.3309192722611942, -0.9917987655527325, 0.7535210169220089, -3.9028230232493657, 0.8853333315075629, 1.1675246361233185, 1.5948154156327106, -2.197444601766055, -1.7086318734363977, 1.385169221540899, 0.27383306332917956, -0.42315522397793975, -0.3552031898045453, 1.3881648662732042, 0.20545636857560426, 0.9524551907263776, -0.15652242089703947, -3.365499063644353, -3.20930127785739},
    {2.40198014326257, -2.6848671237241617, -2.2183291843409982, -0.7429339395451904, -3.253824838408896, -0.08673005581220396, -1.703130555704504, -0.5908317990637441, -0.04116604759277242, 1.0658010552090182, -1.3729840239226196, -1.856153083505934, -2.3626899179730856, 1.529256039980789, -1.635628021943617, 1.1217468054955801, -3.422629613336874, -0.6076759134665455, 1.0938494638610423, 1.8103854319857642, -2.652240631888674, -1.583101096629493, 1.6227465101354215, -0.6479966985522361, -0.9673539799765641, -1.2662886617377243, 1.8639442612513653, 0.8060068682435835, 1.3198072121314153, -0.949336803351449, -2.618756248313555, -3.04317857602382},
    {1.9832824790816723, -3.0976250316402427, -3.32012387141316, -1.2117350200178516, -3.5408193552008704, -0.5696807902743879, -2.194353392866723, -0.7839442662863583, -0.1728898464768929, 0.4404035711704143, -1.6377704463293152, -1.962885047754064, -2.652081987574192, 1.17822507205043, -1.8733801114666129, 0.8809724190211394, -3.726787977063778, -1.3549836436386686, 0.8477202040463809, 1.4618771451313752, -2.9561478323756702, -1.649239918329758, 1.3181216606333541, -1.066451889476774, -1.3167945703956445, -1.4447179349669919, 1.5971151968849857, 0.6044425002331876, 0.9485633990364665, -1.3386093947307043, -2.7034710448828836, -3.491534702721103},
    {2.1544591662773467, -2.8792442635330904, -2.870291093734998, -0.5891814922749002, -3.400154237197456, -0.6210268109260718, -2.156347437598538, -0.5826823333424247, 0.39357540792267115, 1.0194164107978074, -1.5160305901060354, -1.6401282454206476, -2.5720847419218713, 1.5532453455459412, -1.9364820955046367, 1.2773923336266313, -3.836332203460342, -0.4051856488349947, 1.2676891773888177, 1.7608121346942878, -2.8318066244916693, -1.9552046100029359, 1.3877972369150091, -0.30578847910232604, -1.6525543790319397, -0.912905571308984, 1.5680384821149682, 0.4731155515532828, 1.2076449573784207, -0.9393906611944661, -3.1376032407082133, -3.5837840275163653},
    {2.8872992359728302, -2.3825533517872537, -2.663708622414161, 0.21413967527710026, -2.7996736728457514, 0.18876039364028147, -1.48055919772454, -0.43250014174513174, 0.7813007940229846, 1.2162016785260377, -0.4083585418056525, -0.8189250823730435, -1.671950424744315, 2.1491921793555586, -1.4575589362514905, 1.8657619006961355, -3.5751940433037297, -0.3603639325852207, 1.9905031875576178, 2.237240570101933, -2.410498995303861, -0.9068861471447259, 2.515220646099277, 0.04925729208924762, -0.43831991996286174, -0.45407987856028825, 2.254276565964349, 1.4393499707754385, 1.682932239270815, -0.20566599073758354, -1.8350790425272394, -3.124756370814391},
    {1.6662033824199505, -1.5172177761046282, -2.054021771053897, 1.2027832988822365, 0.7115170277330316, -1.3647940750846501, 1.4858828932065806, -2.1942404615644233, 0.8296303446066213, -0.6837301897496342, 2.1108853418738756, 1.3820356630809392, 1.2584787367693222, 1.4647417505930453, 1.6873466405789037, -2.581482033513752, -1.1079194811945485, -0.12283858189799071, 0.9028595495619202, 1.7799858588631292, -1.9503139277133326, 2.094964693451742, 1.154574309029139, -0.6554708491581445, 1.2866199028406493, 1.134711076656272, 1.740772639095588, -2.239384459014305, -2.248545620492138, 1.5365238477838552, 0.071287119307928, -1.9772292309888595},
    {2.4178052903784404, -1.1613150339392404, -1.7853535099026705, 1.7070857415860399, 1.1214071930125753, -0.26996732512337496, 2.0287522941891125, -2.3545051112877156, 0.8696010284290542, -0.5947143947760996, 2.588520473237765, 1.567943096618791, 0.24925809943087995, 1.913477278294202, 2.179424556886016, -2.5296608402571485, -1.081445918112367, 0.14306757323079172, 2.21417064754218, 2.2568664344821046, -0.7123809818379262, 2.216854911457134, 1.7407369982757237, -0.03875728672792279, 1.744098311817321, 1.3051034591648356, 2.243168327191933, -2.0813941013814814, -1.9665990326618457, 2.1595658474784436, 1.1446916454507687, -1.8593976456738586},
    {2.6753147751797504, -1.7236042591531278, -2.173195505867771, 1.8354414709353193, 1.6291424717121796, -1.4102284290619318, 2.6570550521490293, -3.223257198260652, 1.0966453826872187, -0.4215319717342098, 3.1870834055653408, 2.160876067713167, 0.17038906508446067, 1.891023950261438, 2.5315130922616422, -2.7325071919041597, -1.7151540965691727, 0.24177080764022701, 2.07954672886947, 2.174712373370299, -1.4677698862733397, 2.8831743564610255, 1.7091859151900026, 0.14212528130496208, 2.42367513356268, 2.024766147561405, 1.780410603929503, -2.7233754046457808, -2.2801588957408514, 2.694385132133486, 1.0187018011035187, -2.4545754792623193},
    {2.2585413668361527, -1.39961339508476, -1.9601562150711402, 1.682551563877364, 1.496803746491265, -0.7935827499219613, 2.309867379267588, -3.0047689245925344, 0.9925161837689793, -1.1497681922327503, 2.737174644389659, 2.0765854136077615, -0.27152644839486995, 2.0419883558374594, 2.3642007511527767, -2.546120946191861, -1.340791424762462, -0.19645059193755798, 2.3253436624152473, 2.368667784809214, -1.2795848482173473, 3.018951618824568, 1.6814937864075057, -0.6821420846285559, 2.279805274798956, 2.200667730133934, 2.2883318663397563, -2.279971826939915, -1.949267054427849, 2.304693501063236, 1.480368654102821, -2.4283845024448083},
    {1.9699098699584465, -1.3877322932130294, -1.7372105414160546, 1.6375732295701475, 1.7848626170410713, -0.03858623910352103, 2.1382738916343746, -3.0366840389179903, 0.6008545142672368, -1.133285763761486, 2.6470704296014826, 2.1473895520848996, -0.17038389701631895, 2.0074489312572426, 2.391454358822283, -2.25862777131625, -1.1074936035470024, -0.39898937268091533, 2.3163959525735422, 1.8733292268722919, -0.9544361873030048, 2.577970761968624, 1.6349883570041586, -0.7175206427867679, 2.2268561831469995, 2.0076348686347636, 1.9922244643078801, -1.7912367695431015, -1.7328672475069151, 1.7247852506301775, 1.894771826396427, -2.010943136187413},
    {2.236312640520901, -1.690903519625469, -2.6210528409509997, 1.7631178437126092, 1.3668927595850393, -0.8718346332787998, 2.088792353386541, -3.4580117220564905, 1.1536916585407198, -1.0755339509936692, 2.259379109442135, 2.200701122125949, -0.18094852433360262, 1.9051346631611346, 2.231125093190936, -2.76793828382342, -1.3668378346179346, -0.14847122581250866, 2.159796602026615, 1.7127853520550784, -1.6878101107742183, 2.5728665129409696, 1.7270921417239578, -0.5453872822314384, 2.1816977546341243, 1.6914955730642156, 1.9251097253790455, -2.0937156876205645, -2.1391622315158068, 2.3511159494317497, 1.5652408984172135, -2.435480833543526},
    {2.183313386048459, -2.303617564653243, -2.6918353745816233, 1.6264462672188933, 1.25453105178233, -1.2492900991572153, 2.1904980838730603, -3.9271729642840376, 1.0144278575653272, -1.0220354423505968, 2.572770067969408, 2.2629377668662007, -0.10450919645647722, 1.9182347039749341, 2.1794147757730027, -3.1631192720542414, -1.7920135569796274, -0.22580995552794722, 2.291871621056459, 1.5087433177203908, -1.8951668981958294, 2.6632470639774435, 1.5098160364472895, -0.7460539940330135, 2.4209816795120105, 1.8168266302741403, 1.9789966776074635, -2.5374955893792457, -2.4468342504967366, 2.3058025964329043, 0.7345930674970335, -2.6655162506750094},
    {1.9347721864701033, -2.0479240262614806, -2.7020807431767473, 2.177233159551898, 1.6599109189222077, -1.2530004476930776, 2.326742891981616, -3.5141247366324317, 0.9150188501817177, -1.386176777632624, 3.0231075535529786, 2.5735105734521753, 0.41859804413727975, 1.8274523536638798, 2.561610818587351, -2.9304843502990807, -1.3223371140785536, -0.12118206264139465, 2.098246720140858, 1.8091834432804954, -1.8519957380218133, 2.7205490149894724, 1.8445106225313113, -0.4332832072372147, 2.53857665001952, 2.2825524227650136, 1.869393960784298, -2.1366612783006715, -2.50715166638459, 2.595499216511088, 1.1642886005646904, -2.325945192992128},
    {2.5207582377240687, -2.1687788417561116, -2.6901389898333816, 2.12177409403952, 1.6464261239403069, -1.3657033150952704, 2.2849961285287748, -3.4866934044384985, 1.3845698618932323, -1.0701869961273247, 3.1450739318621492, 2.7610600652310793, 0.2810758905776677, 2.154341847409992, 2.5369553019032245, -3.0384412693518024, -1.5432331416132499, 0.3670155975591762, 2.553514855165633, 2.0714817783704222, -2.1763766520398375, 2.681946172143162, 1.6599356086441326, -0.06470110849893734, 2.6578319162585613, 2.0792608472113514, 2.224264629376238, -2.525157431101107, -2.5289852270340263, 2.744339714663293, 1.1035476937587214, -2.354892698530227},
    {2.577919475788616, -2.337300980214611, -2.7545948935841524, 2.3719355694421496, 1.0904724696978363, -1.453163376058335, 2.3244432467854153, -3.757352357916829, 1.0595297525082634, -1.0258382852187382, 2.989593373945166, 2.787140540716388, -0.044234138822258, 2.004298964128466, 2.548709592496896, -3.197588702866802, -1.7551015753735117, -0.014206309974889881, 2.223100093057427, 2.2218869303179907, -2.2527850533407805, 2.498523212485082, 1.2821773166406008, -0.4519861580524268, 2.4769850482509126, 2.1548831008461615, 2.2045853358510272, -2.3944801378705534, -2.6791139087971083, 2.345616627394752, 1.4208549634101444, -2.88243615579403},
    {2.076750170937529, -1.4103811922102367, -2.360253687088031, 1.8351013998414387, 1.2664874396493608, -1.2670215368998705, 2.079367075950854, -3.56277685152166, 0.9409003725606082, -1.7926717420278984, 2.835400203397655, 2.2224259558031703, 0.4694870766637692, 1.8081984624014014, 2.3793479335214376, -2.9269648626881826, -1.3878687570517863, -0.5345633794207556, 1.9609380117989013, 1.827409479931545, -1.8223615491456557, 2.496119868343658, 1.5264154445347817, -0.6217955700255646, 1.7625042585991495, 2.2383096804422324, 1.9803555445175587, -2.608413262021286, -2.1386686254673775, 2.061409108864671, 1.4502045496808298, -2.4246932281461175},
    {2.2107649441971784, -2.1520681576826175, -2.7229197706158668, 2.1700721403551357, 1.4315384154289945, -1.156214563012654, 2.547847072505931, -3.657062794927957, 1.288961138543836, -1.3673466096360234, 2.876537904056553, 2.618643608440128, 0.7761081114944285, 1.5815491288330685, 2.630318899539668, -3.152094724253151, -1.565358298788124, 0.06081586397287975, 2.5579247602691884, 2.293758628873085, -1.9609318947544951, 2.8516603598634327, 1.6727631187747476, -0.20078142039338515, 2.5692549206560495, 2.5308792372543736, 2.401186404988088, -2.7271391584134763, -2.4156637132885685, 2.400207589549809, 1.479923193886146, -2.510939713146171},
    {2.4486240739163474, -2.1692676952802676, -2.984580208675977, 2.0559184035749194, 1.5526443593047898, -2.0797263024264114, 2.786172551910592, -3.9153272400819388, 1.2533840727661543, -0.6784684105272724, 2.738940812964645, 2.724615838302428, 0.7281537756861706, 1.432735519310655, 2.7475373197154105, -3.6027115174758353, -1.7424535846924385, 0.11998414061396197, 2.4712280587408664, 2.199195862562355, -2.621133322487953, 2.7480468564854728, 1.5060675007045936, -0.3690736392708324, 2.5557758446731382, 2.568071347492814, 1.9402098879899843, -2.8032424482340925, -2.7754134239609867, 2.6575842110347216, 1.0229437867821465, -2.648102310068411},
    {2.3109117871862637, -1.3992228919646768, -2.1817401140045662, 2.3196038190104913, 1.388063599563055, -1.5600695432036198, 2.7252856369503298, -3.2532880854653374, 1.3616050592152165, -0.6994788805455253, 3.0032488256341785, 2.742053529846406, 1.130751389229341, 1.7304428212899534, 2.8513091496284937, -2.902735176532481, -1.314551640531076, 0.48048153959188256, 2.757765980631127, 2.452585491934505, -1.73047507807034, 3.0209435273065606, 1.5624980407188873, -0.11276307561553008, 2.5593813308860156, 2.4689451434975878, 2.3324751482547614, -2.53998743545776, -2.807791531606957, 3.0300275534213243, 0.9741753598130061, -2.2204464993323128},
    {1.9233733266245694, -2.179265240345987, -2.775284777580292, 2.38033852063461, 1.2391827787642602, -1.771992155187978, 2.730567532570238, -3.3801439276125578, 1.2639536053062363, -0.9640597118178069, 2.9211036892969924, 2.5842598217673696, 1.4675199599009094, 1.2683387721438357, 2.641479882877811, -3.041056409205906, -2.0224081126439812, 0.4739454037998636, 2.1846971071091397, 1.8611271052789977, -2.418631241131898, 2.608624803745977, 1.08123787157236, -0.3491104127569561, 2.4394559297622584, 2.355261922145137, 1.9011693817274162, -2.794670942553705, -2.957555781133761, 2.8992313557443286, 0.7788954351484374, -2.724714644503876},
    {2.1949136391639863, -2.408267723162366, -3.3016454169054144, 2.436532714451776, 1.48194324504709, -2.04526172538645, 2.408580708758022, -3.6772515548923175, 1.2810725275449655, -0.9235950476135961, 2.922760629632569, 2.4985184878331768, 1.5150751271384586, 2.0577400227892437, 2.6306582783962944, -3.2708368819247124, -1.9019313312874344, 0.22077046624813182, 2.5720377831143635, 2.079719579399822, -2.7242027293558926, 2.986491238328136, 1.9894582215164784, -0.13640038073092217, 2.3654016237280757, 2.737532215797153, 2.207762778045323, -3.0067398938282834, -2.8632569938903463, 2.8138040373282585, 1.536028859949525, -2.560764442473214},
    {2.5553683554942443, -2.005905270337933, -2.68735439371386, 2.7961998774477874, 1.9743055283501436, -1.404708936242129, 2.664068901598577, -3.2599644405512627, 1.6826620002894224, -0.36426991727887065, 3.3940898605570116, 2.9903225338518666, 1.6437268878135156, 2.163681639878956, 2.765491459210472, -2.7559072451380757, -1.869547644400615, 0.6407821568753517, 2.4919668585935484, 2.426142226542407, -2.1825083182001443, 3.201582064619962, 2.2824044429917767, 0.13650752708145808, 2.6391077499204387, 2.710146462915381, 2.5272826964797925, -1.9804585494386406, -2.648732076905592, 2.6843983989119713, 1.6225936882564802, -2.30008013450663},
    {2.4922419282026635, -2.4293113785665184, -2.99127265681611, 2.821916509212371, 1.8481115284598415, -1.9933729654571968, 2.888838282323134, -3.6056795268427932, 1.3362053688209785, -0.869296105467245, 3.553216238985323, 2.961769165481855, 1.102487521033941, 2.248925195747027, 2.8448357851024886, -3.0399721066268683, -2.120444519236951, 0.45271877927781284, 2.6469679848460355, 2.470758305609735, -2.361765150249501, 3.2566910584218594, 2.040719914289034, -0.029478420713078747, 2.6402806006591066, 2.3737469265412603, 2.2047250041030066, -2.1532158120493934, -2.50251519213967, 3.048360464437012, 1.6512178890185472, -2.809672580270541},
    {2.252078867898802, -2.0511248494643155, -2.615740695848364, 1.7801713683323674, 1.3389376098518138, -2.061405285024335, 2.8009317041450625, -3.611670424834416, 1.3980199648652047, -0.8511518741123577, 3.4044041636938127, 2.6514117237775383, 0.7693637289874565, 1.5382460952351822, 2.898642034349605, -3.4089481210461816, -1.9523256145532262, 0.008251438356255917, 2.88812921345752, 2.2892637384905363, -2.0507007600911096, 2.8664527447896466, 1.1823112273497491, -0.19377594680841354, 2.629098521759013, 2.054814548575755, 2.2444528095109324, -2.7514668305068644, -3.0523311033959817, 2.8241852561647636, 0.9402132783134349, -3.1443176922645604},
    {2.6635273431968134, -1.855080493940027, -2.665013617225575, 2.222855434545656, 1.6692918143674937, -1.5464152758368708, 2.954351903110665, -3.5607883827535955, 1.6525112808326825, -0.6725409176286392, 3.417629229563889, 2.9030776833948075, 1.81198558525936, 1.8134575279513314, 2.901808208723081, -2.891789482312526, -1.7377965361426753, 0.800343717102274, 2.868408331052116, 2.49378577752656, -1.7988809480738306, 3.3714296912206265, 2.0218171846552195, 0.5740286874958974, 3.229329023314563, 2.2755162232694266, 2.6560628980834227, -2.9415229635578304, -2.440830969833784, 2.92526778864448, 1.472204917998525, -2.5171365522531306},
    {2.1730179938238345, -2.288839833803599, -2.8291174978606786, 2.473210415303127, 1.862186543038351, -1.7008153406147821, 2.806105418635358, -3.799276271944174, 1.1678328299979108, -0.9428932726954726, 3.3719969964118235, 2.842262525958104, 1.7634474534814712, 1.7486899506045324, 2.9470313577368654, -3.3075738715205767, -1.5484842164014325, 0.4095888348348045, 2.7046005573414567, 2.4448352432861182, -2.3302164901487195, 3.2812262571318485, 2.1791572908147154, 0.116481378720437, 2.9589583155785166, 2.150630244322741, 2.302204204945537, -2.8249536088007825, -2.7239293672366403, 2.8378575762278557, 1.5736666276104267, -2.5547933609895352},
    {2.469448026908264, -2.2509024669628728, -2.725020405704293, 2.4857106175004406, 1.8742927581226043, -2.099506640948031, 2.943202185190702, -3.1595018918674778, 1.7684971823353013, -0.4648210915056012, 3.7176912938988402, 3.0274126628345037, 2.0857967620406535, 1.95512691950006, 3.1818564534599147, -2.9490029278034107, -1.5149149596789322, 0.6423107696433321, 2.5611393831575637, 2.3918780790082645, -2.276565545303341, 3.3961079144909148, 2.104060762033707, -0.2854331449600915, 3.301873206893562, 2.324383608080773, 2.800516176483879, -2.611493475398154, -2.518802886082066, 3.073340032393007, 1.8654562417029434, -2.6524786498566875},
    {2.2999460217949554, -1.651493859383711, -3.202349838406706, 2.6160257702995207, 2.554351692419327, -2.4342920225994678, 3.1703450676633937, -3.1266645537742472, 1.8023172551522655, -0.26755413753751495, 3.5744498855930287, 3.3736447102094687, 1.7307689700900057, 1.494493054189401, 3.3783932135150754, -3.300600760342453, -1.9993755358583536, 0.5875802482196713, 2.765183200502558, 2.2748545807010894, -2.7453817663493134, 3.618961288562822, 1.9009503924512123, 0.2290093437693967, 3.0426635809720297, 2.428773207030284, 2.28776548891168, -2.9154966457422433, -2.9695421329721716, 3.42261424788471, 1.661934324512627, -2.722615240669302},
    {2.004261998307529, -2.4415972592952357, -3.434944165782347, 2.6966665918722597, 2.2527715104891897, -2.2789569455880616, 3.165878900238393, -3.5050766569116467, 1.5218779398521, -0.4802888285365272, 3.4806345634334734, 3.180419990495739, 1.7260230810532413, 1.9240411246888327, 3.234867968349298, -3.326561582526627, -2.1283770786070626, 0.7013961467844592, 2.396074049431106, 2.263317562087914, -2.8521012571338478, 3.517884827204135, 1.7810899712919117, 0.12906749552278435, 3.123853732630678, 2.3523608947975982, 2.265532296458502, -3.1791194406888925, -2.8334363039925945, 3.3268258177824137, 1.393670079243905, -2.827704784182593},
    {2.318736626751863, -2.7483067889600616, -3.084489982495857, 2.2083858388891593, 2.055926909122439, -2.2085871432911017, 3.0313780448377527, -3.5368898362002383, 1.5689841907888222, -0.8965896051778798, 3.690129435933569, 2.4982541313531788, 1.079507411660425, 1.6564451881391578, 3.1180112032731766, -3.152653261690961, -1.763043509410316, 0.007776008483979938, 3.0003667218381875, 2.3414411734998746, -2.520438572547409, 3.5859986714688907, 1.8087208953238683, -0.33748824412350625, 3.1519588256736326, 2.22751627994659, 2.568882374272298, -3.03403679677579, -2.777382500648063, 3.2881196334031375, 1.4261888168728314, -2.943157198218167},
    {2.277300857227105, -2.5259722061901777, -3.128025243620435, 2.36083806763764, 2.0717191747075803, -2.5275973360488955, 2.8658039831255455, -3.944787450906198, 1.4042597370749568, -0.9975590062561438, 3.451338364849066, 2.802055420365001, 1.3547258910600568, 1.6440770866747259, 3.003190941873783, -3.2240739026383247, -2.398571865607435, 0.3402222366918897, 2.60553322741037, 2.4756614158829513, -2.8166859905273953, 3.3471472204025883, 1.6869196053827908, 0.16082374780849595, 3.141908419208751, 2.2693750130430193, 2.5863435554899006, -3.110058211409928, -2.8996996132971304, 2.957006297944, 1.1252507177843893, -3.3862360279620303},
    {2.0794876116470222, -2.5745053230104387, -3.093002628421586, 2.6108638993994004, 1.739122630441351, -2.377313411952352, 3.3270869391524496, -3.62201804235139, 1.4663406827451397, -0.91007716474517, 3.7257990068997042, 3.077454471998012, 1.788014123775608, 1.673366860676999, 3.0127931208478715, -3.314567412474645, -2.0411111894030607, 0.16612555072747098, 2.317547668983402, 2.158658176586343, -2.4364035029018036, 3.4520927335484175, 1.497550626519788, -0.25023033694784286, 3.1055730945604036, 2.914714591224037, 2.203762974894841, -2.959637872781783, -2.909818707746188, 3.029456273395449, 1.5050024164019051, -2.9598704976559014},
    {2.489998960618263, -2.739990744931057, -3.2397157617750687, 2.5798715390497415, 1.441829483519218, -2.561672264026846, 2.9642110808775235, -3.5307678183714444, 1.8088386963379697, -0.6398267189197429, 3.7986525200631314, 2.8226573928219265, 1.4006581139647698, 1.6032905671305377, 3.1490562935165434, -3.2280922559327836, -2.4515663909445, 0.2235234067004475, 2.9515170000704574, 2.454452000277223, -2.6455944450712714, 3.327095634773562, 1.9476355444339093, 0.05350190598106829, 2.940889688783555, 2.53910782383955, 2.3104178731205844, -2.8997313239821523, -2.797449316450346, 3.272794110318964, 1.3012526621339011, -3.303007116000224},
    {2.4963879790360215, -2.388262592821108, -2.957299415994189, 2.423867155592697, 1.962321230007212, -2.1188559642034566, 3.2631350186263606, -3.3274985380860707, 1.395524759966196, -0.9557653731299848, 3.659203240528767, 3.1796317442565574, 1.3870356982171774, 1.870312008147217, 3.465507101369824, -2.9779794004122935, -2.736049067491799, 0.06356068361158947, 2.349135672014488, 2.748060303749979, -3.0140399055671434, 3.377931772568566, 2.071250695708815, -0.004668115244557618, 3.045340787659647, 2.7321175827346007, 2.6039749607085803, -2.6104201635590427, -2.5163659471790902, 3.353358666605483, 1.3323462651414602, -3.1403843022601614},
    {2.1353218850002307, -2.7882541939332386, -3.157253540506654, 2.3163479709704804, 2.158474782941187, -2.3752020526939868, 3.0555885583187092, -3.5608007030318296, 1.5555796137175573, -0.6876012239411435, 3.842808867193797, 2.8346339419453566, 1.600066860743567, 1.7884161342202956, 3.1088508073198744, -3.311068555611366, -2.2876876308456215, 0.4707147371716888, 2.423488129867404, 2.064149119813978, -2.7668971140362513, 3.6046920561122673, 1.7845562793850498, -0.11351825226614921, 3.096279765650072, 2.544172294079959, 2.200702654505871, -2.9063411858969928, -2.932767471377113, 3.2669870191012462, 1.6592863966982778, -3.2830171312458756},
    {1.2536699685316826, -0.04704351866563615, 0.43283391056799736, 1.103131970042037, -1.3830140681075853, -1.7205724240199898, 0.1713711769309055, -0.060437968531569936, 1.736314364570394, 1.3912437080795006, -1.2464146049644274, -0.25855779196313755, -0.20827329655297785, -2.0273762550485905, 0.01366540616472195, -0.38997833934978415, -1.8632987745458873, 1.5235345598034005, -0.4125043944044819, -0.9345841281771918, -0.14596309839358035, -1.0850425207393322, -1.4420365225565313, 0.8778739934391395, 0.5979137391328901, 0.48968436778342567, -1.1025596463155192, -0.768626820020549, 0.08955918615723064, 0.009869188756861219, -1.83639442227717, -0.25530799838085383},
    {0.9102904564121976, -0.6388535701350156, -0.16528802919432803, 0.25574192735571, -1.1491944446097635, -0.9998840185992686, 0.3937498198599605, 0.6059329343037102, 1.1280407238567378, 1.1991271376342918, 0.0780874997542108, 0.25812671108190516, -0.46071007525959684, 0.1698302613398892, -0.42523982646900804, -0.30725319631766923, -1.5263899200441635, 0.5940786116069853, 0.4927740577329025, 0.8084957368185788, -0.5327593777361866, -0.5370454422935533, 0.7374769958357451, 0.47679123493470876, 0.054388962109543325, 0.705555084258985, 0.3911529141934211, 0.21179662410474737, 0.1164173968018156, 0.26094347410132807, -0.814727806779466, -0.9259469784670333},
    {1.5008651711710557, -1.299458843935725, -1.3551284950566311, -0.5688350765239633, -2.3616302329717787, -1.1517228797198418, -1.129121885305881, -0.27141734127858264, 0.7269259156172889, 1.5299243758819887, -1.6741746790506216, -1.0830251826113906, -1.5822110051778855, -0.03910978350599913, -1.5041443463564037, 0.6813036865996039, -2.2735774076338195, -0.34391936789352723, 0.4518529022889657, 0.5470465892350902, -1.2946855341641474, -1.7449033981005584, 0.12773807716417823, -0.2943570798038116, -0.7154989168903381, -0.974997303670549, 0.570318698484315, 0.3120785692098095, 0.25674480107470804, -1.3219709135962352, -2.1645327363134896, -1.6747753589206735},
    {0.39251980240237244, -0.6300098573355205, -2.0833222858339266, -0.49766450372951193, -1.5521395217998168, -1.735571956579778, -0.7500782689082489, -0.7465367972176082, 0.07914071266127402, 0.8687860022843431, -1.3724188697505229, -1.1262192436062115, -1.2183295369883398, -0.7158941820071285, -1.362303594832999, -0.6495177026311371, -2.13058170248085, -0.41032109868680455, -0.3638392526044659, -0.4766908254177986, -1.2429469562429836, -1.981824129483426, -0.7146550412403869, -0.7544035434654565, -0.531130883721686, -0.6210602020363464, -0.24759064654389518, -1.1156960640722056, -1.472913348709225, -0.7400219911998782, -2.68139919767168, -1.8307652881403842},
    {1.100688567309177, -1.5435962776568826, -2.2676426112915404, -0.9708488883465329, -1.8938698852245506, -0.39262324891159534, -1.4206121733381127, -0.2212274778614824, -0.3571763572997947, 0.055739324635274756, -0.8691995126297567, -1.615363219883023, -2.2958132141985024, 1.2159435862327819, -1.8194157505540691, 0.3553712042783902, -2.3582639321518175, -1.1778675673340706, 0.6527339925162429, 1.0965687069705086, -2.3555699505141567, -1.7120239938332384, 0.8691260352061713, -1.1138059187705667, -1.1877238256306728, -1.1886064533128429, 0.9191545604899111, 0.2137842342972643, 0.11641559391525085, -1.421504440438736, -1.6225064420842414, -2.1505557211127453},
    {0.47880652197016693, -1.6925278188840192, -2.3288743150878, -1.5130923782361232, -1.9744975660158577, -0.9780965190725077, -1.4203010961612406, -0.6403850870662051, -0.9992397740197408, -0.00562045897531615, -1.1754639931430952, -1.2551005796161498, -2.157372834030249, 0.3063208254950141, -1.4170237412895175, -0.05287104494380632, -1.6724352597912928, -1.397019591297585, -0.1257077932341704, 0.5580188097463431, -2.484271472990915, -1.3841602175451089, 0.3306713332795897, -1.359568445871426, -1.210870715107614, -1.486710143840057, 0.6412460418138415, -0.438281359640189, -0.2526990661669378, -1.3616608679669617, -1.416493516666193, -2.0446947567639535},
    {0.5034866355239991, -1.4454731186246204, -1.8975158235498486, -1.4371329489289026, -1.4641467292212538, -0.3347733170801931, -1.6435224993038207, -0.7530903800407146, -1.4196370094607371, -0.3428150134470255, -1.447860998664433, -1.9123392776935086, -1.8313038714925618, 0.2992335065716437, -1.6249298746260872, -0.2488339434981907, -1.7301563468385492, -1.553135959729611, -0.6033158438702899, 0.12887200065764912, -1.7040381124980961, -1.518983455061313, 0.10691984119133739, -1.4309305321442638, -1.78760987160173, -1.411427209775731, 0.1549920139946051, -0.561698025884782, 0.24285320636962499, -1.4184526451872297, -1.2213202347342602, -1.7660456741692045},
    {0.38338517002536004, -1.9692670856681838, -1.9651318311094856, -1.2905559441355448, -1.2921385847255933, -0.37102706533261776, -1.1893250081187394, -0.9076776913373469, -1.0534199641687696, 0.08253576935798436, -0.9716216461268377, -0.9651357032359669, -0.9387216768868023, -0.3092753936401617, -1.1066962974636239, -0.15544299566599273, -1.8326076397157207, -1.5333852689054288, -0.14909382014153016, 0.12158898640571326, -2.0394627050313177, -1.169117915169491, -0.27902695883235856, -1.9163980439571457, -1.0209066483909535, -1.3674062292662708, 0.2494833645789558, -0.7383722781317102, -0.4910208307470346, -0.9066080935598086, -1.5078842570113908, -2.226256236732605},
    {0.4590619636309124, -2.0968104286719993, -2.4830035306098934, -1.7097836890986742, -1.848922428472725, -0.8233804413660675, -1.8920782249895298, -1.3530627716008707, -1.5291333576620283, -0.007020652809727567, -1.7618402714048556, -1.9995469935491315, -2.1211823270721273, 0.2050368093919352, -1.7217699627685596, 0.00662921107526283, -1.8256636224776785, -2.2998112319586483, -0.6046626220376748, 0.36038430223364704, -1.9619891739820254, -1.7036669297735456, 0.031010149731009923, -2.2079215187712413, -1.5643828309089338, -2.0616658876165084, 0.31446639655952985, -0.5199004352910473, -0.7806990155858403, -1.7897795021864087, -1.3799359631971708, -2.029090091668559},
    {1.4047914067061347, -2.2511076287979197, -1.2705193633957352, -1.3211033369897347, -2.3566123418325593, 0.26267805949261575, -2.1268984913310667, -0.2024697427252451, -0.6511572977062134, 0.3733236419220159, -1.3788058083786117, -1.92377596185775, -2.105847432099659, 1.0421269442186123, -2.362112432829668, 1.224056350265214, -1.3903510653545952, -1.607336017710584, 0.7143135934527349, 1.1141573220026502, -2.014752858932064, -1.3240964822190024, 0.7490831168760149, -1.045241423298555, -1.7756428556181696, -1.6157217000056998, 0.8605536487707867, 0.5539532522876015, 0.5936527498389903, -1.8659308501141534, -1.274108403986392, -1.9831974924311655},
    {0.24902773709086548, -1.4744988485552195, -0.8468110615883886, -1.095173119555513, -1.1989470730969474, -0.7741550305597557, -1.5365071881543328, -0.34070142373218376, -0.39726174504486667, 0.0938814081245684, -1.593003260051244, -1.2404597759511427, -1.3287891611470704, -1.096072236084941, -1.3967006451483035, -0.23927695921474895, -1.982839252635799, -1.0660356957197945, -0.7572533467978224, -0.49900714242805544, -1.1888379952471169, -1.871234303377817, -0.5984525031553786, -1.1231467594749576, -1.1558699759479085, -1.0291252142035743, -0.512016326813126, -0.5509209018309594, -0.5870804782732616, -1.135504674330295, -1.7999695251757761, -1.9348505933917224},
    {1.0977786501111262, -2.178332176493095, -1.944288495142653, -1.878357814502133, -1.843831195403098, -0.8651011760971699, -1.82906672874798, -0.7870217511131411, -0.4496836461937403, 0.11840349991656901, -2.088573899131861, -1.6695251943912666, -2.1722720653492464, 0.10755846093514128, -1.5548906180914688, 0.27526643983777344, -2.366640971234139, -1.2172725634880586, 0.10001787790216755, 0.4166182134232484, -2.145231807601751, -2.0022177365986846, 0.09929812446667766, -1.5820010190756446, -1.6880230110696703, -1.7319096633085187, 0.17881294378579707, -0.7719819911703976, -0.3629251759031084, -1.4018874681631477, -1.8582600036694972, -2.373031988956302},
    {0.6331497283087338, -2.1055744501580502, -2.014850676287489, -1.340484230914158, -2.4073699987268866, -1.1522241687678625, -2.0305789840343147, -1.113655147312967, -1.0335170555264133, -0.18689451642848712, -1.9290562159389513, -1.5092376482195498, -2.1260713768823045, -0.4653656101909662, -1.501616601818615, -0.8790986838714074, -2.4341726080434176, -1.9779909137587834, -0.614632834241844, -0.11416926620423211, -2.3866213171938218, -2.0645363301580635, -0.8129710910363538, -1.9181128847643578, -1.4483697635458275, -1.9368942818916732, 0.18647629618783598, -0.8654686743763869, -0.5960090745313712, -1.8532480277949153, -2.3456556475556427, -2.396497600317315},
    {1.4271601175957715, -1.7615926640514177, -1.6293435957842604, -0.8717156896551772, -2.36260523793906, -0.5161544507830181, -1.5535104396626036, -0.6144250948952169, -0.062162608470909854, 0.36095852155914965, -1.5722810910800404, -1.4207895957131862, -1.9612460661757825, 0.5244256178337691, -1.2869230173077941, 0.18274876011243668, -2.401952126942213, -1.1301874291320602, 0.2903861754953406, 0.6818988883936326, -1.8974058727895666, -1.7676047217623956, 0.1013467247547199, -1.0495257736251042, -0.7938715228613666, -1.0543463949347922, 0.8849951069003325, -0.5142276379972297, -0.3460538023293273, -0.9938118916739987, -2.2094840538775253, -2.120449025310664},
    {1.9216279056824401, -1.3788581361682475, -0.9599858887333097, -0.528712326460038, -2.742462610147633, -0.300027960163805, -1.4533922545207503, -0.06199926055998856, 0.48041141802026194, 1.446898401157061, -1.1754509741561714, -1.2727454924255386, -2.074480135208847, 1.386524684364117, -1.456347078438419, 1.3140298617398, -2.564096205200277, -0.19946205802248365, 1.100976303256914, 1.1757781040786155, -1.3295937687006396, -1.527017421698518, 1.0023478230321459, -0.05248025419388919, -0.7836490617835024, -0.9334769757535375, 1.3845756338889903, 0.6316338535276401, 0.8097568880922801, -1.171202580550179, -2.1857764987949104, -1.4259104582214392},
    {1.7140928980919745, -2.0925392530881908, -2.071462198577244, -0.1189682525084765, -2.3596119079258195, -0.9263870038672407, -0.8915862339608375, -0.35200667532169394, 0.5357244551478023, 1.0207062246168925, -0.7857355362749148, -0.9466685067474092, -1.576492020270523, 1.0702362712136302, -0.6490387171491274, 0.3964874630625501, -2.8819104122054937, 0.08148503047169407, 0.9127760169475265, 1.2624920220122782, -2.1000058614813457, -1.0404642586398907, 0.7298348657077384, -0.21831186993309162, -0.524539173485812, -0.1265185939439134, 1.4187139575905865, -0.04631781673428428, 0.2136336760157105, -0.5820071155940514, -2.142009818366815, -2.1895423556536824},
    {1.6371937958314704, -1.8988642904050796, -2.2457029999865834, -0.47358338173082565, -1.9157693829158096, -1.5417104843768656, -1.2252003152344995, -0.5878787871280905, 0.16038885561324095, 0.7567820855201469, -1.2114124956920138, -0.6788319825230812, -1.7763224764139218, 0.391216086167855, -0.8568509491650076, 0.38099862029619874, -2.811310081890326, -0.14796140038530342, 0.0922525608729785, 0.7813050882259899, -1.606269346926539, -1.4641008299318645, 0.497530836408965, -0.38005650187154943, -0.7730113393784034, -0.91149816760659, 0.6910500651558723, -0.4843342317682713, -0.05756127231050861, -0.6857662265501812, -1.9370266345991116, -2.361186046670137},
    {2.4629275456396136, -1.9608304991540906, -2.227599344505325, 0.6215388740455529, -2.624840423930991, -0.9026162046138972, -0.7860832228198527, -0.19328963283599113, 1.1338906025154045, 1.7112240287617884, -0.47367530669635, -0.1920351537870438, -1.2050546326741345, 1.4491690846504905, -0.6154312804967261, 0.7567229244955266, -2.9870702408515313, 0.607380430416743, 1.325711760068415, 1.7125842295461597, -1.8154191028071731, -1.1676063919147466, 1.6149955720204812, 0.7415608944948875, -0.20896836861357465, -0.17926070107672573, 1.880516390119011, 0.07364495183102367, 0.36678079266804015, 0.21402927746937694, -2.3023219636085757, -2.599895494226729},
    {2.1940559162675632, -1.9170222167857502, -1.7955604820171673, -0.060603726541674105, -2.5569365699000235, -1.4702058461917726, -0.9940961050951213, -0.23397785447281028, 1.2826172083842653, 1.94348689272901, -0.9199490855809153, -0.686886307389596, -1.9613845919855935, 0.5934186528257561, -0.7951151912289649, 0.22529318883102206, -3.375546554365384, 0.1312504742860916, 0.835475505625872, 1.1543715903286687, -1.6487774968090687, -1.2769860585363302, 0.903604647356172, 0.15486229235108556, -0.24550320723049862, -0.23690118790803422, 1.0322844885884963, -0.473130347461039, 0.17299445680921896, -0.2218736642239329, -2.642373039512992, -2.7233899295874835},
    {1.6677481354006969, -1.960599636206337, -2.3150493925878606, -1.2334256996531563, -2.9019265006587194, -1.2303649411152846, -1.735616851844168, -0.9399657429983901, 0.01864672452054336, 0.8391372241093691, -1.6891515256709426, -1.3303848125112527, -2.432158104260041, 0.8499826832296073, -1.1295266801632171, -0.30256976791918544, -2.770102664172289, -1.0126581309880653, 0.043855886091121045, 1.0127920707389784, -2.2591897274586836, -1.9089115784408772, 0.4596760565518266, -1.073058579400704, -1.0364105335321243, -1.2006494997599466, 0.9758016469278465, -1.0006517356230844, 0.003362925447105339, -1.0184762447919422, -2.81901843241816, -2.3837362276462315},
    {1.995870105793799, -2.3467454937683456, -2.434753987661785, -0.5254925276139819, -3.3648710443498477, -1.584178869000101, -1.514444970534378, -0.8026504367881555, 0.7597778805883147, 1.2307567919198614, -1.5274529062889588, -1.7230222719852675, -2.365713748854414, 0.8622375843142001, -1.583775544316194, 0.4759066345786103, -3.6362116367447226, -0.13670794325224847, 0.8278395811779609, 0.962332296453725, -2.6666467829870126, -2.1279307200171167, 0.6601414681837927, -0.32791245654503864, -1.0477723293014911, -0.7342537484759125, 1.3085296816202905, -0.39065487927584847, 0.19971723124627053, -0.5681677903173575, -2.8609198728802085, -3.2744493956450365},
    {3.702343697137063, -1.3111845057845803, -2.1127083994178535, 1.7941931059110183, -3.4026654840928563, -1.4798134497299291, -0.13991670577871537, 0.7579097041313669, 2.856054589224543, 2.9188802217357996, 0.4915310363423721, 0.17567113532006862, -1.2669642649359107, 2.285927098622888, 0.18562185830783534, 1.6304439626201641, -3.9044668783200156, 2.2069001224946816, 2.569541438773828, 2.9364395206948726, -1.2443662177542254, -0.6554540448532605, 2.347998236486489, 1.8467000320703841, 0.8959609954438518, 0.8696236883663291, 2.5883807721130276, 1.0933097608623092, 1.5660499341674978, 1.3143323649867715, -2.566220881453381, -2.8789311372397544},
    {4.1502151431360605, 0.3298087985892668, -0.5846389924667267, 2.7174408010960147, -2.702565876497356, -1.642094248273943, 0.6698868970299623, 1.5816138108851558, 3.550525430207787, 3.8902833283028744, 1.0654382664103736, 1.2265046467120588, 0.12748997321328046, 2.4247901913072316, 0.8595874732946183, 1.8398393353580065, -3.764259096598628, 3.285237085594283, 2.3914327502092427, 3.2582545851711266, -0.08739690960913887, 0.24239266962701808, 2.7980290095674807, 3.1614898898017327, 2.044679438699138, 2.2670491141088536, 3.0685359523854796, 1.3109597583387023, 1.802033330624053, 2.086714937508785, -3.064967984334082, -2.377195319593555},
    {3.409328345577566, -1.1717156423301716, -1.7937129677239678, 1.6149376418442345, -3.4777890733295544, -2.418144586864171, -0.47317542802872875, 0.4546404382577377, 2.838149913573186, 3.009446044185676, -0.34613652204255524, -0.014634805201544726, -1.1974673635785835, 1.7464938781049915, -0.43062195744396803, 0.8059441868874256, -4.072387685105971, 2.6763967742800023, 1.6399388249901172, 2.287347475587946, -1.307629084911793, -1.251023788379421, 1.7173310956162018, 2.267036513265011, 1.0162847895105505, 0.8941120705467058, 2.2035079426364734, 0.009295676408867151, 0.7145263914724665, 0.9723297162654052, -3.443991676326005, -2.8186062784448707},
    {2.443665519977586, -2.512031622969753, -2.6799132366838223, 0.04433721746545559, -3.518075671992998, -1.9818043428126422, -1.5376597137899994, -0.7865647799478711, 1.6068890190094345, 1.4301180685392358, -1.6787913881817123, -1.3668146289086522, -2.377542463033578, 1.0408569078786627, -1.4573042164096621, 0.1411045611709093, -3.980175765531598, 0.40559076116930287, 0.5911848775704137, 1.3948486334103551, -2.617030060716049, -2.272164217282905, 1.0352085108237472, 0.3495987355172586, -0.9464040700469749, -0.8544540670337196, 1.1925313845820409, -0.4297405198969549, 0.01656723816427037, -0.19391397801509158, -3.611391679783389, -3.274178335044679},
    {3.4234163856379354, -0.6406322191615229, -1.4886075169875916, 1.8623322655183632, -3.226589934872943, -2.0907596195196105, 0.037311079585162714, 0.5362978435739176, 2.6776328947025463, 2.9345636631143948, 0.09191867508854071, 0.6039102587855635, -0.8858873074270451, 1.6966034652964324, 0.47827713248851045, 1.0938422129591439, -4.236688085206149, 2.0103726292214614, 1.3271090585755652, 2.4464607607890447, -0.9138054609581764, -1.0818390598377314, 1.5594206112464948, 2.2032619642296742, 1.2834569746325646, 1.18634489383199, 2.2577954260781397, 0.11317270623482634, 1.0803294911754768, 0.9813980644458871, -3.4831604360783737, -2.981079345991153},
    {3.513015663588946, -1.1402424268972569, -0.967609156988293, 1.3612649779875934, -3.651831215344142, -2.1936495176829687, -0.5788506492345203, 0.6421567224892326, 2.6597429025910206, 2.9670296949345425, -0.651838325591758, -0.4290572018554741, -1.3810912610891015, 1.5578646218706973, -0.28416291301165486, 0.9862385550150351, -3.895762616815724, 1.6365603545097749, 1.5170557117482735, 2.3270598618691256, -1.0835653549886042, -1.5094274130534693, 1.6399702888326313, 2.0433629846038674, 0.9878162014328494, 0.7968900462370715, 2.126198494164189, 0.16510591186176418, 1.455969699309358, 0.529113714726051, -3.659843631158617, -2.8526830526891396},
    {3.258466386275513, -1.456154954711187, -1.4497866464068885, 1.3318499717694263, -3.288739878418048, -2.198330080087315, -0.38234726799541674, 0.3439079267513007, 2.4698623132703434, 2.9388766003640856, -0.7583289816789153, -0.16160227101983995, -1.5069613419869279, 1.3542191888116895, -0.2568443774509033, 1.2766545327814134, -4.050525514714248, 1.9738887714868352, 1.4625313330792042, 2.2398040506738064, -1.5631681264871145, -1.253368501726178, 1.6523596752849863, 1.906290542043751, 0.7843631861934884, 0.9130211813608483, 1.9774873709955116, 0.2979412864779677, 1.1431894142954961, 0.7326646834917108, -3.53048277509222, -3.0342873514711406},
    {3.5341495566949512, -1.0118860218219954, -1.6080971771645918, 1.7988384736466156, -3.528152693819691, -2.3751812395329877, -0.3533117558010137, 0.357032134345703, 2.9875864358751176, 3.1529539852813624, -0.31349029055943334, -0.2337151106139258, -1.152152117118258, 1.5461074887859536, -0.26391706970965106, 0.7756141266725874, -4.188121199721499, 2.0475448480034553, 1.388156324158318, 2.2123340329916, -1.1054622496935669, -1.5819040062324043, 1.6086071722932271, 2.2828124679402024, 0.8383431416584762, 1.2414295330412044, 1.9625536385226006, 0.2893353445069273, 0.8231683068744885, 0.7276313223178558, -3.800924693437556, -2.8405108256489835},
    {3.707283651269462, -0.7703180543455906, -1.5849405726559145, 1.981112837050104, -3.3517891694725845, -2.3877857838032464, -0.27152975986313094, 0.6314082323200447, 3.183416091744488, 3.4893478059366383, -0.17966306164434387, 0.10354888664021268, -0.691889905195797, 2.0358539458373923, 0.18095417171926118, 1.356908465176251, -4.103785361717311, 2.4873910578336447, 2.0243486375909234, 2.8870158622679964, -1.2445305826800581, -1.1610684595340044, 1.968450764870185, 2.3417464000432053, 1.1137016700471987, 1.226548821938349, 2.3582666245845805, 0.34316913241468117, 1.254691936601684, 1.2455255652290413, -3.6310434835745857, -3.1217978118170344}
};

static const float b1[32] = {5.585753852016504, 5.635219056165762, 5.747029253395771, 5.507990282566132, 5.645668203567489, 5.650302091185745, 5.4709237146702705, 5.850796024582169, 5.503368087062833, 5.585755417398942, 5.7290514853288785, 5.574262966827097, 5.70250904785173, 5.643439880611789, 5.523031741973544, 5.825591552201512, 5.805153010349012, 5.683026416985885, 5.628319583369542, 5.68811575519158, 5.69559139175687, 5.455688121810355, 5.671849436931683, 5.541993558211832, 5.569781395472997, 5.542347330749744, 5.61935588269834, 5.843514508697353, 5.766918036326218, 5.626930716212329, 5.762865750544778, 5.850347811565493};

static const float w2[32][16] = {
    {4.767425072027352, 4.908119440486863, 0.0915974621384133, 4.4406248525908625, 4.659565047002246, 4.636412209709555, 4.424620549968903, 4.081269888625326, 4.4759273414332945, 4.894536818694892, -0.02691761019398509, 4.931114348116897, -0.14592745296883727, 4.298372590244329, 4.402117017875304, 4.62400102790991},
    {4.780917289209148, 4.911836556009122, 0.2589043003404301, 4.964367193901154, 5.02846801009971, 4.6944304683997045, 4.557298093521528, 5.122542930769621, 5.080554107221689, 5.056240695758062, 0.08159880702333992, 5.164081109797521, -0.014568492563206421, 5.107921541070413, 4.386324643402459, 5.069564486645985},
    {4.644431791398018, 5.0223443148992715, -0.25385552753870566, 5.397935060193694, 4.860389626722747, 5.43383539340261, 4.924916704332767, 4.812930586453205, 4.9499307862998805, 5.332296984021719, -0.14242197492032024, 4.822813448390409, -0.4739840826474592, 5.1224966313375315, 5.102560852905252, 5.03161421997124},
    {4.832586325655711, 4.9098615484380925, -0.21592128625659518, 4.600695889756098, 5.2001985128685, 4.553100213646247, 4.475615986829466, 4.928961240300053, 5.283357083682437, 5.203523485974843, -0.10141737362272579, 5.00695687647015, -0.3925930114378929, 5.191165868899307, 5.0709138137607725, 4.684180225029514},
    {4.501677018965371, 4.334624313243704, 0.18586387304066895, 5.110900430815519, 5.115555998601574, 4.905493768526127, 4.991029911670475, 5.439166912398183, 4.831013530489471, 5.040775153023929, 0.13047655590701523, 5.424784888640386, -0.6412671064878335, 4.638985552474072, 5.271028373402062, 5.269974579812395},
    {5.583177197474741, 5.2718990907561025, -0.006668445945254463, 5.346012218657467, 5.257817916848165, 4.808396346879046, 4.66029964761646, 5.302532224615724, 5.120368067601997, 4.948915863313257, 0.3761111364473219, 5.125188882994219, -0.18000346906710288, 5.167270103035901, 5.473406266872322, 4.98577350327073},
    {4.999261949299726, 4.256725950887208, -0.06369715454160417, 5.082824781270153, 4.670502322207775, 5.196809754442372, 4.391017819802209, 4.737175253940641, 5.000620203041206, 4.986253866591472, 0.43633635049952646, 5.12586757770975, 0.3703406266635578, 4.807014909361491, 4.810707876761284, 5.089123700495493},
    {5.09240295325539, 4.912738161355669, -0.6908541711557276, 5.01583155949587, 5.2210719869700215, 4.959192225297512, 4.700969907050398, 5.311418735066323, 5.047321432698436, 5.564627528916234, -0.15793424158586022, 4.848742383183429, -0.3042930438467712, 4.776692724464834, 5.01069373195898, 5.471169567546622},
    {4.627370016779516, 4.823081670402468, -0.2622158657481037, 4.884552139697906, 5.010004231129454, 4.936138460904665, 4.951005375808472, 4.933407727251679, 5.090415508463362, 5.054626526566716, -0.1520736152193505, 5.202229165016135, 0.29169075746409284, 4.710245697817577, 5.11307615353025, 4.913879185161188},
    {5.135708943054994, 5.05710168864325, -0.5410115925380307, 4.775188067291135, 5.077990440790924, 4.635597194450223, 4.76153077177541, 4.985688396815504, 5.2708093507222635, 5.315742727914577, -0.08792451062941566, 5.384611460873392, -0.1260855650894501, 5.099474426596471, 4.792831951338617, 5.259958850403625},
    {4.953319477402044, 4.935322293523009, -0.15843241034932565, 5.224858631706525, 4.782404871491964, 5.152992003715669, 5.0095601841759745, 4.952525567362718, 4.8111244515299, 5.011145413485666, -0.06966015054657598, 4.7987340632461555, -0.0831258349729411, 4.760336352493547, 5.280018149083948, 4.470362735806171},
    {4.789547553325692, 4.37371856754075, -0.24880963179140986, 4.554453116238666, 4.750510617323973, 5.49545883544588, 4.458824562621652, 5.141612240172292, 5.042822038524901, 5.110492091034393, -0.04446545475878846, 4.991670391731749, -0.023221563254018727, 4.45671722353944, 4.440501715529392, 4.9083064327617585},
    {4.647641522505805, 4.2425072107296655, 0.00613557345238797, 5.122880937788005, 4.833080580824328, 4.93760952847697, 4.609323393208881, 5.1650498404797, 5.1099018574980954, 5.731362259718822, 0.11742812673324157, 4.832104263481704, -0.2820909809841659, 4.734444483155002, 4.987409831675541, 5.165060697676998},
    {5.050315517672484, 4.787316327794364, -0.045096682639176364, 4.587152643508539, 4.58367066553932, 5.150541510719749, 4.4781602892331955, 4.604390779990786, 4.942228288025365, 4.78236482586665, 0.004499565884655857, 4.474743288067458, 0.2697372885705218, 4.64831687383657, 4.816888169909911, 4.13986434037064},
    {4.627629708235477, 4.963788451452893, 0.2850465794792169, 4.849417396162042, 4.73439389120748, 4.648861197700237, 4.669209618596736, 4.588546691408456, 5.127207727004465, 4.850586858618366, 0.3285764129086851, 5.420114396125589, -0.453140740529165, 4.4644814185069475, 4.713052726482051, 4.921574652798098},
    {4.710116826943491, 4.551762821470223, 0.11771056868060711, 4.754701859061475, 4.483086691578969, 4.183024821348965, 4.283811264304462, 4.330660858701466, 4.699363178470494, 4.389340628820405, -0.05122348543238706, 4.8869622552602765, -0.2975167122429424, 4.718658358762862, 4.337620138936179, 4.944476869600887},
    {4.979841230763543, 5.22198565417991, -0.21481006696667335, 5.273788272077996, 5.019088362123372, 5.646727774006634, 5.483944237619373, 5.624889677604783, 5.447904195720967, 5.096303935013023, 0.14082676118425075, 5.3952064404367555, -0.021707035707269052, 5.381382306127203, 5.153769172928713, 5.757125918219705},
    {4.445855299414272, 5.039990196852177, -0.0162680556849209, 5.299477205729644, 4.7215471446733375, 4.689301645304374, 4.708418643450666, 4.940018334083615, 4.899180122400894, 4.7076271274571315, -0.16608309180335845, 4.932336151382554, -0.20148498925970004, 5.0078093353152235, 4.994322981021668, 4.714583872829905},
    {4.8178374016707775, 4.942673678358355, 0.4318735409460138, 4.687249328349989, 5.218165425583566, 4.7740362359753625, 4.947818134534724, 4.576257153647927, 5.168664548038602, 4.8619511155525, -0.20480971837668385, 4.770620964406014, 0.009948878667129086, 4.617114173162765, 4.701325555120574, 4.779702131427775},
    {4.33220484370695, 4.774108809816681, -0.35995241179402354, 5.122369176378833, 4.565927526043299, 5.064293326744076, 4.70456739311857, 3.9444373261396284, 4.571071772917232, 4.801526663874643, 0.06524499581444615, 4.817628558860331, -0.6702131148965194, 4.580826675239729, 4.431023517599777, 4.679448089746405},
    {4.7422446831522675, 4.907651621169743, 0.147730085146425, 4.84480549682895, 4.819048958558919, 5.6036995193773, 4.426141568368111, 4.809809926307473, 4.653739056590904, 5.262266824435202, -0.48880863860804624, 5.102016548716828, 0.036580805973118136, 4.583804186984558, 5.089341988836504, 5.483956988098954},
    {5.338849855200809, 5.054335014518686, -0.49801443830283265, 5.067361255218158, 5.142951077998542, 4.8922550178785205, 4.803310934312454, 4.879668661446977, 5.172002149281951, 5.109659631327937, -0.027364333724362064, 4.69321705730064, 0.07569508736983988, 4.869612314183445, 5.311347393619928, 5.202944192767285},
    {4.968767333320412, 4.861183639364685, -0.2760091333186538, 4.905477664422857, 4.802120370786661, 4.877035687970415, 4.744193346052432, 4.3492995327100505, 4.192172322934032, 4.771507997815095, -0.0582453103475085, 4.507495352190202, 0.39747109320337487, 4.683215128980023, 4.732651057132859, 4.221314010149153},
    {4.725937484535455, 5.09485193014026, -0.12089618936687145, 4.969818165682846, 4.677220272312085, 5.290511382432585, 4.926876861208169, 4.9856229652497275, 4.636891315775929, 5.616895696427846, 0.4674411632830876, 5.355332792546885, 0.37726262826405815, 4.591860939464151, 5.186211851870717, 4.979909074327215},
    {4.228363681621748, 4.886274943261874, -0.6043772082325539, 4.978203700797529, 4.811433829896788, 4.7657677044517825, 4.75323030218603, 4.714290638785987, 4.890588960648442, 5.127326146856431, -0.41832236924029076, 4.800697503689623, 0.009829154554749876, 4.585050624597412, 4.966138437192672, 5.169873458615702},
    {4.863053638459215, 5.023546662086845, 0.15016541919557178, 4.923538503672615, 5.149115706167822, 5.158516402274327, 5.01399796153907, 5.1698415073357875, 4.796327952506241, 4.962077421569576, 0.10385654662983715, 4.795222502358015, -0.07412836789856152, 4.5708926563790415, 4.5270389251988385, 4.510446167118492},
    {4.607506162522188, 4.772661459698219, -0.1615684964035941, 4.579183863224529, 4.809191501163482, 4.844840970770984, 4.767840453181428, 4.237033610565271, 4.43475813075616, 4.343447462448789, -0.037606985853600006, 4.8495525648827655, 0.022414692303106026, 4.4074351310563475, 4.898432830315763, 4.244195175469133},
    {5.275706498663477, 4.949228824493577, -0.22061280799372107, 4.898637099108605, 4.747483465101787, 4.685200239627166, 4.517290319823408, 4.513132191919842, 5.027698730959189, 4.468490124746256, -0.2534898203129836, 4.792368794353717, -0.07196306302350897, 4.760960520427738, 4.959014738220824, 4.96040928985075},
    {5.041469571627461, 4.209073156120027, -0.40576832441833643, 5.280567046151507, 4.743427281469041, 4.62574226662907, 4.27566287926985, 4.647255856290912, 4.738500279688722, 5.033715101464931, -0.057439117522648214, 4.878640894302378, 0.40204965942327087, 4.973091483773848, 4.719090141264915, 4.732086432886625},
    {4.413886885471568, 4.899778250816505, -0.3777393378033964, 4.546672998831734, 4.7256588363043965, 4.964198028983406, 4.2575358125072, 5.23081097087051, 4.984301641274028, 4.584803489289339, -0.3977195791929569, 5.162734314234626, 0.28777290739914246, 4.910070926023441, 4.512691529089701, 4.700930729678426},
    {5.688532876317015, 5.369116356599648, -0.4979562066471494, 5.612775708251401, 4.773343740336415, 5.0664725026883515, 5.432102256077888, 4.619470870822856, 5.401363099964271, 5.511576879578442, -0.6743103618967636, 4.5585069482172695, -0.19966710425798076, 4.860418839395579, 5.408324425699585, 5.334749599908745},
    {5.295722544966128, 5.278358039635569, 0.074740770455776, 5.113919922721775, 4.94998273001915, 5.191852914366315, 5.4520029923506454, 5.474718225754795, 5.459897559012736, 5.281223261059746, -0.09850435083516203, 5.209760238860387, 0.1819052944725187, 4.996340882028918, 4.821078907097913, 4.977976203272547}
};

static const float b2[16] = {4.7653654774509855, 4.545635580627288, -0.08815873496514146, 4.59040600970917, 4.723987571740454, 4.5256533490418915, 4.779783943847639, 4.5831555277865, 4.618456902280798, 4.716240274488593, -0.07185743180970741, 4.830625813283697, -0.05659155316635438, 4.751235773680234, 4.755086655831923, 4.66633685551623};

static const float w3[16][12] = {
    {-3.906147944688818, -3.1533962147937413, -4.029276837214414, -3.716384614961856, -3.867434961528087, -3.344553141138738, -3.7730373231937984, -3.024514736903257, -3.2751857990133426, -3.3893842547425552, -3.6977767315944825, -3.1949319669707297},
    {-3.6551176587597634, -3.3885955072301153, -4.617204429585497, -3.238056612255768, -3.6837940214939673, -3.3491108207324647, -3.0415642647760186, -2.631279768599742, -3.674306088026191, -3.701148914648955, -3.678297212387597, -3.1629881831269353},
    {-0.07854090789479254, -0.33860851151079296, -0.09039943934796267, 0.32463136877147664, 0.486879750458767, -0.08880380774815683, 0.06964541933592067, 0.10022121361408605, -0.29853070091150086, -0.2935012059778092, -0.7216716588293327, 0.3687725443995049},
    {-4.06712303772157, -3.2674281426815974, -3.9693899307018037, -3.872741369231422, -3.300125176995068, -4.08652378664445, -3.852829752585885, -3.6578790439360063, -3.467644582138325, -3.8645669991007106, -3.4121604748730703, -3.242087475082309},
    {-3.5244837034476877, -3.6738037984641396, -3.23544415147943, -3.928678530442358, -3.603314415224042, -3.380177261693715, -3.8540414629655486, -4.165389282757425, -3.3059008722823027, -3.260025178547314, -3.4708091742371265, -3.2791143102807636},
    {-3.9126825870505066, -3.2829424962868767, -2.847899441397108, -3.1473326684449066, -3.877621589516724, -3.9583238155964757, -4.288378342478344, -3.539776414524291, -4.193322769509789, -3.714885346988657, -3.866415900657776, -3.864140635299082},
    {-3.2019046272205616, -3.7702581636333727, -3.7594659345525905, -3.717944993118241, -3.2018576928323124, -4.028560382083944, -3.904107442766617, -3.150755952738238, -3.4569709442079177, -3.7128335627587385, -3.873796125356478, -3.7025208243107475},
    {-3.3728349602124466, -3.68152405959132, -3.779832398821698, -3.431113205353419, -3.4627474765786497, -3.3270728627220243, -2.929734535615496, -4.286974811197744, -3.7810696916444027, -3.6047616754879512, -3.966698199288586, -4.346716502315445},
    {-3.7089156720630316, -3.204863812017893, -3.350435784238179, -3.5549302712800253, -3.8859990048769015, -3.994347730349809, -3.483377318550098, -3.4427446086095856, -3.9954558755713006, -3.796612607611256, -3.2126091366141285, -3.9735668902072074},
    {-4.038911462899313, -3.5961025744338957, -3.3723268080676685, -3.4764337670932934, -3.6422048747940488, -3.2989457730592933, -3.640424608867428, -4.162112778489929, -3.8523028373227337, -3.898561994772396, -3.1482791482822803, -3.4868110014574656},
    {-0.012254061359708914, 0.10902970518078571, 0.8125664883633811, -0.4089331875234716, 0.1773361031584587, -0.23157203875634527, -0.6234019138483798, 0.15336619221551925, -0.37031420689335554, 0.4937253800922307, 0.011227643483261272, 0.1880511055635282},
    {-3.0581398502906523, -3.631030074134925, -3.873111373730129, -3.7280772942883504, -3.101704380819588, -3.2217000650317735, -4.040178081114914, -3.853204946185133, -4.079912010623432, -3.3395981603564127, -3.3681341195027343, -3.824080478424582},
    {0.18051802590436178, 0.14019528594654812, 0.5829291382898563, -0.5443183873324821, 0.14747792844591673, 0.26306397821311733, 0.4354060909710605, 0.09307885647459302, -0.3087557569691561, 0.26960514611640435, -0.00695664241454531, -0.43911003630069134},
    {-3.099915339133773, -3.9148707544567567, -3.0580495917259523, -3.336982044991801, -4.010840155521627, -3.681567055178173, -3.5352787192528865, -3.7741935736958068, -2.94362023729362, -3.1302219947509404, -3.544436650561974, -3.4690892411576035},
    {-3.546510202235806, -4.178645450147626, -3.6636788872861064, -4.1295728344714435, -3.411898284525494, -3.606387927307789, -2.8702102335192836, -3.7774517147672895, -3.2120257653011075, -3.417283809656855, -3.6800572540537986, -3.8667380490890157},
    {-3.632598004818849, -3.9021721740210995, -3.2526927312596077, -3.5362947856046203, -3.7429973339031584, -3.4794789069509324, -3.5975472914029885, -3.315203227829944, -3.5271840657769142, -3.924559458462716, -3.9223802613786405, -3.3848063709219516}
};

static const float b3[12] = {-2.2325125443122658, -1.52898779089046, -1.0383091358301308, -1.755106474291648, -1.3319439786855334, -2.088483389185521, -1.919380245967063, -1.9042891678065919, -1.9570138327693434, -1.8746088914985621, -1.3728467437251126, -1.7431847685997899};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
