#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.03578252152701975, -0.4804885761414587, -0.5138695657581427, -0.8377380808756641, -0.8911991743605933, -0.4057865080438136, -0.22418359490310194, -0.5711926079964242, -0.7999595526559868, -0.7228670669114735, -0.5701107686893798, -0.6160190008069769, -0.039957769411504016, -0.6887011233163775, -0.085823351712412, -0.634041065349253, -0.3669469820372418, -0.8363330727541423, 0.17063900066501464, -0.5771001111890529, -0.8429860511687093, -0.8338652151646835, -0.2399407853263688, 0.09006271146063395, 0.038424492657534254, -0.28134130687497305, 0.009366044020292601, -0.34950365364772695, -0.5462593444098014, -0.7917057759987152, -0.288413601192554, -0.5918455354783695, -0.5833925574686802, -0.1846287671714612, -0.2275505800377433, -0.7234800944713472, -0.8133443897659385, -0.3552418716901839, -0.7862947722672659, -0.10161348714556237, -0.04464744808389313, -0.22839205247017638, -0.28627960143537223, -0.9031355794081657, 0.08435261516548931, -0.3991882667488667, -0.8024539774572002, -0.5777705490752867, 0.26791261494066837, -0.5482868758599121, 0.03362792972925973, -0.5369200742398297, -0.7991276755660283, -0.7871307373824544, -0.7018669546033793, -0.40357317885687255, -0.304967697632922, -0.6505970763418489, -0.3917472127742904, -0.6268249802394108, -0.6036845625496609, -0.6037978256152866, -0.8514747695283604, -0.4950993199138782},
    {-0.5254796073494554, -0.7135185099963631, 0.6605391117388241, 0.545887258005347, 0.7154158706437969, 0.044776643617113226, -0.4534182866694238, -0.35379940531287346, 0.4355635984149631, 0.6627253731179834, -0.11441251263671494, 0.4290114217312683, -0.16348145933139802, 0.19180045397930906, -0.5940680818195441, 0.21508743394161187, -0.38195057601582816, 0.7342149751639185, -0.5792634054544641, 0.5114589319501669, 0.3127231557409503, 0.06532704723031406, -0.6846128032697428, -0.5277043811662727, -0.5310793344175446, -0.3052084592750701, 0.007275985272222642, -0.34421642015276127, 0.3355366799767704, -0.14787180855616777, -0.1204774809655324, -0.023559402503872742, 0.5971808177199892, 0.17016091292777474, -0.21688846592355093, -0.3886686713038614, 0.4867393813475148, 0.48710093822965844, -0.1713379868791022, -0.1123730952644734, 0.13612740675881058, -0.734160666763545, -0.46702724877607127, 0.4749703722132275, 0.20653698404877255, 0.4233258835960399, 0.44219456102968885, 0.37938287700146583, -0.8188184131511357, 0.6981968323169016, -0.8278846242659658, 0.06091331309628553, 0.7818834007459541, 0.8032288120197526, 0.712052071525223, 0.23158528050466975, 0.15130962138703208, -0.22294767181953457, -0.4399194270633435, 0.4668477565212994, -0.31970163566630055, 0.3520563954315837, -0.15270781598789285, 0.09727387428960187},
    {-0.002477159678900611, 0.15233141024298605, 0.23140721837784006, 0.683970342288917, -0.18781868852624747, -0.36922355617710717, 0.12777881898579282, 0.7444006587176315, 0.37062501802332615, 0.715590746699172, 0.2950054541389774, -0.22897796792731193, -0.12421759441159332, 0.04162185065114353, 0.6334052883135619, 0.19997347960145664, -0.1685136459218251, -0.010264939579233748, 0.013158313491433348, 0.2106520964242169, 0.39421638826713756, -0.13348218307336987, -0.04563570985989549, -0.33907582414322557, -0.36718452242241845, 0.1995597100096664, -0.12473513647509686, 0.16496618005327485, 0.07343674798805369, 0.4285757611725369, 0.6763654639429042, 0.16122851402786395, 0.7314501753888201, 0.21339249963695844, 0.04612543976286757, 0.16480786567047, 0.2728290824426684, 0.29103083742002167, 0.20310163890794622, 0.5119810115227026, 0.06770299913976326, 0.10658857749066816, -0.2601737062688921, 0.27641590475333344, 0.09525964207345766, 0.30689576447308065, -0.040506306963361355, -0.15328969446412477, 0.2031472695693049, 0.370871190127461, -0.5928942511811993, 0.4195372940222791, 0.3016058908784638, 0.27609786422453964, 0.0444324854286315, 0.21728709309826885, 0.06214481807215388, 0.5775294335177965, -0.5410519334012056, 0.2014040291143151, -0.40317173403130796, -0.4763043145394081, -0.1960580096572794, 0.7384151523453659},
    {0.15634146666193666, 0.0009194856791584354, -0.5130622849159597, -0.4137502950499128, -0.45290655475543445, 0.29551208327592055, 0.6950330337514323, 0.7764516566667717, -0.5986674528857199, -0.45279040995133946, -0.23163788539654534, -0.7472318596471991, 0.08170599413729179, -0.2909693392766883, 0.789151435734144, -0.2361728180442944, 0.5277374248473742, -0.5200451027222294, 0.17286472551499027, -0.6687532973442535, 0.6657465476034908, 0.5652476523856443, 0.6766897988951306, 0.1049003725840169, 0.18820082557565665, 0.7818328289670882, -0.650517564651999, 0.14419946550184598, -0.42163857877735295, 0.7106754723622072, 0.7101869600187304, 0.7364768806127371, -0.11658383615427426, 0.4002487378365175, 0.4465142446411582, 0.5489708864669669, 0.11885703164126955, -0.48013654769863157, -0.3628656088585772, 0.16029935688846836, -0.5127453476413096, 0.7354313300061113, 0.10732514995732324, -0.3524743263339626, -0.26424477122141626, -0.43022142286006065, -0.5667277522119464, -0.3333197450376555, 0.6154287673001109, -0.05612405811095615, 0.3403110920227318, -0.33389508631572395, -0.5134076282601444, -0.47055036669842126, -0.653682210213457, -0.5670205173169094, -0.3618330439987452, 0.7553026095118927, 0.1349388433259973, -0.5299067413917232, -0.40934376809640705, -0.4917566816335404, 0.2120308533574267, 0.2608719214594245},
    {0.06908544555293607, 0.2805209621618421, 0.09269213021996621, 0.5224109411383673, 0.48712390198059835, -0.4496621678070978, 0.10935412053573422, 0.5648903647953141, -0.12669644897212645, 0.5018791997927532, 0.5703435818914919, -0.5330043788109603, -0.3907181174255713, -0.12249904999649544, 0.404984369397275, 0.3076478213453932, -0.13724665013125525, 0.038772653852359916, 0.16360388944064524, -0.27151918545577985, 0.18571933017918846, 0.22172743957447516, -0.292591637189964, -0.42309822594524554, -0.42862203691698225, 0.5531695405867517, -0.4198637555851559, 0.07570855497733908, -0.05894705532431132, 0.7113322442443363, -0.05374036615145684, 0.6947916117172463, 0.667526586397079, -0.0631887581346828, -0.21796436726636323, 0.6356912813646702, 0.756492875678081, 0.3430121089639006, 0.1853338767673105, 0.5494411123550051, -0.13654137864871826, 0.28240147334997456, -0.22420688130100414, 0.5021768729968523, -0.3282932383900864, -0.4334349536006997, 0.16405540129814544, -0.17560511649176785, 0.4463376714387853, 0.5222840102587263, -0.24744706512693657, 0.2183847921924571, 0.15204660802666542, 0.5956905530260305, -0.015189962167469243, -0.36347559109472394, 0.36337992203548153, 0.9147057321649863, -0.0860911262164436, 0.0212052152979683, -0.13772989017258364, -0.3075885230658686, 0.5911638719306831, 0.18118086551936802},
    {0.09786811458140579, 0.8156036938215916, -0.0023004547693687358, 0.41764607681200977, 0.928804651787773, -0.3309245756731111, 0.8127738485586153, 0.5980325955413468, 0.6795823916844437, 0.6633229821038041, 0.7077200376867244, -0.08667824767491969, -0.251973086299687, 0.6256151261462884, 0.6678790560650848, 0.8673634210255361, 0.21272962956115452, 0.5956882697453914, -0.20140059471864885, -0.001616048270669859, 0.582111948284863, 0.5017501811576434, -0.09955498797644419, 0.07188471371537009, 0.17091915393549184, 0.6428922448588914, -0.30042494965417577, 0.7734712191590768, 0.59211521992017, 0.7427389312159747, 0.6777799389013934, 0.549187572930832, 0.9001205250188988, -0.3522689132364879, -0.19911721623533896, 0.4360887705780967, 0.6042686018437409, 0.00020983638719153657, 0.6005123468085007, 0.7112009095178657, 0.2565470890632639, 0.699135069359462, 0.29571074426200816, 0.6319344340527795, -0.35366367716673597, 0.04149488360219032, 0.7945567000610204, 0.651724309355304, 0.18826239834245437, 0.443097429834357, -0.034301835196435544, 0.47217918736538816, 0.24174415659998746, 0.9386529353482119, -0.07595799830327012, -0.0621324845565845, 0.7786810997259876, 0.878037859092424, 0.4537090834717443, 0.8023376738478004, 0.480755813604871, -0.03773644577931638, 0.5998101270646736, 0.7933848857232867},
    {0.08483306733985016, 0.5936267639651137, 0.32508164647254506, 0.5775661880872068, 0.9172869696798966, 0.059304595905040905, 0.706869856005657, 0.3849312518553697, 0.5211680206295165, 0.598995039313936, 0.44091272402109033, 0.019705886114071335, -0.3888889663248296, 0.2919918819789227, 0.7064314901967113, 0.7515276443454586, 0.16908285835785022, 0.48980680313252695, -0.4570180078952925, -0.016444231506596064, 0.4059831226216497, 0.6313270011260117, 0.017099265256655925, -0.13732037489256999, 0.13143988410670143, 0.3936031707020806, -0.5562149462390381, 0.7771772025548882, 0.5119458964831459, 0.5614636118730539, 0.8000828332081349, 0.6775875114502419, 0.6863266497868995, -0.253576853311418, -0.3700539344149293, 0.6352585393239173, 0.524159790274106, 0.14327888479840362, 0.5376265308424926, 0.19444953123196393, 0.18415108481270803, 0.7438912849339488, 0.15867478762659443, 0.4879545766237886, -0.2000516810997598, -0.15948616184538852, 0.5141249865582761, 0.6400029897313838, 0.3724804441827148, 0.439635825476232, -0.26468555191580095, 0.4122066757269089, 0.22523651638197145, 0.8836573557330827, 0.1817093237384941, -0.013276667815950187, 0.6623986618049214, 0.9862704800828967, 0.6899505107543387, 0.6496752170046768, 0.29198690114480447, -0.045772111127823284, 0.3347939127609753, 0.710694018394596},
    {-0.01856892005760449, -0.5556524788229048, 0.2122067165011119, 0.18098301078589554, 0.40529415073731234, -0.6824471395772552, -0.23554852952785477, 0.28958562015124356, 0.34552568666163347, 0.6306983273665511, -0.43749125188480786, -0.47689528852403407, -0.5750830014558352, -0.027223301944818295, -0.4369082465797277, -0.1911314575733048, -0.7236192127148442, -0.13955580346064672, 0.005685805776167378, -0.3428554329203476, 0.3253807629211687, 0.01066635017005487, -0.7697300251234526, -0.7269627323564166, -0.6363461573049405, -0.3230637049788434, -0.4666917006575244, 0.057498986470863725, 0.11787503134329473, 0.5028231280438811, -0.5272249854085416, -0.05401427483128035, 0.18834455530885777, 0.267607260183911, 0.14588528020433553, -0.04207425044331379, 0.36019569514851085, 0.2339468019098451, -0.23602642291083611, 0.015136299491584527, -0.4904014682443392, -0.24358267491011876, -0.4419846229582553, 0.5706783928473772, -0.1123561361452117, -0.6742864395729379, -0.037483119442530306, -0.3027234877840492, -0.2074306288798789, 0.49652162515564124, -0.7170034020104091, -0.2682570768897987, 0.35968611931767774, 0.5562145853608635, -0.39447794110470064, -0.4367953949965278, -0.29025414151970186, 0.18540715189764906, -0.5244082430379589, -0.19360659774301878, -0.6448848106120849, -0.3638051611771607, -0.033637815193600165, -0.17040567559590583},
    {-0.43501006898909494, -0.5766352559715321, 0.5108785853349925, 0.05075271568447931, -0.059376308312569, -0.13644610375844182, -0.6597193532417678, -0.28571701449052656, -0.3863883904060337, 0.4747115270308955, -0.6281553509007137, 0.11952748399480195, -0.3766824182107168, -0.3511527200389774, -0.60746166451153, -0.24388199845149924, -0.6180318589823061, -0.1951297651476225, -0.1391394751655631, 0.34754428764649187, 0.01202506800497262, -0.43641845471438495, -0.3105322233940009, -0.4486346219006316, -0.652072010924112, -0.5024073533538634, -0.3143864989946374, -0.050585539148021316, -0.37601772282980056, -0.08918567723384278, -0.2645968016036236, -0.15532351731491517, 0.5409834353925376, -0.3508335321338241, 0.15559692019288934, -0.5020016523188648, -0.39933941062880085, 0.22581634460326527, -0.16124166467652779, -0.0891942956610417, -0.029212920198951567, -0.008060536522894578, -0.3639631094278587, -0.18606579168988668, -0.5126925603852363, -0.3368361043588334, 0.026529665294799394, -0.429145230196637, -0.5939583760928204, 0.004802565466045626, -0.6454894653722977, -0.04263805926748185, 0.21052403830974423, 0.2170427403488434, -0.01675873674848125, -0.5838161462384516, -0.22702924128269736, 0.029103619600508276, -0.2145228421741182, -0.08255728343520548, -0.44499594013927035, -0.0823114103122805, -0.3627823602030443, -0.162258996716385},
    {0.27646240874664074, -0.15037914695466958, 0.4063573198241856, 0.5506149324313196, 0.5457122262494782, 0.4200100354171709, -0.40043979139451885, -0.2519223943624726, 0.7701571659949811, 0.5655405563955801, 0.06208657275674532, 0.7013441327533857, 0.25209327430840056, -0.29454583758063424, -0.5368887457776221, 0.12422787476862936, -0.25827348756580487, 0.44242169875568343, 0.32461332474557364, 0.6844290641169682, 0.4402680618646919, 0.10974464942696324, -0.6906872359626498, 0.17581867775329751, -0.03717503597155203, -0.018266004577899685, 0.5441764633116225, -0.2937636675376493, 0.49904899104845385, -0.29281696137360075, -0.46750585396415006, -0.25100298045896907, 0.3761030959126479, 0.20640767170547097, 0.5370458214702133, 0.21058643643706354, 0.223704968745767, 0.3562262034372393, 0.04721673659395407, -0.13308034697006865, -0.42227900221299586, -0.37122540513569985, -0.4617443234937832, 0.6805876388480409, 0.14219689656982326, -0.32181919140254184, 0.2928892114637714, 0.27093724363896604, -0.5294928955071606, 0.4892487324638096, -0.16005627381136414, -0.40737348002062623, 0.42404889884713687, 0.3259807313373612, 0.5370393319704474, 0.4955723815866556, 0.2960312874641321, -0.531095454084907, 0.3580773062343079, 0.43434584233656914, 0.0660445127267522, 0.49646314540122166, -0.08661848892423239, -0.2183450240471132},
    {0.42497511814646427, 0.09768176189125556, -0.459615027247691, 0.20319509696586696, 0.3986687630404506, 0.2027422588895935, 0.1266558697759748, 0.31563381427022486, 0.7200181024839872, -0.04788137927616022, 0.43882936343771123, 0.3809399233539969, 0.5192242208633634, 0.19893609520266073, -0.0569635925829996, 0.6131133873990597, -0.06621093968048718, 0.02888872064995165, -0.12868050718038754, 0.28277177724590447, 0.42793566969083596, 0.44358654086788063, -0.2585040579731874, 0.3481513946237168, 0.42136745566084416, 0.19980367797817586, 0.15479923384113492, -0.16847162426878137, 0.4018004897948713, -0.04656060568791626, 0.07923420037293163, -0.27126347980878085, 0.5317963176413629, -0.22091148727771276, -0.12714826906689505, 0.36992142125072836, 0.31668021172973215, 0.0004640289105369511, 0.28431827919828495, -0.49058142136797434, -0.48902881518159524, -0.12768654030865492, 0.019022578270179787, 0.578262879767593, -0.1779867368627564, -0.11776181115398049, 0.6117295720119884, 0.02693524537449442, -0.35469605260636095, 0.45141454856644614, -0.0220836069904202, -0.3427820328289342, 0.10074342147215953, 0.5518942789824295, -0.22225419017813025, 0.22224305361491153, 0.07596051863693286, 0.19598090767905452, 0.6247508206813716, 0.15859077132763796, 0.46736797435328653, 0.2772518190660031, 0.2978368034124487, 0.1923627032942395},
    {0.08135021648691027, 0.16469694456271586, 0.5092215170567131, 0.19452163016175303, -0.4131925322104684, 0.4416994593513872, -0.47448037042073876, 0.3232567671341893, -0.25508535224880924, -0.03629677992554731, -0.2388555048252562, 0.06139367725436937, 0.32177870874124964, 0.3294508346954006, -0.09901298503362614, -0.1861053216177467, 0.1113696896520394, -0.040052640048891294, 0.18709429829218063, 0.5296865690948694, 0.473567545997447, 0.19006214222379492, 0.3659044376513438, 0.20366469987712615, 0.36392489858033444, 0.40145364675321715, 0.036244485446483746, -0.3423996770941877, -0.30617762401642096, 0.446273423964332, 0.18245035693808342, 0.451777823726619, 0.18475860716292866, 0.17789775702452068, 0.5924049941533249, -0.17662023109774266, -0.10043711306497859, 0.21318980446477365, 0.20874766615378987, 0.4691109016483695, -0.07977622587243127, -0.05142290337810652, -0.08083404026701455, -0.15500484794806418, 0.46542326182484284, 0.13451880456566606, 0.052762350111840196, -0.3946991835266333, -0.1220061233246006, 0.3102494493814861, -0.04795777048674409, 0.24547083559074315, -0.16017549091490804, -0.19320833433569815, 0.26765300962431476, -0.12527074586327264, -0.4075787527161777, -0.4771905400021097, -0.10896508810920541, 0.0690411909457102, 0.20274268478959068, -0.02002930022287774, -0.017748138780307985, 0.16935845772269373},
    {-0.5339287042621247, 0.1970236196228474, 0.3296899727150078, 0.5204603723503288, 0.8188339703181282, -0.3924298273952481, -0.2682191862825008, -0.5438498329453358, 0.8008369734508584, 0.4174953378188535, 0.33721352239842606, 0.6987091639154026, -0.3311451869833312, 0.703586716858936, -0.004053360092781335, 0.6906806101042998, -0.25593002630007755, 0.5928244335217415, -0.6715243987947044, 0.6658883424852068, -0.5884036285361005, -0.15275412358746265, -0.3266863123549618, -0.35556828300611704, -0.5259439979662429, -0.3413734178318785, 0.5212444003210357, 0.4499672068349839, 0.5794339505810271, -0.5505963021597552, -0.30399311169331783, -0.29243731751233243, 0.3643632742359566, -0.6361703747507531, -0.4536447461040341, -0.5756316161696232, -0.1635312127477113, 0.3415284801159268, 0.44215360955710564, -0.06427342432354699, 0.5049054661759151, -0.45914018223012865, 0.0744659952638986, 0.6025625743553435, -0.17201995578446563, 0.660992405815353, 0.7721698515968335, 0.37430131421889457, -0.6107015958837574, 0.2895841321488727, -0.5306586713446061, 0.510345475384352, 0.5669612165216177, 0.6944373295987839, 0.6922917458888987, 0.46687150959242024, 0.2244758392586651, -0.33400611161840954, -0.03871511638760957, 0.3961084089086422, 0.2378044685619941, 0.15695523968435485, -0.3791681487833442, 0.4531399758215908},
    {0.10408078593369341, 0.64834464192522, -0.33618444753300464, -0.1684943514013451, 0.1020552445572582, 0.5168729574047333, 0.73732397849385, 0.7978280929047387, -0.5820692291452583, -0.2591410596902841, 0.3467902875791438, 0.11890857620352371, 0.4991343304901836, 0.4713352842288732, 0.4897079539969574, 0.3119500658835759, 0.7581118732175225, -0.3338429472475086, 0.23201495267980957, -0.30175430329944275, 0.7538421556369176, 0.6456308088588292, 0.7982580220356935, 0.3810657314367479, 0.8718201986712815, 0.7294682829628629, -0.718616496211698, 0.3568592068155897, 0.32526734042392424, 0.7831133245131513, 0.7681740473150053, 0.30394235570751604, 0.0667196495708915, -0.16179756568888862, 0.5433405226439749, 0.5015719331900418, 0.03191129678043232, -0.22495745346737142, 0.4104530644120057, -0.6614104995876128, -0.3913660426949724, 0.7677724750434785, 0.35110216639134795, -0.4079104140763995, -0.12997248264889164, 0.039113132057373746, 0.15870968512243527, 0.5694990519700509, 0.5407472110713686, 0.11975084642434172, 0.6421837866745729, 0.05857655902187573, -0.20498863427723388, 0.25415781393290887, 0.0619830417990592, -0.5789831622387862, 0.5571692978114222, 0.7941585874628213, 0.6038057844259919, 0.22988107664551927, 0.4935248867146135, -0.051060887228575366, 0.6279619118633505, -0.1434381784164135},
    {-0.27690281058849187, 0.7036804171177313, -0.5711904532341527, -0.8198242906344977, -0.08501368728993268, 0.4109251678261696, 0.7430953767118235, 0.40450888043111694, -0.4767996826277789, -0.6530808287092069, 0.12393107114812286, -0.3464006744445567, 0.3633291544324032, 0.2956313924640868, 0.3515284539133989, 0.3791931352383584, 0.6888504736685414, -0.6834772050134718, -0.1991442301075772, -0.7298633862891051, -0.0004982350315489089, 0.549843590965697, 0.8471963287668707, 0.25994435608548516, 0.8025558175438244, 0.5018324258662576, -0.5070332393818634, 0.816398502041229, -0.5246109262575213, 0.6326772248516693, 0.751379269828508, 0.15533228884812741, -0.41224382195326414, -0.7260005031697468, 0.1286374515822908, 0.29900761633492123, -0.5390936295739732, -0.3374370521325918, 0.78482806519041, -0.3809739129078824, 0.38451899773003784, 0.7092794032397468, 0.6409713725226697, -0.6063920100179429, -0.42435965505909423, -0.24154440713346678, -0.4244500630149167, 0.6359944532024007, 0.7836808661258249, -0.4230307517995446, 0.6530429422843018, 0.2941097045317673, -0.41586584102545054, -0.5230114679556199, -0.41961469713536265, -0.4740286816730365, 0.4713347784864983, 0.4434130360794934, 0.6130430877793788, 0.2588692694088219, 0.6028272467115147, -0.574410321994933, 0.3684518063490295, -0.42539294082554385},
    {-0.5402901926365552, 0.4001683138676835, 0.2632557731303794, -0.23210339763720425, 0.4155393353754153, 0.324121789993401, 0.1478116600923405, -0.09955558136249547, -0.13771758467673442, -0.026056138070012863, 0.4932074717345199, 0.3535612836483335, -0.14375619829248784, 0.7571848167265175, -0.18966038879970615, 0.6463615416874602, 0.542485119336545, 0.0621799859252953, -0.6312629660641834, 0.28842285293844844, -0.41645735920755417, -0.03147779325630675, 0.5968580582297612, 0.24903126019991795, 0.03309726533681264, -0.6180080413829008, -0.23944774579622558, 0.765953160967825, 0.2373699687997079, -0.23973702216488754, 0.15348225905177482, -0.5417237307618585, -0.23719344136987183, -0.8682838814398856, -0.6083193705957647, -0.6159746708578211, -0.6136659409518366, 0.10752346652986708, 0.8814794740640921, -0.6226257277468344, 0.8345817864516175, 0.20870258798776084, 0.3232952418029867, -0.5363408919685051, -0.07252955432234735, 0.5192470883894104, 0.2286676361658452, 0.5784544711784787, -0.38118891131270966, 0.12037133921583157, 0.08885381049234012, 0.23208567409807665, 0.4850101896018659, 0.3391871199570482, 0.6912881370771, -0.058743991803331105, 0.33096496942832876, 0.2545872166991057, 0.010193271476014308, 0.4746586854905286, 0.5609421439277816, 0.32202271365850743, 0.12842767921935752, -0.5495581223404095},
    {0.46167161119017885, 0.6835443786729395, -0.16723492824758537, -0.647093842780349, 0.5695507296909209, 0.44149352726715413, 0.887299212623936, 0.6688459597408596, -0.46431961506193375, -0.34086472428233267, -0.0880757199070035, -0.07546375385639399, 0.7174096706679836, 0.4243993424707214, 0.7204892926010871, 0.07563801430519373, 0.9014136095553287, -0.062496659344884735, -0.4001267501022866, -0.08178586038390416, 0.8648100487593904, 0.6684954581704193, 0.6752330615920054, 0.40025569742849026, 0.5318319681816435, 0.5386083021340705, -0.8401932236299722, 0.6092481711065539, 0.06459992036674816, 0.8773776201978634, 0.6977794316634285, 0.7109927683732155, -0.2969806381795423, 0.19727231636964232, 0.5978518287412825, 0.8320486676550235, -0.012923854758360841, -0.5908668119381254, 0.6115718800043325, -0.5270099372041761, 0.05508138051230689, 0.9252044923098576, 0.45512384522324056, -0.29040665469936616, 0.00697515011034094, 0.018285552578726015, 0.19619084579899168, 0.7078254141278096, 0.8324883736933972, 0.2987823777085852, 0.3803987587708931, 0.03626783581456108, -0.32487440919545335, 0.0754252866872053, -0.3892885011696445, -0.7105500932398695, 0.39240333990493015, 0.73595674409541, 0.8901010245203279, 0.26158829497352093, 0.5243164511698063, 0.2584982791775895, 0.7740604745400693, 0.07307839140784105},
    {0.32793445130357285, 0.8550326547671477, -0.1033146181497805, -0.3177960202278771, 0.3476047245035677, 0.6125911135806091, 0.6981854381324812, 0.4972949343879818, -0.13261500625409373, 0.02215737607144639, 0.5137226355783883, 0.0028252717664961264, 0.5085058025437703, 0.24319839277019098, 0.3297117590179183, 0.2841509405719356, 0.8066388994673243, 0.07696577447712565, -0.38297951211366227, -0.05565326892482495, 0.7486684608832805, 0.3496945283688913, 0.7438536259298184, 0.638464051609952, 0.3904127130634086, 0.6001593267223329, -0.4627165625248987, 0.7372652980881009, 0.29226312465124227, 0.49990922691718004, 0.4636404305880263, 0.36722414228345485, -0.019695892189394704, -0.5553521793571031, -0.08022196068670558, 0.3006751989698287, -0.013707002197220928, 0.21366561593467642, 0.6627136483148667, -0.17780967827082694, -0.052955805715222536, 0.6341465138603194, 0.6361964573606492, -0.4005984826162948, -0.06966378022878117, 0.19669835459848484, 0.3903764738221315, 0.6137621460688977, 0.21701212731980654, 0.3926384434740399, 0.5054398413766907, 0.6358980154340316, 0.033519133544684755, 0.5076718230041475, 0.01767871041838607, -0.371729469015526, 0.34042340230820645, 0.3715241972691844, 0.6331234086914841, 0.7113086880170845, 0.6716679074864055, 0.5666920001622026, 0.5752428691432911, 0.03635463683953715},
    {-0.10216171298716652, 0.2667513230584919, 0.29098486868499107, -0.5500355201886803, -0.13875345887514856, 0.22762510023596474, 0.06027630220115077, -0.07104953533633496, -0.2058896854789894, -0.16920911531363922, -0.19990926096111752, -0.061797543742067064, -0.31727446935616477, 0.37568397188943653, 0.28107371765616773, -0.11844465169553017, 0.36902107069355455, -0.10474808069080241, -0.3438457950456607, 0.24500653546457596, 0.012025678413682295, 0.4470256544435703, 0.43726889626665116, 0.11508868770304954, 0.4253801999995374, 0.4253641534795273, -0.3202650768168098, 0.18404702459394123, -0.2530879288452794, 0.3786815581398294, 0.21585307164790515, 0.47582717978847655, -0.24632020308665004, -0.07022016503089454, -0.22016537891201748, 0.1261973108781345, -0.474157080752976, -0.3515532692726888, 0.3840555426170604, -0.2593026307115026, 0.1354777089346989, 0.6590759748285265, 0.506487636605477, -0.5273117054240545, -0.27940785316128086, 0.08245626131915555, -0.2234321638866105, 0.20295743493615567, 0.49079876330926503, 0.272100197158048, 0.34007464426938705, 0.19430188945563537, 0.051444545569880866, -0.21111362293895228, 0.0027241972969614045, -0.24564871796275692, -0.2719794939162852, 0.4497650399040538, 0.1609961133193315, 0.22860070554293335, 0.2927590267541126, -0.018318612330192788, 0.09932774664182498, 0.29564805122095306},
    {-0.1123267166508651, -0.10816958473083386, -0.6374506752022556, -0.5870347046135348, -0.09976311480010128, 0.2262247847530353, 0.5793283805747352, 0.40565067568038843, -0.3518299819476848, -0.426994045379201, -0.5416482703061404, -0.3008823417379246, 0.21395999940588784, -0.0627105365549032, 0.6080249157987934, -0.14242223511559762, 0.6586640296228574, -0.5956610068812792, 0.19521179063109773, -0.5277162388056976, 0.6777022639823257, 0.033495318744939793, 0.17570937441121007, 0.017261010859834728, 0.1348995617755693, 0.5991747851971887, -0.6572473565293613, -0.2332557837685563, -0.23906325781491536, -0.10895681659414234, 0.4526207123147397, 0.033059973716967, -0.0674699125612941, 0.33665702931300134, 0.2762795054018496, 0.3622203750210456, -0.12600214392085443, -0.47404264539994845, -0.4030266744995487, -0.4359552956824718, -0.2115910612722163, 0.18327916274309075, -0.3315837329785218, 0.23572588827733762, 0.5431575452534291, 0.07178580378421733, -0.26439724798017294, -0.20099868879132232, 0.4639761133164738, -0.41348205622333245, 0.4587506126255531, -0.3160702842728924, -0.32158722483334357, -0.3558302273083544, -0.48145324872495576, -0.5278674011956086, 0.020771732928462388, -0.4086555007127487, 0.19526925957687447, -0.09328632538841602, -0.23713234869647165, -0.4875267321015723, -0.06422914254526171, -0.15000925628315726},
    {-0.043857687516874605, -0.12531358250518987, -0.2391494252443449, -0.5919022938197104, -0.5610504358491295, -0.021651484452690967, 0.3839542408886725, 0.22814059781540738, -0.7067290717554733, -0.5846945612065427, 0.10239269296690146, -0.6448653916748568, 0.4021614580458672, -0.1980444237373007, 0.639684494063546, -0.501555316861331, 0.777582472813996, -0.29775165994993, 0.429661638307327, -0.5778873020242058, 0.11871318664511625, 0.16126582225182948, 0.7661352903056621, 0.1518058724198346, 0.39897988378810484, 0.602225199930191, -0.6061835430623294, 0.22592188014881714, -0.5785423988464549, 0.26014646915686906, 0.2942401992453903, 0.6260738828524514, -0.738069749226978, 0.4064549042446106, 0.4143636529049943, 0.6170597742668967, -0.565381980292941, -0.28018866650112684, -0.39266735571314815, -0.5069367035029986, -0.1748139535391712, 0.29783221010608635, 0.6391893704961612, -0.634411428913721, 0.021230210536858755, 0.13859777709883192, -0.6664481364530519, 0.47321578864840164, 0.8235009233948261, -0.14888110269569585, 0.6776696507087377, -0.15363646584126364, -0.545475642281353, -0.6796987204216446, -0.5091459357584389, -0.4354781407001174, 0.10480162282275492, 0.5800811218041935, 0.20675451166037212, -0.512142839332288, -0.07519804817959047, -0.05188002340532638, 0.08110177134985776, -0.56575200547912},
    {0.2528454339781797, 0.40520082375214894, -0.5224359369087226, -0.45154333601064217, -0.5010495131148106, 0.1873711720948857, 0.4738940610936512, 0.35084248054625794, -0.3935267271264581, -0.48612970286544394, 0.011631627004092817, -0.4862528558676341, 0.519791532053949, -0.40025173561561456, 0.2550923963663463, -0.48214665536650275, 0.8728769540493369, -0.6301965869038422, 0.13095696196102485, -0.37646560563411696, 0.2929295687821115, 0.5309646608507987, 0.7578770331384675, 0.14139992509455537, 0.5626738955385174, 0.740240860179235, -0.81732590623558, -0.1082822698068746, -0.25577059908752764, 0.4393300789476975, 0.332971531355793, 0.4451629171623932, -0.7856364659850297, 0.3929289700003775, 0.6481217507663739, 0.5863120062847688, 0.14867225554486327, -0.38073751846239495, -0.38751184703342095, -0.501095431091463, -0.7717631082531564, 0.4078928742664624, 0.4573078318453224, -0.05383867571421719, 0.03731339819428268, -0.4280742844389838, -0.22546144163863904, 0.44102969934897995, 0.7878453714809278, -0.26759411164684643, 0.7918370622288261, -0.3706161299471931, -0.46407675705421003, -0.4640752039712219, -0.4080200751538597, -0.6936155578763153, -0.193237268447221, 0.6091118866310498, 0.7495734445412873, -0.13908811992523135, -0.04505758054990488, -0.09473427862032249, 0.8212877611397765, -0.5814303413492872},
    {0.47288251481923715, -0.06993375938204274, -0.12818259785375366, -0.24217256237713483, -0.3628366339315756, 0.27538204098693053, 0.7905720020281028, 0.41683774863015133, -0.7125536477622022, -0.6779660461996376, 0.022265723557824312, -0.3338748668725681, 0.4995631458376836, 0.3183157452120478, 0.48002154914817974, -0.2488670757230734, 0.7915100562254375, -0.4735992861727307, 0.10623581480371617, -0.09748447571161019, 0.4205448129208757, 0.5312764555675441, 0.706848328571389, 0.174519850225145, 0.707086706564987, 0.49495425062865417, -0.2673895592030362, 0.2528007477914225, -0.38643676565049145, 0.5760830754007273, 0.7444211312785276, 0.7747703663179298, -0.49377111586334216, 0.4650747796700595, 0.188453869737954, 0.3003710948476285, -0.21993251592997573, -0.4201222847341121, 0.08040745574614953, -0.6834666954861318, -0.15593673272832304, 0.4691279928555904, 0.7353981337220958, 0.10476312420785583, 0.3411521642244116, 0.502031280447243, -0.36419887085548425, 0.15834609726411444, 0.6714525031957708, 0.28011351819177216, 0.7503644697290044, -0.032486156965803245, -0.21314804305705112, -0.5299003639875931, 0.0002923487284340099, -0.29941565157105854, -0.18564496523194657, 0.17727153931840794, 0.6556289336279135, -0.11249093273737847, -0.021465352741530958, 0.006521816591620988, 0.5196628267409651, 0.05421834487472288},
    {0.28556192281407716, 0.027953073130323854, -0.5965967451344192, -0.4361759114152588, -0.26403092732719213, 0.5046056602548938, 0.19688158103980974, 0.04458964331980473, -0.44426260188563005, -0.3504793225193574, 0.1043205910239362, -0.37623202339172646, 0.5369166675859148, -0.5393426555446175, 0.0900556507189971, -0.6510876180488541, 0.33078741009944895, -0.13857289872143724, 0.7522329953223331, -0.5426833814853954, 0.3546904738320811, 0.19659696939022467, 0.5616195147560226, 0.39683655466267836, 0.19797624031246566, 0.4258993323524844, -0.26974740278839865, -0.27713496281584477, -0.39161675766447396, 0.23091447795982203, 0.20034386709789506, 0.5034929630747174, -0.6684412463063071, 0.8155766282162057, 0.6052918927003659, 0.6548839128574538, 0.5224162017498849, -0.5719011970982266, -0.8399723688308464, -0.6100627695455348, -0.690897267206205, -0.12640525888771842, -0.061431432448987494, 0.4017973934073556, 0.6655369186469947, -0.2973796310877438, -0.40253040016514896, 0.10476994151194796, 0.4959843546433766, 0.35349894506810975, 0.582359577891328, -0.08606461035747125, -0.3359349854696801, -0.45234135439597567, -0.6491379340490213, -0.36011143014673225, -0.2569837331704059, -0.16564673051695225, 0.4860291819285887, -0.5398408300848323, -0.28486586146883636, 0.20332652289598127, 0.683861545631941, 0.13990719402590435},
    {0.6850377555230106, 0.12923883220990193, -0.6761056990197909, -0.5043932510414808, -0.4250224879479158, 0.5805841339532938, 0.8219271480830657, 0.7260890800081693, -0.2532157975266696, -0.26195669400525357, -0.3327668367568952, -0.2631762280590979, 0.4791192915070405, -0.45081375747392505, 0.6162943528703059, -0.42530978215126786, 0.5086974460737456, -0.33355733423807266, 0.8272871016786139, -0.40728601210613957, 0.7451020547849333, 0.4668190788646517, 0.7771492649520966, 0.4265289645329483, 0.6324879571354239, 0.9019554993593752, -0.6074865659565548, 0.018212780673248493, -0.3720316980298316, 0.6528399962462497, 0.3510964745032288, 0.8235517796085331, -0.3045671169650578, 0.6471058351278212, 0.8585625238469774, 0.7929142943829676, 0.6139386418532327, -0.6873625342257879, -0.7464418798116582, -0.10218120585420491, -0.8374734307971058, 0.5437483451921218, 0.35051256842359363, -0.04078656437486456, 0.8220255677198826, -0.20484788471893273, -0.3788141553148362, -0.25134635748704565, 0.6127763054190607, 0.17384521359399344, 0.8064644344482652, -0.0756165715097083, -0.6009176181782375, -0.5073732733849744, -0.5709145634787307, -0.6754331563519915, 0.11318042536023104, 0.5676961034686914, 0.7993120884554887, -0.18378934410037795, -0.11306265043750689, -0.03183356016460264, 0.4852015847154131, 0.042060741368755934},
    {0.5090996479119736, -0.017267034686470385, -0.39328865744261426, -0.41317746388017523, -0.6688775540407034, 0.37749129712745283, 0.09847281283855286, 0.6320252844222078, -0.23974081885011594, -0.4897333547454856, -0.4025844745083505, -0.6462662750584787, 0.5383152670649554, -0.5503404112233924, 0.4026986610231527, -0.724575732931938, 0.0779501887732034, -0.5350682586793848, 0.8568480972087847, -0.2204599048220339, 0.4898936337501028, 0.3171965811161049, 0.2734607443377238, 0.38083458719159435, 0.5486610594228127, 0.7835583318831341, 0.016797232955257837, -0.5372734016184115, -0.3537521555832037, 0.07216058428351782, -0.09979508378943883, 0.5218537419187291, -0.5946796124215773, 0.8720966430910304, 0.7221272885495954, 0.4038299117461785, 0.263743565784998, -0.3628634698554689, -0.8663951670369414, -0.30603363262172206, -0.7667534336989261, -0.10561825230274112, 0.2852601746088567, 0.03584398411713561, 0.48808133376330837, -0.0929048388339001, -0.33624961666739633, -0.6659050821009994, 0.6052585819088196, -0.06298936353094696, 0.8034671410095997, -0.28756571736069897, -0.4858851861989743, -0.7907668306044884, -0.6624812096635992, -0.3066689113277429, -0.5283350339566409, -0.5302023458084916, 0.6744254898898109, -0.581549495462338, -0.5142100609478191, -0.16838667763830403, -0.03929613117534391, 0.05745423269536945},
    {0.4467246895195555, 0.35577618256719123, -0.7705779969178936, -0.7979197718798504, -0.57523137100237, 0.5926843330037175, 0.5244770362973878, 0.38627525327349616, -0.3483864063328485, -0.8321209488734119, -0.09090124424725397, -0.3342189161125525, 0.3784446283997242, -0.2978255283975775, -0.0488162553574305, -0.7551137553097501, 0.4051556801142807, -0.58713863693017, 0.6152686774516936, -0.6716634718483072, 0.5505154580421898, 0.5600620362834218, 0.7559252159619719, 0.47850308799950864, 0.5272735842974017, 0.6424949040149919, -0.38215157814143697, -0.6158120633652008, -0.6234287868844814, -0.04328492222103538, 0.09018490938148667, 0.5252842859521974, -0.6558459246654136, 0.622677575391078, 0.6993158867677501, 0.7737430961558871, 0.1105701657024051, -0.7744174287152155, -0.47131148506022447, -0.6258076740515554, -0.7485327730156761, 0.3148466455180278, 0.11961761510364012, -0.37057580005361246, 0.4010844364773195, -0.6204702795020718, -0.7652252944471494, -0.15177992993483083, 0.7878110850626778, -0.5688886121520044, 0.9107441871330874, -0.32015002206573145, -0.5360256382985835, -0.930413993280671, -0.5204765305226652, -0.3022743753761649, -0.62377817308594, -0.4097440876942971, 0.5333300334110442, -0.4217270980002886, -0.17103804396488542, -0.28532058334106414, 0.5334495511335616, -0.3605078176837319},
    {-0.07124408638124084, -0.20245975828493745, -0.21841295973295896, 0.13470247481101102, -0.21045000802564884, 0.11611493626142912, 0.22099049389728453, 0.3446371621404083, 0.19774044809124017, 0.056414182145325675, 0.29086737483701675, -0.07882502602388286, -0.26459699641202433, 0.12499201266407897, 0.6351409204211977, -0.03609835526874326, 0.11597442001950314, 0.21875001122103227, 0.5012030538127035, -0.2586598395298857, 0.03994000888736439, 0.4268300432197715, 0.15506964083219515, 0.2164381136805645, 0.08356844099886694, 0.42033340900901667, 0.22540422058088563, -0.3367735849810514, 0.0644779114204105, 0.11655655241958955, 0.20695584802314315, 0.553444903561543, 0.10532891402688149, 0.6649793736389596, -0.10380085319287037, 0.10199067005309594, 0.4929680764106081, -0.41181854552667513, -0.578013463601036, 0.22734323084867725, -0.13179923717654546, -0.19213946388851028, 0.3000896255676497, 0.48857233949022083, 0.3325819824493248, 0.19668854135139624, 0.08580976987847377, -0.004235199438596791, 0.7094895696189096, 0.08719230436675457, 0.3337451221078132, 0.010998800302776288, -0.017492361309205024, -0.21744485263216828, -0.10292266260474302, 0.20971900488332715, -0.0299548971299077, 0.1867048123508266, 0.4016715614534991, -0.41356800001044663, -0.6108980523554133, -0.04040654221389712, 0.17366988914223982, 0.5102582714224932},
    {0.6863172384460688, 0.43856680948517035, -0.7541571864688227, -0.6829738163102724, -0.20792951918235617, 0.535672446175012, 0.6770468834958184, 0.6320596455522931, -0.5239425773871843, -0.6198641323761277, 0.18165712061318195, -0.6723358813070724, 0.4526895554728955, -0.1491858051284831, 0.43085225164968605, -0.25124834744008245, 0.6323786674385115, -0.4821662349149487, 0.7148991112224437, -0.6219907175866441, 0.8540066385145179, 0.7518730835954187, 0.8109513848095293, 0.42309825552402125, 0.8570281211157774, 0.8723714115152064, -0.5757037167675262, -0.4551754399774675, -0.5683936998410194, 0.46599099660912385, 0.4169766474948752, 0.6903213434110668, -0.4943520137377465, 0.6658953966221615, 0.5877927654286923, 0.8794239341430243, 0.562370853520479, -0.3755398417924466, -0.4930717506961577, -0.5902627860065202, -0.8109234271813732, 0.31526438117773775, 0.32712882578150326, -0.10775342262051246, 0.35340500986310464, -0.2876232219045684, -0.3669668261739593, -0.03980499934312742, 0.5576899607312824, -0.1498730736643426, 0.7258000821284801, -0.20287825825620748, -0.41299520925097377, -0.4623765181343945, -0.7726789843229114, -0.7338732067477007, 0.15650732693091546, 0.3016263624006018, 0.9331905265774257, -0.3659551543417663, -0.21421362276917957, 0.09721155363025939, 0.8232649002474702, 0.20622842521130133},
    {0.46467957467484594, 0.4857304848412097, -0.3392447578883723, -0.4438273801254639, 0.029770947759366836, 0.3724432337808578, 0.254622031398491, 0.7630269258780064, -0.22188142980950026, -0.04478791324010323, 0.24273126492774144, 0.04060027515730054, 0.6728960230483203, 0.20242440569105896, 0.44161108297314006, -0.40146852723004595, 0.34387186130961656, 0.16407263171251757, 0.5248945457481141, -0.4073388138138632, 0.48792002778740734, 0.6827372630501809, 0.6967546340726916, 0.5587159907160265, 0.6847616922707823, 0.7139993742992861, -0.27772625946116997, -0.3135963045360146, -0.1609644939137398, 0.6834368443067536, 0.24431599853320415, 0.7782696633550231, -0.34647312747850334, 0.42280713335588194, 0.5928928304782705, 0.38272991149507096, 0.32669097100517097, -0.5687151106700988, 0.16249321557431615, -0.1975742486329546, -0.5470488183662284, 0.3383208284792049, 0.5599649198575462, -0.18599951139599938, -0.002669735406688673, -0.32468822981956735, 0.10518647311008597, 0.19131953274673297, 0.7267375208566412, -0.21995594468803475, 0.4495680280945425, -0.08160620320607437, -0.5165968615525572, -0.24629121167193324, 0.042480113718314574, -0.6664790150113693, -0.07534657221600434, 0.5866772905914994, 0.7217523147344325, 0.29804506395511937, 0.19996783475917493, -0.39174056633742543, 0.635954474431955, -0.05868599887559391},
    {0.13533583878801067, 0.2837091885849895, -0.6094584051245523, -0.6494790834752412, -0.5452417538402934, -0.3681982834598688, 0.22132129698996197, -0.3597611375216432, -0.247221334910927, -0.7338736071379959, -0.5478156132224242, -0.5207261486239307, 0.44149718296062435, -0.8449096086600069, 0.14471338242673965, -0.7962159063463998, 0.045675740497453016, -0.7950071025155251, 0.157820030934814, -1.0124533774543214, -0.6085358535360117, -0.5914947827193753, -0.19261548966475678, 0.29054605741362716, 0.26370139853435304, 0.22392550653135695, -0.1924949161556493, -0.575755877541619, -0.24298614140856215, -0.6391832905980146, -0.22323681901673634, -0.556841213990217, -0.5251876085586161, 0.4528342972252808, 0.3365239317458868, -0.6058700730605674, -0.6341223739908713, -0.9553213758039661, -0.7082550927581116, -0.5192866521573134, -0.28514499737828647, 0.09257302809164915, 0.04821838815849932, -0.7022187658963241, 0.30147746267391956, -0.7690528089956327, -0.6650609666534023, -0.4355779734793756, 0.42201298465277653, -0.8041885193881677, 0.20004321657795696, -0.5596562145441286, -0.896636746062291, -0.7749099925751409, -0.704882021205698, -0.5489436482758772, -0.252825264129263, -0.595658777344468, 0.2116138157366551, -0.9157227740475269, -0.6669077745411616, -0.23390598427546364, -0.9005940133098908, -0.515773770543055},
    {0.5236767306748193, 0.13059305732136672, -0.6339453414047233, -0.4919061471011163, -0.7711319289544605, 0.21656664794848937, 0.14463350604043038, 0.37172690118265184, -0.557386556776289, -0.25135975509102376, -0.4228204303049654, -0.8781978307137392, 0.4983696128835024, -0.8365200799850194, 0.5207668028591568, -0.7232854204782738, 0.08918827146040913, -0.8594658944909765, 0.146215198597245, -0.7827931752111107, 0.01768690228962206, -0.5072850123716871, 0.18483239394069773, 0.23715933963261085, 0.1869807803531717, 0.2740155942236465, -0.25358222581245843, -0.5164727212317048, -0.26056011481009483, 0.011940223512452173, 0.0421379968143339, -0.6540899811897322, -0.6078155213741354, 0.6042800352950648, 0.5017801681608626, -0.26146695499948586, -0.7234348878696961, -0.3859422687455662, -0.8107328669380293, -0.43531563609017804, -0.5082747847524394, -0.11705586088132781, -0.16579385108688066, -0.8147062010792898, 0.43930447064672634, -0.8499607111135143, -0.8670087214508283, -0.56372546732532, 0.5594220464723513, -0.6938539144201936, 0.13258229503003718, -0.5315609382968206, -0.8468242293845047, -0.6732170959826371, -0.8043315529255126, -0.35990157861812694, -0.5091722428883744, -0.6324211596705204, 0.08819929579988267, -0.8297087551537371, -0.6445104647731721, -0.37270643833756256, -0.6301295438929516, -0.6762262797519836},
    {0.5415335341022814, 0.2300663039194161, -0.25140301012797894, -0.39866614802510336, -0.4441205841790978, -0.5978994920549547, -0.18335399194106994, 0.2951676100354386, -0.042120932567006594, 0.18540991044967137, -0.18433009147596371, -0.009592719766830595, 0.5089280236807922, -0.7828791317496769, -0.07504998614005337, -0.36860596274937274, -0.22130796447179935, -0.7177400396897593, 0.442352064564439, -0.5237088678945588, -0.4013193062107134, -0.7262715716246866, -0.271097994371072, 0.0194508040889938, 0.09805515822647157, -0.30532719677884607, 0.24230705416375645, 0.12928910419123554, 0.10302033428651897, -0.5326638202658726, -0.073587890434463, -0.8384350589304711, 0.27416176620360727, 0.11748391990668434, 0.37608416878338996, -0.6533993398395517, -0.3547136242524039, -0.1406942764858427, -0.4775447047790818, 0.0024587609129232287, 0.22231322586695274, 0.21034498287523118, -0.2630380260224359, -0.2566850787316918, 0.2598744129377753, -0.6883812584402454, -0.6678306759711836, -0.612593122640219, 0.09831308872432865, -0.4277526539077489, -0.09994580951315778, -0.16869538981171894, -0.4171324311884918, -0.68663643266693, -0.3231252948994511, -0.21533391120816775, 0.0523676948325603, -0.4616843438350596, 0.1081202080970564, -0.7090338713366768, -0.4222516736678461, -0.0906321529213805, -0.5593196671842561, -0.05202747270417955},
    {0.2791258967481774, 0.39096197437512514, -0.2083728259929352, -0.313817970936178, -0.3785351874556611, 0.16382598527979872, -0.3671172398749005, 0.45002677286605713, 0.2520111208081081, 0.03360269988494498, -0.051549168416320616, -0.03109030961701582, 0.37338098791222424, -0.36565071109057173, 0.18083021341173164, -0.5530503008923174, -0.08370270901488953, -0.1950382020981178, 0.5324438662747154, -0.6218169863613825, -0.4912337607559184, -0.5706907747971858, -0.4870069955865145, 0.43174035993691146, 0.46000548554427473, 0.2368005561788573, 0.59315931819109, -0.38290104565652694, 0.03358150808762484, -0.32315972249457514, 0.03456516102611672, -0.38470486848825897, 0.22380923026111407, 0.03820112413138552, 0.5958097059081489, -0.5824720619495963, -0.6817886600896622, 0.05070142065750744, -0.22043452262216778, 0.3039850729085266, -0.04239773667670205, -0.1408924627683901, 0.05947498565461507, -0.3314681113009949, 0.13315011515083325, -0.7466400756589031, -0.35729754516184953, -0.6412967506746423, 0.05931191767628007, -0.5947438393530124, 0.2576663869856356, -0.233707802304038, -0.49452979063816327, -0.6453586809342879, -0.07225589905272721, 0.38059863791159243, -0.2367059578606494, -0.6568896284626394, -0.1321213121086819, -0.2413537047625124, -0.19137106193586872, -0.18888540905840004, -0.5621151530507124, 0.2747042587883403},
    {0.5817689551134713, 0.3483592957407465, -0.38082789039225196, -0.20403780491677914, 0.015497360281631838, -0.549716489184109, 0.28168337091511153, 0.44851693477831284, 0.5611088582688756, 0.11711985138243718, -0.3755465715941445, -0.1774217337334148, 0.4211614182648586, -0.13631792484327707, 0.5742787255693871, -0.12562461645293074, 0.43074717205722923, -0.6007926059161942, 0.551442913101556, -0.271108236421489, 0.1711710048641047, -0.14711028599831089, -0.0893673248317349, 0.2154282142087883, 0.6129515097242774, 0.6270555539193999, 0.2161565160477069, -0.19452895146990967, -0.28776387457289765, -0.3255112115131576, -0.24856224028873894, -0.6562900118438654, -0.3043097664214103, 0.5696463685086405, 0.5484650609227136, -0.3271233843487303, 0.2859086379930606, -0.054176914005996744, -0.41672119764387966, 0.19184630578451384, -0.13697676789918203, 0.35556422596747655, 0.4339902986092549, 0.4286085042904811, 0.44995678241304227, -0.6372367731215076, -0.6233949922173683, -0.43970097194902374, 0.33218965359102454, -0.6493391783840949, 0.25454012704882767, 0.2279301033434823, -0.5743887526286264, -0.4692662606129197, -0.5266536714114336, 0.2353329619243938, -0.0007410591175900624, -0.20731824570928134, 0.23025823178114474, -0.39693647100973745, -0.4775032286345838, 0.43268427200568244, -0.4087832012761139, -0.11118874987060032},
    {0.5267201488486164, 0.25338289003766334, -0.512557002119529, -0.1430870777246381, -0.10677925199232267, -0.272925404484247, -0.4837219103270505, -0.24099292278201884, 0.39012513889013517, 0.1697793071888274, -0.16032321598352264, -0.5992511526617557, 0.19171704156776276, -0.3696910893474382, 0.4482023889429592, -0.5102622256600332, -0.041222659479145655, -0.39388138941276385, 0.26806625102214326, -0.1957523520498765, 0.27933009865692976, -0.5171736690320102, -0.41768076737419835, 0.4117056298803263, 0.12738033324238673, 0.4381911208290657, 0.5872050983834167, 0.3106035060757051, 0.14044374387049324, -0.5540576082875522, 0.17069372715727954, -0.05703193112391104, 0.07508870519263411, 0.49912044941628825, 0.34229922193592544, -0.27142755835278454, 0.2795140430536245, -0.33505252670058466, -0.6278848858968153, 0.4082032964929066, -0.3002700735772629, 0.06210610558906312, 0.14879230992828493, -0.34952347779546955, 0.7629932587099744, -0.45021944123840096, -0.2670934074795714, -0.48140079196680785, -0.043156214978376815, 0.04344673862719914, 0.07997798442237165, -0.036344448650186, -0.5746677683482274, -0.5510074241188905, -0.5129410106929092, 0.198524997858627, 0.0761605929620517, -0.1546986121895271, 0.2696616479587927, -0.42694190252105885, -0.5263501292954617, 0.016795762331029106, -0.46063051675308264, -0.20257631219272582},
    {0.5516793563345126, 0.6343908476321881, -0.12139208969745806, 0.006572979670732393, -0.3865788785500567, 0.4319085943202936, 0.2557544956103981, -0.07104440022225679, 0.052839972948148954, -0.42259904985458074, 0.23951877367489346, -0.25706428962850664, 0.07251579274314258, 0.351002002197201, 0.46142023202978477, 0.3520527054974608, 0.11952799036481335, -0.010696390624781902, 0.4631504410207547, -0.26166890900701834, -0.5213250300075667, -0.16579288972205408, 0.014624177378164929, 0.43992417697378, 0.2695955627539242, -0.2017463207328281, 0.6070094037176027, 0.32116214155603445, 0.2604061073363765, -0.6593685539116328, 0.49179059532252783, -0.5266459778340051, 0.14878208425328004, 0.21358609380023802, 0.33833258138296946, -0.22345101717953492, -0.38201288772878633, -0.1337426570175831, 0.029490449975874855, 0.2270974745928735, 0.3006004058148249, 0.2660806124520552, 0.26531522082557113, 0.058278590520405855, 0.45118383783944144, -0.002321047226772596, -0.12653396717033333, -0.4678022580853368, 0.3595609850692773, -0.6537678295602434, 0.6078629998250423, -0.0028648306039661827, -0.5807057502627021, -0.5129918652693732, -0.33251776635404257, 0.6117574402150933, 0.22532384960734525, -0.49110057326579337, -0.11311711052279905, 0.07805931749647474, -0.49200504397710937, -0.4802862665882662, -0.520821640221778, 0.29646199404076123},
    {0.482189891386798, 0.15455410990316903, 0.05542332425448762, -0.6131510056011832, -0.6067776846415189, 0.2527425150508918, 0.07234858262892796, 0.47173183190856594, -0.3979101900745718, -0.1677116016444552, 0.2278118244220967, 0.06142862458973233, 0.586462929114408, 0.12069473094777011, 0.04874861515860902, -0.37909970059718984, 0.5556475220996453, -0.44390415162085184, 0.5440738963863572, -0.27326197077319997, 0.18502601130370105, 0.4125903775629454, -0.136269801684364, 0.4836214371383118, 0.2861413696017669, -0.21649473840626654, 0.3265956141766872, 0.34427597520986325, -0.09521868403801122, 0.4913099929844626, -0.14043296599637556, -0.09979510051492822, -0.02415951464808223, 0.05251490286416836, 0.3712524324350802, 0.3170655999451264, 0.1702099743570603, 0.0868671108455282, -0.1684771432981308, -0.2796189516213719, -0.6336238261141993, 0.4005862746213003, 0.5654898086349502, -0.44582516157606483, -0.09117097020945421, -0.6685340711679609, -0.1777864991314251, -0.0034275472362483923, 0.666034815441303, 0.006272766340554675, 0.6266827169372068, -0.19065012719680802, -0.4045159456824188, -0.6576084306345863, -0.11295149739144053, 0.22483197677810773, 0.32102013656087125, 0.12457501227657167, 0.4549497608844738, 0.11723986855014511, -0.289890408610425, 0.41325661635603705, 0.1642413136530323, 0.2931752846743811},
    {-0.09627222151580384, -0.14785992619994814, -0.12991151036078405, -0.6165984454221289, -0.14725689062870834, 0.15316994942624776, 0.40548322630568123, 0.5615451824698279, -0.25108938594937324, 0.10094809241822363, -0.4298584642754431, -0.5226436444817212, 0.492335043684722, -0.6183892881112956, 0.33107534666755123, -0.4119202161701247, 0.29109218173588863, -0.36956300329426583, 0.22481401058223388, -0.5937639847438206, 0.156487318888933, -0.12055929775095413, -0.08860893552290824, 0.22190588472298153, 0.3556757851633689, -0.17078837291986662, 0.21111938607803843, 0.23728187450290567, -0.2173652912148188, -0.15503528143798506, -0.06873918644919877, -0.43881108892166043, -0.07152912607372641, 0.2917459235920518, 0.2444688374975687, 0.10693196464864929, -0.41507981857913456, -0.46968453899967666, -0.25610800942878714, 0.08955104283640525, -0.2238127160615174, 0.47332803936763973, 0.12412360911881541, 0.03290247595111852, 0.32489728229412945, -0.17962990402090906, -0.2931849053068359, -0.5444142772946713, 0.5326217013406731, 0.003050219016483129, 0.5004472659164267, -0.3091462778412675, -0.5093155518785051, -0.5206829677360322, -0.17070351682661436, -0.13123642916710876, 0.0940300253892184, -0.1483644095923656, 0.6210866856598338, -0.16175022703442754, -0.5447613031509154, 0.19762010900445331, -0.43472708657452763, -0.016634970095196686},
    {-0.08755745127497204, 0.29950919852093744, 0.29918424977891644, 0.4710361343652455, -0.4513113143072805, 0.05774682123086414, -0.045674618989120105, 0.43893970715581687, 0.3930214702744212, -0.16974455182381623, -0.01988345415830549, 0.0678501551490102, 0.4057391726453658, -0.059795067155199, 0.10327478270105413, -0.185218643773989, -0.43382760384208924, -0.48427903933147043, 0.19141264009865722, -0.06128572935521424, -0.5157974851166227, 0.2105987406092899, -0.36205825990909013, -0.26843550107144865, -0.07309674986237433, -0.5901968142861063, 0.05330417350447539, -0.14336094680077308, 0.37977633831630997, -0.26669613012430193, 0.11514906938982766, -0.3252054842886564, 0.0685323120897398, 0.05788569602298195, 0.2061655041249542, -0.3618965006108141, -0.394064718280494, 0.18296980142550368, 0.044163906063667394, -0.001015364028847079, 0.1818612619795143, -0.28856892405540574, -0.04969431500293993, -0.2725756897695354, -0.07961955617931697, -0.2950551826892439, 0.025989561253572123, -0.03240110848633729, -0.11148552662157866, 0.3748447612048332, 0.1191182379893172, -0.5276545484354048, -0.426798676374553, -0.2615706423735281, 0.029917515260263646, 0.3275197593152862, -0.3220567939896961, -0.023492205375426217, 0.1590926337175118, -0.30329299892317707, -0.5182029849109029, 0.3087188366639282, -0.12912673441692982, -0.3988216391033261},
    {0.3615718012577656, 0.30145378131370826, 0.08360768560464464, 0.2088523528372838, -0.36110638826060787, 0.502837261055432, 0.05133317184711036, -0.1307596382742933, -0.13846249804254596, 0.49919236205517803, 0.2329339167454257, -0.17934272192014758, -0.02632742661575082, -0.0803122669667463, 0.013703162574485526, 0.4316415505797727, -0.4814840526380829, 0.08984016473813632, -0.21638405469236646, 0.44221750188953907, 0.47048828680645144, -0.03073434360937353, -0.1219286365405317, 0.44716968133746016, -0.29762463042275045, 0.019700988164590105, 0.27427194969755037, -0.3653097352325496, -0.2737329026672886, -0.2843671548217341, -0.5138835435570641, -0.06781356690681854, -0.29446632058769084, -0.10231930206621484, 0.2356249231316805, 0.14976208408644606, -0.06940655560998875, 0.43931134640614417, -0.1972710227559656, -0.12272441473310024, -0.044099409787182034, 0.19622512088490243, 0.17062677817361777, -0.26239948297765975, 0.4084797254143553, -0.30037790968802097, -0.47291489670176257, -0.4640239122640381, 0.05140313173111374, 0.051193316918109855, 0.28462965614911, 0.35636944621732347, -0.17622483803846106, -0.3705534805655913, 0.42979940231376157, 0.2744440948233265, -0.3916897163935913, -0.3998439088676993, 0.020442239361169085, -0.1396180429880573, -0.33308662433535835, 0.2524390448522645, 0.14916101787792693, -0.015520095439212277},
    {0.6195300258620016, 0.08904838829557016, -0.22184265688245253, -0.24776765741178203, 0.11672670581253737, 0.37457836794256694, -0.27660877497121006, 0.06619404914586074, 0.31269585912261005, -0.039800587142399556, 0.4141227970200473, 0.5326509844937137, -0.0678574830128525, -0.1252838898048046, 0.17812089093991706, -0.1520026577961065, -0.009859560321088045, -0.1706498352702718, -0.4672912200435971, -0.19913970384705235, -0.2683806906159975, 0.3228303003251978, 0.31903814644906814, 0.40606997898615244, -0.3958717809352358, -0.24392249751255946, 0.385727658632128, 0.08902783299539499, 0.14058132359017445, -0.15211638272241976, 0.009467001482725222, -0.24594898208925717, 0.28634155747368245, 0.06174122812921483, 0.008069918558805234, -0.35197530593754817, 0.5580885328097633, 0.5080311256904373, -0.3032086659781443, 0.4694568028073612, -0.009864923247334947, 0.02237307941625877, 0.15984410212637565, 0.26131361801884156, 0.42378035999773667, -0.03241447668360393, -0.31118308526498034, -0.1589629548603704, -0.13800681923334454, 0.10115889885952019, -0.09410715602416247, -0.16086953976108168, 0.0036264572457344922, -0.5141980749596043, 0.3123293699430122, 0.17436792286265332, 0.20601915816000874, 0.05560333445035317, 0.32570024025184374, 0.04685744063438155, -0.21103370532402255, 0.4836850279882057, -0.48139101895219816, -0.2362553238741292},
    {0.20078659226745146, -0.01643383828863643, 0.03756946840196189, -0.3900755091234274, -0.5608119668849607, 0.028169916597507935, 0.3179206822113895, 0.41214210446300387, -0.42854124505992475, -0.48874760179839055, -0.29805983034950967, -0.6291139043986592, 0.3368116740324431, -0.6545396662914014, -0.135548386304553, 0.18930098686859606, 0.1409307095449225, -0.6980184744958887, 0.16293936855155075, -0.005761310281311806, 0.1861234417428743, 0.09519973689140644, -0.03213195210298925, 0.07089304577808293, 0.2909681332428654, 0.12366677201372846, -0.12417050736872288, 0.05006544135037028, 0.16617897984135055, 0.3766192040063253, -0.266826376416975, -0.08277794658488703, 0.0181279091460566, 0.5086692324067839, 0.5460456011453579, -0.10813492429626778, 0.32961422544334695, -0.5078082524460731, 0.03957130494747712, 0.08803083637787364, -0.49980484212863097, 0.5657901142556747, 0.5454420215557432, -0.2566672576020843, 0.5516465665987985, -0.3323442297134844, -0.4721610143292281, -0.05417605287892556, 0.5173634127581752, 0.3609757462021885, 0.14582364728555341, -0.20527361319725426, -0.05715706279472054, -0.406761363095405, -0.14076731635131207, -0.741514981581968, 0.14900711649387208, -0.06241024719154461, 0.4853532584851222, -0.29746607619440174, 0.06527404894773214, 0.27416423653229904, 0.49054514853308834, -0.29200162134226754},
    {-0.12182543770821516, -0.27042243824163187, -0.10145230868839747, -0.2827403024946032, 0.18142940546013056, -0.28925308645274, -0.14760131208719876, 0.053411680620175254, 0.11298140426803559, -0.215344340494269, 0.2929984374099824, 0.16713613566803276, 0.317425817076893, 0.21434952140601804, -0.20511129623566746, -0.06303933312601569, -0.2880237870607629, -0.2635860693913717, 0.4039597344649883, -0.01462142646998156, -0.03647273749755878, 0.18432993369623876, -0.2776914514598214, 0.5175143757767554, 0.2633890541387457, 0.10618761044498712, -0.008688986774693222, -0.4469109660618509, 0.4187970422809777, -0.4509307716019733, 0.10843939699616113, -0.32842583001056963, -0.12994357083378003, -0.11077429616749526, 0.27076903970020394, -0.06512211421978033, -0.3802740764779831, -0.4606285885732789, -0.24012395248699023, -0.385242685081957, 0.2323388934265397, 0.10490674311162468, 0.007653488840002031, 0.4846799749921088, 0.09047119851152868, 0.38752461797488935, -0.47155809174490004, -0.10053753505018603, -0.40970056244812086, 0.06670890775986796, 0.22045324751937734, 0.10740969804958735, -0.3085836703567206, -0.2120845790202612, 0.1439379666874739, -0.18170060089539813, -0.22726516656294246, -0.033597776105603265, 0.27524416970015847, -0.2660145333564567, -0.36901985352772765, 0.4006936694740548, -0.469197721615986, 0.17296895010367708},
    {0.14809744781073048, -0.6354010862173817, -0.2981430910079596, 0.1619080131999425, 0.2538515908007808, -0.5766896189062729, -0.06400209274391777, 0.20378236488177462, 0.1439938401410952, 0.21849184752841164, 0.26322561553309404, 0.48153468867485344, 0.4377153828124612, -0.3040622048366885, 0.027105702743277536, 0.047063292330690204, 0.21834722197448012, 0.2943654969308906, 0.21017405331364794, -0.46084696124280516, -0.062426213110525555, -0.28517244669125125, -0.18791129840617818, 0.4889694683075292, 0.1606355456647016, 0.1411252790053052, -0.1906986676560396, -0.2093605351371346, -0.07247486040517989, 0.4823490149119412, -0.30939405932227904, 0.2866036203539167, 0.3404013350274679, 0.41448695522119156, 0.4385462342590782, 0.14805807628724146, 0.43750086284273737, -0.08351004241050254, -0.043465815263347016, -0.37513638232946267, -0.4600909911149616, -0.5830854082609491, -0.2642769887047492, 0.03890064150242328, -0.13583711930658268, -0.4207198035219301, 0.11808378845289877, -0.44802415784593963, -0.13018854312325978, -0.06466186121105728, -0.30185412606450523, 0.2692090831965819, -0.5052217002856906, 0.05805457021605979, -0.04684160286739622, -0.01593666770767086, 0.11567264104311566, 0.164285837912913, 0.25983034294466295, 0.3466287681242969, 0.25676352863872753, -0.035928763893225864, -0.11174445067398321, 0.4003919685144315},
    {0.4968745914125313, -0.6067326931096663, -0.398974511378687, -0.29816458940330903, -0.36900805575124723, 0.5143894798950491, -0.3076354898633345, 0.5926942050759362, 0.1289129328921566, -0.44917242783984895, -0.33532684006692975, -0.42367617475052205, 0.47817086172697587, -0.4657463449811768, 0.48897739210261637, -0.43498083295234347, 0.10397764538883927, -0.5643097540417178, 0.19580295776277282, -0.5809924049869049, -0.16647350595339247, 0.4130402361858328, 0.22635892773249736, 0.4193400314957623, -0.3568685114861207, -0.24903232317176863, 0.13368759848532116, 0.043667431019794874, -0.05173952926156261, -0.12601776273855675, -0.2333514015501266, 0.27097420449489024, 0.3865184424030546, 0.6918067999530363, 0.630675336283103, 0.24817273506695925, -0.0015768017851115973, -0.43956775935712616, -0.06837356087338707, -0.39216617074590987, 0.13197988186468484, -0.4875404244486185, 0.13897593575304235, 0.3528127314101114, 0.5683201953737042, -0.2038998173180383, -0.2149345115595264, -0.01846482366670535, 0.15568785345369507, 0.09152001084335301, -0.39335987002715345, -0.407194384998265, -0.03171206961869182, -0.1832637395995837, -0.30542414384391703, -0.3144489740197265, -0.06920840454381723, 0.21475502673593982, -0.030217296901668588, -0.5026896945008885, 0.03754627309374313, -0.030417561668319236, 0.1558743642723217, 0.2086310603772614},
    {-0.26495147512778106, -0.057125755795672875, -0.3238566113016345, -0.10545471971778923, -0.06144301255126248, 0.3713024071426946, -0.33376593830576473, 0.4108451813348391, 0.13696389116604424, -0.006697011508303539, 0.19975630572233102, -0.3781328850167368, 0.047938302038893765, 0.14174728979686527, -0.22187661652860352, -0.42726669073503076, 0.09169644271344206, -0.20420968128066977, -0.20058387595939006, -0.3994683887337061, 0.4956566446280448, 0.21287653291360523, -0.08870656579278202, -0.11644681877775838, -0.07486142327445976, -0.4601497814068609, 0.2857976809479316, 0.6032096335788841, 0.3877936529602445, -0.15628284939703052, -0.3612127095391682, -0.11313712257551521, 0.3691257036109158, -0.18381955235316222, 0.08735382209987058, 0.20093354798021226, 0.012391866893159086, 0.5505022043871898, -0.3446100113543562, 0.13463495569071315, -0.38126729936747406, -0.4177191912963497, -0.10339962217104752, 0.3718133211206921, 0.3048500056043246, -0.14855002047747917, 0.27737044169127384, -0.36837305968771356, 0.02371124864748021, 0.2571315500678871, 0.12584335698883897, 0.2672559558159458, 0.053484543257472844, 0.3365285948098972, -0.13086599378564323, -0.012583445832062695, -0.5497628277859882, 0.3622607043639278, -0.45248721549450127, -0.41666233922132573, 0.015955336271701412, -0.366023904159501, -0.08082422808338721, -0.2793801053596507},
    {-0.14614709462863198, -0.3002943998488436, 0.46857562760120036, 0.5413431941790215, -0.14510766537478845, 0.0017563781248112614, -0.1596801020126073, 0.08909590932814783, -0.23553548575029, 0.35087339316476907, -0.22715128284584304, 0.15663621090281762, -0.09663900721649428, 0.22586916825243744, 0.04757558044988264, 0.20744275888243435, -0.417727390293757, -0.16501965837304347, -0.1976186974055863, 0.053802865966351185, 0.1556275536228439, -0.45604151713321534, -0.5431796332707783, 0.5542816932131132, -0.5702212281547557, 0.1895386838054233, -0.08285079349283182, 0.44528182507497127, 0.33468372487161024, -0.18547069170840425, 0.21981722975665283, -0.42932682876154266, 0.1774954588076586, -0.05081889300345071, 0.18611596531717328, -0.13580022055068558, -0.3415499683229479, -0.20093532706114767, -0.2657573519949173, 0.5343917817911237, 0.40410438417331174, -0.26998110951658955, -0.46466764409920097, 0.046892905058571584, 0.4185251443737877, -0.21556946624846798, 0.04820358680320854, -0.23111456812384631, 0.2921023831893615, 0.15854758533563196, -0.4158704480654505, 0.20713776902602407, -0.4383337557509615, 0.058843321242676896, -0.300847448114303, 0.14666986811505323, 0.18018858703657298, -0.3325415936974259, -0.39532537946938606, 0.14065313538859106, -0.1291499559029937, 0.08538818784948256, -0.3024282690545832, 0.5632260964965022},
    {0.4828676588320303, -0.366442626998004, 0.20853250834732576, -0.03190506988489381, 0.008190871507508997, -0.3126324331175379, -0.13063175558144302, 0.2849879858566793, -0.06626387847573458, 0.6745573868965121, 0.18766932447163312, 0.4116585158475652, 0.2806610700917951, 0.09294122800793879, -0.2559388779984003, 0.2217506835992273, -0.07731357318288308, -0.2374596565643603, -0.07042880193572157, -0.2264285814215085, -0.1597258705841023, -0.043992471690721735, -0.38921294648701144, 0.3270143636515749, -0.504811616359336, 0.19515742142651077, 0.10023715867886614, 0.24869112869595789, 0.475074532118334, 0.22358400610184734, 0.22272951856227163, -0.49316788234374215, 0.43832681845187904, 0.30873284993618366, 0.623917631585099, 0.2359958989446044, 0.3801150721598628, 0.014335275459814391, -0.257223807327107, 0.2291767851554387, -0.2522566408630691, -0.1676672763081123, 0.104118410188009, -0.008680341855193155, 0.44922981886553304, -0.18821502181626884, 0.3456770044093085, -0.07835884931534617, -0.48145513403512685, -0.23169272810119465, -0.4025122599304627, 0.2195868540322306, 0.2324878841647095, 0.12436848356755742, 0.2867343551907056, -0.056596760073313684, 0.31755196553241577, 0.05742458076167262, -0.2871321410929439, 0.3214392343751343, -0.5646285156181268, 0.09612336617349498, 0.16847845590172913, 0.08016537179584422},
    {0.11654070240731887, -0.6598683014869021, -0.19813812818796844, -0.06656449076789078, -0.41658444018092583, -0.4377719930308234, -0.2048572913620519, 0.36162431111996174, 0.3213425095766564, 0.13713284718352706, 0.21550459821682494, -0.18893399307157238, -0.521098835160128, 0.1497732500508268, -0.5070494974939023, -0.12428069565033269, -0.7093524335333335, 0.02199864284692637, -0.045009968502163024, -0.19550041549679292, 0.21670569176076085, -0.5606305410677098, -0.4176608285424806, -0.18336593144486982, -0.397908645131863, 0.30969348520206885, 0.10600096326778678, -0.2162684706738013, 0.4726158637543917, 0.44659285387405406, 0.4895775831812841, -0.33235062664360343, 0.32275315261284937, 0.25871887159627804, 0.1072123277822575, -0.4750729319555099, 0.40511924796345494, 0.6064722927932522, 0.10629527722052676, 0.2588134306465692, -0.09664070526296821, -0.4474280889544161, 0.10767576081591633, 0.46319482156475594, 0.29991370709796455, 0.05322112805108453, 0.3076992351490499, -0.2814314569626185, -0.06247790904961592, 0.0042809806813399204, -0.13000989156371676, 0.15283696459798163, 0.28767308524641366, 0.4178559741852488, -0.12446102161353077, 0.008111927358939883, 0.005515337754455601, -0.09906983710312053, -0.32606363024708934, -0.34050635860379425, -0.4158655426410345, 0.0136687033359784, -0.5549934419664766, -0.023769881655135345},
    {-0.41148114914493406, -0.40590621925729886, 0.5021047444492693, 0.30014103781499013, -0.4948928245311199, -0.4226628602850277, -0.46124290353904174, 0.48869201280909397, 0.4257327578991157, 0.31607707053177825, 0.1974914786798543, -0.3460777946122854, -0.5243670067447924, -0.4089890088240239, 0.2589008537201007, -0.4959891918936613, -0.5778736509523946, -0.3242026052528206, -0.2639736460347906, 0.07543825451312529, 0.3048449343328329, -0.2372399019010869, -0.01981754958294952, -0.4553012806724416, -0.10376889629575221, 0.3191686616554203, 0.3977334280922618, -0.003428251895685541, 0.3355542116925205, -0.21532655328873831, 0.05751937777627415, -0.2382683205398927, 0.593638067200462, 0.020333895827650425, 0.4994473499587768, -0.39498019001141366, -0.10145777139846279, 0.45474598528235644, -0.16453009220522263, 0.6648183513672417, -0.41318877228109796, 0.07764873821746786, -0.047450337152585696, 0.2962150642685753, 0.3009420877348663, 0.46440827788187383, 0.19713013569181498, -0.390213718267632, 0.1021394519505293, 0.3505101884585606, -0.4294202710727024, 0.4111952248021765, 0.42689890134407005, 0.23230184929054398, 0.4222108664776079, 0.0317069855700926, -0.42826559082413845, -0.31358241053891045, -0.5983761673687643, 0.010795470438263509, -0.4063575545479951, 0.22725312817273793, 0.22449097595055925, 0.18883030067428228},
    {0.5420203887892294, -0.2724410777344707, -0.24252318135706977, 0.31624305544465436, 0.10533370636545844, 0.20327091377019496, -0.3887448013847099, 0.37323340436829516, 0.19534800769011035, 0.5040149437564612, 0.04357703619115308, -0.13547701994929695, -0.29071326775763495, 0.10416906424902217, 0.010448781615281736, 0.021850336887434197, -0.519696523213055, 0.3148482056673227, -0.49154243669252395, 0.324279781266974, 0.6064123466690643, -0.32993045517599806, 0.040482963299292817, 0.030480020336740243, -0.015517198279295086, 0.17630885566785906, 0.3785025602300123, -0.09621276126688964, 0.34882964926005633, -0.049488066536519514, 0.06162481118344175, -0.27607843678569227, 0.4281122712036579, 0.4717554578536052, 0.54104800529753, 0.18665860696336897, 0.32833852895618487, -0.24461073792345164, 0.28295628115432153, 0.6515583683447268, -0.2041909827446628, -0.21195123572503094, -0.11866192434335095, 0.14366912620537453, 0.5097103706500835, -0.3647060461738222, 0.5417666919269214, 0.1681049519182831, -0.1297436714325352, -0.14005086486370089, -0.02448077935067195, 0.02485844332979393, -0.2666826605335787, 0.0022088256074741315, 0.07394203834443584, -0.03566922331723615, -0.28153866733229976, -0.3710114854774769, 0.2654393849945779, -0.19007588553940824, 0.008755588615971631, 0.4145643169272587, 0.011575756751163277, 0.047170141900089384},
    {0.21802611825971427, 0.49580214293014635, 0.137138188122397, 0.22542510318468978, 0.07390681562394984, 0.34486461791922757, 0.5267525854585524, 0.40518566841489895, -0.10022437833025682, -0.11410585650219737, 0.32753264906523244, 0.10271398362374412, -0.016170246934214722, -0.44471561120190667, 0.46817515254710773, -0.04204162680524618, -0.047882742160659915, 0.42603703594756054, -0.32326298941312104, 0.337689155157002, 0.03528795343574669, -0.34966741398123385, 0.052661770287659365, 0.6517623741153047, 0.2625052865083541, 0.12109127148142719, -0.052891291834007356, 0.013113273797441007, 0.2524290271108633, -0.09471983696945054, 0.12434257026934435, -0.2892109573565552, 0.4345208959577741, -0.2724138823293003, 0.4848882283570647, -0.1375656780882981, -0.13011404285824343, -0.03634473615838947, 0.23267232572316188, 0.5195810992598162, 0.3566449716785, -0.13988652560575449, -0.554465767934959, -0.2985795702267831, 0.285375803012519, -0.03802559757181958, 0.26686551726270064, 0.06590386856324146, 0.25986187227409885, -0.4411366756240394, -0.012990606377048365, 0.3245316555358475, -0.24211603657146882, 0.1829206852403508, 0.24377291088288197, 0.07017143652933365, 0.009087317736725543, -0.22688315359506955, 0.08629622081963363, -0.2733826362303646, -0.13488276939737986, 0.34104636111664643, -0.05035953472048587, -0.33744725731555897},
    {0.20799609853185136, 0.2039632733530623, 0.020093330883941378, -0.12188742553921676, -0.3779726445352338, 0.701375030241138, -0.13979854058129806, 0.48587418139560734, -0.19317700613185854, -0.23995601118322513, -0.052307631415190695, 0.17469463963254092, 0.3665371716360998, 0.11012478343022222, 0.3356615393195988, 0.17530358855388656, 0.01750037359091678, 0.27037157502399417, 0.3610046724187915, 0.500628135612758, 0.41989821830198826, 0.07311853785085921, 0.5257744166519622, 0.17915474047039398, 0.1637626033932715, -0.3512652556639947, 0.33605123044533003, -0.008093395960192954, -0.39931751581948016, 0.023323860052648943, 0.2679011392424715, 0.3121417788446418, 0.02240441895233393, 0.2724691264094012, 0.007943381198816926, 0.18788456420123606, 0.4051113864703569, 0.14013424813500058, -0.08720233624672072, -0.21300672436293647, -0.39478855048589356, 0.1301931729958231, 0.5250229706007057, -0.2953814578378877, -0.4192252646741953, -0.26816983004659034, -0.03148464628197687, 0.33782516060980816, 0.3327793682134292, 0.4861872466305225, 0.31684445406610334, 0.42374049224079907, 0.2742982435294409, 0.14887654817654986, -0.24746911375882055, 0.1058876617378369, 0.4924089932108843, 0.07236077940804479, 0.5140694291243747, -0.008353755587009426, -0.08272031026347879, 0.3527970994544133, 0.4901597726901537, 0.12715614765389122},
    {-0.002674220894628558, -0.48654568512923957, -0.16142875813311566, 0.04011416174445199, -0.03904562159770274, 0.22653957016487766, -0.4224698570377949, 0.4312707498405053, -0.5155098747376778, -0.3293875328988983, 0.17210729010826636, -0.379546121006917, 0.5024737941547965, 0.06539990110360304, -0.21181118580199731, -0.260676307710583, 0.3218952561467979, -0.36772565143190983, -0.5102263592219929, 0.3481441429863059, 0.23666203847894016, -0.18623089285153394, 0.1520819985858576, -0.35783619423309554, 0.4711261139145069, -0.37656341283923717, -0.37613019284723936, -0.21853054739508845, -0.0781294557980104, 0.16993938429420147, -0.049860939914564244, 0.2271106392402908, -0.3091871321326232, 0.13579567960480773, 0.12580767309189445, -0.21628146158692793, -0.1305586798679094, 0.16354419479768809, 0.32971380403993245, 0.3608664113733175, 0.013424052010577914, 0.3757760727430429, -0.19453169566934986, -0.5880226071280299, -0.35378120114846806, 0.2498511459172881, -0.34968806764993177, -0.0658583287038069, 0.15942773643272085, -0.11049593047547457, 0.554729347194594, -0.1469850690722724, -0.10134497561936207, -0.3046072362972171, -0.24979217595267744, 0.021632514897380717, 0.06068575213001975, -0.01857039655392451, 0.13597374468243736, -0.22626413617989766, 0.30228884458524635, -0.5964925028539059, 0.4985788039539683, -0.32878707960994347},
    {0.045049374752236894, 0.14236098819859394, -0.01083927213409521, -0.017823464484493536, -0.05138220030135861, 0.5005906138914455, -0.18127481190974626, 0.5899142551134999, -0.017807437908373695, 0.26354923432303995, 0.25505156285161185, -0.016160476581614843, 0.4843614367961365, -0.42761670551579456, -0.06662617748758692, -0.20202235839649446, -0.10858999811502491, -0.30747501418479684, 0.19677541943694712, -0.2126511363763761, 0.5216792487551725, -0.21540570042004964, -0.09341124203518503, -0.13987931973411796, -0.188421692258203, -0.3879041140199859, 0.28446821335791606, 0.28399322795265236, 0.19866040415874572, 0.49334238218985094, -0.40867701516967414, 0.1522958898427497, 0.12424112357816766, 0.01715715627102351, 0.43037344360835, 0.41843706797497765, 0.4872396676151355, 0.23709845247531156, 0.08914990163389402, 0.18274001152955563, -0.6164713482141417, -0.17964175931192194, 0.2845328451164187, 0.30459896425616484, 0.49742900609327206, -0.06919942085657046, 0.34919784524977215, -0.5149531422789192, 0.47928572525126834, -0.07571358646524269, 0.025351218197592153, 0.020698483618853673, -0.21248627637401518, -0.06566655668500006, -0.14279009667984638, 0.2542105855573986, -0.08140284601485948, -0.16593416881563516, 0.42931048758663354, 0.3814620901898568, -0.20180344211149862, -0.046096172396904396, 0.635245595676703, -0.02630621426952586},
    {-0.29194548515059887, 0.09905201563513387, 0.14381159356437795, 0.24860827816743167, -0.10488762175652512, 0.3781163405530757, -0.2407269769714317, -0.12300090874941538, -0.014321049377507899, 0.17918669517607988, -0.4201142302254575, -0.16700385184875005, 0.5728525250216134, -0.09204338750990873, 0.04063426636104761, -0.11983923834652066, 0.32090705673174186, -0.05407992124315454, 0.4217164284392553, 0.10136420314825374, 0.3857732317302234, -0.022981139666519452, 0.15506772200463712, 0.5522528821790511, 0.5006110747435997, -0.22295011238311072, 0.07846369290909481, 0.11221223245218147, -0.1262065118453753, -0.1198576356075019, 0.03577854404186669, 0.4101298722385302, -0.42204064654435086, 0.28873078129830837, 0.47992037804958004, 0.6275028680009449, -0.13059268169249624, -0.3222737029346762, -0.29778042946666317, 0.020465555920161266, -0.3472970253988769, -0.3948928274134806, 0.30265736011550803, -0.06840937755426306, -0.2181914555300759, -0.16496699889447422, -0.1824143407383016, 0.1170551903283538, 0.3505958406498371, -0.1835363480115253, 0.10818561872211152, -0.31952813577810835, -0.27772478586761956, -0.15854626404829655, -0.024854863153424105, -0.1487933841392652, -0.14711336023084073, -0.08894320877601933, 0.26653092325937505, 0.27128502523248116, 0.24578036193838504, -0.21884045905591126, 0.47609113932238023, -0.30896806030450497},
    {-0.04174663531006439, 0.047138872039628604, -0.028919160823695837, -0.22330235982728996, 0.21502303157599553, 0.7257477898398595, 0.48318726250897065, 0.0542208324836963, -0.1945773511618585, -0.22903816092435522, -0.18328878506870924, -0.46785432009880795, 0.3967780070368113, 0.1910163272302606, 0.507397176270901, 0.17717643269454939, 0.4827994862227698, 0.06125499969116058, -0.04910473557049826, -0.2479474578305529, 0.2518209723244587, 0.23719473045747969, 0.7219486539093058, 0.24249834089519834, 0.5999606458365683, 0.33913520236800726, -0.14705804208453963, 0.23578237330904245, -0.4129670846404017, -0.20690144712482714, 0.3011346404608765, -0.2573645036239543, 0.3213056801807441, 0.4108501264629875, 0.37658485183859514, 0.22679325702943684, -0.017389439207250005, -0.149318310918399, 0.26269299180868877, 0.4608092907913019, -0.39953920295602224, -0.23214570465465953, 0.5279927800392965, -0.275829449543556, 0.4102507720198974, 0.2570115540243883, 0.25491852563262746, 0.2671822430566229, -0.17665753885133254, -0.08838462565514603, 0.2817867570063732, -0.09189948284745235, -0.23611425628060406, 0.05204648862680701, 0.0446481113903976, 0.24219087603736492, 0.012825155734650252, -0.20959342742478207, 0.363179258159389, -0.301839141014715, 0.11602250812218853, -0.49772277710365487, 0.39309131427120536, -0.16211457776219526},
    {0.08996937441335043, 0.13189868116267853, -0.2375401252225554, -0.1593348715278943, 0.052095882762614926, -0.19632131091787064, 0.32373337752923476, 0.31509972319975904, 0.06087585485501823, -0.12668850917179458, -0.4954968420038091, -0.13091605234521422, 0.6985431974744486, -0.0013863855597134208, -0.03978627955383298, -0.2181953423938734, -0.29521828448816256, 0.13882641164234358, 0.6361961374544955, -0.5474157770466531, 0.563494851959762, 0.31643452736521976, 0.322680455068889, 0.029038215356480688, 0.0800575188633497, 0.26357245310772687, -0.27582353455352154, 0.3902539811232665, -0.45402960859519964, 0.4809053213401963, -0.0026994953368555744, 0.2117306341766522, 0.08819075543679791, 0.30922375790278, 0.6087988699457809, 0.570256175439217, -0.35107212243807145, -0.5125112390510888, -0.19724518509790728, 0.29989493701691944, -0.6418012608732658, -0.19468196689973513, -0.3587737709633089, 0.40530070095768445, 0.5550708405285895, -0.18685173123504498, 0.3301428348087372, 0.4117124605902717, 0.13998572679195362, 0.3402494753074406, 0.11306727983014109, -0.22692025122906617, -0.38196846591486644, -0.0345966548710024, -0.3534671672251658, 0.058281235758036835, -0.4316582394300009, -0.04733052978034816, 0.3964204874681675, 0.4431589207112956, 0.05679395010088717, 0.1304124824188565, -0.2330090322109002, 0.11368766383300043},
    {0.2788601615103415, -0.47535349976513463, -0.18464411465759328, -0.1120202085997295, -0.14009807060563928, 0.10525505131922899, -0.13148520235248715, 0.103442563992146, -0.2422339212918666, -0.016845094792387265, -0.4553526046110676, 0.16350021244823906, -0.05900216518516341, -0.27329697862663305, 0.4344101509086902, 0.0035963523726630082, -0.16271720127376457, 0.2309249281521692, -0.18139702872041527, -0.28243892364008294, 0.3257777463978838, 0.17789749230247573, 0.4523527697272781, 0.5123184267675241, 0.28365166499449646, 0.10808090061904864, -0.3344850219224673, -0.08740037148593763, -0.5403439775541182, 0.12494390049241341, 0.5009675984677677, 0.38332627252583856, 0.38775587349020474, 0.2400780979597251, 0.35538753008132423, -0.1335274479965761, -0.45796645007204273, -0.49279637749530275, 0.16133349554545973, 0.28875208282793485, -0.2650707829258635, 0.24608106663801993, -0.33579851436934455, -0.32286342406817814, -0.07934174021452424, -0.31210029388564886, -0.3952663698694168, -0.30755279078292397, 0.5223558024649922, -0.22051119652717927, -0.07586738751519295, -0.46818617995024003, -0.503239153661935, -0.16977013416399409, -0.15791762510031473, -0.5721724869760171, -0.4306114407905214, 0.26793957555097037, 0.2722819732994247, -0.23723199453183746, -0.035722245758371005, -0.2977611058364244, 0.5131505026745354, -0.11482430285589947},
    {0.16907743466688174, -0.17579987676261452, 0.4966858321190424, 0.27945248036932674, 0.18552997927867684, 0.19920398245988313, -0.40947573255684877, -0.14771127742925474, -0.14536836280153254, -0.10302657619830245, -0.04230152466785651, 0.2240081136242405, -0.256614676858244, 0.48935444924104043, 0.11733903451014431, 0.3374871332457469, -0.23078078207658312, -0.10434176061346552, -0.41623231148503126, 0.20685587676958092, 0.24157724362939428, 0.08872362065039713, 0.05124007677619671, -0.15479818342130516, 0.21929221540781127, 0.22394937871876128, -0.22997585457541933, -0.3141273273592689, -0.20292909164868442, 0.5392119016854162, 0.22706063590324543, 0.07802962035149999, -0.19772620882586117, -0.3453130111880016, 0.06257913005354969, -0.2943292850590354, 0.04303828760327816, 0.1329907986886991, 0.4030613673531293, -0.23134176619206803, -0.2692434602733925, -0.20087739787114225, 0.031997096319738995, -0.3407262064980287, -0.21947512522864063, 0.04424577045597667, -0.0325651543049138, 0.08092156993040668, -0.21373819944208855, 0.2943439454362694, -0.30774803950249713, -0.11307205735894836, 0.0689431441090789, 0.31140057548018435, -0.07730128039995086, 0.15631063916626933, -0.410835636745681, -0.21648819099641028, -0.1042654298078294, 0.263758465290383, 0.37431880527409794, 0.15018882676586726, 0.191723784006303, 0.47631792950444074},
    {-0.3783539456589635, 0.2919218550385053, 0.2697121305856738, -0.3397193826343407, -0.1709222271033182, -0.5126387431812629, -0.0062825645109274245, 0.03927968660200508, 0.4655037395337185, 0.03795870465297, 0.37449239371642135, 0.2963709862797301, -0.22412738443301036, -0.45583917226124554, -0.13037161639292136, -0.48745289388759316, 0.40316818083180006, 0.5175508860351041, -0.12083094317252278, 0.4084707161784718, 0.171748663194285, 0.27376207502803307, 0.2583462946899996, -0.4328513250035412, 0.11568843732849374, -0.02293774663695255, 0.14760695946388852, 0.34721600938838426, 0.22700610159258122, -0.02657209366929224, 0.5684797423713752, 0.08132111617888838, -0.07413199785587052, 0.19751943994994664, 0.32043506091451446, -0.20951199574911555, -0.25405779429624725, 0.26577934217709, 0.02586036246477919, -0.003554291926626948, -0.4408226097951773, 0.05350143545558196, -0.17766133251086347, -0.03371277057143287, 0.0958227371362898, 0.031945917662307956, 0.09317227683561985, 0.0352171650887952, 0.36658393558858926, -0.29605040477517486, 0.39510397944291953, 0.17789604670483797, 0.1612982449163964, -0.1516412355149427, 0.3426467036119747, 0.061120232986654, 0.07703246699447745, -0.03498267052222299, -0.07487822071998675, 0.33170943576435746, -0.18178111942095562, -0.2837463724404729, -0.08021474987699384, -0.0562472826933292},
    {-0.12274170715571739, 0.2549808062495525, -0.2665241171725996, -0.3655624967654089, 0.44198390777031327, -0.21135500984856756, -0.03229337346180342, 0.04553335099295652, -0.2783066018480841, -0.06840435999149516, 0.2814936377807869, 0.16150687675593917, 0.5007095815261778, -0.4318471838544709, -0.17504088728694092, 0.14340550530046708, 0.4029957061989315, 0.40706496533753694, 0.17005436662028398, 0.16657041427943514, 0.07038181933049484, -0.16009302905384187, 0.32132399342044, -0.277007261970399, -0.20423120041855888, -0.23701133679295108, 0.20714919105079907, 0.2021615824697419, 0.22371039229900755, 0.3017666037408153, 0.2845337182809724, -0.19858815315806036, -0.1815672403520478, 0.03720973278557325, -0.015530607841190466, 0.2509559717193664, -0.08290895084107669, -0.35782602051447226, 0.28267270119216376, 0.3276489561035193, -0.007567648037199743, 0.22089602605231265, 0.1090122070158104, 0.437503944624808, -0.1808264018455856, -0.30935640936959197, 0.035216669630323244, -0.1010768318779416, 0.27166460858858726, -0.19993013810289842, -0.03307556931304274, 0.4067614296874443, 0.20310324216020587, -0.24207981259849456, -0.10746099017154018, 0.19802711182255966, -0.34631101436500705, 0.2842333449444592, 0.37549034347595583, 0.49119714137245035, -0.20309144172107613, -0.17037148223940932, 0.030087931725278644, 0.06625432555563293},
    {0.09949018492590317, 0.07449612354065602, -0.4762155884679308, -0.32715965297970906, -0.27643374262097153, 0.31002097346371477, -0.06804572417072986, 0.35702488205913396, -0.23028308035284156, 0.17346140926248654, -0.19083183852448038, 0.1072118555335543, -0.08737057576520603, -0.4265766220011817, 0.4241983527818718, 0.3427289055782607, -0.06103295156802571, 0.05061286113915441, 0.3374484552752577, -0.23179497933223844, 0.16969901332291576, 0.3388462835468799, 0.3121774353118663, 0.06886225012810022, -0.3132909243371145, -0.2602925785810884, 0.11638609035620084, -0.16606986634596516, -0.3119643572766192, 0.05723995155071538, 0.28974300359704946, 0.24236142590338292, -0.040992762847035534, 0.2583335364044371, -0.32754178960000085, 0.07469270835734715, -0.07070314715147936, -0.20895105425406754, -0.011849246596638937, -0.28552011428234536, 0.34222904784034486, 0.39191512197009365, 0.23332604706487103, 0.05266972468613796, 0.2810904491255283, -0.014766095821454165, -0.39658972063438486, 0.01439636515718838, 0.156769124552391, -0.13402938344144424, -0.1716786342600637, 0.24956126705828585, -0.06466289142186318, 0.03964100047507687, -0.4526498315159866, -0.32406343061091913, -0.2008060760515116, -0.0812534110435726, 0.22261737255620256, 0.21662590812928803, -0.04311406866199048, -0.5111602632459065, -0.39008614606184167, -0.48799434646922074},
    {0.2648469657825964, -0.27953498376355823, -0.5705577540965266, 0.37583558728660227, -0.36433642412594164, 0.4625411476924423, 0.2054924447436621, 0.3823498564237388, -0.0020571150586976296, 0.18959990836800258, -0.4197625429158267, -0.5225535737674097, 0.12960768160257916, 0.2518003976530695, 0.003530525098546474, 0.367652587747589, -0.37998016430396764, -0.27852113154250446, -0.2039483258515829, -0.4701793242363959, -0.22435379227665317, 0.11183180277872112, 0.02944850136495772, 0.4736681190769452, -0.4059962695652894, -0.008084510130876408, -0.20526448529866015, -0.1942371151555135, -0.09890632129617782, -0.4030394617259049, -0.41414858700482654, -0.024326325386320707, -0.02386279768906079, -0.06151685363274524, 0.12685705148488172, 0.27150439539860943, 0.11826640533364746, 0.030153964871052742, -0.31466874997456457, -0.03966799429617477, 0.46264099333733166, 0.09245733189985555, -0.25835913846962744, -0.2040986649975737, 0.2563351410928036, -0.23562779200330855, -0.08232231335841678, -0.3516831791915353, -0.2955307566988137, -0.38849467944361354, 0.05406223586080507, -0.5264014088378318, -0.46892759955785324, -0.043167632400642114, -0.029984088177026795, 0.11506154174869183, -0.17640778589344525, -0.218644146202483, 0.036307387353493904, -0.2838796581032725, 0.12893888346229915, -0.21663171905811227, 0.1508142336387151, -0.431642892973155},
    {0.14377097368145977, -0.15039487419071876, -0.47814200657081185, 0.41886198299570104, 0.20164360556432062, 0.18876102532032066, 0.3824814730781039, 0.44531252482758094, -0.3021985382422627, -0.44819852633000146, -0.1406495285411715, -0.4249106257898781, 0.0639528178801841, 0.419751798549359, -0.22572452046752473, -0.1920424315372358, -0.10047815405144923, 0.14572880441082506, 0.18214596988020573, -0.2323052793775139, -0.1530994346260363, -0.1676697766700095, -0.2890843046901604, 0.663572690704679, 0.1635855565897757, 0.2732993171635334, 0.15244907433580174, -0.46817777977703584, 0.34726139131959616, -0.3203300647812015, -0.261981484691376, -0.035912674626555494, 0.09034407471873775, 0.06735769657485045, 0.1826485435231963, 0.08344483638313943, 0.38408638939379214, 0.06414983897466699, -0.029359491052125864, -0.3208282650556381, 0.3676532682599426, 0.18595643756973038, -0.011751518362256675, -0.024966029804281597, -0.17737533715308856, -0.2974123275676505, 0.24947478092503608, -0.3770923255387509, -0.2823111734121556, 0.0022355257102596483, 0.25372898497025176, -0.3960216182076439, 0.12125903397084435, 0.2622859242752553, -0.3256931250078824, -0.31974748734469416, 0.418888394225367, 0.017191030360087126, -0.22091067792771843, -0.35145363064971674, 0.29752115300136334, -0.06273161107744821, 0.02519556420504545, 0.13189792411816337},
    {0.16883561072377418, 0.10581432805676873, 0.01843213733099484, 0.24419075497891687, -0.2595552740102046, 0.27763238567199416, 0.07707751271153669, 0.3688315611154647, -0.23768786142171172, -0.1369252044022757, -0.08796163937368565, 0.16391081937133622, -0.1378209229802548, 0.2289788077574499, 0.12812365230577633, -0.3248931652817678, 0.1463844413951629, -0.31203798775914193, 0.4465060972378868, 0.2318108611767229, -0.38600954073040306, -0.40325386949812464, -0.42217186368524023, 0.5131074572243793, 0.08337245661190815, 0.05675129377915425, 0.14744557860456037, -0.08879252710334863, 0.36886760262606033, 0.05197444558740216, -0.5453714290519652, -0.2950556205925974, 0.011356598955612852, -0.021625164548602922, -0.34852843204558936, 0.2769995381408471, 0.5882341958056411, -0.18217726764216213, 0.1903158516363501, -0.30040028126390345, 0.3325035344797761, -0.0826545748684402, 0.24797207261479212, 0.26909590708558156, 0.2394853472529858, -0.1780594888735402, 0.01879049215126183, -0.04839751096740603, -0.012685069141513352, 0.47439221340592286, 0.021944698197612612, -0.16304335374388085, 0.29604564617791856, 0.13720510993484983, 0.053339541710980105, 0.04073459040921608, 0.37130278618205437, -0.2032061959063455, -0.11731361348146273, 0.03624972142941114, 0.07954179175597048, 0.3915991829315761, -0.08158646312309813, -0.20603211881531105},
    {-0.21488529148203, 0.31264991743275006, 0.08019109488933883, -0.24720772711306485, -0.06634767651877227, -0.31443230489230656, 0.13098261797872207, 0.14696077114772665, -0.45171485287577856, -0.31053094027768874, -0.45424697036151773, -0.0014348693665966594, 0.24703532183723262, 0.11749149809853558, -0.5670159579772404, 0.03272742643927734, 0.31554392700598155, -0.17436070777328, 0.06774329832300041, 0.05089213083893357, 0.022596511815762763, -0.38999721178418223, 0.03581303354572524, -0.03355827866019888, 0.3477176551018488, -0.276461783194013, 0.12889534452246135, 0.287031284774159, -0.11990660641244323, 0.02253397564576823, -0.3890798099486166, -0.17685968237223582, -0.37363298406743745, -0.08794604799823161, -0.35977090981783005, -0.05745572415271811, 0.29712870962046145, -0.25800740619205853, 0.04301543546198433, -0.497099391626385, -0.11396068627231404, -0.36689589871610295, -0.37831721544765484, -0.425159323730522, -0.12530919940268342, 0.2423376989297434, -0.3421507515770272, 0.030896239406831172, -0.3163740806208056, 0.020081989927556724, 0.2982684037809032, 0.01015798741930683, -0.3531142410530527, 0.24618399905359822, -0.23712132657092605, -0.03379326982085476, -0.2157120876616095, -0.2466247100717581, -0.044245414259690884, -0.4324717318895178, -0.4183408719176299, 0.3626070304542769, -0.06189967191002694, -0.3205612780157421},
    {-0.25044439284061976, 0.264281718849533, -0.43735249974539875, -0.17834699307809937, -0.34061071871439563, -0.07475860776077681, 0.28849343298275265, 0.1581793852787979, -0.01805223906033007, -0.24822551061068554, 0.08847001164116725, -0.48953489929824534, 0.5356768713853245, 0.3062692570675686, -0.3589516348444912, 0.20831329683722188, 0.09372736218340381, 0.05797671836860858, 0.22158755822525322, -0.39980408796875755, -0.34487362795136667, -0.3385674076162365, 0.3800979577825485, -0.16264626885868697, 0.05216151620132733, 0.03984611387398619, 0.3048185120177855, 0.5190544144858874, 0.27055790669322327, 0.12771550771621246, -0.2272347228936664, 0.3407247432521422, -0.1845128943782527, -0.022007859228596674, 0.23133226992596584, 0.08471428246277057, -0.26978077507407505, -0.41776353156972323, 0.19080207921746345, -0.22494769720083918, 0.16231710470109995, -0.15338080881179622, -0.5247915853319729, -0.05006967524768073, -0.48089425611144115, 0.19814106563147077, 0.27040279711386783, 0.004920270181407483, -0.007797569160247219, -0.23715612409454456, 0.03253460320177804, -0.18167941060317927, 0.18480303094966682, 0.016916443219053716, -0.44506434500993947, 0.34304030942061364, -0.05145180908435518, -0.006835356497656481, -0.24315008847215924, -0.15774269083859743, -0.29785578470722385, 0.20542378230032868, 0.12195815962735261, 0.0750843620014791},
    {-0.3301137389509016, 0.24218348953923857, -0.26638780900783987, 0.23908214892035784, -0.29823054182023057, 0.2531421861315483, 0.07525646080337745, -0.18398781077511986, 0.39878622932637603, 0.1578069137504683, 0.31754167063526056, 0.1924106755318891, 0.1553801014789191, 0.3112661875726015, -0.39727759534617474, 0.2562918634979368, -0.3020107121886303, -0.20519808169912931, 0.2130681793206192, -0.1279775089473817, -0.12721859424448573, -0.0766179685450003, -0.11048302996667467, -0.42458061962934174, -0.32928977814989413, -0.2139686377710617, 0.35775971617968483, 0.37777144147662056, 0.3859291367528308, -0.23925922196813904, 0.21624994396441738, 0.2947495429631896, -0.36976908720338625, 0.13401838880922387, 0.34660565987532266, 0.013624552440522745, -0.4513420193170749, -0.28864068193072023, -0.31140601867350354, 0.12567135708866453, 0.0017675590609113007, 0.22475261274578645, -0.3015778054452708, 0.32986109631016114, 0.11819190032362233, 0.33854254111897303, 0.08029634234963338, -0.43896848455263254, -0.39678584641651693, -0.22336519494296378, -0.22631834702981785, -0.15076246870761792, -0.14976003668700036, -0.19777518232865127, -0.10282761528515616, 0.4239545133071065, 0.3076881414133341, -0.18477053047608874, 0.09995845621638402, 0.17228406415843528, -0.2772383125816166, 0.10560747970581554, -0.1472415574317999, -0.024367393194374677},
    {0.027029500739066445, 0.4001966432764042, 0.12300742147833736, 0.3269067747578624, -0.25192923993378213, 0.24242565234037122, 0.001221231854152463, -0.14964406166763525, 0.3199255147259723, 0.29151314283863633, 0.13351475510249192, 0.31166278919697016, -0.25768866197490475, 0.3228831119235541, -0.46290517929314345, 0.005390070203724404, -0.1937747375600091, 0.06452005171198089, -0.13734059024400017, -0.19495000448532604, -0.3610272934217211, 0.017675055595352148, -0.1870332017001674, -0.45742746542059204, -0.037236356869672214, 0.10630251936333737, 0.37615610948917444, -0.04154169397576174, 0.021769187384599632, 0.03862385726116703, 0.49387772765258775, -0.1940107186388235, -0.11547374487731578, -0.15064036372072684, -0.12128527284167799, -0.40220367813131114, 0.12880040574675203, 0.2801516668707557, -0.4207964754628685, -0.14768888609610062, 0.012126383418279083, 0.017058812700869265, 0.41378525300611296, 0.3689153051667554, 0.27264656466673104, 0.2635664070873956, -0.414421511837868, -0.4190307698532906, -0.1428736672588967, -0.02887557122343217, -0.037076699740732556, -0.32717851822121885, 0.363913581547906, 0.02067457839007232, -0.21141168601509197, 0.4234479498987949, 0.10941003386647905, 0.01846147134473436, 0.247881860009432, -0.3503699710459314, -0.10676743519699385, 0.2113547891140344, -0.10347452689840488, 0.23033736109254344},
    {-0.2048201621093551, -0.06664296978937168, 0.3459997534971151, 0.46607519108830275, -0.22646105681106396, 0.3668926506722311, -0.06662676836078832, 0.2555637686468978, 0.23477641569127236, 0.24065397794521806, -0.06921462182516158, 0.5004832963861147, -0.4725225393235764, 0.1082027221939688, -0.3658945955371931, -0.3580538907134187, 0.012941191749229836, -0.23659444237447255, -0.3642253487714434, -0.15598192948637246, 0.20855898846941978, -0.3271949900736366, 0.11746973224059044, 0.09941203082606109, -0.011848123281663438, -0.160040763199302, 0.1309060409225057, -0.006650400619947273, -0.3480518819158704, -0.3753632362085341, -0.14957971079466745, 0.06649953507149524, 0.2408420245485439, 0.5329375860089876, -0.2972019829740693, 0.18472713427806278, -0.28803675612658225, 0.12382759908566943, 0.023418060872886906, 0.06275675735386707, 0.40965971134068685, -0.0015295337877352124, 0.3564525753473762, -0.23111268588305608, 0.16235640289618244, 0.1741748550537869, -0.15348410594395995, -0.02444563288748925, -0.12719393254715602, -0.05303136645175869, -0.30383010709684816, 0.19858570856201682, -0.14075530260107513, -0.10506939167611878, -0.09313192798477794, -0.09108580568684702, -0.20155294254562323, 0.2945111315294354, 0.35557259305523925, -0.3120834340462191, 0.15685909656902916, 0.017510996139293685, -0.09663975152210941, 0.3962920024755897},
    {-0.47407283667091726, 0.013979530516671298, 0.30471255878130993, -0.3173693851922768, 0.1830446850153182, -0.4961701295958568, 0.32924891041828047, -0.2475134922073044, 0.4342997084781049, 0.2203932010203264, 0.0050220189612800595, 0.03802209041890713, -0.5448199972408458, 0.049173041935159034, 0.2143804084975927, -0.5214897332112897, 0.23758239166292924, 0.31492442145431326, 0.19915064559624598, -0.260510482012508, 0.02108426191596783, 0.013368765672684593, -0.27758509449690927, -0.3296272872377024, 0.21227387077011153, 0.24305964779499287, -0.001141931949371859, 0.3192683418299802, -0.29610251204960775, 0.16217626755232617, 0.17112036705664782, -0.3191691860296843, 0.3836797321694366, 0.3059836959972637, -0.31573731090705276, -0.3349283204575194, -0.35844583059288326, -0.008370760476830356, 0.06680927974433118, 0.19423884491614826, -0.05498302226157862, -0.023833036938507215, 0.2751912174279804, 0.20923206743470765, -0.22917181268452122, -0.19949631011042382, 0.2761755408081972, 0.050936231528362144, -0.06927369629203937, -0.2525037245057482, -0.1081902492583578, -0.0027093611145477584, -0.36959719284149584, 0.14451772419670794, -0.1313669786947154, 0.298006738701577, 0.3359300195330111, 0.43436218659183506, 0.2496598384260317, 0.022289598979936546, -0.09152307607570884, -0.4835295407040512, -0.10401490093287241, -0.07202929053618555},
    {0.4054865150283224, 0.35186173442506014, -0.32673386473373894, -0.28331577489356025, 0.28346205387934936, -0.10072360714863762, 0.21951413930962002, -0.3862748295086195, -0.025991152344770074, 0.2200711116736767, 0.06111499196108621, -0.3573753270184158, -0.11783991972205592, 0.15489476370445562, 0.26996486150555654, -0.09601420296657469, 0.2132391948277222, 0.34030184181147255, -0.2178552331492647, -0.08974633932384903, 0.34947026272474035, -0.05745183915030332, 0.013521856063588513, 0.20641139698478395, -0.21430073450553272, -0.05248439536842436, -0.13533018524067758, -0.30033006405111967, -0.23931496842505548, 0.20669237179644215, -0.0278306063910596, -0.24449004694892837, 0.23025992474115653, -0.09653858795938806, -0.007367010320821984, 0.061567650755616606, 0.2943286489657577, -0.24229816561637502, 0.0010258593922927025, 0.4390811883062503, -0.2220943753559517, 0.3897384707515906, 0.39496407585725596, 0.2813032106416676, -0.0603356514108188, -0.3730980674628766, 0.21204102704951966, 0.3650855005646539, 0.28011711600874933, -0.3684780347065559, 0.3514096624374037, 0.024969984561128793, 0.16786000920741675, 0.09909901418873274, 0.41615712084500095, -0.27841805904440886, 0.389324203662504, 0.12113752810240018, -0.02769228061109241, 0.057824842703990645, -0.3461287736731968, -0.06944363039444065, -0.18404347396816617, -0.24760443333290716},
    {0.42103843242860833, 0.03458475889245907, -0.12561093337928705, -0.24621170220740157, 0.40902744776664535, 0.2332029069900237, 0.034146726680980274, -0.5156475956149554, -0.31650995187158565, 0.4354218454543886, 0.19078827329627424, -0.20675556732383446, -0.35049073020469357, 0.355481012094104, 0.09252486474428852, 0.29583907770857115, 0.24490627866112158, 0.3669239672465108, -0.274242033110554, 0.4574400260652873, 0.11747557992071474, -0.3122481529045506, 0.2939306048582972, -0.30495526838563863, -0.40529869619697995, 0.20383053218136873, -0.21796990010355385, -0.30344792946042487, 0.23648272354149677, 0.29176674079147374, 0.3073126792738668, 0.017613255314307713, 0.39849062088619797, -0.5486539342127773, 0.36997758899870387, -0.08142856245777606, 0.385659172746786, 0.43209572322929296, -0.10590825366777878, 0.642029336239764, -0.1894833722996871, 0.09093085063378217, 0.41159754460158215, 0.07202234916848457, 0.5135073631014644, 0.395772955754319, 0.05740880368447761, 0.46743948835224536, 0.4040743852985516, -0.2966411384476481, 0.34758090329045294, 0.060027044455358246, 0.02787329942265939, 0.2701991420675908, 0.09333273232334854, -0.291915494594958, -0.28543902846251756, -0.2923514913240391, -0.09998072455275578, -0.17855283142322262, 0.1779336333422996, 0.32280495031205475, 0.13453936838942968, 0.008275767734347237},
    {0.08628575233079838, 0.07113860358530157, 0.04771833228522581, -0.22946679818421917, -0.29128739299179074, -0.2157110012262902, -0.42529405348589794, 0.10544071824742343, 0.32536518793050767, -0.05896458141827989, 0.2353737984827367, 0.23583832385426204, -0.14417998232508047, 0.30691002903815007, 0.24946088436044933, 0.1538374683808022, -0.21168298436720337, 0.2590346575284293, 0.22919823643032466, 0.4399808656625259, -0.4800643436230849, 0.16918969157976063, -0.20347799124005309, -0.05432761416507102, 0.13751957279556312, 0.06370771029746539, -0.11677011158825452, 0.0958322615808168, 0.32267601593151307, -0.385697342791941, 0.15192751215580513, -0.22046316840279578, 0.33850428240181996, -0.3134113983424226, 0.38432626264023023, -0.017674110642152612, -0.3080551659994237, 0.26374338304102, 0.29526236355951174, 0.424284493726355, -0.10315035732569554, -0.10827655872217308, 0.34541422099196806, 0.40664829093338634, 0.49137389907265067, 0.41254255663649053, 0.1365396030382374, 0.44266489862061315, 0.3287778596669237, 0.31151830739680153, 0.4143097395353505, 0.1175085547051736, 0.34683689463391504, -0.18748410094432616, 0.27734644251242146, 0.16413072089038597, -0.07431588590912162, -0.10913722681366698, -0.4369247123256616, -0.21241170758989417, 0.2538127178949522, 0.21170603078025116, -0.22750194012180622, -0.3790558627334459},
    {0.17722672509932455, -0.15498761836721112, 0.34865258780988495, 0.08222310612547978, 0.027332472166447713, -0.3291695723723988, -0.32068005427660806, 0.287955796767397, 0.2326777649909146, -0.295422292647807, 0.3906125345277928, 0.1775103384241699, -0.12686657060154996, -0.2616737959615841, 0.34890397012266555, -0.09414437979167442, 0.24341158589808423, -0.0736433683397406, 0.48177001459190055, 0.30904484849386316, -0.23076124198287468, -0.14286315299578833, -0.2595962247570064, 0.36190106369990793, 0.3876223059239174, -0.1984268354898407, 0.18462385999656136, -0.27853773190018566, 0.12010975962410446, -0.2367580152476991, -0.11580467771902389, 0.4344035003282412, 0.03715385506256555, 0.3234690538293563, 0.34870246244005854, 0.4001867392484432, 0.025039553329554657, 0.1451918009001518, 0.3474180739382287, -0.4136697179589087, -0.19242971701308362, -0.11664962503024165, -0.21939891086433713, 0.11938346878989609, -0.26157033080266934, -0.015361100701268726, 0.4481035710509807, -0.21468595153751457, 0.043897961880072375, 0.3921275407564721, -0.22804005502055694, 0.18261771401662658, 0.1475687010249849, -0.2865157222294018, 0.04836001936267891, -0.19132941321295643, 0.39519419169464187, 0.38461921726370263, -0.23987892631799443, -0.030074368190368437, -0.21291499308014952, 0.0917357733030504, 0.004248966440710795, 0.3580998906908345},
    {0.35800273926857995, -0.515244151510043, -0.15385266762323485, 0.07842339646282424, -0.17274095001757128, -0.25615984510834505, 0.1997502842570394, 0.17554116036426695, 0.10106609966554056, -0.44416924042633726, 0.2189858692711618, -0.27274578204476635, -0.05227996246465632, -0.3108467047615229, 0.2785693374790371, -0.12147078030884235, -0.046899872574973155, -0.39473678055372347, 0.5202918364457102, -0.4238437528924046, 0.0038149041959266677, -0.10039573227854667, -0.2755574815744379, 0.44453068277322366, -0.1795454385815725, 0.3133500283521311, 0.2634007838333632, -0.29295491975833815, -0.25340398073880327, -0.3750165521726117, 0.06378534893551373, -0.2154804753390761, 0.1013948988909302, 0.24879008944906547, 0.23248497124680184, -0.21280324689759192, 0.2653249645944851, 0.08004404838088519, -0.25898882412941215, -0.24461753249747611, 0.008712823397632971, -0.08829555570154499, -0.022807067116659432, -0.4386610628717548, -0.3559799528783609, 0.09539050307934087, 0.18874715266926984, -0.4610410592658601, -0.17261060796151084, -0.12327276604899555, -0.28645906927789727, -0.42400810844997994, -0.06557239187166605, -0.1409068051578208, 0.18117694677647325, -0.4295169814884382, 0.4362222340824208, 0.30830103173376305, -0.33202188152026424, -0.007741643050143679, 0.14237689018164792, -0.37325688181791505, 0.179122606048366, 0.2759911996920496},
    {0.29264459830735756, -0.45157531144151375, 0.030833866873804842, -0.3479624426499092, -0.07212194254155564, 0.10141126626535324, 0.4239112289819725, 0.14070967938887144, -0.12830961200056615, 0.2571401270624069, -0.25308203209512, -0.08554784232557112, 0.06311740443657812, 0.056250452396539946, 0.05712361007550549, 0.15990094777956707, -0.32452432636771184, -0.21745346406583418, 0.09925426667838225, 0.034423004296821436, 0.3819896391654422, -0.12493760169494386, -0.3970068772665128, -0.312437308257117, 0.36067901068152813, -0.09265770960087374, 0.2914006214448058, 0.3008636142416234, 0.03923404192580241, -0.4489734112591014, -0.23467586567477577, -0.341597209997745, -0.2852656774127598, 0.28467952536917457, 0.30254550180922096, 0.160425374340326, -0.08487910855677351, -0.3659837452178542, 0.33274162988891764, 0.01218589021186994, 0.07814256800257098, -0.13901853545341733, 0.3681848095802895, 0.10413266807980084, 0.2275514787559727, -0.15726083414053152, -0.2275112095349808, 0.005416000719152818, 0.03628181386638499, 0.3005086120608555, -0.11820298482585732, -0.25510990707235054, -0.047952093766034744, 0.17581977139460284, 0.08347516583250561, -0.36763197470668546, 0.48947033678166246, 0.2635311269285282, 0.10782090895465832, 0.4516679547206809, 0.31694902853401274, 0.284332934367489, 0.030486806047265873, 0.22846754760173515},
    {0.34378306433908734, -0.15401057958966796, 0.4130343459906026, 0.14425074977561517, 0.19775642145650746, 0.1776470715077658, -0.28841147331441597, -0.337429816683581, -0.29366433677627024, 0.13920677891464298, 0.029258029939074465, -0.3504865134654152, 0.41978909436395406, 0.23459595569260427, 0.2340204901246507, 0.1607716051489818, 0.08072431104315936, -0.18299713831925085, -0.033172716643571985, 0.028994500043539095, 0.3067436576497189, 0.26014061574973035, 0.23548256568086534, -0.09652428971903765, -0.15576732677868318, 0.4113966864368483, -0.10343333510764299, -0.4622922613411422, -0.21814160116244513, -0.1876761816186217, -0.2557303198127648, 0.04263033917051125, 0.022703408570738992, 0.1814035646558584, -0.03541438244613318, -0.32641912696939346, 0.09896110442685756, -0.11379053801787387, 0.18486287283782052, -0.2714784697888037, -0.2237347645393926, 0.13838382035863248, 0.1210150536526216, 0.44051555204240544, -0.019816205794098787, -0.019240412390589098, 0.08717294349687746, 0.15797900067082885, 0.4217500283803419, 0.18240420700040416, -0.10984130377061287, 0.10013073097243634, -0.2539327266751528, -0.38473711082918405, 0.05234166121141903, -0.23671971391499505, 0.41395405181353206, -0.21812605897578896, 0.5460931338488925, 0.28997638947276, 0.1201724724349047, 0.5433226648882884, 0.08466958446399514, -0.32306909569944275},
    {0.13436304757582218, 0.3307974320097602, -0.2545744412647695, -0.07935895974034426, 0.026461926572486347, -0.3034458225697329, -0.03280145715754475, -0.3440524053532138, -0.3222969546551324, 0.3078977799930106, -0.1508615121071712, 0.12331081884474433, 0.02725244631978183, 0.14205661463935898, 0.2007620487091027, 0.2521927895165023, -0.13767115123883894, -0.4835813775515602, -0.46701761090494404, 0.2791544191585365, 0.021553639807943583, -0.35278318551670246, 0.1524068265249004, 0.07244905588941952, -0.22200703085285395, 0.08162710933000927, 0.07171816601879817, -0.394432605234757, 0.054912422455344126, 0.3079951622387016, -0.5356120809822226, -0.3973074482205138, 0.0586955145984437, -0.12602585063337463, 0.0910414343401878, 0.24726635003571323, 0.22649923722884754, 0.055317028520889995, -0.12318576301961681, 0.24709065577283992, 0.211197129286401, 0.27073266651365857, -0.5328103910292818, -0.3001923185535352, 0.08479615060022852, 0.012053148846941862, -0.31946434684181796, -0.10972479548899988, -0.09261513279553044, 0.11534840761699415, 0.08915396631761564, -0.011667842966724134, 0.06392120677928921, -0.4587265905080077, -0.2541946711807325, 0.315229281637826, -0.31983616253090075, -0.1905915470006428, 0.2527989935875768, -0.4032176740377244, -0.45878675595826335, -0.3183254379214251, -0.14544695384008913, -0.39548719472514543},
    {-0.051517056082198844, 0.182425885124223, -0.13203619157990756, 0.22450671551701767, 0.3479372786735277, -0.095183612113436, -0.3413401473350441, 0.09535135875359571, 0.2233324018155694, 0.04279911041493104, -0.3447108925212227, -0.41989617717412364, -0.23296711442253817, -0.19671035392600797, -0.3611504038777459, 0.2826105855179939, -0.00040740795788014785, 0.05013012532326959, 0.34728616484130764, 0.11289632343464176, -0.06251520030910047, 0.2795273312309836, -0.20697571178388086, -0.013915304185374334, -0.10252921228649595, 0.27410218687796345, 0.22760593327866155, 0.07669657449936577, 0.04390268860157111, 0.3804788739598559, 0.03813928546453071, 0.32370653421189355, 0.20182337961847108, -0.2758088815808626, -0.3520414888128907, 0.21916440018099254, 0.35068872867164, 0.2235305964403314, -0.08718435139883761, 0.3021367056096465, -0.3282666584442269, 0.2294276034206827, -0.5386297107147556, -0.34544475849912537, -0.11259556720976548, -0.25812635283115737, 0.08819223981781595, -0.13369175214892773, 0.054050186507959834, -0.17204149232245744, -0.4957497504763147, 0.05141394936029676, -0.2372272450628692, -0.21120118959515372, -0.2806768719325776, 0.2875942198239894, -0.5381870623493163, -0.350939452532432, 0.0037332764348620632, 0.2070638424020089, -0.33235557125742426, 0.1990662312555948, -0.0007848830767859794, -0.10768137932771922},
    {0.41173680576193217, 0.10177516102657307, 0.4638087093815031, 0.10391989135331871, 0.11908725797245533, 0.49729679238917973, -0.09899759472153678, 0.45021362487405864, 0.3971453590128491, -0.2430833217159293, -0.3084319621324635, 0.07783146733641384, 0.0450107995194833, 0.2068010239630182, -0.12584772832731395, -0.4009429093779474, -0.23903313874847604, -0.10905387606918943, -0.3972666412876214, -0.15395246913680502, -0.04913497012123291, 0.3807586356545544, -0.06522579330420047, 0.015869796411377774, 0.27857222177579094, -0.3249031942823775, -0.09291042128103333, 0.08940897278985453, 0.23039140254566182, 0.029491506794108283, 0.3106675513737782, 0.02999018131103329, 0.17538308464618643, 0.20310841115088343, 0.08173375910169133, 0.12216550620265164, -0.29151163576498257, 0.0759217745800595, 0.06572464748168547, 0.06935983679935336, -0.34460823835199395, -0.022821606749879826, 0.0025642977481189367, -0.4763613724937353, 0.28008869328022346, -0.3021406160859007, 0.027905061766566867, 0.10144231343039127, -0.4384805284750042, -0.06978186000389565, -0.4544412298192468, 0.1295765606143899, -0.09436675493125565, -0.04365677560413918, 0.03397514909741914, -0.1338676146905829, 0.16119611022067085, -0.03887613809940725, -0.07506641487066118, -0.34136828959203164, 0.24480671712294036, -0.1693478056557182, 0.23005343682431706, -0.2978441880865642},
    {-0.20364537128624804, -0.004499796387237078, 0.20004539772295857, 0.24752438399728444, -0.23117301671756385, 0.37093069332104117, -0.38214098984747935, -0.03391688357276863, 0.003169285827974366, -0.06350448518834602, 0.026870350303991902, 0.11352810814499395, -0.05585931754189703, 0.1720077419309165, 0.14763651496044275, -0.19328670414819255, -0.2035900021765314, -0.26397367469776417, -0.3031919059659817, -0.28155674368187195, 0.1395675097475981, -0.19062983519718998, 0.004052637860344173, 0.09447189199727328, -0.15905136384540786, -0.043624568787417634, -0.030227197900622536, 0.31828005893587735, 0.026762616443928484, 0.13279612755016937, -0.17685618383936588, 0.02384465932710523, -0.0062181054998256356, 0.4070317625678831, -0.13820948976867292, 0.28533892887766227, -0.2094617784416695, -0.16316134458345494, -0.02474147530350197, 0.273491426946166, -0.19351026915146513, -0.3889797608397868, -0.10573935035637286, -0.4073694462357319, -0.18992688458681484, 0.01502050045679185, -0.039350135561599345, 0.13252148661718577, 0.012235981686728542, 0.2186827421951204, -0.06041809781036102, 0.05962494802095268, -0.09014259198315527, -0.014101415267774173, 0.09043910496067564, 0.194074565443526, -0.33928141023652847, -0.2901503040752647, -0.2879962314348155, -0.49162368366427955, -0.27752910588544644, 0.06739317210438124, 0.3006689241381545, 0.3509968441148137},
    {0.27441024215098625, 0.1159713712940044, -0.12366315139176867, 0.14338405230114787, -0.15439698162784118, -0.28985813028077057, -0.4413372457015201, 0.26582593050000675, -0.1893192229962387, -0.12328709050568379, 0.34132252357642984, -0.42079143335450536, 0.24906869885242564, 0.12284395714563816, 0.05447102601784169, 0.2838697282090237, 0.1369296499183117, -0.34708157496598924, 0.09475533305448654, -0.044118768091493135, 0.08077730863717025, -0.2481175524348808, -0.2786112428014743, -0.37581358080442695, 0.32135899835286225, 0.06416321035057429, 0.09933494625356137, 0.4254631328274075, -0.2641812557856603, 0.08003690175245322, -0.462085012244373, -0.3792650911198166, -0.012566182436283302, -0.05317796602081368, -0.16709524818298238, 0.09604913283933784, -0.2993962675399675, -0.21763090912641953, 0.02715152268794736, 0.09543073803199094, -0.0835054902833736, -0.193649676630639, -0.4198435890386047, -0.08948145229022612, -0.013543809621314802, -0.5182623592372991, -0.014432440570032535, -0.1804294964418801, 0.3862664200409463, -0.24549241642804873, 0.22186417422300603, -0.1454108213715554, -0.041835813619991995, 0.12306090791086943, 0.01467301197817498, -0.20820733165424174, -0.10704730424693033, -0.007729697959783322, 0.02054959859478311, 0.15372454131296379, 0.08353491382900358, 0.13297467363697246, 0.19662496720584163, 0.25168376369401263},
    {0.16038709196741568, -0.03946047338868957, -0.15916239688123474, 0.13901752181952767, 0.11711945206225444, -0.05422042904880312, 0.21537955578329085, -0.07848332507856558, 0.3842856443334785, 0.29681890918483156, 0.2854046863320781, -0.18108387777203322, 0.25343123602146433, 0.18845103659658569, -0.11529059613409785, 0.3283410375866236, -0.13393881531813867, 0.28116220277797194, -0.026498507295117425, -0.005811408245129385, -0.2556987101416793, -0.12126026292876267, -0.25129506235000587, -0.2223088234099148, 0.0510709305645946, -0.020209987501930867, 0.17212680365388416, 0.14600847674816778, 0.358247941670889, -0.325226559848603, -0.3172087055010307, -0.2474369469770441, 0.10945183497178489, -0.3903576126467201, -0.09768348901151697, 0.2300384204628871, -0.4058953960021396, 0.5214064225752769, -0.08028191511886294, 0.16824417574014974, 0.25332442330186394, 0.2660270323832172, 0.36712001182660353, -0.32194753135788634, -0.19529595485709184, 0.08325951134629465, -0.1472637979308132, -0.40410743227488866, 0.2874018365237352, 0.007370748558580084, -0.08962483255956216, -0.24423083993593034, -0.29427305162051287, -0.1635074819190003, -0.3142902014822047, 0.3371356790072783, -0.21626613205538775, -0.27983700886631435, 0.2284517893820228, 0.3958466691240201, -0.35559809082691746, -0.257244190090681, 0.44013867054107897, 0.32071847461582903},
    {0.4318065265529692, 0.09831781280527023, -0.06365449089850123, -0.3586589566773269, -0.17531149131124962, 0.009253062630672054, 0.315349466238184, -0.10219692258912103, -0.3876734337477328, -0.04386801700094337, -0.026135107282630726, -0.39075899436359457, 0.4354011599831251, 0.26278260011781496, 0.42383933359587644, 0.25243276528465913, 0.1742667620090764, -0.26524709565841237, 0.22509033873959372, -0.17394116774607465, -0.19775543300166715, -0.0546390346938888, 0.3634313099275535, 0.11625576625275602, 0.16999385636844594, 0.24235080144318155, 0.22486754873664228, -0.034186797610106234, -0.17305853044513905, -0.3271489140694961, -0.44686966302203385, -0.0921468258488193, -0.32306574345901584, 0.3889071880491121, -0.2284825850080523, 0.24507768434451502, -0.14904102599770092, -0.09122407575368777, 0.12320309173160529, 0.033852753104837076, -0.2442711227397045, -0.2129128007867419, -0.25458256534727813, 0.1308133187803647, -0.08542638365463513, 0.05319063226061565, -0.36827860040639127, -0.10554871753378084, -0.07600678439072699, -0.3806264276225116, -0.038454011795556006, 0.01045649561189995, 0.01812937436782059, -0.09486737414266772, 0.014440781873436616, 0.39112702100444574, 0.06643249320960001, -0.24480697291254047, -0.16339614865608343, -0.07354597869831292, -0.3406220661297009, -0.43999871609509106, -0.3248874001594335, 0.29991195886900696},
    {-0.4474594204914475, 0.26015531800404823, 0.03613794730938662, -0.2814409697281841, -0.1720552423439002, -0.3144670929261189, 0.18278381361148915, 0.2837581596411122, -0.1598306679029341, 0.2851047591502804, 0.1977472669897927, 0.3632457848317667, -0.1260411915913398, -0.19311810204235086, 0.28193072346568665, -0.3084274990710003, 0.23622362058772592, 0.29354173904240205, -0.18988922484486034, -0.0264294433355077, -0.0010651819495400199, 0.2750870404170436, 0.21025865706338212, 0.18966807560766813, 0.15164687630111612, -0.10144760541719866, -0.12342661962285013, 0.34626757954953025, 0.3822951641086153, -0.2940208921078619, 0.11825853596081404, -0.07718282209094217, -0.11825503521752094, -0.31903009198491744, 0.2424879423511235, 0.1400672473006541, 0.347329292641658, -0.3394096050780481, 0.2296905505072116, -0.1035160575868514, -0.10387393467661116, -0.15785806803699812, -0.20167833410517705, 0.21613863309565992, 0.03703638243651143, 0.189796259273648, -0.2526706512634136, -0.03089056086671533, -0.4861994267959498, 0.38486575826594727, -0.17087087384958644, -0.08996990038017443, -0.01129876466149113, -0.002065019243561785, 0.15943529708015752, -0.15678579800474662, -0.03124442305304464, 0.36099855780470275, -0.0044229818421522545, -0.31737587938230644, 0.45540407599238414, -0.1603420240516125, -0.10263840875459784, -0.41875234978301196},
    {-0.5534120788800954, -0.37105489212106924, -0.21241913801036139, -0.3205609247461718, -0.10260169405887615, 0.35055831683059313, 0.25266559776324815, -0.12742309494504087, -0.2174206368177905, 0.2800030896722318, -0.09140977025738495, 0.24086718208020907, -0.34545885595092835, -0.4419067704909121, -0.6371864091982079, -0.23940819492840995, -0.04802947272408309, 0.1357784682321522, 0.27321482188500046, -0.20562172431630577, 0.2433778570267586, -0.42050342259722895, -0.03955669517871143, 0.04700840326510352, -0.14856569827006177, -0.4917816207425517, 0.34484222717279883, 0.031474278801045266, -0.17362747594027125, -0.12202314572805348, 0.11741018773559636, -0.04837330231568942, 0.12858691721161883, -0.26336688349255566, 0.3231800874031033, -0.3300305567626978, -0.09503498033970016, 0.24230364547303915, -0.2572406811241114, -0.09507130516149795, -0.30712807388151725, -0.07264385363026661, -0.08913352190157973, -0.33057541215105274, -0.2902131238865367, 0.33562440519983805, -0.0774101983679752, 0.20713920837178654, -0.509716717120174, 0.10968237661731761, 0.13246148748952077, -0.24902651134516177, 0.18522623906906013, 0.11827681436474173, 0.006922207389417777, -0.1364441431739635, 0.37028340054481196, -0.11804997862976017, -0.18125504528645575, -0.41759068951542117, -0.2715584135318637, 0.44731884480538514, 0.08716425897738024, 0.18677213360822717},
    {0.21057301252246793, -0.2602142498147168, 0.2322498051263789, -0.05015983109777005, -0.29752652587164996, 0.14300960407953567, 0.18591349429030024, 0.27261774056615645, 0.11200192442589504, -0.3116836659637505, -0.07048154715511301, 0.09073285956845677, -0.28520409008667846, 0.08676029048187639, -0.2752195964988059, 0.2710988002571821, -0.27172035113548376, -0.09991944968674706, 0.09303320701235786, 0.08049769086117982, -0.322179110518128, 0.29913573472189725, -0.03654090888646844, -0.12545477496733393, 0.3206308133359222, -0.30389929943879385, -0.0872239465367702, 0.17985260490166272, 0.15828017305205377, 0.13471357633421688, 0.19881307581369603, -0.1012849321045043, 0.3370861858951565, 0.3831269143806718, -0.06657679396064968, -0.21042928929218532, 0.11846836271235958, 0.30616855196021087, -0.04617313633124452, -0.40414230751153135, 0.026661488061373702, -0.20980512167532137, 0.46231101695938653, -0.00037528471604074106, -0.04699003696118443, 0.14512591895315854, -0.22945139627772984, 0.17727286020286726, 0.09713894328771136, -0.08599214430834048, 0.1564426503608681, 0.11144632768375164, 0.06532474018884751, -0.27229174158291575, -0.14325669965303198, 0.12240675960472314, 0.5584838955617203, -0.04808188235955977, 0.1532673222770848, 0.19265716421881215, 0.0010082290643533955, 0.03757527628263621, 0.09635354820490595, -0.10115971601859201},
    {0.2980989555841381, 0.05995039160333814, -0.677071373188461, -0.8069005390353643, -0.4838174392550349, -0.22187394277904682, 0.2220487421749325, -0.3315732578604531, -0.3148926455140259, -0.5952131173477844, -0.7099393221119468, -0.8271046647635386, 0.5482129400357928, -0.6746301963447757, 0.24289497815032382, -0.8101922520053105, 0.2955320196204169, -0.565126962679375, 0.43768924053672076, -0.878260611445051, 0.012033388762891343, -0.21001624946410485, -0.29101953914705225, 0.36628278379143, 0.11562137466035004, 0.30114140262665084, -0.21761388908320603, -0.7175389222036397, -0.14603834387761733, -0.7029213441782134, -0.2429717380423772, -0.548474587112219, -0.4046555095119013, 0.4673258481498494, 0.3821137529752783, 0.10963874086861443, -0.3409986040783162, -0.8837733612462472, -0.6503262048952597, -0.7460702058941265, -0.3440406342479284, 0.016218714487660227, -0.36623525654000055, -0.3797511117473849, 0.2743088259061902, -0.7739897692989416, -0.8725708553677577, -0.6152182791261789, 0.29426415982235704, -0.7905306864185297, 0.11736190437562713, -0.5489716519856008, -0.8711213652437033, -0.6946263677072317, -0.8807783394368439, -0.4364298535901971, -0.3154389903851694, -0.6817636305186292, 0.4828767278752956, -0.7325090902969277, -0.6143183916883539, -0.24235566200691527, -0.74382809541636, -0.8529877202809709},
    {0.5835500771314449, 0.20706602136368843, -0.7481663593691512, -0.6889347079936593, -0.6209248725614818, 0.24705661883321778, 0.03379537817332823, 0.37012148751793555, -0.28128302662181115, -0.3210558652139722, -0.5912473016610981, -0.886699895661684, 0.7134027776186807, -0.5678293437149013, 0.4765647994079593, -0.5427745499129729, 0.1712427043178238, -0.6759409357461089, 0.21841219063033482, -0.9324775093482255, 0.306953950957136, -0.20983723488576916, 0.021787371511501827, 0.18042302781500738, 0.3914532768547957, 0.22694174576641807, -0.1757470468389658, -0.5491735970782597, -0.48118655317138653, 0.09507902886027829, -0.029140327277225684, -0.4534721462850701, -0.5464615161369976, 0.4620440357410232, 0.45316798204328174, 0.36685695404078944, -0.6412218239828473, -0.7183927747920645, -0.5168507040681241, -0.3921900777723542, -0.5940049135075588, -0.35367973990335916, -0.48967386750768815, -0.696842619990003, 0.5541421677222741, -0.9351924040372974, -0.7852778032450943, -0.211628004420979, 0.48269248014993016, -0.8464948975591647, 0.39854987170517586, -0.7731990744000306, -0.5796254281271955, -0.7048405471619263, -0.6077905391578444, -0.7124778343525371, -0.6610119395698731, -0.8212341124059657, 0.3744876518808054, -0.8098615153592547, -0.5543844599775177, -0.5677315398792914, -0.10709225931089902, -0.8846851619859457},
    {0.20466039110424367, -0.09086476122035689, -0.2555219737665809, -0.46407215600234863, -0.6889223507286314, -0.3967899385990291, -0.11530830349132694, 0.16410318393404238, -0.14658123803367545, 0.17245477811482457, -0.05298054250592551, 0.026583296966791983, 0.5292810354741593, -0.598399978836375, 0.044574558230693465, -0.16282397879260055, -0.17637961267435173, -0.6039767915132243, 0.08883762975001822, -0.2362544476944381, -0.46304601961877406, -0.48984090252324225, -0.5204419822865052, -0.09167282763622539, 0.41180340653933833, -0.528252590754363, 0.21473550349221412, 0.14662286359394255, 0.07262077100221963, -0.3684561161372195, 0.07207069620252395, -0.8039929229140396, 0.16120264986156396, 0.07780756424980372, 0.301609910261013, -0.45761891982100367, -0.14652322621465047, -0.5713317098127519, -0.3348880210440864, -0.21169316374059527, 0.02247988191916284, 0.30120048950570344, -0.2889574242688637, -0.37967358606684776, 0.4471612383835798, -0.27686975342957654, -0.561260194802997, -0.4832140604808875, -0.08051665449676536, -0.6562840775979245, 0.20982365258854394, -0.4957744623687811, -0.3489329190303531, -0.6147637633643629, -0.6698432742214362, -0.29543375526279203, -0.15508778326422087, -0.5304390798132453, 0.0169554972453533, -0.2728805844849866, -0.2912813681024651, -0.2983836857919784, -0.22139119572934393, -0.34120359523883087},
    {0.5335793119720416, 0.17118122778481104, -0.37814239941067734, -0.2520903888170244, -0.5578688336300531, -0.04016588095734493, -0.340746239051221, 0.30052843960893993, 0.5274890557545964, 0.28838664098936184, -0.0714701618246812, 0.15017318856874814, 0.01982050346822442, -0.2973860065822739, 0.1935439762433849, -0.19381823471889414, 0.0404353742933246, 0.019690444323438326, 0.10719138660929393, -0.15235696923123343, -0.13530486183234738, -0.4448717480739115, -0.43475664520312596, 0.4938139577713374, 0.26883611629801424, 0.17848090684630788, 0.5644195825697039, -0.30042349422807574, 0.0380411883392784, -0.5723419752410466, 0.07914105043091825, -0.15612400529083612, 0.39243040517360256, 0.10745439111976954, 0.4255032959592199, -0.22772929228682076, -0.5179575412514164, -0.1858280123291899, -0.3916551526073687, 0.23534146597053163, 0.3071039183747391, -0.33281575573285155, 0.21364445105016966, -0.08543521305499648, 0.0739776521985139, -0.7001334792084347, -0.31431883049785336, -0.510033975404438, 0.3344270982580461, -0.315267718674004, 0.11941352476418389, -0.34281186252832513, -0.15421758187305454, -0.5239837541062766, -0.06154952474191708, 0.10480310324988565, 0.07169674251766092, -0.4523680930836429, -0.14368126583380422, -0.11935088739839354, -0.3113206821013007, -0.1239280767964091, -0.32541282142760114, 0.34629556664906663},
    {0.6171711659523963, 0.41916382178179934, 0.12119379555538437, -0.42698112340305666, -0.27908525687625885, -0.4928211845263682, 0.12576589719986078, 0.41260308305639204, 0.5945507890103251, 0.14219102146095317, -0.38522923690901395, 0.1484547650412699, 0.3814481106422766, -0.41420986108991015, 0.5313979453825549, -0.32597733179637356, 0.3310589523221047, -0.38383753639942514, 0.38550382054693366, -0.2794304744520744, 0.13057980202814795, -0.11134711921957298, -0.11505959055986498, 0.16289713975089198, 0.519445409227123, 0.41931874334558283, 0.17391336066513768, -0.1890505274166693, -0.1373344098075238, -0.5552888995784084, -0.3662893967706082, -0.6788189504683683, -0.41878255970173806, 0.26692305884362394, 0.45662666794851814, -0.3949037503488477, 0.2737238654323833, -0.34548031672482615, -0.4195064126798887, -5.744331862247179e-05, 0.2498789577108622, -0.035908171712140204, 0.360145688481772, 0.36073680572120664, 0.023551931421690604, -0.5860672718844177, -0.6326262093727915, -0.2416176972165939, 0.13633641789399292, -0.45088988048523965, 0.2527481662150075, 0.40263905930658406, -0.29716846551232257, -0.03333908930613404, -0.4668832535568423, 0.369446053061475, -0.2631626181924983, 0.0195556033757005, 0.25347499886533753, -0.3130216439657079, -0.2848105647144551, 0.37583180649291004, 0.12257545386138725, -0.3541421337184717},
    {0.6810193127513429, 0.36534050758680864, -0.6315998142554209, -0.1758647467433593, -0.20826906718992674, -0.19734738101331506, -0.4417067302709488, -0.3455501360572198, 0.057916101949710745, 0.2599245317058835, 0.024084562458167515, -0.46954992397183765, 0.565769284692402, -0.3457952182375058, -0.04488761837968199, -0.35149527666630115, 0.16793659287180926, -0.5380171391121423, 0.13934198710086307, -0.230609949592753, -0.1406398464130077, -0.2917250181559644, -0.30894426756532845, 0.3659506710035372, 0.43504454209280313, 0.06355660242602378, 0.34747646950130356, 0.10576014166811795, -0.10361040134801677, -0.28502873046927507, -0.002425725789761901, -0.16413092935793355, 0.05856734288403617, 0.3794762366896654, 0.2303506901456219, 0.18989835765738736, 0.22509718550071006, -0.14989493049006405, -0.6456707169063868, 0.008749086144469856, -0.36246553465016246, -0.00043290214692225234, 0.12449964883275152, -0.5154503713929623, 0.6340573800662298, -0.30702417216167394, -0.3790297409543233, -0.5428476271527175, 0.11910917670510468, -0.22509848192040782, -0.10771872474458644, 0.13087814317810376, -0.28638752887819313, -0.15847228948980496, -0.3599957057250207, -0.002668613421492932, -0.2598514081249117, -0.3752670592207747, 0.0011061234861729319, -0.23206277684165807, -0.21189833970371041, 0.021868237131707637, -0.18950620538538404, 0.0010283362311648606},
    {0.35770903256885295, 0.34130060754096664, -0.41783503623538176, 0.01733292505348151, -0.4995602747380593, 0.2547805995612836, 0.10456115026773327, 0.2463251192600507, -0.33692813147523365, -0.5653527107628358, 0.15259282180430297, -0.05554443388607152, -0.060554073695005727, 0.33002433411508664, 0.2799126173076105, 0.25976280598387724, 0.4906083060735523, 0.035644336212032945, 0.19030986660371266, -0.3327567479695262, -0.3534946029578475, -0.05566240417508691, 0.3217777375152866, 0.5899828674707609, 0.4908756003720314, -0.15845494338434205, 0.4651028724154738, 0.46593440702729955, -0.12993542224442517, -0.49343369483546995, 0.2367085042412614, -0.4907596172424624, -0.16682752317337732, 0.1159227512443624, 0.5307928417971804, -0.09454702808964073, -0.42714143079150374, -0.48628963658610136, 0.1655461227453164, -0.0571087460416321, -0.145234625309059, 0.0035188956601064285, 0.33897017575554916, -0.19606790001229102, 0.023310576262896614, 0.1245761371918704, 0.07920885776965544, -0.19186819667244456, 0.6231826122565262, -0.4458336390785555, 0.4720011268159176, -0.20116288351968467, -0.5620661003998626, -0.17580303893024637, -0.5022709121785902, 0.33468210864306014, -0.03969270452737941, -0.29793237299654646, -0.09327027120870661, -0.2729094221944908, -0.4048989285068069, -0.4476719641180263, -0.13916210814949037, 0.21467176808287536},
    {0.606074408084578, 0.1943442665901308, 0.03570948827900561, -0.630831213926397, -0.3609481545836274, -0.17569744967115045, -0.0989707976685657, 0.5948878735576341, -0.11652680495194605, -0.004730760259999813, -0.149782450371016, -0.08695627560819401, 0.6687639420825184, -0.0139397684605993, 0.11705773735991333, -0.08921973909819435, 0.5753413424034401, -0.5670282964649199, 0.2982723377153845, -0.4342937356453216, 0.09784238208906523, 0.2630049714548443, -0.21096881950650692, 0.45487016878473224, 0.5156151833946174, -0.2390344358842283, -0.027465485728462673, 0.20562088557069524, 0.11800334467615255, 0.4905948216068287, 0.042007306448552814, 0.10221486611743298, 0.04656164586789468, 0.13247027598246855, -0.019616536605768918, 0.4039809865776794, -0.2190030683454515, -0.07251765968247975, 0.09827563257395547, -0.22059732359551684, -0.518805679416637, -0.002816453951471688, 0.5746859469402185, -0.4724841916183157, 0.23485568168185145, -0.639158992997878, -0.4479811778069206, 0.17737401959205082, 0.5573001218759409, 0.21915745931655625, 0.2053203134808425, -0.006436118512247352, -0.410487940442618, -0.2618553222861937, -0.4088986521276223, 0.19090837423116844, 0.12349487960635719, 0.07631085449028481, 0.2181800575614449, -0.15776845953832452, 0.0022815805119864663, 0.18921269395135723, 0.09887385485673748, 0.14844883876376916},
    {-0.06249056947456974, 0.20673300306667755, -0.021736356679043983, -0.4368639695659392, -0.5097000505936662, -0.15811391558649548, 0.2894830188538556, 0.19856928099181506, 0.05133760422280219, 0.15773146104604785, -0.4934806659631999, -0.4962663767663967, 0.35289587769835806, -0.5696895230595358, 0.10990331538157548, -0.3666876401737548, 0.18936038170107936, -0.6534604191762683, 0.24318826975274188, -0.3664351564654739, 0.07457976423310422, -0.04130767885316439, 0.195869072141906, 0.14403704287623625, 0.4332954010999154, -0.16076539611517415, 0.12195523896662405, -0.08608036126379719, -0.4613997190756614, 0.1707634640480907, 0.22411006702400457, -0.198170520039033, 0.24839161829410988, 0.2003791751501744, 0.17131961571451243, 0.1282595752113689, -0.5014748001876145, -0.2337788878256538, -0.12154106772951473, -0.28036361490572653, -0.23721752966505852, 0.4614347073227521, 0.3830794680242314, -0.17299918692354452, 0.29104145134925447, -0.14885422700971873, -0.42430649325492514, -0.5006696701728239, 0.46147557920186155, 0.1529105043483064, 0.3026006812907629, -0.35588270829641777, -0.7019634204803311, -0.3168311635250183, -0.46934931662752943, -0.3054979545734406, -0.07557626706990485, -0.1703923837261928, 0.5901070931151186, -0.31673471756941507, -0.5933021351230162, 0.013638280658951491, -0.5284751547287238, -0.05301929733481967},
    {0.39260920791690246, 0.3036011268403427, 0.3096786225917678, 0.5414274297263306, 0.0511790090193804, 0.28272005558021773, -0.1301060483216231, 0.4321259828843311, 0.5076850025568014, -0.17843444315947213, -0.4140407987112922, -0.28183525437485113, 0.2483370547995547, -0.3758681162487249, -0.03417452594600315, -0.32397626615572017, -0.39099037627034894, -0.23522857580594755, -0.2576729083842529, -0.23043982544990982, -0.3192787191286682, 0.14844534640541188, -0.19315722728391826, -0.23609354158330248, 0.17559948683613574, -0.6233517280839169, 0.29022405429813697, -0.31250622081988394, 0.3653055717768664, -0.06820944326898583, -0.2157422557071227, -0.04774314079205669, 0.12716556791190284, -0.11491594604447045, 0.11234149272573578, -0.5558225342366119, -0.5344053993038266, 0.14819961395275597, 0.33101838524513333, -0.36978767480266306, 0.09260931221768864, -0.3179165156814208, 0.13419672640471803, -0.05675327098716736, -0.201190074759571, -0.5102749887995242, 0.05336569227753114, -0.26297487798781016, -0.2505635117218467, 0.11165269287872256, -0.24723274484374758, -0.3154475251287713, -0.40218487756197463, -0.10327722124382263, -0.15252162783577675, 0.15350918347569625, 0.0072598627954351454, -0.141024635837711, -0.25448497784622026, -0.11430917058750079, -0.23077955311567092, 0.24374765722294645, -0.19040893302124673, -0.25974697965387056},
    {0.07588535564242965, 0.22038293457599628, 0.07167898378639982, -0.08409714649710705, -0.4360542168924767, 0.43015721250761413, -0.12281760827479332, 0.12125632461057197, 0.24918695016990053, 0.06152688602328514, -0.12757945562111028, -0.2183013132869919, 0.22770083100669583, -0.3117822245310146, -0.24417029833415665, 0.08671729571284041, -0.39178975163717106, -0.21249163243748664, -0.026675842582592073, 0.08840924198323641, 0.4341678523085597, -0.3434009103076422, 0.02159282862490177, 0.17535711852162336, -0.4541301245891707, -0.20298638955473244, 0.35134792543613247, -0.12969325249663047, -0.15241928440977562, 0.07603834103335141, -0.6365496833685449, -0.1613631169449637, -0.24978591446187218, 0.15025570548944647, 0.17084149310106736, 0.4627992014943091, 0.050520697974596365, 0.2937661074082642, 0.04443855976473864, -0.16126600636419997, -0.014758320872276064, 0.2154392891718373, -0.07376646370512982, 0.05843385749979841, 0.504823012565871, -0.22869210245151853, -0.41357966855971895, -0.5787342515998618, -0.05379698829218201, -0.08023302641483938, 0.2635428905163165, 0.3381678809179338, -0.4775970298614138, -0.32370899979994094, 0.06636537277716455, 0.42726498023107023, -0.3817732058533965, -0.08588807082339019, 0.36236949455188816, 0.01715864486943564, -0.24180842783983075, 0.03210156531356468, -0.03845572091186006, 0.22077005941825067},
    {0.6082487599762546, 0.46603021308009246, -0.29821931441868976, 0.01725766008845997, 0.33295084806237846, 0.29389800939912597, 0.12576218181895252, 0.28632709281788254, 0.293990391532668, 0.07344567296492734, 0.29756696342920436, 0.5303953094068399, -0.20020969773579403, -0.044216250116031475, 0.18574281973175194, 0.12521165553835095, 0.07789569902879014, -0.20071656430050278, -0.46189589913739343, -0.04162939536365651, 0.05702096898477032, 0.3454340537965177, 0.4564972190723525, 0.6263006977584242, -0.17245902122528753, -0.031462528384306014, 0.052977793205115066, -0.0041736057890035295, 0.42050057458879225, -0.43604118041973927, 0.21519905542751652, -0.07343407565681295, -0.10422193679965794, 0.22316450502429358, 0.24118858499614174, -0.22308970761369165, 0.5601687104286295, 0.42779004611564997, -0.1390244303630199, 0.39324796107343885, 0.22499979802336587, -0.13440637140180592, 0.06316396043166908, 0.341201935645633, 0.514086078066394, 0.24105773061006458, -0.43188244312888957, 0.16227566715328537, -0.2343410465454942, 0.36899751574124456, -0.06073893347269994, 0.21266445337493334, -0.26424451374893587, -0.19253851768685945, 0.11936454543662753, -0.062165261301681755, -0.059283369494688175, -0.2610673132916327, 0.4372213346365595, -0.13924581613066345, -0.27547856786485114, 0.24096323595194058, -0.12400344814953891, -0.341878790456855},
    {0.4899672110730616, -0.029993099606609747, 0.11017400897219184, -0.024479457565570194, -0.5385953927578381, 0.11031769677439433, 0.026269100760074774, 0.29091169104968684, -0.4478764460565917, -0.3779507760176688, -0.5645370591851402, -0.40966991762959337, 0.5104550776047777, -0.6785241292259176, -0.01874104268167693, -0.05938550783501086, 0.4109133462405867, -0.612482225042633, 0.1728400814792519, 0.007898032889594436, 0.19483470179815954, -0.04007096320065305, -0.00036186132518230784, 0.49721044211033855, 0.22508030167201878, -0.22640411359374168, -0.08162303427635312, 0.2501552657022673, -0.2081715766167447, 0.11611144241119543, -0.5299393039688058, 0.14521808620679058, 0.13153298755882162, 0.43561122231094646, 0.5984034768356256, -0.043723438915132654, -0.24999540006007043, -0.5368164518707584, 0.23535202198964886, -0.21129506204745316, -0.5461027722199262, 0.6152341365397568, 0.5157517062611823, -0.17289373160464924, 0.39380352506123373, -0.4399472773573722, -0.2702671931179341, -0.2087551086294957, 0.33970074189476507, 0.48545907640553576, 0.013552078806628613, -0.48746826181746306, 0.08491014466806537, -0.5207866267908697, -0.39486978401372, -0.6271872027479667, -0.10479750808881932, 0.16248499950085007, 0.5168147278180796, -0.29867860381616446, -0.14023144000038473, 0.27329824774231026, 0.014904147700665572, -0.178457151448697},
    {-0.23610699785987632, -0.2655256405801727, 0.04075381176857273, -0.3453253506720533, 0.15706831982198272, -0.1982982031583695, -0.0514279218538121, -0.02555166535244681, 0.18498363059906672, 0.016178161549946852, 0.030546204731304767, -0.08588640939165423, 0.3280186680398905, -0.1126088549317254, -0.2637218567310722, -0.38013220313029894, -0.075120218139279, 0.18119804397264166, 0.011144043602401038, -0.496259807150375, -0.2246169750672955, -0.06995554513188074, -0.13294947187233197, 0.3993933949602282, 0.16297459794867514, 0.01606238341101647, -0.3006639815454899, -0.48207141290488664, 0.3581666922435257, -0.37515467632591826, 0.029932218312493052, -0.323436854872875, -0.11494684947290622, 0.25137545521000193, 0.4164152494844933, -0.3921872182121581, -0.4300215239371302, -0.5679110539857732, -0.04927766835777138, -0.567971159777924, -0.09493565363091605, -0.05929242990342531, 0.22109528155066288, 0.40194652985998913, -0.010889970492881209, 0.2317317658943394, -0.17518976664697522, -0.19482906439856285, -0.4076925254002832, -0.0907926985608793, 0.37876462004456113, -0.22337090652391398, -0.5103973463470555, -0.4252265971944392, -0.08137057361179152, -0.17739215811655765, -0.4369717498071449, 0.11575845724007873, 0.33496013957107046, 0.021273125000498057, -0.41140693624991564, 0.3556482313289984, -0.3937579232284375, -0.07059098338865262},
    {-0.12045260513016784, -0.4909397118454571, -0.4865432771462755, 0.19099783755056232, 0.21941042489666762, -0.49507563570320784, -0.18582711826411705, 0.18945783092482896, -0.2376716718885717, 0.25352864601424135, 0.1032439044015438, 0.4194226473408591, 0.4581971667016842, 0.14031893312635976, 0.19821719770723642, 0.24025146185474974, 0.22540056287743154, 0.22354185828582535, 0.33771077611729866, -0.37781001094418504, -0.2282901937109213, 0.10439115973247831, -0.04913318003441377, 0.4421687362475953, 0.2745649992175652, 0.019034757548446083, -0.3343674815112691, 0.13262640831734324, -0.27175227637680927, 0.488993553775109, -0.14781127899943602, 0.042679280589883524, 0.05283300003517088, 0.46907479883632736, 0.022347709618846242, 0.40964504509688554, 0.14066347768327664, -0.5596283448834407, -0.218337492880472, -0.4548711410219594, -0.25255588964687575, -0.2209941717577656, -0.2763474430860824, 0.14160660595122257, -0.1741224656191266, -0.18728136203701026, 0.25039203354813216, -0.3647559270047755, -0.12267560736632718, 0.1290372584822594, -0.3134072003546858, 0.051396806180813784, -0.47921310617048535, 0.02181729127880748, -0.33225078718618495, -0.21511959499864633, 0.08765173205875848, -0.23778472389492664, 0.3216005973802133, -0.007284129247413444, 0.25940028082598565, 0.020195299391385143, 0.32226387424648306, 0.2793704366259737},
    {-0.1145409264105864, -0.5757056410754542, -0.22477141413671795, -0.4692098288523922, -0.19715111314750777, 0.5237359002980083, -0.16772112733652103, 0.020539896961348843, 0.09985485284699752, -0.5332916483454087, -0.5536613529764347, -0.36360682016294466, 0.12941459233847444, -0.44927402581216663, 0.33941734304645793, -0.5761083490305831, 0.1986646058567768, -0.6843640568186306, 0.25248005782960764, -0.6491950108218761, -0.1362227217548896, 0.4519558335829439, 0.06232654363309151, 0.5046276715009995, -0.3630583587070252, -0.12559258281242952, -0.11215963281680481, -0.3106312942552728, -0.12005885073086375, 0.06182529683901705, 0.11992728190644689, -0.02253546689793677, 0.3303575447909731, 0.11070971075391924, 0.250624612399368, 0.37260157117124854, -0.3504803816365782, -0.20346577494808563, -0.36807380207352686, -0.6369934733065654, -0.05629849015057068, -0.3894953533757688, 0.23837587938450255, 0.32632581537105915, 0.4590199240499161, -0.029553933426590046, -0.411605563890891, -0.1780318513848218, -0.23059055886150467, -0.2430220278138944, -0.3824502085993514, -0.3888861267862708, -0.298375728483594, 0.1607119609815834, -0.3745012359910297, -0.19847944901757142, 0.155027539254087, -0.04956034628674538, -0.08833550442634891, -0.2977307916940048, 0.13552856787900336, 0.334953495483572, 0.17942755146595168, 0.10467600298979692},
    {-0.31535648809480604, -0.34210438056874043, -0.3676841574523904, -0.13354631972294712, -0.38080305367690803, 0.14686339623672381, -0.3284532848938515, 0.3102768070051968, 0.3250910219010297, 0.17186401633685686, 0.16764116459263279, -0.2878051167449578, 0.47856312514326077, -0.1022058943904712, -0.04165068429146858, -0.49992787471336647, -0.05598591804486182, -0.5283608567956415, -0.05385990636256601, -0.4605190220399002, 0.19651792568950552, 0.30564976976346775, -0.2981126916619714, -0.4255912625067452, 0.29637232205550823, -0.5509527721082728, 0.08375049749260348, 0.32807794530370027, 0.3250235924963698, -0.206003611190396, -0.46519920877133414, -0.39028314025440536, -0.26715961614078265, -0.1658842304201714, 0.219583682800253, 0.4489558924935116, 0.23166079268307488, 0.4655892714729506, -0.3969628401613723, -0.4959618334169682, -0.4655870325502362, -0.0876903622394839, -0.21223174542280682, 0.3231355994233609, 0.4898183496310972, -0.08951186133189938, -0.1356841949013919, -0.038191925630233395, -0.04712944294990717, 0.15025535548274446, -0.12599959620444115, -0.0689363161119614, 0.08101638060714629, 0.10503360603169415, 0.12885234813148688, -0.014567545358183984, -0.6463685341202783, -0.06581231444028808, -0.26385393397083856, -0.6531112152442365, -0.2743331345973764, -0.3054622073207812, -0.22389426220701597, -0.5043741406843483},
    {-0.44023632029593, -0.2163777807321054, 0.3400600366822051, 0.4286970199192705, -0.1759746243531557, 0.015034468110637604, 0.18728387773291416, -0.21560905714629378, -0.06389375120385077, 0.10664066321850826, -0.44900752631235946, 0.26359198213903756, 0.3167633868296791, -0.17015834024317164, -0.36543070664916405, -0.006430835566407857, -0.43017420226453956, 0.0020367713875258098, -0.31139289689375954, -0.36851149007937267, 0.1672869303326201, -0.27885754906916593, -0.5610287220124147, 0.5917923778297841, -0.41627900538518625, -0.046722389190053656, -0.18637069081743077, 0.3461564508768574, -0.10849119643596453, -0.4328413556127504, 0.10547098129218534, -0.2827059286491901, -0.112962579982477, 0.39531621024479335, 0.007912748905013036, -0.3624342125637329, -0.4074059844426297, -0.15628514426424125, -0.22151254254341246, 0.24757035255127977, 0.2640167549506283, -0.19185635107515903, -0.6865986206386882, 0.22362364635961593, 0.17566934102181858, -0.1106203701393424, -0.3370384990159225, 0.12179272748647434, 0.3156456910632625, -0.2178787454403176, 0.06772127177900703, -0.3593091495867753, -0.47317586426393854, 0.032331931131339836, -0.28319050972242693, 0.2262954747039516, 0.01965708686746727, -0.41081461304465905, -0.2532784410941425, -0.2791796644449969, -0.14031969572361938, 0.12950991548683963, -0.21325603295789006, 0.4335119540807826},
    {0.5297962773491324, -0.3901939411841652, -0.05413648244660496, -0.05368591074449603, -0.03306951745349016, 0.08393838795111008, 0.006122563199707031, 0.12373964303293643, -0.2354485758346805, 0.22742625257749335, 0.1156205664891495, 0.022337578637786744, 0.10693093076171221, -0.03629729654156489, 0.04976277856677525, 0.08045517604074731, 0.10465465738454012, 0.15892829562870062, -0.3095265296773665, -0.021299625488050408, 0.011211123766018448, -0.18782112345049023, -0.28968431572562087, 0.41425426267431753, -0.28449859091629276, 0.1413626077111908, 0.2456860938049807, -0.21315646201208302, 0.11487722624067537, -0.21386613004359878, 0.2777462313135215, -0.24582589254043027, 0.39126277053052644, 0.2953321464993362, 0.5323637544728396, 0.2106639851293186, 0.16067848572645235, -0.0994037841764215, -0.3613959768967559, -0.21467813677802933, -0.14511522527331341, 0.015471272026875718, -0.022899134781705285, -0.22443447366093697, 0.12560095170836372, -0.3848125961800116, -0.022236833761951756, -0.39415901997023484, -0.5297566884052218, -0.15516816332823682, 0.042261220354425616, -0.08404172181856, -0.3283325471814957, -0.32449810770543547, -0.2077440550145107, -0.06286099893897126, 0.0047946384223318955, 0.05691700928585404, -0.036084548139089394, -0.04836247118712663, -0.5564077106036812, 0.2046406399726121, 0.1184713887246924, -0.34825475260750577},
    {-0.09764895908235076, -0.5085089822867659, -0.3317041384634893, -0.014986405957570526, -0.5279990877120351, -0.13860156161672027, -0.41144888935657714, 0.18019535940445267, -0.015598933646619816, 0.3760672766608191, -0.25320046598269186, -0.2196325968396954, -0.342295004161918, -0.2217548648001854, -0.5726846243664426, -0.1899753705693419, -0.5553679178144815, -0.0014554927451457744, -0.22910530401170495, 0.021088599314399152, 0.05256461645553305, -0.44897829851181, -0.20222382196097502, -0.16833721579317976, -0.14462730856182593, 0.2050491549322815, 0.4382807198544286, 0.004364319292365748, 0.18361184720603047, 0.40479249478508034, 0.2786535627342664, -0.18208182759386823, 0.2761128538944877, 0.5027640706691138, 0.3271967813381743, -0.4687914249064716, 0.21588452207543085, 0.39700641949839516, -0.405388652248833, 0.42596200268433176, -0.21314821246655324, -0.42987751825922366, -0.4653512671773918, 0.5040466779681988, -0.06674186924916271, -0.05557714403711921, 0.1973378145786935, 0.0782567589374142, 0.23422731740937197, 0.24378743379475945, 0.04494725688614058, 0.1331185751245426, 0.0029660536332815823, 0.34673536162019836, -0.1991298461279004, -0.0779850144669791, -0.14739155402700346, -0.5407563858982839, -0.4433136058385093, -0.31765407589358174, -0.3428126182437992, -0.10287873420284092, -0.4692409490349685, -0.04807907395856398},
    {-0.325506618070173, -0.3450606357772927, 0.011559711759580277, 0.23899697622331834, -0.4835657900948894, -0.34597089891360744, -0.4652518663944181, 0.14369930072317388, 0.4557955976683468, 0.5297639979206197, 0.07184907065300565, -0.03647013111766045, -0.34183510133827383, -0.49178820709060833, 0.014079443653143807, -0.6293803252499869, -0.4365186416387547, -0.3967865084839236, -0.36277103302097136, 0.028156680328402343, 0.2488434198717551, -0.032604269289110616, 0.10799253065137444, -0.11614069995641074, -0.23888010377154326, -0.05352269468411919, 0.49013362001496985, -0.12951120305442546, 0.10270959445754102, -0.43522013552371774, -0.11926972119611019, -0.14905305962953558, 0.5838116537738774, 0.24159394198784226, 0.37107536494658466, -0.28162300913225774, -0.06460669243552235, -0.04577425982425162, -0.13744751628847846, 0.3864160351012052, -0.5919203952914581, -0.2862709441717277, 0.18633892034478872, -0.10831023906095508, 0.25891319547260583, 0.4575454144139628, 0.30021824412837844, -0.2621998248426462, -0.12346484467777225, -0.023541137296235335, -0.23700741486268648, 0.40844663156513555, 0.0703957216846527, 0.3580023935360903, -0.025920886225750915, -0.056232682345121375, -0.3909578981513057, -0.5308562096625182, -0.3959892507852874, -0.20177073271112014, -0.320604849879914, 0.31448335512909564, 0.35473514673629575, 0.3110131206958361},
    {0.613182230756812, -0.31455580405861616, -0.38947528083737304, 0.5596911046190197, 0.24316331687919454, 0.1375606425714067, -0.19490563750286868, -0.12206387165126863, 0.05791598983004081, 0.06616927966363356, 0.11282061382146412, 0.11567728540414743, -0.13017580367129752, -0.3747072954381526, 0.07604628937885337, -0.20513633496365682, -0.6015027896348774, 0.3177621308016075, -0.3679707718389741, 0.3579300958076947, 0.5904891717530323, -0.4154189808731475, 0.0850995679473421, 0.19816514282319814, -0.020422022443107483, 0.20536148717505895, 0.39043837229589284, 0.005549124184751567, -0.10478398189184922, -0.07832638326298738, 0.044512134442336454, -0.42231310137699574, 0.5430933429330997, 0.3868141709711665, 0.5183111573062684, 0.3907084238516882, 0.4318709295513027, -0.4250059123401698, 0.1177308344223356, 0.5256204147391261, 0.041213596559810266, -0.17400827135532956, 0.1824044933793865, -0.09101811158766016, 0.440717008582988, -0.37529050717304685, 0.47728910909486905, 0.12375580249655746, -0.0834694179135792, -0.3796230520053353, -0.1493874927125822, -0.11794664096148913, -0.27673442601184284, 0.20250581507693366, -0.09601950457666343, 0.2657970813887701, -0.26402056976355165, -0.4421597621604461, 0.40074120079860714, -0.046557854823288086, -0.08441517623044324, 0.41775685798184525, 0.02561380534924179, 0.4442353973974382},
    {-0.1235940971577279, -0.13859191488018577, -0.24638563100044653, 0.193838035408946, -0.17248611659353408, -0.20473703142950817, 0.2507103388748945, 0.4791459764788319, -0.005356968286130502, -0.24635542193159587, -0.13170489665456472, -0.15219348127900323, -0.19099757534472242, -0.4368726419816445, 0.15932096729216505, -0.43530631946244913, -0.22088203977759197, -0.06604621391758643, -0.18283225538269607, 0.04751495129687219, -0.1738089817512428, -0.35920728990242995, 0.04240859208468618, 0.5544144142885062, 0.10178609755902061, 0.08638662219394824, 0.20787377946657118, -0.013860315959757475, -0.20361433475046237, -0.03176457868945654, 0.16640138060679047, -0.2043015281093845, 0.47739360245799417, 0.08722582340248493, 0.34859935987278035, -0.09401081731714898, -0.004874754812761312, -0.05575892955925984, 0.16170892688209187, 0.16916294231701842, -0.16925422067455595, -0.12949186339579344, -0.5569615935864392, 0.06274484925571833, 0.32203005187158473, -0.2379925851684021, -0.05578564480959039, 0.24704916300268343, 0.21914748870174497, -0.23952274636188703, 0.18845972842124276, -0.09866501778990965, -0.348305215729309, -0.07293286386469643, 0.16205381203498737, 0.16173682985890706, -0.3858220680016589, -0.08000999523053964, 0.3248601668900257, -0.29795427794358137, 0.23061702902137612, 0.40962749891118055, -0.3934457341779887, -0.4500969070947209},
    {-0.3328857710571172, -0.3048596552376662, -0.01819665847126051, -0.12866833149671852, -0.5325896011171359, 0.5684905440448718, -0.45029534408631117, 0.33565767815436814, 0.2142571787635158, -0.13248654602250443, -0.05917352292460668, 0.059064672500591595, -0.18713370099894477, 0.23580808965214972, -0.021259355561026233, -0.15474293994676647, -0.37221612918775704, -0.09356681333397408, 0.09286533009588846, 0.3714985055215744, 0.21469085935452334, -0.3314831649628337, 0.43391937905223693, -0.33002579200251975, 0.3744487485646105, -0.5060824906941324, 0.21420354875909067, 0.2699804673319943, -0.502744230107687, 0.3119081037973349, 0.28038234314386196, 0.33768118557238047, 0.16625658105587315, 0.309339424887797, 0.06899319707715909, -0.09787016316089917, 0.12450357210926964, 0.17500240018588817, -0.21626106220788277, 0.12573032191866926, -0.5198019950463497, -0.20013893128297244, 0.39771494091650333, -0.46034045731727313, -0.5390768677329442, -0.06357476777668614, -0.2543420398604642, -0.09063037901324643, -0.0909951987841564, 0.4685676857193045, 0.07323214332632709, 0.34530308046996644, -0.11361958822871876, -0.20941805628818713, -0.19674452183032265, 0.12563244149198777, 0.0845019629069117, -0.052928853834310965, 0.3661692278752106, -0.14759698895211448, -0.04655874224181884, -0.1644237413064572, -0.1544706406876578, -0.01816144366531074},
    {-0.3356641962370491, -0.39997507105173685, -0.057121244847606084, -0.22090676296172745, 0.018607791826122693, 0.4640096968154432, -0.4287754108544912, 0.3409098085684831, -0.5215607589564127, -0.0037695100646639276, -0.14269926760594562, -0.16758768990080325, 0.5129410819948051, 0.1676111881065693, -0.10567672669295597, -0.48784496340915784, -0.033148685397163834, -0.12794940828462004, -0.26993121841795364, 0.24348412781867068, 0.44694849848389484, 0.1435533858482377, 0.26333170794509525, -0.3681919769286166, 0.4653220297424367, -0.4807123893511894, -0.12241766287528502, -0.5185363177800807, -0.32657798430922114, 0.25309365707923187, -0.1458703268371599, 0.24041498482320908, -0.350780190122142, 0.1297015750729976, 0.04922804896429224, -0.2836145536412077, 0.13767940727260522, -0.05746723394162719, 0.10965080353699008, 0.25106521319249986, -0.4210982000435737, 0.0794016785302552, -0.10154695039363168, -0.1947837111895932, -0.3972476251134393, 0.03419899283520663, -0.5047468012792312, 0.24912455423367774, 0.0679155955274772, -0.3694158146739083, 0.38235927380637036, -0.43207222698398634, -0.20253269051516115, -0.03608370728425885, -0.13742428292465186, 0.21818186108785187, -0.13918736574644228, -0.3609376253082497, 0.2028488900231549, -0.4559385526226525, 0.26748931237340523, -0.5439669572787237, 0.3489779954858121, 0.05866798268686246},
    {-0.11940396614354545, -0.06242241617843589, -0.42995614357538436, 0.15343577509314818, -0.12349902504169011, 0.3132383322217296, 0.1595926858012761, 0.27881399048917876, 0.2070524378981986, 0.2528820344497123, -0.2340054107513869, 0.2583918733425061, 0.4743321616403457, -0.4553953944311223, -0.22546478818851684, -0.387868593544707, 0.322054315425219, -0.2791757374116449, 0.47293278319806703, -0.4966709982146096, 0.0554740163047751, -0.2187081327838914, -0.392526866713124, 0.2240310069336313, -0.15497028121392123, -0.38628298294433594, 0.22751440849515134, 0.32853254713611113, 0.045039421787274415, 0.3148566102090929, -0.5705490091059163, 0.015403435762082075, 0.1011882687850282, 0.1451928254564581, 0.4146519225526344, 0.1678045372327667, 0.2613796871934631, 0.25371062409411527, -0.13831794554828605, -0.2540037754948965, -0.6034465387448786, 0.07855488415481636, -0.05808428322019217, 0.028625600535052288, 0.41019455507489405, -0.3239169744000477, -0.17207344117572929, -0.5516941449629711, 0.11684804152914935, -0.39476298284193045, -0.15690050836494224, -0.4362558184334529, -0.28254195133723864, -0.12362715373446245, -0.08522879959089281, -0.11477015062096177, -0.02621018213592713, -0.34967673479498823, 0.08084234266768535, 0.1232531478570486, -0.40615551662137767, -0.28663832710543824, 0.36168487558072654, -0.004086174604790343},
    {-0.03950253704256932, 0.4479936975076302, -0.3502541478097753, 0.13574145629979548, -0.4988770811031477, 0.4960596864304051, -0.4728474109608978, -0.24321614390277346, -0.3733861429903123, -0.04280322686372242, -0.15980133877246303, 0.04406038121589983, 0.6524371525621847, -0.09956491208505029, 0.1777417415562719, 0.18734641501711766, 0.37634082340791747, -0.08268311534060784, 0.46490038640833964, -0.32612851111166874, 0.18826991651255098, -0.17911598558362565, 0.12548472789117832, 0.21479362087360776, 0.3967084422149946, -0.355064474623294, 0.014906493017819872, 0.09519823069620406, -0.41350586317100996, -0.2780590968378792, 0.09847685008915057, 0.24799942508769754, -0.32006364370684237, 0.5351661752590189, 0.2564135421552712, 0.5370064777641631, -0.1486748811064205, 0.05209534269252393, -0.4827709143744157, 0.12027564273086631, -0.06090523407711981, -0.43189406422516924, 0.27103324529518663, -0.13181133501859266, 0.19331284905079196, -0.09456011116458074, -0.044720560885231166, -0.24304112031191363, 0.16319924122641902, -0.390409768171295, -0.022660703082035404, -0.2705162911011381, -0.24631164431731878, -0.4711180110738325, 0.06196527260196941, -0.283267006953872, -0.4161477169290573, -0.475959480265366, 0.011193231432467863, 0.23453273508260028, 0.014426325644760277, -0.2075276266136391, 0.250213046224428, -0.5562417856593944},
    {-0.11411753312244262, 0.2112279930560954, 0.05418878535729997, -0.4862170390022898, -0.11771382429869412, 0.46028876900831506, 0.06318905049332421, 0.18381866864986393, -0.27223763600987094, 0.2329223708300696, 0.022257483073342892, -0.3295767222004392, 0.36365743406191436, -0.1976277739434929, 0.5049907033020736, -0.42826289055346767, -0.04262387029580306, -0.21947758842382514, 0.15791700290276917, -0.12804757662488825, 0.14991112853894775, 0.022149043302289086, 0.5716594279182714, -0.09339629808814905, 0.37905666783794434, 0.2346058791530528, 0.09312968000907898, 0.17643226699983852, -0.5547879453459882, -0.2549469903576681, 0.38582242571682956, -0.5207064605015311, 0.1905589734955638, 0.013460283611622883, 0.2497619479160073, -0.15795744747376214, 0.07912665204506782, -0.36482900561300957, -0.2815759588503983, 0.47385419642413384, -0.5819769092594494, -0.20200879142892744, 0.42057595300342754, 0.06564507996347968, 0.45253056602211267, 0.09606019540088595, 0.2401627053562399, -0.07078831163781887, -0.3599900192466405, 0.04220828923223348, 0.17062059643623884, 0.13093718735697008, -0.060310640525676695, 0.15463036883783757, 0.05542837243299312, 0.29148172240992054, -0.5734132708465383, -0.40990813092100964, -0.20279250977438776, -0.23439482128057573, -0.4690098446471453, -0.6297220148607112, 0.33433047460630355, 0.14900512393943846},
    {0.0067034179953574195, 0.16649832077792356, 0.19235584061145594, -0.3922806627761477, 0.2503647242348434, -0.33664443981380887, 0.10714920230960356, 0.22169860855797224, 0.041849888304199896, 0.11973977455728824, -0.3280018655599928, 0.075160512182463, 0.42420745521054665, -0.38706212228125925, -0.20158367345372694, -0.020339003194636378, -0.2677978691717469, -0.2601711149069339, 0.46817399542266885, -0.44763613688898507, 0.4855643411404598, 0.26513834125005686, 0.07548825437594159, 0.2029759524975854, 0.12580449262905716, 0.4332918855605533, -0.47287748451543693, 0.5064209517721304, -0.29600844225778933, 0.37017700892091704, -0.18343994304579445, -0.04204787708981479, -0.12005788509308013, 0.35661584567449356, 0.14802986987346178, 0.3021105701953326, -0.1864070826194036, -0.23016934587396543, -0.2166045430744526, 0.09996404107109087, -0.3299030986609147, -0.37152855603542984, -0.37488057628376587, 0.28001426797082757, 0.5071099415606801, -0.0727347247960503, 0.21005781683188285, 0.20882461382911682, 0.38070817956783787, 0.4769763165345708, -0.24743328862333497, 0.2510545918972507, -0.4845615441429004, -0.3994461534379711, -0.12121232878837643, -0.047667643730344586, -0.191202188100632, 0.03488461090340892, 0.09413895002270115, 0.3764195245891803, 0.052867038086393814, -0.023296116034361995, -0.12294209570453343, -0.2620347214758056},
    {0.25799474400930555, -0.5403684110967691, -0.0013251366347403403, -0.08347822196661345, 0.04546344538119559, 0.05940154022097691, -0.11668932655108313, -0.34594075819575665, 0.1398001778270413, -0.36702022650484245, -0.30000595678732145, 0.0036892079916413588, -0.1597955864260657, -0.3993667684523433, 0.40525472622370473, 0.15499298179424106, -0.09522516907227285, 0.23141630325264265, -0.3330125661405874, 0.11200104012370721, 0.20111513507767306, -0.08193751640088466, 0.24765869000940294, 0.5986498890876243, 0.1016554456743148, 0.31139590968767605, -0.45642535288800073, 0.0010316472671550471, -0.4601377925686438, -0.20143081127972387, 0.4952429628647338, -0.04211390811554863, 0.28551999057888044, 0.27766417417029515, 0.3969763595205712, -0.15061417075714092, -0.30902464521441547, -0.35495482084401564, -0.011908030656730382, 0.06313774188460489, -0.46484573255500033, 0.373301102882856, -0.5593200866910726, -0.21028624838895307, -0.2860455401869834, -0.34709042297579873, -0.22799685723718324, -0.0765874779688468, 0.46132734976080114, -0.20856758424384855, 0.14141192643959138, -0.408574773618653, -0.3678774008612665, -0.31212309268057375, -0.15201832642963112, -0.14577936105596767, -0.4708778199330913, 0.149871888981774, 0.0385672502242745, 0.11971509219638375, -0.245501056930867, 0.13788631461225695, 0.18830849954087928, -0.4478917417092999}
};

static const float b1[64] = {0.8866212644182313, 0.9097044973237652, 0.7925185262146806, 0.9223012241015048, 0.8846211596364362, 0.8909012587432455, 0.9127414070470443, 0.9267154160639178, 0.8547891758687955, 0.8742817945951918, 0.6932611184238306, 0.8881698219985259, 0.8722572486464314, 0.8801114038398101, 0.9288182448298951, 0.8977931727276318, 0.9239076525821343, 0.857192997775365, 0.9208838259097369, 0.9078042190364836, 0.8937912883743458, 0.7715646162830404, 0.9158955731401334, 0.8934973614682139, 0.8946700450703995, 0.9115553262663297, 0.7439075851508923, 0.9079315295682211, 0.6954870090796467, 0.8875541725306235, 0.9039533776117403, 0.9014447994622934, 0.8891783595109047, 0.9039137054481288, 0.8974222137648281, 0.8932335183312798, 0.9038960726956169, 0.909316756070051, 0.7951380784513562, 0.9024306148383842, 0.9156028609169674, 0.8508738584706098, 0.8636147281440781, 0.9109081495664424, 0.853008204168498, 0.9152217254403591, 0.917724613221855, 0.8084020089821994, 0.9187519921517779, 0.8498276136745235, 0.877024568839444, 0.70998557875507, 0.7890121604814123, 0.8952857213169321, 0.79808161476327, 0.8403702694605792, 0.7754016799137186, 0.872591801313985, 0.9182618260570777, 0.8970613738474357, 0.8541516312809971, 0.7649664159870656, 0.9021912253457219, 0.8256613541807623};

static const float w2[64][32] = {
    {0.8675528884793622, 0.6888618217629783, -0.27304698049810266, 0.9353379154768022, 0.6080621821950027, 0.7707237126991174, 0.6643785223674344, 1.0164865624151285, 0.725885452946685, 0.4311906588561371, 0.96799497638372, 0.9995395632296468, 0.6201276295042777, 0.46813895831420005, 1.0368756774412962, 0.7759923955690985, 0.04154585150132957, -0.28225772164771784, 0.9608088903764647, 0.6135329323181541, 0.6387273927946708, 0.8601672535960913, 0.8281297759862195, 0.07820661578723408, 1.0349361785698554, 0.7801045240869122, 0.714873415151433, 0.6409833738988616, 0.8050008586367731, 0.7191421843183637, 0.03145585832411217, 0.8455113894058779},
    {0.9210210695667028, 0.6217221922435047, -0.24246438541993826, 0.8790341213624172, 0.8000713607089913, 0.8070443442166751, 0.5449128653142825, 0.7664441725247546, 0.7250673972915187, 0.4551088690491692, 0.9118021096493611, 0.6267575160369115, 0.7451691418085641, 0.5058485266537818, 0.6287904473595505, 0.7658963628172748, -0.2538526272484773, 0.13222556928483722, 0.8207959282912858, 0.9809683434261042, 0.6739143336657261, 0.6893823630178492, 0.9853824760169424, -0.16214885661396108, 0.9447552654989807, 0.8684236834604311, 0.7751762517609844, 0.35060570468672875, 0.6503388524743959, 1.025076885206764, -0.07184401695233471, 0.7961290752629552},
    {0.5912790185159844, 0.8816108347803596, -0.2461974326909912, 0.6712838822838125, 0.8193967482389702, 0.9249360901479085, 0.6327634997509317, 0.9291364710184938, 0.957112124790903, 0.3573451036991078, 0.7340439818132408, 0.7984241448483094, 0.7954387388584111, 0.8398436585112462, 0.7225603444776916, 0.8510431134298395, 0.16401254806403015, -0.2930286483420232, 0.5421121800488974, 1.0685716435690227, 0.7795802706863948, 0.9008084328150511, 0.6016323997150386, -0.2843130450253084, 0.610251557642592, 0.6802670432772829, 0.9022451661654697, 0.5977993320293091, 0.8100570664750562, 0.624596054273784, -0.23492071275371143, 0.7266663768771768},
    {0.9684749555524436, 0.8614032975394809, -0.2693651930530957, 0.8075632923062965, 0.9104238157189135, 0.7452614884192112, 0.8978782099043904, 0.8821062173517825, 0.7460419669463694, 0.20163024410782598, 0.9413606722581247, 0.682358198004169, 0.6964571885793343, 0.47627850296551744, 0.9299523027948371, 0.6556747079338064, -0.29588581719574913, -0.17171000778867584, 0.6473398588426817, 0.7146696683839587, 0.9185412536447143, 0.8815778782925132, 0.8370110290177162, -0.056998755903496186, 1.0239692113971746, 0.9100198541922182, 0.87650053307586, 0.3954003304955728, 1.0675930801706097, 0.5890446122457614, -0.2687441578324453, 0.7091594649721875},
    {0.5863577619523466, 1.0592261664545888, 0.17559074322799387, 0.7307381029388611, 0.9856690736208444, 0.9975609654910352, 0.567028269500184, 0.9771617808064056, 0.9619983521659976, 0.31525399303292395, 0.7205646254174859, 0.9482722107079637, 0.5596910322527207, 0.42531148349410985, 0.6853895074995228, 0.7793799005388022, -0.23060966260619215, -0.2554753288872516, 0.8269136369656318, 0.5872203352042235, 0.9743304661982259, 1.0083667882091065, 0.8480940662042151, 0.10850934270339556, 1.039940415336288, 0.7599291602290064, 0.8086776618025537, 0.47206084295773604, 0.6749800498055594, 0.9520335009896173, 0.047382362278606684, 0.5765694614135988},
    {0.5663309963878035, 0.9936560179091188, 0.013340286868462486, 1.0285602684271793, 0.7916514081794576, 0.9607199113578467, 0.8795446719232777, 0.6731292701354781, 1.0195837417568352, 0.3529409592912678, 0.6814803416493719, 0.8191517055199522, 0.5968765531112764, 0.6278622996288021, 1.0162436348214519, 0.5915681002210341, 0.07600894016572333, -0.2549464360803594, 0.5441633607027824, 0.61182129197746, 1.003168442266679, 0.5730349299805833, 0.906419910106235, -0.10849726404086292, 0.6799149932844284, 0.6473656701091004, 0.9606034097143963, 0.6297324048470232, 0.9424727577273441, 0.7935613374837021, -0.2142549430179793, 0.7540873553987489},
    {0.6192962272179909, 0.8636234365355228, 0.11387816161929407, 0.7806420036606062, 0.9430705836806613, 0.8227212702330751, 0.5557154615293605, 0.917000639363795, 0.9920597874056658, 0.5602783046617563, 0.9166768053766902, 0.741634032826084, 0.947107109191526, 0.34927766429438817, 0.7243047465908523, 0.7814215443854613, 0.028905333622785048, -0.13090095854205813, 0.9005708937688502, 1.0351833156604409, 0.6792645899069539, 0.6645857116353161, 0.5336602001483274, -0.15820181490649626, 0.9111394903505202, 1.043757367343562, 0.5915867932505178, 0.2052496480784419, 0.7127070640878155, 0.9057272392812209, -0.20701468439268145, 0.6707677958223545},
    {0.9442015252448679, 0.9295409458191111, -0.17623815238437818, 0.8130024693283487, 0.5560182170019036, 0.8084025850605664, 0.6309650579502798, 0.8113723916994028, 0.9262028259925549, 0.5089638833576796, 1.0694619455959473, 0.6129104308606274, 0.9021356535441836, 0.48069542181906444, 0.7496085450609989, 0.5778823115662227, 0.07072573831328802, 0.17518170690927196, 0.8349640739954961, 1.0509688199921394, 0.6957878129444812, 0.6604285560000608, 0.5723750010706274, -0.030097285163506272, 0.708855090159373, 0.748106239684179, 0.9659338948257147, 0.6069685477389736, 0.7027436206833276, 0.8454908676207179, -0.17504102262229818, 0.7936082179754144},
    {0.6080762396685085, 0.7405712446046598, -0.013170133794033992, 0.7793769104314502, 0.9712750623709216, 0.905125212592581, 0.8132483036121871, 0.908495733877988, 0.5914839549451819, 0.350228962328374, 0.9026259179344523, 0.783231727149056, 1.0288344849206958, 0.7485385326157874, 0.8324599537300609, 0.8148885000959976, -0.14853397666867862, -0.10762694452719858, 0.67370349152883, 0.651829846694283, 0.6634095199125007, 1.0514734586841683, 1.006379775639434, -0.29966640528421146, 0.866766924104277, 0.8876918734969096, 0.681033151556354, 0.5753340806459122, 0.7185903956292007, 0.9612964435278347, 0.10732648880044562, 0.8113840058404675},
    {0.5931298100933081, 0.8222090342986136, 0.1561289773622659, 0.8024812493358356, 0.6370155783569472, 0.6703769694723918, 0.8444786497266358, 0.9689737297295393, 0.6760969475719675, 0.25692619326113697, 0.9978514881182441, 1.0002046428366718, 0.9896744373755505, 0.5226687683008201, 0.7029427843565473, 0.5577856822637195, 0.016240983444371374, -0.2108351724527989, 0.8522959812109591, 0.6613235638927871, 0.7605408305610674, 0.6873984537513426, 0.6570061368218055, 0.0455313619784277, 0.8071602311079744, 0.6041486926061317, 1.0752797990126652, 0.36585012497347535, 0.5920607532491219, 0.7299700266028231, -0.09969930194410305, 0.5749859265004724},
    {0.7141188439185199, 0.7733299318636088, 0.16122219440155394, 0.7809138544648757, 0.6164920892405081, 0.7917839439761787, 0.48317465369384643, 0.6480901835836769, 0.6677831406386943, 0.4535136938450551, 0.6164022987889499, 0.8203747866574537, 0.7924698441830303, 0.7096785853364646, 0.8964401621747153, 0.7520272290238788, 0.11956236044730778, 0.16534177987681828, 0.6360006084519845, 0.6690667314718847, 0.7287502058437835, 0.5401906539570059, 0.7923516371441621, -0.015209758368581707, 0.7297890098006425, 0.7259174455719815, 0.7059552620150296, 0.1920350354648753, 0.6834815287314171, 0.9276495104562593, -0.036327724320292694, 0.7511479518453198},
    {0.6197267334176216, 0.6751015333445074, -0.06529115384998893, 0.615115674136564, 0.8175745674857282, 0.6124254829880835, 0.7245032475652337, 0.9819307948454982, 0.7539962729662157, 0.3858175029779906, 0.8740244771739929, 1.0458351893657931, 0.751730646584086, 0.3812202126647205, 0.8756080456726907, 0.6491902368836133, -0.03590931200511058, 0.1392456435815179, 0.7205975069419333, 0.6876369054625243, 0.9217945984432155, 0.6063314650679063, 0.9627592812511085, 0.1478503506701936, 0.8648994038100504, 0.8536291142670679, 0.6306802897286458, 0.2882625914501687, 0.8894231314209706, 0.8118836928972503, 0.10673572814994754, 0.6134615019150957},
    {0.8659263207551386, 0.8749446387814633, -0.06703910894983753, 0.9308979163343573, 0.9611539507122631, 1.051233794786983, 0.7718777348885641, 0.7817339121161294, 0.9801446908287926, 0.6076972767532337, 0.7722678586288919, 0.9139820024061056, 0.9178448501272061, 0.4756599470213109, 0.7427390244864259, 0.8018733073957449, 0.06582228238057512, -0.24388052165111856, 0.903372407773066, 0.6456404333090949, 0.9063693152056082, 1.0533565347144511, 0.9765534689445606, 0.1436958779124162, 0.9226025083291984, 0.9923764635929946, 1.049985249339015, 0.6750631086068554, 0.6546621404985346, 0.8556064034385762, 0.013352734933564463, 0.7698049074496852},
    {0.9503662955076762, 0.7706656556539314, 0.13743218781288563, 0.9149455161193406, 0.744829872223239, 0.8272020681430826, 0.8706904429124336, 0.7907790282976207, 0.5812248852062444, 0.3611428665442304, 0.97607988028805, 0.8702562697684014, 0.8527418929192571, 0.369696671757511, 0.9121774488699749, 0.6376985003855223, 0.1506503323862029, -0.06876465528726633, 0.7161166100696467, 0.821056031005316, 1.0493323278235585, 0.9803975072481528, 0.5676217608009131, 0.024566531137390425, 0.6194526624025398, 0.788580210347921, 0.9589380107689711, 0.26503551959123745, 0.8582375161202493, 0.8304050646597092, -0.14850786551459597, 0.8427022110182492},
    {0.7257879954518547, 0.6953135718565473, -0.24014806831645968, 0.8571283256412037, 0.7221096708333437, 0.6200001244158642, 0.8567864022700812, 0.6611904967274944, 0.7846189816279256, 0.5024486134036227, 0.9521700724703912, 0.792972914339183, 0.6407545048730272, 0.6707113595043515, 0.8701723752032573, 0.8512240303881582, -0.08342199534336231, -0.03108120522571154, 0.656770027602765, 0.8706978152222808, 0.9442651750368387, 1.0091654257836393, 0.5679375013811672, -0.21438798021249664, 0.9178679246638017, 0.9513771488916414, 0.8430326701549185, 0.5538001378848372, 0.7047135963510281, 0.8290362122956643, -0.08043800801930703, 0.6609353575557133},
    {0.581994441355888, 0.6506476755056597, -0.23696039218923087, 0.8743421079308751, 0.528070465205644, 0.9865052267924226, 0.7087260823077447, 1.0485933731725052, 0.5933107336123231, 0.4265467898026003, 1.0033895667709207, 0.7177191673916357, 0.7881618435605046, 0.4731872595014686, 0.9493504990219116, 0.7614006883730868, 0.046845947196026395, 0.05316342007103699, 0.5919076111204034, 0.6060081428015541, 0.8065955130891419, 0.700555856109387, 0.8246938521164994, 0.040428191283179205, 0.9851218377387324, 0.8166754162471218, 1.0402743301273263, 0.18471874371360084, 0.6875054312601475, 0.9091155772421138, -0.2796300730696921, 0.6347576038491605},
    {0.9934808911026716, 0.873007000281893, -0.2685699356472977, 0.9702966862776158, 0.7512137681803956, 0.7442070985693681, 0.9083887731531798, 0.7310040225566763, 0.8564079315185238, 0.5651011613878771, 1.070089879173853, 0.6666982491719654, 0.8438352476513773, 0.7447277829197696, 0.566934471255853, 0.712743792590589, -0.26478180780198185, -0.10920718653398316, 0.8199046975516592, 0.8984863923765022, 0.7547160208209511, 0.9307312256365551, 0.8511831667950961, -0.17868923712061743, 0.8542764787319022, 0.9799886433728858, 0.6345967240487449, 0.3226284731709493, 0.8555895811434441, 0.9461071794464261, 0.17518232635230518, 0.8752083901060833},
    {0.735600933560901, 1.0477461487613122, -0.14559763064048006, 0.9357103455058269, 0.6459894711757085, 0.6485459166509708, 0.7249862048891111, 1.0182784137742373, 0.7653526044211281, 0.5307295957462794, 0.7582221343238646, 0.7678260330248672, 0.7255304451759892, 0.5309518816994457, 0.921040818794262, 0.7692225786613736, 0.10176096580382152, -0.21290142736939457, 0.8651472242037241, 0.7650172428030344, 0.8987944360192361, 0.830316013594457, 0.9369091171721613, -0.1618281983198233, 0.7451413423422242, 0.7914067427750072, 0.8269611892981293, 0.17698934303063868, 1.0209867632269198, 0.7940548869119874, -0.01887268504807885, 0.7692859579443722},
    {0.8215847695791044, 1.0501915972479148, 0.025884814752240182, 0.9469967215472563, 0.8789148455678493, 1.0764145945750963, 0.7253903178517749, 0.8185090516009279, 0.5701617966332899, 0.5499725956298723, 0.7578363565931896, 0.79110049735681, 0.7514481302246555, 0.8425968717161653, 0.8934761249488303, 0.7160331636519003, -0.011431808092093617, -0.005806821580938402, 0.7740654014656081, 0.76088510763006, 0.596718508776439, 0.6103139517809169, 0.8003090368013592, -0.15329401261938952, 0.9951767630906115, 0.9352164941319658, 0.7782677768485275, 0.41747373073733807, 0.8755108479856993, 0.8000546325848062, -0.13789040610155628, 0.7473502523089564},
    {0.8193577762733857, 0.7854418213943993, 0.09267581442550638, 0.6283203200960762, 0.7313045062796742, 0.770070277725466, 0.9098414140505763, 0.9992292546983299, 0.845849771561675, 0.6325319357741768, 0.9070480752686904, 0.9963363875317609, 0.7302870305001619, 0.853265242285952, 0.6953462820474869, 0.622556034159099, -0.008741044229517936, 0.10127464669229418, 0.6995210994026829, 1.054700236478065, 0.9930773372308987, 0.6391177254995465, 0.5906257808515052, 0.10516835485376279, 0.7386703125066985, 0.764478735955918, 0.8268081310471207, 0.50815403249983, 0.805350198828157, 0.9170350265103169, 0.028135861288281435, 0.8437829800169271},
    {0.8435973975441494, 0.9475190146853941, 0.1367821108960502, 1.0309891258804165, 0.8777204684938561, 0.7270675441704668, 0.8172683339811406, 0.6754065727453799, 1.0505489196977116, 0.6496064387780264, 0.9355958394093973, 0.7997009744452659, 0.7616382416999341, 0.4903612195887166, 0.6050933868661104, 0.4901803323966557, -0.08542343762976515, -0.0369703081805238, 0.6187750617489001, 0.8199980336234165, 0.8393024836632929, 0.7221234325128519, 0.5880375516008847, -0.23489972708476867, 0.9140373435942701, 0.9790403897812822, 0.8720783286509433, 0.5494589752509429, 0.9760832887627382, 1.0306651509500764, 0.0663195973814774, 0.5695249345837355},
    {0.9656781998644178, 0.7617965570283741, 0.10956820011776885, 0.651298660215302, 0.9892717007917501, 0.9075223256471798, 0.8305451520768493, 0.8281839821679212, 0.7357944731297326, 0.2562378163552198, 0.7939989423344674, 0.8096939639001416, 0.771714579992441, 0.44545535729978464, 1.0080564628504292, 0.6541065878759695, -0.28196159543850075, -0.2577285331391911, 0.5583931896013944, 0.651763987321418, 0.6817503978232687, 1.0178275174852989, 0.6320603659141835, -0.04319708751124859, 0.8791798903566658, 0.8504029496913754, 0.9199227628304864, 0.23914129285654948, 0.6749028581560135, 0.640317532917816, -0.17163325729676018, 0.9071878811394514},
    {0.6896316825978644, 0.9438888425973851, -0.011146502468759489, 0.579159992396171, 0.7974621229980111, 0.9843558635472514, 0.9009078835333667, 0.7114763635570803, 0.8026622367196389, 0.6618240636729039, 0.6359366344120743, 1.0646529603568127, 0.7628477797849937, 0.4055861223862277, 1.0293012258652947, 0.8247917118587429, -0.2411530802242894, 0.023368409691683176, 0.8575697744721832, 0.9378732370024585, 1.0033320651625595, 0.645787483913705, 0.6039476047847212, -0.1912960583634898, 0.9800242133245429, 0.7402037880042469, 0.8083328317645232, 0.6636582529960157, 0.6536790430079866, 1.021121477006167, 0.04750251276544322, 0.6058559245188034},
    {0.8934360633271673, 0.6752549633279409, 0.1351429231327225, 1.0463011236836055, 0.9844418121080538, 0.9032193906715662, 0.9491112948506458, 0.997335533969591, 0.7677231276458284, 0.5433467408122379, 0.9340971996596361, 0.7302185867404926, 1.0525873762657452, 0.8377367834878159, 0.8209798029067092, 0.79611576796858, 0.08676370417120939, -0.127354628488895, 0.7609206910648249, 0.9977934318416614, 1.0243209984224027, 1.0458044905928372, 0.9424920273696946, -0.05338780359762399, 0.7807926340762364, 1.0926321282785032, 0.8405205786712342, 0.46552210602301997, 0.8601449942824594, 0.7954992265336043, -0.23226990603190792, 0.6332983357489504},
    {0.8552204209043179, 0.7596789261976348, 0.14454995403760726, 0.9063910456464679, 0.7325082946619991, 0.8359354456258156, 0.6047536371605345, 0.5937063992736876, 0.9581845315048735, 0.5612062399778992, 0.8595282884552172, 0.6007899701943031, 0.6041331095691307, 0.35211742770889404, 0.6816114380871672, 0.8793578737316954, -0.07295362926183935, 0.07362334911414908, 0.7287412998378843, 0.7002525518743067, 0.9552327098146619, 0.7813950597245607, 0.6879337667466, -0.24865564911458524, 0.6050603879582191, 0.8267532043014078, 0.7597707453789334, 0.5333202745240772, 0.8498031663048378, 0.8686213603198246, -0.16442554291538286, 0.6388389332165886},
    {0.7251353609368631, 0.935137948202537, -0.13124462179749488, 0.8452367585318111, 0.6264765942091051, 0.9080926320518767, 0.7184538021559778, 0.6012023872914434, 0.844061691507415, 0.36349473392568293, 0.9461127805908766, 0.7611751984807653, 0.8338522057811683, 0.44802632714881474, 1.0241305021854505, 0.6550486513603169, 0.024495221616887938, -0.1332135211493912, 0.649215061641929, 0.9810719060808116, 0.8579629222386889, 0.7706462884395437, 0.7622363900401454, -0.1482650175408565, 0.7472925466880856, 0.7675980475111251, 0.7945418867779751, 0.5200092090960614, 0.9818089061650133, 0.9632435683517846, -0.20594491377461077, 0.6706133260617686},
    {0.7296118375276363, 0.6024937485702689, -0.14638903172059134, 0.8220030443016205, 1.0321101490943072, 1.0841034298882024, 0.5183054458652937, 0.63215701896925, 0.6337063840572159, 0.49234698269258326, 0.6024826964575586, 0.8365795410971552, 0.5960821444612464, 0.7112638748650998, 0.9496599060497913, 0.9701105932059874, -0.07784935023901728, 0.12042659516272862, 0.7523099818500809, 0.6216078268419797, 0.6834930537955752, 0.7225792349813841, 0.9710015574924176, 0.12245217629421838, 0.9816638711284192, 0.699622295335538, 0.7414426488062708, 0.6438623774118999, 0.9456990462005097, 0.77420167109358, -0.24217100982855805, 0.6782471713706922},
    {0.6557679320414371, 1.048164025315643, -0.2696256591206502, 0.7908880650643357, 0.5964582697990963, 0.9904430534694871, 0.7654923596134542, 0.9192705657833108, 0.701472806816083, 0.4146481717392248, 0.8601172683640256, 0.9894589593374816, 0.5860856769504441, 0.8081029226296391, 0.8870260517177097, 0.7893670697916801, -0.13297116655720545, -0.06219148601582498, 0.7618083967007764, 0.7571267487798621, 0.9864406900795422, 0.717115709891332, 0.8422908122701253, -0.06258957472103781, 0.735633328497155, 0.7867305479331456, 0.8878613048536952, 0.337747345239871, 0.9382028653956238, 0.7549457764344149, 0.08894420248218796, 0.6854144916723437},
    {0.5843844916550972, 0.7869211046513264, -0.11940693862102984, 0.6525875144073489, 0.6042219260766992, 0.9667046258301398, 0.6630019955738486, 0.8385245038733745, 0.6411014884781193, 0.4426571412319046, 0.7292744646971685, 0.9615830144466642, 0.9043578825033163, 0.66751108557471, 0.6586090970472067, 0.8600114595204764, -0.22991228307940959, -0.18030776700263798, 0.571879884853964, 1.0359127494025964, 0.6396178983375178, 0.8710086623987888, 0.5848513711107777, -0.1388164803481295, 0.6430210963601962, 0.6547552178364989, 0.9716269403883414, 0.5712204750387234, 0.5970273845210569, 0.7146669882225077, 0.11408565891972634, 0.8264403873335114},
    {0.6419870938595867, 0.7276425580502708, 0.07989665214811828, 0.8809742085636334, 0.9801747227016002, 0.703427172187451, 0.9942526786113796, 1.01906723009353, 0.8449170475588671, 0.4746395728220734, 0.9994650565393415, 1.025621651647254, 1.0202901392324935, 0.6417925093132165, 0.9363339359043968, 0.901848992926583, -0.1424257273667504, -0.2228474240992232, 0.6407351573114164, 0.9968217648143974, 0.7255542473471605, 1.009516495940408, 0.9676519336417653, 0.015811903637915008, 0.8547682333221407, 0.9114619868889083, 0.8123885188154009, 0.31821414502939027, 0.6783948349509874, 1.0426358272349097, 0.12312225076534881, 0.7247871468207961},
    {0.6447422147331929, 0.8261459795946252, -0.14407254577688985, 0.7582542727202992, 0.8608136476708051, 0.9016436097524735, 0.9248545434960296, 0.5992356672661622, 0.5745142893172237, 0.5086906809827636, 0.7508576677052128, 1.093549247756978, 0.9003045437397514, 0.6922077244575069, 0.8231248865455992, 0.6298880656329887, 0.02072219363799922, 0.136919534029415, 0.675864941620387, 0.6429283279252328, 0.8883201649208954, 0.9495185609653027, 0.8478295497983633, 0.09436960627633419, 0.8753365471725045, 0.8706992223931094, 0.8146134447325268, 0.40299543257547393, 0.8559756319733174, 0.787218356260341, -0.24351841078488884, 1.0335181495395869},
    {0.5597924569666429, 0.6358007426962987, -0.2713522894665757, 0.801217231841361, 0.6553774356662159, 1.0277973832648177, 0.5357042003556665, 0.9057884160528669, 0.7999202727642378, 0.19047689906011525, 0.8675281562830389, 1.048039363231681, 0.6508398654933062, 0.4977899679163584, 0.8235307784766264, 0.9358699395339314, -0.055615875539080074, -0.20679161564891188, 0.7132105037449861, 0.8399124442900957, 0.6438809072880953, 0.6090022302462031, 0.8519802163253837, -0.1132608328583032, 0.8548098360746266, 0.7397239171935803, 1.0385070646339132, 0.6167537643947428, 0.7128224608959931, 0.855015049036336, -0.17038373526425127, 0.9861117328778694},
    {0.5544642357277734, 0.6055581208632028, -0.16935766117730772, 0.5960819642169404, 0.6536034386672401, 0.9626780014424968, 0.8980056223247281, 1.0929574897982572, 0.9049191038203989, 0.4161978184736418, 0.7818841620308072, 0.9889270208821561, 0.8729447802826169, 0.38313317555873566, 0.5746517713975707, 0.5362293076365278, 0.04823860786546289, 0.15492884238082602, 0.7589468956213453, 0.7325678531256739, 0.6573431273114494, 0.7319327670463112, 0.5589890203452452, -0.2060243028224602, 0.9422379844554232, 0.9963279473315774, 0.9878647810083818, 0.5245895606786948, 0.8070974214823611, 0.7322282330565171, -0.14972952599445108, 0.6921521388844428},
    {0.7320216930155806, 1.002901521308992, -0.17199579536498077, 1.0705565514185542, 0.7376465896424786, 0.819670735704191, 0.752911449804723, 0.9015637279289046, 0.9807638564895297, 0.3666560277682651, 0.9787875885376831, 0.7312666547418077, 0.6928386646067014, 0.4465358513944689, 0.9718578943231483, 0.8636222742790276, -0.19324992327531196, -0.07695736381211754, 0.6957445654255164, 0.972973916643988, 0.7756867178979193, 0.9709652085618622, 0.6304246445901153, 0.09369345572560601, 0.6365583644158028, 0.6083454457663579, 0.8423783126451602, 0.46690583466965546, 0.7169791966582757, 0.8300025730745947, 0.014102038458668576, 0.7934379480139163},
    {0.8970941578302369, 1.0578470476321877, -0.10867200461572414, 0.935992115216678, 0.570483344030673, 0.8505622734897565, 0.8460817255392423, 0.8011244892589013, 1.0592241940883422, 0.5505795466450254, 1.0021541784087313, 0.9966861126545287, 0.8804878346671279, 0.596568558446475, 1.028658736803641, 0.957881430602509, -0.11456745326408707, -0.20186083771584531, 0.7271809401294687, 1.0672618770152635, 0.7922128972331647, 0.9252468270716753, 0.9170598168440398, 0.11205953508704722, 0.972175892360027, 1.0479338365773305, 0.9059954565948634, 0.26475311027072074, 1.0373605157607444, 0.745368167990078, 0.029589972163238616, 0.9204713642125512},
    {0.6126489287744671, 0.9646593635284453, -0.26674687027824423, 1.013720901853203, 1.0187988446073901, 0.988833883894285, 0.5842287785996602, 1.0002032187473113, 0.7727296760158557, 0.27162702621138335, 0.9740826974938096, 0.9473883657347051, 0.5916183733993686, 0.7623446083456513, 0.696566871652628, 0.5211905908095714, -0.04528848000313143, -0.1326316771847961, 0.5202210729537846, 0.9311500558645727, 0.9513166197782024, 0.9091496213400228, 0.9624673107661524, 0.06060981167138422, 0.9607170262070721, 0.824017421370912, 0.6091170939166072, 0.33061923619222094, 0.9384341819658386, 1.0503584270185415, -0.2653679321046833, 0.7292246855388667},
    {0.7004068917641758, 1.0450872639672253, -0.06100325462675955, 0.58565382572743, 0.5692284434865511, 0.6960876799721755, 0.5221091327739225, 0.8862062751570472, 0.7293678916227619, 0.4183489029790189, 0.716536070128324, 0.7307821966491297, 0.7365433568811806, 0.33246148872058146, 0.8781762046641534, 0.6768768314701504, 0.1513182370674281, -0.07755314301333129, 0.9838016320424201, 0.9692951749388301, 0.8763961501127203, 0.758869620793924, 0.7760237954787356, -0.019943317414714737, 0.9611777505010222, 1.0426285022010957, 0.7033120947166462, 0.21227660820826216, 1.042389451935095, 0.9589811000217209, 0.04418524908353229, 0.5689651820971562},
    {0.7160238209143598, 0.8943352277348763, 0.07823320192095468, 0.9638994848573855, 0.7147324921982726, 0.9997688733531651, 0.7854427086487551, 1.0104493205900105, 1.0575807961150785, 0.3706812502774004, 0.839870711104971, 0.6709325041124766, 0.8212266648624161, 0.8232252512190331, 0.6272904876286979, 0.7791922912660988, -0.2555842738747224, -0.0936321581031974, 0.5787781753411129, 1.0594011467847688, 0.7885239319922954, 0.9714321174359029, 0.6179283338767754, -0.2198747943416423, 0.7543336656871096, 0.8131037670009874, 0.7838504423985075, 0.4349069783739647, 0.9542593863986258, 0.7730154968363007, -0.2575230944444559, 0.8376160934558887},
    {0.6704302292881659, 0.8614831976659545, 0.028113900813703588, 0.6421405517038186, 0.7436104245484432, 0.9708872002681064, 0.9024103897647011, 0.8473117748316876, 0.6350277902052871, 0.5224345670738991, 0.7253330573276381, 1.0815350509632846, 0.6178260417247675, 0.841571367147655, 0.5815040115957585, 0.5054414556399961, -0.04658259968735316, 0.04698415459304839, 0.7770093059615668, 0.7675693015232349, 0.8038988334770544, 0.8564316341978071, 0.8326193559697649, -0.2623263447449946, 0.6434212203656205, 0.8255255253743584, 0.9678548619088206, 0.28182853035930894, 0.7290112939865483, 0.6724659321982921, -0.027508496136287225, 0.7441178075835589},
    {0.8611219291390206, 0.8163069239240449, -0.11845585119676169, 1.0326299092248457, 0.5628946062866521, 0.8232390780870904, 0.5489527061688789, 0.8691150657191844, 0.6278934237418716, 0.3316297647005781, 0.8803735311734743, 0.8994512358717318, 0.9946946057948994, 0.5528302622882648, 0.6057432388495356, 0.6528669440829666, 0.12631677187270746, -0.11543252546235923, 0.6378358860658428, 0.9202689105422293, 0.7409506338499978, 0.6072865854385352, 0.6410949570485416, -0.11610007465350791, 0.6275294691013539, 0.8883508363973309, 1.0275318098629451, 0.43830943224033886, 0.862331418307641, 1.00113760743865, 0.19151576143235297, 0.7342165802475059},
    {0.6185728095982387, 0.8733843739051821, 0.13847573948574457, 0.7301564877095061, 0.6974976204053758, 1.047650827466398, 0.7554359303358812, 0.8378260611782703, 0.5474859068098245, 0.44906143846443103, 0.6008473639133646, 0.8294269226032849, 0.6829047348395554, 0.599441123378406, 0.5961454932656852, 0.5483847980289046, -0.10171062823460349, -0.03865615251323762, 0.7997424577034024, 1.008477049586194, 1.0483652730833795, 0.8519168778578617, 0.8161141499863438, 0.05759302754627349, 0.8669954246942196, 0.794843867610422, 0.9603016081394666, 0.2197486134890288, 0.9455874558047411, 0.7231353068785739, 0.038747179740841346, 0.9359956681224104},
    {0.7749300022898887, 0.7759554519187221, 0.051694207483949456, 0.7133731083871734, 0.7644740636877464, 0.6830898691896584, 0.947809131982817, 0.8749331784572361, 0.5675430600658021, 0.29506619760918007, 0.9222538319610344, 0.6746414599917798, 0.6472455296248601, 0.5469467815489213, 0.583606915314687, 0.9145554679082089, 0.023186751908826367, -0.18490918378558696, 1.0092012769322323, 0.9357757735298242, 1.021399771776319, 0.6471340463372741, 0.9150894666099522, -0.2300170545899592, 0.821032787448414, 0.7755716520359213, 1.0471741834171944, 0.21444194873415626, 0.6331208442182961, 0.662786268579869, 0.0827034431487142, 0.796400927960595},
    {1.0270321799289865, 0.934464401517909, -0.023471867181836185, 0.6406537232101924, 0.9413618475679268, 0.8256456980329564, 0.8545604242432084, 0.7055154595575811, 0.9059209423465057, 0.3590909254721995, 0.8356613896272926, 0.6116983889544741, 0.8357628618959856, 0.5449748917384295, 0.8277892166686892, 0.7713211056667529, 0.04507643639005761, -0.23623647773861028, 0.7885550329772923, 1.0020622098791585, 0.7459835104645702, 0.8099858608636293, 0.8791790434789828, -0.08155652547456071, 0.9077090364979518, 0.7352061208446059, 0.8672367681582628, 0.5087827057889748, 1.0641362763193694, 0.6931969953473403, -0.0459186910221847, 0.9687112433662494},
    {0.7561049755781822, 0.6565403245868089, 0.08771392924395831, 0.7041976201081303, 0.7803209963075992, 0.6047935244451834, 0.8289129374620724, 1.0458612646941712, 1.0321817929696615, 0.32694720184703174, 0.6717243618394018, 0.972542467527282, 0.5589614814401423, 0.3774198192914621, 0.8124378657864634, 0.6471289098404969, -0.20805076192664915, -0.10965047859645073, 0.7787526673261632, 0.7766948952259978, 0.8313455337858139, 0.6583467662298327, 0.545983211800022, -0.05214904128444101, 0.9356168710037777, 0.712432823903243, 0.7418592435384089, 0.5961017507280449, 0.8147500595258368, 0.9200954232395808, -0.2051683140688107, 0.6107598138217109},
    {0.7964531881596694, 1.0977085600482415, 0.12838322714135497, 1.021281704335493, 0.6612698956872739, 0.6949648205653116, 0.7354861238751201, 0.8679454192650888, 0.6456275805829533, 0.6997191228848998, 1.0437359747378974, 0.8574724773731924, 0.909939820366396, 0.6510908773140838, 1.0857457945148241, 0.9418998223011914, -0.2668468014780641, -0.17014263557746948, 0.5905764672625857, 0.6466228482712209, 0.7610237245694983, 0.8722271131695463, 0.6269315787024714, -0.23405482679213097, 0.6365389168365679, 0.7840233039336608, 0.8065503233193781, 0.6338297137194978, 0.7079147928687936, 0.643310285388059, -0.03273917894745786, 0.9797676350461721},
    {0.8063390477722563, 0.5963048490132541, -0.05168256594472905, 0.6237363330762886, 0.6463896460408924, 1.0392910931525638, 0.6771862454120164, 0.9160938219309743, 0.7522392577107295, 0.33112990924791313, 0.5909708061947874, 0.8305660398152318, 0.6966439410562784, 0.6168718600481775, 0.8575131634684616, 0.64799738527609, -0.2765956997604121, -0.09315781420844495, 0.5445259316385535, 0.946524574920716, 1.0349483906100083, 0.6787504509606227, 0.9949174319618632, -0.056975423027044815, 0.8923106967775204, 0.884296472427254, 1.0415903746701587, 0.4064093385550967, 0.7382949700334626, 0.7625588238328274, -0.27593299867771826, 1.0293882849008718},
    {0.9906867626029903, 0.8629449708320824, -0.007019399827062966, 0.5839303068790153, 0.5733653516896159, 0.8948924863303169, 0.7995472271517445, 0.962083841233773, 0.8113172408434021, 0.4798555334060928, 0.9423616689309514, 0.8904693762282688, 0.705323611025361, 0.7105586549008088, 0.6109896383979497, 0.5590743879976702, -0.20133820138548875, -0.026145524696074708, 0.9574625346541588, 1.0083443217882477, 0.9654908868657472, 0.9110600106727597, 0.7540145418075378, 0.17486113590577756, 0.685062687858993, 0.8910979694984688, 0.6507507152510575, 0.26336880545373503, 0.8556475537583268, 1.0387955183789201, 0.130174446425179, 0.9216331271156631},
    {0.6630161797695047, 0.6962355908135601, -0.28120380058755645, 0.9992160687686333, 0.679331017892848, 0.9368717117207412, 0.9489589174422545, 0.6876645415489243, 0.8268700875821516, 0.17051058575019953, 0.8529151186552328, 0.6209123034060628, 0.8355369606879695, 0.617336407700732, 0.898259422435477, 0.9275007730544963, 0.009939469643740805, -0.0759938984540591, 0.5183309318229208, 0.6342973859156144, 0.6835571071723272, 0.8721567130015788, 0.5833403821618616, 0.07798481925996445, 0.8196367150578654, 0.5942876878821641, 0.8913404676861754, 0.5652893927325991, 0.6021788866157537, 0.774100208368859, -0.01998881585638173, 0.8440790619147086},
    {0.9929996847205447, 0.7207022999945418, 0.10718639104408073, 0.8335957423007347, 0.5639784564975336, 0.8621669361598644, 0.8060237131372143, 0.7764385560818806, 1.0472677113992903, 0.3209853075295346, 0.7512349127693172, 0.8352444453892756, 0.6408676968344651, 0.5929944630710613, 0.7242567081229364, 0.9613864477958669, -0.13772783185698537, -0.05493091610133867, 0.8514567970062947, 0.8847718433332982, 0.9696687824319422, 0.6041085499858578, 0.9126933707852353, 0.026603934133881714, 0.6696788306026417, 0.8774290232927837, 0.9441597653843128, 0.5140966144825715, 1.0323173682329836, 0.9632138784824121, -0.20244156018852313, 0.5682677570937659},
    {0.5485800615297437, 0.8240901350787505, -0.10603139808531772, 0.7119660168545964, 0.678390809721584, 0.8480106351347972, 0.8306576506641483, 0.7614133418892483, 0.9809309093060399, 0.5616959009353674, 0.6167733999112457, 0.8032481110966743, 0.9223156218263017, 0.5299997782432551, 0.7319868183739964, 0.8295054440155564, 0.0689179685136711, 0.10809739284449102, 0.8316587133955062, 0.9327328890171652, 1.022516542524934, 0.8867637059346054, 0.7290138493147904, 0.06203763157396745, 0.8694562584168282, 0.7767004477716088, 0.7282376975567514, 0.170927868395189, 0.9343861092135333, 0.5750245587263805, 0.16450725785057263, 0.5529816538462745},
    {0.8319754162332349, 0.64339402016175, -0.2774399018923498, 0.9755307177872901, 0.609026621894013, 0.8331834293779828, 0.5989382292897139, 1.0659550996370335, 0.7211282898490261, 0.2616128312248197, 0.7326802856855118, 0.6757514291344819, 0.8422076920216546, 0.6615208308093189, 0.7901663364251853, 0.7333385665720564, -0.1647779453925861, 0.02218694396901353, 0.7122499158655992, 0.8142698816593954, 0.6706436153626828, 0.8520698454117143, 0.9838908338699769, -0.2505165556767108, 0.829482648921387, 0.8529522517790004, 0.6265938347244591, 0.23858985220183845, 0.7738841118563422, 1.032326317084778, 0.1083342033736396, 0.9243253954277554},
    {0.8426690334782937, 0.644630667627505, -0.04537483926333911, 0.6780353016880059, 1.0121013781349288, 0.6085401103466885, 0.6637755258794746, 0.6004760181935304, 0.6145672632953981, 0.3100752215150041, 0.7912261740567712, 0.6688291494533601, 0.8740539513414369, 0.8582934680768383, 0.6069094411837993, 0.602094487458508, -0.035507966665875135, -0.12720673302639204, 0.9562474066307329, 0.9457318843648362, 0.6243060358750644, 1.037243790742054, 0.6743089728033185, -0.17296785501597756, 0.6654866241111062, 0.6050820208487313, 0.6437549371331882, 0.5175686597404446, 0.7510141993435389, 1.0602109514948694, 0.1505655343836835, 0.5898637798017107},
    {0.7975608107755009, 0.7440924797568056, -0.14801902614739174, 0.6482148882741952, 0.5193462988310973, 0.7922177921709227, 0.8783290629725338, 0.9201072007009535, 0.6068821573069216, 0.5325280859925982, 0.6887300919246636, 0.7725664533625075, 0.9269392061591805, 0.5422186372258007, 0.671105474049745, 0.9014169217665483, 0.0872520043410175, 0.04556098985174259, 0.6171081788175653, 0.9224527844755256, 0.978881004438303, 0.5885856446887108, 0.9042665872598256, -0.2835315640278302, 0.6603160056767425, 0.6135368139405066, 0.6974511326958437, 0.5734810658043518, 0.6702616923854544, 0.9537117293754936, -0.16947484639989197, 0.8025454915198453},
    {0.6418220719413735, 0.6462311645098452, -0.14231912347221867, 0.7636398591992503, 0.8843115465804817, 1.0342359729095905, 0.813802574316863, 0.9916575210033668, 0.5545147360869999, 0.22894146071715712, 0.8217104607553714, 0.9785189199477922, 1.023736810778957, 0.37531226784859817, 0.581406266847339, 0.7194944101679033, -0.006806905473802045, -0.17687622581726342, 0.8417302321280532, 0.7483070226796124, 0.9078474989960772, 1.0372688862004376, 0.9105693105387224, -0.1455552897293821, 0.6928305983328941, 0.748998961606093, 0.9169823879015531, 0.3112956565149748, 0.8552610847312895, 0.7688141806882386, -0.13272817348894644, 0.9373863612151644},
    {0.6419504658525852, 0.9609301966603595, -0.16342250749987494, 0.658768810402026, 0.8887729138925514, 0.8973804705920028, 0.7068052689843309, 0.760700725639364, 0.8197103003791859, 0.1713504479939572, 0.7199932981416595, 1.0583164249787387, 0.8698561718658687, 0.4751872357973773, 0.7799354430149581, 0.5387523419993957, 0.07064765631527493, 0.1375509090941548, 0.8915858394480753, 0.5997323674251279, 0.6884177926404554, 1.0432234198595702, 0.9409583695222115, -0.00696548543590859, 0.8012310297845407, 0.7392195697813614, 0.6608560442255563, 0.4014179419812232, 0.8057881894006907, 0.7692452682665165, -0.19671571480725625, 0.8183078150220496},
    {0.7825813536590253, 1.061402582102183, 0.09997669443296751, 1.038649814536038, 0.8979772174877586, 0.8090416830188748, 0.7755309036200047, 0.7226349593775966, 0.6485774932621937, 0.4847064529145781, 0.6485025154006295, 0.6766258846711586, 0.9563893403604943, 0.7165839004401113, 0.9736895520831851, 0.630835534231881, 0.13105894028566054, -0.12359165032299035, 0.8132734106077772, 0.6468551976508775, 0.8989103228855564, 0.9318306742026445, 0.9695557125704405, -0.13528040047261022, 0.9221309294735406, 0.8738660124122027, 0.6668829671083696, 0.49356986547493864, 0.6561253707069866, 0.8294560011166824, -0.14787614237921304, 0.5958007658191464},
    {0.9681591523235141, 0.8839987528776744, -0.2874915084886776, 0.7625682690018949, 0.6416708953356817, 0.7962191628324079, 0.8486205103578165, 0.964041706099954, 0.7558210179496353, 0.21706767218692033, 0.7145793726537611, 0.6098627358404483, 0.5825947172260791, 0.4753997546742073, 0.8523408813275001, 0.9676486070376192, -0.04636130664603296, 0.05700858908359826, 0.5894376483058756, 1.0287231759747737, 0.7705354762779707, 1.0386088089054035, 0.9293232781540124, -0.27355110370722924, 0.8066139936265476, 0.8517924058336728, 0.642808589485565, 0.5320684118055458, 0.6289020998313749, 0.7492538734695229, 0.14302562809091757, 0.9768056585409771},
    {0.6242901646562535, 0.9127632493983773, 0.13598987243571414, 0.7394598725125651, 0.6666812736103834, 0.7208469431968307, 0.645071037549017, 0.7074015950168175, 0.7662719008760807, 0.6060675128768686, 0.7238187709138793, 0.7711416253332917, 0.8709459134383398, 0.3122109505129005, 0.7471657897864733, 0.8140137736774774, -0.28075361288777434, 0.02566005562215979, 0.6715340412152171, 0.9152409947057, 0.6132378621166626, 0.9439385526325594, 0.636968399182684, -0.2384323747682198, 0.9983031744086548, 0.8176142209518364, 0.8173308508793038, 0.20994368918954787, 1.0116912113625105, 0.7447213628236411, 0.06882079702450253, 1.0281172882315606},
    {0.9129009742090692, 0.5931451364236611, -0.0989365428672555, 0.8018451048048623, 0.5596866738215482, 0.6527640539316056, 0.7327584922874198, 1.0104638653874338, 0.8699478788585239, 0.36010587860372545, 1.0343459236927308, 0.6590954651720742, 0.532806941463606, 0.4179281581403834, 0.9200363801027613, 0.7082374998976905, 0.15029850440408984, 0.10659170918748444, 0.7243503025905136, 0.7005498298312368, 0.8118146819580038, 0.7784333622938396, 0.7652140139724907, 0.014529810422316358, 1.0667594268279526, 0.8421685988883223, 0.8476709544731964, 0.2647803205113789, 0.7726778810592407, 0.8885969683332988, -0.253173154868836, 0.9211052286188701},
    {0.7891251714025228, 0.9348950243799401, -0.1887842762479005, 0.9065744282576463, 0.6977570670757497, 0.7187750278313012, 0.8130187828718496, 0.9724745118383976, 0.6090745587394962, 0.22789431403783292, 0.7171965665297492, 0.9111541398335895, 0.7726291712707464, 0.705828767238912, 0.9879044879852176, 0.5318475412603623, -0.2257658402462155, -0.022406560198662627, 0.9955477754709788, 0.6031888264559477, 1.0157505407736187, 0.5521797131734395, 0.8259715845287546, -0.028111385523316008, 0.8899869450660831, 0.8361407258381391, 0.6569798349486073, 0.3507842409765832, 0.7989504035915298, 0.7691776065916837, -0.19719402059017357, 0.5913204149711968},
    {0.8997713054329404, 1.0195433114903296, -0.3195008187028694, 1.057296286805499, 0.665413565660042, 0.6334167916220016, 0.5849431281047862, 0.6397355098356415, 0.9165978479560964, 0.31563523803703497, 0.6671699910334816, 0.9662257883854164, 0.6946781997790215, 0.6646603272518432, 0.9132608431551175, 0.6310771903084885, -0.07470669225877832, -0.1826408112984725, 0.8611250143095462, 0.7599191123404118, 0.7506102323506305, 0.8657494605741236, 0.8666570158239281, -0.10513128021127215, 1.0231849923190162, 0.6328817036001545, 0.9197039563085702, 0.5332412896125791, 0.8437447505596303, 0.5878833501139762, 0.06731317120769882, 0.6542030449620557},
    {0.8001853015324832, 0.6819328996649171, -0.22998103580161383, 0.8370520116638165, 0.8811743878878489, 0.9965906165618548, 0.8533948241980149, 0.688234125019325, 0.60000864434974, 0.44805831013153524, 0.7463459415073532, 0.8201953025926548, 0.9318633132577466, 0.5683591988258991, 0.8827352087956845, 0.8649434004795102, -0.15168153662599307, 0.17071375321866916, 0.7791300411670372, 0.6892935576893827, 0.6651125157467553, 0.6476933118798007, 0.8662826063582536, -0.09150701150349133, 0.9559411057134146, 0.6321515974788467, 0.943914414342707, 0.5031994778548067, 0.7919576698013701, 0.6605338934073758, 0.04127943225937323, 1.027514117301992},
    {1.032532590507653, 1.0204491092266645, -0.04594166040812362, 0.6861762958915574, 0.7547713421888258, 0.6337523577694469, 0.8162918281530843, 0.8116960436019632, 1.016969380140599, 0.5192411895085082, 0.9810940120119227, 1.0213254158237877, 0.8870707447022866, 0.3452765532767044, 1.0249589142324522, 0.8558165096963433, 0.11345418147246361, 0.15573309505276325, 0.6033608151863049, 1.0065889945967994, 1.0234356613154514, 0.8624197547931716, 0.6125706101755855, 0.14387583704080095, 0.803861550937154, 0.6982373505594706, 0.7452486425378915, 0.1901190697250067, 1.0297356683123986, 0.9427865827007473, -0.06981373807943224, 0.8880512368392958},
    {0.788126589448075, 0.5829267435763146, -0.21923002672381414, 0.7922303256391744, 0.5912129002016148, 0.8253621814790668, 0.5593233997397186, 0.9353157242753288, 0.9655434802224505, 0.2278865806925623, 0.6011628027989223, 0.9977356132727457, 0.6769099838786823, 0.407381737717955, 0.8888293853216598, 0.9288930981984223, -0.18737206520375224, 0.03334549504200446, 0.6320044992589977, 0.6860714580052686, 0.7034962453722597, 0.6231805240273539, 0.8335963194158571, -0.28591863679846125, 0.8451271976342845, 0.9561556559593547, 1.0014409072653692, 0.6663537696790061, 0.7771590589446657, 0.6904826988691495, 0.16139525329225807, 0.7099072874730338}
};

static const float b2[32] = {0.7506651524352511, 0.780307681864116, -0.08133310866058112, 0.7734827302671213, 0.7375606705513761, 0.7845026551363422, 0.7093363126470013, 0.7762478640774526, 0.7529081968564165, 0.4824275993423211, 0.7402438705353835, 0.7871518569449161, 0.7486203560244659, 0.6000066339989584, 0.774660303094886, 0.7001776637125501, -0.07770108319539992, -0.04508614289717678, 0.7361997304440864, 0.782727355972428, 0.7705709025613816, 0.7464004657006077, 0.6846884988946441, -0.06416239317419659, 0.7904279933487601, 0.791218777183402, 0.7804531185043555, 0.4478325068752038, 0.7606416921509646, 0.7552669831864837, -0.04545005977885922, 0.7522125546617109};

static const float w3[32][16] = {
    {0.524642960513846, 0.8037503544948701, 0.5785424989431831, -0.12775837160110862, -0.263469013717321, 0.7375416140533707, 0.7817858943826789, 0.9651687842558273, 1.0334574542102744, -0.24891579117053822, 0.6877552733106641, 0.2854386992395999, 0.4720388636956687, -0.22616935294542392, 1.0703307184592243, 0.9160197067907495},
    {1.1618656070605402, 0.9343360605921229, 0.7100122811730977, 0.2202346117298537, -0.15624248279716263, 0.7545305201282289, 0.9782145685845495, 1.1388566892020056, 0.8365464423807891, 0.31341207051399117, 0.6673338294540991, -0.2137300585402032, 0.5167255869524071, 0.054389573461222834, 1.139847868454901, 1.1940705222594468},
    {0.24383946978823146, -0.08744329863818118, -0.17720085052238002, 0.22183933610514864, -0.299806709326492, 0.24181393196187592, -0.0041652048900455915, -0.16599754470795386, 0.10049040364615079, 0.06569692632539735, -0.1435573769037387, -0.26834080558344164, -0.01128270780210276, -0.00095898788087575, -0.24061565241423488, 0.2275238038931879},
    {0.8644727169357961, 1.0111865864386413, 0.9371327142541772, -0.19066905757044478, 0.23544480643314136, 0.721969409483049, 0.849145430128766, 1.0928901014911596, 1.0506019440062928, -0.2710608414931731, 1.068671366329585, -0.2524399645467587, 0.7951096199140492, -0.17100301694988124, 1.0274753804425363, 0.7026919436581865},
    {0.9743317883325233, 0.8423481340038121, 0.9340173867159226, 0.037803411146356894, 0.02847547107565028, 0.9066166109014194, 0.9288731640009805, 0.7493459855047202, 1.1463686339239358, -0.10177443994669694, 1.2283825544332703, -0.12164563741755371, 0.8959426162561455, 0.337175985284201, 0.5736157905934882, 1.0664893864458584},
    {0.5912977245602522, 0.9621193483598055, 0.5692612889862757, -0.11446340326651892, -0.3518072281654116, 0.24559878764519, 0.5094190751424581, 0.6478481905558631, 1.1337785575125792, 0.002630917701991186, 0.5617063139144118, 0.03877562507125372, 0.8468911894093861, -0.2943386656908899, 1.116059664978742, 1.0568786324187036},
    {0.8497260167394537, 0.89612389770488, 0.5669037769224939, -0.21866825588375516, -0.12594574716241166, 0.7537393965141277, 1.0086635266482453, 0.4935855404016082, 0.6167484067784601, -0.14724970599970727, 0.8407203644425392, -0.3033822468803203, 0.9372701172214174, 0.08968029352619176, 0.6073147571366218, 1.1230605923249142},
    {1.172017636838568, 0.925374637175319, 0.7987874282054528, -0.07380783774413847, -0.2829044265093246, 0.5633795866639155, 0.36360757418436096, 1.0864148169761916, 1.0386513921202642, 0.14973918882834333, 0.797101080022682, 0.08735148213102754, 0.4725155111649655, -0.3004441650984114, 0.5753054395589939, 1.0748837817591712},
    {0.9407312663287419, 1.1718615713511122, 1.0743901319201659, 0.039917258784127135, 0.23744809273155107, 0.886806043474795, 0.4709233729978022, 0.8649131340981608, 1.1697301945987015, 0.015427415412179148, 1.0769689815578896, 0.10124573232347336, 0.930934590059409, 0.09924546675607326, 0.533598071536056, 0.6589614497286466},
    {0.9134434789603872, 0.3715502398090675, 0.8365380067445181, -0.14428523284944092, -0.27824421118575593, 0.6007346039260765, 0.4336477766387492, 0.7741414128362426, 0.5593945333587549, 0.17486167353419793, 0.4584115749121122, -0.2804861356075779, 0.7062609498103953, 0.03880777383292591, 0.35325129978640846, 0.4993919106898594},
    {0.921962919692608, 1.0791260862407617, 0.9108424462629933, -0.12071947095621277, 0.03853495177727576, 0.6447917282395991, 0.4995074934432412, 0.7512949567406804, 0.8762023426573551, -0.30971199905520586, 0.9542342377515821, -0.3893040524015078, 0.942379196553608, -0.019081488642580895, 0.9462388909014358, 1.1820450025281624},
    {0.9679672777689904, 0.8756550892007948, 0.5178109746101573, -0.2960435011337894, -0.2384028610289759, 0.6633153779310593, 1.0185684310286323, 1.0700818064572144, 0.5904631962443811, -0.2567604324114097, 1.1634458059837185, 0.13934604156908414, 0.42587007908862634, 0.10309435492243998, 0.9230599933718104, 0.9291059673402995},
    {0.5739274309958627, 1.0284179136801022, 0.9021298215053505, -0.2875201932318273, -0.3414515998381409, 0.8117014713490909, 0.41420522438279406, 0.8968892471679369, 0.786390588729191, 0.06206160737889722, 1.0368178359226379, 0.31264337845022055, 0.7376669943622141, 0.18630288745512286, 0.6481264215504023, 0.5749516467467043},
    {0.6518301224178733, 0.47993584836850106, 0.6690684351264407, -0.24803683835800075, -0.22749946614174935, 0.6776797575409652, 0.7324844294488355, 1.0732310874393123, 0.9617583614875488, 0.12305232322826813, 0.6798144005751119, 0.13789567715536113, 0.26526574814014253, 0.14954698032771147, 0.8224227199118193, 0.6612090123591823},
    {0.5303851716554173, 1.0781247610523115, 0.7484891969381688, 0.3187340326712865, 0.046296729647468234, 0.30328397190287604, 0.8287258138005635, 0.6463431850542953, 1.0432721037938606, 0.0989159570793176, 1.0286219140479278, 0.20234405222178148, 0.6534282855661546, -0.1903843714269223, 0.5812334981131574, 0.6765485515572314},
    {0.8074059145051404, 0.9508361308928196, 0.6287573013153956, -0.31882252012838985, 0.018261015674861672, 0.7601616296889228, 0.8812956671088839, 0.819356377692995, 1.1259019295905852, -0.07075687805488654, 0.5290283519274966, -0.05173384462826931, 0.828514576538856, -0.30156771369772023, 0.9170514869978253, 0.7115079341887733},
    {-0.2579621903426986, -0.2061817840874975, 0.11520866680511828, 0.03779185934065696, -0.00997431671339939, -0.026088616658037793, -0.03750298561759792, -0.13395428984839589, 0.1306552433276363, 0.21693549664826345, -0.08114478747286669, -0.221751396066443, -0.2904793874214249, 0.13017952099974042, 0.11939395966089472, -0.28015787668567227},
    {0.05000522645290426, -0.21849977097607945, -0.13676897879105723, 0.09837251478205422, 0.16757770948329453, -0.13337115698524205, 0.05329406944830927, 0.17130510074226551, -0.3276482287433891, 0.14705746275358877, 0.20830725247304577, -0.1438422288755459, 0.13341578778293509, 0.16639744789749678, -0.06705959445556171, 0.03722846633120554},
    {0.6210787676730796, 0.8116621678824255, 1.0564933669796501, -0.04504273925580862, 0.07917940767484719, 0.8459516052331448, 0.5402532254129029, 0.7392621745539879, 0.9158758228559067, -0.262423575994363, 1.1416652410576411, -0.27751921010145425, 0.5524356376742796, -0.1357326816094027, 0.5432206864277754, 0.8733651722285684},
    {0.9636183913256307, 0.90365210108389, 0.7741436910960809, 0.16931134903605155, -0.2950797562461113, 0.31181646368572563, 0.6981587230021054, 1.0785979010910631, 0.5106886023818196, -0.3685004816072425, 1.1738326927294411, 0.22688429999523094, 0.7732737668316836, 0.18507790333348884, 0.9612216606797486, 0.5927722477461089},
    {1.0829458981503706, 1.1570783712491715, 0.6061528059037858, 0.22849279518570098, 0.31174055776867876, 0.8241426827848332, 0.493072856928222, 0.8527182070330691, 0.6830748120580934, -0.30506892111152056, 0.8640516603516758, -0.031917902877519166, 0.7611386194086408, -0.3307208903302447, 1.0543727062129071, 1.086515605630011},
    {1.0847859233787909, 0.7983472000647216, 0.9780610357255644, 0.17437706546196113, -0.11683718626046277, 0.6861510404656985, 0.8473865697272667, 0.8576236864570707, 1.1003613351163792, -0.1592469333161681, 0.9512176237072621, 0.010011117403752908, 0.5584467940917386, -0.24597354578396186, 0.8020777978055968, 1.0817655489849831},
    {0.6354361611339777, 0.7658169776424181, 1.15939979276224, 0.13662234761536557, 0.13605982256653493, 0.9337455996048143, 0.6783226441070637, 0.7925779241566506, 0.6807613716523426, 0.10728184426307451, 0.5991851208205758, -0.2717866905782965, 0.6942652977219662, -0.06371987110605024, 0.9396861424148303, 1.0886434893364727},
    {0.03156692440417878, -0.12026433807850734, -0.0818768191889346, 0.10786800407391205, 0.005861134990218208, 0.05965811791281844, -0.2804855914169199, 0.2311567884053541, 0.33202367133305394, -0.3307843448828925, -0.04702951125619447, 0.008408910982446902, -0.20269403289930726, 0.043007508778242484, -0.1888248923842107, -0.1378816058640324},
    {1.147100060323171, 1.0203251205565942, 1.015171432649142, -0.3729184568286319, 0.16797995772451846, 0.4234808877539181, 0.7293252373606862, 1.0483296703015506, 1.0956863929463818, -0.05225175356181096, 0.5749314285411806, 0.14685768550895564, 0.952048113993313, 0.03973509801069733, 1.204519618311983, 0.8614251340122306},
    {1.063275761101067, 0.8221300089557729, 0.8560237194641427, -0.26261466254602683, -0.005905186015062635, 0.6374427160153994, 0.49576136454312003, 0.6417554576150128, 0.8495195674601007, -0.2185337898122901, 1.011294790814975, 0.017876571819090158, 0.9503628703579031, -0.23879526675694043, 1.1135674196441172, 1.0990083031851043},
    {0.8279357298333944, 0.7415623153069795, 1.0874865830077542, 0.09041195858338717, -0.26730000160610745, 0.26430428092909053, 0.729334936108853, 0.7070403364788337, 0.5208868773036782, -0.20146973590164582, 1.1759082031215167, -0.16074702728147733, 0.436887307962605, 0.07162525729243663, 1.2171567724764314, 0.6100658557502063},
    {0.6097946372156198, 0.5908501929789667, 0.34432883151334803, 0.11343755252112868, -0.3012764276786317, 0.6331957810186597, 0.5898305751773719, 0.8809379250966559, 0.6862951891790214, -0.3129086201438175, 0.35533371906826794, -0.21691620326477273, 0.5858575076190194, 0.27890593324768925, 0.536823677346198, 0.6027383771663057},
    {1.1123925195934785, 1.1916097686560678, 0.5947836929147894, 0.10547582095350186, 0.09223981314831692, 0.8243775617285332, 0.9362945931125818, 0.9518509775082987, 1.132427680233398, 0.22036561679680133, 0.7751630899751634, -0.3344935973758446, 0.9711382994323288, -0.19368750641629207, 1.1655811035226125, 0.9059744236912417},
    {0.609573708072635, 0.9940845337870476, 1.15788571413576, -0.0177698730541809, -0.28712700625216947, 0.2716875577232732, 0.8903865605618347, 0.7606986090291185, 0.8791389567194009, -0.3650070484542582, 1.179752320594232, 0.09413477578656387, 0.7719839787029208, -0.2977867874877994, 0.9360693282675849, 0.9220530213325644},
    {-0.2756818123813714, -0.13308671498510635, -0.29438977176360615, -0.026017846089743585, 0.27779806358017606, -0.31706824658193455, 0.2404133809730795, 0.2510793133828302, 0.12293830377015733, 0.29481596162096196, -0.14281320854957694, -0.039807862950735295, -0.052113638972954075, 0.08368896708115779, -0.2085830777663838, 0.12179475059307794},
    {0.9532254686023883, 0.8353778019115857, 1.1291817023156867, 0.19624783254135816, -0.04810274961582388, 0.27830290941787345, 0.8714610440677233, 1.1758273915278439, 0.5786293177676811, 0.2017943349945615, 1.190213809602885, -0.019604498893876766, 1.0422766227095928, -0.30616249020096226, 0.7519658363797511, 0.6226485028144644}
};

static const float b3[16] = {0.6398089357164924, 0.5069106824022666, 0.5640538065153762, -0.05179752840693255, -0.036397300127014254, 0.45314968926380034, 0.506345527304239, 0.6168489647177737, 0.5867094868179121, -0.028964454069430618, 0.5832199311285833, -0.04249227656840175, 0.4923131262667489, -0.026871648356733727, 0.5787687453347811, 0.5733283163629433};

static const float w4[16][12] = {
    {-0.9208505057391262, -0.5015367789771444, -1.1062182803424134, -0.6459117368989207, -0.5134079154817774, -0.6520922521029924, -0.4040428098785377, -0.8106262433182545, -0.8122728352857798, -0.8643181354509958, -1.0185136393583634, -0.7304989962395995},
    {-0.8037462678977136, -1.1364212600430854, -0.7146794942051723, -0.5014602471250859, -0.733272990299795, -0.9775610339415077, -1.1780480920193557, -0.9596055625114502, -0.7020901714060176, -1.1376913136455706, -0.31354038304723814, -0.8293080089304233},
    {-0.2329928374500655, -0.885457891793604, -1.219370053110768, -0.8662884623862946, -0.8295077718859525, -0.57342889105189, -1.0672401269505452, -0.6538895417321839, -0.8417818229609746, -0.6704475053774565, -0.31007502987172914, -0.4032283662601563},
    {0.0067077772146830975, 0.13985886650945964, -0.4732103399294581, 0.03465093806323339, 0.03531076919342443, 0.23537321612645853, 0.11986665116558129, 0.2863919314073596, 0.1356822720718015, -0.28984541506935274, -0.3265212353728461, -0.3487522826996707},
    {-0.052280466576792195, 0.19387416942265565, 0.4144834349592896, 0.1945314062688199, 0.18645942957248363, 0.36865051868431714, 0.2299354243826579, -0.39423613312972045, -0.2551995106763486, 0.44235971278517544, 0.23055557605574664, -0.31654253806048926},
    {-0.514957082742652, -0.27413175948445767, -0.30127069496086634, -0.7242643333695353, -0.270481542535114, -0.6004359137256122, -0.44189068211403043, -0.9596682035097281, -0.848700952706127, -0.1251940952224044, -0.9192125595771597, -0.16307224310005847},
    {-0.392073659189118, -0.22138281598936335, -0.4530929399248929, -0.6939146892151155, -0.65416985198164, -0.22959455606535373, -1.0210942213433853, -0.3395473870302882, -0.7462856346898333, -0.6742921025000682, -0.49154033665686825, -0.7277468790493969},
    {-1.1246658513898447, -1.0293192733204182, -0.37489069976135303, -0.5174264926618928, -0.9115919333141811, -1.181980183892098, -0.5466170924619639, -0.407267602243513, -0.7119735148763254, -0.8514744254623345, -0.8204519692317646, -0.5475618706949742},
    {-0.27931527395860634, -0.5120860945898053, -0.8912688691136746, -0.891208649459441, -0.2683038477301896, -1.077421179800846, -0.655158741517885, -0.605114605593784, -0.5156516771609244, -0.7315292460248739, -0.6042213777013122, -0.9110541253911741},
    {-0.41209582538935413, 0.4404736595921839, 0.32799227968862915, -0.033828419143816464, -0.36980828497177964, 0.3714439988851948, -0.29351212382603586, 0.12819949907473124, 0.03503580749375791, -0.13545323663394856, -0.4655069046627929, 0.22685442364293976},
    {-0.82013835691951, -1.0166030553967833, -0.6086454409300844, -1.1129853685799258, -0.9372112774277256, -0.7574702660247443, -0.4574437156228843, -1.0690465582144235, -0.5580192160000069, -0.5026134745331186, -0.9568318854463359, -0.8975769226663943},
    {0.2802237462305611, -0.3176880579097036, -0.14200173454131382, 0.3838030764240971, -0.3095844879242631, -0.26415917028132024, 0.35546108800749665, -0.36529143343733844, -0.04043038234437578, 0.3962928083942558, 0.30519836846988985, -0.2877740137738834},
    {-1.0159442140598847, -0.6982543382512947, -0.2945724562739799, -0.6969546969393811, -0.6637626687383011, -0.49870944675370155, -0.504631987056828, -1.1781985461257594, -0.3101655215877817, -0.8768339388468731, -0.6104749206962929, -1.07908009073472},
    {-0.27836991658333, 0.2545432254466129, -0.0616413079995763, -0.10575881295643341, 0.05385912901507947, 0.2799896953192912, 0.4054640384349469, 0.13209713859197078, 0.23676572607386825, 0.3613888605306264, -0.40933894976634005, 0.2306998027506299},
    {-1.087058659550633, -0.4881020501350986, -0.8705297689252183, -0.9672011833678034, -0.9157707161557126, -0.9082564051501886, -0.48628314503917175, -0.5730123317407966, -1.141055161191947, -0.8848845080353426, -1.1145866374924362, -0.425683271785491},
    {-0.6848237141830255, -0.9634810933575761, -0.9446356298296631, -0.26555701414093275, -0.9660186488709103, -0.3090162212517578, -1.1385245343640713, -0.5246062747801862, -0.747592989519522, -0.5558727820220628, -0.851302438245154, -1.167934927180947}
};

static const float b4[12] = {-0.15047104718120527, -0.38192510060688184, -0.30679052803459383, -0.2387306104271701, -0.13185442147472867, -0.3313219814300367, -0.32028361616428447, -0.26977277366732183, -0.3124214573930161, -0.2345033362284371, -0.28620833678617585, -0.2673796534838054};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
