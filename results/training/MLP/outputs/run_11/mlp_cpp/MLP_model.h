#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.6431061100252236, 1.434720399766993, 0.9256885468899079, -1.369291331365636, 1.1501872504754311, -0.5531940782156662, -0.6652687940813101, 0.6481927177998531, -0.3872511528003114, -2.0240542945578572, 0.0819868269923272, -0.09069715804052236, 0.3527940810856907, 1.2154909094981345, -1.192146431077858, -0.32027867698987916},
    {1.331908988574684, -1.3099942627277792, 1.1648214703007997, 1.2664528354025855, -0.2482092578641722, 0.22634498651011373, 0.4078043541483644, -1.180548060734497, 0.19857924413388306, 0.4255846623395641, 0.4100092670474938, -0.14814991692643834, -1.5430055623006567, -0.13050225979569233, 0.4540230694605625, -0.22688772190411197},
    {-0.4815325385076627, -0.18670873710966787, 0.6088452050476391, 1.44673258720257, 0.5723905099932668, 0.2528596717580026, 0.3943013445957883, -0.5977012475783161, 0.9065653007431886, 0.1151367548536109, -0.3042429851916899, 0.6953917123136881, 0.9315635645210664, 1.5247097232193736, 0.45662422605661523, 0.7178104223743099},
    {0.41963280648573936, 0.20849439593627672, 0.9293118661519276, 0.37714885942810106, -0.7557562015792585, 0.3449116075168635, 0.6275572066991967, 0.09896781210914739, 0.441878165411934, -1.232900619677717, -1.3162443664477712, 0.5218207429975129, 0.5741909163747555, 1.0936873615486014, -0.1115766368391654, 0.8671176127132755},
    {-0.19241631394847244, -0.18201552147994818, -0.9306373422613906, 0.8195365190286295, -0.8718152055961228, -0.37899576331132595, 1.5522073269911654, 0.49006420789465654, 0.7779539195850731, -0.5736796625804328, -0.4050348323497353, 1.3491513990516544, 1.0292244022539447, 0.3498143428821715, 0.7657008539996557, 1.0161271435321557},
    {1.4920939354690137, 1.75310714492789, -0.28818423556391703, 1.4948748260261275, 0.21456596551264057, 0.9407761835716916, 1.5348153268854232, -0.23532247896133549, 0.7732307186337338, 0.4034811545811565, -0.32041881776647224, 1.0805605063319212, 1.1198841976189373, -0.7327321499626, 1.1075961479273626, 1.3574199327122924},
    {1.2628583629256211, 1.5376110548922053, 0.0931166071321468, 0.6531754486773891, -0.4369502039434992, 0.8184120310396801, 0.686616589743356, -1.0599872640033698, 0.6096836699791301, 0.32359275301618334, -1.2546733224196107, 1.1318734839736142, 0.686474905571861, -0.289127478195104, 1.2994551847167601, 1.579612516784244},
    {0.5801762033994575, -0.02768124425667235, 0.2776777184023852, 0.9178653775428196, -0.5522477744113645, -0.1670034608310155, 0.9379591445328996, 0.5203457894893897, 0.5683631207027139, -0.40989548188185776, 0.21347046668884817, 1.1424070540380264, -1.0720682893043836, 0.2826570888740132, 0.2964295153867419, 0.7482173363144003},
    {0.5361215512130373, -0.041628765658758185, 0.945972237372196, 0.766744488446015, -0.5488787310589703, 0.9553065073902303, 0.3537136512147701, -0.10116781467516384, 0.682110240487691, -0.5841786900335193, -1.0515099653626119, 1.571125467166625, -0.8404662431167592, 1.2205519505771478, 0.001184232482239615, 1.3163187948558603},
    {-0.04606842231945801, -0.26702578008872435, 0.7288659966351873, -0.8087610491978562, -0.7214185060075295, 0.09612977055893739, -0.2725572956411183, -1.3490894975347456, -1.154459713484829, 1.1080230626850787, 0.41479177992859406, -0.622722714703873, -0.9230771218160222, -1.311860651726845, -0.4072613350042168, -0.6835836601498918},
    {-0.37637803584078794, 0.7171037839960406, 0.26847008936676475, -0.7395342802378885, -0.7101776388158694, -0.7469900345640055, -0.216234114469252, -0.08001360927441796, -0.6716592255505145, 0.7069965118618436, -0.11591328052508133, -0.3535579954559399, -0.43129235314824815, -0.4491861308774935, -0.02278313413520095, -0.41065417531060033},
    {-0.2139744472278682, -0.4369372669703401, 1.3505346872325812, -0.28122261220024125, 0.9221160631416987, -0.08936918795957208, -0.2081304570570337, -0.41860880136999484, 0.2993621462179457, -0.929441381541154, -0.2887343477894804, -0.918311290632343, 0.012471632017887622, 0.36914791189094515, 0.5095032869650541, 0.1644585224238091},
    {-0.012362084246097116, -0.04322679183964277, -0.17088916938159016, -0.08411542325574205, 0.24200706028684754, 0.5027875671035906, -1.2291604427311922, -1.0587699294199493, 0.5690347711903289, 0.9845464683540811, 0.637330533679765, 0.015278565476531484, -0.9825598063531871, -0.819736092139985, 0.7123329400582633, 0.6028376840694089},
    {1.0495284318194806, 1.464186227728222, 1.1547887427325803, 0.15858726679862342, -0.5018584442828822, 0.4660689882108982, 0.7232457919689493, 0.4917450601273631, -0.611584251818214, 0.26696629077406403, -1.5288180370653777, -0.5572876041626894, -0.27497162187779084, 0.9019684181604977, 1.0062656217181507, -0.3347459101328021},
    {1.2414872380086432, 1.6642647391989018, 0.03046060963627739, -0.10366927461034513, 1.0923677600850505, 0.8881293508463334, 0.21345011379344864, 1.3983939824518987, -0.395171741618236, -0.8488200417516161, -1.1023064263609734, -0.508451492604236, 0.12146016648997437, 0.2311270506085042, 0.48919732541031186, 0.9583534546097344},
    {0.8303618387704087, 1.3725828934738253, 0.10851355467046496, 0.5725028968354546, 0.9334654898683323, 1.40874211133523, -0.6096809421829747, 0.07342257949944081, -0.4048862256669358, 0.9759154647288658, -0.5449031770162763, -0.0211335826365047, -1.1478575100429447, 0.0010080899216713787, 0.7293153356798054, -0.11225734566914868},
    {1.5054033191721676, 1.4444823972252032, 0.8016640226342007, 0.6935698904680505, -0.22724162744949022, 0.8679185267907696, 0.8084564126021079, 0.9835711871916101, -0.7512061886160994, -0.22783524296772517, -0.8878977255278109, 0.08349875139169893, -0.01875754198942333, 0.7202261152378053, 0.6739582054702825, 0.6174299126153225},
    {0.40641890932361435, 0.7398161775263047, 0.11189226238599526, 0.06969136314998968, -0.16406889780880116, 0.48058666501563113, 0.16682229399239842, 0.3307656748179348, -0.8078215797770066, -0.19322098497534462, -0.6318537736950964, -0.30670718424473614, 0.43336567446428687, 0.39051994426029496, 0.31590113563139954, 0.6727133429130632},
    {0.4153743769970783, -0.08589935076728016, -0.03194085343305823, 0.9718831029050299, -0.23529248857721252, 0.34914930192417276, -0.36911934972287574, 0.8443775969943277, 0.7741123271205778, -0.9158551733133999, -0.4037615620106856, 0.7789804146699495, -0.19574240540893764, 0.8417586002960111, 0.5429913386242304, 0.9099342273554445},
    {0.8310679813412577, 0.8244323424468375, 1.0748505694722117, -0.00932361601721543, -0.16157618769358428, -0.3981791669282358, 0.019530299215357767, 1.0430160228237038, 0.05419274815476875, -0.47402500831569655, 0.7884359839798004, 0.01616631040206479, 0.41338338016353066, 0.6570769089930661, 0.141478461035213, 0.0678664168249103},
    {0.26369814415972037, 0.33173333451162734, 0.006291504764758742, 0.08090030419358091, -0.32668930926798423, 0.015418863049227786, 0.2691546309549451, 1.365828134235382, -0.09445188758484696, -1.0941067201647492, -0.39738789224838295, -0.16597115299239382, -0.14565543123454813, 0.5594206951509706, -0.37502805154298985, 0.3059564603488181},
    {0.4671490829007047, 0.4422956887891884, -0.841104769942568, -1.0745994397763836, -1.556256502421415, -1.059811445672309, -0.32200733153793704, 0.987806515451864, -1.2818599807652682, -0.04992144880533889, -0.6803390170565033, -0.7494790149897838, -0.5571049286802163, -0.42275001003060453, -0.16226774254488535, -0.4202615649537953},
    {0.3937548209545934, 0.3037169195192307, -0.032096949859048846, -0.4192763478536058, 0.17307184892340927, -0.6204279389115072, -1.0727312239963138, 0.8791315990593028, -0.408624208870248, 0.11815802262519338, 0.29151841383214633, -1.1581524520639181, -0.10675950978913085, 1.1143807006414959, -0.062427880436880925, -1.1832772519463801},
    {0.378950963256743, -0.5518096347278538, -0.5788055927420991, -0.5751434016234265, -0.9244509587977395, -1.1890995429599223, -0.17024590350294494, 0.837938983210169, -0.6257383971485179, 0.7080260340512365, 1.5435616325338681, -0.9381687586978191, 0.12881779384065664, 0.28642132260475683, -0.49309607250691523, -1.0689969612312702},
    {0.009781287100870832, 0.9608522976108648, 0.701157317658772, -0.6211434857614464, -0.19662293798844885, -1.1341812026561675, 0.0637589256660279, 0.7869066662366007, -0.5537880393932973, -0.1554629504970155, 1.2243188516449257, -0.3970923423057966, 0.9426098036528296, 0.9084240769043037, -0.08592160255574498, -0.6133457975040012},
    {-0.742907140686338, -0.7827930161212237, 0.5637980613834498, -0.7058788543091656, -0.5987834544513096, -0.929327543246375, -0.24103305794220503, 0.522288070736912, -0.5971662189088749, -0.4882153035770278, 1.337756717044584, -0.6009163172898572, 0.6048020941640037, 1.1363411739767337, -1.0886331393651594, -1.087818141902805},
    {-0.8028647322505141, -0.7793867089452621, -0.3403382591905659, -1.484279175122896, -0.5277584947034796, -1.0538879873752056, -0.47106750467368697, 0.744652215845762, -1.4074447351294002, 0.0029460208031466765, 0.3234191537493268, -1.0058600863961336, 0.2712412980453979, -0.6847954730500238, -0.8771182773333516, -0.8602332804110775},
    {-0.4446359414929346, -0.6602594086007962, -0.6413309444694107, 0.3438323559210163, -0.28578696190773345, -0.8991565482306658, -0.7440460715909342, -0.2895035361525223, 0.06531926282633134, 0.269631300159028, 1.2975086133004834, -0.014431542323753987, 0.8481171078312779, 0.33910108771966674, -0.27809871199641484, 0.038616163530573684},
    {0.002964903817833969, -0.3203706233100555, 0.2945436863611468, -0.7521029675112009, -0.787096662567759, -0.7202893816241198, 0.248773553896744, 0.7429094372807576, -1.003475167842718, 0.10820342495578752, 0.14025236278968423, -1.4723850029870864, 0.9903564897126269, -0.014836504818465997, -0.29782734290812674, -1.049799069815864},
    {0.19645823323736797, -0.09748614707072693, -0.7338898114615545, -0.13019792607390263, -0.45092924867651063, -0.4387396384061023, 0.27268213530586466, 0.19157790655706167, -0.17005164042892648, -0.0955033159944996, -0.5931572719347228, -0.5554675721118185, 0.5660421497430592, -0.3111014078883415, 0.086387235156528, -0.03487033398314949},
    {-0.1702961955541423, 0.9103357496910287, -0.4759445571164382, -1.0070555044895704, 0.18434642484297992, -1.008107572669491, -0.053764090191859015, -0.08409452865927441, -0.8779228804138065, -0.6498603768634043, 0.7064281863039897, -0.6607739038223075, -0.25729935013174116, -0.12756033864706948, -1.4217117392085454, -0.6948230940264579},
    {-0.212674445636493, 0.8656079415103046, 1.352520504891113, -0.5282910097880775, -0.30278493562925685, -0.665526246281973, -0.36636098534086164, 0.39311958784525486, -0.3518633885780014, 0.22606946387195437, 0.6187445046286575, -0.025839976273941547, -0.1424047903358778, 0.7561217450663753, -1.1161949068935215, -0.6508529924843253},
    {-0.3380909918170289, 1.110746885350087, 0.5703933032211839, -0.6075566536510294, 0.35995428303667015, -0.3668865442982606, -0.20000877333037415, -0.006851904595404389, -0.06312195302197623, 0.47833500851608945, 1.2311317265494424, -0.5386201775404938, 0.7114252268334428, 0.6061231730364893, -0.6231156219189704, -0.7750236879580235},
    {-0.49819457087289004, 0.7617322774729178, -0.011081257978668824, 0.0020295471525221586, 0.1716390197785514, 0.18409067606738813, 0.1007993864913617, -0.45692552062161457, -0.33585919549563664, 0.33328245422982233, 0.8849257268565777, -0.6081515823007592, 0.35008885708284276, 0.47904968950482696, -0.849136533641279, -0.5195809521778715},
    {-0.24776889602212715, 0.8068099582400536, 0.38614953923158435, -0.21233312019079034, 0.21616120564046012, -0.189507791452385, 0.009397945213666173, 0.15838192269028836, -0.10699012214293542, 0.09341114993982365, 0.9515015247211404, -0.39142362224073013, 0.49537917408397136, 0.4249970429340035, -0.5107029976946125, 0.15661758455943364},
    {-0.1295541060027379, 0.5036639413906943, -0.26412393536946194, -0.30689222722607573, -0.1684633475770829, -0.2871741550036063, -0.3764436173243067, -0.26375881597507833, -0.015972846326628275, -0.27277566463574215, 1.00143560096159, -0.32735360680873943, 0.5474693254632924, -0.1377080226133155, -0.594317360536763, -0.39625005214004866},
    {-0.022045753039249716, 0.3080755766664447, 0.0215509469347599, -0.21143282058178967, 0.3930402200902886, -0.17392918354251496, -0.5053126835077837, -0.22065650811065413, -0.5192575876119582, 0.44557310647860354, 0.17661184515019945, -0.24873226778792007, 0.6666229613619133, 0.015717239314530587, -0.27542577234704774, -0.4224127221768196},
    {-0.3392711126664401, -0.10808244496365196, -0.6661117860707413, -0.30180134842150347, 0.25363445580710664, -0.565541630944679, -0.4781315446385331, -0.2156700948518521, -0.2337137242238999, 0.3134923980725432, -0.8266782498335896, -0.4436129420888552, 0.26828625424019986, 0.18989621927062472, -0.2732460407513793, 0.16557919433389218},
    {-0.22771077156097744, -0.02577554409102821, -0.4019816297716022, 0.03733307840890175, -0.05795139959837629, -0.6352110249917731, -0.8972241314928169, 0.16750612069767712, -0.42245438030716026, -0.2715854652042883, 0.21661240485861571, -0.08448823302038624, 0.32888802558338753, 0.21667641642195404, -0.35868924089301857, -0.3558530871008447},
    {0.06179377306049768, 0.008507886088386101, 0.2437420229240209, 0.20687479390815433, 0.1520086185187131, -0.11211469383207831, 0.045423278811483364, -0.012825855718993173, -0.03483520906173887, -0.25849337088743707, -0.042332761805181286, 0.25572224583415765, 0.0073112053623169745, 0.06207348640970274, 0.10535435617050497, -0.07883928142134819},
    {-0.3450911010278614, 0.298232094943736, 0.6872584750995514, -0.47967041263303967, 0.59699119209619, -0.03901396281457632, 0.009271468576824853, -0.2122776293265952, -0.3603447181961127, 0.6492572776667456, 0.42958397412203875, 0.1444442835560189, 0.1655377740897537, 0.38362197994191777, -6.697071485203671e-05, -0.314855593916126},
    {0.2900099584176572, 0.5644515208168831, -0.05555972226251046, -0.000969232387125611, 0.24162188237057636, -0.2471726582632202, -0.35644702057950794, 0.28193967366916994, -0.15104451941553088, 0.5149640809422664, 0.5401638024761738, -0.6579206361750202, 0.4407896435985324, 0.3686317565134427, -0.6334076444777245, 0.03275140886919013},
    {-0.3313237904237293, 0.05085973649421121, 0.19089027735030178, -0.12664607083200582, -0.2540263485225603, 0.39916663294448246, 0.3889422846570266, 0.18246677296959282, -0.23031092018142776, -0.1265867923515896, -0.06888039004360792, 0.3094658316431177, 0.06966658060157255, 0.1577868168500184, 0.10967644271258817, -0.322333979839966},
    {-0.4397706475365293, 0.09906277796602106, -0.2727608411127597, -0.20539834267139828, -0.33608544174486504, -0.1596725543883136, -0.44613491037225755, -0.07507286470250327, -0.4206861819400416, -0.23182828331833755, 0.1351399966357623, -0.05031070818957346, 0.1081681090624718, 0.0634184911016592, -0.385465203470125, -0.46649961488661756},
    {0.1227118761719841, 0.3238779764656233, 0.15624539468548365, 0.2781039110994466, -0.1738074261291969, -0.20155019322047343, 0.24642636586702538, 0.2372840270980056, 0.3821626403578203, -0.03399144083705054, 0.4734494824701116, 0.6007914523280745, 0.2204624902639024, 0.23045821962215066, 0.17976723829358054, 0.33978481940962346},
    {-0.37293006966081244, 0.1894214418233432, 0.29023891039349436, -0.07577698296509898, 0.08065955868768697, -0.3702865772715171, -0.060033606689243665, -0.044851127187093096, -0.36034167407185674, -0.12114262013677987, 0.4216539108931428, -0.4882927509627902, 0.22062684079227404, 0.5349617418520303, -0.14841012734398876, -0.6573205832024163},
    {0.1251361534523563, 0.21727896565043273, 0.4829553606550147, 0.784248868961936, 0.5165231453683495, 0.4778159887583692, 0.6394379594263315, 0.4175289018751442, 0.4307257310870233, 0.5680017947180669, 0.22126239522639, 0.3315174108200548, 0.25088491383030986, 0.6259035322156168, 0.4276205064345893, 0.28575040215494074},
    {-0.46107756894385793, -0.10463612020091646, -0.20764755890598816, 0.35045208815540446, 0.2837178724502958, 0.0358424827382968, 0.24924527982406172, 0.24024683560931215, 0.01066802434419965, 0.21511773003047246, 0.3755736924636972, 0.06280275528873062, -0.34416550314715233, 0.21504920507478756, 0.40617332670033335, 0.39306418303061696},
    {0.5555810059224731, -0.04859507148906992, 0.6968613965772569, 0.00694683395384345, 0.3342988894422868, 0.04359350147053055, 0.6414290341939143, 0.11399008935338681, 0.5551298938037652, 0.6060005705190196, 0.5580588865973048, 0.447824657425131, 0.40055871470728877, 0.7771464904164465, 0.6266696573996035, 0.12422967154760742},
    {0.1701123267050724, -0.28734711092850523, 0.0462646599451355, 0.42850719689729233, 0.7427603106321511, -0.40497516641484405, 0.2216846646305257, 0.13110726005717765, 0.09672449613331141, 0.19220794344414913, -0.13470652736137465, 0.35027291662932464, -0.006877132123769647, 0.4474785942520791, 0.45664088120193064, -0.20858814184355423},
    {0.2995091547802819, 0.25770322561218817, 0.3825678806045677, 0.3703523389904047, 0.466553823668562, 0.3825850883299618, -0.047286751546805596, -0.019469464910258288, 0.3287501241450073, 0.07421392342534677, 0.2646076617807855, 0.05793048114545146, -0.19186759308689996, 0.47543967458017095, 0.3748136377057616, -0.2591573665858919},
    {0.3882776710927451, -0.21824943505018757, 0.39601663910942947, 0.558415193108202, 0.19631795221536824, 0.22901366523847175, 0.5392102374130856, 0.10251370498273372, 0.1722491809797445, 0.0815411127526047, -0.04338716589322707, 0.1516685100360547, 0.3797229340526383, 0.42682570665012254, 0.5198193313871432, -0.3519230000989829},
    {0.11937114187138578, 0.3682176782229819, 0.43525342980882176, 0.37158386046150266, -0.06872524164874749, 0.437864497153688, 0.4782724754218638, 0.32555461492389814, 0.1946087151374321, 0.24680911064156486, 0.15417267924290626, 0.3087258675067873, 0.43940950158397185, 0.1439396045343139, 0.06402100456422935, -0.18728473880371174},
    {0.10196369588594735, -0.10472979999674195, 0.3348377332961833, 0.17476540574458208, 0.22988351169635912, -0.03814681542446489, -0.0743630797770852, -0.22489165108231937, -0.5595872615633041, 0.6081701004850821, -0.3743160882420542, -0.21661582708214439, 0.25688872550867947, 0.23322789326267904, -0.012821782568757644, -0.20974603934215372},
    {-0.17030302813149178, -0.22153605604133414, 0.20834767881212, -0.1443474844692811, -0.0004388047162847948, 0.05728318220928304, 0.3175093094705236, 0.18039047875424524, 0.18602318798076928, 0.12189066664206114, -0.29490147034198233, -0.03709983302263361, 0.032049761974227375, 0.048884088689986685, 0.04958397176023817, -0.273725967436673},
    {-0.1934890435877816, 0.08921608184343024, 0.563919633316928, 0.13350647307402128, 0.047358255804822315, -0.15339676007211742, 0.4211685672571819, 0.17050723787752184, -0.2377857314049586, 0.37735063350708714, -0.013377787562768256, 0.24699165709996915, 0.10884725791540548, 0.09867105344432753, -0.06363626799419689, -0.17404666295758314},
    {0.21818569647381572, -0.03986157673794968, 0.46391738013846745, -0.04895740560575465, 0.13335971569262048, 0.224761987186598, 0.019228398014504232, -0.09994021980838826, -0.18038679859071585, 0.007456757027924438, -0.04448856736600763, -0.023956040429405585, 0.6640761027862513, -0.20405989431164942, 0.0896314088754359, -0.5854246857147777},
    {0.06446633970157907, 0.10591104324356097, 0.5504016139910035, -0.09814016318086678, -0.07854858429304452, -0.1506518582428267, 0.07559607727092783, -0.20474421901423742, 0.32336810132271093, -0.026273525975283023, -0.370409210596784, -0.4739999986833699, 0.770410893238288, -0.13538129222038497, 0.015728984603420922, 0.016028734122831814},
    {0.10517714394415086, 0.18608336476604717, 0.30505479980369443, 0.6980540887426343, 0.13248997073567506, -0.026400458479608545, 0.4234111811759301, 0.12269402520720843, -0.343565222473767, 0.03203988045284193, 0.2485823969550849, -0.20372761632960126, 0.3009738156516735, 0.4227713290109586, 0.08936641456823755, 0.34742457214329786},
    {0.1203773904462237, 0.1042021256825034, 0.19587926083307727, 0.46064244759908274, 0.5434813196064306, 0.11430681701111713, 0.6685113722305305, -0.12070471405391002, -0.2812844926340299, 0.049407857211531056, -0.24621902213224237, 0.3536900249052792, 0.07877982773673085, 0.32281950986829755, 0.6056253237154947, -0.06175528996809495},
    {-0.2821490980649264, -0.01906490149501534, 0.35780285016832913, -0.025999159080223655, -0.11146395216801164, 0.3130282759043339, 0.26066511703260165, -0.08452897396025749, 0.12802353161703162, -0.19878798595116737, -0.08744466250612246, 0.11782456298756412, 0.30174178070512125, 0.07474660276164043, -0.014355419487610786, -0.1714438488059566},
    {0.3906893725319382, -0.21014950698845078, -0.19400677156228943, -0.2652329782578896, -0.06831727884821773, -0.24596609672895026, -0.08805743217179615, -0.07090245412915148, 0.14732487250584336, 0.12243878065214786, -0.023463076782860328, 0.02252256437333879, 0.30817507241013026, -0.27639588001697646, -0.3657443905696903, 0.15484604030770674},
    {0.01989544461339491, 0.24244166106116816, -0.24917139350892847, -0.29980981833401193, -0.496937710356303, -0.13061728431447875, -0.3600040681360631, -0.39099013199160004, 0.45380671749445367, -0.1410516795677054, -0.13564548556677705, -0.5731537665433871, -0.07306090142935333, -0.28636482600152047, -0.45163260467511956, -0.3216273071437779},
    {0.276694447295711, -0.10359784168116687, 0.07616139436235363, -0.021377944744034746, -0.1343778412642424, -0.06609712610951526, -0.4624686055056851, -0.07703433367113492, 0.46446142388493905, -0.34969653066453027, -0.3195860164618818, -0.3300595110610032, 0.15928440784758313, -0.2734542424329876, 0.06315939681013617, -0.01778902320805228},
    {0.06274657944842399, -0.3522153198031693, -0.020623000271121638, 0.34477958682305965, -0.1477946894723813, 0.03497117092718409, 0.2570558398964071, -0.18352387312105434, -0.1527404451321049, 0.14053930802658834, -0.4017328269365384, 0.3257275627337405, -0.16487531037669825, -0.09832322977037619, 0.3032263093111868, 0.19133772383583747},
    {-0.4252589309333951, -0.2526410343527447, -0.14441934546053392, 0.3419055470588833, 0.06998665970073568, 0.29302286374341086, 0.05902146484079646, 0.3543324689755647, 0.3381215967489961, -0.11597038627588843, -0.2786467907300096, 0.11249842042872604, -0.04853706203922054, 0.10166334345557251, 0.2060692984783611, 0.5620620545443393},
    {0.09390277016093443, 0.08630058545859846, -0.1882235362293747, -0.19399659873086036, 0.17289209352633172, 0.2549223229583883, -0.031205043889442136, 0.038016005972432654, 0.019772324200542826, 0.08773215188074139, 0.6154423613691699, -0.0009194662901212875, -0.20686171222503316, 0.11882535487485447, 0.4465284574984553, -0.1273053526429586},
    {-0.3914371554286017, 0.0014145212974816788, -0.1839332739753479, -0.04024106037959108, -0.09975579902069488, -0.12081521935827552, 0.1846419738190803, 0.021188016461633364, 0.07439781900240823, -0.11287933873024258, -0.08921646369196333, -0.1985046260998996, -0.41487392781654103, -0.20063736831164294, -0.3002216246759262, -0.04335082370160078},
    {-0.29048892157085215, -0.08515807317027567, -0.08152167849748687, -0.11923081944473031, -0.18265533597708516, 0.023740406222392856, -0.06136302108112622, -0.3156618668972555, 0.11892940889839092, -0.29573028045533983, -0.1640915067330863, -0.43570530693570775, -0.33610323658505564, -0.10909233164741385, -0.2462727172866128, -0.0826895246778314},
    {0.2258902850571584, 0.5881854462348326, -0.38151288520341825, 0.15701919254333033, -0.31974654460084434, -0.019755813940444705, -0.27853445070857025, -0.16289768098003216, -0.17593502140616457, -0.15402936708681655, 0.4635867071086895, -0.2710265825228258, -0.1597489707927009, 0.3184531419109336, 0.02116630025794495, -0.3135468362128851},
    {0.3404556785594902, 0.11032754772126299, -0.3762555432185988, 0.15373112004441858, 0.06046639825970516, 0.286594936215867, -0.22417186213503704, -0.04156033525811355, -0.2374170335320777, -0.3134711737057523, 0.40992622098965853, 0.2446246295379128, 0.009060505368276725, 0.18282250438588352, 0.5377536313254854, -0.010721858456129734},
    {-0.14051724908249102, -0.2199904734091414, 0.28346965682594266, 0.020178783477928147, 0.08248022229724263, -0.3633983291103533, 0.07806723041020511, 0.16095539516738608, -0.011634781599993375, 0.10284729940445257, 0.0007511164490983997, 0.03647094131980087, -0.18008363008878808, 0.18315346755516618, 0.07783240581288603, 0.039135428098006145},
    {0.4053290697148582, 0.13647721732838836, -0.2132056793913087, -0.15377063674721245, -0.14883634018563546, -0.0680805014040309, 0.15991100978695497, 0.34361057354647895, 0.2066132966500398, 0.29391808515352247, -0.21507243129266473, 0.26053535393328026, 0.17686591418007552, 0.08655191818328126, -0.4738620387257301, -0.11091629385834524},
    {-0.4421644368512293, 0.21102482111926066, 0.07869792668081896, 0.17054202893673928, 0.181307028718358, 0.3233029618993345, 0.5142781876507195, -0.08382270481279343, -0.35135504846080057, 0.3994904581986438, -0.006567402756847978, 0.275107345388307, 0.17510592168998412, 0.1889798697459675, -0.12832682533404913, 0.27618680100812254},
    {-0.011763501836220444, -0.04739641163886551, 0.4004191976892464, 0.385346140497938, 0.25987143511770583, 0.5466748498963432, 0.29324614192574683, 0.37436442398877323, 0.1798332367192334, -0.1415724841410926, -0.09363318842529698, 0.5014573678708153, -0.03418196642825412, 0.012828329763584239, 0.5765712751019626, 0.5838590451998904},
    {0.14045861206619348, 0.42844522369923, 0.8010838790344826, 0.3832789902077731, 0.5489722444009466, -0.11947694519117369, -0.2601669185573174, 0.1624109137511443, 0.12809695639876667, 0.6320671826046717, 0.26532774214856797, 0.007203291661608789, 0.09940463178454025, 0.05767714632039622, 0.05329919661566434, 0.35131420991024354},
    {-0.15069203338312606, -0.20366312122765104, -0.5809904785212051, -0.3021356089439241, 0.2250241147665795, -0.20710691774978207, -0.29139489376265443, -0.15185047551757544, -0.19343191447367797, -0.1875714057498737, 0.08294232280203327, -0.4493216217575816, -0.09066783611961024, 0.057216744287763396, -0.3422390657325743, -0.4824704233719938},
    {-0.07765672148389681, 0.16635440438580798, -0.1809057680005809, -0.4303208338318438, -0.25121056981515394, -0.13935414999507167, -0.16360898037712907, -0.18763853396551197, -0.3163382962293865, -0.04053313248936158, -0.27653153256192803, -0.05107711142024453, 0.3451832494908485, 0.034475138512775734, -0.2939051223090615, -0.7143897174822106},
    {-0.18714654182270873, 0.2605338605024145, 0.598840856400004, 0.15745315878566593, -0.07921225611976267, 0.08365497496495983, 0.2955922069014573, -0.04855754076218017, 0.06471080751858252, 0.3206133775588847, -0.020921660648604134, -0.03303394136502474, -0.005088987352342461, 0.19205985950600377, -0.07912012627278997, -0.13415329844439697},
    {-0.18875094160886022, 0.5109893971600324, 0.6053346791271337, 0.040781870119596345, 0.6088531552908586, 0.3151900980770618, 0.16051482500738654, 0.35433716428448586, -0.08224495454406268, 0.3686548910914298, 0.5197550088555815, 0.18266248872855523, 0.010783461252343697, 0.5681957551730838, 0.2991877097596014, -0.4855162422251526},
    {-0.2434121516608025, 0.19514975469145962, 0.11963172632380578, -0.19598942921218418, -0.13948047613854692, 0.04846633302324558, -0.30924201628261194, -0.09213447584312831, -0.029823763295972493, 0.20258683794811652, -0.4083877697716944, 0.12495421807160913, -0.2597565584110877, -0.554603574156091, -0.3600830256621198, -0.26887292482006225},
    {-0.388096228004682, 0.2233301171017767, 0.012239417744689826, 0.29727178896442025, -0.3597230198066657, 0.19106345542454276, 0.2009237698651511, -0.333845133386784, 0.13198148307048446, -0.2647512563880186, -0.14603826032693124, -0.16827573075467195, 0.09995299947368844, -0.3890935989429987, 0.08710693429372365, 0.21420181262696222},
    {-0.4775458957491548, 0.021855436967022517, -0.2979882819390223, -0.020315750118199156, -0.303446495371638, 0.40309476252407106, 0.2673508134631251, -0.028002939109114038, 0.14808933890523038, 0.06987156832040657, 0.08273956182565792, -0.15092098106356616, -0.5847036086024514, -0.12398168213182047, 0.2508573797304414, 0.3637309339059128},
    {-0.23318992983649256, -0.5312341384880984, -0.07750565091848304, -0.16875567030059788, -0.07253290925954252, 0.3165685373219148, 0.44381264940024173, 0.06016544206333766, 0.10876758515488519, -0.04547305088430059, -0.3981077956106678, -0.18837487565208197, 0.32786824460380676, -0.16722135596991794, 0.3160216736387567, -0.017370168516863328},
    {0.013055222152537512, 0.5168542262943775, 0.21633649917810666, 0.2079821972144111, 0.013623432199728454, 0.15414403955639347, -0.1432777876475856, 0.18545774494502432, -0.21773592434252714, 0.07374931639241034, 0.15651942759889934, -0.1291469672888961, 0.24258028975872975, 0.06326996584734568, 0.03577612927206294, -0.11874656017356508},
    {-0.3539764453012504, -0.16472754631881165, -0.4022454253828359, -0.1902248905784008, -0.2169959377134424, 0.1360386260387908, -0.1011378296051492, 0.20867955417588616, -0.05829373049214864, -0.2292073039039606, 0.10905324166823627, 0.04600892356604773, -0.007535817863264833, 0.03582998058043881, -0.2906216075026196, -0.26225425323725987},
    {-0.6220001852616908, -0.13579075570979118, -0.04082232645682166, -0.4348941270368207, -0.23736098621098353, -0.22244405655273386, -0.355683109159941, -0.43501745512458007, -0.4035429274337189, -0.01582588580710726, -0.02213010866311157, -0.33677891596472437, -0.36229525028507953, -0.15988523648231281, -0.402894453117038, -0.463937169847546},
    {0.42856732633662775, 0.3988705158220257, 0.4369210964771449, 0.11281499963208146, 0.2534864025709077, 0.15848649507500767, 0.40722188442934265, 0.16638155674730276, 0.4672140922189712, 0.468051783888243, -0.1734811160230229, -0.04367297058257219, 0.13045278784817263, 0.27701768163413937, -0.1540114491958711, 0.39122406189577863},
    {-0.4142807693624876, -0.10551847219926042, 0.35730511973763973, -0.3037815028140219, -0.16535331196160966, -0.12371724231238296, -0.011689276633259412, 0.19252751986449265, -0.06563046859576108, 0.07689739822272394, 0.02159693578366874, 0.12484172435238979, -0.1346037350829632, 0.1845423592403326, -0.05810549882426346, -0.5490740681157421},
    {0.09764868360391545, -0.3026131981933368, -0.7984203250333963, -0.4270698696782937, 0.04360567877127122, -0.168293723633681, -0.28695307264749775, 0.0634911375378058, -0.4098379275127862, -0.31470011750274807, 0.18780372410367926, -0.2293806625250113, -0.2229694109218444, 0.05762750519064797, 0.1881657623094712, -0.022749769660268652},
    {1.1106415155524776, 0.47726223883488966, 0.2675449117207974, -0.7909305524550939, -0.13809828954603098, -0.9199931828009953, 0.36930763436926867, -0.21291049580671634, -1.5419340082518278, -0.8286233380999329, 1.0019711229747894, -0.7508437756222701, -0.3090259298180604, -0.4916496053891336, -1.3764896454095354, -0.035624360325608305},
    {0.6913636241999735, -0.05979668519649709, 1.0570711348828323, -0.6669383576479856, -0.9324254308949259, -0.4546393533105586, -0.256128370666531, -0.16910750664977034, -1.5204908847777425, -0.6067684720579969, 0.4350276560707702, -0.3930926612355951, -0.25607754940289484, -0.17569328791593425, -1.3273255571164646, -0.2873782185799082},
    {0.11968269951236939, 0.6540261450879742, 0.16927061819230035, -0.7519765660930551, 0.1976941806271161, -0.5938181098478257, -0.6994795558924835, -0.023402449747810184, -0.5377081722024761, 0.09533725059979276, 0.7704007952502819, -0.570681687448957, 0.08216509149005274, 0.48213190210224766, -1.0832860506027624, -0.511607394265116},
    {-0.7523960021916638, 0.561147654360073, -0.06555645700051155, -0.28651750523225034, -0.1352045513649461, -0.2243440921871092, -0.14042463648473452, -0.17647211872095744, -0.5030123313056651, 0.27866134712234536, 0.846348179713923, -0.3710943647611047, 0.05263234715489891, 0.23294957660395327, -0.7967258502222527, -0.3493856414521593},
    {0.06959391195771854, 0.6316706288088466, 0.45412651365511253, -0.1130384518676395, 0.20364435764367822, -0.013714334505771995, 0.10673175874850345, -0.07240540463905411, -0.26229378333322734, 0.3477692212035417, 0.6042545283388553, -0.31920101431623654, 0.15086510121574762, 0.27931203472594157, -0.9030206274995314, -0.21268956043003878},
    {0.033429294111598985, 0.7750659038843445, 0.10828383345419507, -0.0027322088293081324, 0.3690945991386789, -0.13046878457418365, -0.18441831044438659, 0.10080992937055018, -0.39978530048357425, 0.2952656509038806, 0.8112457883875702, -0.6036319233544899, 0.08937726893128164, 0.14592463558968205, -0.7557705792205234, -0.06828032739261997},
    {0.11189813457752529, 0.18881771392651106, -0.29488295085218535, -0.2507863906176397, 0.052727520514516145, 0.0597770478486653, -0.5392665548788035, -0.0965365762021867, -0.41876201496977705, 0.01620116129379606, 0.04745683280496897, -0.20043033034928157, 0.15029411175110088, 0.056123452689187406, -0.15160654506629895, -0.244857595401992},
    {0.030426343697188173, 0.09380336339649621, -0.10275276495448638, -0.3137703573191232, -0.18679706319587439, -0.5860223777887404, -0.14308202767661776, 0.12102096920685441, -0.41960054551145787, -0.08854351479715152, -0.5673202642067305, -0.15635228780312602, -0.17249782265895666, -0.17767095758892745, -0.9532070702250534, -0.27615502524094443},
    {0.26931021887832796, -0.05578576584268578, 0.12530954002637812, 0.30723013345750183, -0.03949860855488486, -0.04501650063119053, -0.5860405996474475, -0.3108602263671923, -0.6496174514139873, -0.4552222678746245, 0.23243732860320812, -0.21344067104208642, -0.18714908396839253, -0.10229813291776134, -0.08038052417828882, -0.22026478468511393},
    {-0.32190949087407916, 0.6011509624627047, 0.40161580303840183, 0.4886167936616739, -0.04820167427764584, -0.2893604302368714, -0.31591889759045116, -0.00309836379921756, -0.42771123616990664, 0.0010392249757815051, 0.05543185763767042, 0.19301323872834386, -0.37009261791217174, -0.1824267088780273, -0.189690786637506, -0.0359361835196177},
    {-0.6193825189357434, -0.10484691976445289, -0.0386554086046677, -0.3381905483229263, 0.21200759679288653, -0.4130146069335398, 0.2150778583120853, -0.11047973443038386, -0.5121457214630579, -0.47810738198386216, 0.3850886994224463, -0.3175244181475552, 0.019409083103270885, -0.38552280973184766, -0.5298544753085989, -0.4647730724675656},
    {0.22180149967018592, 0.2670206034658415, -0.03708759628292403, -0.08853172134969498, 0.021570113965043772, 0.14036512734529183, -0.5631700293127427, 0.402083352402248, -0.11147959756656305, 0.12034828628216868, 0.6119140821277139, -0.37052986741162636, 0.41789155885004686, 0.12646984448435813, -0.5957954152807907, 0.03526592944437236},
    {-0.09109687775534461, 0.11624368915217562, 0.5163751624562748, -0.12150447848510759, 0.08405556737874852, -0.341972494048513, 0.07591278019517807, -0.17725064478833624, -0.1845939985438748, 0.03663291721282027, 0.23680509735104333, -0.12329687873176119, -0.06086110900235853, -0.21914726482780425, -0.28545329738839054, -0.43159747481150623},
    {0.0746619784695622, 0.18863589401942885, 0.025803227619349906, -0.48331976938668025, 0.03074351722038042, -0.6851358769002709, -0.74682326687179, -0.00955114340216514, -0.4468884565724128, 0.09640272434623606, 0.07183924620999789, -0.18077496541205323, 0.4310966416103018, -0.043835262165570266, -0.7768158536587406, -0.9802608476975383},
    {0.09610876551774596, 0.05938305352979228, 0.23623258960095558, -0.055793640028184405, 0.08590488804478626, -0.0961384849046532, -0.039786421445630576, -0.0756152507269217, -0.40406254806785497, -0.033523746366408404, 0.0550353073556174, -0.42225208601797193, -0.026077136830635856, 0.07200005777935574, -0.21860153624028775, -0.35233077498727144},
    {0.09558808286285703, 0.05034724772935699, 0.31486601596438846, -0.3319488528982731, -0.19408391025845897, -0.08304343247344173, -0.025478968339750625, -0.0609574817413652, -0.3734305489010799, -0.20923930770603963, 0.5006997239204459, -0.486873179166121, -0.5734126613370228, 0.045711601464049546, -0.0565396326702695, -0.2608384822266714},
    {-0.19256795976693294, 0.25784133158542377, 0.6863747232114621, -0.2693510948157233, -0.2798518115742183, 0.17952495132237908, 0.3763345137772657, -0.10366450063399671, -0.15576442734633805, 0.2283732471682371, 0.11029096735326815, -0.26936939580554087, 0.46501896338944443, -0.008202185183294068, -0.479831759839806, 0.22415858858997298},
    {-0.5877355501991234, -0.20330946033855418, -0.22484175031689915, -0.03437015614380648, -0.1705760676846417, 0.04641904355020726, -0.09733819160375512, -0.15412385939747808, -0.6987687491238135, -0.36022827596452034, 0.1806642268146299, -0.29626845686148917, 0.0831332079229277, -0.1821513185644456, -0.24701380267267484, 0.3836052735035476},
    {0.08567218615671118, 0.5116960822749891, 0.6671222882059719, -0.26625307820621513, 0.20747136380344014, -0.2527173443314953, 0.5907571135639472, -0.11851774686069272, -0.6654135781080207, 0.4578229959369816, 0.21342191876495248, 0.1588040934613706, -0.006236499688120269, 0.139283599257275, -0.15854806095191787, -0.12467814679330003},
    {-0.06610719080072125, -0.11425367130286365, 0.6839288417660919, 0.12318381682697604, 0.1028551711267837, -0.5140667621599928, 0.22904181778793162, 0.039988460974887265, -0.1704057504713324, 0.1674920505851781, -0.07221287196772051, 0.11842135655366709, -0.13225074881798982, -0.46475503375630156, -0.09346497000672105, -0.46719961306353947},
    {-0.36480977557986155, -0.030772386063583457, 0.019508574884307153, -0.2646765070216466, -0.311155775079764, 0.014725998615561337, 0.05459947382122938, -0.1041304819796973, -0.17427447107191946, -0.2391117642593019, 0.4892457502017368, -0.23223108924842337, -0.042109728742202764, 0.04498520318788841, 0.3117070353980454, -0.24887093821933265},
    {0.014405058840407606, 0.014121975190930528, -0.20768966408341746, -0.27827224316541965, 0.0734794191589675, 0.16717489827598084, 0.24770161068416036, -0.1460514629619504, 0.05520534333788262, -0.11945830934400564, 0.6526777396131264, 0.20531506941336738, -0.08435933826357842, -0.1495496496915687, 0.3862996897667804, 0.10945410440541899},
    {0.08752054279512513, 0.48723532555003923, 0.0536026672643721, 0.05966389200515057, 0.1711300192554118, 0.2469600627157272, 0.16421027507067582, 0.26725673588218396, 0.04244699242089591, 0.11969615194303909, -0.25533992965466046, -0.010764158005813027, 0.12680514232084436, 0.1659243449812478, -0.13790841066501552, -0.028454046199855764},
    {-0.10782963418297829, 0.045422791607439034, 0.12897788245846545, 0.10426495299919761, -0.2744384988666162, 0.0668033933767371, 0.38117802139487655, 0.1725118075014073, -0.18070261492336562, 0.05234866755596135, 0.16240426927175897, 0.3270056454681442, 0.3755884004657931, 0.37207835837388914, 0.14810114714858594, 0.28040462108143394},
    {-0.5842515502822185, -0.4857255021468795, 0.32675752440340616, -0.3218310870921479, -0.05786171709695179, -0.2636765450814552, 0.2621741904155462, -0.02272874656620471, -0.360935527847217, 0.381687765234525, -0.041476539163959124, -0.18289667592848977, 0.03287029851893423, -0.10159942149123817, -0.3924136097888428, -0.01041317923720675},
    {-0.28254125937636587, -0.02913216284098373, 0.4329282732515828, -0.1908591458684457, -0.009848668782274762, -0.18811825250272501, 0.2636824607793155, 0.22401742787384715, -0.15613489595547803, 0.1346765197878955, -0.12378733574066951, -0.049171645133610414, 0.4338736104288549, 0.3435168617130272, -0.008137056953065491, -0.0541265561144406},
    {-0.03733475636450502, -0.015109094180337098, 0.6217196923937348, 0.008509395324011501, 0.11614680816459604, -0.16844305735419027, -0.05573750208684849, -0.0448834513159416, -0.14520083511040027, -0.37830813657336115, 0.06071056897726471, -0.1731016696917535, 0.02380762576852344, -0.19134681051744232, -0.10493743451126458, -0.4611879999413748},
    {0.26218557106479184, -0.31703264970326706, 0.3301403194053346, -0.31904078701792893, -0.02395645858994456, -0.42652450604899905, -0.30848863698737894, 0.13842383225186938, 0.24630951072622712, -0.11480870039569374, -0.24999853924156368, -0.20384618244614924, 0.33270719048748626, -0.1371021999985696, -0.09549679674311697, -0.3152240474794173},
    {-0.45955101384327274, -0.18863841134294326, 0.23565218041366726, 0.15567345596051305, -0.11543594671731104, -0.12032453517421245, -0.11155808414463153, -0.03447740255386316, -0.4650511505077045, -0.2507377128913518, -0.15422297362536252, -0.16429037234917052, -0.1327204362857736, -0.5524538831842457, -0.17618063022521052, -0.1116436614836064},
    {0.10840239971863556, -0.16317420161917454, -0.06630674522477108, 0.13321486908071245, -0.08269089315968982, 0.2794416704312532, 0.350781752474547, -0.07402521299993109, 0.03860646782572255, 0.0730030265475639, -0.019666077230329534, 0.17967949461631863, -0.3778573021664484, 0.2568932907832724, 0.2139689265513937, 0.14350947150321133}
};

static const float b1[16] = {1.7302996640739507, 2.0804907778742314, 1.79599118259813, 1.4491931589192135, 1.8380152667551437, 1.4375829831652922, 1.5104813574751408, 1.693020513476624, 1.6136532592222124, 2.054165030724297, 2.1262563576919224, 1.4070486337446009, 2.019253042595358, 1.6293698058607704, 1.5141287564993025, 1.490375842797522};

static const float w2[16][12] = {
    {-0.6704039679513799, -0.2542159299006604, -1.0841718692033293, -2.0203071856230173, -0.881386178399203, -0.23577754862544237, -1.3029143504650884, -1.4484342743419218, -0.896309068231817, -1.2896634619194565, -1.0625838096539963, -1.467394831424097},
    {-0.8461917771441256, -0.374981720028134, -1.0783185340351367, -1.5677414278062753, -1.500516405522105, -1.0629663760115622, -0.8191814025180608, -2.025843700802919, -1.7653090481545295, -0.731307426079621, -2.0408943148361067, -2.060552648232712},
    {-0.9975287584633482, -1.0331858600484496, -1.4886762771716624, -0.7772288510036215, -1.5035373800365601, -0.552357426067375, -1.0784006135662372, -1.2524418129142563, -0.4387540324561235, -1.6484175494442548, -1.18673837846603, -0.3441518985595815},
    {-1.2297433320331999, -1.6468666042210256, -1.0380706106263176, -0.9394904050850039, -0.18906057899855655, -0.8445940414725255, -1.1483605979728317, -1.307344767782844, -0.919387855043489, -1.5440953655879839, -0.7930332174428492, -0.7696001902549318},
    {-1.7754752107701037, -1.1723853296267661, -1.0154927249247017, -2.2628056881643874, -0.5807801723176192, -0.7883001894719766, -0.9531431110430814, 0.3295919514842577, -1.8823436855607802, -0.08005165768030727, -1.1222333127602862, -0.43387416168420784},
    {-0.3783359531946774, -1.6005874176803854, -1.3865271043199967, -1.6610031724586085, -0.9818176752569625, -0.6248271827836137, -1.1406120383157772, -0.5108692251272079, -0.6381502310954373, -1.260001314535246, -0.8730099198108748, -1.3003521772657338},
    {-1.2475499346178835, -0.16344860895205685, -0.453600104612102, -1.851312318687237, -0.9661569560876005, -0.8916332101000014, -0.977434821199168, -1.7753309004536086, -1.612522261853311, -1.5430332762131655, -0.2607171723483891, -0.8391732075892203},
    {-1.5471951747372337, -0.7773779695899099, -0.16353621019600992, -1.5611133997728153, -0.6093531447741639, -1.9767598104706006, -0.739430537015852, -0.2479706507620612, -0.10176659042287192, -1.2871994120804446, -1.0818026550558708, -1.984427804212054},
    {-1.4129247522366277, -1.541731126658877, -1.1338147899606268, -0.11419809395353894, -0.5921467578229926, -1.5147124851442502, -0.4884232887856226, -0.5567153433167251, -1.1521853112587677, -0.6570530765963314, -1.682125883288432, -0.1762433804466335},
    {0.0581146157847769, -1.3463166149748005, -1.4696156422390099, 0.08887506368239892, -0.58576978260858, -1.4244812963048932, -2.3318390656023404, -1.217062944337742, -1.572794467160725, -1.2565390246412325, -0.688825400571883, -1.6404192752414941},
    {-1.8877472028964846, -1.1136784619909128, -1.713901452095328, -0.7063516745992175, -0.917547305066095, -1.1913151047175612, -1.5477603648502376, -1.089472274638414, -1.0252513279982274, -2.124362284211946, -0.3543337042450876, -0.9957789260509101},
    {-1.2055070964191654, -1.0661406128233089, -1.4550784150946028, -0.5484911309394007, -1.2014369523508373, -0.5424298100392243, -0.2460696338313132, -0.7910608831143213, -1.506938430199601, -1.0031839120129598, -0.8524979973257494, -1.1833430756573617},
    {-1.7048241381850129, -1.7602719561287024, -0.5158166584021587, -2.233763338156655, -1.1697230374746523, -1.0966336509999512, -1.107726419235265, -1.3668856390490907, -1.6718321385136463, -0.272969166340859, -0.5392927187094754, -0.7447897586226028},
    {-1.7007069952784881, -1.822828298751811, -0.7616296201524697, -0.884784578628023, -0.8881373193910699, -0.9309119480761644, -0.07928798189095786, -1.1431454989665133, -0.1160887867819492, -1.0001304898748595, -2.0086868287955557, -0.07629235204986029},
    {-0.5935067416226538, -0.6909223095965459, -0.8655552141640402, -0.7009514117953669, -0.885742300908686, -1.4831878944690269, -1.306938253718777, -1.3580469454002242, -1.6118547522472193, -0.379686858996595, -1.6785925030518318, -1.0117305669947094},
    {-1.015142631216431, -0.6587916776480972, -1.407365545491247, -1.0807990763666213, -1.407283629589305, -0.6321032758674611, -0.9009376856935317, -1.0757198453370598, -1.1754080909162914, -0.5057493031072808, -0.9944019085141508, -1.315436183860537}
};

static const float b2[12] = {-0.9374761153283128, -0.6977589853632058, -0.8184107236269562, -0.6906180884481902, -0.8973288401259176, -0.4722819030510533, -1.3730031206095215, -0.6984303791974575, -0.6750559109842139, -0.5776190016311545, -0.44045300353887623, -0.7975803808416904};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
