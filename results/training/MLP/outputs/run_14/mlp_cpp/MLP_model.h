#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.4304428775957493, 0.7598691444682735, -0.23772333888732405, -0.6260554165322021, -0.9126031991755111, 1.0344701515473829, -0.6780843508161223, -2.1037827941961136, -0.27239268414239787, 0.345945227695592, 0.6435159018186851, 1.4577615948231963, -0.6731694416513364, 1.435344159812555, -0.41080543021948285, 0.7126397110249488},
    {-0.20257696901564476, 0.7966575680672261, -0.39316829813363224, -0.8713698605899196, -0.6291607270417235, -1.089746470252887, -0.1935258590342455, 2.0014820965530293, 0.5153315649110427, -0.6887583838128962, -1.4663257224018227, -0.43896028928350284, 0.9511371513115889, -0.630635864249279, 0.5917307028730113, 0.12034635719779588},
    {0.7113786514368896, 0.3232658552126381, -2.0716518665349404, 0.07055226119682886, 0.6175916841788001, -0.07244856584831791, 0.5200840377571901, -0.42510639443763293, 1.1662326801777176, -0.020404701589426224, -0.6992986605913465, -0.6328422196802624, 0.739091381552179, -1.3115441081338495, 0.8616804382835408, -0.5962235522604632},
    {-0.023310837829385155, -0.7583536544577381, -1.3108428439072988, -0.8931091224348052, -0.3325185512221086, -0.4105658216062203, -1.5693051002957543, -0.7823264949665848, -0.22052393745645843, -0.6598214294992758, 0.7061421373581072, -1.2738539125637265, -0.6891249754295904, -1.7055214662473446, -0.13301594928285423, -0.2831874801283487},
    {0.8404474090204089, -0.996673105934888, 0.023726274274020825, 0.6944881348939372, 0.3043679323383596, -0.08411254019242621, 0.9345477146319741, 0.11726012312091189, -0.4887411246822703, -0.760483803306521, 0.7004119438843806, -0.624290888009205, 1.282753479633507, -0.8866557927480888, 0.5728468812695999, -1.114433229909486},
    {0.5315892520886338, -1.1974664327349998, 0.16580069427401745, 0.8721817640210557, 1.1212894020463802, 0.3872534045111744, -0.028161028368604304, 1.1894391210948962, 1.3027174761395846, -1.124856689074342, 1.4921650955833055, 0.38112339987812355, 1.1800887667763855, 0.4006484209600301, 1.3256180246552516, -0.43435943527901305},
    {0.6564494258796588, -0.5972023691246515, -0.28176319702950714, -0.021777113208633136, 1.563514119413506, 0.7127222367570665, -0.7696667854371677, 0.7124348747852176, 1.5035912518835683, -1.0064584003711694, 1.348658240551686, -0.5888319266529062, 1.0076537792769371, -0.053640085478437266, 0.25196385137244587, -1.1649099602493314},
    {0.6802108128964969, -0.53985189045327, -0.44275748206690757, 0.43661573344658994, -0.08574927957335353, -0.8000917945421053, -0.0908897483026966, 0.23797067738639957, -0.8443886369273336, -0.605301812571763, 0.08198146500801118, -0.44625281865611455, 0.8797541736609473, -0.7697799810326138, -0.10864028683600899, -0.7176163989632547},
    {0.8210763728186014, -0.015185663305160517, -0.9206135848757234, -0.3899432864729692, -0.186603037787272, -0.5888972587440116, -0.2736112284185359, -0.33982665124063793, -0.5483225772768121, -1.5049931342811032, -0.33152829666165706, -1.5566868695496006, 0.5506201982523762, -0.3891388407457009, -1.5938474468571777, 0.5766840316560942},
    {-1.0307948734818593, 0.7482094479802576, 1.0969186146625909, -0.503712051652804, -0.5532282282662848, -1.0278499228760585, -1.1017216852374088, 1.1430268029903121, 0.29690018583203404, -0.306165882508447, -0.94688911151783, -0.6446763146893526, -0.7853760136982648, 1.0691840363004754, -0.6009372339428285, -0.09522524943089976},
    {-0.6462442258799445, -0.4439524400062151, 0.37058485015721787, -0.5940422891263326, 0.0293707446100485, -0.8054651020208636, -0.8559491909868014, 0.1710216572242446, -0.5439350201010293, -0.16367526796227905, -0.4609669334126408, -0.24442800229646705, -0.57995135691531, -0.08568395333943295, -1.216071022685594, -1.4717901143696344},
    {-1.042297723567482, 0.33129854527820873, -0.747589455301807, -1.8434615160136543, -1.1812584636011199, -1.2183111093431673, -0.6449760262019553, -0.6380386290347638, 0.5967408468923358, -0.5612935735309494, -0.2074079906914039, -1.2145773033317775, -0.4876212080271647, -0.5347411595832763, -0.14729294545159033, 0.22951046858398008},
    {-0.3135447834105245, 0.3716109532708095, 0.15035670446666247, -0.49335283522544393, 1.231325777078881, -0.6255932383520125, 0.9949641697020671, 0.7469480471519838, 1.0568507156117741, 0.020528559219385088, -0.9593087347871829, 0.5594548037757215, 0.7697095107740478, -0.4050334335429643, -0.2805150821282306, -0.07419298252077304},
    {-0.3241892832329695, 0.21305836996935787, -0.08408285674447567, -1.043667381780191, 0.5345369363848722, -0.3412602447893658, -1.2174844989140694, 0.6084011069179636, -0.17044019901625967, -0.45467522175172126, 1.823426473026425, 0.47013772680075494, -0.45335756601434757, 0.43421123684662144, 0.19473295354587233, -0.5580609133444694},
    {-0.036688550609054106, -1.043254599426032, -0.9709522776929556, -0.05730147240644751, 0.9990712192583047, 0.268596805447988, 0.3290565881325274, -0.42601574402550396, 0.9363029791163615, 0.2901410300696492, 2.2298931958459014, 1.3825466032173566, 0.015259662158907823, 0.5021037578963993, 0.12810348764078347, 0.8622263930639421},
    {-0.46364701384976564, -0.26109102328887723, -0.5361055358757074, -0.6245295616968987, 1.6805846977585368, -0.7005414133472526, 1.0950307229657017, 1.2639690707534965, 0.6168386160870486, -0.35799917967108935, 0.21710575264406, 0.8959012975266097, 0.18513588818336957, 0.39243517312996157, -0.2191754627693136, 1.0972617998021743},
    {0.6654674430123573, -0.7565170656776674, -0.0334208844781828, -0.27682409767306965, 1.0268255659381569, 0.1923012288084621, -1.1243961026597993, 1.0774480462225908, -0.10309141887773714, -0.34924553397993685, 1.1866605905912524, 0.44266232163190583, 0.49147867439453097, 0.7594320028743511, 0.35008929032004493, -0.28965218088054095},
    {-0.010608595488310585, -0.2772103787796587, -0.18771793880918533, -0.9911359299431797, 0.6863351058250382, -0.5068231090568924, -0.7289651509283759, 0.20914048458150827, 0.16927052004039786, -0.42008100104477886, 0.9559994409206054, -0.42428733606855334, 0.22254728760130177, -0.02934968121460961, -0.10328912229778207, -0.02261075023334329},
    {0.31697554904853803, -0.4308537984890747, -0.9248986816898056, -0.43611792116073256, 0.0493349274603375, -0.5312233239183741, 0.3889264699239679, 0.12508678840097548, -0.30934888081286804, -0.7711126829426365, 0.15757002178841822, -0.6108762696454904, 0.31982767106480203, -0.8699726690157035, -0.81975630112731, -0.11830429450724217},
    {0.775158684356845, 0.0382072804837022, 0.24155073023627693, -0.4890118973756, -0.4843783769791293, 0.09704704046596756, -0.739007360514535, -0.2714493350878295, -0.2087897553382105, 0.883366072412348, 0.5436663278591434, 0.6784344518797749, -0.425326324667693, 0.38356160474856826, -0.5364150009153688, -0.18343405055240816},
    {0.3370153154940488, -0.9898592784260798, -0.8380428988946799, -0.3424414620164495, -0.31156759327498, -0.5294659672476244, -0.3675567928076913, -0.14065039380714398, -0.22590340557683872, 0.0017199121878380401, 0.6417987673906926, -0.25462373919518766, -0.6091117468988556, -1.0498432146668557, -0.5264411607161292, -0.2733083023824449},
    {-0.9494910394197522, -0.9819630065415155, 0.4760784393156832, -0.14660570058864972, -0.5036223563236115, -1.02242755873888, -1.3210437077633832, 0.12428810602451094, -0.29537918125771817, -0.4378550520667953, 0.9948139552566211, 0.5444832199109989, -1.1172480902529387, -0.2715065082591729, -1.1220157080938444, -1.2245712902724548},
    {-0.40124933432711124, -0.34709488768676927, -1.4354726903098047, -0.006164440648535301, 0.5508648894747318, -0.7659273655015112, 0.1553706142552617, 0.14433680662677184, 0.31750113713160694, 0.6228524087448184, -0.014447773130694352, 0.7379257996224736, -0.8044888709952731, -0.627669287861448, 0.08150958665406445, -0.7055439632222121},
    {-1.056166156202707, -0.09635963594998172, 0.20045316027574947, 0.6397001174708129, -1.2884945017332008, -1.4092447301782463, -0.06997624028858351, 0.33334137818037085, -0.4865757072425539, 0.5138036825475104, -0.20719092007962076, 0.10273828727806121, -0.4661357811734179, -0.5803553764258481, -0.027338400284504023, -1.298171817324413},
    {0.39357594052250444, 0.08995006551700456, 0.4108978049645647, 0.6469113551834241, -0.7790101105404307, 0.6197954641207492, -0.4690077439370423, -0.18715024657456739, 0.14973132245588153, 1.0063514688178978, 0.6420604271931756, 0.7636009852707979, -0.6986527516874643, 0.7719598696418756, 0.21690599185143375, -0.8493780299636068},
    {0.4201296690558619, 0.7821021896749373, -0.17931101765276236, 0.4119606024067804, -0.9842768572208802, 0.31316907592324345, -0.38329304492563365, -0.7164392641970918, -0.5953855842790476, 1.3042295664298413, -0.37849853582374887, -0.07565334564167893, -0.1544793187677259, -0.09439893055695328, 0.052391492958635724, -0.08042776625855348},
    {-1.5116949803321929, -0.8443000274453517, 0.4462827422760076, -0.77843284536123, -0.7218867396791341, -1.037215075671877, -0.676315233664292, -0.6658338838954715, -0.33705628789108477, 1.0437999067322097, 0.040623569999070026, -0.24873450130843264, -1.1087665240451676, -0.47689121573238086, -0.6762296394507414, -0.52895619120083},
    {-0.16027900342767137, -0.28153861287618254, 0.1260403469668442, 0.720360919617818, -0.3470114822032209, 0.11124898647673534, 0.7593062055558534, 0.14834405405450443, 0.5464466664070292, 0.5418852381845779, -0.6627249043935015, -0.3848242122160329, 0.4807694200472129, -0.9875552429489358, -0.23846066783722883, -1.0339712807445145},
    {-0.6044450010828867, -0.48979124189386225, -0.004740261910994544, -0.42742108205782386, -0.5707636108837714, -1.3714040413772774, -1.1216424396665747, -0.17974670047472974, -0.27152102273745776, 0.19450605785293296, 0.40884762073769054, -0.6998482765554052, -1.0670243147113025, -0.6820234203167053, 0.3879042409894616, -1.3455314832433733},
    {-0.7058640354492417, -0.36794774184501505, -0.15411376665101761, 0.4712733472266417, 0.14858414681223056, -0.46024983352795434, 0.6360111338776752, -0.015788209478005077, 0.09123062551234606, -0.30128619613432656, 0.649653958894698, -0.2623467944303005, 0.3098479351911682, -0.11218162348442096, 0.6249785897879663, -0.8002105528468981},
    {1.4319756904257808, 0.9464208031464397, 0.6704436777115139, 0.801937749306383, -0.8419701600886876, 1.9796351585263008, -0.34981653633859205, -0.14372754920792832, -0.10752640102771185, 0.90973805878183, 0.28131928733668626, 1.711869390431435, 0.2963415394272851, 1.9244610466236123, 0.10593978924952611, 0.8879539197633305},
    {1.39498395884539, 1.358863238856671, 0.49813874664925634, 0.5327919753161019, -0.5240211414957144, 1.825738208585152, -0.7375181165733616, -1.168288295427339, -0.682297321569617, 0.8849142081854958, -0.49623848784219554, 1.8507241577494777, -0.26236804076955145, 1.9713714268414524, -0.5612648266012702, 0.899792235597472},
    {1.0610692313743995, 1.3217410718834888, 0.5683130983301045, 0.9861980888169348, 0.03921004505625265, 1.8807695431558906, 0.10154570114360101, -0.5303809081814513, 0.32753338195237636, 1.106718106426818, -0.12467353549771751, 1.847780427760266, -0.48492711226433455, 2.04364287148211, 0.23584846622018255, 0.7803324306504169},
    {0.41682604242673077, 1.0014836600463686, 0.22424938637037203, 0.9246491695609003, -0.4727034197961975, 1.3417926274006102, -0.5461881538721174, -0.3018155452848619, 0.05122530860471028, 0.7940171494569237, -0.8663301053106366, 1.379744699772171, -0.2610161741553162, 1.417731534089862, 0.13647832875479893, 0.7287566519718246},
    {1.3104561881045016, 0.4886015980462717, 0.43371678725278423, 0.9406102333492105, 0.15163142141458613, 1.7221685965538285, -0.21760792133539208, -0.30955866250838937, -0.07517743480940992, 0.9732962931126944, -0.3642742122716899, 1.4192021496025982, -0.24162172243195884, 1.280269036565956, 0.22753381961698102, 0.4247297830213035},
    {0.6781279370788222, 0.3862629323494647, 0.5420176222222127, 0.7055264574907993, -0.44694727450392924, 1.4578257242253745, 0.10800315302678956, -0.19506085032495357, -0.00833183617320197, 0.698618899202127, -0.6709098296632835, 0.9688623858521359, -0.2503093075895286, 0.6398339642079958, 0.41898030425488236, 0.06323236631870541},
    {-0.5717196764928797, 0.19973494323886418, -0.043976302907195675, 0.06396719730823602, 0.47346631684171286, 0.7155755185723011, -0.293339766828849, -0.41334549441401813, 0.214492944640038, 0.3498676360892528, -0.5192949115417997, 0.5424397590151743, 0.4666324054446167, 0.4925259795294641, 0.4495348346621281, 0.14031499338909167},
    {-0.18391796424041812, 0.44330844568282773, -0.08588828806215698, 0.7279844841466337, 0.11604770762447336, 0.5758648850023791, 0.36030448327632164, -0.40486706854617777, 0.17494617234186474, 0.44044739069230143, 0.4305012665815544, 0.018578945813281133, -0.2600947243374931, 0.5394111137710234, -0.015982846970353543, 0.12725791982515272},
    {0.5374664693671948, 0.24892362154743664, -0.19568425378474386, 0.740912848623464, -0.25096729493105, 1.0875035374897997, -0.20904524067228342, -0.35107349402664556, -0.27260756392974994, 0.31204337845790675, -0.6537562403657137, 0.8855317413040009, -0.07509386353064496, -0.009121469956983088, 0.18438364586801873, 0.12632057622705842},
    {-0.0374116819411127, 0.029001493474055468, -0.42933364400982543, 0.097933103744689, 0.017877001457346945, -0.0698157942423228, -0.18024750200917936, -0.11134840125749619, 0.04519028222739141, -0.26707729988418716, -0.40491800910231573, 0.25931774993166873, -0.29335717105219283, -0.041922550865589124, -0.09321873615800612, -0.1463975769964159},
    {-0.1007890167920481, -0.039173350721131206, 0.09866836298556099, -0.6852797972890194, -0.18718944774686674, -0.28330915687962016, -0.028537270481256368, 0.0999087626206135, 0.44887344632015475, -0.13047457166451543, 0.26043887191070886, -0.6371329913438797, 0.037603844002718004, 0.5031315876713895, -0.05790934599117409, 0.1588451899395776},
    {0.09328281519083331, 0.3654278961467269, -0.02864851951119087, 0.3199125388199786, -0.16556155885108406, 0.5913278909688275, 0.14359534555623188, 0.1821015817125568, 0.03070773045529642, 0.3690040442519134, 0.07659677153301066, 0.4678887401281075, 0.11621522386608449, 0.387860193721629, 0.38729840710007135, 0.24745366053762743},
    {0.15270402295387123, 0.16392142244610808, -0.08823225702727132, 0.47370112723368196, -0.42281902391531284, -0.27213452392935167, 0.030728584375293043, -0.12334075228309424, -0.021275008184056515, 0.054178182200743545, 0.4043166251761853, -0.28143681283936467, -0.7019028362159156, 0.8799162957387925, -0.20330223913122775, 0.0888648202251489},
    {-0.05109571551280845, -0.04180044309248322, 0.0013040224569590957, 0.23577308057917798, -0.08427408160131059, -0.0732148434885726, 0.15420978348813635, 0.07121307971600287, 0.1871043249674422, -0.25989601202521234, 0.2322988560917212, -0.4135049162808133, -0.07957539025748554, 0.12714837374104543, -0.35824012884958534, -0.27171075604587885},
    {0.30726406585806704, -0.03798335283496602, -0.05274014744203387, 0.48234823263470106, -0.29337308715058347, -0.21405492526629963, -0.05023696737543685, -0.05454493613113526, -0.10349518266490668, -0.3559080965334971, 0.01008282954597956, -0.7156673695246923, 0.7662205576696955, -0.2050163201999186, 0.2906984145017526, -0.6299021006120976},
    {0.38916131849966573, 0.5474018610616002, -0.0351926280323944, 0.2205166783903719, -0.38884895618311394, -0.17228038874768128, -0.4942154409333042, -0.12849330767455533, -0.021154422483078594, 0.44671772651651076, -0.19050366445598033, -0.27027102883583887, -0.46904857498590635, 0.42684302251107586, -0.162043126506662, -0.2574579178722798},
    {0.18316384731582028, -0.2537483347222891, -0.714752931664127, -0.05961353866710905, 0.100786817441233, -0.25850082199539126, -0.10305652331848648, -0.02963849484064242, -0.27660803266649897, -0.23082887265210697, 0.06981610384925752, -0.3679332280423459, -0.11264843277913235, -0.15630528956157352, 0.010023091303296731, -0.02325285289273839},
    {-0.12047002257624943, -0.48500790472142596, -0.36357666071801814, -0.46671639823545286, -0.27261011035576527, -0.1375160000459438, 0.12280879189362261, -0.1315604162189844, -0.13683677817921222, -0.750595765360269, -0.8472406245399396, -0.5870673158822561, -0.6823206489153771, -1.0545389186409355, 0.2501172151011208, -0.8649007063508579},
    {0.18246867593126176, 0.4192950522339533, -0.17876507777695322, -0.029708322315952298, -0.2924320994441907, -0.3194997645320619, -0.15119576102154822, 0.07129861703628991, 0.25869101435037983, -0.11148398102897548, -0.22308110978998372, -0.29338769516151986, -0.2731061212253452, 0.18577685788100684, 0.04783965494575025, -0.12057798940253563},
    {-0.13511778198539, -0.08260913736241138, -0.4233438013955583, 0.06894261777540772, 0.17179190086661525, 0.040350158975586, 0.33645245727811046, -0.10137565483645421, 0.017625929706940564, -0.4506914016986138, -0.28492917875296275, -0.2227764674909994, 0.6191329901856063, -0.8775088935123444, 0.7835908008687401, -0.7117778169313965},
    {-0.0900494532909523, 0.10024927905265545, -0.47618107547059835, -0.41253891484597827, 0.08407475062507482, -0.4761675139661356, 0.003310828460903178, -0.15340334832207256, 0.34437036470170257, -0.32676923376418104, -0.34012278139214824, -0.35855686726759556, -0.06698631994197345, -0.11090379894483021, -0.015988240210677556, -0.5438648286963302},
    {-0.28762582793264085, -0.19628942925815213, -0.1854193725678322, 0.2603317571180735, 0.28170491846020723, 0.3306583503137578, 0.20356955669383203, 0.0007747366179124033, -0.03748592265041388, -0.3938291231831636, -0.07386759092223068, 0.1894293177647333, -0.015255615345187531, -0.4056636436465484, 0.45252823198508985, -0.09476147204073267},
    {0.5118409443141545, -0.026997496853515258, -0.03260110081038425, -0.24786895939545855, -0.023082360345364112, 0.4555815087036938, 0.3431550998266209, 0.25410841677944035, -0.10137755809482495, 0.2500861987541, 0.19377371340071164, -0.3626358403808174, -0.12685186184066174, 0.030523427400586178, 0.4438791179303156, -0.15444317397758084},
    {-0.6379503467234523, 0.03802741477343343, -0.2004834642403026, -0.43466940561307577, 0.9323273357897135, -0.09899787935427859, -0.28094662499859735, -0.11329998582875568, -0.10155937478981643, 0.10181013671562479, 0.40938543808419575, -0.1609165993350058, 1.1038440242206196, 0.40462366794224075, 0.1836966752821417, 0.31052106403842383},
    {-0.33856135097845375, -0.6426707849120947, -0.416512112901236, -0.027076671188276957, 0.07356192329890526, -0.9472005596562578, -0.17876405350605096, 0.026128440573659588, -0.04484580293481916, -0.35338402679101844, -0.40679128461457964, -0.86650312822775, -0.07516390266983555, -0.6590009372078678, -0.15688749480088804, -0.6111960108910109},
    {-0.31319211192476015, -0.22798182711267306, 0.03398618620245251, -0.160900582691877, -0.5850309430942968, -0.33433029623486654, 0.2639574325209412, 0.13320154905468903, -0.21918361147122453, -0.5792261255986677, -0.32977506026484793, -0.8488169115641805, -0.14235583677341918, -0.7818051391300008, 0.1347493461664714, -0.391065361764188},
    {-0.22720512283558583, 0.00048279501025267024, -0.10171998236853032, 0.18452288525454358, 0.3525253451492966, 0.20084410972413572, -0.06208681169997001, 0.15892863669631113, 0.00808488890844288, 0.4947934129665551, 0.04429793652566663, 0.29394459296475134, -0.23651733933594402, 0.3659679597222932, 0.021914283134299606, 0.7770816261469389},
    {-0.8184898465294648, -0.44301275007910595, -0.046329658907379195, -0.7421296468423203, 0.05704496266160062, -0.1683743332385839, 0.05307911695910045, -0.34147634226411133, -0.07255277390659261, -0.2765698790246991, -0.18264627214921894, -0.48977898171257356, -0.1779405904920581, -0.5570923076946567, 0.008416421470777102, -0.386090209779262},
    {0.11446233459405443, -0.1668934201275583, 0.27847633129588506, 0.042099851539068894, 0.15235108452008814, -0.19658319865757512, 0.224047033642847, 0.1477125215499425, 0.22701823380356406, -0.07848328152868499, 0.5188846113650276, -0.2709411714554766, 0.1658989247665421, 0.3088520648036084, 0.49898356443074227, 0.2834729183937532},
    {0.23904290054988545, -0.5331991854199333, -0.2364441490305866, -0.015369327498047404, -0.5347993924808727, -0.39882358330840334, -0.0538102317687001, 0.17523681934431556, 0.041726143732058955, -0.24498883778273806, 0.20588871277395457, -0.23831043873060312, -0.471525399176591, -0.18218163893411257, -0.07255404104167835, -0.24694670559631215},
    {-0.939273377673983, -0.680619191174094, -0.36505289316309525, -0.859620390347877, 0.27227069374878277, -0.9153229839942463, -0.20133524581416198, -0.22559126436347973, -0.022545826367055134, -0.7725113492553264, -0.2928041393947784, -0.8533779751570898, 0.28746387972586696, -0.981339903426525, -0.16932423564176133, -0.5550190380246821},
    {0.47594037913667997, 0.10527247941610415, 0.03541412310636795, 0.11242729789389654, 0.12699790263991698, 0.262446342469395, -0.32755649418366123, -0.3449643984535438, -0.22277082169547008, 0.13952801224413436, -0.12342190752634553, 0.05389798080262744, 0.36051795210751186, -0.021245704819611314, 0.013222995459656816, 0.20735703509927889},
    {0.6171525601301713, 0.4527516033107361, 0.26774336134825977, 0.33173912262858796, 0.21107159040318219, 0.4017855380248039, -0.22949752288293962, 0.009684944466673218, 0.2494727532533838, 0.28973508142898335, -0.14638659205012194, 0.5945568265455997, -0.2399323700048835, 0.614123245573068, -0.14488044638083694, 0.24039446822446933},
    {0.9873790871756183, 0.4789420915551394, 0.16775031140050442, 0.8354224256513505, -0.10804713349998413, 0.6501914056218503, 0.013842062966616005, -0.28341494263348227, 0.10828091325179473, 0.4438855184424824, 0.2998404231378029, 0.5659016306469087, -0.09423974588200655, 0.8867231021231672, 0.00260819324212044, 0.3081049320789962},
    {0.2833852366704632, 0.3339632303947165, 0.19059294628882112, 0.5206566052904318, 0.17385779746675023, 0.30084852233736586, 0.19928390609039814, 0.03628892428553945, 0.207554113511525, 0.41758768178877276, 0.03715749179561558, 0.6728746689675305, -0.17857205554999034, 0.34089891957982343, -0.1894786340220526, 0.3298623955103777},
    {0.7774241553971517, 0.5218529544098873, 0.4378224999580848, 0.720876303298101, 0.09350951393052023, 0.44858839569218145, 0.380364125161462, 0.018117378095873576, 0.06755778017599533, 0.412630067158432, 0.20222094067580834, 0.264131029651991, -0.04587892792962099, 0.2351974225288712, -0.04898203433966579, 0.48759950336317837},
    {0.44198860880677876, 0.5690917447097542, 0.09747382071900054, 0.4317096984373008, -0.10311198699208113, 0.7654631511612341, 0.020056252721236227, 0.08115762200734188, 0.11918874355451964, 0.21980532010052042, 0.2930119099338441, 0.5552455833961475, -0.7811383376171633, 1.0360818377769774, 0.24365577061583085, 0.5288659381827896},
    {0.04521496135473423, 0.40189682742395355, 0.11082837806319519, 0.10692109167602468, -0.44673456811723117, 0.3327631501332905, -0.04559521387360969, -0.1259949191589811, -0.037718855031145034, 0.2206545020509042, -0.2741606551320255, 0.2747372168466026, -0.9255249620596957, 0.18680898213211553, -0.5844898831956928, 0.44674018784684744},
    {0.00659754698151691, 0.1493605129239077, -0.15382892815867255, 0.3806829905955491, -0.017636719053714462, 0.28149949128431695, -0.06879911513025849, 0.018255221738437827, 0.03332395703252225, 0.41781028743795207, -0.31185942675613243, 0.40688999347060506, -0.1806973133259586, -0.15654222277424887, -0.06245311380807844, 0.45636642827294627},
    {-0.3379625798133287, -0.044781828504797026, 0.16226972112981258, -0.11112444673759786, 0.14048960542898214, 0.09865566242610492, -0.16056149477911033, 0.03854931006780231, -0.24612538256526134, -0.02598234842934705, -0.06745888225330551, 0.18781510181862046, 0.18612874531844034, -0.044199781000148576, -0.14653112545291871, 0.2644563317495809},
    {0.25944925650534373, 0.04548257054442147, 0.16382465753965447, 0.4701822801773347, 0.10449345669793315, 0.5226700200456922, 0.32845771660125905, 0.022353392852275375, 0.0062722805011431884, 0.3791557640658267, 0.3238739644958793, 0.10638772650834478, 0.3487169543421122, 0.33746561940572406, 0.3411952898147362, 0.34004640639409506},
    {0.6597192112223865, 0.44061250651860223, -0.23752570482144345, 0.2180485744658166, -0.4050837237934789, 0.5041057951071365, -0.24411775526442064, -0.20756629105411137, 0.10198740647773774, 0.07275448059750099, -0.6627188804162258, 0.05877504103980768, -0.5242805527095707, -0.0548899081592255, -0.13747081661053454, -0.04896994359467275},
    {0.5023714706401169, 0.033819057663603394, 0.37905688434771995, -0.06600515209970229, 0.0778126015400641, 0.5348774296709092, 0.2639346594008857, 0.016530417905110357, -0.2603492149436914, -0.08258265404809685, 0.15466556763590902, -0.09697124634814197, 0.5237525084276694, -0.13262318486866304, 0.3551243386923273, -0.16263468148115165},
    {-0.45157554118784954, -0.06884444431317957, -0.3629765042064077, -0.12763347341988818, -0.12096999998102646, -0.18384965985318916, -0.3259537693121955, -0.0013373288101337602, -0.1874430178822383, -0.36730841670009207, -0.3272918781888029, -0.1697809025538894, -0.03388529827683152, -0.38928142069120963, -0.04449941241561462, -0.051497768357692354},
    {0.20589348325047108, -0.45366908726098615, -0.23196943847743604, -0.041241046971470394, -0.4855222443590731, -0.06075280873332913, -0.44969195466753903, -0.22409125275917513, -0.09669078811937673, -0.24081090511439224, -0.46034601307659945, -0.01485443949333575, -0.6011868649006613, 0.07029728661110438, -0.2561651738201137, 0.09131084357661219},
    {0.5849427181118337, 0.681283762967091, 0.11654202006072407, 0.6806558299430446, 0.06590490341505537, 0.7269192790435695, -0.3493881238282164, -0.25936530417540055, 0.03392500999995481, 0.4702538606691882, -0.05408745433651463, 0.5290238531178459, -0.13737537507631312, 1.2655177959491903, -0.25363658597674305, 0.4852195174768731},
    {0.0408421874884498, 0.24266800015207426, 0.19399703439426208, 0.16403215362627385, 0.04718193403357608, -0.008171006960812662, -0.05452552773526115, -0.15681250914900718, 0.11132669268055252, 0.22497110875724238, 0.1668462739189407, 0.09027286879587712, 0.06147251254399706, 0.029719683334684922, -0.12702679870744127, 0.23207652144915492},
    {0.09500298416423524, 0.2809813524071876, 0.29437395674659295, 0.15931661708191588, 0.1821265126185512, 0.3087557892482143, -0.14048654011324122, 0.06557261161311642, -0.10037569830486515, -0.0801765125613322, 0.48098991324545526, 0.1513290940410975, 0.1797671423295643, 0.46080782088938643, 0.14484260394067808, 0.16754497109008443},
    {0.3015127318060038, 0.050032120328842244, 0.13429331862606428, 0.03406513456968581, -0.07157563501694732, 0.251410633573561, 0.25486058493666325, 0.32974291170314696, 0.0030745379175391376, 0.149279230622705, 0.013653826076603768, 0.05525802462570827, 0.04161690247210494, 0.08437594892412466, 0.17026337082658113, 0.11395501383114624},
    {0.6160334461309032, 0.10258399582800097, 0.002509637395471379, 0.3747707720464306, 0.002889093565802531, 0.7102453080657196, 0.2795527705973221, 0.3037516225294516, -0.0501051885461913, 0.49657860163115447, -0.06736485726123863, 0.646476054840584, -0.448861356674141, 0.07375051458313228, 0.2728336616640093, 0.6969103663066722},
    {0.3502738633980054, 0.8353498591242766, 0.4412362649723684, 0.6699779824086193, 0.0342924757353738, 0.7405669767607753, 0.08186005268273633, 0.1836955398359247, 0.319165041533791, 0.3726944825342752, -0.03882516419113595, 0.6772845890655382, 0.00032791874268916165, 0.5787938584716558, 0.4522496508354446, 0.27656414213197505},
    {0.19337485597353266, -0.01012800460729395, 0.2572733423765041, 0.30319436576300474, -0.13815238890436718, 0.15238787762206016, 0.07994933635641034, -0.02371193371257397, 0.2695390419690532, 0.2578630142733708, 0.09925571026683394, 0.2748253910705367, 0.48898653981744705, 0.2981711719923994, 0.05619665021822793, 0.24223990126021508},
    {0.3768926013680358, 0.1271456656188379, 0.3660116504741942, -0.06362478893705523, 0.36295670203051456, 0.2662190440492724, 0.3250172689287937, 0.007280383502425762, -0.09991044464544103, 0.2225960775534199, -0.11379065662311598, 0.6897810889934205, 0.46012101097970287, 0.24832810203480357, 0.08605478514055247, 0.18574202155508981},
    {-0.3848757988611527, 0.0786620325142085, 0.2640016008829886, -0.007375662622697684, 0.3272560878613977, 0.133747638878197, -0.1734159933143512, -0.03397376746905756, -0.25617451114829987, -0.04704225287978387, -0.3122286465768986, 0.06053493541713747, 0.19250187936877067, -0.13567528853416613, 0.2729871087961038, -0.058521311055555365},
    {0.2167261361869471, 0.0311899858860329, 0.028739012575386604, 0.15289279916830426, -0.054810225505751875, 0.3120549527981302, -0.10703822780502943, -0.05575639215541698, -0.005419345438969489, -0.03290181782577099, -0.008331753459523025, 0.23419988591495627, 0.46570821538214213, -0.12781685718746208, 0.09590865023086478, -0.19298218722264368},
    {-0.3180117620982195, -0.002324049886317778, -0.14671855554766491, -0.2524522118306226, 0.0038725616841540616, -0.713326562301931, -0.10699186433171984, -0.3620675677243904, -0.11879157987605679, 0.0032957898546706913, -0.20575830020129604, -0.4034544400018688, -0.16804910536439252, -0.35280985198257625, -0.199940933204805, -0.2529625443863872},
    {-0.3704343831399047, -0.2019863719138801, 0.22418314604479783, 0.06168214519824391, -0.107831750031609, -0.104840791520785, -0.03722236333910602, 0.11454508260784192, 0.07675582664272264, 0.01163602813582949, -0.034302064549289996, -6.327457290482194e-05, 0.03274825214960977, 0.015174283889464924, -0.020982367957196157, -0.15148796536706002},
    {0.1357391764582825, 0.11018514214778236, -0.02550902839082512, 0.10583614358476567, 0.32707506719428736, 0.16987323386358066, 0.5795554469115894, 0.5770146262900782, 0.07058231167908735, 0.18415808867769928, 0.564414726416203, 0.29030711038978574, 0.26893218253975426, -0.04935976147389677, 0.436663845817715, 0.23442643607319524},
    {-0.3119068237044603, -0.1535115479229684, -0.0662493765340444, -0.07177472535236834, 0.3133625533526908, -0.3064042257495586, -0.03440547186615497, -0.19875019481839326, -0.2558395911356165, 0.04705493026501003, -0.33322529361490116, 0.1857226187798469, 0.13771354599368102, -0.4083918775387118, -0.3010627302330668, -0.06303382003802474},
    {-0.4579014693701189, -0.7164205146259887, -0.09935513603969107, -0.2425441436787459, -0.339125887593443, 0.08938915208694616, -0.031209322510285405, -0.07453506639045628, 0.36479361152535134, -0.08482149420737153, -0.01863169411716234, -0.35382113443072305, -0.3181894759017267, -0.835603549218662, 0.1688164064294926, -0.38851924933575127},
    {1.521638849826556, 0.9774492588960618, 1.05556574886049, 0.6437425838720368, -1.715602700742165, 1.856678266789632, -0.5158141595992631, 0.4654659729877665, 0.3428180012145771, 1.49750001852481, 0.4157781779153918, 1.8530276369269505, 0.6621980918506873, 2.0226369577375816, -0.17435483059729415, 1.0841617860138035},
    {1.2501813325472446, 0.541765184404797, 0.5873679044092499, 0.21889429389838327, -1.5074262214164746, 1.6933688778015021, -1.5298514877426788, -0.1759050721042527, 0.2523292528479329, 1.511788948155829, -0.7028194467191506, 2.07745533521334, -0.05605797374220615, 1.93602687287878, -0.8990953034332781, 1.3013869938067375},
    {0.8546827951334982, 0.889272406750631, 0.2958651636228868, 0.9052643290901592, 0.034602178524969655, 1.6711552633160334, -0.6535270960020273, -0.15245988563464938, -0.3180544825444342, 0.9439389486337013, -0.7230264140471573, 1.640726635191107, -0.40392716578989213, 1.4174055688410063, -0.20187128079708822, 0.7185234839124374},
    {0.40168419546310874, 0.761288180340236, 0.012915504087515161, 0.9749910028428184, -0.4662962671718054, 1.3024424203348253, -0.28782551158830055, -0.43774604061721867, -0.003351036764284359, 0.4707884647784145, -0.9106733227311273, 0.8197796892645517, -0.29096378734825834, 1.2524723551193608, -0.10078394656878033, 0.2868797984726136},
    {0.9754284867557949, 0.759139440080316, 0.6507206457088343, 0.8192155080322865, 0.2571832689579699, 1.4773882929066673, -0.17502381077766033, 0.5016497931089294, 0.15151666916154566, 1.102331529510867, 0.37607976846144486, 1.1293187849357293, 0.6104470933631572, 1.3054968855474742, 0.3049076937488649, 0.8905119862610917},
    {-0.06438072985469817, 0.16226451816643522, 0.14852812946124194, 0.5619257499960706, -0.5271318569059965, 0.7602274522044735, -0.20314070037832552, 0.1744152290992482, 0.10914302512338644, 0.4054368401134431, -0.2653930597467376, 0.8625120032415096, -0.6182558878977661, 0.8206903824212903, -0.09448014646476612, 0.13802385227583408},
    {-0.027278904492547898, 0.14668298214543157, 0.07201514489154527, 0.2973580196469044, 0.252274486948212, 0.29429716523719984, -0.42368914563785554, -0.1113206556142283, 0.10212660980796012, -0.3072814135073572, -0.2890189817403116, 0.6571574447505835, 0.427439375831905, 0.36015044285294817, 0.053794981293185405, 0.28789066329628715},
    {0.3208930512959233, 0.21066000270612878, -0.0936236171954252, -0.02083134022168831, -0.31667719267976757, -0.049096188630505966, -0.13258527437563858, 0.15907186536252274, -0.036744837692106264, -0.019291047161651198, 0.38336806110223576, -0.11128273609277706, -0.3669906882886512, 0.7294827086065694, 0.05365371471243569, 0.09915710987728675},
    {-0.19126164416702027, -0.17018898105246133, -0.11222335266295137, -0.005871919143485637, -0.5109992515732701, 0.3106036842837183, -0.5425609227964137, 0.09828669042694801, 0.317938271846966, 0.0631660321174346, -0.19839280741749724, 0.5428929959855061, -0.36230869610106137, 0.7335292363377174, -0.2912605808784227, 0.2916574646593516},
    {-0.01531182408779685, -0.025280019947425684, -0.07716850233933416, 0.0836842839550667, -0.3635462529725448, 0.13635395576892848, -0.517981524666526, 0.061873919653163516, 0.21137047691771915, 0.04628789175141782, -0.3484378468492743, 0.3170116985637559, -0.4068818923635096, 0.5208315910099961, -0.4633399131985912, 0.050233180957920814},
    {-0.025378659449403367, -0.6831860572423702, -0.33733181371098875, -0.3216682424149621, -0.7489372521497464, -0.21734713355451063, -0.3315312493811064, -0.5106453778332942, -0.3169214026085815, -0.4366216009914448, -0.502734345232206, -0.4130564900299301, -0.4059951001968209, 0.025369065935928255, -0.2679362103091136, -0.8835040166707584},
    {0.4254203795636742, 0.32824361830208315, 0.21310680426111048, 0.472302071199113, -0.0047472768254959025, 1.1865215750662819, -0.13693706244706264, 0.09795439742973455, -0.06896104121657272, 0.6868720736293702, -0.13032221321227927, 0.5368244840000529, 0.021556446690717535, 0.6484565945020435, 0.21286450629144762, 0.567518369896705},
    {0.18762034805195074, 0.04808613294205576, 0.303408449167196, 0.3991712403108875, -0.2436264260320272, -0.03755449138687988, -0.016844631385605158, 0.04690810701525674, 0.25370471075215406, 0.5957390521222856, 0.5132787701392254, 0.10302771167050209, -0.21383181829711828, 1.2697441014574995, 0.04831504755279735, 0.23586033400968115},
    {-0.08155504036894858, 0.30759003429424475, -0.04417679663009729, 0.12527306701626917, -0.10834450905097898, -0.16977626194057874, -0.29845208498847614, -0.27282572071446104, -0.003934526271833951, 0.12525032188294036, 0.22098139954569185, -0.20392939250509567, -0.10069122671788684, 0.2205940843717321, -0.40340532715437466, -0.0559015165562638},
    {-0.6545555676379478, -0.2020768245917213, -0.2737719179334275, -0.37983248769015976, -0.23010292468016602, -0.8356803605164381, -0.7077149278852376, -0.4550654103344801, 0.25397672586868847, -0.4075230288947253, -0.4690744767509422, -0.6622761557004259, -0.21073824851708728, -0.5217201969173886, -0.571652979700187, -0.45824599728195686},
    {0.34899724590923253, -0.1691974566126154, -0.2058441482374369, -0.08446715781064687, -0.5529535393454115, -0.4837845788344125, -0.20504326321688693, 0.14967712924457216, 0.02099280544297262, -0.05944041964002953, -0.35603264910437854, 0.03400408990781855, -0.6016902612168902, 0.8056223823237073, -0.19543143389821963, -0.28779175872036117},
    {-0.11998741936908047, -0.4905011800299673, 0.1383231922337831, -0.19958193969223995, -0.330935374331483, 0.0806284862839906, -0.29655315677174804, -0.05462783028839603, 0.06868174094631375, -0.16549896754310928, 0.14121499657119668, -0.21860868337697167, -0.23640284960290947, 0.27186478382659496, -0.3850919241508328, -0.0020980602877104983},
    {-0.1399986294258156, -0.23182655815721293, 0.15038518335206885, -0.5550896972195453, -0.6167377781227881, -0.2440036819727061, -0.37196545466446, -0.14363514333612606, -0.22521039148050412, 0.03429836519982928, -0.48175894613949233, -0.14959893783201847, -0.2292824819334507, -0.8771937698002878, -0.2025969609521679, 0.22076798702098538},
    {0.25486009462247133, -0.0712018241830338, 0.3063484542116566, 0.24747655372434524, -0.42575687968913356, 0.3198691719172092, -0.3686802969860198, 0.2547606236685924, 0.06548306335830416, 0.2896600149182011, -0.10673457333466477, 0.27680742176679046, -0.3396029067991073, 0.5060456789781995, 0.03144454145968897, 0.09766779546264676},
    {-0.27190158354083604, -0.11635641343272396, 0.10709302309327409, 0.5288443188817745, -0.40805635836173765, 0.6660109517023783, -0.23377708092193344, -0.137294132097109, -0.18446780875039878, 0.2103961678559455, -0.635857589654762, 0.584557966645148, 0.5051635202112027, -0.09367730066253124, 0.41631633580524546, 0.14183868348719708},
    {-0.0327031134838843, -0.11206406406115241, 0.07921869573828484, 0.07679530793103845, -0.27328403384726385, -0.09442558251926415, 0.28437638782281954, -0.301036830311456, -0.07322239819901799, 0.13246045504025644, -0.5974448002602458, -0.22748183572369074, -0.1727595370521581, 0.06072419855198464, 0.11612791937988272, -0.3444643230269974},
    {0.39012824169244364, 0.07806497165777553, 0.24500178166474867, 0.264135451626739, 0.1420294511510413, 0.4386345064880527, -0.20885903936886277, 0.07225250397359212, 0.0051621562693639185, 0.05108459137720377, -0.28990862950126167, 0.22269555694670046, 0.2525780208113762, 0.5049335839324028, 0.23871819907923833, 0.19861575174900095},
    {0.5089706180089486, 0.1423308849719649, 0.1364780753307549, 0.09720051051627468, -0.06800591587205862, 0.03725712423371841, 0.10762713559030657, 0.07759548339644688, 0.2647733112835625, 0.3999385643411103, 0.42619473911565336, -0.16782943085713695, -0.360969009927634, 0.3885306697535799, 0.3098201006285285, 0.08758354626322329},
    {-0.28483069434330704, 0.31514549587494106, 0.334577781114936, 0.295305967632906, 0.5190154890687917, 0.20735771930954133, -0.01337528424894308, -0.1249698663166946, -0.17631521801855513, 0.448240699660065, 0.33751828188756505, 0.23981108478110147, 0.5305676980840731, 0.5794575651196717, -0.2831548097654989, 0.5430802733456622},
    {-0.5570844892613902, -0.2366522924775454, -0.12633132316394766, -0.23206915716310503, 0.034590636974852026, -0.7457790694622917, -0.48681723824024076, -0.22038679091329175, -0.4631295906594681, -0.4540094875599242, -0.5845408151268927, -0.50910577054063, -0.1307838174338833, -0.660715678797651, -0.06441117090447214, -0.4303997112313497},
    {-0.606318691653442, -0.30958066586429817, 0.45846132258712097, -0.5912378396051873, -0.4855850992164508, -0.21206362610994936, 0.017803919750524026, 0.18502030473526893, 0.12305938377010762, -0.24994303099058263, -0.06854653303368807, -0.4815537431173102, 0.15656074649384025, -0.7909950657611696, 0.09498058604045245, -0.04162461499689833},
    {0.19948701505804564, 0.4684670173168491, 0.08324113272446587, 0.37792274548484556, -0.29783016586232824, 1.0371328132101056, 0.11496190265985447, -0.1085600434138299, -0.21695138841414385, 0.8601565722460888, 0.3804766123465099, 0.686607196741868, -0.6824585577041137, 1.0763269122441088, -0.04197615684655121, 0.7562593099405726},
    {-0.673875020078891, -0.4337716896564037, -0.4364632141836431, -0.48639621058934346, -0.41275025213163424, -0.5088431337669067, -0.3355449044579312, -0.30682008454384113, -0.18977427444487818, -0.7549210200545365, -0.7661090363700906, -0.6183361953347221, -0.4078010007874357, -1.2141769177192332, -0.2551096654473591, -0.5116207265220205},
    {-0.32850774100698965, -0.23694199155877793, -0.14633418805068704, -0.5714503570993359, -0.09236835763478297, -0.1503604829798217, -0.18089127708493272, -0.0387471511692725, -0.12120267701748787, 0.014441801049011207, 0.0728876576200599, -0.43426199047752045, 0.022620714354927112, -0.16787036844947217, -0.16562794969916864, -0.29893895579249496},
    {0.044661172159612156, 0.06605236790891243, -0.2631503014195258, 0.21331032906525427, -0.583570223228, -0.7339170163773321, -0.24603990195451425, 0.2265291233138124, 0.12949901929553617, -0.1946819691759078, -0.16876464021859194, -0.5196647368769189, -0.6051061500040819, -0.017053786917164335, -0.2886808373341258, 0.19694239295405042}
};

static const float b1[16] = {2.142645110229477, 1.3648291556932965, 1.6069484388238773, 2.154330865193156, 1.4709903458101368, 2.2074922370051366, 1.869664077456856, 1.7242102466657119, 1.1356814726012252, 2.444033743620063, 1.9195363302862247, 2.236034542291213, 1.8169753854178596, 2.2492559826539402, 1.7780744863671771, 2.1807988788694153};

static const float w2[16][12] = {
    {-1.6314702127414784, -1.3016880408534097, -1.5399038945039467, -1.557620949942575, -1.3125347081832144, -0.9546714396919384, -0.23632041165333464, -1.4549315753463457, -1.0078235245944254, -1.574318751490212, -1.5274550880934648, -0.9483882164404679},
    {-1.0150673576216955, -1.8388771460243327, -1.090183384619483, 0.0053409420704161594, -1.0031047180961257, -1.4139471100689838, -1.9907840237170296, -1.2922170665383985, -1.4387127785832967, -1.5696788042232446, -2.026206189035833, 0.32092210144604905},
    {-0.1954678230836748, 0.04936654220765613, -0.8217602391481863, -0.10833938817436196, -1.9073981730723835, -1.548361910182737, -1.5902514313669214, -0.9479430539011643, -1.6483623515922752, -1.50274692698617, 0.5210798837023956, -1.7256250214280255},
    {-1.9372524986459267, -1.682774197360924, -0.6771212872915667, -1.005448150285878, -0.6652722076165167, -1.6573789127652536, -0.430912508482076, -1.4420904378125226, -1.7073854321859148, -1.4084348991872526, -1.00666688804434, -2.021598299413413},
    {-0.007660750535205758, -1.3898689045127623, -1.3029933984633133, -1.411990642391881, -0.7683227229245071, -1.2563220256886432, -0.646353878053815, -0.9065364476409673, -1.7076534636501006, -0.48555275927281866, -1.1682344127608157, -1.455297682131272},
    {-1.225900037857459, -1.7617888986806904, -1.5751327004949829, -1.5657376476982137, -1.8251000052732773, -1.3307621295590948, -0.9597858562091943, -2.1962866126073317, -2.074488907832807, -0.8034091000483969, -1.347639188803679, -1.6007243507752191},
    {-1.9764474218613466, -1.766057378775312, -1.8330467931479217, -0.19634291574756704, -0.4519746112467922, -1.8257114933222751, -0.610934169789688, -0.08019452434398153, -0.8143417178965053, -0.7642097075390343, -1.1155130348872502, -1.3784621806434796},
    {0.12580808168948682, -0.3439984332988733, -1.8059033220344372, -0.38322487168148556, -0.43066045720211066, -0.4238583756325972, -2.16410570136913, -1.6284915726671112, -1.529036830572824, -2.025708623729435, -0.7491623093761811, -1.6529858369289157},
    {-0.6021852790730707, -1.1899131882979845, -1.7495421599146095, -1.391601460206405, -0.41031154214874815, 0.04046759276317564, -2.0059328103122596, -1.3424398659211572, -0.8036004167295762, 0.6889678281004382, -1.1999430133702362, -0.2736111991252417},
    {-1.8280545059617515, -1.9276851199882898, -1.1470102511764402, -1.7890940991367186, -1.3395926100693423, -2.110001598258964, -1.9674581139667853, -1.2860758751735413, 0.024082645300644107, -0.809107053598515, -0.5485472777914211, -1.1227991820085488},
    {-1.7818921059981612, -0.7518717454901818, -0.3066014354745094, -1.9481043150902693, -1.7984366752372598, -1.248765970379253, -0.8563360206882674, -1.950219833635478, -1.0842498880069267, -1.1821735599678902, -2.1007726390132913, -1.7917611096636679},
    {-1.6035192620447283, -0.7229476506367234, -1.3422034090731707, -1.5892542825178009, -0.7885646949930363, -1.6431818010451253, -1.7946119601313364, -1.577649286670861, -1.0534346873920144, -1.4403275228052184, -2.2861258944646776, -2.2755358878969143},
    {-1.923604898675237, -1.1343625431397661, -1.6301320433424131, -0.8238200877813063, -1.209707339538055, -0.5026693413675695, -1.0235967447069847, -1.2573384699482608, -1.1434316807425586, -1.4626110695948575, -1.1066217329989176, -1.0885910838869675},
    {-1.2937291388879741, -0.9207695452480443, -1.6939665760742253, -1.7743615761181701, -1.8529406522673266, -1.197062700598627, -2.0490044869865494, -1.3137225722470114, -1.8316589003456203, -1.8384084412103148, -1.4073074945195623, -1.551309983959566},
    {-1.1044003938863916, -0.8926533352502236, -0.5807056879919968, -2.2024120100160127, -0.7977155480592224, -1.4616429888552065, -1.6889577182742603, -1.0460037137876625, -1.2608191532528532, -0.8453423525450969, -0.763502668137016, 0.46715622359182163},
    {-1.3883277801537786, -2.069163840186862, -1.6415523132685657, -1.7751529399325534, -1.4962603326983324, -0.3466827860464063, -1.176179672679354, -0.00086312074177187, -1.494798109177623, -1.6156061115964033, -1.412701002629957, -0.9938855503930352}
};

static const float b2[12] = {-1.193443588272096, -0.8557917847187522, -0.9031461073885847, -0.8125668170049714, -1.007667972994968, -0.6689604693321258, -0.6529776018144556, -1.034568900962982, -0.6042362314501744, -1.128850800969214, -0.6168808401761103, -0.4101083484339126};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
