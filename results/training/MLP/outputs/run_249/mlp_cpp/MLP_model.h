#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.406502886073057, -1.2356219791809837, 7.910226279062388, -2.102328350132918, 1.0160903507687045, -0.466221015003882, -1.0311087430022656, -1.990408213829612, -1.3585632228417492, 8.67395451891011, 0.01765061423436646, 1.0307132717547403, -1.36842194140813, 2.3540538161926956, 0.5454494239117393, 0.7087861367548928},
    {-3.3752607767797445, -3.7623735805717717, 6.246704493309388, -3.534835130680394, -1.3378916370965863, -3.3129789852264406, -2.6610249365312653, -3.408749187116946, -3.1684842004799627, 6.184881168885311, -1.0104805626989906, -1.2660747697684096, -4.018794029601963, -1.7014010205584056, -0.9833288465945019, -0.8162556399177568},
    {-6.4320459195656055, -5.486074257855883, 7.539763716499811, -6.9549526290333, -4.372963484577197, -6.036043307773676, -6.316166317521754, -6.593222222137132, -6.772641847836064, 8.049261088620044, -5.729561448205678, -3.156568390684534, -6.592296964995291, -5.559763444115385, -3.929548726612695, -4.4193361282193075},
    {-6.574896108274515, -6.089211425434482, 7.647332605179219, -6.8833790748590395, -4.150700106722656, -6.390276846445937, -6.23210203588751, -6.561660457542807, -6.576904515087319, 7.457036100180262, -6.178449012383984, -4.148252469130292, -6.933732523559347, -5.685741624991865, -4.704715595695927, -5.061651073357264},
    {-6.955595068613437, -6.9053692561170035, 6.781227713664634, -7.4085409289324184, -5.673362394932748, -6.902899954068167, -7.183416755261022, -7.102745904901276, -7.37608465413223, 6.147866261739024, -6.732927218585086, -5.994699040389463, -7.141405465436515, -7.147938329490019, -6.199409531404156, -6.632052428687677},
    {-6.572509401236083, -6.392078568691238, 6.1633924046017805, -7.1119949369558455, -5.993560722406682, -6.528661086655906, -6.963667053208843, -6.902077708723849, -7.084291907326858, 5.44180216347888, -6.406969250439175, -5.6699082288761105, -6.874425358590467, -6.873985121750191, -5.983758560789788, -6.660694370709737},
    {-5.766155145202736, -5.683630597265163, 5.953235789594241, -6.249563067801605, -5.04684579060363, -6.224932368416191, -6.459512959667705, -6.451468246113354, -6.597282812967026, 5.121169845141858, -5.148399712116601, -4.776261914933798, -6.353825184649871, -6.593782803119472, -5.097744450925082, -5.829587572851064},
    {-5.7888934099484946, -6.074789401996563, 7.059629821786808, -6.247113879496076, -5.3982446812167515, -6.058919628821052, -6.3866240893266975, -6.50810727336962, -6.510988553801565, 6.634023377826084, -5.813673797891979, -5.034385373759914, -6.510670642201357, -6.138869190813588, -5.498953788665335, -5.968492911066936},
    {-5.802744045898937, -6.388800897055547, 7.069045043371, -6.807837304185231, -4.754356733015368, -5.87216362932198, -5.27157479904771, -5.740907634842388, -6.03741171285945, 6.612571545514645, -5.200899403306794, -5.009810525683451, -6.434044943551455, -5.945220366455803, -5.495375145811501, -5.7781816123186},
    {-5.8856335324503455, -6.068063299800527, 7.292336269474574, -6.48074792811485, -3.8643661150916198, -6.167544445249863, -5.126705401501243, -5.914212800712834, -6.193574115254688, 6.843216428887843, -4.871902683465917, -4.001648799634054, -6.82328035810825, -5.834204344610637, -4.6760610973511705, -5.363687112284373},
    {-5.360345928230578, -5.784167594827287, 6.093820297389821, -5.740399304896871, -3.2331443827848045, -5.5240525729309295, -5.150103185631156, -5.295207995807434, -5.681172474099507, 6.266925977640355, -4.454070755638536, -3.2269441092528295, -6.095030445629529, -4.931414865850273, -4.09696908513106, -4.473807948923774},
    {-6.272952051059637, -6.368869407026913, 5.654828329404649, -6.536638030414386, -4.331269408045106, -6.388961236126097, -6.0441224839679375, -5.997182293828522, -6.255980069760673, 5.3863044716706305, -6.352793374192302, -4.955218941321488, -6.418168886374894, -5.5941354933650445, -5.553445936382488, -5.834107386582807},
    {-6.5746728383813915, -6.890312379528719, 6.051921199009857, -6.937026229865982, -4.998586711548221, -6.675797151020155, -6.73436516840254, -6.5769099234238855, -6.897046340273787, 5.5447767791006255, -6.914186880179604, -5.340741595074104, -7.211970500757247, -6.525447510562586, -5.843061521759657, -6.326221563427857},
    {-6.499100776499231, -6.759085795619857, 6.012464233940961, -7.157560816022995, -5.378100650033722, -6.835951640217333, -6.523120727990332, -6.785569211376651, -7.1787415460617785, 5.7911602652273615, -6.889673770697528, -5.613322048978294, -7.03823965958385, -6.446758056668212, -6.187094211665092, -6.428687742763391},
    {-6.079388832253035, -6.745173794691478, 7.011257789386242, -7.2802848708555405, -4.854541789174041, -6.602302559937424, -6.454796073063974, -6.5684526866946555, -7.113534815221195, 6.577925785734725, -6.453246784415377, -4.739523239259136, -6.888093323004999, -6.343021252093898, -5.601416023913859, -6.3496438962746495},
    {-6.5138479986110385, -6.852742918859887, 7.477443915467269, -7.4298355314795055, -5.248115119137615, -6.980911514236897, -6.648560248691676, -6.947532708001896, -7.0796214842509535, 6.4930644898635315, -6.666771667015449, -5.184121706056822, -7.1107306149278955, -6.829757442166616, -5.905971784849687, -6.336305373703383},
    {-6.701290179960591, -6.904894721625429, 7.63352314420984, -7.191070995902943, -5.440148885386451, -6.833638196656038, -6.701541611328405, -6.840975098746883, -6.959307907832642, 7.007347356784538, -6.684387924622181, -5.387476796314213, -7.190618484576979, -6.5373721161983935, -5.794006346868525, -6.3831727569215415},
    {-6.7400777782579855, -6.6303010595396055, 8.036121141214203, -7.346299296512409, -4.964003303607158, -6.610238817934515, -6.563111186605633, -7.030494557978218, -7.068301841042054, 7.855656290272026, -6.717608467253792, -5.140626818650313, -7.00235886917385, -6.11242851464241, -5.895738097551635, -6.483079048031528},
    {-6.919039917901647, -6.557135942471823, 8.163294209240638, -7.5175022258444, -4.933458870024861, -6.633638038917227, -6.749979932505874, -7.044136343290426, -7.46783216555581, 7.870893601654979, -7.018911106529, -4.788294273170547, -7.208875278818237, -6.315000858283928, -5.948547692347108, -6.422264903572137},
    {-6.875463607202179, -6.613765736790376, 7.826663359019595, -7.311217947690818, -4.438612756368241, -6.987328045485984, -6.994611190828299, -7.307826854559075, -7.286857475566301, 7.491587714831074, -6.854828081049935, -4.331981375314314, -7.137942908883472, -6.4237854454588135, -5.642965456852308, -6.062812633323518},
    {-6.871918605916567, -6.677020126289487, 7.576383130457169, -7.467668400936908, -4.0378215927436205, -7.078649623649037, -6.909239508085813, -6.80730954802156, -7.013240703112651, 7.063156268282994, -6.987411144888652, -4.817898223012276, -7.1493821731720315, -6.27570235137941, -5.756033642106089, -5.883651644086878},
    {-6.670382508140089, -6.314937605949717, 8.021082016155042, -6.894230022797758, -3.6146355769621668, -6.400839636996225, -6.461596216800126, -6.579576552077424, -6.608104463914611, 8.158875873445131, -6.296974153941941, -3.8215382591058984, -7.197054587106516, -4.782885059894689, -4.790089705597623, -5.200104665135815},
    {-6.0613457378011875, -5.597088169855025, 8.26220080659455, -6.720077559424865, -3.0818049835065473, -5.929693222787658, -5.413090073056649, -6.050954238250337, -6.142058879369391, 8.305762131318636, -5.5828725496956455, -2.9501257171638735, -6.595982136638533, -4.072505017715206, -4.18352882054738, -4.4877863933568625},
    {-6.2526623585328895, -6.4368873395396875, 7.818774369320089, -7.232986990988326, -4.341988562343293, -6.435107555668274, -5.967777301903809, -6.368295333526083, -6.785030495370955, 7.5021833116876175, -6.3294107512163915, -4.319580034534332, -6.742402126256617, -5.149299079676193, -5.3422516976125305, -5.542753799352638},
    {-6.760912557877804, -6.981415886357224, 7.2850943038189975, -7.176412376526279, -4.447470784646177, -6.740524671923707, -6.292660672546966, -6.812746870940784, -6.607677502164659, 6.622670962163496, -6.192861602168918, -4.932183804093478, -7.061471165016993, -5.6097367951006065, -5.820166822826011, -5.606160274169176},
    {-6.371464011693812, -6.553839852959283, 7.337268283922751, -6.83091803791151, -4.295547786546589, -6.599398758923444, -6.299790442695726, -6.4336132324664055, -6.557181369966346, 6.882982185275276, -6.434520644299832, -4.741243044196785, -7.061838521573697, -5.2717927110532345, -5.328320347679747, -5.378494339742111},
    {-6.6976823045949425, -6.538059940803969, 7.7918217559986305, -7.066144989309347, -4.1369769385615776, -6.648267310047743, -6.225139562507586, -6.729447235324335, -6.561937003122565, 7.646055581260116, -6.282084825986272, -4.265628767258219, -6.84057338636425, -5.5694630542160635, -4.805480571747036, -5.429504927774382},
    {-6.864635290385672, -6.886641717900343, 7.829263944954891, -7.557129776763099, -4.650163584572655, -6.738840246039193, -6.90172998309627, -6.841893385919786, -6.978661952063665, 7.524083705646248, -6.573802227901025, -4.643693978982691, -7.336412804831928, -5.723041195831121, -5.448992172016354, -5.927502838154187},
    {-6.469490172731808, -6.999447664519301, 7.231747987174377, -7.285966734478061, -4.556434672913734, -6.8677333921432835, -6.812137926173102, -6.852829611111272, -7.035097526167319, 7.044481467857412, -6.356880962442894, -4.655491535293828, -7.289880634393641, -5.803690853611796, -5.541784822201648, -5.617614116977316},
    {-6.74004062764726, -7.06919830805358, 7.400456296169671, -7.326848217849146, -4.386807948876814, -6.9612563847125974, -6.579938296778007, -6.802576529905687, -6.754510370827938, 6.9625812141508465, -6.3491022642193355, -4.97861857818758, -7.299615389671103, -5.187157002299845, -5.7062007550459315, -5.555168146673929},
    {-1.0097740764716734, 0.0884466424830934, 0.931370900256395, 0.2905952906147362, -0.4585678521367206, -0.6160817265632131, -0.5325418869161704, 0.6967605030540872, 0.22654214735222358, 1.2545977826034365, -0.45434610986872986, 0.1719536990434441, -0.8087744790856688, -0.9976797034797424, -0.5364793110890786, 0.39467056741230927},
    {-3.382248887432148, -4.067994402751893, 3.5260556806429513, -4.187712778039614, -2.983414077305787, -3.378181735451674, -3.1156563594215645, -3.9103370828352784, -3.2175364874098955, 4.5036225543259905, -2.140595310406141, -2.07721791008307, -4.060705379454817, -1.9987195832804274, -2.6335652391925914, -2.9029628476655374},
    {-3.133902546569644, -2.802143984541846, 0.0070336558208003285, -3.517669189604871, -3.4264188745024633, -3.4465204410776473, -3.743439849213379, -3.46596327665581, -3.504595546032178, 0.1463634934972547, -4.425922500974631, -3.519926060613658, -3.1667898992874233, -4.020332419749726, -3.7747257573358755, -3.826736082126794},
    {-1.5287165790627237, -3.4377134034786807, -1.2341719783790108, -1.4648644472437995, -2.871858428160501, -1.7713883096171348, -1.4493193299421434, -1.543651461674225, -1.017163127925688, -0.77060475422568, -2.0829502831928375, -3.9052161603042013, -1.6345163396771476, -2.090684505521028, -3.781873295414358, -3.3739161028635163},
    {-4.936561010269361, -4.602825260679302, 0.47005545344034877, -4.98782957165906, -4.353388570909218, -4.865053772128449, -4.787548226062233, -4.7989826279708225, -4.854958415287283, 0.9423467561977927, -4.800921457606043, -4.467113159294999, -4.765317746023798, -4.763065469306454, -4.445869771618228, -4.181085137685137},
    {-4.049853086904695, -3.897618666272994, 1.4516252478732046, -3.9850614555622546, -3.588900792588449, -4.043855890233227, -3.5790430573116607, -4.1158022099638405, -3.848183531028948, 1.9279973309687974, -3.753637036928795, -3.693328087726628, -3.938990473045106, -3.960439526209358, -3.966180335695416, -3.8625108398791865},
    {-4.47369905276215, -4.225730946735863, 1.374061548109644, -3.711518849032496, -4.276938078164401, -4.540647027075538, -4.418965808822165, -4.461957169199502, -4.341575988473647, 1.5765301525037405, -4.262937116324764, -4.182476064695684, -4.09455931423027, -4.453395352634433, -4.3068533940773985, -4.095054168715026},
    {-3.5246849549041923, -3.498325528882302, 0.5034698082003057, -3.1758430265257385, -4.133402358145827, -3.501253939424098, -3.335288542392333, -3.317120960950671, -3.5673757677785436, 0.9248641955746132, -4.00364323418692, -3.81631713147997, -3.263718626477728, -2.8636087384075517, -4.268106328594825, -3.752204657869972},
    {-3.4793629877041545, -3.906097789432302, 1.4052577685962961, -3.3768336643509698, -4.216091278134949, -3.6034021684484108, -3.541496936372666, -3.4626047968737965, -3.3104669710720076, 1.8542128400912974, -3.782756715654057, -4.330421731401299, -3.774364300578807, -4.453947342606756, -4.215653142582113, -4.065157635745025},
    {-4.840515728809511, -3.923302867674137, 3.3356709506216715, -4.31698968452921, -4.27353312165763, -5.101261730434661, -4.876636664761796, -5.18032346511256, -5.191991675733361, 3.0595814556282144, -4.906525611584871, -4.170864985132875, -4.7276311441391625, -4.7717577911376985, -4.502557115903744, -3.7853454606965014},
    {-3.7682951918153034, -3.0822071636223716, -0.09457623499354571, -3.0671067589433307, -3.8628136582545776, -3.9947696241484145, -4.11403379320606, -3.6153323136825097, -3.7438468026171035, 0.40335729440978596, -3.873588055378622, -3.9220226505103, -3.4627456685813693, -4.132120429156836, -3.667156139568524, -3.3768970018617384},
    {-4.401223593223654, -4.615904746276907, 1.1885991746008655, -4.400865695826918, -4.801821074778801, -4.459411355790112, -4.197917575256923, -4.3265826111551915, -4.2799480925021225, 1.5654248772618853, -4.604428707313522, -4.776098534096368, -4.414419058837908, -4.709571304473184, -5.181889670260188, -4.818736330696914},
    {-4.772098691399227, -4.255044532041547, 0.5995415445421247, -4.022695733197948, -4.559869669313591, -4.5772513082984, -4.805526497541678, -4.5805426316160975, -4.646152159609008, 0.6639429521109204, -4.763636976035695, -4.694889912221784, -4.433314237987663, -4.639665207160688, -4.812370761805399, -4.692374227501352},
    {-4.776683073059718, -4.658932386716679, 0.5592663610887341, -3.8523550183313264, -4.546940645705186, -4.922348045208842, -4.9935775493964405, -4.750196863997186, -4.830650674697824, 0.4968424759913827, -5.072209927285704, -4.678166573407177, -4.3559525542011235, -4.99361705767761, -4.900533369403104, -4.865719963379332},
    {-5.2713957534724605, -4.387805645175845, 2.0222924762423276, -4.109883193457488, -4.536039798596561, -4.907264413975859, -5.316615801618622, -5.0642981747877895, -5.061107727858406, 1.9288340078828925, -5.157698157428533, -4.2907793508836765, -4.3937409466341695, -5.1112579275069185, -4.872914240284685, -4.633781973449881},
    {-4.476873408988247, -4.845752840272632, 0.12686869389530425, -4.271509163887623, -5.428386482012505, -4.474988577336666, -4.5544897225006435, -4.814339150823848, -4.733307104493507, 0.16759944955237457, -4.92036456393393, -5.149806762846004, -4.120377857883613, -5.165363247479242, -5.365681334158682, -5.1382229635475944},
    {-4.1781904962491305, -3.9571150311558214, 0.4586355977741775, -3.0478765822399447, -4.541713589988512, -3.7664336926767503, -3.7833317825505226, -4.159347950991075, -4.312305583613886, 0.7989351202098905, -4.457413826300896, -4.446062483440464, -2.870832292477334, -4.034042644864461, -4.676440987512689, -4.42523968958291},
    {-4.467277428286685, -4.399504344346605, 1.6123791613324658, -4.16678007911897, -4.356618484958602, -4.070947009821367, -3.920184228771592, -4.9045192782125335, -4.832224216194788, 1.9498640450492415, -4.901655567496525, -3.961613588284146, -4.097409435463566, -3.9440755829256404, -4.472270201087256, -4.794237355009754},
    {-4.810616093047222, -4.451626786941492, -0.8737983530204962, -4.31612741564995, -5.142909756690769, -4.304911092528043, -4.709854379283436, -4.709651027425925, -4.662446205221618, -0.5768957086578004, -5.480444338939508, -5.066232828070546, -4.239186807192942, -5.5277795388872555, -5.06142284628854, -4.950333141731895},
    {-4.414943049926948, -3.306437507037971, 1.3622160093607876, -2.8955038934408663, -4.101134988357536, -4.5047536664707195, -4.435771873946911, -4.688335495531528, -4.293173113636567, 1.5115602702374946, -4.678113972690805, -3.8991638708097134, -3.583766322622752, -5.487118104757362, -4.067827131696865, -3.740817834306323},
    {-5.541835884802704, -4.461295954922017, 0.3741351788232318, -3.573982123556142, -4.4497459345562405, -5.5184110747231, -5.309876955840646, -5.4454586464316845, -5.304198513113309, -0.060791198673547694, -5.37302923646684, -4.785834921358616, -4.344650661345249, -5.9486494286318825, -4.706139545250149, -4.833064131433092},
    {-5.795756071392151, -4.985152009887466, 3.635769369866511, -4.7340811572188075, -4.794475940599159, -5.516047474981347, -6.246280470645621, -5.92368563255227, -5.648635088558927, 3.6078595214672764, -5.259823186441909, -4.873290785542725, -4.694279608934142, -5.509960079525633, -4.962265346024736, -4.816882689657883},
    {-4.178414528015474, -2.1436085826003253, 3.2019521742622903, -1.5499765929448446, -4.212266998940428, -3.605227393662672, -4.695304047712933, -4.360920849623737, -3.702185488690204, 3.654711553359196, -4.2510963830424, -3.6455370350093945, -1.5445286325014362, -4.656183818407148, -3.912460201553738, -3.6036517720668337},
    {-4.606222401368006, -2.6999247880420247, 0.8567799707591598, -1.8152647758808318, -4.5975770184154, -4.1387943866895185, -5.111220854255329, -4.880800746932401, -4.398067821775492, 0.7453306603534253, -5.214766345230596, -4.361563904976296, -2.220294336706984, -5.0981728602731575, -4.462686103308034, -3.9013204512601853},
    {-5.45958097928616, -4.671935449229539, 0.43762759518658917, -4.139532634975812, -5.005055081723522, -4.991585757081011, -5.499944213380386, -5.388089243246544, -5.248970631247281, 0.8029118660399244, -5.9578565928963405, -4.646380339599187, -4.550231264734911, -5.622015461545508, -5.01508772774351, -4.5416768704637605},
    {-4.350203527735085, -3.393789151166038, 0.3170687752753136, -2.6313637083364037, -4.6830034047557785, -4.004790642936882, -4.548110691559638, -4.152382321413915, -3.882527437209564, 0.8499870017876441, -4.843117120944913, -4.814084493846252, -1.7273672957881445, -4.8893395265827, -5.028243926318554, -4.460799620644283},
    {-4.445978642265123, -4.01875676897028, 1.8858187940071027, -2.185001095256899, -4.805837043020906, -3.7533043058285864, -4.667241292083443, -4.1384273880785205, -3.7541802670600486, 1.8492870597462638, -4.4686370259925985, -4.2044326260613385, -2.970523106500831, -4.78483496791549, -4.5786267786620956, -4.1971675095046},
    {-4.753475963984229, -5.124376180150147, 0.6453807430733786, -3.5553892412450603, -5.563960353580251, -4.578206450703241, -4.966006257554387, -4.741264957419576, -4.336524248493722, 0.6487341458084221, -5.051499636443716, -5.346200319158036, -3.9322185206950904, -5.478273477512371, -6.02673785366403, -5.156839969581881},
    {-4.775028926216479, -3.9588961762981336, 0.8258872262615967, -3.3038226057522384, -5.521333179915634, -4.429950872006495, -5.192121730206983, -4.62858683666856, -4.638439892572938, 1.3321728080172694, -5.443817054670123, -4.936114766820109, -3.3046406122173333, -5.437092672352323, -5.29122907885437, -5.228367453863828},
    {-3.709515276251741, -2.9074285697903597, 2.455547077151554, -1.0055793128272101, -4.431746336293976, -2.335766717912112, -3.349126379718179, -2.9812621085366184, -2.7638553182316974, 2.6088205195167244, -3.62693853350958, -4.179516052286854, -1.748543942684587, -3.2721529430614287, -4.548890280161953, -3.0540726722597014},
    {2.734081377492733, -2.2748702907602527, -2.391135290956734, 0.7595241343270929, -3.1604407464257513, 2.839831445417784, 3.6778850919552744, 3.007614835388606, 3.2584230269237278, -2.2168026308790156, 3.2584083120665093, -3.0368874362334113, 0.40820605630413137, 1.081279126949514, -3.037639033214877, -3.260528068596117},
    {2.286847745773624, -2.134748242209389, -1.3558888316951743, 0.574495011948647, -2.990022082408517, 2.133116581091125, 3.182266742274339, 2.3164162887228197, 2.535124732594613, -1.1656270553485033, 2.8037831668019493, -3.1565590239772616, 0.05070162461280715, 0.5576564870986471, -2.720616614097224, -2.8477799303875933},
    {3.8053084053018815, -1.9763016226058545, -2.614594424924691, 1.9179477901206692, -3.367556434338829, 3.9906968330073314, 4.513119725464072, 4.064692459384239, 4.539106970665507, -2.4997300161066067, 4.085509413464884, -3.036983103133939, 1.4453055484937303, 1.3788200348055135, -2.994217275131396, -3.274792337550901},
    {3.9267840871324746, -1.4527225095042489, -2.0380229673891272, 2.0572825979443587, -2.961167650535914, 4.1850283075617645, 4.211123823146698, 4.0899404636594, 4.321319700925567, -2.007674463738854, 4.368177488571005, -2.8580500027131426, 2.079216454944357, 2.158596939197549, -2.396642922631509, -2.6368298816900433},
    {3.346179296561602, -1.925913376016665, -0.8298357728173268, 1.4719925284697568, -2.7919129238741283, 3.4298292412311984, 3.924633421268416, 3.5878183594957704, 3.5751814780299394, -0.7522131797949494, 3.830277180988371, -3.004454408174288, 1.3117265266240934, 2.0105725533788497, -2.6542262297023935, -2.682786913701526},
    {3.6199244530653965, -2.23779294541454, -1.468121061801402, 2.345556090224896, -3.2269035924615013, 3.9349603249161555, 4.432792482683745, 3.8651072895330425, 4.307992317237803, -1.608697469308172, 4.109357762405024, -3.164321255204712, 2.03389079330816, 2.3765020141807183, -2.9375581315372057, -3.1840485965775485},
    {3.5546842806274714, -3.232539871277211, -2.1717121406364774, 1.9021959794314192, -3.6870153496109537, 3.8005975864103005, 3.997620565836191, 3.650044749940191, 3.961547798659306, -2.2914324897082703, 3.829832750966139, -3.8407205297403717, 1.567062358729273, 1.387093476308346, -3.964953434903058, -3.7450002211227202},
    {3.5276506983946034, -3.7649648057283467, -3.2067539954949456, 0.7256103679022373, -4.6181002030027605, 3.63371760320988, 4.083808532177498, 3.626965500845282, 3.8549542218268282, -3.174499104006638, 3.6095274294630517, -4.570925949350668, 0.9988310189520546, 0.9287969837565662, -4.35417282791999, -4.284911082307889},
    {4.138287729623466, -3.2666219221884267, -3.6724353124727926, 2.4784268709049733, -4.5327975100322435, 4.7264289449284105, 4.8363504426703905, 4.610580169567245, 4.645209746891342, -3.4799232024872935, 4.39093556698511, -4.689907275538795, 2.129744561139802, 1.6264789932527342, -4.37105928304187, -4.189618687021352},
    {3.6705984076477334, -3.2327309385262093, -3.635089096454879, 1.9175248990771958, -4.873298924645822, 4.207498854579643, 4.237611559348881, 4.188612885676249, 4.0725544831960185, -3.673109683498946, 3.967632705456846, -4.653480352052422, 1.7881042202432247, 1.1023035285613905, -4.525910779061318, -4.434471533153549},
    {3.242997981541314, -2.6097363063047028, -2.205651945318032, 1.487323275414581, -3.8061107746376166, 3.6327998453870025, 4.1750716620201365, 3.4592082178675208, 3.4982017730828456, -2.0937516687824353, 3.760656034681777, -3.8583084136952848, 1.4219301065957528, 1.5649049749097546, -3.67318155146193, -3.727468038142894},
    {3.75270468000261, -2.8868503548747952, -2.406555860707459, 1.8967487796626599, -4.55307607907004, 4.1138149641813735, 4.679086649033869, 4.083365338232224, 4.172016590733712, -2.174768915138439, 4.196293249203764, -4.419856105507005, 1.82810044375208, 1.0515965329239008, -4.198584396047258, -3.786281615447956},
    {3.8579853382814933, -3.5065384588436497, -3.2779132738785264, 1.1863829503576304, -4.897752197825364, 4.242221275537718, 4.423729997151653, 4.215599223708722, 4.0682105736252625, -3.255137127390102, 3.939347799427969, -4.680775299123738, 0.6103232812865412, 0.9086202165031393, -4.32413764539599, -4.4990693233768075},
    {3.053639229732009, -3.4766135991235987, -3.45856787898778, 0.9236493704770118, -4.578119956679522, 3.6829437950547206, 4.03961244088825, 3.2996905941594163, 3.944893454113626, -3.294985385377992, 3.513836483664746, -4.677990495096285, 0.6831116568302322, 1.442821239950153, -4.543043373624472, -4.366979554599525},
    {3.5012583643580943, -3.502953632421831, -3.597676899916708, 1.1845772146888627, -4.887888418773709, 4.030115693150012, 4.203200170066811, 3.8671628453135134, 4.162592761636463, -3.320862525718882, 3.7272342112030414, -4.775309730385261, 0.9945114957459565, 1.11453735521482, -4.534882233844052, -4.34487400339727},
    {4.050515719528213, -3.4459814781952063, -3.149723072839215, 1.1242626169765633, -4.45488314700179, 4.627859002783248, 4.697673609726441, 4.266095932816895, 4.622417181811322, -3.141961091637567, 4.733141740043946, -4.209352883121788, 1.2720424877562833, 2.117320465530894, -4.200335871288858, -4.010460410531815},
    {4.5212432718469, -3.5762550203308567, -3.143333390123996, 1.3509276690716745, -4.842864236145071, 4.886323867445554, 5.199990193528057, 4.755509936326463, 5.043797261322294, -3.2970635228237697, 5.0367997044407256, -4.783248369990436, 1.4401045527049872, 2.30590682938101, -4.858850553580181, -4.530244437164698},
    {4.244713204824067, -3.518685786639744, -3.593006167316621, 1.7076630351118574, -4.858418076567577, 4.366714905595866, 4.884568313250107, 4.220729711223567, 4.413292920636869, -3.300066367158151, 4.623672664063002, -4.5474227990181655, 1.6736895560457985, 2.1365991466934506, -4.424641626676153, -4.3636645192466625},
    {3.533062454320368, -3.7306028441718473, -3.882669082755989, 1.3411300776414767, -4.79443980780682, 4.077954049928533, 4.422708903209629, 3.955770910784366, 4.307898741707232, -3.63997184436814, 3.8580545852965855, -4.948314955740049, 1.6092819678780963, 1.3136844474151836, -4.836343937696452, -4.884981677139401},
    {3.966213760023912, -3.7644288723805968, -3.8084133500493267, 1.0782858589666962, -4.8118182343590234, 4.5494378518101515, 4.798628520357317, 4.397715445689286, 4.731322195495069, -3.506084991742121, 4.577287182260499, -4.662759466671027, 1.6450782672671156, 1.587173543389054, -4.441038518754084, -4.457029442932788},
    {4.3671054253396795, -3.5841955019831446, -4.070031321644618, 1.8141307107565954, -4.291693594376429, 4.8365727081486245, 4.932693617306395, 4.469230283088681, 4.879615360701402, -3.9182497036408503, 4.449004971140487, -4.579062547123295, 1.8804497096522244, 2.1268221562911376, -4.319413726576303, -4.01289621141269},
    {4.523774971871803, -3.8053583929967334, -3.6165169458416155, 1.760553346282231, -4.397457296593508, 5.001233142609372, 5.163181610360312, 4.768567185005444, 4.858123774061289, -3.544023360199883, 4.7903245654541795, -4.279752575381489, 1.7452385247764908, 2.4985556714897674, -4.489109906737186, -3.8999630672650842},
    {4.4500962199393825, -3.416233550930183, -4.353026865769115, 1.9245815633424994, -4.58528740826045, 4.790788979022093, 4.898927868888067, 4.576816717514686, 4.842569630180168, -4.1591957900135945, 4.519173689256706, -4.740273602183147, 1.998028360571951, 2.304140280240214, -4.628020633593856, -3.958390420135606},
    {4.220887013850031, -4.374038432147536, -4.766689276953346, 1.4438354586687658, -5.195213771437516, 4.501336916305731, 4.940977814181713, 4.598700747885665, 4.51224060596541, -4.645868579778252, 4.761147712961895, -5.1551634527469306, 1.496789343461212, 1.7195639237033744, -5.105838212750009, -5.113832718374979},
    {4.519900347217601, -4.300850669754111, -3.5881702228255676, 1.4978887977815636, -4.897328940409674, 4.767302774807912, 4.985626606132048, 4.486532899533193, 4.879417225464271, -3.526714196677002, 4.736519538580776, -4.807019961530112, 1.371267631567612, 1.9841201851863095, -4.812368243364827, -4.895929118551695},
    {4.3161746910008905, -4.4848799031123825, -4.258753521103459, 1.0329056640637724, -5.443936377649854, 4.893084208754949, 4.887776386259554, 4.2915796006220885, 4.849141065359201, -3.9840486225826566, 4.518177533528079, -5.402109468735488, 0.9327641854353309, 1.6167455106865112, -5.322473543015942, -5.04341326257723},
    {4.788792551878065, -3.5790027541122678, -3.7333294246990043, 1.3051584850687699, -5.206711217491868, 4.72850904373214, 5.334269149217525, 4.618144671300498, 5.009828641027647, -3.828350117588379, 4.847445665465764, -5.038023379020752, 1.3417719096541612, 2.341359247496526, -4.673458657680602, -4.638243736860782},
    {4.428244340970938, -3.6388783394997293, -3.2953817385304354, 2.208044679817876, -5.0936705244212135, 4.993726273314617, 5.117160120808711, 4.598417074173447, 5.211900377859959, -3.015790290754563, 4.661290741404676, -4.759688213267784, 2.209574405371623, 1.8112362277350091, -4.649337559338297, -4.333977322219597},
    {4.109777500748345, -4.33315122974587, -3.8731283413372113, 1.600573747871134, -5.4888319977613484, 4.712997308949743, 5.100776938883929, 4.2992127906022946, 4.7284337576606985, -3.544596034839077, 4.602029161139754, -5.392432462961993, 1.809333084302437, 1.2316199980041835, -5.232851663592931, -5.171875255838156},
    {4.434455278554002, -4.005919419218472, -4.237225349758632, 1.9188167286949185, -5.245547696344817, 4.85152777875467, 5.1327464475870785, 4.6638032428081795, 4.888896346760646, -3.9475360334938894, 4.765438259981398, -5.095385777599146, 1.6856375937183268, 1.9773055478305286, -5.161002034532964, -4.70824873104691},
    {1.74434294788356, 3.6439636804841666, 0.16895382845631715, 3.6553790288864385, 1.703468674895997, 2.5501575448298177, 2.012535570908752, 3.33246581113652, 2.503619660927928, -0.48488265002851055, 1.6259003058860437, 2.1005476190669765, 3.6649723625807358, 2.1956436447231726, 2.143330531353593, 2.874163303811159},
    {-0.88868731974347, -1.6772723998145433, -1.233866539251594, -2.3799590017402306, -2.8964505896675004, -1.7850985729801012, -2.6201099651552457, -2.068478189616042, -1.6357813645921502, -0.38098099985924844, -2.233952387288464, -2.8227042386211396, -0.9503902554421219, -2.8162974198624364, -2.2167070239524165, -3.440801602334459},
    {-1.4559744576556306, -0.2559767482761091, 2.5388481882030725, -0.3815488880225994, -0.03823763263680275, -1.0154160046200758, -1.4828665700682442, -1.0115845106888117, -0.48830209459498686, 2.2691317917973497, -1.7609833599988385, -0.5379288091738225, -0.649657155157222, -1.4846477318750233, -0.8431403277674807, -0.07160449351120012},
    {0.917575961408691, -0.6285896313421417, -0.01927468325467072, 0.8535658431215969, -1.0493739811087914, 0.7668757630395405, 0.534749872280577, 0.7615184792694173, 0.7227261420312795, -0.13556988141232393, -0.30419097270486073, -1.2710663735658574, 0.7567519371167141, -0.28010619050701613, -1.6645137968856476, -0.6597260004003036},
    {-4.095708039681287, -4.0696146896103915, 0.6588290620765574, -4.039070364354101, -4.5080401487098465, -3.6092911912772068, -3.541610413587516, -3.724904118644526, -3.454267980251228, 0.5531587379880784, -3.707003340863006, -4.281935122210547, -3.3459903568884033, -4.193123458469842, -4.608715128570752, -3.9409241969634343},
    {-3.089939151058326, -3.1813854884181616, 0.9020279421167497, -3.375864467382338, -3.4605275190183655, -3.1283081136750748, -2.8925337447368884, -3.1718880397798492, -3.1032891022409594, 0.8351502561056627, -3.158644414099174, -3.344886096238336, -3.3528036743667693, -3.0682387343262465, -3.5515870812387704, -3.4263695388315516},
    {-2.987521981060912, -3.253245378527536, 0.753435855899563, -1.7637654717513949, -3.8825999158920177, -2.8461779150525826, -2.7730105535043243, -2.295917167766539, -2.3935125420113184, 0.7396214740338978, -3.1831701155699412, -3.869502075835827, -2.470748943767808, -3.282034652908758, -3.7364768603504572, -3.6339231494002084},
    {-2.5176926921729557, -2.5028054592725146, 1.0092331210512615, -1.7115230361570104, -2.761743677849406, -2.305930012182566, -2.4939365400652664, -2.3906459118657457, -2.0985253164327102, 0.9073474015818321, -2.799385286414556, -2.598838724592209, -1.8969403335713224, -2.060630330439333, -2.584561794174171, -2.6931194693675202},
    {-2.77549861828883, -2.9595838170447197, 1.5417159375020866, -2.785789355743302, -3.6060175515534567, -2.8738818866340763, -2.1529058462966186, -2.590792452624044, -2.0843378845986513, 1.764265689921247, -2.680628951263723, -3.2842802329669487, -2.7748715461880953, -2.994864541933952, -3.321239478614995, -3.4205542318752835},
    {-3.9330554539070666, -2.016832741267949, 3.404681082091556, -3.032724086443374, -2.7287499689669032, -3.7625897699017288, -3.470620956192271, -3.917943597896874, -3.7272085197622262, 3.341064112016052, -3.429169653676623, -2.365684115520623, -3.233868805902497, -3.680733224039413, -2.999286920537161, -2.3015475770885554},
    {-1.1055105619249377, -1.1328822355735442, -0.291817837694811, -0.6001383602979736, -2.527706253542546, -1.3463423322641495, -1.8494915719146707, -0.832581313469833, -1.0541131562387671, -0.20095899362513506, -1.5271144092856852, -2.3154047188855307, -0.9601399701855236, -2.8452538119327455, -2.472989194865518, -1.698115304707363},
    {-2.496490288991072, -2.3890511137992543, 1.5870291225152144, -1.5603768034405403, -3.6771003177279034, -2.3755589789373803, -2.431192925710961, -2.2334477100452372, -2.3395495521419223, 1.5544807546755537, -2.6819295891227206, -3.695074362806576, -1.7886390457268848, -3.126111573553159, -3.4068541582223757, -2.999166772387003},
    {-2.716187217691642, -1.9047020537491672, 0.7986398019944378, -0.6876471195474105, -2.551397142109717, -2.062651412759403, -2.444273225587966, -2.1145797590471447, -2.2398202930972633, 0.8375410445472417, -2.6337511732590597, -2.6477660383649515, -1.0071323953959455, -2.7111554151243804, -2.3082594774712146, -2.1183267809917536},
    {-3.1662490976022193, -2.0101151259033876, 0.9058312181676283, -1.068082033392463, -2.865883817066727, -2.6129383952583023, -3.085247563173448, -2.912335815439293, -2.848939684526457, 1.0165914722225566, -3.5953943858782083, -3.0553637197916927, -1.517264157419469, -3.415761082152912, -3.1998556070437076, -2.3564612578267434},
    {-3.7743588931263887, -1.998752945892729, 2.032036526098313, -2.2577455359245646, -3.354090481005388, -3.3211491351285325, -4.049858063531748, -3.536069832381184, -3.7446894115177236, 2.0452780202265206, -4.120767673949571, -3.3528611552056904, -1.954132936061497, -4.27909952809244, -3.375774435214646, -3.1917113082535606},
    {-1.8889535856078172, -2.286318561222682, 1.2789438458093407, -0.901021101189032, -3.3394996152008196, -1.3634290076284912, -2.1458156750290804, -1.7049928730825945, -1.7309322797622475, 1.0137479740299637, -1.9154759378523099, -3.213252923324413, -0.8400029405248387, -2.605712982470982, -3.435909820501645, -2.510101583636178},
    {-1.8304859392313853, -0.621427995612231, 0.6654785982095412, 1.1377008862843512, -2.2021909941457407, -1.3233447068347701, -1.4066960801818573, -1.6198449533876074, -1.6368083746172415, 0.7656557071057477, -1.8590968667341212, -2.6941475222967357, 0.9722922297684966, -1.9521783349364845, -1.9279434110871196, -1.477794428388905},
    {-2.761292113722175, -1.9539206955694675, 1.063486329432373, -0.6020642224860931, -3.2232841780241865, -2.2001939397104686, -2.50941797340459, -2.390212989954991, -2.127054707059164, 1.1307071101332233, -3.0716611289145863, -3.4321610200818213, -0.7629176469884739, -2.9007591640148114, -3.42160732432957, -2.600422327475735},
    {-2.2224993317231814, -2.5618754684697067, 0.29794892240516985, -1.2054101894193103, -4.106549359960474, -2.008669656420077, -2.6637094097511063, -1.8745543155838764, -1.5045807532316007, 0.3774128184126704, -3.083568801875464, -3.974359723708617, -1.2396474209550135, -3.4341803645050555, -3.8905824426708024, -3.5982795564340817},
    {-1.8957321669141483, -1.6747388734042987, 0.8627084166276928, 0.40183409773019024, -3.341171972208224, -1.033156344074865, -1.7219878554614647, -1.3481292220623589, -1.0267527796672784, 0.7548613645216182, -2.25205131364027, -3.261633277359769, 0.18717587207795236, -2.922239074577519, -3.4978372484028393, -2.5227136229972427},
    {-2.381806275775685, -1.2475322714467276, 0.9598079988278126, 1.5468607778986811, -3.6739203269460425, -1.0217046026610574, -1.504737348066063, -1.423737260058222, -1.3100760855658313, 0.7549373397110344, -2.0113579931192436, -3.6248530428530255, 0.848983075031892, -2.7662053343209885, -3.1305862656201997, -2.809241112367674},
    {-2.1214478630758578, -0.17080548048007527, 2.4879710027035493, 1.1137494910348995, -3.329765945784823, -0.61971139646007, -2.523091084321057, -1.6191149719524809, -1.1943211365185775, 2.2045919309529634, -2.582856217731778, -2.9829537875373324, 1.7346279614980848, -3.221811043566548, -2.562104198279834, -1.81492512941763},
    {0.2868711358209286, 2.9453398158767303, 2.572803445875797, 3.6271264402371552, -0.9728702057085267, 1.7733346866409658, -0.2331503875986656, 0.9385708759735627, 1.4974198380572512, 2.4964548577481156, -0.45241931435837907, -1.1355617026538634, 4.119402909219327, -0.9597136115889937, -0.42565873139073357, 0.5844422215994916},
    {-1.734528067323232, 0.7042221832102178, 0.471976883888334, 2.4311650106379443, -2.830919037097514, -0.36978469266907976, -2.10232681594692, -1.1287055649277347, -0.8402296985436273, 0.1519160588763271, -2.690599822181431, -2.553899596182834, 2.407659896077403, -3.042060315164276, -2.0374087406792407, -1.1922543139436967},
    {-3.271941424990231, -2.4474700036854835, 0.04390884614586939, -1.1096478299643988, -4.4973597944907135, -2.48100976394498, -3.2114688130491293, -2.5484931813576646, -2.642233548094243, -0.02336434197917327, -3.6651552929188944, -4.5118708798884075, -1.0338694100144805, -4.406244149509891, -4.404523477025992, -3.4846047164141685},
    {-1.5018688581439095, -0.3963813041034941, 0.6969251946866485, 1.5345226966665544, -3.6474391757719578, -0.5142339936989107, -1.5035699376005611, -0.5135949977361096, 0.0996019120750505, 0.4419946712131501, -2.5026336428593288, -3.7327876740248565, 2.0854744995407852, -3.140166881274279, -3.303642365172058, -2.449871620749326},
    {-1.6275385238417603, 0.268471882012195, 0.9986150073843019, 1.9776264919876194, -3.707401240925664, -0.35137342072110345, -2.0910051839680364, -0.5530865895564019, -0.5714257964666357, 0.568590402382231, -2.4006384840588493, -3.3586052452049504, 2.2290413363560737, -3.4933160239428185, -2.8739544115294207, -2.0100847386568677},
    {-1.9677709574606566, -1.25710500229385, 0.13644029537582703, 0.9563996892911618, -4.397268393245835, -0.5764346545901954, -2.300710925225364, -1.0856713583018072, -0.6450976292451543, -0.23698856896793893, -2.592287740223589, -4.235967920407974, 0.7913341048222691, -4.02561575707606, -4.384314348690358, -3.2265119035776455},
    {-1.9990783433613573, 0.2549329415004429, 0.29289671286884145, 1.4873851126219062, -4.103668052753619, -0.8628854748854573, -2.301425220793191, -1.2778804529178118, -1.0525491207694857, 0.07216941169318589, -2.8715007071225727, -3.7812289660273435, 1.652230981640911, -3.873527342231302, -3.70557427479879, -2.6318829446934857},
    {-0.010899160155255414, 2.479199284336258, 1.1467737110681382, 3.882060128249853, -1.3529902401893183, 1.7463613846186998, -0.023310887474580374, 1.0329618949270345, 0.994574995918817, 0.3304030392034814, -0.17696164634999018, -1.4719082239637618, 3.709565265751008, -0.8495397076710302, -0.5855859429215654, 0.456353200604359}
};

static const float b1[16] = {7.7238428278122155, 8.134558965918204, 9.092016892083448, 7.850830878904033, 8.268443487199976, 7.840377505280094, 7.902457012507038, 7.801391219433894, 7.865821812258013, 8.98502035839156, 7.969016820697007, 8.165902153143083, 7.953846049037456, 7.926688191276338, 8.314890775662027, 8.243248856366074};

static const float w2[16][12] = {
    {-3.696782738840061, -3.7451998515346205, -4.092564767437143, -3.725530338817503, -4.659070836939093, -4.477128844765598, -4.341426140875578, -3.8375833257980587, -4.380619103917625, -4.5969622751657795, -4.2510632710660365, -4.011866007456912},
    {-4.260578241519442, -4.149802658638224, -4.0453973550085545, -4.580096222473417, -4.703169890617312, -4.540103635373318, -4.5288689786321035, -4.415911308399177, -3.9027557992309228, -4.4515534758725765, -4.210398114259349, -4.443955070781805},
    {-6.209883973408996, -5.918506374681856, -6.377509267920569, -6.353651335064594, -5.821340840214826, -5.980034125676687, -5.930081732046731, -4.979547176612594, -5.4441131844505435, -5.9162120655964605, -5.526656717647507, -6.025518488389108},
    {-3.9468087630451034, -4.642473080713371, -4.646312464686008, -3.980985227516368, -4.00575209656963, -3.896090137208111, -3.929657117505676, -4.286784387043042, -4.824982748341716, -4.2453642672410945, -4.08543334228891, -4.095420806691484},
    {-4.332419488693843, -4.076335638188219, -4.294158122761969, -4.209814684550984, -4.797899914794039, -4.136602982408907, -4.493943605157752, -3.9735539164321696, -4.53631138683655, -3.8817037589346275, -4.4890148673735695, -4.895517216233438},
    {-4.397746140956576, -4.555445529378096, -3.9552333653249208, -4.76091612211859, -4.61333518730471, -4.014702139552342, -3.8766626052523177, -4.585495943715015, -3.3275948746125743, -4.817858575122587, -4.444649810069332, -3.864794791624581},
    {-4.232620583096629, -4.235671242182639, -3.962741066415511, -4.118605356211859, -3.8847274291787115, -4.211871786704795, -4.007410087856956, -4.30553321505396, -4.189302350315991, -4.379376934743852, -4.493803179391147, -4.884252142644488},
    {-4.397251578832068, -4.290346250601682, -3.9395767964610515, -4.55785200918781, -4.067381353555067, -4.212293610027559, -4.8029132824791825, -3.8229622725399057, -4.574527347404833, -3.8286466748126773, -3.3346083280356895, -4.662692867802968},
    {-4.461886832416502, -3.7793976347681304, -4.496718606529625, -4.2237251158677145, -4.045637255713195, -4.594951660881279, -4.17997773515725, -4.488886823211696, -4.3570280668751735, -3.7797805596918526, -4.3720296133426055, -4.240238086718968},
    {-5.581869970883954, -5.801916787800435, -5.392319281409819, -5.562912354174805, -5.999188605597096, -5.770643660806624, -5.772438797830508, -6.757364580468037, -6.279948516047401, -5.809385863304746, -6.222977584247069, -5.661866635064385},
    {-4.516935855388943, -4.728132128565793, -4.837482178928651, -3.9140120489926296, -4.362285656192079, -4.098766902067622, -4.243396417850266, -4.206151522999123, -4.4466419085866224, -3.9833413233441424, -4.35992646791192, -3.5598261023754247},
    {-3.748201657083479, -4.4966861132938885, -4.112327451086013, -3.921881476996182, -3.881413756400586, -4.651485626229615, -4.035154519500402, -4.9707307795199664, -3.9925525442818532, -4.866214657817006, -3.962617901575881, -4.03688432855008},
    {-4.272060983788575, -3.657939115944792, -4.296212296327797, -4.175365163791223, -4.309022902010291, -4.113443771799529, -4.981487103486216, -4.191549922574856, -3.685383534817611, -4.6126972195076315, -4.2435306469731024, -4.5304135814003335},
    {-4.004354528878441, -4.5576679828023225, -4.014618029718514, -4.648659631780941, -4.0864296839795315, -4.399121017848721, -3.938901982517694, -4.477078695432868, -4.560840900964435, -3.9705508438665746, -4.6070928575475065, -4.324109429031491},
    {-4.632752824935818, -4.368295412068523, -4.1130487045378885, -4.3165479459665725, -4.221195498400727, -3.9811755024037194, -4.421843246546214, -3.833151264853315, -4.470008773979522, -4.32021753377583, -4.588420244915068, -3.8034112371572073},
    {-4.647815908732609, -4.381427087228845, -4.8613202024603455, -4.4462158282474045, -3.965377459407144, -4.285821957640899, -4.1252097744841105, -4.419262502578738, -4.571325311040298, -3.9917202408978456, -4.2202113332275015, -4.36421979333136}
};

static const float b2[12] = {-4.72417893103714, -5.273222818265369, -3.115771704813252, -4.0881595728681805, -4.071365348724726, -3.6772751435021522, -4.458169640392974, -5.109918956970801, -4.119240720235462, -4.140460915213409, -4.1245642562160665, -4.945445156666737};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
