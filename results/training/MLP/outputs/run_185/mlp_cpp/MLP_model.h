#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.2535470492073411, 2.3632373709521013, 2.761965935269022, 5.532085014218828, 1.3896069207221853, -0.9749592199054639, 1.2616758306332874, -3.010906156816218, 2.4362159934069756, -1.4268971586687875, -0.9508564432308412, -3.561145290055473, -1.1540649065180026, -0.16200889746339928, -3.8931427552153157, -2.7029471463832384},
    {1.0617377426757826, -0.7254063191625576, -1.743662767632224, 3.6068839846106933, 4.760741192304517, 1.5320900524624315, -0.2909696553506972, -4.047896738277246, 2.2469963745115047, -4.379039697785095, -0.12317412248437476, -4.289393776729024, 0.048331198791674135, 1.1165985194480934, -3.8929133601959376, -3.2377857318367886},
    {0.6429421095962453, 2.0833482030287422, 0.8262398593835878, 6.7033375011659135, 4.035346504876413, -2.304046279488249, -2.696025665665113, -1.6190588889479045, 2.0124608898440495, -1.3256234318901035, 0.035766635076798475, -1.8162668713679129, 3.775428660095188, 2.8675236731920193, -3.5619713074641095, -1.5322764882473527},
    {-2.4765831889130325, -2.8584921784502, -0.18331392725652404, 3.6707327432693755, 0.8332326252792552, -3.8609832548946623, -5.245445229294278, -3.7446399937697668, -1.4697605938320704, -3.857289721941269, -2.7434603773485984, -8.558119384243485, -1.3486590073913396, 2.880417281568995, -6.5253451674293155, -5.524696714373695},
    {-4.0426169951731925, -1.9771715282221756, 0.04690645910709537, 2.49270486746513, 0.6396909732296011, -4.316142854473535, -5.131489039941429, -4.568953710234543, -0.17729415249395347, -4.615634708590485, -0.9491662553843534, -6.697756705556514, -1.4689701042248335, 2.201539502423027, -5.29465698763073, -6.127875904331584},
    {-0.5251814466975905, -2.6129466433453423, -4.199363526525589, 0.9489430699039225, 0.6814398975126554, -4.4245142663327774, -5.777493237507862, -4.9980898717125495, -0.9578041569154683, -6.348776501035716, -2.251965169121786, -4.566844129485301, -0.7790215214581795, 1.2592349870564066, -7.320144486118478, -4.891907598092209},
    {-0.20541846774037245, -1.3586699487028304, -2.0691711462291997, 1.2170511415869902, 0.7040336324512585, -2.0225436605997777, -5.848499316159774, -4.727603554297054, -0.9657487000647873, -5.911790615161305, 0.8513058477154655, -4.77870760749174, 0.05072864592843479, 0.5360609232347533, -6.128239040773531, -5.9485487167849},
    {-1.9680112052092158, -2.0750955488930227, -2.0051861249878487, 0.6448534338673315, -0.15578281495442348, -4.665444022756638, -4.714785789523368, -5.005651810664579, 1.9052736220320776, -3.6619533889145837, 0.7332121093429446, -4.066739260342809, -1.2812329711624888, 0.42841457922892523, -5.5632451987109475, -5.229195132691046},
    {-0.32068786274454586, -2.9112760617608884, -2.0167520960189846, 1.471032508268918, -0.5244641596573578, -3.1445103671441244, -5.102968035512768, -4.936121239470791, 0.474564754212711, -4.367455055115516, -3.3308340289464042, -5.7897986237012224, -0.6889775104401449, 1.6606954956403057, -6.332827645300402, -4.808165194080106},
    {-1.5054587871069778, -1.6256510001241926, -1.273474063186653, 1.37963331062418, 1.156007067612223, -1.943148917387691, -4.877673431279966, -5.798294164047088, 0.43615461460287497, -4.150891554539027, -0.882717293713356, -8.065090796266391, -1.4225815935581578, 4.894747060716846, -7.435899184946087, -4.347184958974692},
    {-2.894640618531573, -1.7728989366216903, -1.7305314970864156, 3.1345186212276293, 1.24111626027422, -2.3713364077588213, -3.36164427828374, -4.9315376095239625, 0.22464157644593105, -4.955527588557602, -0.26106817513355596, -4.550410574365946, -1.750795656599689, 2.349567097159529, -5.174235468372051, -2.859112640201834},
    {-0.6369376306374881, -2.3947337242526503, -2.645718697223728, 1.505774841395442, 1.614508356692213, -2.399977106823387, -3.0953486253884015, -4.125807722112914, 1.7842178337756762, -2.121128789950535, -3.4004671573742464, -3.067732327589984, 1.2909998631881552, 3.045814775132384, -3.8479726523847235, -3.1439248323116638},
    {0.23440771424245938, -0.7735172013511679, -3.2351744505969875, 0.3221702238647248, 1.5039711334769517, -2.7017675271975046, -4.163531724885566, -6.43858055530626, 1.2916044994049454, -2.4339863886699487, 0.8448491450802951, -3.2179551674237024, 0.4567376118276713, 1.814607160280855, -5.585137543855809, -3.679218252839695},
    {1.0654348348623761, -0.11659811669810122, -3.0280596413815823, 2.52258429858864, 2.2441452399942228, -2.0386034729330245, -2.069868671267567, -2.729833708730891, 0.1298149492830861, -1.6760828645652224, 0.19216741902317905, -3.6460770414328363, -0.029213583696946325, 0.6353799897513543, -2.450935291610852, -3.5205796567757077},
    {0.38062593712939513, -0.27703200781607296, -2.927182603876567, 1.5347890981903374, 1.1090468324309612, -2.3448134272788588, -4.7837217385082775, -4.147756238367392, 2.6560368762708277, -3.7084177361175565, -2.1415710584802143, -4.782745622327471, 1.8017831060419556, 2.5378518451344934, -3.2014106586206044, -5.442256849300435},
    {-2.026462189570539, -0.49335793819968715, -0.7080412889522497, 2.1414416949275568, 0.19697417397079334, -2.535669673363372, -4.434812421722175, -4.654555922511162, 0.3664934340011818, -6.392193765999749, -1.2345160721772381, -3.8966394324751534, 0.5012904020561417, 0.37483071964028575, -5.359779383935006, -4.608332411036434},
    {-1.196361311745751, -1.144974500570224, -1.0833147400615284, 2.2251135139623655, 1.3899881817131499, -2.6324469379249393, -5.327393832305924, -4.892252293716231, 1.7219508515607227, -3.8950762914466104, -0.9019784893641608, -5.350258190708915, 0.5191796951979256, 2.2288092873358614, -4.470755493630379, -5.196269454286327},
    {0.04968900861072371, -0.30827608135360807, 0.5337611625384313, 4.373013825103749, 0.9867289294968294, -2.2105471957139593, -3.073689262851715, -2.783874484039994, 2.35859131021577, -3.345794332707857, -1.5248205552956655, -3.1373745067951955, 2.8475682381526144, 1.2037915555950869, -2.2120701113470003, -1.659044974753666},
    {0.16901075078021846, -0.8976507748556537, 0.33949473139022385, 4.135134468891697, 3.388784179896053, -2.6857691315522847, -3.4713546603941263, -1.2318081475715998, 1.3736732411106518, -1.3428625571026767, -1.062397569681167, -1.698777944462699, 3.712982149903287, 2.4758572026404337, -1.815040225156623, -2.263913917715809},
    {-1.1884717449387834, -1.2403253639212295, -2.2126788543653126, 3.4027219088537257, 2.086377593132018, -3.6018555198020197, -5.075522314948652, -4.1894326343309505, 1.4327747443656569, -3.0940656675927367, -1.338911539436938, -6.391210420254531, 2.4398668609546577, 2.0162891256113076, -4.210496262430756, -6.547199766549194},
    {-1.8455783660850533, 1.211211978772888, -1.5704520769475105, 3.336446425348627, -0.34370612949193924, -1.5931142818926156, -2.894681085244493, -5.928312083564903, -0.515960155980487, -4.055342880201625, -1.2837070436600826, -5.122166651210255, 0.3490289762346882, 3.1103564075074934, -3.252988073203055, -5.149451820629573},
    {-2.0335683893233956, -1.393024537873885, -0.08750485763396061, 5.004960446667721, 3.9219207050040774, -3.701585448055778, -2.2989383071034863, -4.483924937519132, 0.7668275874516093, -2.4991582409011173, -0.0062119961663983266, -4.191264816173732, 1.7338578039963053, 3.8908341021064468, -4.445259411349656, -4.469999960360229},
    {0.8346403719282195, 0.466224023820429, 0.7309751464467503, 4.9967138164613365, 3.4021975075449427, -0.19925514201608172, -0.777373671433574, -3.2381239568815996, 2.3723508339336288, -2.0313864253745337, -1.09163785954983, -2.746382604477356, 1.7028388635169016, 3.680465565311787, 0.017244651921427757, -2.627264951133256},
    {-0.48744591628005474, 0.457040371145678, -1.9913363060934932, 3.49967492575313, 1.5323975018276983, -1.2921005071618294, -3.865136820361059, -3.126009568774517, 1.0700287470029464, -1.8560517179637515, -2.647821134027279, -3.8460858333429635, 0.892776116946568, 2.5577239978953186, -6.470282314938592, -1.8525793960650234},
    {-1.3249345305637668, -2.51069414920048, -1.8953053024625173, 2.4745278864763103, 1.3504572273697208, -1.9431922563794675, -4.135148338406297, -4.411004498653702, 0.8570731407649961, -5.018394715105623, -1.7054823698434465, -5.868525941189063, -0.3298194346248876, 3.0889571090035837, -4.829229783973783, -4.579522601748167},
    {-2.102759605472126, -1.5313120744029132, -0.3639785752207651, 2.5829417119566864, 2.116550657172535, -1.064182445984044, -3.380916910807329, -4.846057108378361, -0.07575500804424154, -1.738495147721425, -2.2178158083773867, -4.859357128927696, 1.03297874679239, 2.3263805324088596, -4.154322852629896, -2.9911716446586407},
    {1.6915114173958692, -0.8288398217003593, -0.5764099822854771, 4.41145096697606, 2.4641973233866494, -0.15003092084838282, -2.710313237082109, -3.6083771815340935, 0.9453865197959559, -3.5533067902523023, -0.7359566398843485, -6.190897352429462, 0.5251716279924125, 2.7535722676684724, -4.402501731114615, -4.3158297532955485},
    {-2.048286460148581, 0.6446661608049954, -0.4529715561177521, 3.611903204260154, 2.3177438208759864, -1.5381301763195727, -1.503511768724586, -5.433500490892132, -0.02593020083242387, -3.6376504884729015, -0.053668259697583175, -4.244599449819681, 1.3602197353858518, 2.5981993468029576, -3.7577525784743937, -4.789595399481509},
    {-1.7408826504031027, -1.8718853676385672, -2.4744346805102473, 2.2495306774705415, 3.310223949575683, -1.5603257508399433, -2.321041418251867, -3.9113076266354527, 0.9546241618262565, -3.472225244099159, -1.4791308142815454, -4.273231825385493, 1.4095033767993879, 3.5691785382365535, -5.216148324929742, -5.392824449913205},
    {-2.83305109686302, -1.890583775816399, -2.811453234474592, 3.1394476094195896, 2.571090091414018, -0.28610768485107824, -3.1371260239510974, -5.055129441568635, 0.9897312288605224, -5.2825837109131415, -2.965840283449212, -5.155399462241288, 0.43036932598884786, 1.5288849429863864, -4.398227280692648, -5.062185011712029},
    {1.9515014281674994, 1.7796600740579855, 0.314479230999114, 1.1699565564166532, -0.23248236579084336, 2.976592762165662, 2.0751087209244985, 3.167339619487774, 1.0597637904099522, 2.2258722566475124, 0.4901725871409998, 2.1625628979867595, 0.9767900141816701, -1.8815894922532457, 1.684453297322686, 3.234958383719464},
    {-0.7282155203911832, -0.09158347597394761, -0.6888338179234281, 2.0155345635981567, 1.1696864741090474, -0.8703651328978602, -0.7223807823984099, -3.812192558027713, 1.6339756106205408, -2.1616336711408755, -1.5576408805529558, -3.981929490328296, -0.6892259372719735, 0.9228526999964417, -3.324473259894808, -4.159829466320442},
    {1.9882583516588526, 0.24795542170039875, -2.001669606570485, -2.042979244271682, -2.0566215409899167, -2.536900233527531, 0.733460237596569, 1.2928301791340295, -1.0177782586378399, 0.815738408921566, -0.22245497665469388, 0.13665667453326705, -2.9249200613382667, -0.4692546065505076, 2.429287930726367, -1.0782410328598095},
    {-0.2407063313206622, -0.053495912675936244, -2.434419903596106, -2.6799461201196344, -1.2606871649371225, -1.7259414570691696, -0.4920336660942996, -1.801874057928368, -0.5335775667784125, -0.483152418749586, -2.305748166781353, -1.826719464543867, -1.5481773846874722, 1.703770028639192, -0.5118104521013008, 0.40757064637319734},
    {1.2464174919463746, 0.7307466901757134, -0.98744425976826, 0.7027002776863284, -1.0012713167961154, -1.3866306470286855, -2.166500811713793, -2.12514878636906, 0.9157551050469018, -1.9242128144852282, 0.24344611291630378, -2.1040454109953983, 0.7748975303080631, 2.713932597804826, -3.2015072178120474, -1.0319880834964132},
    {-0.43547515554785343, -0.5299497304228794, -0.0748446971130787, 1.5297376920339048, 0.09706097309827788, -1.6576427603754824, -2.016325566114691, -2.248837266972812, -1.7219654995981506, -1.8602675523757932, -0.8194595563694449, -1.60290573426456, -1.724915824958301, -0.25643338593449405, -2.051362716049206, -2.4631374545059797},
    {-1.1813590256956024, -0.5184612836675578, 1.32719775273395, 0.19288397696359189, -0.9911510943132413, -3.2028644306233347, -2.37372018249232, -0.6128267067320932, 0.8864210618555807, -1.1988505150031028, -0.7328206492611801, -1.7356658134698353, 0.18150667513444102, 0.2585017409019408, -3.993179826166012, -1.2372502752529388},
    {-0.18399628971104529, 1.5383175735181176, -1.8109828123466276, 1.6466803143722741, 0.7636613675499658, -4.041339964601339, -1.3408859338306025, -0.7909352088872078, 0.5505913193933996, -1.913283768026735, 0.7442852071917538, -2.300899166435087, 0.385322448820144, -0.07538998094621009, 0.6803620267048254, -0.9808542492866931},
    {0.7629467295082741, -0.8644148584266241, -2.5657769596398827, -1.8773143863635882, -1.0722707099345081, -3.652339188637177, -0.7276504561656222, -1.7447725489449264, -1.917032596319766, -3.122322785464421, -2.615441341023783, -1.4392927984505375, -0.20472042634296858, 1.1759112627990735, -2.1208808888082555, -0.7403625229232758},
    {1.153327376751842, -1.0230232671490824, -0.17400721620165216, 0.92496794402743, 0.689748461547421, 0.013177104645388087, -3.618610594678546, -2.96262477890636, 0.3230830465260721, -2.821378739134472, -0.88041482162809, -2.968403693498173, 0.33490404406476504, -1.5226111914535583, -4.010683750727263, -1.746326102046429},
    {-0.46164627085623866, -1.987990059165569, -2.1043307374302236, -1.919409409878472, 1.6998251985314619, -1.6685951724959418, -2.003025399706027, -3.220242195382349, -2.4488380134166046, -1.8163485374668098, -2.045541832045606, -0.5831280409885733, -2.1526335299429284, 0.4949262667323167, -3.4192153600528385, -1.1542815617626507},
    {-0.8777222011528434, -1.4687207050391242, -0.38563099507856696, 0.42363560798434163, -1.8468215861323016, -2.391213389785291, -0.4452419955823089, -1.4194054973429902, 0.3243555384220583, -1.3707756050513762, -1.6648672197767866, -1.9076694059142656, 1.1046503212544814, -1.3623599808254039, -2.5325449210164757, -2.6658189685172284},
    {1.8304859133000346, 1.0702245919881324, -0.017875190614183065, -1.2508920163042427, 0.3202488689555146, -3.252265702827256, -2.4748176912547013, -1.8544284795033346, -1.3102542579749819, -0.25523973496732216, -0.8531301541921303, -1.9372641574564413, -2.4091513855457616, -0.34119174201030184, -3.0666031547612085, 0.011679154445583975},
    {0.7171891890959963, -0.4404318385615053, -2.9581537377564993, -2.0825542108642643, -0.029494949643628667, -3.455275773234669, -4.802776547700346, -3.874075208369452, -2.0067222803799742, -3.09241971630725, -0.4245167231025159, -2.535300397363473, -1.823768297411783, -1.2645372767135745, -2.8825937590107444, -2.9695300190172804},
    {-0.8517769320680056, 0.374891096595895, -2.013501141452034, -2.404690721815465, 0.642942578555775, -3.744309873967323, -2.7867140985009846, -2.78614727912786, -1.62718167202152, -3.1224952877008163, -1.8981569734809987, -2.090309468805833, -0.44097293208933935, 0.5374981831436091, -4.746238098971473, -1.4958808044832337},
    {0.8290056379386743, -1.184370725183844, -2.45065843676359, -2.6053023452206063, -0.9144793173478385, -4.617236175284963, -3.913023450527608, -2.519256736840258, -2.562926382687155, -1.6783884415192711, -0.9854939462860821, -2.0886323824089272, -3.413952112748968, -0.0704078926619663, -5.608020519424075, -1.228328887549329},
    {-0.34881122897571987, -0.4653323216884863, -0.9119019275348055, -1.7232689373834478, 0.8203445931901542, -3.3290635561394195, -1.9651787473134545, -2.991602174052584, -0.6593058265731412, -3.113233245969954, 1.1326483678322168, -3.243481641057525, -2.1908448388128896, -0.5689960528862663, -0.16029824619975158, -0.8377242773413834},
    {-0.4846718873745562, 1.8628254166173177, -0.8406871152962897, -1.2978741832555407, 1.4541769123760475, -2.28540157062016, -1.1596789269359347, -2.938865939070518, -0.07998563606371722, -2.459110227082761, -2.885285806163717, -1.6716914741064075, -2.074738045756201, 0.6268317815325264, -2.09606052207002, 0.6658257404288656},
    {-0.2708024222311883, -0.955323031252052, -2.013222575692455, -3.4824206600569525, -0.13333150528442184, -3.535586493262793, -2.2995777580129797, -1.3807495362154814, 0.30882882931924033, -3.2893951703682505, -1.2510189665688225, -0.3075251052990664, -2.417556778737511, -1.0646681468784671, 0.10601662002359054, 0.15068391731149167},
    {1.4425842821806674, 0.43672966554669435, -0.22817689416439388, -1.5513135362266712, -1.6087057864102379, -4.073422509727109, -2.033944039503888, -2.5751110957612955, -0.25191584501410674, -2.8882526525888585, -0.7549226487295989, -1.6327391838675136, -4.626997689985378, 0.686163709750846, -3.4896377460719883, -0.6397981407533916},
    {-1.2912215293496245, -1.203125225644581, -2.9037739653883508, -2.414414935780719, -2.3783961589705607, -2.440219985206705, -3.950895108827017, -3.3807584521119183, -1.5323685659748703, -3.3221873216358935, 0.5939505055249197, -4.600683625164958, -4.376931167552918, 0.18025431112455056, -3.5644964784689783, -0.490790917432037},
    {0.20989264850999, 0.828324331168411, 0.4150141262266023, -1.0589637754837744, -0.14565196430410496, -3.6850917889462815, -0.5695525206641323, -1.51820908924078, -0.7558793703003943, -2.9537841574812322, 0.7720326627942202, -2.5051760069366455, -0.387358058816721, -0.521186384804459, -3.289706672549151, -0.9143295326973112},
    {-1.1779609822519355, 1.7426271831687246, 2.604355773784863, 0.35842962325576944, -0.57522033879961, -3.0157066406787227, 0.5776087417257666, 1.8972549365667986, 2.1865679232109243, -0.6569748713157271, 1.3153962918780968, 0.4149603783013142, -1.534622250137705, 0.3506660263653311, 0.6566104685856058, 2.070526300284591},
    {0.05355322583608794, 1.564322762713151, -1.640567579248113, -2.4220001078422704, 1.5696203065659862, -4.077191793061176, -1.031979888085795, -0.828932666960951, -1.1936620181528235, 0.330866716889269, 0.8725511877719844, -0.05194361895450349, -1.1690039777916157, -0.4760277868406613, -1.707015077053169, -0.22629821143654003},
    {-0.6185828800234145, 0.3835562998018978, -2.737693484304245, -4.645862894276926, -1.1126366709970945, -2.7092563873718998, -2.548136985066389, -0.976898564614362, -2.98031484983078, -1.1992767229339316, -3.094564091784574, -0.913592203928678, -3.0775144292930223, -1.7077584780267727, -0.15734018247132336, -0.803017093566193},
    {0.12798034047397652, 0.6103172825164763, -1.3601630389436512, -2.7792745294905443, -0.26234562953573753, -1.0571924895792926, 0.6689409884730315, 0.5361523031803911, 0.23592032904305069, -1.506576432439569, -0.21937510341153738, -0.6906542859431745, -0.4983383780238498, 0.021965346415090046, 1.7242163314124448, -0.027632461680972758},
    {0.6588782746225271, 1.2133867779226835, -0.7999557339057485, -0.8512422455432923, -0.0637890126416563, -1.7970030226997167, -0.8164978151592966, 0.6103729608745276, 1.1368521912755045, -0.3115040797956419, 0.052584684968317016, -1.1416039033367524, 0.9985037412786812, -1.2102973639257153, -0.8439294253702948, 0.993304202058706},
    {0.6730155947007208, 0.4975045707764896, -1.942735910351437, -3.6916652546082185, -0.22925740606752576, -2.572474415405723, 0.06455210900274896, -2.0986840151664885, 1.3400919076400266, -1.1101646229368116, -2.0060087272231226, 0.6297156719778562, -2.5799133987016214, -0.7144705783855771, -2.414531077857351, -0.7738658064558835},
    {-1.125898660197081, -1.3598577582975802, -1.142696249171572, -2.2888993884986277, 0.9956015826001777, -2.0429811663504744, -0.6258519799514672, 1.0465581652869917, -0.09211975811126742, -0.7067287603011035, -1.2477679503477717, 0.5923944900934847, 0.1637472497625917, 0.29512407642137106, -2.92757453985669, 0.26811944290368234},
    {-0.2057210667173876, -0.5066434713112771, -2.5254870333783046, -2.6050438055598346, 0.08951730070130347, -3.369033885169105, -1.4707000254352622, 0.3878579226228857, 0.20973905908095836, -2.0747674944744663, -0.683785397096724, -2.5153182061984514, -2.237821922890139, -0.6419341877016116, -2.951738010637355, 0.3315381646808354},
    {-0.5689722847327868, -3.43809644823006, 3.5585679928062266, -1.8385184648012092, -0.4679629104597287, 0.21515631617718525, 0.8885798454088742, -1.4437980307827858, 1.856433412508278, -0.9222787089174437, -0.9616345412268623, -0.5394293390622501, 1.931365840779087, 0.4116795511869928, 1.2622729329260882, 0.33320050367869236},
    {-3.178842085670424, -1.261649655940816, 0.433544079289147, -1.5555757712065743, -2.4980422566928695, 0.06969304762911438, 2.3821136351493846, -0.5019930070526832, 1.2268571425751922, -1.9452374974474855, -3.5518258243916696, -0.7664961353344523, 3.336873245920822, -1.5110552005963127, 1.8442591740365066, -0.1207741512237754},
    {-4.188171950320833, -1.7189416237067587, 4.099796579921395, -0.6408585488094405, -2.5032816492136054, -0.972963883991964, 3.5225646793241117, 0.040855035913795176, 2.4074492172150563, -2.1427894583577394, -0.15985486290701412, 0.6805234062772179, 1.8266678427995815, 0.03651691631865115, 0.330620288409636, -1.8430996630274503},
    {-3.0985195416162132, -4.882738844689168, 3.2828393012822987, 2.0236587707150555, -1.7598048348171305, -1.2360031331369439, 2.9144941409047727, -0.8647911213733248, 3.8656673345899537, -1.4394874023506368, -4.313925167549143, -0.42569229594907826, 3.4813382848612218, 0.54419419908923, 2.189157371766951, -1.7864627474168582},
    {-3.425649095727756, -4.97931390333198, 4.865230086876641, -0.914635710234822, -3.3989386222844917, -0.8380380777115692, 3.474827100148942, -1.3233312006166384, 2.92529072416837, -3.8969855041889234, -2.6297462353930596, 0.09891060304027877, 1.599756531216501, 0.14090813813455264, -2.041866882502831, -2.2315855623606784},
    {-3.5701721129058064, -4.22132086738432, 4.094036375373203, -1.560412581382433, -1.2128111328382436, -0.9595122510578384, 3.7941206018893774, -0.4997803592050681, 2.142920394330502, -3.2810228654171993, -2.5591879625960074, -0.6210826574273779, 1.271260739635066, -0.8369100276774212, -1.6276123398186972, -0.1999460331080415},
    {-2.774006034937792, -3.7179819265410723, 2.008709670195129, -0.09074857356355936, -2.6239470234759112, -0.6290748855464849, 3.0034311668040754, -2.127216210613124, 1.5004821585248254, -4.213029987642627, -3.956824899277106, -0.5339301616505532, 0.1357168391929559, -1.3802425644674365, 1.8813653993280506, -1.1518507753288054},
    {-1.8802814505494518, -2.730510472134204, 3.5460319317845848, -0.8290739939367164, -2.5695404626965326, -3.219168293054373, 2.8621158613347095, -0.08492990053340524, 2.1139439782690412, -1.6680610840498846, -1.213244536907029, -0.0373084604782947, 1.4350606786882016, 0.009485840046210012, 1.1116343953837828, -1.1519866674023516},
    {-5.183605353975974, -2.9703462127018496, 3.172524133753654, -0.5772497121823243, -4.993709220051421, -2.008084150479496, 3.684963995698115, -0.14587037210239795, 2.426689668249977, -1.396707772807182, -1.9361303772239404, 1.5304545146888748, 2.267726087375885, -0.42757641235696114, 1.1860314748037488, -1.1129996027179023},
    {-2.0572977067990204, -1.5090111706991969, 3.7940960226981746, -0.7190039466005821, -1.618903697093949, -0.3017534072981586, 4.1957947505212605, 0.5690883375194349, 3.089267471412963, -1.2968054596754743, -1.8849381683500757, 0.354784740355377, 1.1741957765570754, -1.2076482425180963, 1.1390364131077704, 0.08332741833677156},
    {-1.9799143463406403, -0.35920796727255805, 3.1204958337456934, -0.4802768726330387, -4.30279920535872, -0.44888160879507744, 2.1277689637810075, 1.9077380028401574, 5.548333045024438, 0.6061514931599543, 0.20006551281712995, -0.23009817574553162, 2.9275714590439135, 0.5318487559344031, 1.6355603563636323, 0.04110515369038662},
    {-4.450254593295087, -3.0262529979614796, 5.707994391323618, 2.621639455264527, -3.001976383228355, -1.3636471817758822, 3.187616429431545, -0.5976432675728455, 5.6562651603271155, -4.673782074113589, -0.6233660106268659, -1.1231762434702255, 2.0628455353149993, 1.5401498577855974, 2.212195862585201, -1.3281728758522648},
    {-2.597912947664213, -2.932423097451908, 4.637559039824058, 2.124035016224448, -3.550980253307818, -2.746768147604229, 2.5779334213192215, 0.9790079316717879, 4.259205931967216, -2.1390545669042833, -1.5712190345518495, -0.2101891093605667, 0.2201456623132788, 1.5669604288264876, 1.006774642193886, -0.3760917947072356},
    {-0.9553900157198887, -4.222697690536115, 2.368747257694797, -0.21729513166708356, -3.8631186840593448, -4.644501531887741, 3.3834800684337987, -0.03521978289577714, 3.929504578968813, -3.637248996811414, -1.65882354894594, -0.09565786019132826, 0.9519012242744199, -1.2816124071849238, 0.11031373184331177, -0.3331850255543925},
    {-1.0587034007452305, -2.4534543150745627, 2.8099082186824114, -0.7251842773929258, -2.5908995513887736, -2.0282118609495203, 2.2881685343089746, 1.3849593937800133, 1.057611375084273, -1.9548078727952583, -1.4846448796178684, -0.6284873254693235, 1.7527690499894355, 0.9175565198717107, 0.8629896022348601, -0.7361427238745835},
    {-1.635883929533931, -2.299281233397926, 3.066226748256691, -3.179997911218952, -2.2427209698503, -1.7761014185380293, 4.876135147576777, -1.3228627578830099, 2.4078941946865875, -2.0301528681599916, -3.5148980299562904, -0.09512756327185083, 2.3837698224295174, -2.7848804885580956, 0.7967421248827338, -0.8839638811077419},
    {-2.63305659567137, -2.1457902344020012, 4.364281370748288, -0.7518648920265788, -3.6738169464328716, -1.4290664045859574, 3.463456009380023, -2.6019791566749313, 1.6037906551037706, -3.058855638637054, -2.7030887452512538, -0.9518000676315653, 3.1558052511055608, -1.384161926727799, -0.22497252287586691, -3.1843500285142823},
    {-3.3503512787995757, -5.185606875113026, 2.376637685594535, -0.9625498395428972, -3.4597885695523085, -1.8478822903758083, 3.782828622685179, -0.9818826559507434, 1.5953566095120972, -3.768281131580664, -2.420331931685708, -0.4305821954911311, 0.059401883253398936, -3.0605597042890995, 1.56909371731056, -1.0211508623851409},
    {-1.9336577683228753, -4.237204117576329, 2.687396583337689, -1.4965107937385231, -3.984872757302307, -1.9369826842102866, 3.2490008544844446, 1.042237579053945, 4.433279523560727, -2.5927298046667806, -1.7182677508631083, 0.1413603126637596, 0.5339618595132837, -1.3012693476848527, 0.6065695387016214, -0.513610385926667},
    {-1.473239720867934, -3.5551929476279995, 4.653899227188587, -1.9392322842780614, -4.460692603710509, -3.09192387998204, 2.1498630132929106, 0.5952835384851259, 4.797719871497114, -1.9607078611813769, -1.5065489054318317, 1.907715747231641, 2.572870612504233, -0.6613230503297651, 0.7076912523610134, -0.38712777587228053},
    {-2.461271757159652, -2.3550305923519086, 5.854214124643981, 1.1328544557073337, -2.2232319798162825, 0.5260747498455619, 4.845249595005322, -0.7048055030301973, 2.374419504799435, -2.0737045344135874, -1.801256390865905, 0.5640290940634007, 1.5906412018024916, -0.5899712132173578, 0.003245157047498089, -0.17350361524863525},
    {-2.601966720630534, -1.4802513111099431, 4.250692159832345, -0.932069921744965, -4.66669145327134, -0.8793638402212209, 4.2885399637128785, -0.7802338260243779, 4.912367011675167, -1.6847707717687859, -1.2018087426489272, 0.9978848565457419, 2.154652007628541, 0.20734215843194007, 1.8161491419278863, 0.5250797979898264},
    {-3.454809665701113, -2.5168359761865977, 5.221783354305113, -2.0624203357357764, -4.794664413170485, -4.65189240327965, 4.774508990981165, 0.1907619028615177, 3.4595414975298007, -3.277683086496872, -3.439643843619358, 2.25982033624176, 1.895559319589498, 0.8340426060669444, 0.7912726617171353, -0.6189912335289165},
    {-0.6511889189849449, -1.3683047913750273, 4.720741969324482, -0.31983699563168577, -3.8988532885312437, -2.0712173017430366, 3.291844302969904, -1.0505315861609574, 2.6581712031209275, -2.6254394810239, -2.0697758611508323, 0.11894114590335388, 3.454063323971531, -0.13447411418484134, 0.4229803131379492, -1.8326188567202262},
    {-2.356642621173849, -3.501950321321596, 5.248333014303301, -1.63569481351333, -4.30290988029712, -4.429518463878453, 3.735336071797652, -3.4464850615657103, 3.8424610617746704, -2.994865791330994, -2.9930936834723165, -0.533653022934398, 2.95303081328064, -2.319967484667699, 0.14846404802119614, -1.748373826656671},
    {-1.4496919514919129, -4.114465225953267, 6.38294837193373, -3.637731683826286, -4.328136972407659, -2.6569353121591517, 3.5994316552480177, -2.16136610668235, 3.0847565656582376, -4.169295268822218, -5.032713944083703, -1.6030443365898976, 2.9273022811252494, -0.7209258814357475, 0.6458389606353031, -3.1986199357502025},
    {-1.284054909153664, -3.0789441092519807, 6.24952441405087, -0.45539993305776916, -3.307253925056073, -4.939678564575642, 4.736410941988024, -0.7587367227392176, 3.4997211722009633, -3.544881811505558, -2.529395442169351, -0.3604621631469917, 1.4351105896997154, -0.8652782348109276, 1.6496900344979404, -1.5809633668976406},
    {-1.3377205581450942, -2.385879794481544, 3.786630518926744, -1.6689169010996914, -3.03319929163449, -3.5193452207508957, 4.163904732973734, -1.1990656320877298, 1.897995760852591, -1.7253258883958673, -1.4510114819723654, 0.20713809803647076, 2.2012656475703807, 0.14604925989382195, -0.7436664885977788, -2.7504899013140776},
    {-1.9064209574999793, -2.409105559856813, 4.468981908227096, -2.775438746259548, -2.2826236136472997, -3.569540310997214, 3.6638532858499717, 0.21481940450925172, 1.6013395459912765, -4.343862459715477, -2.3104246155917707, -1.0197843823625796, 4.095733941266661, -1.4452761938475487, 0.5876824385241086, -0.6133412417351847},
    {-2.610800926755938, -4.8639442406468865, 4.746305563878213, -2.3242061140003503, -3.863267255018202, -4.059780134419607, 4.650471600187079, -1.536538328567513, 1.9560011651036617, -3.250433114353482, -2.7696881243181433, 1.528494293638852, 2.0751852236898185, -1.5893307584471377, 1.0208653843417068, -1.3790063371112988},
    {2.761114140906443, 1.0055704940323016, 0.20163189026860753, -3.0408282631437458, 0.42277076296474086, 1.0029677615985118, 1.2321466345318157, 2.135834859081414, 1.8495606881678943, 2.009647252768665, 2.582620305184115, 2.8226470566648554, 1.84274691838479, -0.4514535720165395, 3.605971424309476, 4.922151034936923},
    {2.003796543102918, 2.279995588044415, -0.5907279915096719, 1.271180996189653, 1.1090157007373114, -0.15450871933892257, 1.1330172463754042, 1.923877880450994, 2.049063120280936, -0.2160273005916247, 2.3770224112736162, 0.9524430724548218, 1.046686347622646, 0.1044826032664884, 0.5754827368611395, -2.1294467883263284},
    {-0.9532379617118045, 1.0122135881262981, -0.5445523254565157, -3.1617424755054624, -1.8201994790519307, -1.6596220830688488, -0.05406998210270459, -0.29972656887943133, -0.4898871497801678, -0.6094706137254985, 0.5540987423513245, -1.015505681024682, -2.160857724817559, -1.0927634489382134, -1.4546072179814693, -0.1939514317923473},
    {1.2857745104317808, -1.6743001813310785, 0.891655538989483, -2.086683397861937, -1.059903032241535, -2.220680632197732, 1.613562585873924, -0.4856274197738916, -0.806603688651473, 0.44699278742970494, -0.33940673792109116, 1.5596656656967827, 1.1208487447297428, -1.3307231815149185, -0.790755950402776, -1.1336849174572954},
    {0.7042626840748341, -0.734160519046283, 0.8372111446622786, -0.8188587107646254, 1.1698494197470228, -1.277267867554924, -2.3097419655867357, -1.2240810235829747, -0.7705935532465561, -0.30657679867441895, -0.41595115346683986, -2.1693029045284433, -2.599527175433107, 0.2534962613976252, -2.8973894579339947, -0.42709404635395654},
    {1.288291708579152, -0.012137721283978015, 2.98815348221621, -0.4168291996690974, 0.46869837854910074, -0.6929371236978029, -2.625376521358374, -1.8946488487603828, 1.2734773364815322, -1.654297537626905, 0.6395033338878795, -0.8431209077740424, -0.606567145148898, 0.1700775348466184, 0.5310581767146856, 1.4845430939027386},
    {1.7448705364992196, -1.2418098443668775, 0.36658993222119424, 2.6584512025387093, 1.1831290130701617, -1.016311776394586, 0.45341918119252445, 1.2620465678138406, 1.120653171038222, -2.0085502128822745, 0.47805306392764924, -1.2472972422571214, 0.9463393610035006, 0.9502027348937294, 0.08753355850028925, 0.08613160023914111},
    {2.5270740328925316, 2.3168319003235958, -1.687962833681835, 2.1888335094406717, -0.498707620761992, -3.145052009948439, -2.760512614078069, 0.011617950586184582, -1.3270698542518111, -0.3206497765667834, 1.334019195471822, -0.045896922401236454, 1.5390887123968853, 1.2105597244412214, -1.4106977497854203, 0.30059153959175966},
    {-0.959805098577878, -1.0773443705940708, -1.3067661512800557, -1.0858142261652735, -1.1588783796894226, -4.239824450453471, -1.3120311141637742, -1.4459149430020153, -0.5605630398663233, -1.5313900360565624, -1.3697572818337664, -2.3223190051990215, 1.308153407455335, -0.9887355687673683, -0.5601173467863569, -1.9723295925626656},
    {1.0886318973099618, 1.975211487874793, -0.6928145693678032, -0.22348734631290346, -0.49031073929370683, -2.9994293797340097, 0.288657935013016, -1.7275337429734146, -0.4202243919943464, -1.2067584758091454, -0.3780281446696528, -1.4827835818052912, 0.04905141589983087, 0.9010621346513571, -2.6403583892742852, -2.8376198193907602},
    {2.6261079767418676, 1.3128725306383655, -1.0882989573054225, 0.007056894810182679, 0.9562797010272851, -3.2414752862116085, -2.3377849065973604, 0.6256812205775997, -1.030997644068456, 0.2668496104802249, -0.1924863582635559, 0.5548619676711783, -0.4141504605174853, 1.8026233943684549, 0.1953985954824647, 2.7965669504663335},
    {2.761382585177015, -0.290698154733209, 1.4124098351534753, -1.3749272183724899, -1.5642241031471755, -3.597756323801526, 0.6537716942164921, -0.020933632683863217, -0.7880632389754857, -0.28190416828992176, -0.3480487009118472, 0.6416934184500069, 1.7712286880703598, 0.4021720647448206, 0.37936166806305854, -0.5756057298309717},
    {1.4673398570791971, -2.894583267910653, -0.35124486634989127, -0.9191268545478845, 0.6613575629396226, 0.057871856123582956, 0.9149664980955035, -2.430961292344271, -2.490727490566096, -0.8439636955265682, 0.9939290142974084, 2.2271629599238882, -2.634041957667279, -0.9099045101109521, -1.181389089379418, 0.0649950669552126},
    {-0.6272188721500991, -1.0117013291940973, -2.767052330549039, -0.7346208884813143, -1.4964098063833604, -2.539114827243232, -1.4714898303103712, 0.3534119176046044, -2.519309153888947, -2.729577681283265, -0.012211891713888189, -2.6180860743179557, -1.6882356599510147, -0.4898482645574491, -2.1199159068204887, -1.7811596517947574},
    {-0.08850307838421119, -1.4130115606692324, -0.48564277675555945, 0.6978738289435483, 0.07945665991516578, -1.6032174768645677, 0.2882501151063049, 0.14546312065618158, -0.51120950091355, -1.0894301704776983, 0.30765426555536585, -2.0699009182850063, 1.6458083265302506, -0.6397630109919193, -0.3850157540384286, -0.5442275813671905},
    {-0.5348092294615265, -0.7865531187073681, -1.33007850407977, -1.5819585825021982, 0.5911829491504383, -0.9971920795670847, -2.2131670980767795, -0.46683678198234496, -0.4246621260310888, -2.412316376169177, 1.0794560765532701, 0.12273587858655252, 0.07954324079810439, -1.4370299038281407, -2.2561693331783927, 0.8038366862929425},
    {1.323782082080095, -0.9584913731216499, -2.4481574976115326, -1.899080281921153, -0.053152955416791416, 0.0684301798516425, -2.9673803204864053, -2.6978818609638027, -2.2454692136432537, -1.0845063432716726, -0.6481451394664736, -0.14911482549645008, -1.7351641452331288, -2.4269085097958127, -1.8946973009661203, -0.407532095099269},
    {-0.8719541522703894, -2.192660224863535, 0.7420168877085825, -2.5102213862646527, 0.2015480991667715, -0.022420242800116116, -1.9848931438204878, 0.5296461477655031, -1.0070999308802597, -2.348351439825607, 1.3506422650688812, -2.202054525595874, -2.303178926898676, -2.440618128920351, -0.09297658627122043, 0.6950993666371071},
    {0.6750259783337097, -1.493721971021688, 0.8576721702656158, -1.023887604834441, -0.6097561893676084, -2.0237210396651553, 0.21334206612499965, 0.301790935220555, -2.329113983540339, -1.4649256504613732, -0.8853308472285518, 1.3133305250104406, -0.33747681004967356, -2.0598825346478735, 0.5946411504778069, 0.06151651593248523},
    {0.6567519232407812, -0.28811752521646306, -2.981896872253847, -0.2853612380632575, -2.3465719291457643, -3.7738125582057043, 0.015187629040660556, 0.3103035197724281, -0.49374520409160055, -2.5637799936106824, 0.45750137223096804, -0.23896360867113192, -4.102773008491453, 0.49282811378236485, 1.4179259602940246, 0.8243578248995503},
    {-0.7294476343703392, 0.6834791838098594, -0.2760393278841254, -3.584625432340984, -0.5751994791603645, -1.7948216897653264, -2.53824674703372, -1.1248934918078808, -2.018727566811694, -1.9130471917356715, -0.5972634926840088, -1.5748998522057065, -3.1579092370180124, 0.3012389744218143, -1.4130224317525732, -0.12573529128457328},
    {0.8007101147059725, 0.8087210080350993, 2.2168799356845685, -7.103228002604289, -2.69888065981103, -0.9248757576027624, -1.3443617743926395, 0.48636513285698857, -1.6388969259458679, -0.024027076070395156, 0.2755011533805044, -1.3942598189900255, -2.9573290896228652, -3.0318528671530403, -0.5279776984025805, 1.5411890005012743},
    {3.395706942048211, 2.411319700525932, -0.011949135085608515, -5.138659219678826, -0.8819849893340271, -1.1257968260714604, 2.8590071157092383, 2.482097966265749, -0.2303457104120771, 0.23943863656104844, 3.7798030795151387, 2.9525535414092414, -0.38416532577109674, -1.4378935469783891, 2.466065193114469, 4.652990366530217},
    {0.5812113500199724, 1.1708916028278133, -0.6723650706399235, -3.149160684298831, -1.0892933290890217, -0.7310523729311343, 1.6024220783130754, 1.425627532695942, -1.1689092481531855, 1.0125292539570587, 1.5060932078856448, 0.9620791094678576, -0.7452304400054095, -1.5619097386046745, 2.7789102898079054, 1.6841513983092096},
    {1.395307114747573, -1.173815192251587, -2.2066535064172625, -5.206453004300239, -3.464801755933881, -2.860812332489027, -1.7385987567668617, 0.3029799366370139, -2.8094919141410495, -0.6042474149710136, 0.39610369500455767, -0.2742363086411259, -1.2831793611793987, -2.503441681307433, -1.2879493742506212, -0.25582671523265754},
    {1.3469869186314538, -0.7044375206323715, 0.990522541535797, -2.245637288154837, -0.5277150547721094, -1.216086347703119, 3.708631946029558, 2.7966278546725194, 0.5392323358442763, 0.5452295446622817, 1.5532991540566081, 1.1689060667178937, 0.19108519789703002, 1.3048626860311576, 2.314100386610905, 2.503846248104653},
    {3.047176154713092, 0.5920888807852122, 1.0058218400335803, -2.056606619247938, -0.18995526499073628, -1.4623912844453564, 1.5276009295930635, 2.126351673817815, 1.5178721822918884, 0.5269839322532526, 2.971963022539593, 2.0517667168487304, 0.9651769381274591, -3.303625963677431, 0.6704566106043156, 3.2371047367987726},
    {1.528532915559655, 2.101016474918977, -0.6447337076780614, -4.100292664982369, -0.7130449231752686, -2.221413111351103, -0.44912825837795967, 1.1791657843766712, 0.3125689204148954, 0.5211966827961989, 0.5432215921822471, -0.49989195512211776, 0.26443282018106024, -1.1868573526372426, 0.7214668678889176, 1.7968269165766115},
    {2.6106170367246455, -0.8524796238176016, 0.04875228805472669, -4.6800198321316335, -1.3249590264092685, -2.154841699518842, 1.5668656002876484, 2.351945000583262, -0.24525254803798557, -0.6722027503991547, 2.3669758434022907, 1.2467994041803308, 1.269653681705797, -1.2588611292475451, 1.843123233625873, 1.6485759618527698},
    {4.043951023172005, 0.6155359882373438, 1.3912399107541102, -4.993238630261447, -3.1226254364759116, -2.2675898081807255, 1.4031086671792279, 2.279877069460222, 1.072776517904779, 0.9371756766160027, 2.0285728735904995, -0.24348570185188081, 0.02126666429729075, -2.5701260483029125, 2.5043318963718315, 1.4692788053522867}
};

static const float b1[16] = {6.057031419837485, 6.448598494710722, 7.15233690793724, 6.836636952901546, 6.5476436709913814, 7.142984265529114, 6.9751961995169065, 6.581367900254254, 6.670263919135047, 6.686871063623239, 5.38510696971875, 6.924622446994494, 7.0569885790453615, 3.7544941116023076, 6.501261757444417, 7.0562982514684895};

static const float w2[16][12] = {
    {-3.659873844702818, -2.3205478764502803, -4.197245331432765, -2.7816218394826113, -2.7649306758263563, -2.563976833145638, -2.3385771960942794, -3.8133769552323713, -3.9434959452247673, -3.1000205759198782, -4.151552578580868, -3.29961025034621},
    {-2.660138870801209, -4.036378014135559, -2.4262025497050614, -2.649885198248435, -2.5899463440890793, -3.8416080948605065, -1.599874064938702, -5.136846060748014, -2.47037472395301, -3.3148072962355073, -3.82246381151234, -3.504360709844004},
    {-3.9679477231317546, -4.567933854916611, -4.310716141438557, -3.728733896759114, -3.3370389611962166, -3.271693756776739, -4.087625927751256, -3.9541982495264567, -2.308171965276771, -3.4179041809061173, -4.83626296258688, -3.7108340694056396},
    {-3.722755392889774, -4.009902202373881, -3.1789865269886, -3.959746522388789, -2.7126784984353316, -3.920191158814746, -2.066369342795822, -4.00518185382173, -4.129001937584163, -3.007663365103589, -2.993584149334991, -1.9025808422338049},
    {-3.750478540053362, -1.894176223954179, -3.130294984655866, -3.5105419412229057, -3.5329010459995156, -3.6081173878263577, -3.8868827242709667, -3.388299507261427, -2.459708863491658, -4.318616834679149, -3.399001509744138, -3.6577191389272525},
    {-4.188726907321599, -4.7799296828107485, -4.053107924210933, -2.6348620681689043, -3.029788826825274, -2.999686502444691, -3.186103916388957, -2.9458813710592384, -4.688337121981026, -2.8224878847148336, -4.544390213599384, -3.629672414898541},
    {-3.0519103456623515, -3.8361010394807287, -3.707977490155577, -4.348016317293423, -4.108326940633049, -3.1211847630020015, -3.0772231949796636, -5.162739256827304, -4.5131412591042075, -2.7180503540761136, -2.8248848681227905, -2.6825982024092476},
    {-2.8978998393236175, -4.149159976032832, -4.524306445057322, -2.6385195046488086, -2.1941291831458565, -3.8832699874195225, -4.998867112686622, -3.7413017436012694, -1.529083686350915, -4.355690887407881, -4.010998886209889, -4.493729554128688},
    {-3.6027461832029686, -1.5497487010430055, -3.465819575029889, -4.387143621076274, -3.8251262834011426, -3.879559117862413, -3.116776791707443, -4.0045345247112305, -4.28636123400019, -4.739847711356852, -2.327676055319482, -3.5803005343702012},
    {-2.6403618619611593, -3.1186352170138947, -3.20906153067566, -6.070766858514104, -4.301764861921003, -3.7669129452924253, -4.08755165416775, -2.769084641814286, -3.917954674105374, -3.089163550201962, -2.231814611384669, -3.3181556999466295},
    {-3.38164222480289, -4.056428871894802, -3.4286961913123006, -2.7154476969940395, -5.003844604847083, -2.083745892052967, -5.53100386969234, -1.0900824170084824, -2.667444090681249, -2.9173668113383604, -2.3046969311349765, -2.2879991349587145},
    {-2.740690303832021, -2.852802689570126, -3.4809216131944174, -1.2171511446648866, -3.522795886082868, -5.154388964283493, -2.7067402294406335, -4.07276257996111, -4.809484081731187, -4.324866491468275, -3.447748291684723, -4.066401288899951},
    {-5.083296384870196, -4.624220372286419, -2.4331509136003717, -3.676338492985872, -4.28712049192196, -4.605133530359647, -3.154184376453974, -1.479688714660434, -2.9286827808542646, -2.7107304931286937, -3.6652264832452515, -3.8800971114955543},
    {-1.1900958090855371, -2.6336809044054617, -2.7528991346512406, -1.6206675784246165, -3.2887787694257775, -1.4133049305465213, -4.1059981802662815, -1.2599662742657127, -2.3842516738909065, -1.588491909134782, -3.140850026897083, -3.9259466634597544},
    {-3.492615456261157, -3.3427736760460194, -3.0902158544203813, -3.1940980369089123, -3.6011858954558362, -2.5452183668217656, -6.02035940148459, -3.7639836299684717, -3.7039770221291057, -4.876553804458146, -4.400466047795163, -4.983457712319707},
    {-6.0377697019480285, -3.4388069824548153, -3.237207727289325, -5.8228110478594575, -4.01129645131696, -3.8553716802567015, -2.330168268900537, -4.702439559035039, -4.493186015823275, -2.9009935158755153, -3.2566303782381834, -2.674503097568412}
};

static const float b2[12] = {-4.032235472355204, -4.453850096796408, -3.871266870085231, -4.270317359971934, -4.532148931945416, -4.234196675269525, -3.9664753694646047, -3.16635053963379, -3.0487919709636278, -4.439383212810972, -3.6004912758728986, -3.420984765191249};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
