#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.3015457917586796, -1.4754663329139577, -0.15308701577284858, -1.1124878243081673, -0.22378304841640242, 2.97107075341712, 3.2093433446847035, -0.3934022387149593, 1.723461062737604, -1.052874720889717, -0.9377754830623952, 3.0630285226247627, 0.5880239850864121, 3.714903169100617, -0.4745205927398249, 0.8959326664425076, 2.4566002555836683, 0.07006190615529316, 0.2302779094428627, 0.6785200250599823, 3.003832390590983, -0.22810357723533684, -1.0147776765780703, -0.2998544875656764, 2.942020404604609, 0.558408422538937, -0.43787162430942395, -0.9070119118777814, 3.677207300043696, -0.678904539498135, -1.016723256991647, 3.0075047693405192},
    {-1.6335322009107698, -2.571611924582424, -0.7996985504866916, -3.2100968693109415, -1.1709967636341339, 1.4568159701092576, 2.5500212975787293, -2.079149370550846, 0.32792891316878686, -2.724411965693408, -2.2336171803879026, 1.028265412048375, -0.34655961299403265, 2.8059058448657574, -2.1513614518533335, 0.03394359766134885, 1.5570811497026087, -0.8325811743448679, -1.336026823699378, -0.6043814763331948, 1.4639466711394487, -1.2709668089189654, -2.313899747415307, -1.5804893477494433, 1.7610316897528453, -1.7465714358293816, -1.878494607587688, -2.239803996626539, 2.324560506044827, -2.814438350951177, -1.5802784577923554, 1.97107059548471},
    {-1.685321218509855, -2.149774814431919, -1.766387398587836, -2.4868957613434204, -1.7603435008617343, 3.1230156094939194, 3.5071072053142567, -1.983569053686645, 1.581259531519961, -1.9003254683148378, -1.813415544628006, 3.1356191403164746, -1.7005867764331726, 3.922266042757133, -1.8581832710975883, -0.17852465850255614, 1.082996425707769, -1.8202643024149732, -1.4440079434066861, -0.9690052567422209, 2.8721015320032834, -1.652490361975317, -2.092408368097178, -1.7002236303673763, 2.947918964820532, -1.3668595348649644, -1.9763305167211072, -2.014320880943736, 3.3265900702187134, -1.715408303525224, -2.1397651453719027, 2.5702802384136456},
    {-2.777423662715661, -2.7668624269119553, -2.552505077417612, -3.035416159649026, -2.4729082194084593, 2.205361549960034, 3.6434740322234576, -2.4334272257939156, 1.1428246777418427, -2.754672410470127, -3.1286739537676485, 2.2655522154499597, -2.3707805388897785, 4.080084944207952, -2.492765978275746, -1.1264227638044813, 0.6032533477480992, -2.540833818625322, -2.2472202438790685, -1.6939622389307627, 2.3594388760482983, -2.554426685297846, -2.713153494363021, -2.749758408621987, 2.4689086947882415, -2.045140677897612, -2.5253911264055917, -2.795662845127529, 3.5747256576494415, -2.2660985139839003, -2.7866725665488494, 2.615118335320766},
    {-2.814469496090301, -3.181175970446102, -3.1671308389225112, -2.5415284257474795, -3.1763646830629706, 2.062212993163788, 3.3822475861891204, -2.847246146281668, 1.3407139848154148, -2.227583313950614, -2.5266097369565284, 2.6401044792221655, -2.983336004298486, 3.3619204562736456, -3.024350771334593, -1.571337052699315, -0.6342838987808166, -2.844356805790895, -2.340723256953432, -2.2120317451915437, 2.1323223229043187, -2.7394626521227288, -3.0497594243232204, -3.0110129821061196, 2.4951798700519805, -2.26932520828097, -2.8550696664794324, -3.099070579513291, 2.987328036145125, -1.5027492309383774, -3.2715171014154367, 1.7646280755942199},
    {-3.0374014434632493, -3.0902466426420983, -3.2031692112655206, -2.6953891903669396, -2.894774548824597, 2.365760314552439, 2.9081871666806873, -2.9634921608061013, 0.9869552626757484, -1.6079169994149334, -2.3886124968670948, 2.7506308192609814, -3.121775020604319, 2.707837151535425, -2.7251708991584547, -1.5341912816482435, -0.9476159667924805, -2.5458971191717903, -2.6139640454943183, -2.641540150297512, 2.0769341865676565, -2.9187684706593213, -2.6388330198196743, -3.020755187536975, 2.4842709227337147, -2.302938028074807, -2.6131461414878623, -2.9538294649763936, 2.156399247433026, -1.1454299382664725, -3.378806775692125, 0.974836460771623},
    {-2.7127786608047635, -2.759870756297813, -3.1469552929762994, -2.7324419100699266, -2.82408638675582, 1.776888381562054, 2.8628879355660204, -2.9569643804395853, 0.7544858314490138, -2.235730181603397, -2.3550812051363295, 2.4979794159787896, -2.7284841126912256, 2.1014024474192263, -2.886732774248167, -1.9391640501906728, -0.8054935664363034, -2.6238588585648697, -2.613834991797292, -2.5466356701035235, 1.6991731746851413, -2.5075843736767713, -3.0229642923362467, -3.018213375367232, 2.0743974920371966, -2.477328121651687, -2.6932242383718235, -2.849462816851778, 1.6930560267678778, -1.6348489336216594, -3.2244643557452175, 0.585979498017091},
    {-2.8838889638209, -3.3542549430981383, -3.5134437639573632, -3.0449394303229886, -2.967847273212924, 2.0356769384914837, 2.573628683773891, -3.2206011333616416, 0.06591124249384074, -2.2515939033742147, -2.880471362003288, 2.0105296777107684, -3.1289324393967664, 1.9283694193409504, -3.1165716101852783, -2.2060841067928934, -1.0943477750424786, -2.8271820811118022, -3.1303527039157726, -2.591983733071259, 1.7636414995937542, -3.0630020985867565, -3.1579880548463763, -3.1161082922530228, 1.9430010973144336, -2.684983837715223, -2.9169544120366067, -3.4975933918920257, 1.663862090600921, -1.9146032865494633, -3.521048496007029, 0.26069435588523615},
    {-3.0200806757139724, -3.4089852581412132, -3.2139894619751823, -2.964903533628265, -3.041926521410066, 1.3761306044646087, 2.696464227188695, -3.27512117501458, 0.024367617181930392, -2.5354251514495485, -3.210332578552406, 1.2504408633630362, -2.9892449207646252, 2.4615995577857976, -3.096414147171868, -2.3837617382223955, -0.8120275868930567, -3.092276136380301, -2.9992481615709585, -2.617068559550339, 1.4286267710418028, -3.11960607801431, -3.1011557880226976, -3.084037779519771, 1.618841385041715, -2.547836073169348, -3.330931202220942, -3.4536019267652383, 1.7895748880762683, -2.2199526618456713, -3.27764067611688, 0.7395870013958311},
    {-2.848841522520062, -3.422564559774505, -2.702978633832062, -3.474356179308106, -2.886868287200249, 1.4623422898929945, 2.839093504579113, -3.1227862622482947, 0.4852277863114379, -3.056380583445945, -3.1111155259151255, 1.3039069661093807, -2.612897021318069, 2.7773379367247593, -3.336895225038477, -1.945998102038447, 0.15855741730718648, -2.9217829414975864, -2.576078104155149, -2.5047789012920347, 1.3856083875598477, -2.9513901598016288, -3.2208795622842956, -2.934739150679333, 1.2945790126594967, -2.318325263919542, -3.0382496089931514, -3.428318416279241, 2.6442889750478855, -2.7446288471928515, -3.017221569392338, 1.4309777871901002},
    {-2.9277536378985016, -3.0977335275689, -2.5014523942092803, -3.4212218874051503, -2.7154559508887828, 0.1669592088503418, 1.5541020296219874, -2.818996192676772, -0.09220822938465595, -3.281397297872005, -3.228603964170575, -0.14069757262432475, -2.0131939631205182, 1.9060724759684646, -3.259788010870139, -1.8364466912541348, -0.18102032127635453, -2.614242103722568, -2.7416783863365515, -2.1075507739110857, 0.2589346657430534, -2.9054544456694735, -3.3267223984395167, -3.1090438243758407, 0.23147278473297972, -2.658580064998896, -3.188038843987399, -2.914488533608839, 0.9842598783222788, -3.0749395798018004, -2.7058981833785793, 0.8984033902323866},
    {-3.3434308697856636, -3.3127815601828803, -2.6173826893308423, -3.38080729735777, -2.688202603367684, -0.07850751680724331, 0.7976708746804166, -3.1852761514940338, -0.7675396807243451, -3.1994690394139518, -3.325442010999825, 0.06238564357736009, -2.42852659439993, 0.7739728742265087, -3.239795341099992, -2.4043100376382944, -1.0559457048142769, -2.8521891674944055, -2.8822395539654746, -2.590180436818483, -0.0402075116457851, -3.1008776396700033, -3.2200083541432796, -3.293299473822499, -0.13860719810765687, -2.5794900362803834, -2.8929637915287163, -3.1708293559313345, 0.6524669403665428, -2.94769583807358, -2.664579759633083, 0.08272766093438476},
    {-2.7564544739865533, -3.086500067981307, -2.94246585376679, -3.385795082700696, -3.1006855901800643, 0.15537171875904213, 0.7253974783722175, -3.062156590885362, -0.7176250870805366, -3.1399310939543033, -3.13870015554783, 0.10584065952557437, -3.0016214982130967, 1.2731639710986284, -3.263887875962964, -2.3399591008084393, -1.2094749295201048, -2.970908411170783, -3.033670296609353, -2.43714291616324, 0.41711675346358235, -3.0446924561750706, -3.1446120822423245, -3.0681301259544833, 0.06504876940333751, -2.5825433204950956, -3.2621451748607164, -3.2218666026923564, 0.7360553224829139, -3.2099679444427425, -2.6798480046833806, -0.08483349343467773},
    {-3.4462552040334584, -3.200643521686176, -3.200921043647569, -3.404178075508125, -2.9919944373653635, 0.3389915560273889, 0.9921007599345132, -3.213068453579863, -0.6662478305173116, -3.184122968064236, -3.165854332937961, 0.11234376730852058, -3.028096736641736, 1.1110483263790325, -3.4887398960120204, -2.223969722315424, -0.9227600865684917, -2.8035629442994736, -3.2778662684547224, -2.391176743367351, 0.3184050593747562, -3.171096455006739, -3.0857508419512776, -2.9145155494494226, 0.24426149035347222, -2.892017620452012, -3.369707721229057, -3.013741453412788, 0.6181615166902614, -3.4115068983537977, -2.8774470005745836, 0.010017549533011975},
    {-2.7529300777322017, -3.3326735581457525, -2.934346451853144, -3.2767461051329803, -3.000984505758502, 1.2044258167814628, 1.8022038262580444, -3.3891070025169077, -0.577450347717166, -2.942344583699109, -3.2549367219796754, 0.9241346751826806, -2.7663919472138883, 2.0864387363261057, -3.361206706996497, -1.9876110341750681, -0.5016939140103871, -2.8554707183429135, -2.954048014607331, -2.2018730641648205, 1.261432576623138, -3.00141695460628, -3.135544115589542, -2.9799365553949553, 1.0399769323956392, -2.5922105603858974, -3.0918576024479707, -3.0861920365246163, 1.617781811001548, -3.176329280816177, -2.66978943779988, 0.6893616614450272},
    {-3.129917246871026, -3.284784635947862, -3.0846265295198454, -3.2531614152265877, -2.951514811393642, 1.968354475790716, 3.1332605162676956, -3.2376288111994533, 0.6349964311415822, -3.172325677355552, -3.1509694012832874, 1.8937388972165052, -2.917068745646467, 2.9848470948869896, -3.115544395150891, -1.7442660115505781, -0.24235995413044156, -2.9693040458467252, -3.0146910124848736, -2.365272922288459, 1.651192265585222, -2.8487651216786842, -3.0937394255464854, -3.134208926319059, 1.9491142794447305, -2.766570440332502, -3.078539338635039, -3.134319948686988, 2.47537806307356, -2.83980414163571, -3.061446481197126, 1.195274130318623},
    {-2.859319126743129, -2.886581747712825, -2.820087497242201, -2.890063527972013, -2.7753640075820925, 2.344954196160022, 3.411091614288195, -2.8824585945012995, 0.7263691945824858, -2.8308797196161115, -2.6002554871511783, 2.5616132213145444, -2.7701200582832253, 3.5723372602059906, -2.753399213750161, -1.590749815489893, 0.1577181950037491, -2.6665124610621214, -2.5729878667527184, -2.1251826851495266, 2.434655309807349, -2.7484038304921437, -2.929815670339515, -2.572188882152568, 2.446583237374068, -2.156597492142337, -2.804732491603049, -3.0399813554494126, 2.93647781171743, -2.6160051173511687, -2.5444579486848364, 1.9650263626287219},
    {-2.1036210908981534, -2.4495742024310294, -2.1588978620511394, -2.6638978903427586, -2.5167720278800796, 2.9931564906468484, 3.4875895482507318, -2.6641806775303927, 1.0886366123427158, -2.2788779120638423, -2.6739090789269944, 3.1200646162871273, -2.023442520300005, 3.7288160451636205, -2.402631718498815, -1.1532843842149196, 0.4372239651091905, -2.4178791518566767, -2.1149835886034203, -1.4900066642090224, 3.348553465147352, -2.0554501790358537, -2.475291087719475, -1.9571453325376689, 2.8453316997143836, -1.7984583935075282, -2.3620520811486565, -2.36693054661557, 3.3100883532367846, -2.1815606914529786, -2.2732157916850353, 2.4630521863740498},
    {-2.1005134836500425, -2.5573882302289306, -2.3269582481141433, -2.228737548571854, -2.4257584020398744, 2.8653965513066715, 3.3317539884472422, -2.23410789214784, 1.092856858449067, -2.1429361479755005, -2.3874198735575796, 3.2372257962967437, -2.5929011195478897, 3.756319458915759, -2.2345419452108475, -1.2342432587609813, 0.11063424160494997, -2.1110073828010507, -1.8009355583539293, -1.380513459884557, 3.0541171337764297, -2.0668774702945, -2.413234434127095, -2.139814150121751, 3.0105310143339183, -1.5591494827078853, -2.1788561076182242, -2.378891698617928, 3.279455401681551, -2.068053570491657, -2.424546370076187, 2.337703647844044},
    {-2.5526619804472643, -2.9861188711204774, -2.456646754783985, -2.5610015842730625, -2.7353449022551177, 2.322855719042954, 3.2919012939702386, -2.4583142453428803, 1.3117231900965909, -2.6388701392686555, -2.9101916994910257, 2.685082396024452, -2.466168530847006, 3.7577773211392005, -2.9147695986115276, -1.407117951033095, 0.24013224446115136, -2.6209684206799193, -2.2878145296847214, -2.0125474106144914, 2.4585460279872358, -2.745967423665701, -2.6613053780356926, -2.512790154950005, 2.187529615074532, -1.757721313106225, -2.499995156626786, -2.915482244423794, 3.0584203698881756, -2.5150390152480417, -2.829165640482661, 1.8084971181184326},
    {-2.806540110473422, -3.330156293792709, -2.7393449542993684, -3.1133630602258617, -2.806718147351359, 1.674399715713604, 3.2348105051170615, -2.672932565131746, 1.0945015365813269, -3.1935870810759917, -3.15366147084308, 2.227130564930554, -2.264304708724895, 3.508361188647633, -3.1167180045680953, -1.197555986884967, 0.363317895802018, -2.6259066809303873, -2.448797550558486, -2.2781186730548675, 1.8926790170312624, -2.7945797129502434, -3.0813199594578773, -2.9389001532255783, 1.8042271022672556, -1.931095749789323, -2.826772566057786, -3.169078791528161, 3.039354796034932, -3.0317202869798447, -2.6777922468197852, 1.9491372864387377},
    {-2.304483200041339, -2.5013208946250067, -1.7582406556943209, -2.8648668157344077, -1.8101781955261254, 2.9655864766516427, 3.7245365733957736, -2.2163378125105764, 1.8521141071925549, -2.7342478386681317, -2.757571873345414, 3.4265221405785824, -1.5694386644711635, 4.204800217291022, -2.233749457283685, -0.3563852365756012, 1.3652445261696173, -1.9905706914467345, -1.4237920371182644, -1.0788942404466573, 3.0935066151877573, -2.137261845674769, -2.2973613585960764, -2.080771480563081, 3.10436809132498, -1.513122607017427, -2.026783248839717, -2.590769970556936, 3.746182296458285, -2.794839296013716, -2.163591021554428, 3.363714378307413},
    {-1.8707038954406747, -2.356994370254763, -1.2332993940888448, -2.537871513056409, -1.378539006309867, 3.18732398885796, 3.8376813420817326, -1.9646647374115147, 1.550879196095842, -2.620541719617374, -2.106278741955133, 3.347786972659677, -0.8308605088121822, 4.085602727438914, -1.9926325148827118, -0.30062609049972205, 1.857780512621393, -1.3018297231648273, -1.2897311453777407, -0.5451675798982196, 3.208617541243401, -1.365061568993031, -2.016356026410931, -1.3771927536646507, 3.269042846801279, -0.9629337835262529, -1.8590660804089467, -2.181212219880235, 3.7574393373312134, -2.517579645096835, -1.5681934505299528, 3.1440134127120802},
    {-2.270229089319509, -2.6029539861222353, -2.08675986004299, -2.8765433229161026, -2.1903277457384878, 2.1338612742565797, 3.420782451833579, -2.204256467096912, 1.0501480147046596, -2.8296860250664326, -2.670111649249216, 2.63440511523592, -1.7561007379852835, 3.875049569325088, -2.362792410635542, -0.8313994892472952, 0.9559439385022761, -1.8206605007864134, -1.9686674614446327, -1.5108430566611761, 2.792156570967278, -2.2848545301185026, -2.3001198428669167, -2.1469976446497507, 2.4505028502914143, -1.9645194384520708, -2.497236712827033, -2.4900480284404996, 3.3970334156325435, -2.777677962349864, -2.4710141728104045, 2.9626851522881923},
    {-2.4156811582092668, -2.8392013922651804, -2.115160728670549, -2.848279808429295, -2.1623292904808267, 1.4145898571008115, 2.6429421499352874, -2.7216938269080178, 0.8964655326675156, -3.304011394422103, -3.062352830077705, 1.663193923956678, -2.0088340210216367, 3.7054635921318333, -2.682171700575214, -1.2184655834438582, 0.8529274548563605, -2.4888022917640664, -2.1089094707864917, -1.9353602871658548, 1.7368824175703315, -2.5785855736348164, -2.9307059458928517, -2.6981340350833185, 1.231936296316221, -2.1425228306445936, -2.638977231677722, -2.8018983224852683, 3.0740522008521887, -2.8466391409592373, -2.293217272108052, 2.1296874638994625},
    {-2.338205779726948, -2.593989361404368, -1.813820986798012, -2.7776328988812664, -2.201158407590094, 2.057395135232536, 3.0828392538023137, -2.3412644338822655, 1.0694943038420561, -2.938729676111901, -2.3373429478747636, 2.590139432277069, -1.8459689907003984, 3.8588323933373663, -2.4754789641493358, -1.1422964733615406, 0.27085646426000937, -2.075128757439414, -1.9509635355504533, -1.6994310931119374, 2.181474730570122, -2.3947211990878303, -2.7110506974143824, -2.1181202471248306, 1.9014929661630804, -1.4857043101638114, -2.0854596527761657, -2.4776454709232167, 3.0751887008736944, -2.8682238598920393, -2.0677851647050973, 2.2925880621151706},
    {-2.290630072225518, -2.7213630276119, -1.8668223195208777, -3.1179927643916985, -2.2229908036957364, 2.1851566197381014, 3.3224103720057063, -2.4523221175097962, 1.0648133961394677, -2.6786017577956347, -2.5731161669707574, 2.7407798701948436, -1.512642390939279, 3.9713186000004854, -2.4722964799213614, -1.070228851775388, 0.9985601632247748, -2.041933083719129, -1.7758085790734608, -1.0198277499586847, 2.668498665154904, -2.184915496396324, -2.351970893246254, -2.2868747236223816, 2.846921974096608, -1.4951175624877697, -2.218600583862365, -2.7121481947623174, 3.364970729957344, -2.977869327183662, -1.7260389124739888, 2.6818646022005788},
    {-2.4940538547813476, -2.864470065512261, -1.711547275882471, -3.0230036993454887, -2.432711981576338, 2.5377461625700857, 3.4590373725705086, -2.5659906736936695, 1.3598419483487525, -3.131860107382042, -2.841278482288839, 2.8932059970274304, -1.950293774759495, 3.9818234616904107, -2.767789113897087, -0.8306959403391848, 1.0910796719187608, -2.2473401223750904, -2.419389620214243, -1.259398278269299, 2.4658677811273932, -2.187496544487264, -2.936685025472949, -2.380470847735517, 2.446369277185177, -1.956080650417085, -2.469539272940452, -2.7827318609116016, 3.3656341927530447, -2.9579637557832537, -2.3145017610871803, 2.5083713049735143},
    {-2.4790645641572318, -2.8398822785648563, -1.86953973788298, -3.4182970740089083, -2.3099049836143544, 1.855721759052755, 3.131595400109927, -2.5798362995661983, 0.8676299554104808, -3.199672584495486, -3.0946330166412093, 2.1428060003162033, -1.927013789370984, 3.871025480529958, -2.561979498669804, -0.9629953557419555, 0.6786171789779134, -1.973496058455151, -2.08249147732444, -1.5518503657076286, 2.179550363019954, -2.580518580869468, -2.8404256789096665, -2.4882311002410185, 1.7721783030599216, -1.8826155675028586, -2.5438926767979724, -2.5804530426740357, 3.2636192125102346, -3.2069115275308007, -2.0269954065916753, 2.2774944605700522},
    {-2.4652523336598176, -3.2221826494768147, -1.873928583700925, -3.1269551829710687, -2.2859408332703532, 1.4893295942286302, 3.03937853941868, -2.3043000748328035, 0.866871285699112, -3.0124735117626544, -3.042422182700768, 1.8817993803577415, -1.9955548355574189, 3.7815398414550225, -2.6849843024114812, -0.9126503680320566, 0.8800702522696956, -2.2683160402369107, -1.916002266082873, -1.6542351445282126, 1.5609842100794862, -2.448436035830601, -2.901674719145117, -2.82907190030068, 1.5802675301537075, -1.618390065077659, -2.648023696757479, -2.706678945323244, 3.2869061452578325, -3.077413033068268, -2.013023287509141, 1.9940088315619544},
    {1.0624104039931683, 1.1162549959325503, 0.788238416071262, 1.023389646421582, 1.0919839685247408, 0.12378519003507592, -0.9673548260210645, 0.6939580319959752, 0.3992006843123036, 1.0971307803390333, 1.1039482867228536, 0.3552656113517282, 0.047958358339694404, -2.1043117443484713, 0.9098149410814951, 0.3926902365961963, -0.9174832663684088, 0.6463271304909204, 0.7589713606370884, 0.1892261896756535, 0.04566023500076354, 0.8482708966910381, 0.9403807342668645, 0.6183474732194166, -0.505114726679172, 0.9750157829047319, 0.9731235578887303, 1.2564361055789788, -0.7003194839291778, 1.146930312022792, 1.0102837787831886, -0.7818491685656946},
    {-1.2023883357615512, -1.8685905778706842, -1.1361174688064681, -2.589502858578908, -1.2522998634911497, 1.4940164753439338, 1.225815283819561, -1.6691857171683084, -0.0702911350868041, -2.2815028605105643, -1.7328073110184021, 0.7433658936505428, -0.12044413772541775, 1.864933076204184, -1.6251531222861737, -0.3453978616666409, 0.6740942106343044, -0.34789022061528374, -1.1278771142139414, -0.4239029732482922, 1.1185235683147368, -0.8973982243841893, -1.5942973770634339, -1.4252973398130013, 1.3794639852456185, -0.9288434757415892, -1.5614554691943985, -1.6991270048540403, 1.712202832949818, -1.4140317137433056, -1.4118497436897819, 0.7854447508101309},
    {-0.9815655918189362, -0.5803068706246282, -2.2170239751657763, -0.584427486165169, -1.375181839738484, 0.46800486643753647, -0.35077395622848523, -0.9746190829570337, -0.4547952634544822, 0.5746032998844499, -0.8227119206467044, 0.3371235311997351, -2.329316182773057, -0.6179377607497066, -1.1999344031633308, -1.9109481778202222, -2.359918892022449, -1.7404061848410806, -1.6976448535467046, -1.3714168601379908, 0.5246548973769304, -1.2927604617983006, -0.6777923489788765, -0.8960105178861305, -0.2920242456826629, -0.750998309734999, -1.1367137696678973, -1.2517703058844625, -0.5735616266959005, 0.770832844371238, -1.802549452381808, -1.7142131350752077},
    {-1.407050904045732, -1.5758116026419102, -1.620343038532549, -1.3483468460393688, -1.342500107783102, -0.6831956324502066, -0.9797777234598539, -1.0704823939508457, -0.6434391497141164, -1.1276087649773436, -1.4726902276630593, -1.1635171893719602, -1.4221378814642303, -0.9414582858646595, -1.843758771710427, -2.0316655266346046, -1.7762040250534714, -1.509443929731052, -1.8719127504958522, -1.534616001936188, -0.8381066844466237, -1.527784114098326, -1.466168977729362, -1.103627065436522, -1.100413314116015, -1.1991567691637133, -1.3458980937922265, -1.8505011176342652, -0.8048915890862807, -1.0555862558086937, -0.9005338533150232, -1.5167023787979619},
    {-2.5691107063916956, -2.2869584437420563, -2.1932276277620244, -2.3821805318931673, -1.996440513212375, 0.04137123230021641, 0.48736581413516955, -1.9861838426613507, -0.011971786894015889, -1.7193374969755453, -2.1562189692219103, -0.3598006256094923, -2.0032946856183877, 0.6328081090905552, -2.2819856440283655, -1.9069526447390337, -1.788335301483412, -2.1978118810912903, -2.067427081678214, -2.1583425447587237, 0.2544196540690001, -2.301051210391484, -2.4487982334078664, -2.4704688346499735, -0.30300670597515844, -1.4877912468725116, -1.998019861423877, -2.184233792113708, 0.3830031270657958, -1.2101344293639245, -2.054804240517184, -1.527938831797787},
    {-1.739745784226948, -1.738476742941366, -2.434819985351111, -2.1629117455150944, -1.9197627731064668, 0.26111676082474194, 0.39226624081637274, -2.2971755589296308, -0.6444184159582909, -1.1478820178480305, -1.625671421165304, 0.1393082388768675, -2.128590556725726, -0.031528810598385235, -1.9461169114399115, -2.14711783221865, -1.5691985417089924, -1.8992075774157113, -2.3341968277737863, -2.101985763740839, 0.20394685946537366, -2.046240738422907, -1.7931650599548334, -1.9333416873963587, -0.026578878914100677, -1.9626272785664476, -2.3029505141360818, -2.203158619104112, 0.21968065575656617, -0.47387620757928495, -2.0369572267735436, -1.286826493745922},
    {-2.1860936214433404, -1.8040608786458412, -1.8956686693007094, -1.7784952929243056, -1.6647448084972394, 0.38002364620838325, 0.37152807521102554, -1.5517354387097333, -0.5082287418423858, -1.1435193480457497, -1.3636000000181177, -0.026880219021676286, -1.6547883585609624, -0.12621757028848357, -2.0421989424734512, -2.11620369659295, -1.243926484565883, -1.779381886797153, -1.732743523457303, -1.812423149966906, 0.16568105672608452, -1.647558177470768, -1.7837946015808999, -1.7175612664826407, 0.1551596211709146, -1.5388376892536457, -1.888757499137241, -1.9469540234884917, -0.14163769140224633, -0.3977188070694836, -1.8751753152874449, -0.8999957327483796},
    {-1.5911099780132445, -1.345881271145852, -1.3615070454372245, -1.7899001564634074, -1.3858707602102727, 0.15101031951648533, -0.2775154674042853, -1.7857967718210739, -0.803233158500165, -1.1307243345856743, -1.6966947339741714, -0.2316584021192158, -1.530451300446131, 0.13982473188681413, -1.8616487816807834, -2.256664581358614, -0.8041716426044273, -1.562186797070922, -1.7338808573493292, -1.7526539602329863, 0.17729274562747235, -1.6206527306990925, -1.441830333403481, -1.6353885128906442, -0.3989804929206121, -1.467127217222286, -1.7469257889533882, -1.6711401172113929, -0.4178144911361291, -0.8839866805085167, -1.55402394245729, -0.8016393578839058},
    {-1.5825223607900516, -1.5830165944010188, -2.118182444360393, -2.4040403057260877, -1.922515502825749, 0.43227212317436253, 0.24595386110857864, -1.560399651208523, -0.49422695946204037, -1.1281052255852968, -1.85549968248343, -0.3746469831859881, -2.2207142102234707, 0.06393538683950077, -2.223416529372469, -2.365077904481613, -1.783097534900072, -1.5605587337517004, -1.8189773117062196, -1.7939169830897121, 0.3447567560742003, -1.8937612102774901, -2.047823357160404, -2.198339550953606, -0.141821756933476, -1.5511892418770794, -2.0876079639594436, -1.9562537036146637, -0.39542826786392665, -0.5877512694996931, -2.6856420528179212, -1.1515318716103504},
    {-2.2754279555014345, -1.1108968268997796, -2.059179314602591, -1.756253369500601, -1.8365710959161579, 0.4707393493429533, 0.8633691283057057, -1.5929543977138443, -0.06794763553936153, -0.6682345925835445, -1.0508569011460298, 0.22767845965955552, -2.076974624817561, 0.5408061948163118, -1.9351862515965692, -2.1930671908134634, -1.7393360362215324, -1.8626969583556932, -1.6721650188822963, -2.1125753501084628, 0.18968734210444588, -1.9330594498108467, -2.0235564396031713, -2.050486323922744, 0.3628132753411975, -1.0752825955884344, -1.2020518589154205, -1.8115545247130556, 0.5527264565087058, -0.46468730700353383, -1.9960947439588372, -1.2625756188326493},
    {-1.9752112273399431, -1.9509243075447902, -1.8328386987129623, -1.606917488099436, -1.9180215551248574, -0.4600951906472621, -0.07476417447541235, -1.49762692280502, -0.3366414772545274, -0.9617286013646579, -1.2672808898489831, -0.8437281104551287, -1.8959339025524906, -0.5219437035256563, -2.1054307873058757, -1.9287124202987798, -2.4924738289894726, -1.7036810476153372, -1.6339554598453339, -2.062052282517014, -0.39400600470714636, -2.1188216446980483, -1.861591338698322, -2.0579745111065595, -0.7281879322805486, -1.243449168656343, -1.45949982780277, -1.7887553563227745, -0.20796017887721668, -0.7088173293431814, -1.714370463613435, -1.6955261307247882},
    {-1.613026220335167, -1.7673656343339992, -2.4197732459462817, -1.7877655386753066, -2.126618685052773, 0.12128886655428021, 0.09592965024922445, -1.7682341555821048, -0.5204499754706033, -0.9469227554382074, -1.418077160724033, -0.03716214472919868, -2.344212168625414, -0.3594225461783946, -2.0286340213517375, -2.161464055351285, -2.011417528133549, -2.0928839763362155, -2.1580152391736176, -2.303799941331665, 0.2709050652125569, -1.9827697918494198, -2.308073942350681, -1.8284312071431128, -0.15823336785143208, -1.6748829490440444, -1.5274486153482576, -2.31923553862952, -0.27489620140126014, -0.5891841899413048, -1.829716714410716, -1.8429443240118073},
    {-2.4245988667543155, -1.8392874634613101, -2.314137201858075, -2.0470967080656037, -1.9130357827182345, -0.22796546929929354, -0.31934163851019515, -1.950888948084881, -0.5827357057533813, -0.9270619002190023, -2.274427975035237, -0.280957472208455, -2.8627819135767036, -0.4538416124659649, -1.908033893340416, -2.4036425003217756, -2.1932689749829364, -2.337045559577665, -2.017262743964658, -2.1641163759021347, -0.22223463253259532, -2.1544360672918996, -2.3190159418162355, -2.215082047269032, -0.5496986326940504, -2.0142942499074077, -1.9327272193238072, -2.393127322259311, -0.6189259648832851, -1.1510868336117266, -2.260838547903224, -2.029133509429629},
    {-2.4626765784617732, -1.702565220422404, -2.6837120517769564, -2.0288544564983537, -2.1748804163168285, -0.4548502395182736, -0.11759243608812936, -2.1810779943699443, -0.43229764267776877, -1.0354462548421386, -2.018092750721207, -0.5382069694125431, -2.722065282572795, -0.5168403039609346, -2.204612327848476, -2.5956763349236343, -2.307638811912259, -2.2724587953568056, -2.4105029855840225, -2.2977840425574225, -0.45608613393944164, -2.0908352639819077, -2.267818037953251, -2.3461813104059326, -0.9903125783298266, -1.9706005454439446, -1.9462683991185725, -2.0442191387226316, -0.7688356253963298, -0.6100615253326664, -2.585129282307674, -2.2820904492327236},
    {-2.0198555202051627, -1.450693428673639, -2.411785381599126, -1.3655598661944772, -2.175787977502041, 0.5858716349880816, 0.602392776426418, -1.9482039725258495, -0.06200019593632609, -0.4172748700646186, -1.356594390518274, 0.7455242024652876, -2.7597128124805743, 0.14470941770361975, -2.0832347434590495, -2.187584825785047, -2.1859312448063157, -2.000673519058106, -2.082179577452306, -1.9409054781593802, 0.5074147172492381, -2.0151330822775777, -1.9956651249906197, -2.036483898550405, 0.327282358575242, -1.1241889224102106, -1.732558042058428, -1.864991408493821, 0.18348454178703552, 0.14901088603248672, -2.3680607848116058, -1.6006883969965904},
    {-1.317672462015011, -1.290313758198047, -2.4344205047564937, -1.488542486467611, -2.057339289116876, -0.08886975241711423, -0.09737350791312842, -2.090127642079248, -0.37025128522570755, -0.41514928920736166, -1.2728899428193656, 0.32469139680642567, -2.5634903023835007, -0.2442213296370475, -1.4960482445988994, -2.4488352158774673, -2.453159570421462, -2.008034499957222, -2.4122338899360702, -2.1550763704726177, -0.08620969316267657, -1.7271080521537547, -1.5477929687154868, -1.7118818438758163, -0.24213891801302195, -1.8088868048605664, -2.0449531065594164, -1.676200740879855, -0.432106892452454, 0.19032335517800958, -2.1680412788566317, -1.980489284569036},
    {-1.7511888058403098, -1.1374744357246755, -2.318144795134348, -1.7234869960217147, -1.9141711198971114, -0.038904902725489604, -0.1442951499584736, -1.8026615973025564, -0.7091230653776924, -0.8853528427924002, -1.715062138007568, -0.2432209155869143, -2.1863011398156296, -0.08441394836396691, -2.0348103081941744, -2.7310713680475516, -2.076332960072021, -2.1495851546537383, -2.236743854592712, -2.4125067447050776, -0.24406791679598067, -1.6276617202276722, -1.6554735477172244, -1.5442569074352435, -0.08824691527223294, -2.013381227916143, -1.9876172179298253, -1.663247351806576, -0.5500929964149589, -0.5779636939003059, -2.3716853611865116, -1.9476627847739947},
    {-1.5338527453527842, -0.936218986156419, -2.3257063337658375, -1.6077367782133962, -1.4294841698766236, 0.7214994935372611, 0.15277141588592152, -1.6822205000196901, -0.6148356137968916, -0.7493102897270161, -1.2750385008881477, 0.4274408345755283, -2.1372311270819444, 0.48948350381824635, -1.1006974057147967, -2.236421675827297, -1.8092566984309835, -1.886613802373468, -2.1388114304798336, -1.6129707560250088, 0.879875454902026, -1.361797711171149, -1.5939966016690943, -1.3041725568869436, 0.6148552631915468, -1.504495848132944, -2.041596851456492, -1.5246050447143045, -0.2923272062357478, -0.3641390601426703, -1.8140484262707786, -1.1773182425307451},
    {-1.8880624247041815, -1.2275394080092026, -2.5078081479615744, -1.5394307076109035, -1.9777493285777283, 0.07062879819862544, -0.45694391940430956, -1.912078037634626, -0.46385121884380937, -0.10708815712489483, -1.0650111536961182, -0.23338590343066545, -2.4161083125759446, -0.5174876041099212, -1.4178317520620114, -2.328748009515841, -2.8137605055769126, -1.916365907064519, -2.269937694272685, -2.175527566123153, -0.12711514665647242, -1.606201893671085, -1.284931055756436, -1.7027457317004884, -0.7445485477492549, -1.9454200560851393, -2.0344918126956197, -1.6463501100376159, -1.0965357207269322, -0.19839239544131754, -2.331076861933905, -2.610168497589},
    {-2.3450223653431235, -2.2050979410728195, -2.802460500647166, -1.805753761486418, -2.4160788522563914, 0.14386701239567323, -0.3418291639096725, -2.1496917356920093, -0.5832854943749353, -0.7766954015907833, -1.731699997170708, -0.5354184974478426, -2.95882491444059, -0.9131447582889984, -2.2637502468180504, -2.92897318727523, -2.78069794812341, -2.5116937738715333, -2.2491498841884567, -2.7921570460679326, -0.16769542585089167, -2.1485205225626025, -2.199141708038134, -2.3347039912069745, -0.6327123798550057, -2.060350204433665, -2.4168681659906834, -2.2689843757400463, -0.7651924111907085, -0.52425981212355, -2.7763404325901173, -2.5111781788364005},
    {-2.933804266966449, -2.7690898938344737, -2.8930824754252917, -2.3394445737588794, -2.6172950319629558, -0.39893444052206894, 0.1847867836513821, -2.615289115143965, -0.8161637100732938, -1.6322068712197486, -2.518011624803704, -0.5222769024663825, -3.0273863819436047, -0.6484804044071084, -2.609867642731566, -3.0851213531159543, -2.646033232025356, -2.471539189458046, -2.7700444222531515, -2.748180542954754, -0.3246466638556255, -2.5355791569031387, -2.403058054087883, -3.068171615296581, -0.5640046569153495, -2.40311704831372, -2.8654605248591842, -2.81525485049448, -0.5329783120016885, -1.185156118064714, -2.6193043175112476, -2.292083765285907},
    {-1.4199782419444165, -1.1810869788372, -2.2800734540108545, -0.7389105832973619, -1.5880847815471244, 1.9950663033089386, 2.191456424573942, -1.64106018340797, 0.8985943974675934, -0.14227416362944018, -0.5310227675511016, 1.681388907999016, -1.7747254441289602, 2.116923832761235, -0.9584749921689669, -1.688624973058727, -1.3843519296928495, -1.590983876399442, -1.5556786501065154, -1.843371748696007, 1.7154649408759888, -1.2071388896474924, -1.2026876021199193, -1.3273899688691628, 1.7406084278864848, -1.1933519541207722, -1.1809012468127005, -1.5637480648102926, 1.826286130045291, 0.5699041267893068, -2.396767943702265, 0.27968937751732525},
    {0.12249401642648948, 0.9161713978912454, -1.8324000197742358, 1.302244491495335, -0.7127540928416435, 2.1341616002808945, 1.9399621264734055, -0.4449541412719034, 0.9379744686576003, 1.748787133423511, 1.4334237707537605, 2.49422466285175, -1.4279175411851708, 1.2717501417484451, 0.4238824113742916, -1.3851286177821234, -2.1419688301968907, -0.8965245471603788, -0.7737926520557887, -0.9974035148743122, 2.233426500030883, -0.08149872731779058, 0.24807637552728262, 0.016033655957128922, 1.9985791902840506, -0.14205872606534245, 0.2508605370106248, -0.10100473485554386, 1.63910085768786, 1.8843732079039526, -1.4803910989886926, 0.165134631727069},
    {-1.0693960317011248, -0.06027835926751427, -2.688766863159538, 0.2050109694276716, -1.8829678451682326, 1.1608443247286622, 0.6393489136465038, -1.7926034624853293, -0.1846228250790873, 1.1741533805484303, 0.07655517055796081, 1.5014923336817942, -2.749673446876801, -0.21745013616590805, -0.6722693118340071, -2.3306396145934913, -2.9664062842510672, -1.9749469572683376, -1.9263392462506725, -1.875357845000732, 1.1516659430564051, -1.290472162043646, -0.7472210590053378, -1.3583267273579458, 0.9274270315789789, -1.2831873253415926, -1.146771843359394, -1.2470485966645724, -0.3285623318114408, 1.2663208151330514, -2.1665470258846824, -1.5635415128634607},
    {-2.3149961606844753, -1.6744162309881896, -2.8633767117789803, -1.638839032639309, -2.241973760080412, 0.2263134776760835, -0.6096414449748243, -2.6364600614512255, -0.7862370580443429, -0.5456618407707218, -1.6503153353778233, 0.14883165599880982, -2.7175630279861447, -0.6017267904957501, -2.1760593672844837, -2.681933110657586, -2.888714445946464, -2.2287563074690753, -2.7247991971941303, -2.342526154776492, -0.08278866832817967, -2.3935430644592812, -1.9906870250942603, -2.074027625394521, -0.3848590478431178, -1.9439623408719888, -2.099842093805655, -2.183418329641419, -0.5815810015010315, -0.32245071022260513, -2.8084922925501763, -2.2836431457225705},
    {-0.7273898815636191, 0.011133702684491521, -2.1240395020318172, 0.3634674953044315, -1.1333546248070785, 0.8373800086785964, 0.20019541211376957, -0.8959731829855528, -0.2613842763132813, 1.0974398639540361, 0.20627650562728375, 1.0970682703641785, -2.216104837944241, -0.25230735287475914, -0.3394278200115709, -2.182393898865302, -2.959106826635352, -1.4697583277429849, -1.692653799911945, -1.616818715879988, 1.0527279621060845, -0.7833552809351421, -0.42738802966997463, -1.2573363580735581, 0.4837672222754005, -0.3691312615331785, -0.7393302128611504, -0.42213964224213074, -0.4295240020757951, 0.7123684724914664, -1.5219229357876283, -1.8895226650570538},
    {-0.7412123665492312, -0.06031138492377122, -1.8681967676169755, 0.027828894087337325, -0.9591554570452556, 1.5695553892401501, 1.0013089220951872, -1.2791976118084811, 0.2318991566254836, 0.7572990875369016, 0.3012094925259459, 1.6824533885525434, -2.486446883142489, 0.39632309954793243, -0.36407350006836053, -1.7239198237832862, -2.3695559212041752, -1.4471899414808025, -1.648320472629804, -1.1584678404212783, 1.5062477926328917, -0.8499145211645859, -0.8156096267479369, -0.9517975398396626, 1.2067537564990476, -0.9625073817792776, -0.7143088893712469, -0.5422736582148027, 0.5635017061232596, 0.9916933430585806, -1.841769157458038, -0.8827903795792585},
    {-1.220508396234725, -0.779179948059488, -2.501389863200752, -0.7744888273740613, -1.7287794698381755, 0.9749665396047071, 0.6506801652940143, -1.8587167985498783, -0.2024031116094303, 0.3487434317575564, -0.6198726887043511, 1.3653540911316402, -2.794251455469123, -0.05279153462884647, -1.100310924786432, -2.1919950431916044, -2.8359417045680537, -1.8639175606438776, -2.158980828464207, -1.9724607139811765, 1.0012911987628197, -1.1795927391016972, -1.1809468145135729, -1.3675806741043683, 0.4529609465230721, -1.1919646458813675, -1.4744328128680055, -1.200277351879299, 0.14593236757446318, 0.8343742147552166, -2.302699155100274, -1.7311688256832207},
    {-1.2903233186499665, -0.2162793180603618, -2.447939317176212, -0.07772704783751606, -1.3920517494341318, 1.327057034155133, 0.7956130243961922, -1.4111276633988423, -0.07597428093308184, 1.12328967804268, -0.10123018241246921, 1.3215249471335428, -2.648778875513746, 0.13186614225517418, -0.4059148828107154, -2.1086013130443466, -2.9368029733923118, -1.8043294065544706, -1.7556239332110362, -1.8766261729303093, 1.2001935517139224, -1.1239265407757812, -0.9028115009528089, -0.9955266110511488, 0.8226604407097382, -1.1885957397473301, -1.0746744076242862, -0.9748274027604051, 0.0892519639548412, 1.2758408014117864, -2.2079707400647814, -1.7236797513355713},
    {-0.5693647127944736, 0.2971611047508204, -1.8890610483732027, 0.8262190654685101, -0.7634945537849213, 1.452911471545371, 1.0722165878844894, -0.8548299810936882, 0.5586779615334666, 1.3204482263370734, 0.7671042104776556, 2.0495880521361056, -2.1215683146548003, 0.29530326534815743, -0.09330665482006825, -2.070497858811315, -1.9825176479785303, -1.3586698355514961, -0.8607791953243563, -1.0690005103609286, 1.7111658290463463, -0.6417641304992207, -0.27042715852640453, -0.38679530018262526, 1.0361815076831828, -0.31186256517293476, -0.42434977249597977, -0.01127423758882884, 0.6528167056249244, 1.499070966823284, -1.6920355199929604, -0.6377541425322325},
    {0.9088820652987641, 0.7223417945545472, -0.3359633823114346, -0.29771501701998376, 1.0925326847941814, 0.9512171384371017, -1.5756343493012015, -1.301755573191819, -2.2623446128694304, 0.7360135586118856, 0.2797191048904049, 0.5519879664102522, -0.3480867811117016, -0.8805526086603015, 0.7797957939946351, -1.9644308255019314, 0.19773897454621298, 0.6537435268588213, -1.47095965435591, 0.7311214942477011, 1.2368497141252208, 1.0103945030811436, 0.3093157059509938, 0.8734158885889449, 1.3528132793166783, -1.7869663939236964, -1.8704249025838084, 0.5822542280132038, -2.027634384556599, -0.25128772345049405, -0.3545670398218578, 1.0029845059750364},
    {1.268658419446643, 0.7078006506419244, -0.5022381826612068, -0.1773292846889737, 1.2993309356559275, 1.8720283203231152, -0.8822122802254708, -0.9171530464540938, -1.7815118867557396, 0.969668195671718, 1.0368964982290074, 1.4441152013645604, 0.10925111005748446, 1.0021088184905267, 0.8309433083569785, -1.399256594620267, 1.3161145052351473, 1.1764506633727234, -0.85473105764915, 1.2061097151318734, 1.9147942941127785, 1.5127000140267834, 0.7219316093257013, 1.4345898610398349, 2.15495940536878, -1.4603357115822992, -0.8343074214397332, 0.7748965668833255, -1.0551746549182661, 0.01668870723804881, 0.03173521167725775, 1.9989997845123872},
    {1.5065201409801363, 0.8221836768472702, -0.3941078114495255, -0.23793666874942654, 1.4341023306091363, 2.0401371247705127, -1.69459157890137, -1.3699334220762371, -2.357078035376941, 0.5244220824994216, 0.7619826423578859, 1.1819658938688875, -0.37615939238999063, -0.1342662005344933, 1.737007484695908, -2.3658977394858574, 1.2049427682188898, 1.1745844316313356, -1.7293368902998463, 1.1709945539357103, 1.9092066337241744, 1.7232493556385267, 1.0543104141487907, 1.3369845082265461, 2.1204639732781847, -2.0827428695477033, -1.5243024144739583, 1.391146772899529, -1.837662413855224, -0.11066725995720601, 0.3679853868939958, 1.9959728841780195},
    {1.6279674134346134, 1.0965897287286712, -0.7123554318491102, -0.13378016620804747, 1.6257881175358473, 2.153848307266652, -1.7627811805722535, -1.6677234116997608, -2.501504985104825, 0.31717065328944144, 0.7245216547300269, 0.901520560775205, 0.2830592596263025, -0.14137320011450732, 1.4374679777851418, -2.337281652389374, 1.4094171867388796, 1.4260093644340086, -1.5364794173378769, 1.616025175746524, 2.147932720837373, 1.5974029509736039, 1.1939387022579673, 1.4770092349867638, 1.871097223050842, -2.153577359067731, -2.0974298345594065, 1.3684902965030796, -2.187178424003253, -0.36213139963751034, 0.345970978299058, 2.298487005635599},
    {1.4611206909206906, 1.0272812163414045, -0.24640010220235195, -0.33923590114125396, 1.604864537290104, 1.9058887769198367, -1.4448584918112353, -1.3293550083238697, -2.374827353750678, 0.5565570990466661, 0.8878284721482792, 1.5116790489900813, 0.7403274431622768, 0.14256954430085267, 1.3115637475992883, -1.9611615425926676, 1.7250347067847915, 1.1856097284999718, -0.9011708096565078, 1.841280251766346, 2.1821995406581562, 1.4632976419908035, 0.754904021843989, 1.5141626109977901, 2.2052118645514276, -2.0318603910994257, -1.8712264610449572, 1.1219012754665902, -1.584506109161809, 0.027866750728678443, 1.0117929562623333, 2.4795137646715113},
    {1.5492159571943984, 1.0970476312711523, -0.5318972306330778, -0.10566218215171627, 1.560444096678694, 2.1934229343893787, -1.6900947147697594, -1.6377794090425593, -2.5193939349904806, 0.7154406077270766, 1.2673962783533925, 1.9244753971906117, 0.4023713346748551, 0.22419595818322022, 1.4564092041089196, -2.0564332769459854, 1.686637624564395, 1.251376342894401, -1.4661798186514652, 1.527789721373436, 2.0043304957804513, 1.5424974765297412, 1.3204515297314534, 1.4820610545353472, 2.3569814421049324, -2.3763397655175162, -2.167850407196239, 1.3683724795222025, -1.4362054874264505, 0.00975766571258871, 0.7597964305177183, 2.246559185844391},
    {2.018182282253794, 1.12504225986896, -0.3475657434104931, -0.31393632509341535, 1.4785327834304622, 2.05233560760627, -1.9440905964775068, -1.6995306324551867, -2.684854520375453, 0.8230542247082674, 1.3019430085965908, 1.4115938841097206, 0.14391394383012782, -0.09292086953358805, 1.4214091128243895, -2.3645831622822375, 1.2643095184257378, 1.473438753182937, -1.6097810343068124, 1.7545027289766768, 2.3257636458192814, 1.6766987978579142, 1.4085868136311266, 1.8252513526176841, 2.2169561323775033, -2.4118183383663276, -2.3475301058838762, 1.3406617726392391, -1.5475083024486107, 0.11982484128282425, 0.7645491788073066, 2.0227281361271907},
    {2.05940200703544, 1.1515352842506767, -0.46243462402700847, -0.3295682731695511, 1.832632273876788, 2.122306408486648, -1.9698560851820073, -1.577147180165527, -2.6756053713479164, 0.4572807299935359, 1.1317513559178551, 1.1822910311898152, 0.13394905908446741, -0.1576138362846987, 1.6588979874619463, -1.8656448918700508, 1.7859799118944182, 1.4347663843137106, -2.0104769542100076, 1.8893735495693118, 2.225554232906991, 1.6345041805452698, 1.6837023985718118, 2.003967065970729, 2.2778477063804057, -2.6349706237201915, -2.3424009887619857, 1.4985078078407512, -2.0120118619046425, -0.10419297469832843, 0.3613205531116227, 2.251310230109026},
    {2.2189495671323196, 1.6399741316857106, -1.2343814885580744, -0.4196662822712266, 1.8831296365084993, 2.4303735433861515, -1.9691329086881852, -1.9321664676174146, -2.9774094619277287, 0.6215793151494351, 0.8684560018107412, 1.5868372740879542, 0.07630708922953924, -0.04211538510663795, 1.9128002682754672, -2.1682426659371, 1.8429875336877788, 1.855996198932322, -1.9233375771823502, 1.996436780107095, 2.2137061224814665, 2.3282324356856066, 1.759688306875982, 2.0671616446855614, 2.6538732481568834, -2.7767306344268348, -2.2003179388022605, 1.6019678933857526, -2.10704613486778, 0.0801063949462449, 0.5224534078082972, 2.290583785171083},
    {2.3607967882744005, 1.6700125371697858, -0.5107565766943678, -0.04819217364213403, 1.8862036553039143, 2.6036628749656305, -1.9619219030262123, -2.010825690821033, -2.7979598178652356, 0.6355427335256602, 1.014518706998766, 1.8920387158500782, 0.18289287683141459, -0.16018034095102218, 2.0979082924356045, -2.3837383160592016, 1.5794274781749023, 1.5212840151156088, -1.7250807436512856, 2.2319939473157073, 2.4469630528332282, 2.3039151480587767, 1.7639388747421065, 2.0262426028444187, 2.8973122287743496, -2.603729968901011, -2.0654138726713134, 1.999103851577057, -2.1227133145753263, 0.26786921380500833, 0.9230956432468779, 2.7681798214594546},
    {2.039477131263659, 1.4037152336063052, -0.1185058033024668, 0.2026023060512775, 1.7999226362322573, 2.7175586503195834, -1.6243141609241964, -1.8750428181073946, -2.7324508596607275, 0.7324251348694822, 1.302377595309893, 1.401177507553994, 0.23802546367278823, -0.16181634290066843, 1.7718009198517117, -2.453038032818529, 1.3892496468926594, 1.5265019959027433, -1.7659104857806236, 1.9142629748066728, 2.2128698714330124, 2.053255633220244, 1.6020637547577283, 2.237222902707148, 2.751703381642773, -2.2072181640251247, -2.169380970098428, 1.7027968886610667, -2.155634853416411, 0.10824433319865094, 0.9901448893044413, 2.1570364668180373},
    {2.2294746783701678, 1.6035760695801038, -0.38811607953754707, 0.07643279421576392, 2.2068906150573873, 2.354227856091122, -1.890688030511273, -2.0550808390959574, -2.9516865295224894, 0.9411538547360491, 1.4098615136991484, 1.576254668867835, 0.096266831007496, 0.10608468148224572, 1.6991570063956782, -2.451215279247443, 1.6742254062169293, 1.7320209042377859, -2.080197564608787, 2.250593255890619, 2.505387728784768, 2.1322649017944753, 1.6809301650418034, 1.9679668086908055, 2.772066128207749, -2.4655447839979057, -2.1595339521359116, 1.6586518423189471, -2.0296070704062625, -0.1165568582157021, 0.6309718475644079, 2.504936557583246},
    {2.0579954185627436, 1.2469626324447491, -0.40665071433161537, -0.6526970438062637, 2.1077854170528045, 1.903286263717902, -2.203532111386337, -2.015775520333232, -2.7887049170556346, 0.6869381921879583, 1.4425587291963622, 1.0913072875951106, 0.027741545043812602, -0.14401965618080867, 1.9382802722971808, -2.441780911942077, 1.6255971299641958, 1.7095898304763935, -2.1583349438749027, 2.159971403377851, 2.388138992266126, 2.023367825523028, 1.3495690315886288, 2.219791932802113, 2.312518987259955, -2.470410232210527, -2.2603864270569742, 1.789223805667187, -2.434974995215984, -0.5249453979128345, 0.6912815545035734, 2.420150939528261},
    {2.0078733550093513, 1.2036262076497275, -0.3331489088294335, -0.11378338851175833, 1.8203430547899593, 2.088170068748227, -2.048750803758942, -1.5319585428561842, -2.7901897228027868, 0.6674289567538381, 1.2446572699525815, 1.3712798921625806, -0.4257078643454094, -0.7779862048103573, 2.21112796421779, -1.9889216738479474, 1.5468090953917764, 1.635832104859959, -2.0147782145353372, 1.8133422956081187, 2.393591177869022, 1.8404468881852225, 1.022178028280839, 1.8855008723813345, 2.4594136758199547, -2.134825472885997, -2.069769489970156, 1.9439070015475874, -2.1425652830532895, -0.024112056671581214, 0.8333446202694063, 2.3029455907645198},
    {1.8695248748333497, 1.3033797891009968, -0.7428599636086128, -0.0033352394037387957, 1.9370174673498621, 1.4859231330269094, -2.0431752807811425, -1.47468441233473, -2.825265942087763, 0.5891735120904694, 1.3537764940542383, 0.82813622337071, -0.39663451828801954, -0.871096261702109, 1.9767929821098058, -2.124649586654762, 1.083956475873839, 1.6758498925019236, -2.1725644651832545, 1.9398012280183337, 2.087795306209323, 2.139076111849194, 1.2453109282727266, 1.8984025130318383, 1.8639836425072762, -2.1889337626887517, -2.2196139714762593, 2.07384225755489, -2.11958130725004, 0.12056922247620518, 0.841351731815267, 1.6146848738665263},
    {2.1847642370404734, 1.3244055334502034, -1.0580774882408561, -0.11082540122712024, 2.0529414117020734, 2.1423256849465524, -2.05798151552009, -1.8258972271859293, -2.8572977563860458, 1.0010264221173164, 1.3135684875803804, 1.5119431260925973, -0.2742395201263948, -0.6633006959069588, 2.0458163836142758, -2.6264433793167843, 1.3995187508478537, 1.4313690816344564, -2.338970845229035, 1.7014715651392234, 2.285758938152755, 1.9132312657235606, 1.6196441483124042, 1.727846569663593, 2.4115865740462508, -2.6783586945591744, -2.320091922117076, 1.4323519899393828, -2.29091975164219, 0.08045785472061344, 0.49023441744965734, 2.180791868653276},
    {2.229359004278823, 1.1934921872803108, -1.2290117634160604, -0.42586425413662066, 1.9367201965914431, 2.4321198379722295, -1.552777761708633, -1.7066679943050138, -2.7886403046130175, 0.7272062601713254, 0.9356058090817047, 2.070503758252939, -0.6964109281822249, -0.10591749141521144, 1.8550263178681308, -2.5793566807902013, 1.845994873755479, 1.8318566188385463, -2.6029818559060804, 2.0780046868144404, 2.410484829402582, 2.100062920255732, 1.5616976607214699, 2.0740903875530914, 2.825742719555068, -2.8254570270423147, -2.508158510896422, 1.8505037074190758, -1.5398042923742596, -0.019613285777328023, 0.3256269850337342, 2.38900322727309},
    {2.151510524202212, 1.2641078793287828, -0.9534785348848865, 0.07357815978827047, 1.9471618220985667, 2.534812985389131, -1.9895606459485164, -2.1708060604003485, -2.9433490581811914, 0.6118350896811892, 1.0430650863274264, 1.5835146463508147, -0.3524054901909231, -0.7569641536606195, 1.5789201392446652, -2.5273764850574, 1.604677522720836, 1.9828116811644956, -2.6083553292322184, 2.0788823233156157, 2.5906138049385636, 2.1753884483002133, 1.746766441351046, 2.0767408092873807, 2.682106659194236, -2.681890902730655, -2.386298818015762, 1.6487889874516566, -2.232112559081658, -0.01757612928417055, 0.37398063227863293, 2.526190778334122},
    {1.7526063221547536, 1.2490205306842912, -0.7650537730186343, -0.48150537461402504, 1.91982749814968, 2.290191156209608, -2.1854563807008334, -1.764667671327413, -2.958154005275198, 0.12311627111590832, 0.7674484880379174, 1.5416550156871789, -0.4036064977414352, -0.9889966113210793, 1.5357288252894605, -2.7690504783478787, 1.6983582385272322, 1.4778102277466054, -2.471531178186864, 1.8674495114795906, 2.1173752504225307, 2.148417790525159, 1.2731073363207028, 1.8730788777294887, 2.4320739259674897, -2.3374282230390606, -2.1555859963697976, 1.4964120561420802, -2.305960788551738, -0.1587605131646948, 0.6213545819820079, 2.433156951080856},
    {2.223939460747788, 1.63947695713844, -0.8110601950947878, -0.04536888426555326, 2.1150901844009447, 2.457530074141284, -1.74709596658637, -1.9243168023068575, -2.9979823478011394, 0.43737189023247136, 1.121545938509027, 1.2936540794948284, 0.06705438873529013, -0.5865872591515013, 2.2059791503706454, -2.6677503083188467, 1.6979725363131286, 2.1187306877483025, -2.3109854721650573, 2.255356330329376, 2.513728138062757, 2.2363435266550002, 1.5848738706679675, 2.5863859579977357, 2.4512263056123973, -2.652180680459407, -2.090144594702247, 1.9707703138788688, -2.3202070366041014, 0.052748847653183266, 1.0220420288520078, 2.840420503497999},
    {2.0971716590814227, 1.3006508233192826, -0.8512974520489279, -0.1938012758495827, 1.8341496912882942, 2.097867052932266, -2.087822420347766, -2.14175165791356, -3.1890870698025413, 0.1779020471086192, 0.6906579352642782, 1.4653481419924466, -0.2851990460744888, -0.8409454636670215, 2.059100219703255, -2.64401768639601, 1.7846739107296736, 1.9925749508273616, -2.7968537129031796, 2.2461104701406156, 2.143565018945758, 2.1849479656503923, 1.9768985303935696, 2.1078972972001164, 2.162642083024978, -2.5937909353114934, -2.1860363545964945, 1.733892050505681, -2.320888868291132, -0.5337126166608535, 0.8828103447890195, 2.3115790925387127},
    {2.368658167105634, 1.592549444699894, -1.0656802876145215, -0.11434489907971698, 2.226562014492013, 2.31779149543651, -1.9290425611995201, -2.143372830546622, -2.794667485757331, 0.7510646581572037, 0.7659427499199548, 1.7692569324052978, 0.07582822215550993, -0.5532725464845447, 1.9090379385280023, -2.2989917280605887, 2.3115581813323542, 1.9161614469392083, -2.7174830796936003, 2.3327585007595624, 2.6853480537473544, 1.999379482663467, 1.9197159967488961, 2.1908612831873824, 2.6605493171214856, -3.044007389719489, -2.5308280366969536, 1.8816088986259296, -2.143630464433114, -0.31575913784836335, 0.6691104629415053, 2.7381661520249323},
    {2.257580797901444, 1.5355793986495585, -0.8575876802026107, -0.17883440622942492, 2.225222281313425, 2.2333382675806064, -2.2910309970634226, -2.0550804536980585, -3.0190542605373483, 0.8116809174050446, 1.0462953758552636, 1.1948715475961158, -0.4037532616629976, -1.1679673530068344, 1.8870468768561701, -2.470472977188782, 2.5594705852214927, 1.765578977480202, -2.7644402850256338, 2.3419179727730053, 2.452186249632118, 2.610917643709697, 1.9071067285403471, 2.0307227760020776, 2.4847121878990586, -2.792459734834065, -2.3140655853079006, 2.014137645512927, -2.6667889277961563, 0.022436520564897096, 0.819865917822847, 3.013041338787612},
    {2.403164139998336, 1.6971990596977027, -1.1578776251832381, -0.25854533785677386, 2.5361416094939577, 1.9858534502658292, -2.2532588869637102, -2.103690362349751, -3.1973059622551507, 0.701688927147175, 0.9917218424550238, 1.3850007602831944, -0.7444646638348605, -1.3640353683707724, 2.050329771889056, -3.017467292500483, 2.117689035849746, 1.6806738201852391, -2.654458756333281, 2.035033131696645, 2.561311473804694, 2.5299815578832345, 2.1242037174048796, 2.277063035838853, 2.3224442441012867, -2.8860899710029537, -2.325248848433371, 2.199800291872334, -2.712432311667745, -0.40925398365236804, 0.8589965190957934, 2.6616291185680936},
    {2.1272862338351453, 1.5415595624052922, -1.3969442901493596, -0.20129999855609046, 2.163372950248886, 2.4093931771572845, -1.8824269596461176, -2.116468384032886, -3.0922990452050914, 0.48857608522206797, 1.083758856336681, 1.5238122123412126, -0.2790022781044603, -0.628524820153761, 2.154855974241135, -2.5463095297842644, 2.1588071871795447, 1.555099114194318, -2.620551927018265, 2.3643324097153435, 2.8312141193422864, 2.2139480248868773, 1.9479808399627783, 1.953434704990677, 2.6812424638030805, -2.881525307808002, -2.362790619463327, 1.9667316480950874, -2.0291046732369606, -0.19492091992708618, 0.670479218176578, 2.869062518828868},
    {2.4013847879466317, 1.2197866836695102, -0.8628452479468008, -0.11156136964532067, 2.0153454581961148, 2.4854765154158107, -2.174470395892975, -2.217095348918385, -3.25315923063966, 0.46293655946639894, 0.7066753668103756, 1.347231103118516, -0.5064886058526945, -0.7373200384849338, 1.9947882854046235, -2.755434117612325, 2.2237682423665652, 1.7753835805139493, -2.7523220192399664, 2.441806378185525, 2.725901896432497, 2.4661058359411934, 1.9401246892996884, 2.4469096905133774, 2.5900676166939363, -2.8027023880568724, -2.6484091625584965, 2.0264451908006613, -2.5878225836773407, -0.09514459969049041, 0.42677713851613824, 2.802268139505355},
    {2.5057208846281553, 1.5773332727174871, -0.5948995346997528, -0.014381324200842987, 2.3069059194066135, 2.177265125606778, -2.2178255266738427, -2.417442183178545, -3.091631836301188, 0.6968533308707588, 0.8812034538489324, 1.2130858093577774, -0.1678043262611725, -0.9451803504880993, 1.799650647702838, -2.981075931039219, 2.121080929079881, 1.8883312486540906, -2.9688696839473607, 2.213767952014937, 2.4889293019776995, 2.508156261710978, 2.3210565497081683, 2.36504864197329, 2.6080474814840158, -3.05698458962567, -2.454513309056283, 1.8230985531691077, -2.666724684359066, 0.00715522766665485, 0.990250078832436, 2.7372049411512602},
    {2.1915798700032143, 1.1127265385609133, -1.662723378956587, -0.4721813185639122, 2.280547278595955, 2.310311446976085, -2.026232636943362, -2.3424143336142795, -3.1215018566556925, 0.6270875352805663, 0.5119850466357935, 1.1822216448765637, -0.8310220025538729, -1.0850495681889707, 1.9946313168191598, -2.7847106509913497, 2.0431294926407046, 1.5893112252546446, -2.995353741805822, 2.0828803228513526, 2.5598713138252354, 2.458264875101809, 1.8612333831657244, 2.275184091070706, 2.6601282931940284, -2.7846587660383255, -2.334371774639235, 1.8503716285053151, -2.497963937094586, -0.17639503685988928, 0.29012926247798193, 2.637984688639982},
    {2.211359884424892, 1.3316147819925335, -1.1827733708879622, -0.315951236852546, 2.184915141913137, 2.424261909961327, -1.8670493471495841, -2.5865794556076334, -3.119817572014412, 0.3515824471668283, 0.5311826210903953, 1.0075167951062804, -0.9024155166280211, -1.240995871012517, 2.2184610247484433, -2.902160470276173, 1.9625739184982771, 1.58903216671911, -2.7736120931151986, 2.3610410887057505, 2.4777203930894567, 2.330273735754167, 1.9135914521280812, 2.621867675057129, 2.6473861386255626, -3.0902056834145886, -2.5065733188768657, 1.589750074393167, -2.4864420434909342, -0.2047187549862871, 0.6788367358586701, 2.8103957202140477},
    {2.430249610707596, 1.682704575160929, -0.912495559210939, -0.05422191387217414, 2.1404397504129142, 2.3424491211349294, -1.8992790219841675, -2.3490408492614514, -3.2071670811969017, 0.7291961957215815, 0.7979487407196636, 1.4332420276242857, -0.20612269518413018, -1.2791428915537897, 1.9822684112771582, -2.9319748671476855, 1.9457087569623717, 2.0041626382259516, -2.7729985720814643, 2.3048442288765005, 2.317129938083997, 2.495911326488742, 1.6884048261727236, 2.4190907448359282, 2.457929279682644, -2.799982086028275, -2.54500453830932, 1.7202476937387912, -2.4305576049837625, -0.02578396579308451, 1.0699771976163746, 2.7646390155990863},
    {1.6144649248487815, 1.946435821629497, 1.0011434522325526, 2.189097119208792, 1.3239601413585231, 0.41386395341507115, -1.0071582964609158, 1.1399482988104146, 0.05311338478580527, 2.126888877640568, 1.6908415129549, 0.8435094067923687, 0.06480635437211127, -2.7193586851582303, 1.4393357605585195, 0.2554478835975404, -1.4353990102033873, 0.876374918049208, 1.011369140611146, 0.9980947268933179, 0.22650923523216063, 1.3361682603025782, 1.4914446032647546, 1.4119634838021218, 0.019870038259591508, 1.3876055553150994, 1.7400161752327086, 1.8113302639059268, -1.5880687233907207, 2.2284598410399097, 1.1279792278669516, -0.7609076543497841},
    {-0.18093324497125318, -0.009420968823445468, -0.6947831819148469, -0.12190352638357756, -0.7192274380808087, 0.9177433261671363, 0.39446243927456853, -1.2024942752926018, -0.4167559078998152, -0.2619174193158775, 0.22310626551181847, 1.2544975564650795, 0.14984806856111949, 1.0788695155546608, -0.07685801847033245, -0.6895159139512012, -1.0855050268388984, -0.2708029433855899, -0.8439369353015636, 0.09922863786587947, 1.5784707430019649, -0.21281864559850494, 0.47910862311137903, -0.15973324237993675, 1.2451761033391764, -0.8145871306464026, -0.9762425422667351, -0.18371564703717, -0.0023503629134450275, -0.16804645420390826, -0.6997383325490297, 0.16391514057702705},
    {-1.0006244070616033, -0.6125953685436382, -2.083126929826454, -0.30561325049065596, -1.1358494088756823, -0.10368005818373335, 0.07622248380773378, -0.7193431101842769, 0.35649732084532654, 0.5858022829486016, -0.7900964991384621, 0.7517187114947428, -1.6714307971803835, -0.9482939277040398, -0.9700828430059113, -1.2746604455501174, -1.9452876589478953, -1.5902252015635197, -1.064520911786445, -1.3874464886200015, 0.15567974496643236, -1.0802350367387912, -0.5928469606713714, -1.0128718314745249, -0.3188131901801778, 0.0030003976051579556, -0.3598330245147489, -0.9227029313365526, 0.07954771419442519, 0.8685337581330111, -1.7036550903062864, -1.5292970460295225},
    {-0.3118670630171142, -0.3636915579776866, -1.7917384647063515, -0.45916787183011537, -0.6440547284731316, -0.4613137912726908, -0.47065477319080584, -0.3989922626915788, -0.5686375835185079, 0.29494267388948464, -0.782769349524607, -0.3602042725343209, -1.3618709804628741, -1.3034961487035666, -0.5469088112057833, -1.5536368425382971, -1.2720315108562923, -1.1641734229153604, -0.8288509706746678, -1.2235371594845819, -0.29117930856118185, -0.8790788643888057, -0.6884761814283724, -0.6044634498887386, -0.5926231517472699, -0.517309573506488, -0.40681055230033664, -0.9918028910524137, -0.8048417919320074, 0.4628035207354354, -0.9556831956234193, -1.570997981291834},
    {-1.7002738913123943, -0.9622032241530438, -1.8340352532044593, -0.7533138774119543, -1.1335278663540584, 0.5952520545853873, 0.9003306058747323, -1.1266217555439588, 0.06553768460469721, -0.1025400191192902, -0.8126793162251698, 0.8066168271877062, -1.7030921304029112, 0.3710805705620414, -1.3157528119015056, -1.6533065842494734, -1.3284556450250409, -1.6164063838734188, -1.538824202914845, -1.6012471267239745, 0.7379147417750078, -1.206092737597848, -1.3689142068021054, -1.781124652106978, 0.6606179792865053, -0.9941334436125208, -1.1350606800502352, -1.4973795609484355, 0.238252134015782, 0.6093306758545041, -1.7593183478339656, -0.8878107782983311},
    {-1.0511380752589836, -0.9425045746859742, -1.6377554964640364, -1.3610335418943098, -1.4771614731527893, 0.24504475817495106, 0.565011880540003, -1.502162610057791, -0.5172372682237333, -0.46092453145412465, -0.9132126097174009, 0.6321270311291215, -1.3765518212161636, -0.03279399186022343, -1.282207572100052, -1.4754954653969017, -1.4815882233640132, -1.4107597101441618, -1.2077595649084203, -1.5284968231128462, 0.554489185710636, -1.2969047162312235, -0.8950206033297357, -1.2494639107408485, 0.3450808686011455, -1.228991061752203, -1.4933171737228774, -1.294822463668003, 0.25730595592002736, 0.20907707305003725, -1.0519878918017305, -0.8633769449557442},
    {-1.1215112202298525, -0.7225521058059069, -1.532604885268054, -0.7075461299568011, -1.0232949893674836, 0.32747494511533487, 0.17370495044288156, -0.9329242929902899, -0.2309408646203747, -0.4945749384584892, -0.481145189213601, 0.21015560591480098, -1.068696026423641, -0.33562507150322807, -0.8391272318594712, -1.478926787084532, -1.2170502859840502, -1.1603778193394898, -0.9379094341402037, -1.2772442598156464, 0.30925472098852863, -1.2351057089035933, -0.6413754105625026, -0.8477945862323428, 0.5500231235948342, -0.8362868468475093, -1.029260758156118, -0.6744740735878486, 0.011993939941130958, -0.02288211806357607, -0.9422674896675189, -0.9145721019328326},
    {-0.3151857550765092, 0.008446510756501066, -0.8059138435654685, -0.8514626016037306, -0.49853504268094545, 0.3369036317078905, -0.06281879673889666, -0.6809254062333188, -0.4410023108829535, -0.18997051226933154, -0.6762351783371934, 0.2925123015342874, -0.6440444403091187, 0.030590782718596835, -0.790378622158593, -1.384411572283485, -0.9999327127301245, -0.9730534891866874, -0.9525993802441024, -0.7504682158504237, 0.3228363632299, -0.6671343579955733, -0.47392140397971527, -0.4758125842268794, -0.03056345219698075, -0.89953909776341, -0.8763024285777824, -0.492708977955254, -0.31958631507912605, 0.31541026984837506, -0.8893609424868055, -0.6734856927964348},
    {-1.2182262021324757, -1.1610708324488999, -1.5768953730654545, -1.695094901424115, -1.2347973060402673, 0.5252982029217563, 0.05923805579916764, -1.4134612056413254, -0.1253499384696501, -0.5520989012490417, -1.189551300840089, 0.38524777079941624, -1.439883659343692, 0.27195319476918095, -1.5112662880374141, -1.7077322415555303, -1.343844334257797, -1.391184446766776, -1.7819421319506181, -1.5326586408264462, 0.41709372881492024, -1.5631135856214502, -1.2535535660270478, -1.3029242973382973, -0.27078882408727845, -1.3392523939765313, -1.315409840304784, -1.3488234089732865, -0.24289434985050481, -0.250646626611169, -1.622084377952221, -1.2227193348145073},
    {-1.2056288809072602, -0.40145553876807655, -1.5179453545760893, -0.448637949751075, -1.0879876689829835, 0.647856772202506, 0.8679984960397935, -0.952810495036804, 0.48181723982093316, 0.5224583174849249, -0.022394513341016286, 0.9574494525592258, -1.3928555052091176, 0.7064573352850644, -1.0977564181214259, -1.2990286795358317, -1.7520070071592189, -1.4366239801934098, -0.856459807514009, -1.511660541644276, 0.9682715071722164, -0.8831521210986786, -1.098076994791418, -1.4249429968076839, 0.9467918760018926, -0.5073155785439063, 0.08982685949495238, -1.2768730711166456, 0.6672152146726431, 0.5485611406997899, -1.6050442517990136, -0.5750275962235621},
    {-0.9526974447580449, -0.9113805372293626, -0.9603993843362898, -0.49677453742407657, -0.9030987598714766, 0.16002875105489028, -0.061658926487156256, -0.46897288866242964, -0.00030869820546421833, 0.47616172107746363, 0.10568489194465396, -0.13176998414109342, -1.146010240521432, -0.6587170348204057, -0.6699983741044466, -1.2877080096164972, -1.7144039147948409, -0.4570081000855175, -0.7531894174433418, -1.0612865852858906, 0.015456391825187946, -0.7633566160452343, -0.6879679146380955, -0.8733316602044653, -0.36561536769589215, -0.36854545525896254, -0.4984204405004467, -0.6496597248678042, -0.03313231024647354, 0.3109782397258356, -0.7813891428588094, -0.8035180981373141},
    {-0.7194471810889097, -0.7296719593459919, -1.3163365012936323, -0.7223706357729608, -0.997265162030479, 0.37870151545910125, 0.5115140571942632, -0.5035544946113107, -0.013204538861886682, 0.4667496671480353, -0.24393032865841704, 0.7179448354057293, -1.790489750264236, -0.31009826019304804, -0.3682516065822154, -1.5362831399909533, -1.3049974926706334, -0.7085195511372677, -1.0892551222422933, -1.0962674624884816, 0.7022276302211503, -0.8308386599087595, -0.8645503444666673, -0.5588487936173252, 0.546148131484946, -0.9579801557778118, -0.6492656180156701, -0.9557966511058564, 0.05578574836615226, 0.5416218705665176, -1.1587170996723197, -0.9956887935310608},
    {-0.8485029533458945, -0.12539902961003346, -1.1301438503489536, -0.5368365024708376, -0.710427814799674, 0.19047098744304433, 0.07965650280777856, -0.8139802090121427, -0.3774069809738225, 0.37284045913542646, -0.5964584602130387, 0.796361916430632, -1.9956720623797128, -0.7258607202925901, -0.2698156716573188, -1.3064196688822034, -1.3502108428724937, -1.178815527615891, -0.8686069534149085, -0.9999907248773136, 0.2935773790022165, -0.48982370787027923, -0.42660133306085474, -0.5143741301296378, -0.34001969519290215, -1.1759386542088623, -0.819038836270976, -0.7787198066595671, -0.3843401804998747, 0.19011619972264363, -1.0082853253692765, -1.3852502732975251},
    {-0.8842181921883567, 0.10069110186051992, -1.4803023321024245, -0.16940949712889214, -1.1011703905984516, 0.3635272649294739, -0.0035229151419650427, -1.1819893973009055, -0.17846123082314136, 0.7155267492455797, -0.30680816882565837, 0.7737110142385509, -2.0370026774962495, -0.40258818295163573, -0.5929653393916277, -1.4923923518061863, -1.7659985675800804, -1.3251148706611242, -1.1735272059286126, -1.3539531321928788, 0.25582146408104584, -0.6932929456597868, -0.5008571873177691, -1.3120921817465374, -0.021328396174528447, -0.8034822764564118, -1.0886938104705828, -0.6454814645949382, -0.3605845006564896, 0.4883096013885991, -1.3544841661989495, -1.4101544760315907},
    {-0.7185819557576504, -0.07970511178464444, -1.5822820778034437, 0.19702979007964352, -1.6622532561821268, 1.30006043102434, 1.1783109588840752, -0.8639491061502383, 0.741492477193604, 1.068127338881515, 0.05176457233489749, 1.681771930248894, -2.2909083246668915, 0.5617123717302976, -0.9520393814352677, -1.1657194895021965, -1.7709726858873045, -1.8443544328783443, -0.8297217524831815, -1.855260988658075, 0.9484659098482524, -1.0479711176487077, -0.5977810631696804, -1.0019902710302466, 0.8342534337790618, -0.3044648342679507, -0.07132604658317622, -0.9960762371709464, 0.5907145558756579, 1.4195072138013352, -1.6691985717910767, -1.111981298159339},
    {-0.5813488079443736, -0.05188598332282798, -1.9648234156509166, 0.343400642013555, -1.0125525510086928, 0.8993751169146401, 0.4335246078427511, -0.9201385724856813, 0.15249470225356385, 1.0991146091900192, 0.15827353056898863, 1.0184693567320169, -1.8062969430890459, -0.22011619857066977, -0.4202971247888903, -1.6099155590278758, -1.705123378362238, -0.9917547674555472, -1.3839531617847092, -1.4371332467484892, 0.7285357145838984, -0.5299696241926172, -0.7619138554967277, -0.698283542595274, 0.3602048343146971, -0.4501743138534521, -0.4294792290996902, -0.5196069817132449, -0.17269336041157346, 1.3922433518191988, -1.823952492389277, -1.0748376815920442},
    {-0.6388542753776423, -0.20393990013849997, -1.8249506216832836, -0.2563242582571463, -1.065659659112189, 0.2891534173534263, 0.1585758278880813, -0.5756506919627623, 0.0913292508972298, 0.5156632749232517, 0.3869194326924746, 0.5587137325211439, -1.9316922585090655, -0.6218028596322078, -0.6261472071036405, -1.7220454113923827, -1.9778349193445808, -1.3137743570480802, -1.2286531885661596, -1.7098613975259962, 0.0655419018426442, -0.6540010109207846, -0.6255684843051843, -0.47951565312803235, 0.020149030011576967, -1.3232106395776608, -0.5236086889546154, -0.8478079282676234, -0.3039138624651861, 1.1234766149365798, -1.3871964622778117, -1.246960873153091},
    {-0.35105652423740474, 0.572380016990222, -1.7945473419339297, 0.5281396733987235, -0.6761830678258371, 1.156246017942017, 0.34684886474571114, -0.7144158690882099, 0.029081400977874497, 0.9876322455996394, 0.09410600799192567, 1.5145460538242883, -1.9524147809130465, 0.09256624574634863, -0.24957524952410895, -2.05617052104209, -1.9374942896808982, -1.3208684134977566, -1.44499390385949, -1.3391644163867122, 1.0922597689929037, -0.3945543677082527, -0.46516705416753584, -0.2837562556851395, 0.8549861345273636, -0.5550016163955742, -0.46553539093327734, -0.3378933709428131, -0.01734925659179871, 1.4064631900720466, -1.2154498117490882, -1.1467704726231218},
    {-0.5874088551907516, 0.14005744833310096, -1.8290138591026182, 0.44327953785457097, -1.0781979986307046, 0.5642209742481241, 0.07196342926580578, -0.7321046720139437, -0.23869486732482065, 1.1062218039724347, -0.12997834931782826, 0.580779069974854, -1.8078801230374344, -0.509152617181494, -0.35893646334297036, -1.4905830696563687, -2.1971350773266054, -1.5642010687248007, -1.230065299295179, -1.7372939989740275, 0.14049592172698164, -0.5821254245018505, -0.25941164923851123, -0.5904613035452828, 0.44681522477090213, -0.7832860603266755, -0.8810229573544347, -0.3603058666791673, -0.5358630261610471, 1.4208685250453619, -1.7739279267230372, -2.03134757843565},
    {-0.9797156397779077, -0.42587487860636986, -2.295240915154852, -0.3758513437686117, -1.379569629277475, 0.6678232322336746, -0.04917198487373895, -1.1704466514511727, -0.3717517884615149, 0.6087589108815326, -0.12662677230266503, 0.310785935801678, -2.2375958777400773, -0.8806001899331187, -0.6589033769115129, -2.258922036831103, -2.527071069504067, -1.6227512896236498, -1.4005382835509987, -1.8489874765266319, 0.3117955369393538, -0.9700311144492313, -0.732043410938394, -1.237242643100574, 1.2771537263630722e-05, -1.4629122770417928, -1.0984980567355491, -0.9244771696993265, -0.4307658274888897, 1.1261461862470001, -1.8170706909174563, -1.9528191426574568},
    {-1.3090270375804758, 0.0027687744361470567, -2.6415476929540875, 0.4190180311282061, -1.2608994264788103, 1.2470165325301794, 0.6375479642624792, -0.8659881936434378, 0.03987739075299479, 0.9510528666255349, -0.20092034276323098, 1.3665262455743852, -2.312014383217954, -0.5835011451796105, -0.7581445632623675, -2.222941036816259, -2.339217928156909, -1.7857971912215402, -1.662564205765262, -1.5300324073568217, 1.0347893125502083, -0.7310170276026975, -0.6873809912519907, -1.257046869167981, 0.8794478626749218, -1.2136241170847932, -0.8856615379944909, -0.8831125039096395, -0.27636371204523885, 1.3399993538340305, -2.206589856896354, -1.440863931418721},
    {0.2094692703233949, 1.1553827748288368, -2.2864344774657033, 1.8783223819909853, -0.3476300920457618, 1.7656617446766143, 1.5647578147418022, 0.28223757841189145, 1.0160866480604345, 2.4356863616452986, 1.6188980056368822, 2.3391818323687126, -2.2329150843041448, 0.26547409975624275, 0.7614403493650355, -1.5115650924835444, -2.2500628927893, -1.2706032505146962, -0.40382027230057094, -1.08367838323856, 1.9713760572475483, 0.5608352151861211, 0.6332223867014181, 0.380057624766689, 1.81413876690216, -0.13245063719115105, 1.044653887430255, 0.4910353924933254, 0.9825431574753436, 2.5530437010209543, -1.5697349627228936, -0.4975639965408029},
    {1.6176646364122145, 2.297566693395548, -1.2620430594893282, 2.877935233071026, 0.30739474406941864, 2.1354779280063934, 1.6942483888237494, 1.154220734194334, 1.173233498032879, 2.9551461143188384, 2.5529897522160234, 2.6449662894252683, -1.628702573338646, -0.12068557629823004, 1.8597821734568323, -0.7626360682472255, -2.623410451434868, -0.47569173184469105, 0.5732517369330229, -0.4021980041984369, 2.1473572657827735, 1.3389835828375956, 1.8286338787311918, 1.070992497254195, 2.057398673959258, 0.948166438160699, 1.526006983158966, 1.5226706815677071, 0.5894494472174953, 3.1562974786029327, -0.16389515069693655, -0.2980384439867458},
    {0.6364338790633308, 1.4881073024196514, -1.973460184589015, 2.539231528544966, -0.3078438390632417, 1.7336445329879744, 0.9545256694135414, 0.25769075866807967, 0.684710108996522, 2.5757009139687574, 1.6617231569285318, 2.0895047472236175, -2.1754357359307526, -0.7610818094391616, 1.0949077265641907, -1.488737043646489, -2.83974909200191, -0.971918140227975, -0.39773903806180544, -1.056597911271601, 1.576815760269678, 0.392334510451018, 1.1291818041696902, 0.5363329569279515, 1.1646950064467305, 0.32769817504552734, 1.0405808520427189, 0.8440561003455125, -0.3536487443665203, 2.9243563334824914, -0.7553245410690137, -1.1544172431958795},
    {-0.5390528589311501, 0.14635384124304937, -2.4787194655271247, 0.759443026175151, -0.9826805078381246, 0.8712180710208236, -0.05596967674542575, -1.2763719950082808, -0.1372572204351824, 1.5025461608636206, 0.5760824902157162, 1.148705054150721, -2.46353304449991, -0.6651047508097692, -0.32263946618160433, -2.341966064399073, -2.721184231070656, -1.673308239803678, -1.5789057245456584, -1.7508370489232643, 0.8644039893190686, -0.8476031341153368, -0.07830971267626327, -0.6513410382594863, 0.3697959248960539, -1.0247079434675619, -0.7051455358505958, -0.41308030606362206, -0.8461236857213851, 1.840738539738807, -1.9942778268042927, -1.6250241947808546},
    {0.37799229190953815, 1.4406159536553347, -1.4040345062983228, 1.8039456171279253, -0.12877924349313424, 1.0696013360608567, 0.7242876718255944, 0.38554742671415576, 0.37935172238982723, 2.494650262867024, 1.8005797894723305, 1.983428249832424, -1.7963755169928357, -1.0555102939296606, 0.9689766468690809, -1.4790836680044814, -2.645538709007838, -0.9404787276215121, -0.8799017760881642, -0.7645615168680391, 1.3301833010454092, 0.7503190373204658, 0.7651804390341235, 0.17695620331326933, 0.9489936517752641, 0.29454889691739616, 0.6874839188270975, 0.9511818333703838, -0.2674124959607071, 2.3853184890506323, -0.772769816625396, -1.0918468649489577},
    {0.41300828874241163, 1.7816929494746845, -1.419027119671307, 2.377538491684063, -0.20570877406216484, 1.8083316773818439, 0.999538845715499, 0.4275128770563975, 0.7147702087376208, 2.431670807811554, 1.717494292880782, 1.9410798278377872, -2.480586180225884, -1.0255864068538845, 1.3255907749457077, -1.2513629356719351, -3.2131017374760553, -0.7236986955106458, -0.18092671436063631, -0.9062706184941287, 1.5136413737059105, 0.4358471179996487, 0.640266566201621, 0.5612731051504128, 1.0670733252506763, 0.39759640778723365, 1.3554779665926735, 1.1943117478960354, 0.03079948246598699, 2.6896076912863145, -0.6182126642666813, -1.3076834692154486},
    {0.4988250554607653, 1.4518543096639067, -1.5240744265597044, 2.2645834981283333, -0.29631033632424203, 1.374787178980215, 0.8904123156369167, 0.33541858153506393, 0.6216152932422125, 2.5032688985717533, 1.6150810640644597, 2.1874271138431767, -2.1511616639197784, -0.9714623185803408, 0.924701494660741, -1.5612547803918646, -3.0501911489291755, -0.856734317062389, -0.5856464839371321, -1.0334096128899013, 1.361128597803989, 0.45130770620261657, 0.5168382498587427, 0.4692300832432735, 1.2170324448299077, 0.37265343099586756, 1.0388936539391342, 0.93432008571478, -0.1851142818138549, 2.6045695039117462, -1.0044994357948136, -1.3826534486397524},
    {0.87078777455471, 1.5930760041995766, -1.4032630180435304, 2.3353696205543213, -0.0036173741664189472, 1.6712202615575555, 0.7336931041012101, 0.44101482750621523, 0.42671560692858057, 2.7440204430598754, 2.253432351994061, 2.0291746232491783, -2.0255413633904467, -1.0338001660906666, 1.0415402192528371, -1.4724904163181645, -2.972094209219286, -0.8103225587709252, -0.5896789646479587, -0.8852144128826311, 1.447887747474463, 0.7780481395154273, 0.821827658502668, 0.6480507600207398, 1.2816006462373533, 0.4064079504711253, 1.037718765911001, 0.7458470782507581, -0.2374174233326732, 2.811951772805869, -0.8977915423066204, -1.5134631531388039},
    {1.1092577433648618, 2.0863410039154764, -0.9947561538437931, 2.598100872470981, 0.2880873259144029, 1.809062685431848, 0.8883188960217817, 0.6752939562877823, 0.8725533240873152, 2.7134616224496457, 2.0841476683246474, 2.5647872097264823, -1.534639061918824, -0.8472218193669567, 1.542353978300048, -1.3414090477260332, -2.5709925683601957, -0.10476288221780024, 0.1259370990322564, -0.5308969785185834, 1.577529430937388, 1.1370091462094778, 1.47182566681047, 0.97745837806083, 1.5268954477040333, 0.8062140466850611, 1.7956658502056957, 1.5193829311871905, -0.02703060328227069, 2.9672026982267283, -0.5620344498499702, -0.9519183504157277}
};

static const float b1[32] = {4.079846250623876, 4.075382691213355, 4.235285297424738, 4.011527991557388, 4.054151149873916, 4.312143459589518, 4.490963298631724, 4.226709628980318, 4.195504786794073, 3.863712791072388, 3.9057508169033066, 4.464277267552447, 4.212766978966671, 4.622987859325859, 4.0881546388185255, 4.299025623494777, 4.393330527264593, 4.01101479582663, 4.287763467398225, 4.12034728307117, 4.236914989746963, 4.106439500812947, 4.082528258631676, 4.035843460747625, 4.372378923231437, 4.302372770210915, 4.345552787339352, 4.103908999416058, 4.62796937525746, 4.032063538594751, 4.048071157992942, 4.479322427265741};

static const float w2[32][16] = {
    {3.0196670660789313, 3.5081388993841514, 3.230135330527047, 3.489526358542403, 2.253440219028446, 3.3581286338776812, 3.515117889435489, 2.7785922568327632, 3.7223375147029247, 3.460382012743141, 3.5217265115988985, 3.2340609065509542, 3.384974516399966, 3.0147600651198467, 2.8784818891028454, 3.4713078585101718},
    {4.02117580433905, 3.6550246751445847, 3.1991352010605203, 3.5299906981990428, 3.1002892132340607, 3.6337439536268303, 3.1934561463250555, 3.4828013215764537, 3.6788641467335443, 3.634868312449659, 3.788790339849686, 3.4763252649741703, 3.096256662415247, 2.8525954787079453, 3.019994051178646, 3.318838244284745},
    {3.9818294270268115, 3.751602717851979, 3.784960896149221, 3.3394464328423528, 2.8535510069023844, 3.688057883344946, 3.532332426411742, 3.583781626263995, 3.3905897388758284, 3.8014237147587338, 3.4276018779435815, 3.1385383287612063, 3.411893012340048, 3.3360865990474786, 3.0791253674677015, 3.60846703132597},
    {3.647052627472217, 3.238469290301925, 3.457203899536012, 3.7104092419599124, 3.0446014702832556, 3.528112151302196, 3.707661413576021, 3.433485233139296, 3.848079041761889, 3.901872656820831, 3.7630314159116187, 3.1732574782512133, 3.882896472455578, 3.656554967995481, 3.063487040615681, 3.796862711776072},
    {3.5993352458819388, 3.548897859007034, 3.0748617122890494, 3.694755610961868, 2.8125605038925823, 3.525618101102878, 4.026541548786882, 3.0764103138957806, 3.151561500759419, 3.460743809013676, 3.0882787857017573, 3.03162161144571, 2.8020417811636205, 3.550909322410267, 3.0300313495078215, 3.651702000932938},
    {4.034321184482015, 3.8090033894247575, 3.7331581272968664, 3.891409157383087, 3.188022636334776, 4.110698005427719, 3.867304450838635, 3.994829947257278, 3.9968690032088294, 3.3568083522424863, 3.2802136125712997, 3.990704584296647, 3.8380423045413092, 3.535843606507994, 3.888889725017198, 3.862776697263136},
    {3.787880557406921, 3.759840363152436, 3.9867408203714905, 3.6234165674908394, 3.548405235479182, 3.0665045321809425, 3.3830788631069804, 3.4634575828489336, 4.147126767966284, 3.9686795587176538, 3.7061873971422727, 4.262883356016134, 3.33962121191635, 3.6551656137622897, 3.238572230019556, 4.342128756022075},
    {3.319862260945516, 3.7173368205137187, 3.601010510829702, 3.5467380300111975, 3.3441044631631702, 3.5803628882718384, 3.4432678506055545, 3.637226316276616, 4.095753602074768, 3.825544928572444, 3.470960981466429, 4.078460389516262, 3.8068222472372972, 3.7808760135479225, 2.916831813890485, 3.8872591603912348},
    {3.6456117334666898, 4.353499594996085, 3.485987048908503, 3.669764089919099, 3.3802142288738475, 3.7590519437509964, 3.798017308048805, 3.9269674121297995, 4.27529457706247, 3.985414063535708, 3.9399792958703483, 3.346506436913392, 4.008814763864409, 4.0093290980112375, 4.036346421228612, 4.081994974458586},
    {3.651078801662312, 3.61305875440356, 3.8153974101830443, 3.6422766948641248, 3.3385696682563646, 3.427063720199982, 3.2478134723742507, 3.862905579987878, 3.3069187228880894, 3.625697958268432, 3.726645135007436, 3.6928255777310373, 3.3840266814243045, 3.563252040376483, 3.28264959351461, 3.563604298648274},
    {3.412306456474671, 3.3667830713960023, 3.4338562574317586, 3.1953771198351015, 3.268407814615473, 4.017815524373439, 4.084902948377719, 3.4485524054234267, 3.6138131152253217, 3.1497267555536617, 3.6346861148504255, 3.739748068394007, 3.0983427548312132, 3.925122209511777, 3.0378880320620865, 3.6169477024071077},
    {3.698920924475865, 4.00950866939721, 3.5436648940435105, 3.779536843446749, 3.187775809889182, 3.647750580561736, 3.935244432722979, 3.7330711235916083, 4.191850982678003, 3.991739133614892, 3.8798149227548224, 4.258363166567287, 3.923508399691446, 3.4372545874597753, 3.5231203331504735, 3.981934809623451},
    {3.2394630651384246, 3.481053997123874, 3.6294497678052986, 3.0084448657407115, 2.6155237035147314, 4.122279337760568, 3.69502055943842, 3.557771784364233, 3.6531189897708005, 3.267997257199668, 3.7184219732311035, 3.6734902603524873, 3.333985146645383, 3.58754101468415, 3.4322353984500005, 3.7443461654425567},
    {4.1704378538105775, 4.7093375063605265, 4.127621030298602, 4.309263949433451, 3.5287235057798294, 3.9218778749630947, 3.79336705787055, 3.9097889161249846, 4.265359934975751, 3.9390052289352515, 4.031149580318478, 4.301691547120235, 4.051429227619274, 4.2835916155397245, 3.755707985817921, 4.334250043097026},
    {3.330433559127012, 3.4387313043580514, 3.494993940022578, 3.4421474603679987, 2.7537407679239503, 3.4395799450210442, 3.836804723995212, 2.973817087035142, 3.0781395481785236, 3.400731371481563, 3.2455069009408097, 3.4783712711927945, 3.0298980478334387, 3.501233039182284, 3.0810909174243153, 3.472707681350725},
    {3.727237549856035, 3.767699720951017, 3.8216784470357203, 3.778274510728726, 3.6145832963895685, 4.146516086000416, 3.862841909989209, 3.9900324825380555, 4.171265180499324, 4.084907778795795, 3.8952127519747943, 4.395598835117811, 3.8819689322287183, 4.072412763193567, 3.6382390562103386, 4.158737968083817},
    {4.106505856560064, 3.709032163088167, 4.268631809299435, 4.119470745202816, 3.833947697532572, 4.175838998954747, 3.821734908558172, 4.594878120090648, 3.582834167196363, 4.109579570793892, 4.209590777834582, 3.807762224389857, 4.391182903954619, 3.8285879948202215, 3.553372715712563, 3.8540290570884492},
    {3.4184675619392944, 3.621839380129824, 3.3128892149472486, 2.83541892512034, 2.4208829831501086, 3.6311825763244983, 3.417512447850724, 3.6604820580988475, 3.5309396327615685, 3.1985069999531293, 4.04036182117131, 3.5055746367993184, 3.5446593512439764, 3.5582577454366, 2.6644655187655313, 3.7223369743937824},
    {3.7186796085649747, 3.3157843505177063, 4.25572291488306, 3.5704393000052357, 3.6584363108620317, 3.7182399492538045, 3.6454100477271054, 3.584414803507497, 3.6884931748410934, 3.7080460694996233, 3.9004032017175767, 3.7474080665436618, 3.71155508751435, 3.7114541450332332, 3.4144946286331908, 4.115938485388302},
    {3.3038440328111296, 3.9054325667049317, 3.71282031737567, 3.2555146765673784, 3.412496299480122, 3.9585693038506142, 3.1834541246953827, 3.8166181667605708, 3.749865886982347, 3.650822245436701, 3.8043926671889277, 3.362420588097452, 3.757662237171697, 3.342859191848849, 2.7022926197091612, 3.7413648386514478},
    {4.060222195507837, 3.936054612624205, 3.9275070030408408, 3.7102256237486966, 3.5770160309491392, 3.8875033444784814, 3.8855496572834047, 3.7059551745776362, 3.5208968999124113, 3.5412843916317485, 3.6283438566526423, 3.802244380716764, 3.568898522654301, 4.232786687380268, 3.53226880468429, 3.8036605126044343},
    {3.2160498638645336, 3.0455184037723475, 3.5485222319455527, 3.520855557057488, 3.142380357003954, 3.5656248291606367, 3.594890876041736, 2.9850106719815317, 3.575309939006891, 2.9723875323872644, 3.5941515950968426, 3.1076233970018143, 3.056240680890762, 3.2598172486563297, 3.5099127127577647, 3.8871183239454887},
    {3.325171476276295, 3.516623623500269, 3.763572002505936, 3.3070147862041015, 3.1694491521135357, 3.6322506778812214, 4.012986922961986, 3.363539896046562, 3.4341783319393655, 3.5894651923653593, 3.1438921664278814, 3.0443748491722102, 3.182701048364697, 2.858372752026135, 2.856172924765982, 3.7550861109814884},
    {3.076696129126091, 3.2538392068993716, 3.3921596732908497, 3.6705383286367153, 3.0230322054601078, 3.986341123632966, 3.1992336990063706, 3.6303434706921025, 3.2265216455791417, 3.1470601542003678, 3.1562841435791626, 3.327348289818008, 3.4161725157917373, 3.398742879636086, 3.389508488876032, 3.5282564661240876},
    {4.008825557519018, 4.200555389270341, 3.5460463243880618, 3.5743867419427553, 3.6553300876508694, 4.057948589135036, 3.9527219031071716, 3.455708721950224, 4.213738121154926, 4.4117669602667196, 4.11138003402625, 4.539648662185364, 3.707278971771523, 4.085607791538253, 3.735810135780094, 3.948681812729902},
    {3.918062224986411, 3.636039569652578, 3.8893110753611095, 4.032555600006377, 3.561083358186638, 4.123555591058142, 3.7058320701154916, 4.0034404624624775, 4.4493192579047385, 3.541466922040623, 3.7034603551753973, 3.6766091795915994, 4.142237017468128, 4.174556084865934, 3.6138419134255932, 3.700291090977921},
    {3.4858651774529803, 3.5717111523545664, 3.461750872292465, 3.8545114543881365, 3.2221212504124708, 3.619007942809674, 4.214423302631292, 3.7627838920251566, 3.4513115330989734, 3.762030864015213, 3.48488361120064, 3.925132321847898, 3.3470563734178227, 3.5589703901478997, 3.4203164077026202, 3.3513381771272943},
    {3.192772114717738, 3.546036804491704, 3.246496283752085, 3.4656318987526236, 2.767673800762095, 3.593649691574409, 3.1151060697169934, 3.503540726946164, 3.207734089084137, 3.5935743194439933, 3.339192285136371, 3.170137091604649, 3.154660723783647, 3.0571661957961282, 3.0032621062435587, 3.178310855260619},
    {3.6660216069449683, 3.986067909969813, 4.061191123202185, 4.227994777773518, 3.100387577397061, 3.840840944056336, 3.885327804479637, 3.9502092020911572, 3.8648420363375986, 4.086180431451275, 4.25331332972247, 3.7532021469947714, 3.6029248910152263, 4.365456366999679, 3.095420439430454, 3.730344714358822},
    {3.7127068903813796, 3.4527838634644694, 4.102451159047841, 3.5794620848412912, 3.4076845812405105, 3.7519461508515923, 3.2871749327726683, 3.445410669586942, 3.198542429550555, 3.9658006332416833, 4.193859858304155, 3.8771920262805835, 3.754705767529583, 3.9968048186122362, 3.7964135941422783, 3.9788227339574647},
    {3.2211902983978615, 3.5994376523153524, 3.3181872050595764, 3.252451333196209, 3.353096869301379, 3.4591337153414807, 3.1325644587427512, 4.10124737201094, 4.027538507632476, 3.6297398068900883, 3.6941933003948164, 3.5158154805957307, 3.5064963302194476, 3.3020179126340206, 3.1224649222978593, 3.240466619743153},
    {4.1570482109600055, 4.603933044314577, 4.005561216418577, 4.252615490141999, 3.5235732584876174, 3.9427540200206277, 3.629697814772628, 3.6273232295867768, 4.044720862311434, 4.579990445249898, 4.166062836413418, 3.4359634124976193, 3.978280008219815, 4.011782159222067, 3.723900427562309, 4.325243906542429}
};

static const float b2[16] = {3.5237474080468285, 3.55066073757864, 3.5150053764796763, 3.104182914436795, 3.37205816370185, 3.2198395056653513, 3.3318667515722513, 3.3837290833876246, 3.453426583261192, 3.3123501101662156, 3.2959159289233124, 3.5202500494175135, 3.3839454241296405, 3.5230742113288565, 3.474354568119954, 3.3498770154382633};

static const float w3[16][12] = {
    {-2.872389621789185, -2.6677748166157813, -3.1775893210849913, -2.582103611272829, -2.974879598616381, -2.382068854031517, -2.70698760635411, -3.0458002224380745, -2.1526522062111533, -2.695566672164373, -2.7946560025813247, -2.43458452921023},
    {-2.6823048088057253, -2.641750646458817, -2.4580052254439826, -3.030209836047258, -3.0580020589951182, -3.3869239513786207, -3.0090652822793555, -2.411877081898194, -2.8958228475605345, -2.8671795301465663, -2.8337166403491914, -3.031632457889316},
    {-2.9598235773737085, -2.5399818851811444, -2.903249719803649, -2.6965941860244276, -3.027201084319618, -2.471543907186443, -2.4198219295283425, -2.9844066541077354, -2.7021911184647687, -3.218293624503774, -3.447696434096617, -2.689284218459423},
    {-3.2372294306186307, -2.2017154651997846, -3.2449421743103666, -3.541619663489063, -3.4081746620001283, -3.0978316770012837, -2.341169170795229, -3.0895576847591233, -2.895466839539531, -3.1219143382168615, -3.1310988285744092, -3.2795663974298472},
    {-1.9444877832258642, -2.430321203209327, -2.544647371124881, -2.7388543962332217, -2.028178983498829, -2.645151342220193, -2.779441111204422, -1.842655713615608, -3.072025433370757, -2.7692593090101885, -2.5664963442618767, -2.800159675618278},
    {-3.2361509141512452, -3.1477323565510003, -2.504571774546816, -2.562594215006597, -2.632693068403996, -2.8773534111871424, -2.6309643292868325, -3.2269334741705538, -2.556419135874543, -2.963083946151004, -2.8247269567723436, -2.723486379314524},
    {-2.0238701889141533, -2.5938045163548815, -3.043264737562322, -2.2272412766737952, -2.6963467113763846, -3.136846035394115, -3.5565577818231406, -3.7726035147373884, -3.232189781846086, -2.799788723752351, -2.664641404482768, -3.0156684489991923},
    {-3.4248276386028493, -3.715053989570729, -2.262268017584712, -2.294777876274883, -2.5721643629126265, -3.2762458845032474, -2.603737364810067, -2.6970571339481815, -3.3030702618320293, -2.8967479630968054, -2.613317450248049, -3.0991741552526313},
    {-2.883056632086359, -2.1611698323453368, -2.7061229601055707, -3.1158660463053676, -3.377342367889428, -3.1885219126231226, -3.3686141261120803, -2.5333205488717856, -3.0012999707237826, -2.5714792620442433, -2.113204206915979, -2.562088739645456},
    {-3.1839238104615, -3.5250566901042473, -2.6461891775104056, -3.038209624110155, -2.194445976566357, -2.606216744345865, -2.917266769744692, -2.5397116841431013, -3.0715759935430538, -2.4332802033027763, -2.79213169015224, -2.729982310485273},
    {-2.3632247608847843, -3.0743219320694837, -3.2267268328296734, -3.1405021834601774, -3.0583927065305496, -2.673184496190161, -2.1995652263170027, -2.9860843704588986, -3.090424959285417, -2.6786651278872595, -3.1938868534977125, -2.7882457268755494},
    {-2.882792306286873, -3.0613155201887814, -2.422828508177279, -2.763955201975617, -3.2097077253220894, -2.654417343311503, -2.683183294101587, -3.1289157258717393, -3.1417839337090583, -3.539015640070063, -3.0182093988896703, -2.6597583637046824},
    {-2.9096919713100036, -2.1101294930898757, -3.537361673748552, -2.960847050039211, -3.0425959179000106, -2.4936925613496896, -3.1230249650151456, -2.801978252724121, -2.4270042348594107, -2.9101908324633774, -2.658964349823957, -3.3855310070480074},
    {-2.8971959231452318, -3.0401380145131998, -2.850799203126501, -3.3764889568667007, -2.9588157361933267, -2.7246578341776853, -2.7790556503809016, -3.0040185263002526, -2.762084424437154, -2.460703465230247, -3.045233957899224, -2.7844646854472095},
    {-2.6657101602005553, -3.006761317812629, -2.8820660458301224, -2.619636002004813, -1.9433486364424049, -2.0887427676296935, -2.767583744897653, -2.3638288822293325, -2.463747553984864, -2.473821531577081, -2.2825749813471594, -2.7986586702232468},
    {-2.6566052001113514, -3.1215631576752085, -2.771229700280872, -2.4648244491909415, -2.8140675390595535, -3.264107497686722, -3.2313455902447945, -2.5456773419910568, -2.414029550185241, -2.7043038110623194, -3.0673528754678596, -2.3460825813939934}
};

static const float b3[12] = {-1.282657703343622, -1.1715842430346675, -1.2435393631848024, -1.2580880128800582, -1.2417468892016381, -1.4067253962372959, -1.0800355109455837, -1.3407242615698471, -1.4844961752427135, -1.2112259878877822, -1.6574990346844558, -1.153486565769143};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
