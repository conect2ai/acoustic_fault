#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.11174886059251679, -0.14981487691458503, -0.3527278497318537, 2.2056773272299264, 0.3992959952808663, 1.9811482956389987, 0.41677853713897356, -2.3193694561190767, 1.0356438106947825, 0.5352670334134689, 0.5986092136291057, 0.36377874592498777, 1.8848031498450708, 1.0695159455959877, -0.2527868443059163, -0.25122178682169616},
    {-0.042063209836431845, 0.443045419992099, 1.3062653890009661, -0.9205063560254856, -0.9194974165077346, -0.4552235524440248, -1.3146589118798369, 0.4130618464322445, -1.6073973665378036, -1.5329036289269993, -0.7751863462995222, -0.8311665841498557, -1.3945652979443979, -1.306019542251046, 0.19757205018980872, 0.5587731742491903},
    {-1.2468488477285, 0.39354897500165215, -0.16518501402262373, 0.059954072765207186, -1.6732331928705326, -1.2946707135167126, -1.1200616449267229, -0.6739744879080654, 0.3652082066418061, 1.0771571019225838, -0.3812617003339762, -0.36331514315920255, -1.2216098563332765, -0.9949791519770624, 0.8163143042021178, 1.4761394668290138},
    {-1.9659092439494656, 0.7755415607660098, 0.12529749446034305, -0.18843423802342063, -1.6957777157612626, -1.325995919735616, 0.6667298872932822, -0.43045849319802293, 0.5066681069952154, -8.343152425148799e-05, -2.049474992923773, -0.10163880479049504, -0.7685048816480907, -0.27586302568809945, 0.4359866299741753, -0.6230370816514287},
    {-1.643426364882972, 0.8547572062979175, -1.2962583025871353, -0.4072351901166043, 0.15032596440124224, -1.3876170100174468, -1.2408477406413336, -0.049600586343979854, 0.01839476823236277, -0.8416160493594751, -0.9167366890992827, -1.0419268214238229, -1.7481663824432472, -0.9239764444441957, -1.154181512185507, -0.7269091151174302},
    {-0.5247515722143075, 1.6972331782394317, 0.14232046570788964, 0.08220856103228408, -0.3148578656791044, 1.1762855619856516, 0.32264063198999654, 1.8476481241545393, 1.5262561983353058, 1.6007471956291606, 0.06958853596098893, -1.1271264842111208, -0.5432371422912765, -0.2847954822676845, 1.4373408849817604, 1.7605027441488557},
    {-0.7691410306005048, 1.6617437629675242, 0.41062378987976395, 0.433877461829928, -0.6118986974861437, 1.8459923704988426, 0.6127554152290667, 1.1580771332011164, 1.6244556207582093, 1.5592140015248261, -0.6194301575567183, -0.5569693749244474, -0.1942859223903566, -0.023610466093830478, 1.6485683721192579, 0.4361720527450247},
    {-0.3539006579438524, 1.07663682669474, -0.49309061584986685, -0.549345049281973, -0.08894844470143459, -0.9663646547865778, -1.234193277542748, -0.5662354217986286, -0.551349903041935, -1.1381985689165983, -1.3552076751577116, -0.6027080541277479, -0.9874392822453405, -1.5597726580843765, -1.6137746546895353, -0.21269679447495007},
    {-0.4204017808719014, 2.0871811297934495, -0.06590138930950812, -0.2989303476472787, -1.581915204606648, -0.4572353595636632, 0.770994771986418, -0.5876756195349778, -0.3636901371832087, -0.2449764946619949, -1.9188738726609131, -0.07502101066932232, -1.3711189073699217, -1.119114151628321, 0.45859720723355035, 0.2783899070337981},
    {1.7115981506285909, -0.07843884317085162, 1.9896446213142045, 0.3024322003629083, 0.5642787227569837, 1.174337892407204, 1.0975026706201951, 1.2493161681856972, -0.39867836123371797, 0.528953904403187, -0.2934989906380568, -0.5988828403214531, 0.4949050372600766, 0.13925320500806046, 0.7256680627548305, 0.7700704978878684},
    {-0.7676214432689833, -0.41828706481679273, -0.8560228076374278, -1.34821502205667, 0.2870377769961369, -0.4012471962158716, -0.11029622049788394, -0.021695529319568193, -1.2634499156460557, -0.4531588581562356, -1.1446823565737188, -1.009684110936319, -0.23927126374464575, -0.9592573691656516, -0.9208511023360777, -1.0541763239847843},
    {-0.610479045958913, -0.8506243933984253, 1.2660984309779435, -0.19047788669359247, -1.992986250211974, -0.010804475111086774, 0.38370701426462916, 0.17337050525885062, 0.830593329298892, 0.6741825078794648, 0.15146194113118422, -0.9151691810566389, 0.28777166060033504, -0.5443976736494552, 1.7115705892640196, 1.311346769070039},
    {1.7675051030102444, -0.12153386590097777, 0.6317970567125961, -0.4226143008653934, -0.040507690912688125, 0.7753995889855333, -0.09308461675438832, 0.5914177250728148, -0.3458214939050373, 1.3421215604215393, 1.2639486657140997, 0.3418063968558564, 0.05138968542143601, -0.8502282984555448, 1.1581706464471442, 0.6234748051706707},
    {-0.9528881119710932, 0.4279890864113126, 0.21485635228350247, -0.6754635654891825, -1.3655994297778158, 0.8900670030617703, 1.1957844723067153, 1.2808696047787844, -0.0595687394611984, -0.04085197200033694, -1.6720395200890295, -0.1277804198712444, 1.0819534092968837, 0.7772496655695235, 0.33154314358245646, -0.04144320543064319},
    {-0.030214113107902296, 1.368238607508283, -0.6553814131107091, -0.08260270357599567, -0.8539875420913173, 2.0821180029239663, 1.645954267720258, 0.8409737949402024, 2.2013385004092894, 1.823388622201933, 1.3751786098550527, 1.3829055788781974, 2.399514374618709, 0.9001122569498268, 0.8779015202653938, 1.2378312814359662},
    {1.6047110392591941, 0.9075362620629744, 0.3064243483682895, -0.8089953494210617, -0.817965815934527, 1.5644567004353271, 1.4912712953001226, 1.142720767900101, 0.8754342667280077, 1.211793547277441, 1.451026545969552, 0.9776619727213786, 1.0333780963343884, 0.03004842025337302, 1.1901756618886183, 0.92639967586809},
    {-0.9223465824561118, 1.8160201578879807, -0.4745861346917065, -0.32348421257455917, -0.4636378518166439, 1.2620635861314478, 1.1631862190262647, 0.8453416014904083, 0.030569735225049924, 0.021692367316467655, -1.3601119186594859, 0.7862621937619132, 0.9332133659204517, 0.3862293212080564, 0.06109128416932766, 0.3700296104496455},
    {-0.7925130701027137, 0.6111131807440379, -0.31625456972818317, -0.8712017878074898, -1.1184070586469719, 0.19772534920213308, 1.0165466970268915, 0.20463462299169327, -0.140221477798628, 0.11807544219798502, -1.4668275097619121, -0.36469364143971594, -0.008244482200006287, -0.25983904388542595, 0.728133424747716, 0.21998401356922823},
    {-1.023654393556748, 0.5399040160960086, -0.6034057499955653, -1.148726953630214, -1.1560724328688288, -0.9756006559524514, -1.2091031491132234, -0.7916031336668792, -0.5502861808960294, -0.9784455313993637, -0.830770741856983, 1.0510987011728745, -0.5341830682289104, -0.8324652844242488, -0.16942563365339766, -0.840175039025389},
    {-0.2223071657526957, -0.285199218693288, 0.5922446944919401, 0.43113118581777665, 0.22688503752305023, 0.6561761850674667, 0.1543472310561564, -0.3386534557113847, -0.0008661173180669391, 0.25760590642237685, -0.7133321438896547, -0.3805367796567983, 0.947622863027786, -0.6902205791375117, 0.1770915908470976, 0.25188224789771896},
    {-1.7774859328133716, 0.6946528355883952, -1.080355988336797, -0.68023667880937, -0.7971470088641578, -0.8751322120572583, -0.48920840015022204, -0.7603268102086407, -0.1344343347281954, -0.9515466232533127, -1.0779876930493844, 0.3805679459717189, -0.07629353550760593, -0.7130156663502664, -0.9994768915150238, -0.9346668933576481},
    {0.007380302845254573, 0.2745631715732756, 0.14477362530046683, -1.047104727913131, 0.29874899656558795, 1.0589385624918684, 0.6066739571217035, 1.1075110195883704, 0.46710955786189784, -0.517237947937585, -0.9826654602159327, -0.11912442184530621, 1.4837417895000444, 0.8200589848658725, -0.7402695162110833, -0.6510759733024405},
    {0.37400976581837947, 0.08541415024022342, 0.7597328588688478, 0.4960899733189068, -0.3181926706283262, 0.11541791194642764, 0.538188608449736, 0.7224843081759341, 1.254367339174357, 0.7595325526173039, 1.0868617500950988, 0.9226204219634048, 1.8156846876973212, 0.6836917391591786, 0.36179422373497866, 0.27339656578635546},
    {0.33972290430684615, -0.48668450988458745, 0.9073843989464725, -0.6540301478674979, 1.4328212217197545, -0.5813985623839837, -0.7344118033901506, 0.8329612400149946, 0.6575465431655796, -0.7220843151183737, -0.2819595773474277, -0.37218401875120105, 0.9058632259907062, 0.35599468801542283, -0.4914072283364714, 0.09484765689240461},
    {-1.352896761186878, -0.3582156055846767, -0.3418240386844193, 0.2865852809338474, 0.573556973148484, 0.12953070009663692, -0.9761134204348578, -0.37843594497074945, -0.07113196992054242, -0.9566730589555784, -1.00265803147496, -0.020037654853718893, 0.8931144983799143, -0.018659881875725013, -1.0043222835232368, -0.7681294549483152},
    {-0.9896778677648647, -1.0753060333277202, -0.6388130427880062, 0.3462078095170997, 0.5997468807495592, -1.0566350281165522, -1.722447062460517, -1.4329338997430754, -0.9067316433385358, -1.2330210404647775, -1.1646259958916865, 0.7142012981333669, 0.21380024988606383, 0.34664363332148945, -1.1085308942812653, -1.003471433612569},
    {-0.46035357988490155, -1.24733701007539, -0.2586752683470331, -0.7695198702034932, 1.5904107954830966, -0.3771942188758496, 0.22650990362183113, -0.3288886027883395, -0.17224994439046068, -0.7564507237004783, -0.1756381928047655, 0.2332639082173657, 1.1769290652042352, 0.24323894161243728, -0.4473942454304037, -0.9375180270265532},
    {-0.4508756287287539, -0.6551130796413219, -0.745222880587902, -0.15033952911281376, 0.7872188777202522, -0.984125064619984, -1.9225526072746715, 0.11751286245272607, -0.49661829382019346, -0.9953903368061932, 0.31571586657154915, 0.6650474544360631, -0.3461805644529422, -0.14261036086829687, -0.15785059057857584, -1.0635456397484515},
    {-1.2405826289137043, -0.7719006184053999, 0.035659900571063954, -0.7147702221376915, -0.17692092562600684, -0.9752141870041747, 0.10570082282047134, 0.8749430340923321, 0.6937567192178913, -0.5646546181043066, -1.41660227684046, -0.6852467515071595, 0.15446845824826239, 0.5213023574109359, 0.022540569920535117, 0.04274391126478881},
    {-1.693467705035755, -0.09272730206931382, -1.1864459937677736, -1.646434319474451, -0.6191445052746284, -0.8667034669124007, -1.0745775350732476, -0.20404887983153797, -0.34116035145685414, -1.163368379405887, -0.44554481854245875, -0.3236336772682983, -0.49387646030748045, 0.2676909171658826, -0.7752008565582003, -1.179355861489725},
    {0.968033633604572, -0.5673485585157585, -1.7598093283913843, 1.5428016655794663, 1.2794971839955047, 1.9172883224863213, -1.3874363177183975, -1.5974257464047175, -1.8517248854778723, -1.7092397728547981, 0.4974664715743683, 1.2746009400626015, 1.7561350412245214, 1.5184824857685377, -1.8695412737700494, -1.3446043362706157},
    {1.2611058584941792, -0.324739960361968, -1.475142074163646, 1.9121441316547618, 1.3057427793214302, 2.1944137380407387, -0.8392280445969367, -1.4660629436213835, -1.487038589781924, -0.9700844923129397, 0.20188150152908613, 1.9045901320386533, 1.905443351445837, 1.521549486963974, -1.4306731787570983, -0.7938366777452155},
    {1.4508479226311437, -0.414530758866088, 0.045391484331599015, 2.1639703364661353, 1.5817546822562056, 1.5784436080728061, 0.3081527420760903, -0.40752183472719455, -0.7639400618555706, -0.04565347347855328, 1.147659747260746, 1.2135830438987494, 1.716962823204277, 1.4075772254596404, -0.28069147587028187, 0.23750304864713204},
    {1.3661984206840587, -0.6644081140598489, -0.6845895912751183, 1.564873302567282, 1.1388743540671045, 1.4105892264692215, -0.49938937362842833, -1.021134260323856, -0.7623909126024616, -0.44265948735926564, 0.439200717101615, 1.327493926019184, 1.318631148734144, 1.2866510845112311, -1.1116416757836605, 0.38787871270930824},
    {0.7755209965752938, -0.013934404417896527, -0.3870960492662637, 1.706210070658752, 1.1945394959778677, 1.1940001950919195, -0.552515055212869, -0.4955283817676672, -0.5845504705105962, 0.14027680533777898, 0.36893421641886887, 1.2115777906589245, 1.1910101606694643, 0.7298194274714138, -0.9326146482852418, 0.06234679278415068},
    {0.6197398448622967, -0.33598496278042844, -0.30767302797478313, 1.8157942682346582, 1.1189598270477723, 0.8945108344337179, 0.2432828807580083, -0.45514019574638404, -0.37245457297073364, 0.0008553130448016957, 0.8338704560169306, 0.7285122165319787, 0.9922557510040093, 0.864712950108659, -0.6451919951313054, 0.37276383957254156},
    {0.5138016485763245, -0.7520427234069706, -0.3596775761399439, 0.7424981575599171, 0.7044045289092477, 0.6000931837373855, -0.0482191038126801, -0.5137457818872981, 0.03098998183604897, 0.15224741049843676, 0.4992467780491832, 0.3691965761746489, 0.4091431909762746, 0.7308259236179598, 0.0734954631624813, 0.06909315790210234},
    {-0.23942450218374453, 0.062104408331050444, -0.5289584758076842, 0.2515671834729589, -0.37406127397638256, 0.07453749254441606, 0.014078988091404423, 0.38449704800180967, 0.514179666938461, -0.08981438106828936, 0.30532937616428063, 0.27769798445370697, 0.03970800327436064, 0.4321767067673296, 0.11370709008662062, -0.004399355551570844},
    {0.4250857196291969, 0.04082998843374867, -0.7894053870882756, 0.9222823956125556, 0.443040346420321, 0.42915625813729613, -0.4227278652016876, -0.5591083923702179, -1.0321877603343637, 0.13941094603679496, 0.37719328730306745, 1.239937538123107, 0.538215893209617, 0.8855946995919363, -0.8990225693716575, -0.3693249089632977},
    {-0.5324008123271351, 0.08114713825910828, -0.08213916972871742, -0.17952937196907814, -0.6332188778800741, -0.17940589344901967, 0.027186808042903902, -0.04815093696434732, -0.15173285095628627, 0.16249714878058882, -0.23204391218178855, -0.4481667134198318, -0.6377296549730064, -0.5654684707203634, -0.11685962186067404, 0.2106626513016699},
    {-0.28662110762424725, -0.5801731378423771, 0.8859674866754357, -0.45855696944854524, -0.5295834769502218, 0.08743935393527055, 0.0436845346521233, -0.25899633673556843, 0.5174594830924888, 0.5323756834442335, -0.261035853486012, -0.45180135074684624, -0.12465163750407213, -0.3634765523477475, 0.6115549252192786, 0.6176232231831703},
    {0.42392259163352963, 0.03479096875398673, 1.0887134073809472, 0.11266877651378077, -0.21286947730922928, 0.002169664187714696, 0.6135840508490029, 0.45255697305112075, 0.786794585536718, 0.3851804485851729, 0.6789371883573965, -0.10162866391752289, 0.4969948256226715, 0.155607040122372, 0.38178824806356093, 0.774486242542476},
    {-0.368057360096238, 0.24899968074072693, 0.35048038265154147, 0.2798446952860479, -0.4266375130116626, -0.15366689170835945, 0.5242678539328304, 0.5833189288126103, 0.5955679880152385, -0.040340390269489323, -0.36745868932751835, -0.08242592196070188, -0.023703726169867084, 0.18955589932046452, 0.5451190340691896, 0.377232358850734},
    {-0.35465237847554915, -0.04642148778006679, -0.35132310162037517, -0.4175923078939947, -0.47779626844865963, -0.3621175116035186, -0.25014311875510015, -0.0584768566143041, 0.15146732786616524, -0.5317700108784973, -0.012493271790766224, -0.507293152502692, -0.512917701269851, -0.17297900648130493, 0.0655061048859376, -0.15606698859270252},
    {0.19857014378975804, 0.1710310840388478, 0.1024478552148124, 1.0369893239847283, 0.44386503421907963, 0.41430576592545815, -0.06611875899358795, -0.1905828949026956, 0.4350748443405929, 0.3031804024137633, -0.06849105871249653, 0.5500164063000004, 0.49140755892759763, 0.420853070444048, -0.15806749764254074, 0.41948811337513764},
    {0.6457892064821018, -0.22276633156597508, 0.04451978499072236, 0.43975830465755716, -0.12341332921593627, 0.01755901727693468, 0.16663835850842204, 0.12506451837365334, 0.33760747931978285, -0.11468157424542869, -0.16853815068327324, 0.0649334074096959, 0.4315525561210642, 0.08268286606619384, 0.15357500066774082, 0.5824813824291124},
    {-0.09807820357552312, 0.1950813362235769, -0.02155173375978351, -0.13180354662392801, -0.8740838929508691, -0.9078863638034262, 0.11516990928563728, 0.1790402329682809, 0.3774249510311258, -0.6759682953709394, -0.3633476439943877, -0.1422566948650759, -0.2938763868684699, -0.4645403714790145, 0.19136181983945355, 0.05794059468166181},
    {-0.9900891698570127, -0.3325850278412466, -0.6835728809329028, -0.24670952928905138, -0.47861264468996684, -1.1930964039837504, -0.49932328530879144, -0.17912194309042626, -1.0581395071914406, -0.49788556973475107, -0.5397666747813745, -0.6243875912320777, -1.4352257707187026, -0.8356768850951437, -0.5353324196271502, -0.2687408436603906},
    {0.7914859636309326, 0.2493846402937486, 0.2011994061155889, 0.8283590572787212, 0.309217302541, 0.2453809521683227, 0.12548454920413957, 0.12608428002000785, 0.15230251579661036, 0.3750217568366289, 0.22141123498384416, 0.38149640513823996, 0.4851125252938809, 0.28176159940848255, 0.3994194664472614, 0.6892902893293179},
    {-0.5130445566224644, 0.18433719184403777, -0.19380589357560127, -0.11402315285789612, -0.9804272757365642, -0.958652878747748, -0.10817711708330563, 0.4003937987081855, -0.017879493518248087, -0.022398412716287692, -0.12067074251195015, -0.8946524428898829, -0.6920467770059413, -0.6722417503113602, -0.015399394952749152, 0.39954377345698533},
    {-0.0456086046502609, 0.16110836424916447, 0.43954732281081266, 0.36536563074174283, -0.6909777157370308, -0.24227251957695162, 0.41121183264493705, 0.31431463524469944, 0.31517359327617317, 0.11847233312713773, -0.06800625984242568, -0.5765494149481969, -0.3101385171453153, -0.5426953768610155, 0.7073995238584514, 0.649249985918355},
    {-0.45759445642544366, -0.01491034364337143, -0.12908544469186864, -0.07061336794588882, -0.6595749134096448, -0.49261032886682843, 0.20845345667688206, 0.3008056482655914, -0.34146374842974636, 0.08355041104673329, -0.4464280381117879, -0.30392225550210505, -0.6324031703323968, -0.42710055649919704, -0.6392874085225622, 0.4696290293989202},
    {0.27122056924226046, 0.3889395337151533, 0.14259059252667816, 0.7407514011349934, 0.3844584380911857, 0.5474620789204485, 0.2950382480769009, -0.21453129905380713, -0.13501632952379428, 0.11099923552561623, 0.32280928777030926, 0.38976339088875595, 0.59870580758592, 0.5717830057075248, 0.07856739398188886, -0.376008943708102},
    {-0.5390221265701772, -0.14912998922787066, -0.537328252930284, -0.7445590204009308, -0.5887537600381187, -0.5047443701136978, -0.3495292966116169, -0.11447467617222716, -0.052656878215479444, -0.8454698336267439, -0.991181018971226, 0.00125553101681452, -0.5810735282759192, -0.5608393175306928, -0.30692778051535774, -0.3420374970028848},
    {-0.6008541078357393, 0.2915620926948338, -0.7074331988361707, -0.5077847580290357, -0.47090744004427676, -0.6271056284384219, -0.27342461795316253, -0.26294942789247333, -0.546533958400225, -0.24548069682517384, -0.5698185539031083, 0.10440379779431148, -0.29531064145435815, -0.19691065988897277, -0.3209723259460263, -0.21073383606092722},
    {-0.35487909999822015, -0.19989580588170983, 0.3041149990972527, -0.46680897774981694, -0.36380825367224245, -0.36169715178841716, 0.04945801842882107, 0.10037039056009872, 0.27389091035030355, -0.30295929915726205, -0.4988773469773329, -0.2857389836859157, -0.6623949567515358, -0.7760278062200305, -0.01857020637747154, -0.2718265206843467},
    {0.008481318607052715, -0.1523307132276301, 0.1681408868461195, -0.25830289124879924, -0.3958861966430813, -0.11579526986119493, 0.6456374209435921, 0.32519467583504974, 0.5561260879064542, 0.3618255925207679, -0.2781045069599982, -0.3637255294463098, -0.27408917509689784, -0.04934087221731798, 0.6504732351500365, 0.5612676499222501},
    {-0.6691430909054655, -0.41611873675693156, -0.01144490473042928, -0.35882318534530877, -0.49633721648114276, -0.3276978984560019, -0.3593012646154528, -0.0578856195826609, -0.1125007705334341, 0.33077613746377854, -0.12849109981706158, -0.1436000482871293, -0.4353095558947691, -0.3086617284796248, 0.12754190825942155, -0.055778732016688454},
    {0.2035410941713261, 0.0872464805403955, 0.21066369595334147, 0.7382040116096974, 0.37801684982555583, 0.6687519101741998, 0.498591156752974, 0.19000292300443103, 0.4061023434579501, 0.010922666562418505, -0.04257177108437312, 0.7536481037559684, 0.6598829290681432, 0.43492776158657653, 0.19536653427916098, 0.7795215865875639},
    {-0.38776544424916376, 0.43238476471525783, 0.15667496776134573, 0.11004257177317822, -0.03420639676933572, -0.05789295312437496, 0.5589667110328989, 0.29481401640239085, 0.4076801283932485, 0.20665002891383227, 0.11609735900196545, -0.17261794806209946, -0.13855322866416928, 0.10771561104719858, 0.32140639134078797, 0.5763589782248953},
    {-0.4594357686986053, -0.15623081932809546, -0.14048979834132044, -0.5977174197197317, -0.5124178495311777, -0.35118322773406496, -0.46579033992785973, 0.020289678957832187, 0.1502158573091533, 0.008383951709481228, -0.6816216110139685, -0.8894768937293355, -0.7286054847661544, -0.6440681218224094, 0.16619035638730686, 0.07025301565790498},
    {0.46072538987102646, -0.05569942655631269, -0.7639739605993652, 0.7034356892114373, 0.3943653923931657, 0.3084823374258269, -0.5524170255166463, -0.2433897376737508, -0.11223344563044715, -0.9025322732176714, 0.7855969202718692, 1.0485275750609733, 0.11221786683464612, 0.6189491204011275, 0.03665979901578742, -0.8901111341011434},
    {0.7019734774816061, 0.045371600447322705, -0.1283511404006084, 0.9967407960955879, 0.8080479033607627, 0.923755804338853, 0.46419842216423074, 0.393184039320861, 0.1948886971621994, -0.08244268344780238, 1.0966754316129563, 0.9552662054514368, 1.2299792919529422, 0.7675189756426581, 0.5210500398152961, -0.01944927437131656},
    {0.7847223150440958, 0.34004805897120516, 0.2769757168667239, 0.6449085185054907, 0.15850364949743806, 0.469621119921368, 0.06893229267715412, 0.22872076740600888, 0.1981741885086479, 0.20285091369176045, 0.6466583645093024, 0.38420464150567507, 0.3697345481617923, 0.5290899767666719, 0.1727704129017304, -0.09097756893445179},
    {-0.04798089616284325, 0.05939546499936497, 0.06470209455497118, -0.2328778951191503, -0.14153102302781947, -0.15560054787676939, -0.3230092929662442, -0.19345450358614313, 0.17778909993890776, 0.17868960834369688, 0.027019272417929615, -0.018499841352648597, -0.27165553931932324, -0.31126431410143585, -0.07927533309313492, 0.1601449392415007},
    {-0.007607494574714631, -0.12118272478156382, -0.4575050666561097, -0.07167833282514809, 0.16853227965294093, -0.39955443378234085, -0.7449770170080335, -0.24827253643737623, -0.8288695842214415, -0.2988225987242272, -0.2169121159747273, 0.4219414596628899, -0.34360016107590835, 0.1967366355237809, -0.6559847090524431, -0.41749667584243555},
    {0.15437431690534567, 0.09419012336237885, 0.10454327632771206, 0.1998116553009561, 0.2837930274570342, 0.4865442380380654, 0.20518450062956134, 0.43400306540901795, 0.5573633741751933, 0.36624501682990385, 0.23143551966684392, -0.013648086411144395, 0.147786399434531, -0.04196631504472604, 0.3757961480180882, 0.27445121900155894},
    {-0.2923643647290328, -0.16794000014143218, -0.5883379538283131, -0.2790422670706142, -0.6272851706339593, -0.6010502161973037, -0.08626121695046299, -0.13113891199386193, -0.30388156361716184, -0.5372177000878655, -0.18880605998468247, -0.6781799021768518, -0.6720513983441535, -0.18681171590114773, -0.2657000632596962, -0.419849673547573},
    {-0.2685422165832583, 0.2889568997084284, -0.6987813109894668, -0.22449425048036847, 0.034206594406079184, -0.6628420778636278, -0.2805592636436809, -0.24544466447539634, -0.4309854671195334, -0.504504923421662, -0.28442443475344914, -0.10913984780059319, -0.6152235860808054, -0.46478385311867526, 0.08156060847169685, -0.3335790126730828},
    {0.16427326222282992, -0.07879516561925971, 0.5002221860917024, 0.3487720382697418, 0.34358342850413426, 0.5828332299517724, 0.19824051984975055, 0.3059674037925497, 0.5524543366199218, 0.2489165232726999, 0.36895149498786306, 0.2778268462345074, 0.5365295034328807, 0.1700100640951563, 0.2492853500647736, 0.017876447486969965},
    {0.21578005407714515, -0.5083571954542404, 0.2664469107244801, -0.22031242113006244, 0.3569905492179635, -0.0028879299208425958, -0.1659412848666167, -0.18506692773747, 0.0566736176214059, -0.022426305308839958, -0.02326958261135388, 0.03372802781170217, -0.10049613187039673, 0.11735368567739426, -0.33962134406902716, 0.11536308260956758},
    {0.4350130550514036, -0.4736009920711571, -0.33675428198552954, 0.7766272035317425, 0.44389951918918824, 0.5160680831615436, -0.052546983386367645, -0.3131941662536446, -0.12086201933372698, -0.31291223149514424, 0.33437928228801334, 1.0132600419702884, 0.4952771445402084, 0.4116497399691728, -0.23291381733141675, -0.10477937271248333},
    {0.2499728322637823, 0.1351925687620521, -0.35652470908446665, 0.8353284111757954, 0.36026153061496163, 0.5036867906163952, -0.47845296486164174, -0.305176088456294, -0.4949581087079165, -0.725460238010799, 0.5563919229365182, 1.040424816422006, 0.41638190071133135, 0.96774141561418, -0.45330165099649494, -0.35600176984597925},
    {-0.16119020675792922, -0.14529323757300222, 0.03877139350599839, -0.11319818530959735, -0.17237771511119174, -0.0782411534520191, 0.27360380039805654, 0.05962543174977443, -0.031113867231236304, 0.034788869616583604, -0.09742366574134989, -0.5181747965188861, -0.26448775580258915, -0.3481952540172087, -0.08111504333425483, 0.03223087476356376},
    {-0.18082108535590136, -0.1398704957430252, 0.25681446179421674, -0.20298879982120865, 0.1620411299661174, -0.12444133233472938, -0.19860642200768, -0.421568870062484, 0.16385415501429462, -0.38517156562431093, -0.2642081752907609, 0.13367831553411733, -0.13130771213706285, -0.2154388453339236, 0.3280216021202544, -0.3312402477008215},
    {0.6399650449617997, -0.22184078796602913, 0.2865853458326019, 0.40312666726714097, 0.2614489755650141, 0.4670167613338452, 0.19439382889204912, 0.10555593943774208, 0.5242847750225963, 0.019930528507816354, 0.6329762517222359, 0.192172025188416, 0.3255539598652052, 0.3234135257447542, 0.2659270551071528, 0.023678230720776135},
    {-0.6278513000073884, 0.21260774507576713, 0.09737620398648272, -0.769032583000428, -0.3598954350974295, -0.6597939369416701, -0.5381369692024177, -0.30902797581690233, -0.16491054115105122, -0.6362005795682167, 0.12733774555899763, -0.3888100590510914, -0.31056988363938415, -0.22038504123584904, -0.02370727517155713, -0.4570586758328388},
    {-0.4700962383167694, -0.1744502799429714, -0.580062674168775, -0.6256115448460751, -0.2665828427007657, -0.586783102253012, -0.38452010902476896, -0.1392954267101139, -0.37489135183917094, -0.7546303478340111, -0.7160159187784301, -0.21322283696477332, -0.4629186645815582, -0.28470791840233173, -0.23635386184675722, -0.2603534030921471},
    {0.1257832659650507, -0.20410097544894854, -0.1510485466194367, 0.24736179900115807, 0.2261382753740313, 0.21398981201425468, -0.0797862516420293, -0.0017261911915529976, -0.24182864358845046, 0.25845754011042693, 0.041170086163687634, 0.17088789990381534, -0.01952579290292661, 0.1988705597090619, -0.09452680426304684, -0.020776981929515388},
    {0.7474487068730735, -0.22112418343279155, 0.45020706864718507, 0.5607443922012108, 0.6859092253542933, 0.4850527347518651, 0.216822581340813, 0.21617187858799897, 0.05611919671412327, 0.6877325314540937, 0.5364093537653419, 0.729221632054411, 0.738295209634513, 0.7130728218547481, -0.42855132818512787, 0.27411779134134},
    {0.3426778847346166, 0.20689974166654704, -0.3355162623612305, -0.34609042735402823, -0.03326000533336251, -0.3960639742524637, -0.6311748159189545, -0.3547264938561545, 0.02119428331141773, -0.6351794594491582, -0.1044860558352437, 0.34420896614167157, -0.037648028203510736, 0.17066943497858997, 0.05512856347145345, -0.4990356704435947},
    {-0.045789715947992644, -0.0013059247194412034, 0.036823240421795286, -0.1270273106902722, -0.30392767062706005, 0.1273259546138211, -0.18837753274256794, -0.1980683710335262, -0.18372985139676087, 0.29811203833069433, -0.06755419299043455, -0.27788221203031244, -0.05256544313660174, -0.2603454604302898, -0.364366000373933, -0.1786109198734942},
    {1.082901068418381, 0.09961893021793256, 0.6388276536440955, 0.776713652492855, 0.6199129278465947, 0.9404339871979088, 0.3019816740949611, 0.338609876069067, 0.23343452862369649, 0.8199079229673716, 0.6081205640231637, 0.6179548213372994, 1.2370074172615617, 0.8244974458807589, 0.07918339775514129, 0.4733559739325949},
    {-0.43732459532042717, -0.2670581645040352, -0.07656448232861086, -0.49798097634397287, 0.04781940821775542, -0.3977246521538572, -0.07515183937444002, 0.09450540108913026, -0.07319451358163073, -0.01700765009880306, -0.5262842126774033, -0.28849696653142387, -0.7673679793631231, -0.2206621746257299, -0.03652510494560126, 0.03098315901279734},
    {0.4212926830456117, 0.0963919518828566, 0.07080039701955021, 0.5930119890793978, 0.28203307311964865, 0.4412290668831881, -0.1208497694614895, 0.12282940696615836, -0.16209129465077285, 0.04065703696517817, 0.3980382667209172, 0.3461456012747135, 0.421624535265956, 0.6209728707545589, -0.13535833740693737, 0.003758821288145147},
    {-0.12996044814293964, 0.2594411124010132, -0.2522424019677219, 0.2479837280640618, 0.04241216568120744, -0.2929209042333893, 0.0465349713407482, 0.06387242800145197, -0.4835426533314093, 0.1746213644429197, 0.05009654960736077, -0.17923336516506078, -0.03758734752400755, -0.3224293181848627, -0.29767472204309925, -0.07526405365900221},
    {-0.2925222986017688, -0.577386992793584, -0.4606537085659118, -0.3441446826061502, 0.030562415243042047, -0.5203562670300269, -0.5782888509936618, -0.5264243001345146, -1.0789399868005864, -0.19595740591159955, -0.23270489986261408, -0.3822218591819348, -0.8492678229613672, -0.4685274615389129, -0.6606275459435436, -0.40192984481945837},
    {-0.05613886485347607, 0.4994899873209696, 0.19401536855904913, 0.06105215408576378, -0.6333076752045227, -0.08341385750459218, 0.0765217126215888, 0.12165089050572238, 0.1462593483651704, 0.02278738930322147, 0.0652141485655603, -0.11263237941136718, 0.09821067004759483, -0.10731917192902421, 0.07534591747152478, -0.022278735268369328},
    {0.2916669716577976, -0.15453068132960152, -0.3312745593521781, 0.0865067628794693, 0.05726785930566993, -0.24328212083930884, 0.1176752025781511, 0.04542834002642542, -0.07149426457909754, 0.04581358255162611, -0.17281885058573918, 0.18811656643509653, 0.22112479874590757, -0.18024351158409052, -0.14431705549256715, 0.09618883791352913},
    {-0.8893564147076775, -0.17203337605271354, -0.7394001320318698, -0.6623213308262449, 0.0023035753038114217, -0.720995880766361, -0.5481860765896903, -0.3080682679400486, -0.47121340100848363, -0.19618539073820604, -0.4254991238668658, -0.5357813697510484, -0.5983512113242364, -0.4905679526183452, -0.5733666639685733, -0.3570827565317453},
    {0.8706850578509334, -0.1251311619411495, -1.7828692324588433, 1.2701563868697652, 1.791650700737505, 2.096293917420897, -1.4797227945174645, -1.787796169674359, -2.133171254915716, -1.7095567355287689, 0.32920008707199294, 1.5306382292256437, 2.0108127083833187, 1.3395916299692352, -1.563646054179237, -0.4120794545358906},
    {0.4120285949411465, -0.34850360859264795, -1.6557262070985779, 0.4116963560723817, 1.5485000682085148, 1.9128368876233959, -1.7589818656372436, -1.7362642275822873, -1.8318189940448442, -1.5901788099617782, -0.16339569679350155, 2.065844370949951, 1.8748967811455994, 0.950162411170043, -0.9043525609708172, -0.5160579447690825},
    {1.515733964044667, 0.02667360182326813, -0.6869363980949027, 1.9572273691134925, 1.5015127832132533, 1.6127251012783683, 0.35611941342267595, -0.4007793532724634, -0.697771689941731, -0.2615805747253057, 0.7613709594217768, 1.5259586084773626, 1.8170136863884274, 1.3212886618465374, -0.38680538796142233, 0.07637961658397453},
    {1.3666815589946588, -0.6762549898130891, -0.6607758449497332, 1.2485427220435534, 0.898128836227142, 1.3788975582230356, -0.7274028759130265, -0.6441765819230236, -0.640841809523363, -0.27350336868890235, 0.2914361097441062, 0.9665027833428464, 0.9602007265685696, 0.9034671114674292, -0.9523753721274664, -0.4922428483499206},
    {0.9381118857412092, -0.22477540038386604, -0.15643754389560444, 0.9946916016123011, 0.8634538275420397, 1.2132638302594474, 0.07975554342131329, 0.1909140601481409, -0.18860409387085317, -0.09799902563151389, 0.32170482620233304, 1.174609659939519, 0.9195659519961482, 0.9315275612026681, -0.10347476253321838, -0.05132794307192995},
    {0.8819407018072658, -0.2541346790825997, 0.3131615513174492, 1.2098453677174177, 0.7530286610052662, 1.2965149782287058, 0.5049435517030216, 0.23780142702383597, -0.02585306085060638, 0.3654751828945007, 0.7649360231813284, 0.3459597548487513, 1.0433068948857895, 0.8792065293965541, -0.28413499839734185, 0.7078363595587435},
    {0.2504565621388705, 0.45138835047524845, -0.23970229238480115, 0.7013075324205094, 0.130004686938454, 0.5101769785762168, 0.3058649502946287, 0.19519687918196862, 0.16088282368999132, -0.4389268417599652, 0.2469306512651042, 0.4734859824542679, 0.48184973777518664, 0.5511552809531873, 0.5547976502461095, -0.01620492398192684},
    {-0.05892677372947494, 0.11465370763623622, -0.4425295802265604, 0.0880603003928313, 0.09767565551903754, 0.16645562838946878, -0.22073624751807933, -0.13370602819523125, 0.014433092497826283, -0.6258837817053311, -0.7840277041717069, 0.25985562737629414, 0.27265336075110136, 0.15756804557956536, -0.19150113143635356, 0.01893577192618567},
    {-0.2139905111363108, -0.23312016288216136, -0.8479337569369708, 0.08500409543047419, 0.7040302914335176, 0.7700889769567795, -0.8180504941790694, -0.4384577507119264, -1.1629862101470694, -0.03268038213217312, -0.21385120073983893, 0.6302286456326482, 0.307342633594186, 0.22555054039936984, -0.7260663853398733, -0.0693189678613299},
    {0.1911615782217589, 0.08698030610413146, 0.3094180380251551, -0.615681715638415, -0.12965447403895375, 0.1612223067044744, 0.2663104606740603, 0.2760261636201887, 0.2837206264375137, 0.5985958221075479, -0.4049689310861875, -0.5601388132318791, 0.02352279926661762, -0.46920476009995815, 0.09452400111403063, 0.6760600120331839},
    {-0.9038872977429174, -0.34557331322976653, -0.278834406753148, -0.5227292999791915, 0.12415710472606231, -0.5784086479170154, -0.5475809981258469, -0.5508756961505542, -0.6730355261531596, -0.1494508064932762, -0.5917072578580949, -0.4944778836501374, -0.7748048029738649, -0.7866082648672726, -1.0593691508597312, -0.30445365640551725},
    {-0.28380107598959214, -0.4349713670157722, 0.14971044886540344, 0.29320835894793873, 0.20165127476773662, 0.25765191093614515, -0.28938746180313973, -0.5197446528515021, 0.033724127036882455, -0.28176627620451894, 0.004920558490452853, 0.14594121248884817, -0.02980681243806028, 0.10680118511093353, -0.1435083707089385, -0.3874194467130133},
    {-0.07688779094113722, -0.14681026100326383, 0.04413704784902349, 0.13140602749240934, 0.4474172497619019, 0.40653530377904645, 0.1810582134080894, 0.2087796586702317, 0.29043242808154895, 0.08078537548602785, -0.04937538729157762, -0.32169243572687833, 0.20439859510872913, -0.24392432747181123, 0.03854291662801199, 0.15884142767968196},
    {-0.3457924696671355, -0.4754659183364932, 0.3192962668881731, -0.10855152239306064, -0.44672467778900354, -0.22123306816547983, -0.11450307172360637, -0.033739442154216294, 0.21256009090866662, -0.39911799330453757, -0.10991423411204923, -0.37317909886993367, -0.4058104840896689, -0.18801552289157838, -0.2681613382865794, 0.049945154072594776},
    {0.8705843693227924, -0.44048772700775557, 0.3688921752156374, 0.4369115551189566, 0.5183783279536562, 0.5517004928956694, 0.3502471716736546, 0.2514525698899393, 0.6671669453779528, 0.15563639827495587, 0.16399022679153394, 0.4613035654770431, 0.6340468448092043, 0.7313373783162704, 0.18568683306316155, 0.46365347679136426},
    {0.36230786023974754, 0.3444859109804178, 0.1625593789383645, 0.277441248092152, 0.04637305951583203, 0.8234670850635213, 0.5370791172587848, 0.29046346640889714, 0.5638678981079865, 0.06374342664806973, 0.17785910113447082, -0.19902474800887557, 0.5350627008837122, -0.382354182594721, 0.08718774638078809, 0.599390273214359},
    {-0.27138153461528547, 0.12615380073367935, -0.07722410898845891, -0.10741278631851107, 0.2999167967838944, 0.22770623805704776, 0.337282565287556, 0.09837828822928285, 0.05642950550937499, -0.507572601950732, -0.4028376731986028, 0.17053781901532447, 0.2801353863979151, -0.2428878658372854, 0.4550970011775714, -0.05242683860942693},
    {-0.6507241393704802, -0.5212880740154623, -0.8370885302274681, -0.26840232900524186, 0.20902745579802398, -0.40739159828901106, -0.8171731692371778, -0.705266433083282, -0.9476185093482408, -0.9556796647916517, -0.40695509645310196, 0.1822085317751095, -0.8160401746263033, 0.06939407736523258, -0.8278440111178339, -0.8393937303428525},
    {0.48602987828097693, 0.1322075847843592, -0.6257950767694516, 0.5835366737093297, 1.1034359404624432, 0.8388669983466052, 0.0015280552831913802, -0.09708904045398017, -0.18533698154299558, 0.06488783522374383, -0.05579253482110219, 0.6322569771722036, 0.6326343875985626, 0.3993303528118765, -0.2245471700628531, 0.1658644698846612},
    {-0.30249529212383647, -0.262877528353902, -0.33116389239297234, 0.19212675454923195, 0.0404466834242379, -0.2687331591008031, -0.26836421953518946, -0.3069825234336951, -0.29134550248883334, -0.2652707570205516, -0.25260414705014667, -0.20711764977652286, -0.34509664280828733, -0.41997966489282945, -0.2269982190818528, 0.08083298769424987},
    {0.31191025068885037, -0.23526351973336346, 0.45641443610852256, 0.3405264237660416, 0.3980129900073506, -0.02739217816125906, 0.23415923371880512, 0.07713104546912296, 0.13640297015300618, 0.33622131386453513, 0.016791075368793092, -0.6142708024119202, 0.34989868862428114, -0.18637556393950624, 0.29932935868791144, 0.42069316382911315},
    {-0.06606207301535191, -0.07966327455782923, 0.1616919270862873, -0.26780258696966663, 0.12494852564820266, -0.2569824386585611, 0.16950123983386595, -0.1055164847973143, 0.29742221826419024, 0.44269637538781575, -0.25142462786414466, -0.4243632318920392, -0.3423946872031891, -0.3582257441600057, 0.3098767203573266, 0.12793615365911834},
    {0.06835981281257034, 0.0019626483049327488, -0.20267988487697927, 0.3272035091392469, -0.0449193749499284, 0.33112511123167926, 0.5434619712346547, 0.13792209884211618, 0.5992569840225007, -0.3460915870309837, 0.2234864420970424, 0.4544020773305766, 0.12153754935819393, -0.05614731085030082, -0.02554436395357017, 0.21808394186599825},
    {0.36650255413875193, -0.17416723257420555, -0.5166616580557473, 0.24420685745127377, 0.4707244537522819, 0.15550311210634685, 0.03395731450716828, -0.05668504609866902, 0.2445269531787177, -0.5842348111500157, -0.5061375143968233, 0.3894275424594199, 0.3079626589663795, 0.024784166355345336, -0.3054628723350872, -0.13738253295684388},
    {-0.10726863260898312, -0.02884828591766262, 0.029375437623704325, -0.19998321512616601, 0.12302218561659095, -0.4036397157575043, -0.46002955188915945, -0.19174749611196285, -0.6542191654876919, -0.27396331617505354, -0.4940775155139483, -0.14927838550089154, -0.2062886393948212, 0.07940653133971688, -0.4371947657656951, -0.32899593815701383},
    {-0.07621858537049155, -0.5020079831629145, -0.1296963019713199, -0.4308351383168858, -0.04813513317108861, -0.004654118875028514, -0.05782451627103801, -0.22268439424673994, -0.02363742080750145, 0.11885853311180117, -0.39976734249314994, -0.12772881714501585, -0.20635971403244982, -0.40326050623223114, -0.1500532596575462, 0.06900777778507612},
    {0.10519409428138826, -0.14409560304296357, 0.13038174228197993, 0.27985601564244655, 0.5591181120037474, 0.4548809644196206, 0.17274032402928194, -0.14950532332573566, 0.4448697066818891, 0.14158181235194298, -0.14220145314429597, 0.3275157192304061, 0.6678248369175128, 0.16799269625319058, -0.20295857204617662, 0.18401302579953738},
    {-0.24841661267950596, -0.4096264365083575, -0.0819975580777236, -0.3305601645561247, -0.4305785463497001, -0.4337325437627057, -0.10456680776904917, 0.17806822475107897, -0.03424718851981429, -0.13337130687900517, -0.5490567328253683, -0.19530171802440563, -0.3299795906058706, -0.33423017265782345, -0.14302170387517432, 0.043766661675607464},
    {-0.9218903721309896, -0.4166491598021722, -0.62742908891631, -0.4942167424065313, -0.19525906932317416, -0.45398943594834296, -0.10680714503212356, -0.007737630711532251, -0.4835942875402804, -0.031187113126420696, -0.6601935890872626, -0.11709613612825777, -0.4905815944075009, -0.3724464703572427, -0.1405649358847575, 0.024201429080211816},
    {-0.14542313805401202, 0.26231187304647585, -0.02890852547886315, -0.2011354231989081, -0.30815957583380904, -0.047643845333560454, 0.11586802189785243, 0.06008478260846163, -0.34393824108364635, -0.29531490752354705, -0.3137402500752875, 0.03105178046250117, -0.07485748886574967, -0.16936154358359518, 0.48701625446623786, -0.11231925328656661}
};

static const float b1[16] = {2.605591582707863, 1.5093527092419037, 2.0170614646548297, 3.0710485195679436, 2.280898612277263, 3.257264840762853, 1.8224773590510432, 2.0013134527524543, 2.0686050515481083, 1.9155187040466035, 2.5694531310523416, 2.344150333698703, 2.9367117512243905, 1.7052476918972077, 2.112754244224259, 2.129470704496365};

static const float w2[16][12] = {
    {-0.7706790332122654, -2.344911806528426, -1.891987469659398, -0.6182441463285864, -1.1548897003046463, -1.3585453774696097, -1.7818704610974927, -0.5870703605841808, -1.9093906038034552, -2.4053739996515207, -1.6305130420635485, -1.8015885656464439},
    {-1.0915697548775962, -0.5351821779946913, -1.476847733891506, -1.9789125296398677, -0.7092030103298379, -0.4217657279801951, -0.3177695646534881, -1.3924898399998387, -1.3473349087242656, -1.0999246977450896, -0.9883084412985175, -1.4603691648425976},
    {-0.8206792693348232, -1.3780123204057553, -1.747740067753409, -0.19954214223761702, -1.1215564450544067, -0.8950748873314469, -1.3047968876441625, -1.3318056247154788, -1.387465160201128, -2.401420400684335, -0.6030142367842103, -0.19105165667653873},
    {-2.1420710386233233, -1.845132445858588, -1.810096037414983, -1.9963587198200374, -1.518165444857884, -2.067910505684904, -0.7328069938178391, -2.0138648518128264, -2.014799664518026, -1.4565050866553089, -1.671853703119505, -0.33743469731455455},
    {-1.77194545211813, -1.0721946795911361, -1.2797694967002367, -0.9128312890082767, -1.5819313576266527, -1.8902179762695661, -1.4473173110691537, -1.825341411574401, -1.392485700187094, -1.8148548732975645, 0.13515678690579247, -2.12838912979507},
    {-1.477137918459001, -0.8743548059929764, -2.322697626486791, -1.941556870196447, -2.3594862092683173, -0.8607885778204525, -1.7727350661148926, -2.492734593878205, -2.3272927108257235, -1.4831413716964494, -1.948460448056361, -2.239585462770472},
    {-0.6662557237321435, -0.8670995699532537, -0.8350402676501937, -1.8252511129376754, -2.213326947870072, -1.4442550468768847, -0.48254056815369417, -0.3781137952831968, -1.1747424229095866, -1.3847589533191498, -1.4778221457308336, -1.9227162093134857},
    {-0.2925729144482205, -0.5843106234852036, -0.726815854886542, -0.4125129106350597, -0.36021710244697147, -1.741318722594795, -2.397506155819827, -2.434479856934079, -1.2734606933892334, -1.4283987681042503, -1.5992995067153342, -2.009569513724345},
    {-1.9191608529515465, -1.2645386017625093, -0.4439436157714776, -2.064941681734503, -1.1632964137490527, -1.3779849083527427, -0.6285396118663739, -1.1764121902290976, -1.5199161232731504, -0.6677093707615128, -1.2766534739229771, -1.6281944639121493},
    {-1.3680122284540535, -1.656323029328654, -1.174042464190956, -2.1476415839002216, -1.3524535954173924, -1.3093061954020846, -0.5788464554292244, -1.2532658011106543, -1.2172002515390057, -0.37146835931280014, -1.1149210745747442, -1.4684376576170626},
    {-1.8684158202432783, -1.1704386379624745, -1.7969705850337219, -1.0337794163891538, -0.6576112102367687, -1.8189772211466584, -1.8230147090668745, -0.45254654853626114, -1.3665822812533515, -0.5672884233548914, -1.3507753186240405, -1.8138743516156426},
    {-1.0961547891428514, -2.540716161355448, -1.8120390628357592, -1.2433587321266024, -1.109044272693547, -0.9230470451606054, -1.1572456451694926, -0.9227527012323158, -0.7978387628949857, -1.5542165714432015, -1.6873537063521091, -1.800424405341321},
    {-2.2337287928172613, -1.0362566375185605, -1.281005348853337, -2.2445059968243006, -1.3724941344832837, -2.148906926926924, -1.9144568053568627, -1.6094344336995117, -0.26834360794904083, -1.5182591745039573, -2.107785892175518, -1.3595881768239175},
    {-0.49509097509486216, -1.1001381435284059, 0.2201465807716731, -1.299781494524829, -1.6141848584003484, -0.867475429629875, -1.4798824807605937, -1.2343809230155585, -1.9998657567078286, -0.9562131564174042, -1.4170132475579975, -0.7053962915936419},
    {-1.1249928264927564, -1.7514399130566933, -1.8406860825216478, -0.6911212011267177, -1.2668541687705628, -0.7351581045839494, -1.5851592884541175, -1.2334111805194488, -1.256156364510179, -0.8736512458376344, -1.0632609899629022, -0.5375132796144673},
    {-1.5860218710995455, -1.1985603225350354, -1.5688939779238136, -1.373060896343214, -0.5365271288839337, -0.7038413632002969, -1.8928080254176831, -1.370744093543267, -0.8491024746850911, -1.408215839645017, -1.357536482715459, -0.7023245758779888}
};

static const float b2[12] = {-1.5452234631255057, -0.8996995680522453, -0.6608776551568943, -0.6153704160786425, -1.1053362374745446, -0.7458620485811438, -0.8137859909638043, -1.0353165781434315, -0.6866955454156537, -0.9673361262546027, -0.87399402325407, 0.02351028809304075};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
