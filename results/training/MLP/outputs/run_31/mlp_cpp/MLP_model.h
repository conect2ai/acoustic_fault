#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.2972408153594801, -0.9861788270818203, 0.7521435192758371, 0.7124639198728405, -0.06649658285066402, 0.1767617658836243, 0.3246553664024477, -1.3113923735442623, 0.1998326414572171, 0.12516971539584884, -0.6914771150605447, -1.0356749609074167, -0.975619638965574, -0.6729735036256813, -0.9829385743230604, -0.2677070502059278, 0.4715629971608943, -0.7854534675064201, -0.6886748247809561, -0.8514572281935177, 0.4710533597592306, -1.0602857745530618, -1.0171199789548517, -0.6888493931973293, -0.221945794890892, 0.49200734933909723, 0.6894262091486701, 0.5719547623962685, 0.48545078237932937, -0.1653541628828042, -0.020134948980123545, 0.5708193536018227, -0.5385344880233668, 0.22723706318200335, -0.8782377455563943, 0.10235485720714423, -0.13275904782759063, 0.5062134909606261, -0.9143099959222886, 0.8569738708625454, -0.3135316789198208, -0.7101929796376278, -0.15131738067222203, -0.9874271905394265, -1.1147506039355484, 0.3628064586543721, -0.002276801166114855, -1.1633987180741043, -0.9619218541330714, -0.6339508479803149, 0.7150201771559637, 0.8132389613586011, 0.7322834196775689, -0.5693385035557412, -0.437607618699517, -0.040079936608523103, -0.1609423415533086, 0.2131037934359629, -0.12384364833400191, -1.1336027413765744, -1.0984342010064905, -0.7120755916718293, 0.054913629498699136, 0.6412927005073108},
    {0.405940595637158, -0.4080914851808216, -0.6609936201428029, -0.09729817685057099, -0.5250535753324901, -0.3742722443600251, -0.5598821719832521, 0.2768971810404579, 0.08013408759560196, 0.14801809249530284, 0.3232732142117643, 0.4871656233877431, 0.6045046139137671, 0.5758903763114378, 0.6668685272314103, 0.004138039785508668, -0.5837473322576151, -0.0062158866761370685, -0.021523629997366192, 0.5642695826849001, -0.9536407557217461, -0.04772873036634189, 0.2184795702584612, 0.6348274535934091, -0.6782838416356314, -0.8877875095939729, -0.9423568749139105, -0.4635229270954748, -0.4003172755976107, -1.1739184677960768, 0.5629853306495438, -0.5892674225454807, 0.1912745939272143, -0.015845682516207132, -0.5586298567983019, 0.6825711645735526, -0.2617030503141821, 0.09697035906191138, 0.2535975620380389, -0.6587285362957293, 0.5082578669189768, -0.3951696752764939, -0.06117947178046239, 0.6481692996553733, 0.4082422903092397, -0.8767248382791352, 0.8039357466336714, -0.2280644854847101, -0.1316511190102943, 0.2403974914475227, 0.06981243956163134, -0.9512401208567878, -0.8750672786108395, 0.04793067534257814, 0.6284943086004549, 0.23764438329317894, 0.5688705507967048, 0.4065078598817664, -0.009602202033307835, -0.19486949853473837, -0.4677266418511845, 0.04925890548513749, -0.19604597818928327, -0.8846371140113074},
    {-0.31240731157151685, 0.06926827906362197, 0.5448911002358968, -0.2170028874346784, 1.0999220160855687, 0.5611917456262887, -0.5180178068169411, -0.4810462191767788, -0.812729018325803, 0.04076231577968831, 0.8362950315162268, 0.7165195195757789, 0.9247707105249777, 0.5668857721844246, 0.334404540129113, 0.9648213350660271, 0.043678796147799404, 0.8618823101827858, 0.6732131709069016, 0.40390420845500496, 0.30680143606316457, 0.08650287282719518, 0.7308287948402206, 0.20158724240070267, 0.8555315976670047, -0.2046755123879446, -0.008315636225325293, 0.13607749880376377, -0.37579025750378553, -0.05896406617646962, -0.5205009558988526, 0.6272253701125784, 0.4001682730148336, 0.5467453286103099, 0.3315724389475501, -0.6304788046969587, -0.49598891798223504, 0.3772962552662097, 0.6779455993651285, 0.7620960644151924, -0.3104716526727478, 1.0926905282468744, 0.1796454344985331, 0.9918439444581949, 0.8431400957833294, 0.4719286740464659, -0.13945226349244078, 0.4507769597344861, 0.6890731246034077, -0.30919118820836206, -0.17490037642640913, 0.6284628504690257, 0.8207986244841116, 0.46500010278303755, 0.19240539297720466, 0.7164745335465069, -0.4035440890785063, -0.17004048044477144, 0.8917107922444522, 0.5436580936827847, 0.7489646000775392, -0.1541809109199878, 0.41110448183343856, 0.7740040135131899},
    {-0.3596225049250957, 0.6523593478175579, 0.9076402109991296, 0.07964046028658664, 1.2288824682019612, 0.4070134068177258, -0.5199067555745984, 0.19668539310793848, -0.41386665590670724, -0.36969966117336556, 0.7009059581013015, 0.596581997836978, 0.9018189373411201, -0.05354446904364789, -0.10324748183786024, 0.9395788975586769, 0.5652044533543868, 0.7356825689811975, 0.7136616675802407, -0.30363450904427924, 0.5126038957360909, 0.6660107337882142, 0.6650572896967736, -0.10633282347234033, 1.0468179345873674, 0.806141284479749, 0.9813957555027696, 0.21075475244565176, -0.07035529473505554, 0.5803204483720764, -1.055246858397386, 0.6068695383504249, 0.4533746268964694, 0.5981798106967682, 0.7738202138265766, -1.4877218125987295, -0.08292349470537294, -0.28802593112436153, 0.7503016495395052, 0.7302928003511193, -1.1188504300145572, 1.097154178213361, 0.39790768958465494, 0.12016379910887612, 0.49555021738973043, 0.777443607187636, -0.2875057061895143, 0.9549743373122117, 0.9502810835525166, -0.3882628813754312, -1.071874116581403, 0.9961152816544442, 1.2242081353642447, 0.847904166744982, -0.7115509180460863, 0.34242322271121645, -0.5110122488554807, -0.8821372913668479, 0.5686960776486267, 0.5502643632749956, 0.7417703958876029, 0.2594572501605723, 0.22551836740826808, 1.1915469705743031},
    {-0.6248504897404777, 0.8955824901256024, 0.5833030091807498, -0.6123563866593017, 1.0741447629176453, 0.06542574668309377, -0.4976027194303095, 0.7889460961836151, -0.924741866914432, -0.37935490200672867, 0.4366247053400715, 0.37685166540293935, 0.3869152171985304, 0.14034934660631934, 0.8718171713201287, 1.0753150018755326, 0.14700341143464496, 1.1186542116236509, 0.6308239526663307, -0.5797217289615514, 0.7401197780743214, 0.7052197219248276, 0.6884248610360956, -0.1119281487608836, 0.6030779597369479, 0.19683950763021993, -0.2120449527314151, 0.10370153949877874, -0.3204326361271457, 0.646556295468899, -0.9337064621452309, -0.2779063223718058, -0.3468922742829963, 0.10477929778974707, 0.5287421004009031, -1.0663652405090285, -0.7669017335863394, -0.4461476066068181, 1.1425862055082305, 0.7882702158179878, -0.4676581656939891, 0.412279066095693, 0.46507164580889243, 0.8673317875830139, 0.5163443660072189, 0.5890712140889344, -0.5213312845221022, 0.7405711570104652, 0.7014485626018013, -0.18277511463432683, -0.5720000397256819, 0.7746748775436751, 0.713332568343611, 0.1515876906429524, -0.5041571627350474, 0.3182044712759468, -1.0067333702022752, -0.110424947721443, 0.6271878588440097, 0.7226376859861613, 0.7023395007368032, 0.006550817969341563, 0.4044338219524779, 0.5103637512760341},
    {-0.2943651249174634, 0.9608158018173406, 0.4519000716622993, -0.08548028903776195, 0.8919676872337883, 0.7814015960461866, -0.8587858046222293, 0.6800488609266692, -0.5729514401966441, -0.007759205993515522, 0.6477751866988742, 0.6327326105632646, 1.1904899605710835, 0.5355484031699802, 0.865586758154308, 0.7490189044832118, 0.4400298444513095, 0.945402020233545, 0.5817374467780593, 0.6608778638345408, 0.7268928575258858, 1.2254032570075408, 1.2082522504102708, 0.16162550679990573, 0.5628530700679196, 0.715604709226295, 0.2233969283665964, 0.04860627275155695, -0.6160271306038293, 1.0780872087767202, -0.528443316441743, -0.7441589119974629, 0.7091088916176663, 0.19994875943590956, 1.1208730231487023, -0.4149823818095273, 0.26494814616666573, -0.5485883649853943, 1.3401418113398458, 0.4713854786959406, -0.2511743998295551, 0.861433332152654, 0.8058317462161247, 1.0670996719155545, 1.0011194754037491, 0.8105029554677283, -0.18575960140290715, 0.9128159825657169, 1.0491635760560885, 0.09849283040519885, -0.6532547944278368, 0.1387801790855521, 0.20138388388034467, 0.9606118711363207, -0.07203512541040333, 0.5082890147096063, -0.5394074520626149, 0.33132100104523143, 0.7021724099390162, 1.1782814420173098, 1.2259056549998033, 0.024847809080629467, 0.14466714982100415, 0.5502288347365568},
    {-0.1479335045745584, 1.1689896656682086, 0.7917637403629302, -0.023446121232576462, 1.101047235410573, 1.1101419655239704, -0.45409618341203634, 0.8644685341269907, -0.7423395472058789, 0.1651220695284242, 0.8071595404624574, 0.7515431152441371, 0.8907121446317655, 0.013089643663448986, 0.8728682656155706, 0.8246816724645356, 0.515096378934901, 0.6661995250447639, 0.9917113307907183, 0.8326073325032287, 0.6665824347485589, 1.4177170984687182, 1.0975658831131678, 0.4982989682683592, 0.8120906019676895, 0.7453860711676638, 0.5978515251245475, 0.2108760285905016, -0.16091745113175498, 0.9802236695217311, -0.43671456667379116, -0.27614793440788954, 0.7339071229570536, 0.29969117448089594, 1.3480989887637624, -0.6297056340478939, 0.5265494407025089, -0.7367552063697553, 1.232606640413847, 0.09436313355616131, 0.033242793203005404, 1.2010846434633335, 1.0089489518075674, 1.0206774774972955, 1.0351016979781784, 0.6187444394869531, -0.23134284939624808, 1.109059393520591, 0.9108430529535325, 0.06065433007535873, -0.847867067024074, 0.42623574517814017, 0.4006661019662284, 1.2798510411884285, 0.07661950754873884, 0.8055731564869725, -0.7260090693571616, 0.27854004608308197, 0.5205338271656816, 1.209352316977242, 1.5413156525343374, 0.38500094562310383, 0.4398021460344366, 0.9377357598140208},
    {-0.7596205889145516, 0.45627107903861075, -0.1046140858459073, -0.388310855587246, 0.34585097118134, 0.33786691922716305, 0.06883536317704515, 0.7301229693419391, -0.698947068672111, -0.26869545301672293, 0.08919788032476642, 0.589696080591507, 0.5842544842980653, 0.270980262327645, 0.22004529840010043, 0.5957309678576488, 0.15692863204036997, 0.9607069590969329, 1.1459492358006134, 0.05685374307454662, 0.11930182723234814, 0.4869008083894909, 0.4667677337206342, 0.03873294888688946, -0.012018869531099478, -0.7877423001770764, -0.25359815343447684, -0.12080407565194047, -0.48239977557109914, -0.3382572353379722, -0.5490537073618488, -0.607379496790462, -0.37938104958831265, 0.3372246051234409, -0.056408626829488245, -0.8214951130196867, -0.8040267435367524, 0.26533811416626213, 0.489049538201776, -0.030601282511223914, 0.013765180061081487, 0.2567156299161163, 0.47575471177870676, 0.8089227184660055, 0.7783326357322464, 0.35722989589818427, -0.37593721675607056, 0.20552720265569183, -0.13682582002657684, -0.5422397135493243, -0.4572689434563114, -0.3734105201144824, 0.2073834028505263, -0.36949063117146913, 0.40176919597527994, 0.44994517501406545, -0.6850028051748662, 0.6734216663394073, -0.04990274470601786, 0.22928946985166093, 0.23311792943218085, -0.5976384201134719, 0.1389099984633111, -0.40281490270445847},
    {0.5766312500349197, 0.4809876547387944, 0.36382275431449285, 0.2975891541575365, 0.8952811945898743, 0.8698718448804917, -0.04968662930167172, 0.6636182442707614, -0.5652144608319882, 0.18166431178543507, 0.361733984389483, 0.8074486811461952, 0.6478560880698643, 0.4325954025657807, 0.5476693504639001, 0.7475651314490583, 0.2866559633671838, 0.40902491529703244, 0.9438795716567842, 0.44380132184771587, 0.19716198490986556, 0.7354158225990112, 0.524837642482406, 0.8235238785663221, 1.0306429904158558, 0.3849810742801594, 0.013333836422373624, 0.4886376698314808, -0.13119234841245694, -0.21448947926549244, 0.20056876527207612, 0.27279814985615203, 0.509536899134462, 1.1116584520790074, 0.8194281457919903, 0.2735153348062511, -0.041472803148400544, 0.8954201397916577, 0.7857902446031472, 0.0861455251714961, 0.08220207579947778, 0.41934177499157393, 0.4754206559052887, 0.8982444714286841, 0.850944992356576, 0.07762645939546714, -0.2837995720071016, 0.7510379692308575, 0.2828662382309006, 0.44742033831944733, 0.17431260395983647, 0.2800454094917777, 0.07496236810852554, 0.7172298413684042, 0.4144936037058444, 0.911854669219648, -0.15174688468756947, 0.969314773988113, 0.6098186949918509, 0.7032233185930465, 0.6083062144039413, 0.5832680817806523, 0.7809022552227872, -0.06688441947751024},
    {0.67660939105152, 0.020296356026301098, -0.29255371838804567, 0.27135735150125756, -0.8730616696499247, -0.0871961334831871, -0.05221473250617897, 0.7107985898481167, 0.8100494748313848, 0.6901380213899759, 0.43980770229294247, 0.5799489952399077, 0.2719348008461369, 0.5196610092357937, 0.4708909295557842, 0.14393481367041694, 0.20646510314467767, -0.04126720775157349, 0.5422479359113287, 0.7204846619792665, -0.7085488585503208, -0.04417478316241571, 0.519550395525642, 0.21331163599441436, -0.6557009932814742, -0.524409217271426, -0.52537128254142, -0.5901817449655765, 0.22542023709588013, -0.44960667535677, 0.8721888009436816, -0.6982224780075037, 0.5256879920052482, -0.3382040799156192, -0.05729678349902973, 0.8304480350856912, -0.3125685006354093, 0.31507421106260847, 0.29181258151174005, -0.4912447314125681, 0.6439566890094635, 0.2649633432316613, 0.40178126840559714, 0.7575123159258712, 0.6383308907625496, -0.003032663863919796, 0.8621789778327102, -0.038901628260627506, 0.1677694560640736, 0.4049160331368332, 0.6952231822459759, -0.7174846594892444, -0.7727009003972075, 0.07674006249573061, 0.7035064386523411, -0.45528409674109405, 0.6782402587687233, 0.8161287492742865, 0.41645328067557263, -0.026601908962011006, -0.4969920912637073, 0.20754513675382982, -0.09190380713127191, -0.6353552599140374},
    {0.14584155537122223, 0.6311046793853491, -0.4757089793627467, 0.5237705926670246, -0.17871742513105632, -0.38647539780458745, -0.22272679900282638, 0.702242579685137, 0.4415024811213031, -0.0897619500867002, 0.8001494570134925, 0.6995334408118183, 0.4870126405703704, 0.31603987786395615, 0.4772170744119732, -0.17907797690466512, -0.5452926570662114, -0.550902028467195, 0.3496816439672271, 0.7834483829267451, -0.3836860021772078, 0.5311324452517684, 0.3493273687241864, -0.26308640574213105, -0.33757149585600227, -0.0828007976454802, -0.44717128607291573, -0.6580292565108193, -0.4933963815663991, 0.25624475696408877, 0.4590398389087427, -0.36661300875449493, 0.9628779751430113, -0.40064625927122394, 0.580706926188188, 0.3786749505101494, -0.12545121296715658, -0.3804773700185253, 0.2282682947138975, -0.0839475710616445, 0.2400313679520191, -0.1274133866232029, 0.5865060968456617, 0.44872091328012154, 0.25805337595357347, 0.2946706632043914, 0.571159172633992, 0.16118665513323566, 0.5523736451933183, 0.43253942268253165, -0.09513461184647443, -0.8817619789903401, -0.8039576575864863, 0.3602733115316673, 0.2637895234295701, -0.5680980466077272, 0.21174069274389853, -0.43646766280202115, -0.16361720163836446, 0.503271160016687, 0.40565686967505177, 0.19210907156448143, -0.4693444507725194, -0.16906473941465905},
    {1.1021951606277658, -0.6857181576849715, 0.4724679386275215, 0.2837564279394054, 0.485591314753367, 0.6258530746022789, -0.12202031565746446, -0.07165745147697603, 0.5770917907949613, -0.026397472261769576, 0.2812819793410473, 0.7570822288923686, 0.7672000798101073, 0.5412212117471005, 0.5933101823994468, 0.5684723663357477, 0.41275399701970783, 0.19790110435845093, 0.22397614031724142, 0.20748587940745072, 0.14369244262427777, -0.32840676239500155, 0.33197281391428396, 0.14170428238759566, 0.47741948991673994, -0.5503921924995612, 0.34522698632819004, 0.2144210373235471, 0.8345769935393421, -0.7894138740899201, 0.7594963495821918, 1.0081645747543082, 0.8428618645694232, 0.37936829028712793, -0.4317295117234297, 0.07320858379089018, 0.48994275747503613, 0.5770137511563526, 0.5150727963421976, 0.9104908146292399, 0.14738438951119126, 1.0007460932855439, 0.21577870742715904, -0.16378415944402655, 0.5014356197130575, -0.3591729490504806, 0.5898453381371197, 0.012510703168418272, 0.254830137140171, 0.3457361109156272, 0.34260649738164234, 0.15605045953485122, 0.5082597886607958, 0.4010702628993237, 0.01478431789198372, 0.41388408524043446, 0.7262761624907585, 0.29156735906969034, 0.7086206839751872, 0.08758079190223661, -0.03468016928716155, 0.1295199125910917, 0.2748374800256672, 0.681232088715668},
    {0.19284442639051036, -0.24938683226574657, -1.0763914459096227, -0.26656489256909305, -0.62925661248649, 0.060693559614377654, 0.5307221453109779, 0.4618791399064451, 0.42931287873856205, 0.76019413962635, 0.0027915832032807467, 0.4705957145318377, -0.3111841750715679, 0.6352903016058383, 0.3205074889018319, -0.34121815740247946, -0.6675981613302309, -0.017985508338721794, -0.4115905688529311, 0.7614737155170566, -0.5416660807827692, -0.1015739167900058, 0.30293132877232737, 0.8395553793068906, -0.6027230720815848, -0.4561857026491047, -0.47275717273925905, 0.4193278421619374, -0.891684299497259, -0.4476091750819177, 0.7784364099223199, -0.7506201673690621, 0.4822735991609906, 0.3561767593668711, 0.08862037913685022, 0.5994022563526555, -0.4848111509727499, -0.034546829386850136, 0.19804386316974953, -0.8523358815496217, 0.9693898415258537, -0.3608406290887914, -0.6807960018218089, 0.6256617864738186, -0.0009518729217734447, -0.6200624503837687, 0.2776398143067154, -0.7380840717577012, -0.3950760220000207, 0.08164894157430085, 0.9261338448249276, -1.0644452875393409, -0.9743517445062967, 0.44552097093992016, 1.1090603611613947, 0.3122853287960959, 0.5386332441281667, 0.670334227172913, -0.31459682869029804, 0.49830928500053245, -0.28691395076406984, -0.42434747658054855, -0.3194823719420903, -0.795500937090205},
    {0.7968919671353539, 0.6891830847281927, 0.1665821698104624, 0.6903850920747301, 0.5743700918322294, 0.03357947660519166, -1.3279284477837123, 0.15942274182186367, 0.9667684247648395, -0.6229759424155147, 0.9919411212288719, 0.7315540603368917, 0.3994932860476449, -0.0880575600899538, 0.12860744849123934, 0.0010109418936719919, 0.25008014463105144, -0.24147881714721942, 0.2629968803704134, 0.846841518789675, 0.35867513577445354, 1.0123528923070986, 0.41656150878657094, -0.07558212954615051, 0.2803105703067483, 1.031751536888267, 0.788989858957323, -0.1446510034270184, 0.5844842247516572, 0.8363853462151681, 0.03581314166910887, 0.5381061493040613, 0.9942627076244817, -0.31101696814395535, 1.224649322198882, 0.3884503999419815, 0.39900450590004577, -0.3732105739808508, 0.5363522085316609, -0.006669020665334032, -0.2430671676114704, 0.48681374402068656, 1.031590094861578, 0.35833184911118526, 0.29721023783191897, 0.33227059739261017, -0.4359218913944426, 1.0849330725633657, 0.8516651210609932, 0.6826672680986777, -0.7075467011113957, 0.02448818949134154, 0.43463853869720387, 0.9591514419731465, -0.2836071111686533, -0.734494912893294, 0.6381527753232297, -0.8301038529544766, 0.22661136742423302, 0.817468090541133, 1.21947422763311, 0.7966713928750456, -0.26588252426782505, 0.2558774589304414},
    {-0.40425286266632776, 0.7964049170958505, -0.20331415758141552, 0.6229849134190426, 0.7317204182626816, 0.6015764821936307, -0.49182479625433984, -0.18457248256834802, 0.12280271315476915, -1.1532691571274405, 0.13800716561586854, -0.34944937773471596, -0.4753301958346901, -0.5495101718763625, -0.18862629146083168, -0.657583144974811, 0.20232670494053853, -0.9520470331445579, -0.8286453363288043, 0.07172835134862184, -0.0745658287007183, 1.102552310944691, 0.15184097593934487, -0.5156232659569897, 0.22141083397443678, 1.035179483571035, 1.242133294712768, 0.09744137409761582, 0.3396399548397892, 0.660610875640124, -0.8215139163928766, 0.1018821370437587, 0.49014001552251746, 0.08886925754976033, 0.7779821366978078, -0.47521266111582383, 0.7108072748366971, -0.6891244207445776, 0.2552208197970163, -0.7458128639330546, -0.8961176542466612, 0.2657257930900318, -0.13474032338384723, -0.8201662159850936, -0.7258549397625143, -0.2720099691500407, -1.1606841323949486, 0.763303549817758, 0.17974288379251732, -0.2135349548008824, -0.557990615336305, -0.06750218426247545, 0.23841856587106525, 1.1848902109051793, -0.6079946973094391, -0.7090988487759734, -0.8369704585559766, -0.7974880382333053, -0.7372820221608581, 1.0626509833532274, 1.044619940911482, 0.6741895451625477, -0.4853293684416116, 0.017209851822262232},
    {0.48239693534088074, 0.5689404889023886, -1.1086821814562973, 0.8104074601069557, -0.45453982135261434, 0.6277986581515609, -0.15111775553817258, -0.26833086159564523, 0.615269455714121, -0.17647098488144317, 0.011744063721529025, 0.8479734432976905, -0.6467414517111175, -0.1678716877209942, -0.2498803605331571, -0.9949909987877643, -0.7981634555347547, -1.0942305554797402, -0.4697381504092535, 0.9514684307208906, 0.1663526018951996, 0.3194265441824626, -0.3778083042836264, 0.5455259625898217, -0.22884576384139846, -0.06294725720747069, 0.6488175332788446, 0.2746216152399339, 0.5091624510416971, -0.15555190638990013, 0.3244312734136956, -0.09238325869990091, 0.7134396054127876, 0.12596305870085567, 0.6103372523249655, 0.6345145708799711, 0.20573510385362603, -0.4819737868128312, 0.07677185224312684, -0.9691596718687228, 0.5516778288650119, -0.6737072973067695, -0.7562280532540077, -0.287582916753919, -0.8565673832544339, -0.9418046476673303, -0.705629840639713, 0.13838617791989702, -0.18046813314090235, 0.29979607264588654, -0.16111445771078087, -0.7903106224788045, -0.8049573324453236, 0.28206358013167054, 0.12998017192146433, 0.19848816896052152, 0.2848505980129468, -0.009002536325940724, -0.9395734779162378, 0.7512374841038931, 0.6129190448879527, 0.3641270954656629, -0.8103969380476242, -1.1575177066548608},
    {0.08926811782741884, 1.1397119428092188, -0.10052548871746256, 0.2744330195776137, 1.1038816779729341, 0.1366233279253577, -0.8124120622111994, 0.4115314255176098, 0.7988509003170943, -0.5055492569077511, 0.6894052016726797, 0.7997108288189944, 0.4961533304576183, -0.4984507231959648, 0.6929549654586553, 0.519377657022855, 0.7866638052767642, -0.6180212291879164, 0.65234255581673, 0.6547630806207909, 0.24087292857076778, 1.2514280598524972, 0.6097409905687069, -0.0682921557368776, 0.7354688258797005, 0.9870648484992467, 1.237715677264662, -0.2563200340594951, 0.6943541762690693, 1.1533346550909138, -0.022126930602851924, 0.10433872681237295, 0.8657161534928062, -0.3078300415342505, 1.3159123995990052, -0.0963795514927958, 0.8776383788718725, -0.7346220046525112, 1.0219498836195264, -0.48315792632534493, -0.4920588411167041, 0.9315809882849039, 0.9077124267477051, 0.18929274197260162, 0.6343775482810615, -0.12381356068983627, -0.30896153432334583, 1.2823268683258204, 0.9510311118495075, 0.1747679483743118, -0.8426055836896761, -0.3527428002989167, 0.36841135606939046, 1.0940702375424427, 0.022585904629278168, -0.39685254963223343, 0.17837733110027473, -0.4245560774818966, 0.04500197861253181, 0.9539279815874953, 0.9405617384361159, 0.9038543111133283, -0.36257959896378106, 0.0620997399613546},
    {0.6170551301159145, 0.7893740068750817, 0.060977579016524945, 0.5754320536369634, 0.7521202336528137, 0.8322830092825244, -0.2497764432175577, 0.3929676674599491, 0.7922402251672795, 0.12754807287156944, 0.538612358122106, 0.72551110463705, 0.17863811821116823, 0.6503964417120669, 0.9620913464971698, 0.3317870206861047, 0.603961008981968, -0.6651353308062712, 0.5057540987535383, 0.9688035079135988, 0.25825913591761257, 0.8066582850556735, 0.740087038456949, 0.37009733846406556, 0.5693874012446791, 0.7564615815506264, 0.8334216711080806, -0.003377290762889888, 0.43774519808411694, 0.7253021898696801, 0.444523680855006, 0.016466773864101766, 0.6717745751282495, 0.3679779065780292, 0.9314049161519442, 0.295922530158009, 0.9426703051093677, -0.6018074805414463, 0.8898416441714486, 0.031232595213363995, 0.4813349947994012, 0.4807232810678398, 0.7271304880906934, 0.2426311121660239, 0.36400392694196293, -0.46330333651998634, -0.1348070669545844, 1.1499250885039978, 0.9865679105828108, 0.8736966469134619, -0.7627968999036183, -0.1252575643205219, 0.24376104046117428, 1.0710446159764668, 0.04754733429876479, 0.0053884024730016696, 0.19289142296949424, -0.28842734228383987, 0.14368248630080233, 1.2081543699571835, 0.9306514372673259, 0.956067187167708, -0.12237939288389016, 0.012159394870623012},
    {-0.10558556030080067, -0.22769742091064363, -0.13911195370182586, 0.2287453403736829, 0.4885974697991541, 0.5034708192415009, -0.17069323391134375, -0.07605343278973287, 0.17746842461992357, -0.7067556232102686, -0.1930732365524356, 0.056653042386871785, -0.3990096878199693, -0.1998852648477967, 0.08711843948022516, 0.3307975828515744, 0.6530634776270132, 0.14022386047554544, 0.5769351471690897, -0.11367824605032356, 0.7231605234917813, 0.5664589415392801, -0.06580347965196953, 0.03694124739802231, 0.5396405715365857, 0.03724269093154288, 0.8171997659926992, -0.02925311418878015, 0.3550375194106223, 0.6004158988790591, -0.36716835823172733, 0.5271817070057381, 0.30324896170144783, 0.12826837897513546, 0.21524411943828534, -0.9548032787684112, 0.9104536613370507, 0.27043086796906624, 0.43003433475795566, -0.1632934655659639, -0.40892846910865954, 0.40977630954543337, 0.22983128861913588, -0.4515301139341386, 0.2919327613874541, -0.3044628398343512, -0.4394798933809227, 0.750504229381982, 0.22206854030919343, 0.23176329678927382, -0.3306040035829276, 0.2645548128618811, 0.358896707876846, 0.5876865004416418, -0.26134698785018085, 0.278331636261452, -0.531047856720424, -0.22104059368109327, -0.38264735271487826, 1.0152703416843, 0.4843898601089187, 0.4384582430007858, -0.11562320337529886, -0.18117976905444724},
    {-0.19445400393433016, 0.16579384456460583, -0.1402794430003923, -0.17377324179679757, 0.2993586798240488, -0.5391813306454667, -0.6811836008140651, -0.4818665666805853, 0.5050549902570087, -0.20248279160161767, 0.5898706384803569, -0.26140911022145885, 0.1328447916053912, -0.38421335296086845, 0.10565571324329183, -0.27321332545414045, -0.1876830920981149, -0.23089237799913054, -0.21280320528788693, -0.08171744287498231, -0.0871182399380967, -0.20438135790036493, -0.13012603572978243, -0.3003794115491589, -0.09865208383007282, 0.4325275480083752, 0.4266522395975788, -0.1257573817965837, 0.09046329140394663, 0.404277046342458, -0.7556289695380842, 0.4091071431357794, 0.26952344372424447, -0.16853198979673545, 0.3289558332431217, -0.4029560951815952, 0.04112769710556486, -0.5245129692455428, -0.11012275055046404, 0.0603877614755235, -0.72506707965058, 0.6516462083720056, 0.41390074110512076, -0.34114237205582626, -0.22102163018744747, 0.4387721056779943, -0.07626291714497709, 0.49721403834663697, 0.2565806068177467, -0.6719791136350453, -0.6667653191253671, -0.24708152422917762, 0.30354822750026816, 0.42972611969094904, -0.49576254848593293, -0.6148136679845465, 0.30696309494298774, -0.7418930363559748, 0.1460503095753929, -0.21287569769076015, -0.09201705208586664, -0.14632722158069578, -0.5149685848062493, 0.11888332492773176},
    {-0.5898221793235419, 0.5454548267837656, -0.2235487919764406, -0.26122137051892463, 0.28330758467632305, 0.07560249893466742, -0.2293075539933425, -0.8385299748710596, 0.1439885781958785, -1.0580457149689766, 0.14596229894311524, -0.5824609969203278, -0.26657525341650684, -0.853737775236329, -0.6395145294359644, -0.4076237670581171, 0.13472427308757917, -0.3217665183173127, -0.44079577303553763, -0.7096001313652659, 0.350890350489116, 0.29253555529516645, -0.15206082754972552, -0.606792697157092, 0.8435794232733336, 0.9254938749163004, 0.8143164337924637, 0.45233067795674486, 0.27603868798155734, 0.8795957478357929, -0.6646108757220449, 0.7005985212798351, -0.2692195998383581, -0.12567964469082443, 0.3111942555424593, -0.618636874345704, 0.6923158295405479, -0.7182324031920283, -0.4191371465611644, -0.19685812169723663, -0.9802387859568337, 0.2673279239308011, -0.5823774365923211, -0.9435586609138282, -0.4858722683183141, 0.06112094607600491, -0.12242106860671761, 0.6897970415471247, 0.026832057934309903, -0.6396180148393833, -0.6816132778858868, 0.1599231892755309, 0.4691494807089852, 0.6844567644097262, -0.7474111891279626, -0.7228806984686295, 0.03462593007170282, -0.8083479145386564, -0.10480670016766737, -0.15229049195218894, 0.6805944103679877, 0.3625828882001604, -0.45037466308622487, 0.6035473670650198},
    {-0.14337885092236102, 0.6645611015598896, -0.3194073835775507, -0.04408891796028257, 0.09640556166235568, -0.8504741223823019, -0.46108392729185316, -0.11907937282699303, 0.9187568587537587, -0.6540785456110196, 0.10897674428719457, -0.27588372593505756, -0.2604950053594871, -0.44224335954964733, -0.3592223790089412, -0.45047736368477564, 0.2669195096420455, -0.703331422119837, -0.441721081662834, -0.32797562970017546, -0.2548108810529477, 0.27762361967539434, -0.22603889697279292, -0.8018415359089173, 0.1692270566860906, 0.7350455617645403, 0.559308534926321, -0.3781036332130649, 0.39562115024506184, 0.848155232648083, -0.7228492571376993, -0.00026129285367335335, -0.18046468037610416, -0.8314193477789164, 0.6329511474869182, -0.4231625526695722, 0.08075752943929476, -0.8352199278577489, -0.19785307254186646, -0.17536393953240773, -0.7175582239319446, -0.2245833419139772, 0.4370027291116963, -0.7061584356913646, -0.249424530439438, 0.1674768946210767, -0.473342210557314, 0.6052070560645035, 0.5182213984439269, 0.015837590701519546, -1.005447672800507, 0.0011495028930037523, -0.04192615622224363, 0.13629498987369712, -0.7845923886312749, -1.0770203547756036, 0.3914069265326626, -1.0712475950579063, -0.6633241287166813, -0.09638049596026278, 0.6348596060945744, 0.3197024802390948, -0.6652861439173786, 0.17884678087681402},
    {-0.4647447390759895, 0.4514865710252871, -0.6458499668773797, -0.3202446747015248, 0.043833067437720384, -0.8390692309589943, -0.1560056026715431, -0.49233315844417364, 0.6167298706182237, -0.4399117665879369, -0.46503561420153716, -0.5406715010022725, -0.5824656298813592, -0.4561466258336682, -0.6036128639373085, -1.0490005210263538, 0.0020005129887055006, -0.7735825532096475, -0.5968612620544513, -0.7641528528614249, -0.015693482085182106, 0.19900517497756115, -0.4195564527461336, -0.5922089444799247, -0.028850418066438642, 0.6465689786864063, 0.7275097543884028, -0.21869743372032033, 0.07256402853905529, 0.7750184456913505, -0.43194578241742965, 0.09436411009654344, -0.25958780385006086, -0.4990160697487524, 0.04449435641019729, -0.7904398681962989, 0.963045205417282, -0.9340794346900764, -0.4743267916576226, -0.5745181230652431, -0.9401586410786007, -0.06190897837247429, -0.5559917523534043, -1.0158071146469194, -0.3915480694946284, -0.6272588677065658, -0.22574468268969497, 0.29451053822679635, 0.2991275477872304, -0.6534935663460805, -0.8855185070218656, 0.11909421428996571, 0.6198278693965282, 0.46299415775439395, -0.5153796455514064, -0.8816418986525094, 0.4642390097937459, -0.9468897437396684, -0.6781432347671883, -0.33835745475327367, 0.31946297314289707, 0.21223567934431298, -0.5276518473714285, 0.5471253395851744},
    {-0.4344463934592553, -0.258734006980292, -0.28166064566831867, -0.9802103324947332, -0.5466635736818382, -1.007502207484188, -0.07242471545267054, 0.09368920601154464, 0.48902252160535936, -0.567035103900003, -0.30159349720769996, -0.910715726880907, -0.20329051006379623, -0.8937527954071842, -0.13271456002700496, -0.41734584871742053, 0.2655340331371316, -0.05206647598062251, -0.8387339876708336, -0.7381519099100066, -0.30338612033900125, -0.3538933374342524, -0.4083658756611934, -0.7876634326245929, -0.005999571409640582, 0.11080257870324109, -0.6176361328206577, -0.9247538846020685, 0.02565416887547443, 0.02279758367416465, -0.8101589411236905, -0.35014050446019146, -0.697703429994753, -0.9017680223503519, -0.8945273965378849, -0.934685304510071, -0.0677890940643127, -0.5142550699075775, -0.7141153352890157, -0.45226131625593263, -0.5603402112579086, -0.3408069335901132, -0.1366732406948918, -0.6913926310330963, -0.38910337096745573, 0.008268585942919465, 0.2870351789574665, -0.10027314750490096, 0.11624154847922955, -0.8063011424058653, -0.3288772472263634, 0.0128632473797624, -0.15758585097331473, -0.6673483258860917, -0.6606340552721494, -0.759401048103752, 0.8271851807725202, -0.42290859172461615, -0.6325389112117944, -1.1355440215467871, -0.17118429767555993, -0.2888148425748483, -0.42092459010334443, -0.029605315787196596},
    {-0.011411578237866496, 0.2644101185608089, 0.9338802436545204, -0.21966118191288503, 0.8802517537622742, -0.7227913881291331, 0.02949687874625579, -0.17041587307739536, 0.7034110057517986, -0.4642751167654761, 0.23179274481121104, -0.38467149620265256, 0.5909844542885572, 0.16942438310592753, 0.23622028200747705, 0.8145629439275269, 0.9151918139740668, 0.39055459054360175, 0.04625714878551792, -0.5181341380303882, 0.6655043371813725, 0.31034194019619504, -0.1986329950036318, -0.8303734008567232, 0.5999970199812973, 0.9355494127548969, 0.5730584430596006, -0.10852822829950197, 0.7340844379971393, 0.7619581467753853, -0.5973739470588472, 0.9152900233605438, 0.006696341813269876, -0.005701549527306428, 0.2907075305979665, -0.40983923133036315, 0.42375347537249164, -0.5799506273350243, -0.050691657580792714, 0.7482934370916774, -0.5634990753419898, 1.001881233258257, 0.870138521177551, -0.48356409954682417, 0.4551930015378433, 0.8287023810464225, 0.6030181543861056, 0.8464413314241702, 0.6874366585082493, -0.1273053499753811, -0.7302550608071708, 1.1865747031150125, 1.1827114309337594, 0.4343395788938476, -0.5536782025302738, -0.645662464700237, 0.7087677625041197, -0.4878487235870279, 0.399712390073773, -0.5943014933003268, 0.4191420140561944, 0.3876508851047011, 0.024260849895081132, 1.1857817097515357},
    {-0.5321905571032618, -0.21394442424316212, 0.805276646642487, -0.7396362083654996, 0.31045953984096614, -0.5408287075388795, 0.5229111572418124, -0.29522574277792685, 0.24013874533654564, 0.2315234129747795, 0.26876426078571, -0.5110561823255201, -0.11395130214061285, -0.42298799604739634, -0.32575849769833126, 0.3787519171725135, 0.7410829129512895, 0.3217732207600364, -0.46892905452267847, -0.9676687278531324, 0.0919767230038667, -0.4098307761984662, -0.47466676590434975, -0.7929596717831031, 0.2298781283339583, 0.5929829587893983, -0.05290849315855127, -0.4520646635862214, 0.5890572113102773, 0.23330184677899585, -0.25381195171383114, 0.28618318012804667, -0.5052216123672701, 0.07145180008786016, -0.42914003292663105, -0.5821200895896472, 0.5008587267817709, 0.45408791011124544, -0.6216715125313331, 0.7094778527592736, -0.689348996177411, 0.5264705772016494, 0.5659324221207599, -0.302607324473016, 0.14798247702006193, 0.8631335309185495, 0.7378962533369852, 0.001529646409473337, 0.31792319041292216, -0.5421464217772954, 0.14337806226576538, 0.8915247042469324, 0.9749880426021184, -0.4211012035246219, -0.18691898479696492, -0.38273198376098255, 0.1686548168514632, -0.186208172180176, 0.4665639290886689, -1.2711954044452096, -0.469706598425056, -0.3747520131869075, 0.22866119923779366, 0.882980879267608},
    {-0.05042440156390424, -0.6963885039949779, 0.1600347980448522, -0.3514215684302247, -0.3607684660565797, -0.39816886013565184, 0.006378912916530416, -0.26117264019183056, 0.5306593787740879, -0.3008712636672278, -0.34594020096319766, -1.2140627623388578, -0.5548650608294496, -0.9923740609707339, -0.4173284993941044, -0.5367689707482175, 0.2813212504688159, -0.7896751961766444, -0.7517709787398791, -0.9336738863248621, -0.14829630517372, 0.030547460254014353, -0.9727353116657576, -1.005401460592675, -0.19402031097939693, 0.29894876668498754, 0.2807502273868163, -0.9390171936595719, 0.8023345373921638, -0.014667333776248922, -0.5868554156952119, -0.09641238479427329, -0.5230981627010965, -1.0644557893710893, -0.6725755655535957, -0.5495384313026689, 0.4878924132561397, -0.46709240063737034, -0.9456341402426159, 0.16988300722084107, -0.7546302184026655, 0.2270732349092873, -0.08114507700943101, -0.9390747139389849, -0.4759707432394052, 0.18260952705131578, 0.02171611281089558, -0.11404301599394809, 0.14608683594569102, -0.15297701332730237, -0.2621716763030821, -0.02770391131808871, 0.6668915213674905, -0.6947894569847791, -0.7226149649597706, -1.0915555488421764, 0.17955681138143578, -0.6482783908062579, -0.5026157412991193, -1.004110072980527, -0.511583477568096, 0.4066680713424758, -0.6129407860966428, 0.4618205432458889},
    {-0.8100435547463978, -0.07164892414191464, 0.7548943879390226, -0.890018583404297, 0.2020994243867878, -0.542880115805568, 0.4885034518766874, 0.023685922685226492, -0.13176864608810104, 0.09189846990725539, -0.2766326389993259, -0.7256013103798642, -0.2712743099666657, -0.0936735993310319, -0.3487171335105264, -0.24663101719877023, -0.2683487294763594, 0.41152546718477917, 0.2007713440579048, -0.6522391379547321, -0.3993337167511927, -0.4736320212996038, -0.4536421160765078, -0.27891175440740107, 0.31565576091846503, -0.02779072417790503, -0.640658603658871, -0.4414824759654646, -0.03241684560924718, 0.2449846727594017, -0.5832515786184699, -0.2259205984342153, -0.9623031461452011, -0.5873289314630529, -0.6385138257134688, -0.7532029041716644, -0.12347699718595216, 0.13573921427560004, -0.41274411463411287, 0.45148334906294174, -0.9321743311949701, 0.29776906199939435, -0.6018414776596667, -0.33801700708694543, -0.12167019040462018, 0.9394091257546159, 0.34555761610560914, -0.8031148021411725, 0.1625719607975148, -0.22579067182902635, -0.1874321983328757, 0.18871779193881802, 0.510948601046567, -0.5822842853179779, -0.13239548835854806, -0.34594041051614216, -0.020985418601339866, 0.049344706128753225, -0.14795215742438544, -0.6462920935609446, 0.03591676017988273, -0.41366666526158485, -0.19673032382601235, 1.2670399882745484},
    {-0.13440824376255217, 0.3432705745844915, 0.6397425627153999, -0.28617452469684584, 0.7613818186502467, -0.628842243114227, -0.6461452255080885, 0.05837584258386087, 0.4497866528349052, -0.253345075016664, 0.3546539838892223, -0.7298758970906989, 0.44031311674060075, -0.8315537293415672, -0.11413682769542154, 0.28679974451069845, 1.2776501159574136, 0.05170031483941096, -0.1284451318042962, -0.7947890488061112, 0.2721881238280842, 0.2617642820800647, 0.22076748447876068, -1.0782738738543476, 0.6981586227645096, 0.6122471244699526, -0.05806425020164448, -0.6991287795082979, 0.3778458146901874, 0.830472285836766, -0.3475991780436228, 0.6621236271960836, -0.17034846022966166, -0.5129608868639406, -0.1272728160237172, -0.752358950031416, 0.528804075931582, -0.5701490005719164, 0.1627917064452577, 0.6668287797530305, -0.8923825668299326, 0.7806576085861741, 0.5158923595081965, -0.4190434298253308, 0.40937649455369524, 0.8249536510819114, 0.2655666689108192, 0.4632339818544506, 0.8079960018424113, -0.2523668532321745, -0.8596812852782492, 0.6006852701526686, 0.7688104066520492, 0.2571857221354792, -0.9659755644918017, -0.6358052135782432, -0.06967031435557024, -1.1390443730384519, 0.35918443170726805, -0.38908453329071646, 0.602356796669754, 0.1912012371809371, -0.9092542979319872, 0.7938311510500612},
    {0.3150398154885918, -0.33046073751917543, 0.2875068075152555, -0.6371768416778312, 0.359492990254916, -0.007532153378933551, -0.010644174876058222, 0.24242496823967316, 0.35779675169550124, -0.17045688871911116, -0.056779201302696966, -0.6257352146730073, 0.19334891641449883, -0.6214829035200834, -0.11333632888151529, -0.1476565922821879, 0.9965444631319738, 0.1851738346132656, 0.17794412117041591, -0.7508379458805231, -0.13603245353245472, 0.417294547427207, 0.065177248046494, -1.0235265287304074, 0.33383199373551903, 0.09271067046803812, 0.3495726571606084, -0.12428989304889854, 0.22096370159901074, 0.8466014394704376, -0.6653443574333274, 0.3727669271630253, -0.2656970713456963, -0.8020075113336448, 0.3043636384207884, -0.6117447865512768, 0.6254460145019899, 0.17882325072264363, 0.29881280377728964, 0.1586193893366024, -0.711526938083044, 0.7595521757622534, -0.4244403533058302, -0.8028216912954846, 0.16483629512385575, 0.25179996926798515, -0.03908043165089073, 0.6065058492138475, 0.15086131204427147, -0.06607646449267741, -0.9327999608602421, 0.31233569897822283, 0.7085579454307995, 0.16676977207486818, -0.38848004507273276, -0.5964301962602355, 0.12770218920559806, -0.20371521771367124, -0.21109871201948083, 0.415634011618197, 0.32613801944562143, 0.3454046724296074, 0.20485258477018264, 0.6184643599765924},
    {-0.951769602803648, -1.14184015728293, 0.36833129694268435, 0.239926235696458, -0.20505996749983235, -0.8083458218231214, 0.30754695726937165, -0.9730441356608538, 0.18056399075660523, -0.037811782417858264, -0.7193324531101157, -1.0898861891519303, -0.8036091453976928, -0.9113748638273734, -1.2373117108655571, -0.26735375625783886, 0.6908629563172468, -1.272264909286763, -0.8833026523043866, -0.9010100573229151, 0.03712914560486137, -0.8967788924715322, -1.0704128812944782, -0.9235168178319246, -0.15893323733227518, 0.4131916520069296, 0.6352672998119635, 0.46598311995048175, 0.10508146682301887, 0.5565127174889942, 0.33836265666680365, 0.20907400928449754, -0.7174778635149563, -0.8404722239270541, -0.925808714272858, -0.1376532843620776, -0.6391186395019358, -0.08983868854112304, -0.8279533807668602, 0.2693428071788781, -0.6855749614097326, -0.023443476483037046, 0.09284876777014389, -1.1474686944616594, -0.5961998622003623, 0.2445704934536772, 0.28895094210081496, -0.8090015856439641, -0.848303763247237, -1.1660784327152716, -0.015888601987415606, 0.39753506748128364, 0.14793251459302928, -0.759025117594258, -0.18723580012591728, -0.9586747675824487, -0.461511510400543, -0.086426601933825, -0.24596337240097185, -0.9253770383166717, -0.926567817086959, -1.1813117419852304, -0.9245018143746396, 0.5021482927730265},
    {-0.5149995021961545, -0.7405743076717656, 0.8171794573564266, 0.6923036216228561, 0.23950851793637118, -0.23184802328510098, 0.024929215688268225, -0.72910351899694, -0.2622479668510574, 0.5113378780713472, 0.18142381456900272, -0.7676129273461215, -0.8817991581651586, -0.08375904838777778, -0.7395261417417202, 0.3523362104551234, 0.6938839928192686, -0.45695444933068263, -0.586546983150207, -0.7605437677278415, 0.6874421876891853, -0.5311969402123161, -0.8665589032997654, -0.9900962695376778, 0.7218666151522669, 0.3485110973364375, 0.45980407285294583, 0.09080698648179569, 0.6282075192734698, 0.45351710425139774, -0.09438291083133049, 0.41294410455569397, -0.4104962736943633, 0.21082390798858314, -0.9105548269662997, -0.26155035942635035, -0.34478168368886997, 0.6722998251735847, -1.1127810540038823, 0.6555618872775595, -0.6350678596465709, 0.5902828382024419, 0.44396074628473947, -1.0047046194400406, -0.6558792814062979, 0.7391365898061086, 0.16399547779202242, -0.34540114806466315, -0.5279671351336539, -1.0774202839447526, 0.4295839265537164, 0.5123812252512218, 0.7241750312238658, -0.4805067142287997, -0.24940155898897964, -0.7288755813201422, -0.026541254540183818, -0.08457405990886677, 0.2931454766816707, -1.1271299090650437, -0.690497865043264, -0.5835052756141924, -1.0880692147332285, 0.9171601579435009},
    {-0.5058576484275488, -0.5918011905725028, 0.5775136121941182, 0.229031747290124, -0.12513703776571156, -0.2600947564401127, 0.657462480519673, -0.6391410477350425, -0.13824242605356507, 0.38975777145422147, -1.0459569682136656, -0.5727827715121968, -0.7344537110742625, 0.2525211553352913, -0.7191677211854651, 0.5147966696210937, 0.8959544281029168, -0.5321762501606989, -0.32376314417792584, -0.4870478771830231, 0.5022499600919442, -0.8150295781717422, -0.619806552428644, -0.6290405072187785, 0.534852515161088, 0.011194488699524295, 0.27181427987183704, 0.6130933237359302, 0.11854791121546629, 0.13673009692439242, 0.16401052131127167, 0.2754845541754531, -0.559765625149663, -0.1409032020454377, -0.5642457890166124, 0.5392453212000421, -0.2459454172248764, 0.5451045296277175, -0.6393482715619795, 0.6541031940556787, 0.6525114245455786, 0.1387376946280517, -0.22007993381192567, -0.4106546174682894, -0.8235473147376765, 0.5214209247583531, 0.08460188210455684, -0.3918973348895552, -0.5078847196882136, -0.5597908532275686, 0.7973385106851549, 0.3748250108205445, 0.4847083210135983, -0.6506878139172945, -0.05721683736329079, -0.3157339270190062, 0.107234878932644, 0.6066558350023656, -0.17177700046685165, -0.9738631575992525, -1.0080324431830021, -0.8631168554976568, -0.522338766083087, 0.4281940730372101},
    {-0.17120413070822083, -0.6918527968562727, 0.27312401690902555, 0.541842525385901, -0.3661903887690815, 0.14031574640251188, 0.7179203509009798, -1.0258948994849442, 0.18406414191224377, 0.09910444609428024, -0.1436418572039655, -0.2740163283476393, -0.2819453087487696, 0.046729434496006576, -0.681654876648836, 0.5433077768340258, 0.4286312589711312, -0.322440759452639, -0.5869217016106895, 0.08029085459834193, 0.3705553159527091, -1.0273550197706298, -0.9053343683064383, -0.30468756368698924, -0.06453505910918804, 0.06788921465959215, -0.32263355171577607, 0.7201580341815796, 0.5151203003248533, -0.3475533874229099, 0.2624201026186841, 0.7232126587877369, 0.0975980869555712, 0.016510854308645767, -0.8831216380554829, -0.009036729278244462, -0.4394097836007925, 0.7152274768311082, -1.2339256748763603, 0.6750273574384967, -0.012341971989856239, -0.029596147544620414, -0.32479763169301457, -0.6897024047809949, -0.288708252966493, 0.430042528317025, 0.0977320054007759, -0.354816489582466, -0.8310389341611447, -0.59838587863744, 0.6022591610105086, 0.40516835964381737, 0.3931387747066951, -1.0662754077382612, 0.2451685554306142, -0.04527065288136623, 0.1481057036708718, 0.14765568393408116, 0.17278482686465219, -0.4308576913016291, -0.9041995744149749, -0.773791217732533, -0.1996453667993702, 0.39292394384046764},
    {-0.3119776654849474, -0.2882682622983267, 0.8108465700682848, 0.3706530864112405, 0.17828072979692938, -0.22652355824910878, 0.42656489154769717, -0.7589103015210105, -0.10687522685779598, 0.48914310771347724, -0.22041247844760908, -0.6926204548001658, -0.6976844955441933, -0.648878850910797, -0.581497930813871, 0.3710714861171922, 0.5326254368780843, 0.19883602783171292, -0.46636791340107125, -0.346344295386751, 0.6868819349274141, -0.726706653120116, -0.30421030170107133, -0.032768034348029496, 0.07497003139665158, -0.03895825212996202, -0.34206655768507127, 0.051987106589761314, 0.3931610221211889, 0.6216106802177811, 0.1677401892961478, 0.03732715151514303, -0.7084446695691745, -0.008550493430067942, -0.9575369061584129, 0.16876291706295546, -0.11139478963483858, -0.3336340972854214, -0.4116611515565515, 0.5772303151377957, -0.6016003683986557, 0.7098499348430615, -0.2671244617401949, -0.1965955848481355, 0.08398459459685262, 0.6991115206376156, 0.12285227685109547, -0.04099693542128497, -0.9079243158014674, -0.8019241295760282, 0.675875505556885, 0.8954678320959049, 0.4362593922496749, -0.6207155140226934, 0.3746491597665585, -0.0729628636257856, 0.0808969514455918, 0.05660563586854959, -0.06537274544747272, -0.6666589311978129, -0.37807775307220143, -0.43718592701593745, -0.022385779272844335, 1.0286519964306886},
    {-0.22184770294086814, -0.05865677946965211, 0.6027874491801771, 0.1740708672705381, 0.5727149534548147, 0.02472087732948678, -0.5070253886006895, -0.7676018394679738, 0.058376844923240814, 0.4194609070562932, -0.00724821972945788, -0.09068103601306213, 0.1326119736851402, -0.05120186970055114, -0.2741686603884351, 0.2964781906497413, 0.2513664349918994, 0.3684040825150449, -0.6575218634383071, -0.6655615485912079, 0.4653865712407195, -0.7062152335521719, -0.6574973407043312, -0.2535830528522414, 0.45445452370223904, -0.050696110736957165, -0.5384951911394118, -0.10990179686044538, 0.4966369127163782, 0.008600672171146554, -0.09975439745384812, 0.029529211113010188, 0.13591538633685962, 0.5876918140683757, -0.6481217869634784, 0.12100343392135257, -0.20595694790078334, 0.4857149245903714, -0.7451482224800392, 0.6296799538921561, -0.26882839719683055, 0.14842721952731963, 0.6109686820823561, -0.2988676511572094, 0.07464207840713803, 0.3281416482223011, 0.7223998431353092, -0.3136777588039091, -0.7250718061319822, -0.8296839319562391, 0.4303717634800165, 0.22710782209832575, 0.5883210317871831, -0.7377906522358358, -0.5641108415481558, -0.361244566410654, 0.06861439977098793, 0.125942067607736, 0.21803965843545098, -0.6549956356326558, -0.7574098428235776, -0.49504543244337884, -0.703289434408458, 1.1618931206151388},
    {-0.513715708295624, -0.6031253949708087, 0.6588794059174877, 0.27544368849715783, -0.3446432416066093, -0.09367499156682814, 0.6301846082571717, -0.5488298476916756, -0.28690807751602626, 1.0330557661250062, -0.24258939348121056, -0.4737834776559239, -0.7353726902904348, 0.09159270534564136, 0.050435880349864286, 0.3230409983333985, 0.31716292665644724, 0.5057686144813411, -0.663307297358736, -0.39734686605518793, 0.8813569787312644, -0.6387287590115094, -0.6099028925062683, -0.5031678800609521, 0.4842250533283444, 0.25876008138617584, 0.19885629030691457, -0.4426699311234134, 0.3691190433587478, 0.6020423168248886, 0.3404667759441908, 0.2031551088720004, -0.09384091035655537, -0.9789441907003694, -0.8205983564409506, 0.10525040184162512, -0.06514791890545907, 0.7245370253968938, -0.5790198927708742, 0.29401626858157126, -0.1518942553657716, -0.06411458514007244, 0.15427772282326357, -0.32339671139340626, -0.1635111759188871, 0.23676101886097423, 0.7335784602129652, -0.46890913944639406, -0.9511553533058049, 0.0920779887220271, 0.5778188909714459, 0.3589094588241255, 0.44262175349719585, -0.2786771833482807, 0.916621049643883, 0.3141533271664017, -0.13523762335101994, -0.20951923819482018, 0.749804663917745, -0.16451676610390045, -0.28456049029888536, -0.41254298954669333, -0.2584175705194013, 0.5484517619753594},
    {0.0642892780887014, -0.08704440151187369, 0.6339242985675285, -0.1882692621628772, -0.14292432538617852, 0.2688692649648792, -0.2058970556390017, -0.6470467277992178, 0.08645255797528444, -0.06784014748395494, -0.40985839207653774, -0.02051664516766232, -0.2148610039663393, -0.3746049949849545, -0.5983822151363818, 0.6192401485137999, 0.2689002077874923, -0.21370679276130727, -0.4565445648659966, -0.497812475938972, 0.7499262937368776, -0.47153908588444476, -0.5536900417866643, -0.40607985970116, 0.378343706385529, -0.06379221927874086, 0.020094686484873486, -0.5388422959345591, 0.6660231975702502, 0.30285241046024497, -0.23126811928793736, 0.4841207550941081, -0.5956095856627858, -0.17316182016635603, -0.4186139673785044, 0.007705447430761885, 0.010523767436153485, 0.4203295830642527, 0.07107228216984754, -0.4696599138908632, -0.17462108962560374, 0.11705910618047512, -0.13981507163802606, -0.8931539931034348, -0.611978676639626, 0.2931317780043574, -0.6087111006976377, -0.2817877062773505, -0.48147715306972777, -0.08558526261213056, 0.37959014724241014, 0.1842664673844914, -0.424774962257347, -0.6660003458150124, -0.5003303971910024, -0.06947648510010071, 0.7007888514821433, -0.29601949826995105, -0.19287264011189187, -0.23436072441574954, -0.18846304622954524, -0.0803797118328821, 0.30975234609167923, 0.13508059320170054},
    {-0.4291219186631787, -0.40909049755851207, 0.6027144732855381, 0.558861946964131, 0.6339430367551068, -0.7375978230938326, 0.1746079011010931, -0.4546634429111894, 0.05351193517625036, -0.43738883725562006, -0.7387327879172613, -0.18133206224593265, -0.6118039282726399, -0.08542002741590593, -0.18854857103953956, 0.581082422144206, 0.523882774262541, -0.24024984516104694, -0.5982458335462252, -0.03756497731435878, 0.5254368132418907, -0.3217129201752977, -0.43357085221781083, -0.42897025407422046, 0.3198530528824563, -0.2034533274026352, -0.13474939208511932, 0.018195123330429133, 0.5380658289975111, 0.5998585351377853, -0.19733447596457585, -0.203658331291365, -0.13960153412997447, -0.18812044873930597, 0.13290180431862864, -0.06739915392024856, -0.2688708231891849, -0.2558719174387564, -0.1258065072183289, 0.5065242600319011, -0.4049955795859754, 0.020500192736766263, 0.20163722843785528, -0.8930023759422187, 0.13621188609341786, -0.18406636380017774, 0.5817006952271401, -0.09771148598853936, -0.4633856089758886, -0.5173455591083905, 0.43975159579283696, 0.6290788231621863, 0.06503837646823317, -0.4795105056277298, -0.5502061814780979, -0.2468331472516642, -0.2570284700263507, 0.22479353970709515, -0.11058915950402196, -0.1180324988123338, 0.18446281740076115, -0.6203113419870175, -0.44230305991542956, 0.8802681468034055},
    {-0.3753153196256487, -0.19646506555740367, -0.03274212584645652, 0.5968054407232343, -0.05123507556307097, -0.2847582420507178, 0.4754409921076358, -0.4942904746174631, 0.534306044550579, 0.13118323872980506, -0.2607559790487189, 0.2540896149129807, -0.08419763390574388, -0.10275477132356829, -0.17879530676690553, 0.24733257568711858, -0.12809366584023163, 0.35289383278180364, -0.09269264661052244, 0.10451187008631353, 0.1803258376145608, -0.7245224951499264, -0.4842956754937856, 0.23949866611482717, 0.4488513509471054, 0.36946823740645446, -0.3795506844955755, -0.11399946196666458, -0.6489271300429486, -0.5086880552270997, -0.23967392911373508, 0.18162667511185576, -0.2853917886854605, 0.3054997566298487, -0.6797618083996807, 0.22622585606514328, -0.7850612746768205, -0.3616469922186794, 0.28561093083974515, 0.6508755245113242, 0.38045401095775744, -0.4580624403413467, 0.4773444890138596, -0.10220069116026281, 0.2547422940786542, -0.769727225773297, 0.20717515218158555, 0.3385797963163401, 0.07978390809345688, -0.5721449502727766, 0.33102696704308415, 0.10490281459097733, 0.4357778631929574, -0.6369505578764154, 0.03437800015071863, 0.2223890614648481, -0.2432854211080706, -0.002811888887294167, 0.8172661736750666, -0.18092217558387544, -0.427985820727735, -0.24193233223268984, -0.3881925763124986, -0.004488315601074233},
    {0.444198227722975, -0.49945874514919164, 0.8113831898806022, -0.16269817776397258, 0.08556840930323542, 0.05745794797666037, -0.14864212739463623, -0.461299278398226, 0.16319672479768935, -0.15205101721187578, -0.16292508003041317, -0.0183504822232935, -0.028572336261288765, 0.5132083322231937, -0.36814153432047936, 0.22726570157335294, 0.7965748109743642, -0.4265436911249736, 0.0689230080297483, -0.008314214898320104, 0.595208274037441, -0.16992632721965675, -0.3054746022856805, -0.07000715128631448, 0.022531284236725953, 0.25564254463648894, 0.2667874828643333, 0.13746919581118391, 0.7967243055072518, -0.3575076891050643, 0.4132736986314734, -0.20774347448651448, -0.23696845233448283, 0.44260075169746416, -0.549379691573498, 0.11908213490215515, 0.028823774317402507, 0.5046032104216376, -0.46406932028662284, -0.11953530986015255, 0.21545836645023542, -0.4010327254307106, -0.4457901058561336, 0.1096929630912566, 0.5554529365854154, 0.09168075326836919, 0.6729401512607863, -0.015445272011109656, 0.05660118194077913, 0.07586207656120075, 1.0709831974160622, 0.08748175551163888, -0.13842276268752976, 0.08525877098387229, 0.36509073883443344, -0.38810995798494496, 0.24075873540465073, 0.2494654157322886, 0.41756938389668913, -0.5080566873907141, -0.5903810103656837, -0.06332381155389893, 0.5769366781233162, 0.5457105903764817},
    {-0.2358848084035486, -0.055692464376369766, -0.2364466369921935, 0.9041821299388004, 0.22335534506408777, -0.42297124704938427, 0.004625558201769395, -0.4582341365136052, -0.10410218367423237, -0.18618678610897285, 0.19797556183579346, -0.040700021498919325, -0.37801143292992384, 0.6173839968316966, -0.4016622548657614, -0.32545585869357624, 0.042115765678624226, -0.32411864037437993, 0.1753031780537237, -0.1327044235763347, -0.1064347846646202, -0.600358717083442, 0.49064541880905815, -0.2903886785205949, -0.049035984840282806, 0.47465963910954745, -0.249724236234702, -0.5742326988552623, 0.49744930015142974, -0.28582671136134585, 0.09857038003510661, 0.2955028412240482, -0.5670139943144035, 0.18118317849149002, -0.4999763370870451, -0.051869156486737344, -0.17210656362270288, 0.9296067817784788, -0.13665671750924432, -0.05184230552099304, -0.12519125258015104, -0.8118744805973803, -0.16649956617007164, -0.3537969602883288, -0.0035739966586633785, -0.5030018421289059, 0.8474297214575117, -0.5274647843639474, -0.4517699089830586, 0.16755296245376858, 0.35082582306725246, 0.5940790430909848, -0.397579198564069, 0.14230990703586552, 0.03929590694914736, 0.15528545910084893, 0.13341330621469083, -0.5203958443871521, 0.2354707938047543, -0.1363793852559355, -0.3009091501639812, -0.8501456157425406, 0.5106279423702331, 0.378230790580508},
    {0.7762608564668574, -0.5255406534745839, 0.3303087671395221, 0.25127469385115725, 0.41942226830547163, -0.6493345024584505, -0.19761104044965758, -0.8216258929916543, -0.26884933531385913, -0.41091822113144727, -0.21207460412560641, 0.6349713297704349, 0.14335566489448837, 0.16369106928332272, 0.1313767716692732, 0.632597964194293, 0.5838273655969114, -0.13205478411683913, -0.6680745184763822, 0.15284457456320047, 0.11351270759956623, 0.33746345959845203, 0.2648434648013522, -0.6700713903728568, 0.9146287393964297, 0.5854305746402314, 0.3882340619691852, 0.6549682944512447, -0.03095164611845083, -0.04077116054143705, -0.39939058270901745, 0.37382916417564604, -0.2717658604863588, -0.2190559617881961, 0.11115464165917371, 0.19888674929900718, 0.08532784291754889, 0.6280535914163099, 0.3515856016228157, 0.2638434661523246, -0.41910025657223776, -0.1064321365932685, 0.08819375118794852, -0.36227185641485926, 0.012413834539092495, 0.11388584761520582, 0.05856128669720827, 0.006505520292373277, 0.4289659436876613, 0.11824330612591491, -0.12037614158341803, 0.6450887739397881, 0.3070585634059215, -0.2897011717275995, -0.30894078989728185, -0.18797379098765873, 1.0288528068456946, -0.40298530268395016, 0.05259382546193405, 0.409562621015315, 0.24111397540798638, 0.09615452635027805, 0.4669010638351601, 0.2999992327498628},
    {-0.12916951095686863, 0.25841409338718246, 0.02697634658167836, 0.4861221481314806, -0.42144042001256893, 0.6276908407805223, -0.00923248839328142, 0.4446773509968028, 0.37373033012681706, 0.5017856124301243, -0.2800616618038378, -0.5157911960808423, -0.48481169678038, -0.08961711509880435, -0.6351388797738785, -0.27108933081009573, -0.019344407040966172, 0.02699949571956744, -0.4284197223181283, -0.014794558127260443, 0.4933517581272882, -0.11251329011691188, -0.6206175702197734, 0.2741602879616985, -0.11855202653861818, -0.3619599205543953, -0.6490857734035763, 0.24835695055299373, 0.5988869263190798, -0.5003836710912779, 0.4830848797234445, 0.8015708138654922, -0.33273973430323744, 0.22836861243773693, -0.7949441706807011, -0.8459159263356412, -0.10822466769823373, -0.2955036673529365, -0.4222191222937923, 0.5233338519478699, 0.07051477100520823, 0.027837948728202735, -0.30562194572418777, -0.461126634242227, 0.45962918467085123, 0.1600957009324549, -0.5432774772566757, 0.4453468944657341, 0.636339781133397, -0.10497280428932176, 0.3776756438269708, -0.18665533762804015, 0.03103483278280875, -0.7948082699044798, 0.296924612890719, 0.5928450623346446, -0.5083249743239615, 0.02477757770326639, 0.06482407978747651, -0.3606551996196995, -0.15915319770526634, -0.4248628966496768, 0.1809728729014444, 0.41995077384292845},
    {0.14132218261840432, -0.2434203958658517, 0.4060772423853978, 0.18134136608069795, 0.2825077816884549, 0.1556428241905226, -0.48903443764946763, -0.040084670363138244, -0.20683454993257033, 0.6372695739780981, -0.05300283237682956, -0.13997179030182402, -0.09884400375328059, 0.867276856124934, 0.6237109000742498, 0.5896914630144348, 0.5705270557908191, 0.17535418751013462, 0.14244785325675938, -0.8347443874002356, 0.6186675817023037, -0.028562207068655598, -0.09785123460212351, 0.1432764384752512, 0.7162129843180981, -0.23829852628906337, -0.03240515920895824, -0.21935783946797846, -0.125482655745743, -0.3898654107481832, -0.25791499511919075, 0.7926983519977336, -0.910095313383472, 0.7642529256769934, -0.16149968935287837, -0.33199944192710806, 0.15803995344081098, 0.3080489186857774, 0.28683487834325866, -0.41414348444958643, 0.5594757346510877, -0.2645242112847463, 0.08163133491012849, -0.4399604263593051, -0.25806083503800814, 0.6634479602854044, 0.1986878582978342, 0.13678501463524054, 0.12679855422212855, 0.18608043947555855, 0.7370407470708613, -0.29436623656906497, 0.1690117206389232, -0.3309061272795929, -0.0671609753512905, 0.8516817980541177, 0.04471020725359035, 0.4730185966359506, 0.6852664959504802, -0.07113984026951778, 0.3752754170532027, -0.26449932011804456, 0.3419805349761915, 0.17952411701409074},
    {-0.5814847258437885, -0.5016524557537626, 0.5367348595748275, 0.10899643892661902, 0.3259267353357622, -0.141154899325346, -0.2678324789994117, -0.14744280648349706, 0.25902646414227243, 0.1673727922347292, -0.326327893173554, -0.6536029946537623, 0.14446963538221744, -0.2810547272946454, -0.08112622435515247, 0.6745811642742054, 0.546062141042078, 0.23957476211412987, -0.25284082662244767, 0.03443676791938287, 0.030135427280943195, -0.355453030107183, 0.39416919042762366, -0.21723722303260168, 0.34892732918197156, -0.05173225865943241, -0.10015381859170787, -0.19456549365034723, 0.3309610275747181, 0.12475082369287312, -0.16084362406180872, 0.5656619940607296, -0.14352654847801566, 0.22940833216698633, -0.3594244105834849, -0.10175061565170493, -0.47986618267219083, -0.06600656653921763, -0.431262215014054, 0.4138087387078394, -0.7445737211148008, 0.4842874578413482, 0.003448043599610147, -0.6104838233394948, 0.2273129218690267, 0.4946628853975453, -0.33158547786164283, -0.056113354026332746, 0.34031211525476585, -0.24010651876083167, -0.05378728132453796, 0.4237074481090604, 0.5901411996355339, -0.3898085538745753, -0.4890110344803675, -0.19515433679311564, 0.4674408121571576, -0.4004479907648717, 1.1115076415933627, -0.17073396754808134, 0.038093006317237645, 0.04133817758374701, 0.3465227770687936, 0.4328923851829253},
    {-0.558754986125708, -0.40091401726365333, 0.18775139347389136, 0.062463276289341355, 0.11892155425625427, 0.20968602029731168, 0.3164077263832777, -0.7597515020376205, 0.06085290561958301, 0.14732062438311222, -0.4259177148198216, 0.0709256416674295, -0.10545130394899878, -0.013554951636712815, -0.7487654291882232, -0.09553087780709897, 0.25742474882459654, 0.2049576836545629, -0.18084308130898916, 0.2154072329989139, -0.28199636227079605, -0.3485019596377596, -0.44035357667769254, -0.20148359563665544, 0.17074216091545075, -0.39367039121119235, -0.02180760180897683, 0.2865512420410937, -0.1939187512538877, -0.4778125214691134, -0.618095291248743, 0.5282367127711802, 0.09952218108460129, 0.28108947024804426, 0.2687445170398707, 0.11979253289670252, -0.4839789035001224, 0.18319685600721103, -0.049309654228816856, 0.6098429286548558, 0.22917467544271836, 0.053373242008861795, 0.6827436456572906, -0.00855612783767752, 0.46060302488304317, -0.44079120907666114, 0.3345584511595571, -0.1262005965402948, 0.3322777780005896, -0.6342458325612906, -0.17164094770789035, -0.329538886593687, 0.2359498436066406, -0.3147408362375805, -0.020831755914000768, 0.39817111155756607, -0.5536738809898067, -0.20488325258328832, -0.05004686806239471, -0.531512399348263, -0.21769681979237318, 0.6922260730792493, -0.09025978320359446, 0.16595215340152747},
    {-0.09829736725991625, -0.5329310613490728, -0.06293862895546486, 0.08029447128683205, 0.18053566009826497, 0.1434285928920041, -0.29640568138565154, -0.8219667421601481, 0.23026580482652467, -0.3811230011209425, 0.14509853725741534, 0.3999697296218328, 0.6137570235148396, 0.4781313000142432, -0.37659993167147465, -0.05790079901278141, -0.07902342320111909, 0.9664799732496433, -0.012264657914932512, 0.46430996392642004, -0.07205972903480817, -0.14643249809010336, -0.010908266864791363, 0.014481926303831591, 0.4759605090439155, -0.0436419722096157, -0.6435944461823513, 0.1547236485871096, -0.009330714476779281, -0.5333276792017849, -0.6952959746799189, -0.148968175160882, 0.3194320726531105, 0.5949307069514574, -0.3643330496509144, 0.6615034620767307, -0.5754369225310029, 0.37773790113077127, 0.4717740099679554, 0.3417173410729707, -0.05455418155040762, -0.24896342339701694, -0.18691522458177864, -0.006417005405074196, -0.5639306532565129, 0.10021657431289646, 0.4003229501407842, 0.19448989922755927, 0.0663344734667805, -0.36945184895735694, 0.12023210529532977, 0.06423836290714333, 0.27567743166737474, -0.32076678570193384, 0.2722870513482544, -0.02528482503775889, -0.009993437023084363, -0.3071181654710167, 0.4654537094937139, -0.6659459006638265, -0.6737071139194766, -0.5401750629922542, 0.8490955272313487, -0.16326771899069364},
    {0.294048677728761, -0.06055110206564024, 0.4848500344823372, 0.3189897460710912, 0.3053403380609031, 0.21830105484123233, -0.5586213838471702, -0.3016333979211435, -0.11887953217476412, -0.4057849807651444, 0.2819551985684021, 0.3023550145482715, -0.23856331467317607, 0.019580189710683323, -0.21752897534080823, -0.08073572524406182, 0.20248853276848588, 0.5533352196480119, -0.28205920704772947, 0.41583602814340426, 0.4225836529405934, -0.0511638725794528, -0.008456019551812523, 0.7817575694753323, 0.20988947294615787, -0.406324158790418, -0.5751612182649845, 0.6824894496796866, 0.25374911958201896, -0.7294907779783963, -0.14730591253935424, 0.0003209318583679155, 0.08303915883305482, 0.4666641369156123, -0.48101553524401863, 0.24052964008669062, -0.3667572902182095, 0.9267386501150854, -0.04478322399446463, 0.08425512101751816, 0.4589351948566797, 0.08622130197860155, 0.05680717009293537, 0.5513368873904417, -0.1507209370237046, 0.0005782223121821989, -0.14849413007801415, 0.10127423251679582, -0.14489034412070673, -0.5452228067795386, 0.5718298126971231, -0.12400140859525897, 0.08505085103344513, -0.493361667226708, 0.0911222784839427, 0.19759467621165186, 0.3317193539534022, 0.3038480693884232, 0.3771920002288732, -0.30316961826921773, -0.4169541555960914, -0.4196095043137037, 0.3347002032159267, 0.2709862341870863},
    {0.11445279064102828, -0.5815853771307932, 0.1833224317921954, -0.16749121263115427, -0.13719731923928158, -0.17141172537577543, -0.7568943668373538, -0.9562029978635644, -0.23569525289215554, -0.5729262225114373, -0.23797970077880634, 0.32036185595353006, -0.22021829797902134, 0.04012858536175028, -0.020424834124967567, 0.3958492477715169, -0.3691048365830357, 0.5225869754063099, -0.529422341311663, -0.19447195654790755, 0.07758772252741154, -0.8504876995588787, -0.3997264905743276, 0.7846660990276292, 0.35461341042522215, -1.0201122213509097, -0.050520389632053825, -0.8625865107582326, -0.1273750183252891, -1.280824104144039, -0.34918346449941795, -0.11479437846395628, -0.6294740320184301, 0.35657814709156993, -0.4300048704581996, 0.13439671815224613, -0.22440852082539703, 0.20558795014484593, -0.09193991789344193, 0.31581965416789287, -0.4078706886878361, -0.27150725390719305, -0.046862343261613724, -0.4240592993955914, -0.42819622472129654, -0.5730853395006125, 0.29575830476272835, -0.5109062542149295, -0.37326910568755717, -0.4223024688375646, -0.09634257291370187, 0.4023926230605007, -0.4573996606390679, 0.19128403015496592, -0.5765002034685932, 0.6196504147311861, 0.6864732239350892, -0.6085748157367211, 0.3959168131623754, -0.4283552662688215, -0.5855774469378473, -0.2534101877940871, -0.24593689104414057, 0.2447124653942001},
    {0.35307378687271307, -0.24672272470530052, 0.26410099879969906, -0.28995164382737426, 0.47618224685036376, 0.32736202952292776, 0.609712259732524, -0.6919141381674387, -0.4341069461424764, -0.09166660063855, 0.6929929106294883, 0.17712706802491468, 0.1880746043000272, 0.5098622572123656, -0.15548772789690982, 0.4712500336673216, -0.29992438225732554, -0.3751082539824928, 0.33369139984718166, -0.361047657785921, 0.09661875856816753, -0.5048346365255646, 0.2648564765916661, 0.44638297195251486, 0.005641140014841999, -0.3291387424772738, -0.22993967996331857, 0.008372045767030812, -0.09055005706367852, 0.32029007277915983, 0.346356406199664, 0.25784303966149885, 0.03328978102242912, 0.5761380425238383, -0.2195925926753638, -0.132087372834647, 0.10196072915427348, 0.3626619356416759, 0.8546076576924238, 0.49995918176074006, 0.4828434535887569, 0.4052851765421975, 0.21019925531387026, 0.2801415829469699, 0.426987161256719, -0.12257791361618275, -0.14150467665468802, -0.28180818972036703, -0.5105575365771383, -0.5201932366205283, -0.1399162566363857, 0.6620618354493243, 0.21479565349168456, 0.18795600865579645, -0.17963054918895652, 0.03980132881310226, -0.09752454616116861, 0.01715246567151584, 0.5217356196551489, -0.15415103980416278, 0.006126124376338091, -0.16551552935900282, 0.49961228701105226, 0.08106608681716279},
    {-0.2300828275040596, -0.5777051859060082, 0.012172568033100248, 0.183256655731467, 0.6149363984290489, -0.41930743296685224, -0.5395632127393314, -0.49017332123722346, -0.0904213649427999, 0.15078735001641477, 0.7384025690124256, -0.23532755052711843, 0.2733233296252305, 0.24760862272450415, -0.39608520783738244, 0.6413571857788856, -0.14559847059508893, 0.44636710402016155, 0.3925024080148262, 0.03588724434061522, -0.14264374159868448, -0.09777166227508884, 0.39757785514889477, -0.41396482936947404, 0.6701650023953339, -0.0253445350550931, -0.16767444333707976, 0.593520376032965, 0.8166976639067529, -0.1291106005979969, -0.35235813936157745, -0.05379228126368599, -0.1278405404097148, 0.7002023020062241, -0.18166579939635402, -0.26970500696343686, 0.31564632846845275, 0.6352535833755999, 0.06551784068389431, 0.09777565452686611, 0.4730685697417739, 0.2516488115682419, 0.5454003482144669, 0.3054869592274965, 0.4650621933822227, -0.12088811712925997, 0.6392460204985149, 0.3075171082836229, 0.39972731411578644, -0.05586550058166185, 0.23379429250402697, -0.11787591528142509, 0.08079114077073003, 0.12270296166411412, 0.2446607151311012, 0.37596146333295594, -0.005935380231516802, 0.4991447050319573, 0.7093765623063212, 0.46232416021720507, -0.18523912574749204, -0.7265650192719499, 0.36599260925765864, 0.20169713487360072},
    {-0.2750285269482279, -0.12951750256988392, 0.05095088910490699, 0.6756139198682038, 0.6255782987308816, 0.1249639384720933, 0.3385731707136117, -0.1730901965753326, 0.6024934954876295, 0.6254499484166259, 0.7411407382882573, 0.3125755194932032, 0.10855671984126469, 0.5176627104386985, 0.13907702746621767, 0.19457701984099088, -0.22646382111599328, 0.30964501768875263, -0.3416752742047477, -0.23447159114883248, 0.2523577056566584, -0.5844746377258858, 0.9245228391164543, 0.6283611653382976, 0.21819216030847122, 0.05418391617241517, 0.13878508576383544, -0.37135199448859874, 0.6074090844964206, -0.33022444775882676, 0.7505697452911556, 0.24543456697360908, 0.6167263810793574, 0.19774501789235188, 0.4226259978235067, -0.0539407823257619, -0.44699859415961923, 0.28955848061222467, 0.09073492871730975, 0.42721436244865435, -0.10713794486933202, 0.36377306156469963, 0.08845790031313863, -0.20071273177148294, -0.3013769780094673, 0.09500883754500145, 0.11728969829562137, 0.3335353506836216, 0.5972989862986556, -0.41414536050264494, 0.20957448421014138, -0.06014264443218152, 0.4274335912611638, -0.16972189929990275, -0.1950558001847971, 0.27658759358976237, -0.5222389057768962, -0.5888733942982969, 0.7792145142138814, -0.032215913709079134, 0.18614521036683665, -0.5305849319960375, 0.628906916856014, -0.15781154895147279},
    {0.19461854329205355, 0.17809747251593672, 0.09262014254476358, 0.7105705062669627, -0.08463843814360321, 0.18857998347318072, 0.09403376770353523, 0.06242727803825381, 0.7685788260551061, 0.5152305996789358, 0.010612835752880915, 0.06345640962011692, -0.32408355479415213, 0.4640990455513638, 0.6777932803987817, 0.09167952571903913, -0.2632947159733934, -0.33288525358473764, 0.053385565649577124, 0.32656529469229917, 0.19819612706752815, 0.27980242025314417, -0.03881581409606316, 0.12426299559262238, 0.26988405232182777, -0.29535472281557656, 0.5788331291377714, -0.16156228063023423, 0.6003312858905104, 0.09987060889692459, 0.15600912588711766, -0.6537612378283829, 0.3943457937090067, 0.2699732122292169, -0.13889268428544635, -0.14725554458550455, -0.08023514605579345, 0.3026401396585928, 0.017694093222909952, 0.3405130539158647, -0.12079753635192758, 0.19120088771293672, 0.5646203071324919, 0.04971863190240013, 0.19530871244797346, -0.7549621389694041, -0.08138272610025307, 0.07627036167811503, -0.5460450425763447, 0.4231561826053333, -0.16018581889241762, 0.14487357879682092, -0.08568203189562575, 0.2504389322180806, -0.17367843295666166, 0.41933774248962635, 0.1439419067409685, 0.17705240216825796, 0.027884469989401285, 0.15837193540288635, -0.29248157483542886, 0.09101049863179103, -0.0921551027638529, 0.09277183149987497},
    {0.14144526758203743, -0.13448095370263594, 0.07155650519828381, 0.14893296723669824, 0.19647030255022593, 0.10630953169896176, -0.6749843353829362, -0.4191266009984537, 0.054398125719079246, 0.4530793431582019, -0.08102387157432046, -0.21108685064656316, -0.34741647688884114, -0.6715486155207727, -0.15138719740911175, -0.07799987588668865, -0.35806386570142096, -0.3971988856727995, -0.08416454980185231, -0.05728999465917826, -0.03908827651789579, -0.5245935183966085, -0.4448290199493661, -0.0984185670245447, 0.14585962199260466, 0.18688382885134852, 0.2927401487354468, -0.2871386644850625, 0.6180008428247509, -0.14355352457404374, -0.28090558441560165, 0.5387009072880605, -0.30040673793094463, 0.6854679815836682, 0.1680068528507573, -0.1797282535581453, 0.23215710107196266, 0.037383331939399196, -0.2752672660731735, 0.1544219764823617, -0.300056351407051, 0.30117119641583595, -0.027596645101842038, -0.429773653674852, 0.3164496556427921, -0.40484752927151185, 0.20173664938274094, -0.19574504399796638, -0.46985310271336056, 0.26021678938212683, -0.10937717119830563, 0.019756233385425138, 0.34238881064750876, 0.3720012453024126, -0.5848371496002112, 0.06837269461635401, -0.5316012803372574, 0.34327455420880376, 0.14716005587814332, 0.16985584841972404, 0.22135128448814945, 0.3299769394432183, -0.25950569832883613, 0.21557493658544685},
    {-0.042518444451322523, 0.5466965076913421, 0.5680311037975656, 0.28615203251431737, 0.023576749686567613, -0.07823748565499765, -0.2832526053887623, -0.007094549137939294, 0.606463092305154, 0.5025225285767548, -0.2257021355785951, -0.18128178582809534, 0.24478295823586976, -0.034626115372733565, 0.12825027366329794, 0.22993035270226694, 0.5390942466497685, -0.123090294277598, 0.047994456039920134, 0.5555879684741252, -0.11737482345431029, -0.190983213139723, 0.2872779999531436, -0.16409011891279224, -0.011337612638132273, -0.33856286008279346, -0.0025244056946793748, -0.5281491770188493, 0.06693546442377384, -0.1304782642084511, -0.11237259526941494, -0.1600543715611776, 0.4459852320237121, -0.11472618194310531, 0.17182641272247354, -0.31838728369604624, 0.3165039714542969, 0.33427898016830543, -0.14245010023931398, 0.5422080665954182, -0.07890884517146077, 0.3634288057923719, 0.07390231217093257, -0.10337573981662106, 0.034442943670062974, -0.6425633028776125, -0.49430369950451014, 0.3270036601141338, 0.2901897228922127, 0.20676504972159765, -0.23699120508382265, 0.07971253304989964, -0.45551424075210184, -0.3651378713530148, -0.6566826406625813, 0.14434976158215243, -0.33033652083268034, 0.14384327837529007, 0.09701075621918367, 0.19440943922576445, -0.009467996881717868, -0.23492909052540742, -0.22066980186686883, 0.249756754969308},
    {0.5891818709070142, 0.13321105350647183, -0.5468548797116448, 0.27968064121428815, -0.1371179906589988, -0.31137400672563664, 0.6173249784200091, -0.2172916668950492, 0.004880412352066548, 0.19733514079004805, -0.15225470933095772, 0.10269815020762842, -0.5217442828173102, 0.6600499000902085, -0.11571078473590003, 0.5377936085078562, 0.18957908966660403, -0.6611013664995504, 0.272100541826057, 0.05026616151647751, -0.03320856906805334, -0.14577724583899268, 0.22808761824579915, -0.28421835728861294, -0.03818390117501731, -0.008403974489930703, 0.5320070645212474, -0.6551252409892985, 0.1084778484634188, -0.17705960800252382, 0.26104831480137075, 0.16573364071481061, 0.7497202343715278, -0.2754860753267582, 0.11274150092006215, 0.33219026121147205, 0.3443255309588698, 0.7211011120793681, 0.32163519006542035, 0.21961401709709852, 0.3440382016016473, 0.34167951776520344, 0.3072917204362752, -0.7392694895969145, -0.38732369046755644, 0.3489990950103444, 0.046394715497387246, -0.31137773803586544, 0.37176535941922206, 0.5023577732034747, 0.14015234969973908, -0.4004556598496689, -0.02044897027471016, 0.2909036437630834, 0.3281272871377191, -0.17079382248622293, -0.45503052436996333, 0.5036508108488825, 0.6698359616986646, -0.384771721334483, 0.376483144318361, 0.33880415708499945, 0.37543612255425396, -0.45566910494938634},
    {0.52864178884513, -0.31079964389612247, 0.2161483310282294, -0.048429301425348396, -0.11758093727107824, -0.4906189745780468, 0.4570352520436593, -0.20737958190057149, 0.12938677648308747, -0.11513997673583992, 0.07509607735910952, -0.04543037950461315, -0.2578501948869759, 0.16113582578878702, 0.5199817668392007, 0.26491966673318307, -0.3701620668229965, -0.24881451332929191, -0.5463066660049575, -0.1589655552208096, 0.16139628120460928, -0.16548836072788528, 0.18798626342500965, -0.1512945459264128, 0.4290996672256863, 0.6432035990693733, -0.3896878029946142, -0.7226278428309487, 0.2528028380697856, 0.1770661003753668, -0.2798146955062384, 0.10007452786066774, 0.27539572858221695, 0.34217801023695865, -0.011029605835952371, -0.5524917961907807, 0.042819541236233036, 0.10992572282961376, -0.7945016349380581, 0.37500287401431165, -0.494240752337788, 0.4970494524029176, -0.10318130988809558, -0.0438118700512962, -0.2856829244549588, -0.25021365141621776, 0.45484836141903157, 0.7071108886514681, 0.3489200730133581, -0.28568944465768603, -0.2973739730184153, 0.2528562894799337, 0.6296881708877515, 0.18810305325947166, 0.6025778220222375, -0.36096503694546905, -0.06472906855416026, 0.10650040736105776, 0.4375034314888085, -0.34730628248748907, -0.047813642245369437, 0.20402722816309016, -0.23282198231796997, 0.2089813501424015},
    {0.16860467186460418, 0.02508420837227968, 0.2651597508657987, 0.16388712953790383, 0.6542126076727598, -0.169380070318519, -1.0024393558304345, -0.027092268285742516, 0.007110184724626381, 0.2638044381008689, 0.3465321256012045, 0.40623776211579804, 0.14431814999509138, 0.6013982304705717, -0.3757246833150542, 0.8062500570914878, 0.7644054387995459, 0.6209548948266398, 0.15570945815681486, -0.15716278512258341, -0.08127559500130965, -0.3250752066743108, 0.23495929148745218, -0.48399737556971945, 0.7064602178786762, -0.4841394658050663, -0.08792461940495312, -0.20039477033706485, 0.7566250511734441, 0.2781908551899845, -0.12317197256985812, 0.663651200820719, 0.35577959951509786, 0.49513647573188035, -0.11630410694702122, -0.2003690942682864, -0.017021183707533156, 0.5331606919316179, 0.07793644386324541, 0.81280586602769, -0.672660416099313, 0.9156596428396205, 0.6162471400303673, -0.0610762722076633, 0.4492976343611854, 0.8235113001539822, 0.3836372826432509, 0.4350388262374174, 0.27467913465849747, 0.08559033139805626, -0.47497739255971616, 0.14894351416371912, 0.35687626041483433, -0.11308980383577352, -0.3882785749197342, -0.10489392494717797, -0.046083743943716, 0.02963410227497358, 0.063142127875617, -0.45332655661619103, 0.573612498588912, 0.0634074481876828, -0.18896743320883946, 0.7170064582240735},
    {-0.4205817556585118, 0.18337798437494623, 0.8017337672543026, 0.21036698106315457, 0.592100541735718, 0.4303237619908751, -0.4002504900788498, 0.5328665992378953, -0.0011086486942977253, -0.3434560421052768, -0.16811433492092134, 0.04556561378895314, 0.009812688812635488, -0.2699776195543629, 0.670151595803666, 0.4850549350345604, 0.7494740764263805, 0.576029223092298, -0.34458230739357726, 0.10773055184693542, 0.7668841539761022, 0.2713693441247188, -0.33208417296351395, -0.3344040542271672, 0.35832585093786046, 0.22694235786950778, -0.2815647407013928, -0.12897211437836575, 0.5634085165727007, 0.10030207646040598, -0.15929933368790944, -0.15587373987069655, 0.0538395565346641, -0.4241260283339478, 0.46447723814132824, -0.2952310795381022, 0.2286972358221382, 0.3215886030983652, 0.3269126883121166, 0.3705785237707845, -0.6301694554612017, 0.7286326929590603, 0.5923942575150904, -0.218121627641544, 0.23662316403112116, 0.07527480656458975, -0.4576497052733863, 0.4062231772322908, 0.263538770198073, -0.6345700881021112, -0.27493294680024305, -0.27613532649663514, 0.5585229674871179, 0.4991493650163646, 0.27898838669212955, 0.46529715246770265, 0.13558264478919355, 0.8565178841767932, 0.6976791499434434, 0.09510150640538999, 0.45429769962008115, 0.2893607470945771, -0.09985647033201163, 0.5456793835367645},
    {0.33502227165102344, 0.3618267281374883, 0.09506198112725434, -0.2451938979986894, 0.731234536769018, 0.6543035499672191, -0.14121013424662382, -0.22902068415484264, -0.12929951634453996, -0.5003046748453779, 0.04419382253859067, 0.019526442294971358, 0.6425723160453831, 0.7810557754067831, 0.9065948899334262, 0.27951905055406745, -0.22810820813355906, -0.32332571798492654, 0.4736678143001076, -0.13373578366966082, 0.3196147166571023, 0.33538869213644756, 0.1794067424097128, 0.14933775644899394, 0.10679183839744717, -0.05038177999019752, -0.004681221429258717, -0.24797978457811207, 0.09326834679742617, -0.43897741843415033, -0.005564038428882085, -0.36545897555540413, 0.9160923172121425, -0.41320399255482715, 0.20902186651816407, -0.4106729626679068, 0.4700755498536809, 0.023226517556504105, 0.40281244019896195, 0.01919324822161978, 0.2963086781348902, 0.3221463540111376, -0.05668908898250193, -0.1301882951162746, -0.39446529413394976, -0.46120315101310855, -0.35603776994473896, 0.025381798176669846, 0.42487102657564896, 0.628034514574507, -0.4088398604272921, -0.2209537417802031, 0.3255196242541881, -0.30421052187724873, 0.029154735740977877, 0.3139859040137038, 0.5881070399260879, -0.03357886558799202, -0.15410134403716452, 0.24219140352796523, 0.28619034750836647, 0.42472098770404265, -0.050180088782953096, -0.05467496573217951},
    {-0.0724026483425715, -0.008389764709676117, 0.5491335919181102, -0.38649178791199146, -0.03035063483383091, 0.7385995848414434, 0.022711684877263976, 0.16095785906215454, -0.5540627758552582, 0.572446767465412, -0.011328152400468946, -0.009062125289408685, 0.24350084801726474, 0.2055965246944385, -0.12482547873643274, -0.3260219315426766, 0.3388775874308597, 0.35645061040371606, 0.2350716973666885, 0.18569406042025666, 0.06450100394527401, 0.15141513764297507, -0.30852239280915267, -0.1878742316718446, -0.05500683715096561, -0.05291730599031752, 0.037771550894245505, 0.19607903060424428, 0.5451390159019756, -0.008124029679804367, 0.1499592759655219, 0.21307257139805236, -0.4195245167703346, 0.9856039327057745, -0.2136613031190218, 0.13899907042865955, 0.4725868510711984, -0.3182279801274089, -0.252501612881817, 0.24390332018628474, 0.1907128609983451, 0.4991874850270739, 0.22699990426410163, -0.24066561238611872, 0.5368955374102405, -0.006947145015933075, -0.3929384806595585, -0.19573890547142073, -0.4403421983747255, -0.24684494825651584, 0.248954449908114, 0.010365660384850133, 0.355702639689314, -0.0017862232538166775, -0.010340017477341548, 0.5086425998704432, 0.07368851238213946, 0.5450639104787999, -0.1274814946834342, -0.029035942165701736, -0.04468510083058232, 0.036625320899740764, 0.2093736084983677, 0.2716834740064702},
    {0.11688366354547443, 0.13873864156533486, -0.234028418337943, 0.454587536136142, 0.1470641208492127, -0.27444047072200806, -0.6416003262296779, 0.17237347597459649, 0.45756128859136186, 0.8405301237505565, -0.03941930276406073, 0.20129689312237914, 0.18648930847103898, -0.7061147355875785, 0.22294377839626145, -0.45956523351253736, 0.20771524111455128, -0.5753336752747537, -0.40584025970711785, -0.016710249193031476, -0.4477846804688995, -0.1189411057827219, -0.06671485437609122, -0.6547877187741522, 0.5773039302467748, -0.2292982026992722, 0.27637650901614375, 0.2629032688496841, -0.26909932991862906, -0.011706214967558465, 0.40575489111748925, -0.36806979823766317, -0.9763406455001722, -0.04642825859975341, 0.039133944451761264, 0.04984075039216917, -0.04450608304878478, -0.2546197381601537, -0.18745590876188387, -0.12687563224112539, -0.30535805224951335, 0.03796545533513845, 0.23452281953960824, 0.07766391106910353, 0.13676710769804418, -0.1432625053807788, 0.09564620309184642, -0.08606780313846507, -0.4710803020788556, -0.461084315059749, 0.2901074110014831, 0.2544962415664536, -0.2435120843663714, -0.04887194187081669, 0.13771354803805277, -0.10283065029599565, 0.428771117739027, 0.3804559711493692, 0.36362663145672425, -0.07031857014004354, -0.088480737742474, 0.5433602261649626, -0.9975719125359275, 0.08006951722508415},
    {-0.1665690616827624, 0.03489889344290904, -0.02578850811872383, 0.117174213431431, -0.49778931203364735, -0.5329602893047972, -0.5251673798715787, -0.6262186845089808, 0.7288177636989784, -0.02175400534247027, 0.35780821579888505, -0.059127741283000856, -0.4087426622543471, -0.39901828323783983, -0.43987124649713666, -0.03804437193652819, -0.038582128304902534, -0.1721960264157391, -0.586283263272349, -0.1995340560797437, 0.2871000326958386, -0.34446755149706665, 0.17355682168977002, -0.0844119679590759, 0.26329916794919284, -0.2722800151695953, 0.1440672323648004, 0.05738985520883883, -0.6288058851562831, 0.3861117937597377, -0.21322730804212073, 0.10576427423439128, -0.28620012598111455, -0.5231978216372811, 0.052001622195145404, 0.21359724002032968, -0.4803974987359046, 0.15864985564137654, 0.27586138608868654, -0.015801877232509594, -0.26073772158398834, -0.5187206714146825, 0.12390013752568753, -0.18459574971630588, 0.20342272152416074, 0.34648346154563475, 0.6575110000713259, -0.2012787828254343, -0.5744851039424507, -0.30092514266094567, 0.2150535167728872, -0.55229553261429, -0.33271541934596754, 0.41526758812402864, 0.46662916491392714, -0.038970691125861795, 0.07130660390242415, 0.061863765479663615, -0.1686852076604082, -0.27975580312830484, -0.026831317974018897, -0.12326143431150792, -0.398030423620241, -0.017782195879467798},
    {-0.054225266412149156, -0.2754420208690186, -0.053204003359971566, 0.3108501820630212, -0.40360728459783446, -0.9656297471712868, 0.08066056160146438, -0.6147995791578712, 0.29494546001316724, -0.28612868191565183, 0.15041033239864454, -0.2973344152960499, -0.6239594290508695, -0.6562481772857196, -0.13071643088727636, -0.22002656180184546, -0.21498419558071968, -0.04485974745665259, 0.004430363091194365, 0.25744702718781975, 0.07819553469418969, -0.32529343185123893, -0.37048003276437447, 0.3334387138004827, -0.5697246780896502, 0.04591257629524535, -0.2613858520363421, 0.3383756290572004, -0.4772046272033145, 0.49057543373208373, -0.8387976888629065, 0.042737128737996406, -0.40117445301523935, -0.1728932805735516, 0.41636232405786205, 0.052618043488140094, -0.37443862621697377, 0.3325864111638026, 0.0707030186296286, 0.11719382890209368, -0.054592953655726514, -0.6928067503992309, -0.2769739413046791, -0.049929015987263986, -0.3257368879083564, -0.0158489711667656, -0.05990677617601148, 0.24513861824737274, -0.19860506604386094, -0.2591127982277952, -0.020337795782439445, -0.3200605175834174, -0.09912896592159372, 0.18955755931257987, 0.4010880447659198, -0.15165487548156834, -0.5868918038697027, -0.4414219740272319, 0.34180942053707203, -0.10637918474531209, -0.08456924008214206, -0.24214146945878212, 0.35828235427379407, -0.08691401328921693},
    {0.21047651713442903, -0.25180979138908277, 0.3855443958722389, 0.39970556954157765, -0.09652879521414201, -1.0304586737625896, 0.21781681810257036, -0.39095093866276714, 0.2314031782840446, 0.18629351530564917, 0.19014335057840562, 0.5517390949721717, -0.14378013849956978, -0.7348423875280851, 0.1994320977888909, 0.20413265084637996, 0.21444935271142335, 0.2955393159749247, -0.012340292429464947, 0.14955983926291497, 0.12784817797453685, -0.20519458165477394, -0.1856938860562167, 0.44419347898228395, 0.43523162194147746, 0.8670759148845707, -0.5054889613825112, -0.2521820560027274, 0.11725058517122143, 0.27470865839411074, 0.0404072867684842, -0.19922500926078474, 0.22660863427153374, -0.030737020968026333, 0.29580364377352364, 0.5350590171211032, 0.023840749449352286, 0.059068132962522446, 0.04966889921354132, 0.217933983514793, 0.08537668180553465, -0.3058792781733254, -0.7067015262622162, 0.4477632552980156, -0.22821971042590253, 0.2354547919082899, 0.12842730768825925, 0.25545686049892424, 0.6477863051215258, 0.09354261021465597, -0.25205650109686756, 0.638400062160279, 0.37959448381823874, -0.20012357902258995, 0.0791559997282155, -0.5225189528821695, -0.23448149169069352, -0.07312096524169039, 0.35432124075585775, -0.1815493329151812, -0.06993231904757806, -0.1964656600804509, -0.16936789592255763, 0.031588760723958643},
    {0.4774569737016393, -0.4265910156342969, 0.3706985592003796, 0.33822678476501344, -0.3560512829407282, -0.38275557122022286, 0.14659020334768244, -0.2514391445193029, 0.48646406020003596, 0.09812842623846661, -0.03846151879889925, 0.038634535395851, 0.06792608010620141, -0.043301751415145966, -0.13589538530944684, -0.13119888077750907, 0.34722018792410325, 0.2943598691761919, 0.21043702975717588, 0.15343998972014447, 0.282302195244307, 0.3602642987852419, 0.07896562738974186, 0.22729634235517546, 0.5918283434028323, -0.17146881313771076, -0.21588548041413752, -0.2704612812296948, 0.1630645375006394, -0.08010263644274127, -0.3201533023481011, 0.5884257953998263, 0.27400613373022953, 0.2329826829166681, -0.2878123752263595, 0.4531645077384603, -0.20948214625643372, 0.759556699388676, -0.2779902618601129, 0.2973961042832924, 0.06794289075434658, 0.517749045438876, -0.26125961469304165, -0.1548422290668096, -0.002241479129862713, 0.29428940994482883, 0.03446367138443189, -0.3821881522202, 0.830808853305016, 0.16020829513534732, -0.09469775440862765, 0.22236174056118801, 0.2492018065810518, -0.6307373607950232, -0.2088779864047173, -0.24884733366634748, 0.19701823832176124, 0.20589289471830685, -0.44227663372223597, -0.43093254478631227, -0.5547038290173366, -0.09435141227964221, 0.2530055015450619, -0.405958385687433},
    {-0.43051341777451163, -0.3213526957658887, 0.12451754013668244, -0.33435950477504667, -0.5613062538270028, 0.05334171233986857, 0.0077255041219508385, 0.1420305101127081, -0.16209699913610826, 0.24688992875078464, 0.23608835476180726, 0.09737296711413083, 0.07421731989644853, -0.07151462818488763, -0.30439804300758583, -0.21765655298554257, 0.15272684870943284, 0.4357276479319596, 0.6304270273985813, 0.3078145357691744, 0.06706959702957348, 0.12570185376891851, -0.04230407190346411, 0.19653041586502196, -0.19876546971616915, -0.6600907785716542, -0.32459665369556606, -0.5076446392358933, -0.37647274842079087, -0.49583165955834013, 0.1419989752996922, 0.3325552574713456, 0.5998446810731537, 0.22627408047177117, -0.32757792085594173, -0.17198118503966328, 0.3047816122388045, 0.17917259133738014, -0.2332373625846951, 0.28389323906397734, 0.25801323527281383, 0.366095098040612, 0.21690848870836774, -0.30975364938055855, -0.24707343829473125, -0.14370808981348357, -0.34420991076030905, -0.45691131654659717, 0.08236320786440371, -0.11198980628552611, -0.14222759531354523, -0.20006376620966856, 0.7096220077583856, -0.6217015825241019, -0.40026491838624617, -0.05653227847783224, -0.12906517734471865, 0.32002629028237295, -0.4093831157544282, -0.20289612060406587, 0.1882357952017628, -0.1475428157357513, -0.18178403567846346, -0.24191736883312312},
    {-0.6432947131902524, 0.05498359867944378, -0.6316481563372727, -0.608638165192916, -0.2712564616562559, 0.08895193217319844, -0.06227826701808568, 0.07015858559355423, 0.2479070279484657, 0.4899550108957562, -0.19187607089186573, -0.015196098449020009, -0.8430757558045897, 0.26386131884455877, -0.46559179822705365, -0.16938009960888617, -0.504392234379039, -0.4009991799046126, -0.35657047359572625, -0.7194789455075766, -0.12374576915598812, -0.1066605552072546, 0.3703564779231778, 0.06287322115091817, -0.05802033904515406, -0.4481909529369632, 0.04113892631575167, 0.009075050547245488, 0.18237387961453067, -0.08649438812237291, 0.04799524398802764, -0.358047937924372, 0.2754510037056748, -0.45421887115009907, -0.2007671624236131, 0.26184293071941683, 0.06202176028529974, -0.23217035855180873, -0.1652531918437098, 0.20049319308614577, 0.17272961922897306, 0.11660855614212594, -0.17800792685170036, -0.5647273966222296, -0.12003542612403034, 0.28454338524448985, 0.11379392089610438, 0.3809118657319457, 0.17776245632122092, -0.5666854052496558, -0.3527107228196145, -0.5588667477532425, 0.3425741149587081, -0.24164706280121293, -0.2195830555296965, 0.0957902035776023, -0.16306635841967865, -0.410591636846592, -0.010518978697320968, -0.08397857523647947, 0.5174704626046688, -0.30941905460304087, -0.4237596428932711, 0.23607284639811535},
    {-0.8258655069426906, 0.26815170082806755, -0.07242470448564627, -0.5188287961764344, -0.16335554489754062, 0.09445956370153315, 0.28665944442632624, 0.03758739812701573, 0.17816693142353132, 0.6647921947191444, -0.2789470268754909, -0.041021795694952685, -0.6550375706853568, 0.34868271939760287, -0.01900793626206213, -0.19955561262857657, 0.10548002925761422, -0.2393139679342059, -0.17271157439399393, -0.17634497835380514, -0.15636814837391122, -0.0018313134190436236, 0.2502576057053037, -0.47386321556213645, -0.21251393886135203, -0.23214143848392732, 0.17490964051582114, 0.3262736869578824, 0.5225321844181923, -0.09622127793431295, 0.032428334453755786, -0.591623098006291, -0.2010094992898546, 0.517080393617423, 0.23208537671794252, 0.12239274288262648, -0.22888455420776457, 0.16056492692022148, -0.07968656464805651, 0.057669521777101516, 0.44249315342773105, -0.18817763212487157, -0.5298925319923082, -0.3423207232248838, -0.16591639949127426, 0.16696878591291675, -0.620018813416582, -0.13698932466296154, -0.12588925510573667, -0.4327812564264305, 0.3220782543007423, 0.2040773177941274, -0.12091647215067737, -0.28673154252789623, -0.39117620616924687, 0.07955254369419805, 0.40857565891268965, -0.26046369406327585, 0.013019970925511219, -0.1958022673954983, -0.10645897105890056, -0.3405851040504127, -0.10201498677706024, -0.1351376560696368},
    {-1.141968803525592, -0.38090973158018604, 0.46068184078128277, -0.19399381929796092, 0.13831271949686966, 0.45582806401452264, 0.5234128801917184, -0.06172418247561664, -0.0434531874057591, -0.6348280648671705, 0.2543938035826014, 0.3501048081690279, -0.020233551117060055, -0.4195078389010925, 0.11459363536561326, 0.5046575875295435, 0.00979482912289392, -0.24545786995275748, 0.1497528436547063, 0.4064253189397283, 0.14724700491237405, -0.1272920269172125, -0.0513580877642303, 0.39356456735889755, 0.07461151237725333, -0.08192003618733232, 0.13185701088272125, 0.12463518191518073, 0.024279947528291934, -0.11047980652511076, 0.3084153470976975, -0.13345885557711698, -0.09674481748780504, 0.41980969131794055, 0.3351204144638414, -0.014894867495684177, 0.11081275573917317, 0.37678989724724943, 0.040205634253203434, 0.04567349181946484, 0.1282462535651883, 0.49504085313182883, -0.5882410529856916, 0.22079172548189613, 0.3718030339318378, 0.1863326045515581, -0.4567860882481095, -0.3932416828942493, -0.409666764563127, 0.13524912509310247, 0.2030405255401385, 0.08223533354603028, -0.07127783158062774, -0.03099901227135026, 0.08018514501662863, -0.42797115552269094, -0.04444423069233639, 0.045056290923024746, -0.10490564490256372, -0.10073102417189042, -0.3488695567735042, 0.027780661172683133, -0.12426467069160557, -0.41870756786279717},
    {-0.39803855018682077, -0.22740354290452677, 0.27366562499984926, 0.1150663273098478, 0.3425113009044701, -0.021780937523602828, 0.40259448734551617, 0.03828304306283532, -0.05381284072247356, -0.31482068368993305, 0.5379459344575511, -0.24063001283844213, 0.8840338105716925, 0.014597651245001151, 0.2600695013348729, 0.34319450103833654, 0.06562390471915312, -0.2883976529176268, 0.1142485197014134, 0.20459950916512717, 0.5705847658953418, 0.12599537692368906, -0.09608313598025846, 0.2688095484434587, 0.09167800543705748, 0.013757497765601772, -0.2855462854936764, 0.10332227233177202, 0.09428546086152567, -0.5655293981983285, 0.5319132968035314, -0.5590634438519603, -0.18991136767900507, 0.06987903325011811, -0.1864126586337066, -0.13720382594295225, 0.10278752998750211, -0.4617835062336585, -0.29473707281954736, 0.3136841196269143, -0.21067030086942615, 0.42836683015931226, 0.6430823240200222, 0.23563918945151213, 0.6116317960438068, 0.3936081438691865, 0.7960298966762446, 0.309947858160832, -0.1595647765758897, -0.5067537805593538, -0.08121016181053141, -0.2362754121810118, -0.0657112149624662, 0.46018353193554856, 0.5791029303489471, -0.17619833417470326, -0.8876043751744762, -0.16341595897212396, 0.5019975162616167, 0.008439103533790954, 0.18725408514393468, 0.5687124583168599, 0.42497071258618585, 0.009697421821920972},
    {-0.20355994516050813, 0.17845043342124436, -0.1661216181073611, -0.06710924192821778, 0.26759916182077187, 0.04979738719441785, -0.20764881634515794, 0.24399065655058866, -0.6050919766125518, -0.2055181117442523, -0.16597358667988996, -0.7610349971202502, -0.08987180166106128, 0.5066103628036656, 0.03567277319783188, 0.15833464060251945, 0.4210190791492816, 0.6778656820062116, -0.2195624277903472, 0.10949880265102734, 0.24305575769493165, -0.23549763069948776, -0.05052787330327341, -0.35066683410276994, 0.10364305162794189, 0.24178225294573524, -0.15484715480588063, -0.2093566319935474, -0.23145045340928982, 0.038121448021097924, -0.2657249495583915, 0.16807195140226625, -0.6233720486534037, 0.7811560348211349, -0.5266314382260997, -0.27416354000414006, 0.2831280876663951, -0.17029334944650507, 0.3197137513578086, -0.16409094998547488, -0.43318777608256975, -0.448610527141219, 0.03997078661047729, 0.4550715624764867, 0.2975441037848621, 0.28511828190786365, -0.035731103281763744, 0.16048343516474015, 0.024500623914834593, -0.32673795808857403, -0.10096756558826504, -0.18822006800908544, 0.057409097627072525, 0.21023062705862253, 0.6417706278934225, 0.40113220980929054, -0.44809954744164404, 0.3163911562532811, 0.5132711540243375, 0.008874114431700742, 0.29381443075537783, 0.2744083814502222, 0.514216442207725, 0.4325863935995293},
    {-0.4925144877104837, -0.15416919005329366, 0.061413778153332044, -0.11229915642416942, -0.20729129510515787, -0.12734240210022574, -0.34771431474786435, 0.3561244536651895, -0.30664596402536765, 0.13475993234643957, -0.19622477102841626, -0.5591461786599204, -0.3970806346380042, -0.12149730997135431, -0.0037992841240135225, -0.36987930672354785, 0.19728861252004357, 0.6894066422700121, -0.2405574911781774, 0.17547779802132404, -0.010387731096708114, -0.07363978187006762, -0.34459223353984475, -0.5239327148736257, 0.3471593414806931, 0.187484807961707, -0.05038279050173767, 0.10544211811140952, 0.08337999583195574, 0.1699196111543, 0.15306586245511877, 0.5442237333155147, -0.06208247557244213, -0.019512891554922553, -0.13749263752077714, -0.44876867652073194, 0.04074907064070554, -0.03616285401165673, 0.1852710916267826, -0.07436370992020862, -0.10112945669973847, -0.43419527547884923, -0.18459623977815032, 0.3771903308807175, 0.027941610562670565, -0.04125178897388697, 0.5606270148705607, 0.1990021900147584, -0.106749973036174, -0.5245591184664479, 0.1732027006127565, -0.2821675854241969, -0.22436100729892453, 0.1014676482778672, 0.3364566460480757, 0.22796459869699143, -0.05241439183096358, 0.47353063433201453, -0.6554161503663225, -0.19798601123554682, -0.01753788759660975, -0.154891281324776, 0.23285006973327332, 0.43675074622447757},
    {0.023077333567972588, -0.023839468840982054, 0.19139047422747554, -0.18785593487134233, 0.08929700804536518, -0.02028513336131008, -0.1447688184086886, 0.0450263958034616, -0.2697112358623218, -0.03969661913491554, 0.15724480438619878, 0.056756198955105586, -0.17281126252142673, -0.3959950879746624, 0.25408180485852816, 0.6356922473042694, -0.5514555140097374, 0.326201414822239, -0.020207473720327725, 0.8133164309981215, -0.32160042620654666, 0.27333315974031086, 0.5004983188146154, -0.08570931731644929, 0.19115711209700006, 0.07557179391322909, -0.006416825936037175, 0.6258119335899093, -0.13369066857004766, 0.14990142212034782, 0.049722995973975406, 0.6724471017160759, 0.7943209855813367, -0.0943815342983867, 0.19058853035334844, 0.03192019558466316, 0.5734069679342587, 0.1160453534523004, 0.5388944674051439, 0.04473248123614599, -0.3272528124371366, 0.021268191113352194, -0.6174315468053146, 0.11440083089248514, -0.06723645746131769, 0.07398115268484184, -0.3948328732599418, -0.31834837908931995, 0.17179114149322425, 0.48659822105003814, -0.3453487474685263, 0.2535024831867551, 0.46212027909430325, -0.22927618410009518, -0.08150783873964741, 0.012732423105010642, 0.18947201000798805, 0.5372021009725984, -0.6122430148862769, 0.4281456114569654, 0.34377795588181664, -0.10910405557659324, 0.6443443033751964, 0.15909087770143096},
    {0.5426630908987403, 0.20401512101408414, -0.04221366088343855, -0.09940788650749918, -0.2113415389776154, -0.11180189205141189, -0.31993611982782766, 0.23888236848878064, -0.0963996563614511, -0.022621213013464047, -0.10782295570992707, 0.22418090756100112, -0.2517702803657301, 0.049237374671481336, -0.2754198948846911, 0.163378166689974, -0.17647364615247135, 0.2076430269502618, -0.5572099041798348, 0.15872102960620857, -0.048249356424655505, 0.37449399915889936, -0.018763632598717855, 0.2707174888457783, -0.1312974905005974, -0.10187957549833362, -0.10317842576058234, 0.10013666311050722, -0.3491873318360446, -0.13542047786190814, -0.11166698771618279, 0.33700605467130457, -0.16185661875809215, -0.11893014162348899, -0.12741479096333794, -0.24882970460982942, -0.3277644589157856, 0.22785164588774842, -0.4505146467367612, -0.22981261888457752, 0.1629303494756039, -0.16801241691705382, 0.08459548820267641, 0.20999525307857034, 0.10909208534865728, -0.10469791390865306, -0.34829024015257637, -0.6522538411553065, 0.2845778602405567, 0.1567572345933758, 0.41049254516141587, -0.3407514652516137, 0.028501725463373238, -0.20864290994782758, 0.511921563425926, 0.1239040274504583, 0.45211258564318757, -0.2995509830997789, 0.2153951005294654, 0.057600963990443066, 0.461088655933739, 0.06855913295290608, 0.18388329256432048, 0.06734315753814338},
    {0.2617291350395021, 0.3921785174857433, -0.7901394094265057, -0.0021705873961081453, -0.36305394432724136, -0.1969419862356903, 0.09009396435852669, 0.3512633077662635, 0.24802306765692006, -0.3168140585134788, -0.4627858077522294, -0.03420998739264672, -0.08108632068842896, 0.5797878685167689, -0.05282057975020178, -0.047880788101059786, 0.3761173961563341, 0.035761494882562174, 0.5027354279225686, -0.1630715390967597, -0.17755625532502084, -0.08241802000090766, 0.3843698887741217, 0.06977778201642605, -0.3575690952112299, -0.13849580357706726, -0.41895055391282116, -0.36420436084635194, -0.07067239909162085, -0.03569283794163007, 0.04989924076885545, -0.17725951717862679, -0.09222287801480451, -0.7528828229464426, -0.06348759049489626, 0.06608979527216856, -0.46435506746286154, 0.13499046974589982, 0.24747577848781724, -0.17855639720200403, 0.0863418473980956, -0.13276615097459304, -0.014685453660249, 0.12032048445118104, -0.017739280770390865, -0.3247218732745999, 0.6388629645374672, -0.16393754130957544, 0.01346496053513954, 0.47718967554623093, 0.18568937041520947, -0.2593984611752861, 0.2894227713955008, 0.5755083492421728, 0.02208812626750454, -0.4293185715742917, 0.26092855659072856, -0.185361902114483, 0.47638779630234496, 0.15072324819291916, 0.1464297592538306, 0.1850316352595553, 0.36699622021689443, -0.306683309688137},
    {0.19638389611963786, 0.42784998534131835, 0.29137446580516824, 0.4216572545436512, -0.08686055110854819, -0.02654913321937425, -0.3478298277990838, 0.012565902529785592, 0.20413229030037866, 0.1550815061002738, -0.212500200271412, 0.005118042349631005, -0.01163427169220259, 0.407317080871864, 0.48908947463177893, 0.2775133366448715, 0.12085374028062902, 0.04350488611301643, 0.49222481849490224, -0.049464678192646744, 0.04237086609556395, -0.005233078441161475, -0.1926691227064076, -0.0797156812866386, 0.03415057275568159, 0.013487770862322624, 0.4044379016368748, 0.1508369517352706, 0.19012298131362662, 0.22186604525067355, -0.16685930245540337, 0.49174645228918074, -0.12387931909141875, -0.29991502502531947, -0.3957160744169881, -0.06290201746789192, -0.6593279395372958, -0.15041776152139374, 0.647579363067572, 0.12108126477918392, -0.14121922649774515, -0.07144531708481996, 0.15257518295163622, 0.11992064893580559, 0.32124683084734607, -0.24057059702586295, 0.45070475352094036, -0.018232939477836056, 0.1922889092815453, 0.4614251307565122, 0.07308643150181718, -0.07768417555403047, -0.3194532037034672, 0.35506878299953604, 0.08675430185022628, -0.014178371160556869, -0.2959801166842259, -0.37577918512556435, 0.9994754328334069, 0.2572977668512506, -0.44990539128422197, 0.025601485005985518, -0.16729713312594757, 0.25952737991601255},
    {0.13801342982988551, 0.3072146919354521, 0.39151844625616894, 0.45828409377303375, -0.15928178017914163, 0.060075343322851485, -0.32607338712228773, 0.4528300435556384, 0.29903464620717424, 0.10684424074599194, 0.42457670047956075, 0.14285785216296273, 0.15057464061215373, 0.019430407383778155, 0.45871257798198417, -0.15836610751596408, 0.3875696277175969, -0.25991077145246155, 0.66971630685066, 0.19133056701357287, 0.09277206954780984, 0.11468865338903958, 0.21668834174635468, -0.10474067792373609, 0.19056443760295863, 0.025150999655596015, -0.21353421473580617, 0.04107058257285203, 0.07279069201006455, 0.032137541030774375, -0.14548735313411004, 0.35496992158721574, -0.16040454590114264, -0.1786737523536688, 0.17263783509782196, 0.12985546050559688, 0.05260536469898604, -0.30192161713401416, 0.16399823381215556, 0.19392167460222143, 0.16457227443735045, 0.7218746109146945, -0.09635065685177868, 0.33634093683298005, 0.5648689703422906, 0.010927964678051696, 0.38667180885409086, 0.1500702678559873, 0.11731441194203071, 0.2757348773729105, 0.01831539925653812, 0.30537816276780033, -0.32056319318091014, -0.13146479444166118, 0.17970484481211366, 0.04328282685290014, -0.13805450952339085, -0.3698579012459029, 0.39202124709332753, 0.3686013077715889, -0.1601656302862479, 0.4169969815106711, -0.428952905312286, -0.02160166101535414},
    {-0.20369496789915753, -0.17662926106297563, -0.1596112913939673, 0.09612612800086943, 0.2936260276826079, 0.014600164325027039, 0.19141448876758937, -0.3057003267857623, 0.13850914858847463, -0.11741388812795767, -0.19926599521807098, 0.19351529861086275, -0.2565220161308827, -0.7710070443075469, 0.4570112728605984, -0.6369405799853036, 0.11002824798669086, 0.021000389635655845, -0.18384471177873718, -0.38960741052186154, -0.054747918918103586, 0.06994471280659625, 0.03931439684245362, -0.16912983804110474, 0.3640862687848767, -0.2793204623259925, 0.052950944154919403, 0.5084667723025342, -0.09304293580895961, 0.05591022623496272, 0.0703005179883061, 0.17662916273661414, -0.6971355328100728, 0.0183074340099038, -0.27853129104883706, 0.3290922782878778, 0.5965144480188878, 0.04894663814919646, -0.355880398966399, 0.21569669307562125, -0.6352632640098107, 0.16313886036281236, 0.0023030447793556076, 0.025403816479017037, -0.7663036131308281, -0.028796233033954743, -0.3015702846342316, 0.1623313708606772, 0.0326362717062435, -0.18073237918147575, -0.3739330550792383, 0.24420956700624613, -0.03132221718640137, 0.10645984894666229, -0.362936206603618, -0.07833117107295368, 0.9344095227624678, 0.5246103694080925, 0.18540518371140183, -0.1147681864246506, -0.16156815762652782, -0.18591888904562592, -0.11540833490342405, -0.15249298079972473},
    {0.12096467076850523, -0.18910899020545835, -0.26593027593209495, 0.13582779796453878, 0.3924226261235645, -0.7031237072615407, 0.025063480704390063, -0.14187909300490067, 0.3774868447896626, 0.42012255935310877, -0.011002540133213893, -0.261414159260952, 0.2205538454816189, -0.21644101725090098, 0.045904861656920704, 0.003302858318452735, 0.07444323353773558, 0.3931528346957474, -0.1456251313798763, 0.21159917877149387, -0.5082200494734164, -0.19835300530376726, -0.6015813321016836, -0.554824883510318, 0.2551810517770279, -0.15975665083384805, 0.14602101954226865, 0.5557647926653643, 0.06703658228998788, 0.6878997814204516, -0.007502102884596242, -0.034680177541253875, -0.24509168258821507, 0.14727783168517844, -0.004890214241398048, 0.433366468323664, 0.2850243035882815, -0.25375710605555546, -0.719136852812782, 0.04450295341268647, 0.001510803587602994, -0.17192275754244393, -0.08086842532152108, -0.49579833348098856, -0.5366070088768301, -0.42246210101557685, 0.4319475204183296, 0.27179180951197507, -0.15493161475159242, -0.37734908644360354, 0.16397217416672294, 0.017127726874228706, -0.44850222034833304, -0.06354662058269255, -0.4367146089485163, -0.2911034263167622, 0.43713427184162196, 0.16962893224587938, -0.3034334871233438, 0.033921806936887254, -0.01982817593977719, -0.23250785121301146, 0.39088424717022935, 0.09705486972911657},
    {0.4021561845390189, -0.6303642975968593, -0.3716816340952971, -0.598066958884897, -0.3561051555396562, 0.12777276588578382, 0.061271778299130775, -0.6207810807209627, -0.22371529944269816, 0.02671415444541034, 0.11417561641014047, 0.08267703874319264, 0.08147257079278489, -0.42898260606554645, 0.2667859991828057, -0.1387888973160642, -0.4269931039661078, -0.47331201927662025, -0.3436637227699452, -0.3759706014874784, -0.17043310488960287, -0.5298023702166337, 0.12855614827951786, 0.18958771365052796, -0.028871488097566084, -0.5884266417972307, -0.2142345978552181, -0.1033628485712408, 0.32578809363285705, 0.10439651787893099, 0.39270777109154653, 0.24437212421991775, 0.5497600158738971, 0.1252358034881903, -0.05415602665410369, -0.5292337484573457, -0.031131688583163463, -0.5115544911674792, -0.22748396009326505, -0.4146734487912378, 0.3281105112679996, 0.10907312769115803, -0.19253470642472584, -0.3976629977615576, -0.3046372044180125, 0.22549910782871005, -0.15922457562110987, -0.25882642485101404, -0.30867898438555946, 0.06421930266197484, 0.13110320779255535, 0.20253690236323119, -0.2719341606550496, -0.06454712570046692, 0.1373020675724702, -0.5311984011466349, -0.02929117726480136, -0.1637872111048112, -0.724375942907479, 0.37059275939104996, 0.16492111771955734, -0.17521393979602515, -0.33567546967234824, -0.21281104454829455},
    {0.11160425943849223, -0.45915149354345136, 0.08538313952931188, -0.33397262791461224, -0.40131026587242735, -0.11985570828006084, 0.4224980191857604, -0.2504644214417089, 0.12126861128084164, -0.9552032326235204, 0.022221274953787312, -0.11399072811806532, 0.503954289206758, -0.17581180737318228, 0.16913764882402257, -0.19131988822284446, 0.12323130431372237, -0.40663367866423, -0.6181191631405836, -0.11659116683157364, -0.4692811179359156, 0.1610233943955374, 0.0376223219992431, 0.2527934563362722, 0.34203266799716286, -0.535633224357718, 0.09845182498450578, -0.42252665616613294, 0.2127885289069065, 0.3578576848363664, 0.3996169758588867, 0.4445948938561816, 0.4128789905637245, -0.503661920413323, -0.11474669414494121, 0.08322977237820676, -0.36328352107382583, -0.5389575228117962, 0.14441894274511166, -0.29009512692466827, 0.37408972176784777, -0.34404640120868774, 0.07194740781622413, -0.010463980732757632, -0.2866147157437055, -0.09437159074941959, -0.1584563534381302, 0.768582154417801, -0.004047944265813779, -0.0409430451194623, -0.0006641141638969998, 0.08894887516024155, -0.375618198419474, 0.19788120533456618, -0.4463145923602443, -0.05757403352745229, 0.12784174632280643, 0.25076034692237803, -0.04146041705296621, -0.28644137445276363, -0.4531814237235129, -0.591570259941529, 0.12195323291112163, 0.12445321744767655},
    {-0.06114727939222179, -0.41832320933456213, -0.14636822660474658, 0.7562448493546052, -0.14467054605452345, 0.3699288479347763, -0.3218460825866727, -0.1037578617961256, -0.3877530039182538, 0.26841745947334217, -0.03422120876624632, -0.22551603699621922, 0.04062978252651674, 0.5257715889620707, -0.5585629353227038, -0.21177837972981312, -0.19963626507284485, -0.17605605731667304, 0.2949023833934372, -0.03649559621008546, -0.34101859478771984, 0.4826761060141927, 0.49712752082434186, -0.2597166912658965, -0.10951121311397902, 0.12489890184694447, 0.47341977152229164, 0.03492789382333774, -0.49049910824862836, -0.050072347924862086, -0.20752486566339903, 0.5512805470128369, -0.1871851310094855, -0.6082575757329167, 0.47658916625522113, 0.08308690653311895, 0.2787075786532727, -0.20722182657121, 0.19765651565775672, -0.1851069336286952, 0.37293719125002617, 0.5868155958913744, 0.2341876527587885, -0.21359985864605707, -0.48388911607383306, -0.11364745927221201, 0.6248775342877259, 0.8442713158598134, 0.3600436297520285, 0.05917740819932502, -0.3154807740465729, -0.09982265273452263, -0.06920515795645672, 0.12497085980571919, 0.38924279163946784, 0.017198880401209187, 0.2683349992536896, -0.27900088385420996, -0.16560600110979512, 0.09421207281259296, -0.3777152222007871, -0.6804326081497045, 0.36372534834320974, -0.287886509412981},
    {-0.046657935941267444, 0.24901800057772036, 0.21110893158076766, 0.20505626466357485, -0.2095203915629414, -0.12943679380003417, 0.0916382726587145, -0.21859820070501018, -0.02984884037370853, 0.6880181875482816, 0.43891592642070615, 0.06975364402121849, -0.48920411523574625, 0.8948468976477382, -0.29939830098215575, 0.4049579612723958, -0.505640852059879, -0.12007273781034397, 0.49139779305997555, 0.22048882496425765, -0.2308065209643763, 0.3491500927266719, -0.0960812381460422, -0.5924501897163911, -0.48788599071319577, 0.23386058915127675, 0.0657827507018888, 0.26682175854459994, -0.007674491105228069, 0.0494597723812523, -0.5210407191616232, -0.2572860523630172, -0.13553434838629638, 0.17730894972127892, -0.11683942465041335, -0.16227597749702327, -0.4878601098694344, -0.4607023099514184, -0.16273822604455992, -0.33773294702643797, -0.7052335641104298, 0.6454794862329535, 0.837384814318839, -0.0022176765742093763, 0.09128253402976357, 0.28354860396992937, -0.030377226439224782, 0.14573216505014033, -0.29237474923757023, -0.1047886186404537, -0.09675628320905154, -0.43732320412380443, -0.335642070743476, 0.17691653480972913, 0.08549795613107815, -0.05563961691500506, 0.2102597162066021, -0.28913514194084705, 0.21792804626868745, -0.20707179683439247, -0.31037741946950875, -0.3331308848501705, -0.38319154658376225, -0.5751892923711618},
    {0.2776640922916028, 0.23128261466765135, 0.2067491104780772, 0.03338549812561312, -0.04830053837177487, 0.049609008653006915, 0.21060734725127345, -0.13724701351723778, 0.44233030744616525, 0.5285794732046122, 0.0902077036558333, 0.4045027524161336, -0.28226828902444184, 0.19524590265551064, -0.12651645323782848, -0.24206973540235271, 0.0815634300074542, -0.217202871487626, -0.029256730215936957, 0.20636059866374706, 0.4473062135201097, -0.3202174577849734, -0.09587712203931953, -0.04643896519323023, 0.14569643076768327, -0.39833081029467654, -0.2546960267812147, -0.23750218500486514, 0.5581288901592616, -0.38448145209626455, 0.18963218090772474, 0.17363478539693933, 0.20311063385775097, 0.37587717541449733, -0.27901638388308736, 0.28644961243215084, -0.3661511733924509, -0.07935371023250433, -0.14841584772354716, -0.01753904245965234, 0.08882242621615867, -0.38231207081616053, 0.34531076169106445, -0.41858459197454084, -0.16945442873598646, 0.2416164344345679, -0.30690538650797977, 0.04688159002755339, -0.15749868251795401, 0.7601763449999013, 0.39307089913795895, 0.4170587392665324, -0.3545862109577951, -0.44841711755744257, -0.4363444374993328, -0.2321528745210193, 0.35085171136819665, 0.14607885542837898, 0.26613636200779145, -0.09456907200591586, 0.18867489557056827, -0.012618475268311507, -0.503682244608123, 0.05690220461131348},
    {0.24582224686064755, -0.05385499052574821, -0.025360646604679255, -0.5001105140820109, 0.1100946376114401, 0.49281247213686524, -0.28416403286958436, -0.41327229765451107, 0.15603305400203635, 0.25440024713405124, -0.2091961174301448, -0.23985916024498444, -0.4689087281954615, 0.2659646247323757, 0.6272953010759605, 0.08607312344701627, 0.0825394766046257, 0.17026675998870425, -0.10952190858355855, -0.5291879078488158, -0.1262379192785954, -0.5003687111915813, -0.15104597625613586, -0.07604329270132114, 0.10531004203479669, 0.051173801807267404, -0.1401083100675488, -0.2951178359918137, 0.10484988656308078, -0.10474397944775332, -0.8677963392915408, 0.38362592241541216, -0.2102210844111587, 0.10412174216221641, -0.2734748437045975, -0.2094661507947321, -0.6119039547496511, -0.2061089425393946, 0.11169130838386244, 0.08230591839944791, -0.21328312627293702, 0.001186438543104013, -0.5426717904318117, -0.4529440809523044, -0.6777990426865528, 0.149817939512704, -0.11553387075383498, -0.24904956046830223, -0.4900373627161272, -0.37445755885974186, -0.012507676100412899, 0.2526659557483937, 0.2966112235011703, 0.08069328818191876, -0.3960214163451912, -0.10632152700521276, 0.20936446417278645, -0.37694502507506594, 0.019346593304224134, -0.34905083927451885, -0.14971790225511927, -0.6819234255406273, -0.30317055847297103, 0.10758253037745755},
    {0.009335797771717337, 0.46205761737246254, 0.11184193023318274, -0.1509662729158469, -0.03391683073338834, 0.0033558020704623514, 0.4192899611224523, 0.023023349468710343, -0.14893802633567438, -0.16969819503757888, -0.07078300442825784, 0.08681209025927926, 0.18844875653812923, 0.2977009415249619, -0.21540348526455408, 0.38452940211063796, 0.11594948027782453, -0.09551162646871578, -0.719088260216817, -0.003155603051640375, 0.12570287444534425, 0.015995400470856548, -0.23573754245991307, -0.08936402266345425, -0.029407598400146145, 0.506119228153736, 0.5271540765141687, 0.43638069191573653, -0.3038812976576228, 0.38350775662866204, 0.1677734680860513, -0.2441915040611395, 0.0520242126562482, 0.5604542579172016, -0.2992281958821339, -0.5680122309740779, 0.6121465262010527, 0.005243727635034898, 0.0867042318523237, 0.0023649705474272018, 0.14275495682789394, 0.0987180531446593, -0.3230287256912943, 0.07436704309252853, 0.41698015585966053, 0.06756145151724607, -0.46381736691868386, 0.05512596949094453, 0.1613201418479772, -0.21255091383836738, -0.5305180976898887, 0.08627665423938609, -0.19997952226486734, 0.4749987955506397, -0.15641468417075724, -0.15785901220783755, -0.5509273900006871, 0.1895611695751189, 0.06007368946465326, -0.15860519837179377, 0.34440495381028663, 0.09296633476605795, 0.12303667477548487, -0.09931971219358825},
    {-0.41577821022600137, -0.5656678898294624, -0.32575576097902076, 0.4395281354895178, 0.16004123978299414, -0.17981373781926316, -0.44763719565405047, 0.17134042282323667, -0.21025200379779438, 0.10535417352354129, 0.07268438267608618, -0.20019204810525212, -0.3419370275795376, 0.3427179181508749, -0.2917552119458352, 0.6072162373254215, -0.08373763738070043, -0.09674513018673551, 0.2822728703924997, 0.6057061472993117, -0.343273168143073, -0.49499741495192795, 0.581423343292786, 0.2993892031573881, 0.039014423905841575, 0.0686700525861021, 0.06623259123952578, -0.001800272303745787, 0.5291723265752903, 0.2594650851334554, 0.31030341445437576, -0.6553137454967747, -0.30257182227337737, 0.3086398767523015, -0.12162620687411799, 0.06063893158452256, -0.2760703121005391, -0.127837828115899, 0.06988392602311294, 0.1315428363602307, 0.1755985338109703, -0.566556430918546, -0.045759047695370855, 0.11943974230479425, 0.2853623141024569, -0.09503479165922063, -0.015117015832239107, -0.4048961345648731, 0.3476012618355827, 0.23310000470702452, -0.20448889698824618, -0.12472211200716606, -0.5388501015749263, 0.21793327291621148, 0.3638509300104585, 0.5586858933164063, 0.15732965727186962, 0.30845885194156325, -0.27921226364993734, -0.23128157092796683, -0.4101314969329551, 0.562196370402838, 0.694265342751712, 0.4643749162164571},
    {0.24225391024413442, -0.2873194192258477, 0.19609374194038046, 0.08736917084232676, 0.3495949816138877, -0.31066985152394017, 0.32786706548180955, -0.10359040146409383, -0.02736230586981569, -0.6264539318546019, -0.11229062295566795, -0.4697617366340109, -0.3014638448122903, -0.04694144741228217, 0.41983373956802034, 0.44975205776638666, 0.057856385895835895, 0.055788531736621134, 0.5201181984999088, -0.011180100795101731, 0.3235317668818227, -0.1496685325123834, 0.09565218441495645, -0.1707215883583102, 0.12575260848156283, 0.4283942008474391, 0.1299692010968357, -0.2452701402109901, 0.23866945038592263, -0.6494375636002735, -0.05305633856164838, 0.3527784729166481, -0.3281494534885177, -0.1493364969886574, -0.6255528985406331, 0.039977100438470296, -0.08143373948718856, 0.13158403223745885, -0.22873219389928676, 0.2469132422412096, 0.07894976420256243, -0.4467775264405444, -0.016219456339310177, 0.3199195781467383, -0.4865077585072972, -0.3214443665319062, -0.032103020068420036, -0.24840427412078397, 0.26569297283163446, 0.5780435660553951, -0.15338471617122337, 0.3791499654426831, 0.5078570188570143, 0.2340599426069911, 0.1422896352256159, -0.056324066480024935, -0.05003846206766955, 0.07917890906396158, 0.5403237180501843, 0.22254995736603259, 0.06851525571911135, -0.14551949007523193, 0.057213686958330554, 0.2581076947692897},
    {-0.524314288635759, -0.7467099082147342, 0.4952120763124573, 0.26474494465529147, -0.34480245362087164, -0.7406748680800067, -0.27445862845003954, -0.38292646385557094, 0.07893157496729682, 0.05490969356743824, -0.3467463256890341, -0.9897166290065412, -0.8666257814270484, -0.6899460112032622, -0.7228109965792989, -0.22591185431423624, 0.44892000488001976, -1.065970202142826, -0.4250490392672384, -1.0465328799088562, 0.19419981235133768, -0.7540769012757517, -0.9725767541043222, -1.2132793854625379, 0.1513484077682672, 0.2594399843815754, 0.2720934822521318, 0.05184614958261743, 0.44266883443123156, 0.3580941836507301, -0.08187010206216018, 0.2612182871269301, -0.6104297289158543, -0.9114312390047694, -0.7722738020028936, -0.14376567280687935, -0.7824137604402541, -0.05478423862447069, -0.7414195126863579, 0.32557916392632014, -0.5268100569014026, 0.15185984853763412, -0.06272959981134235, -0.6580364454734353, -0.7371311107473628, 0.40208609472240564, 0.18957657003896947, -0.33806403467207236, -0.8197629553314506, -1.0579631862758534, 0.12930381341462072, 0.2817403487673122, -0.18013623126525974, -0.6683029403740967, 0.022688870526363168, -0.9961547245366403, -0.6767123210953683, 0.15865132752161526, 0.29301914587768185, -0.4733057975526343, -0.8443038875562762, -0.9670782993765368, -1.1378496173857529, 0.7931640326012751},
    {-0.2437180148249955, -0.6990066846082934, 0.5230670421158138, 0.5570820347232055, -0.13015252422434082, -1.1018470252439758, -0.08491314853212728, -0.6132879332979899, 0.16937512003233424, 0.17494784614983655, -0.05116930957697793, -0.5920352402645288, -0.9306963360087613, -0.5835257103663367, -0.8011238002553409, 0.1050978930869336, 0.5298410206476879, -0.7214467195682456, -0.6170490903914688, -0.6386578658774703, 0.011833271272629184, -0.7161908921091203, -0.83475233666863, -1.1099971302371838, -0.10542704468463011, 0.2107558475864891, 0.4344535178820827, -0.3765053582464259, 0.7601670401021966, 0.33603187434250775, -0.40078029066034576, 0.04495902592064064, -0.44591492236096647, -0.6432619410304847, -0.8804603887918329, -0.4911722397044416, -0.6721552377364658, 0.5943699023268002, -0.8787002192602753, 0.3110502691159904, -0.9483481666398782, 0.34026671384970536, 0.41537028906154444, -1.0116392439147455, -0.510031004085979, 0.19009336265354432, -0.14911721131264674, -0.25380398489087314, -0.8175925386835843, -1.0444113463252689, -0.022709412127181937, 0.37641494475487236, 0.179887023612181, -0.5038900959026561, -0.19627733693155963, -1.0550198964917281, -0.19994621832386808, 0.4294686198471271, 0.0862341747245705, -0.7354170161852134, -0.616323420095286, -0.6153276643538091, -1.1086121055401963, 0.5593331460763497},
    {-0.36213047320980296, -0.6446574394024929, 0.7594166381992831, 0.32562515779932, -0.30920335503264834, 0.05823060695622632, 0.39226052395410577, -0.6218893043638003, 0.7261696543198287, 0.4226830117274598, -0.7958812503525895, -0.5513027321111574, -0.6960760638192872, -0.25839633461281364, -0.797945592333638, -0.014524607802593442, 0.6347530915707096, -0.7466151075290227, -0.03965968098611032, -0.6745349503683743, 0.21797030084327804, -0.7861905383781993, -0.693464860907859, -0.4656381794402951, 0.07500516533828382, 0.026732806592690856, 0.38582909659256986, 0.13123022025766787, 0.6001812450930661, 0.3980755235302529, 0.27373522093654723, 0.3942773441104028, -0.3136173229716052, -0.2945586315832873, -0.6964426758281963, 0.4636793898985557, -0.501332897979726, 0.005868353309740126, -0.46528714044238667, 0.41557492376887223, 0.5482032652367604, 0.08763313674797497, -0.4593640665457139, -0.6542553587700491, -0.7286067540124576, -0.07059055724221441, 0.06066909929235884, -0.939049276180486, -0.6868278637469396, -0.4236077363504986, 0.574167850836033, 0.09054268955014601, 0.3129271197432148, -0.4813665623147959, 0.200920238400785, -0.3681228465633198, 0.11193642782189137, 0.7479999482903034, -0.4679818631761318, -0.7670878718521534, -1.0329858756380874, -0.3613972262047735, -0.43333204106563955, 0.06683600362047051},
    {-0.2481208119613942, -0.36217513710592636, 0.6143271620814195, 0.42320604700045494, -0.7928233251764916, -0.12683621008177953, 0.3335199342250009, -0.6989672697491838, -0.016879781091872444, 0.5417938335016764, 0.08279802162353858, -0.15259089067659226, -0.17387348871822064, -0.019453666465239036, -0.5789305757378216, 0.06889480311669885, 0.5140300361538526, -0.28070137447299737, -0.26980240476416967, -0.3420944803120228, 0.24296930566440947, -0.9407212449520134, -0.9442709407177698, -0.34787763451368564, -0.0384240423932255, -0.19142713266089306, -0.481359204534935, 0.480079161872172, 0.40787662396318963, -0.311042979519678, 0.21700200470722175, 0.7498244937512915, -0.3768231432798895, -0.42086763987778675, -0.7372446350783818, -0.243320146451538, -0.43586040703546053, 0.5649167193640218, -0.9463291813315118, 0.6104592922417154, -0.2368805896973767, 0.029379189488333565, -0.6190141970388144, -0.24456243395428723, -0.4137793659163812, 0.06671773590254264, 0.19243760720613481, -0.6990871548211917, -0.7197360770174472, -0.6650844644520411, 0.5756668114922568, 0.6661006995588115, 0.221750874865711, -0.766406928055702, 0.6771928658678349, 0.18527400344225464, 0.9273996937977601, -0.18859517287172037, 0.5186438165034848, -0.782043077484987, -0.6238148141424036, -0.9445017460324598, -0.26025712768780895, -0.03050521743715342},
    {-0.20611145855994936, -0.12241885689286224, 0.30818978524973284, 0.3431424088418742, -0.2112432495352868, -0.35446344622158427, 0.21251124886162204, -0.747099983708285, -0.1845643582025775, 0.5161646438966944, -0.3273620827276719, -0.1404531050915008, -0.5883434826039772, -0.756317290041917, -0.22694433978984482, -0.1887259807124372, 0.4578350670540718, -0.2761314716090955, -0.11317965313622075, 0.19987918122321843, 0.5874061545578058, -0.5220388895192098, -0.02091748881344003, -0.005511663037413249, 0.08638734207639572, -0.0380869514014958, -0.4587002085210605, -0.5287448032040245, 0.5093839620573934, 0.0214739577578941, 0.08813674249326349, 0.43283975575386396, -0.11593108407434147, 0.11705939338668359, -0.7941813712034506, 0.4117290704085957, -0.18168626779941047, 0.019860256992372885, -0.3226882186940728, 0.4263919429263638, -0.40222181526559403, 0.3468440876908915, -0.2380895992776209, -0.25363842316873375, -0.35945109992630775, 0.7631157553636917, 0.2341680270822434, 0.1331843615557312, -0.7863319595431487, -0.5048942694119423, 1.0673126011630154, 0.5774487958618901, 0.43450666325864507, -0.4806008268652802, 0.30632413754959315, -0.02379808770261626, -0.13019717331778105, 0.11910382369176623, -0.47713007605468094, -0.43722649691078863, -0.38932453466137085, -0.6132997822913643, -0.2136412603691353, 0.4619896781945986},
    {0.060584023010656636, 0.16617883780974813, -0.0227071472154576, 0.16169349425809434, -0.007119226929887138, -0.09990493319359822, -0.4824679225562095, -0.6711634852418024, 0.15967631673297536, 0.5951934916113081, 0.16805537477595273, -0.016499717016246685, -0.46992465967052405, 0.09270510362023196, -0.4400667988826425, -0.19596125687653063, 0.44912985714805564, -0.3108507973848594, -0.6857725149075159, -0.4293633911593498, 0.007268992737644796, -0.5166942044507602, -0.7012467512754043, -0.5499325570532765, 0.19878625146134943, 0.0982270075693643, -0.670720562683987, -0.033070343212453945, 0.06310036354797187, 0.0006547826415641099, -0.14162629866670687, -0.5074056616513563, -0.034579459726691165, 0.12098166302974026, -0.21991160156287612, -0.01881550475884897, -0.49315301068279704, 0.3027896564169489, -0.4923983193575552, 0.34528082940444205, 0.04113402236756704, -0.3542772055700637, 0.1379825837562322, -0.41417312298828296, -0.015161917657492315, 0.09843293847092212, 0.5197029022402977, 0.05384031422552589, -0.8606780562142408, -0.730007904098632, 0.4279238966249698, -0.01578071996900041, 0.058676230651218804, -0.7056439144471562, -0.6701752855149901, -0.5713098009548951, -0.388180031771125, 0.3569963064753248, 0.17011353785073377, -0.2476413797662646, -0.7224716066956157, -0.6221131264520795, -0.9067126825493863, 0.44868024600433054},
    {-0.4167864532154536, -0.6477972972495475, 0.49725954961372004, 0.38583285215856183, -0.1642877673604779, -0.4779800061492964, 0.4417696380833018, -0.35478931994068746, -0.24967954620736468, 0.8179070831681957, -0.016304757004325404, 0.1273580129270161, -0.7348402437467491, -0.15128609956206315, 0.0034756284062107956, 0.4072056437813123, 0.8461782511000504, 0.5831302508451851, -0.5503167863837509, -0.4451681483408757, 0.5609434809568925, -0.39561510755211793, -0.19015433665893605, 0.09867291505751823, 0.4590635973610292, 0.10906543595585741, 0.4172399556868856, -0.14898147218357935, 0.3094724858093718, 0.4924175367607459, 0.15159209826402487, 0.03935799995860186, 0.10081419678910351, -1.031997971334071, -0.7800898898048139, -0.2339554705180957, -0.16543631042415435, 0.8059849478776746, -0.018494771414604993, 0.2338381002301235, -0.4312078322727309, -0.22046491713161817, -0.2493161029177673, -0.07467048422378617, -0.285164322495655, 0.3002952201855399, 0.9004364537190779, -0.3903127108811233, -0.8606904905753239, 0.5438095643503703, 0.24081676653049428, -0.15273498463689544, 0.26550472885385157, -0.4514212856950501, 0.45418345280120337, 0.49311931331134656, -0.42897929387253453, -0.3362360730945663, 0.37017468075589877, -0.18438882962520395, 0.013255292357651275, -0.024360819441095815, -0.7157265093794201, 0.0330355993472832},
    {0.03599353666097926, 0.09282760222183996, 0.33440316312527674, -0.036029168412589276, -0.202935069107143, 0.1478407387800623, 0.0629707314907136, -0.5038335374778665, -0.39329573169447707, 0.30401543872562353, -0.5519140199493726, 0.4108758599110892, -0.4004771228556462, -0.10136209804559868, -0.5140236675914368, 0.4496561492078784, 0.743224531936784, -0.18495466384843334, -0.22810090785256262, -0.29859590247823864, 0.8145618147983367, -0.05144125480253499, -0.3120652382350219, -0.27141770188366415, 0.18371984904060232, 0.07741781668335589, 0.1731733103401555, -0.5965288840972185, 0.2668631144796716, 0.011939822618252084, -0.5382558907973614, 0.6089895287677474, -0.6877491880420319, -0.2281521244690547, -0.3159621593169035, -0.1470344277074502, 0.19402205754962895, 0.2608684100859371, -0.369801205094561, -0.17648154966754803, -0.3617875707939452, -0.1443229848056851, -0.1801393433069142, -0.7099426149016832, -0.2885745903604017, 0.08387930491062333, -0.5021905724476878, -0.10970519092059752, -0.32630623980142426, 0.3298827030221197, 0.08507632587182996, 0.23693398547112102, -0.24749373344961212, -0.5475896176269398, -0.5250669369691717, -0.1446207703422629, 0.8535306765747078, -0.5416822111670611, -0.10367929944914255, -0.013661589591992512, -0.1638353381787621, -0.3806208837151815, -0.2157314844638039, -0.10033349801268066},
    {-0.4914851215370971, -0.5777850880512689, -0.02626497149814096, 0.5580324279430497, 0.5629887023357856, -0.6287593960294737, -0.018821456481076013, -0.4775852945410135, 0.162807102576997, -0.4805801013215716, -0.28914821967381404, 0.15271693204517206, -0.7479597556401657, -0.01434867385525454, -0.23298823220658874, 0.626879867010346, 0.3935532488145418, -0.05607885720590069, -0.7325979859793714, 0.006534070146913374, 0.363703766918034, 0.08923249535862009, -0.5632490273823176, -0.4947531943122175, 0.5918779198187435, -0.22519390046508123, 0.363209639485837, -0.15033433709555574, 0.2755423130145727, 0.30909357241698515, -0.41809157451854495, -0.0290530991789157, -0.31595120993444087, -0.445015417792713, 0.3899905970421211, 0.077538534737235, -0.39661779696129335, -0.06656497555687957, -0.17001040264502046, 0.11497055556985636, -0.25843531053364843, 0.11278254053103438, 0.24094269978180047, -0.6339066414024587, -0.13078098733635632, -0.1477088327754881, 0.04259996891598753, 0.1869810973033487, -0.44021522153413795, -0.55293492685109, -0.044055502283775236, 0.4533624151560886, 0.03919864096460778, -0.4702176879718824, -0.3975974368536853, 0.12864898903454502, -0.15192105601758057, 0.6282524443923115, -0.19555723586654047, -0.09185086301652941, 0.3773012063017692, -0.6536443513289483, -0.5178447625786483, 0.6237200710690464},
    {0.16338154974359612, -0.3358894198450422, 0.16437783359564534, 0.3733415545368231, -0.10154905268606759, -0.5902437948021427, 0.13358106768123612, -0.5387690185203393, 0.13685563141451978, 0.3330426868124296, -0.5407647400421222, 0.21831293027721846, 0.4935075653433663, -0.4167953250851776, 0.13506908886119134, 0.28997899631345025, 0.03579944147504985, -0.10696018075263765, -0.27765111820685, 0.1973006403528014, -0.33939182109706983, -0.48517699511864554, -0.33494858082008616, -0.004784677582778672, 0.5172729089508685, 0.49062008046553557, -0.22597012451429851, -0.18522336765313285, -0.40707056890239784, -0.1372967244014312, -0.04651203616726302, 0.7692022930140474, -0.2472716028191146, 0.005082853676770904, -0.5203570033004333, 0.7780286691329215, -0.4470640121153745, -0.1689294334573235, 0.20472718954919616, 0.42665460617640905, 0.4653297527273743, -0.13938386078804216, 0.23047461086777116, -0.4566811823509749, -0.1032971940613835, -0.6146657197635466, 0.5932006658876577, 0.14800452067359007, -0.15247882165544174, -0.5144893274915124, 0.6077337063527242, 0.47504693775402024, 0.3101092927927445, -0.4818337931572703, 0.24520471653623743, -0.280647641224164, -0.029401146321567394, 0.3616412974641346, 0.9423665435375292, -0.4906009789381958, -0.2976485192632214, -0.3521387216936095, -0.06498192350601259, -0.24261816525194},
    {0.271642592022154, -0.21461233565343166, 0.8495176727726189, 0.07784079443316723, 0.5557572074892044, 0.2436233047569616, -0.5461011865804802, -0.8087081374151228, 0.3191289735041848, 0.1714635251402468, -0.020339556966581837, -0.16446091567710525, -0.0067224971493764375, 0.3878722200004594, -0.008057062873533562, 0.43450199111096105, 0.7133872146206831, -0.08881227829464212, -0.20138347371916573, 0.1323838860095003, 0.5516012391953163, -0.32855125420765324, -0.22724018156473316, -0.18737409797390828, -0.06061513092169646, 0.17770273012068583, 0.12210994034906307, -0.10667465732009092, 0.608392908230739, -0.21601600021586614, 0.2838907262059653, -0.23909946273736907, -0.2671436059534929, -0.13771156525167036, -0.44264176895619334, 0.20298756918183058, -0.48684620534653184, 0.7689268310263409, 0.018015835157221948, -0.6280368736575899, 0.0654987986984604, -0.28878259771184045, 0.2599267575365331, 0.2427339681000468, 0.03723649942284971, 0.6052440489801818, 0.5682461493804608, 0.15215066527972648, -0.22141726547760868, -0.08897558014223673, 0.40541233358195916, -0.002049447776311561, 0.14528369586176174, -0.20781901493963348, 0.023090441396063227, -0.7567489138537237, 0.4991344236804569, -0.08780982273130322, 0.08133545965312583, -0.591645024212504, -0.3012433975571719, -0.08051000839796962, 0.46401623999267133, 0.3011968719131819},
    {-0.45001319705589954, -0.10017969644753358, -0.25910556683377467, 0.662510201657373, -0.3956051338113368, -0.11749625285947671, 0.31198896714446445, -0.1778485583924327, 0.06998022445742312, 0.24670080641075803, -0.16798739200093474, -0.3039146705068599, -0.2808838667063523, 0.1543495583535338, -0.31705904184713973, -0.37265331561329723, -0.1686236996263717, -0.2872187310134046, 0.567344591791482, 0.15289365013098685, -0.6636993929224394, -0.22453293796639523, 0.9036231179964851, -0.3886719390473026, 0.1530444755212765, 0.6107765582556924, -0.16550370290925404, -0.6520005763432141, 0.746431425792037, 0.008484177172718889, 0.5651706988600125, 0.3432140079276097, -0.5789801683677088, 0.31771596870924973, 0.02135095590763444, -0.022978478112931952, 0.04935818789214268, 0.3786652175603281, 0.06042894880103837, -0.2847969442836571, 0.14257323989174234, -0.4851573603225622, 0.1171291579691067, -0.18262763604806362, 0.4397850203399359, -0.2962412435263436, 0.9276289279653613, 0.013829973475241517, -0.29505302532296845, -0.11477039809894232, 0.779266788517753, 0.39199361945910105, 0.03453485599116426, 0.11340174565126579, 0.32285420919989877, 0.14958121700276422, 0.2923400271245938, -0.3999675946675362, 0.8200134385712222, -0.15591968755065597, -0.3480016172947586, -0.7873496455015347, 0.27105734446304613, 0.05912677951432775},
    {0.311744638947126, -0.27431937637255355, 0.5989138058740653, -0.04826394052082809, -0.010875947345338552, -0.6825990203725287, -0.12831987494284913, -0.7083939557608918, 0.055382434039057245, -0.7599198757054914, -0.4466257254833455, 0.2676606184657326, -0.5736617651976603, -0.12478104154070932, 0.09852255995525065, 0.475008746546972, -0.00743586332834932, -0.240824714461616, 0.09112523946380494, 0.23171946120403303, -0.2250183232477906, -0.08258000184010314, -0.10771987785924662, -0.7582587415952476, 0.6397273287414803, 0.2271048114642588, 0.2761342449269335, 0.3445784574769554, 0.32676140732983316, 0.0018903626420318704, -0.22239562842066712, 0.22864741767457697, -0.3143082558398801, -0.3814341192145174, -0.04125823228213078, 0.48860083648408353, 0.29325332938182647, 0.7083126822773324, -0.054585123692059805, 0.37198716699786755, -0.06453602362006576, -0.18981727226179917, 0.2540708335625521, -0.21183044780361943, -0.006029240277533482, -0.533875616158559, 0.21647735153401, -0.2020498574435681, -0.25060449052501865, 0.22617779162314747, 0.009666359824915953, 0.4523514863357372, -0.1429045198375973, -0.27520527710151954, -0.5650992764749881, -0.23843765142519457, 0.5971262740697034, -0.26800930311934873, -0.17139849709236887, 0.31685094844069744, 0.23231794371944064, -0.24873955701523115, 0.18299892920662295, 0.12833486547455333},
    {0.32509408104904336, -0.10548189872882294, 0.22304594280067122, 0.2508338865737693, -0.6394130377404359, 0.21025625196298617, 0.09272775926581445, 0.2656062948394623, 0.009466394157867661, 0.7652312882375331, 0.12955589910170054, -0.04401707247881001, -0.22850593435191607, 0.1288468612875694, -0.4815658347191991, -0.06468846515125631, 0.01261270412672075, 0.31460322116732503, -0.6898143564519857, 0.3509235576439072, 0.27375152491110527, -0.18556829164958177, -0.4031056342956742, 0.0927276302273847, 0.018576910161681042, -0.2245623731727271, -0.6148898272904502, 0.2683730098835389, 0.7182827537633452, -0.4334639625736117, 0.1664923726793185, 0.6972750202414325, -0.10151552500812835, -0.2876935355211586, 0.006396296180014977, -0.9135870808335447, 0.17913692755411376, -0.1047825314267741, -0.3174733315516339, 0.8395207896611611, -0.22609630367725306, -0.2450955885792877, -0.11538944237504684, -0.5031282460789837, -0.059032763017008334, 0.2221055332582783, -0.6173821288412317, 0.22258069103058933, 0.5238761869966944, -0.2879905575175142, 0.18726846763907531, 0.0878324489371503, 0.24002501364300785, -0.4541776624213721, 0.07289399409698875, 0.42949936462565375, -0.5819229968483927, -0.3759481989359376, -0.03885767793012452, -0.1820262334484935, -0.26966589029246185, -0.4733007641234264, -0.16083283134083015, 0.28084607768271325},
    {0.3854748241940386, -0.25054343963363085, 0.226123493123781, 0.34186951130805454, -0.22880885591032313, 0.3050870224622169, -0.7652259858380503, -0.008440796526636802, -0.11266043544958708, 0.5109967838304467, -0.3596364585232543, -0.2553225369917773, -0.0004799044724868239, 0.5874483036007371, -0.0442784976547508, 0.26178154595528275, 0.22488012339460767, -0.034216622464300205, -0.1657253110012569, -0.849924183432925, 0.35013704482178015, 0.1687541700640182, -0.4110119510018092, -0.15102897470500967, 0.3673529668755827, -0.18938347772234612, -0.0617882684354717, -0.2550794346744725, -0.19783228231410452, -0.3533570044979269, -0.4335836471490829, 0.14059423811551422, -0.6143247060536242, 0.10992027919399412, 0.13205751672388888, 0.07039726313752243, -0.07361490822881143, 0.23904808809876804, -0.019707804972478354, -0.5236604131413664, 0.43571707184013375, -0.4200586677168743, -0.4843057435614479, -0.7817231395568618, -0.3716881152250194, -0.1120003112225028, 0.20253116927952533, -0.17216386113884508, -0.5229984860516083, 0.011288193336424309, 0.33979599411288774, -1.0427069110981706, -0.3565077424941151, -0.4860256668324717, -0.11634673265504426, 0.3153406835172498, -0.028860841868544228, 0.40632962701769093, 0.002243530747874176, -0.19358684111263996, 0.24144644515226096, -0.5173791430444276, 0.4789944481437818, 0.5005081003791226},
    {-0.4124328507648241, -0.21871046165781322, 0.42074797490250604, 0.21198023374243138, 0.02759143770323158, -0.27339439814648964, -0.4113597571643127, -0.5378035305638786, 0.392586392718811, 0.025627658340636267, -0.3617820533487664, -0.6343359935759624, -0.0958044839934146, -0.7833221805224959, -0.02608055168688213, 0.4293517079830198, 0.3537095134464372, 0.19979083854605958, -0.02043047885606712, 0.039187201482111765, -0.38621556227990456, -0.6495144218398683, 0.29921412520515395, -0.2666506341828818, 0.010903789662359113, 0.018576435160448355, -0.08860701146201694, -0.07394591515104736, 0.16039540621782958, 0.13123612315351388, -0.37202670215729844, 0.6964577281878366, -0.4195797669255808, -0.7962465840615172, -0.5589876192881211, -0.09155822489474606, -0.40043640432953437, -0.2408417506284628, -0.38060949572376945, 0.0051360037186572735, -0.6143562114921692, -0.2352019274680992, 0.364931811771233, -0.6154426871175526, -0.24259401724228163, 0.5324183450850083, -0.8879838695791842, -0.020524954090652556, 0.4084679418895038, -0.13477752659854125, -0.3748733136625559, 0.39631218554724157, 0.24956077644738128, 0.007726941601312901, -0.26949900821886325, -0.16105432433152525, 0.47113526295444297, -0.5146772640104417, 0.7165356490964765, -0.2292848667971982, -0.08632997982275553, 0.37942872966780883, 0.21170291425211762, 0.1027687773985448},
    {-0.2765099524720141, -0.34088008935775826, 0.05554018091725135, 0.4225350302154932, -0.30794139770433604, -0.14092065534066264, 0.0904533038301895, -0.5359860804615085, -0.09252229837595453, 0.1315840135329208, -0.09950823961623834, 0.502711322944633, -0.26655474297299575, -0.16242336179721698, -0.4629027257126597, -0.5820560236076998, 0.3053152579235023, -0.4283915292504587, -0.41441565957281334, -0.14505109592487186, -0.38429487877451035, -0.32197042216403743, -0.955664014768875, -0.17692351482578847, -0.42688658684258424, -0.18695913885521567, -0.08405314970125645, -0.08136835735988446, -0.07143588443805578, -0.35888904667182236, -0.2766970623148381, 0.13007900841008022, 0.0706098209520855, 0.42352518825047986, 0.04635290670773978, 0.08827141365964485, -0.5448501044659874, 0.027961798073125422, -0.6404608166307924, 0.4483435292752018, -0.4124981017928471, 0.0056180614524239, 0.629754202587319, -0.1599818731915198, 0.43414245494061793, 0.027361708126456125, -0.27217255698561027, -0.06730623767810764, -0.22219296117651746, -0.4056588767758743, 0.0051088814113270965, -0.3910457633381045, -0.1754650158395706, -0.5071953894950215, 0.05022186060875485, -0.1325606513095816, -0.5019258554355235, -0.26241537573814344, -0.4451762816643023, -0.7609231140848645, -0.5090822640054072, 0.3128406288461409, 0.07632715034175656, 0.40391781719406594},
    {-0.4587283098896396, -0.8623589430199086, -0.4330911052888797, -0.1486604430398713, -0.03158311434851057, -0.43512375648256757, -0.5014271783494119, -0.46886480599835245, 0.5609569703498015, -0.35953030794471447, 0.2412131963946394, 0.1783591311174958, 0.07341533634482322, 0.40558457868937214, -0.17263888241199477, -0.031090411361467025, -0.16797762635143212, 0.4298158571309716, -0.1636269531265066, 0.22029934330654058, -0.07714222313505766, -0.12223891731193455, -0.2117425754203567, -0.4071954209422667, -0.03722135795826624, -0.42614598520305524, 0.09169161326893956, 0.021075047345951295, 0.2097400735921473, -0.7614078991345913, -0.3406238372506578, -0.2935230356584811, -0.04341401490030779, 0.1314272926575384, -0.18900820886827302, 0.8939469869552892, -0.6337069520020975, 0.5415077656072046, 0.4399119813782505, -0.2792058135261859, -0.3625204494607157, -0.35319007296733823, -0.05471081915019827, -0.2073717055300223, -0.6955402284020588, 0.012808087933181304, 0.21319071504522252, 0.12368660934193482, -0.31173458804116255, -0.16005639865663118, 0.09743286483813471, 0.058447264043229474, 0.16709329279790364, -0.3301711021443745, 0.13677448048154123, 0.030441766712071813, 0.3734949624328408, -0.11944399879632785, 0.47007536280507567, -0.5909275658777677, -0.5704610174297071, -0.22232314962905284, 0.4185977073444665, -0.22638771583206233},
    {0.4495781029955077, 0.22204422696386447, 0.685802415063922, -0.0033989823500970478, 0.3994237158771815, -0.1377380942457466, -0.5979256909625593, -0.5059006962851607, -0.5582146525288395, -0.7418827780034296, 0.14470082097137496, -0.06486962172985578, -0.11378794825406167, -0.4282737804695346, -0.33732950090117264, -0.11413874481969058, -0.11559777106047138, 0.18813371297899403, -0.3006701455572805, 0.013265730474530658, -0.07472804885166569, -0.023106165980522973, -0.34935248712152406, 0.5044297008296158, 0.1170287976463913, -0.5143116630251476, -0.4403542484089623, 0.27934181584325635, 0.04384543556624955, -0.304973584770175, 0.005001302927149418, 0.14128622047532818, -0.43922662740193114, 0.26013992909975237, -0.6155683402730757, 0.23500338829663794, -0.514247738239779, 0.6034334526343446, -0.2254435070118924, -0.3900042182501995, 0.10222486906060418, -0.3787946331654832, 0.8372775033984223, 0.1490132525454741, -0.3709734818272616, 0.06906746339265081, -0.4565303804382156, 0.08690861620615212, -0.16937822127951507, -0.49718195225786604, 0.6284792097732683, -0.026661383472330942, -0.24020921775624332, -0.4968624212925115, 0.13409759862903675, -0.19364081800058922, 0.04286405143314676, 0.13169365236139333, 0.48578932094103805, -0.25796062311775464, -0.6694168031959434, -0.6241407583128405, 0.15953398684139256, 0.4301856281125788},
    {-0.17279343636970435, -0.4587058320087428, -0.13201562722365745, -0.08289962419864859, -0.09985956526821047, -0.19568392451588543, -0.5567576486850075, -0.6325437186590449, -0.07017656982866162, -0.3995387147684878, -0.6215796600818964, -0.08381235925717376, -0.4219365320421709, 0.06397699017076446, -0.1711437218678076, 0.5368834245403898, -0.4415131203595549, 0.33729502899239683, -0.9297990220393735, -0.050177241930367364, -0.15461643368986533, -0.7081993484048793, -0.5978938781164393, 0.3741947495441362, -0.24858543987179313, -0.5517559118907266, -0.1489799426295143, -0.24915573242848157, -0.39216668016658807, -0.8324769739368224, -0.3487962446184054, -0.38757456110381644, -0.32179749408620745, 0.03576749499638016, -0.31830211717014567, 0.5608598455918844, 0.03020476114889777, 0.11294645601994995, 0.18156736465203632, 0.1375302940324602, -0.2011375005145185, -0.4331404767368635, 0.14483279886820113, -0.21851863422479748, -0.15216050390643576, -0.2704923672833244, 0.3809863305204723, -0.3857586189214796, -0.934179427370899, 0.2441798187334232, 0.19278952763163937, 0.030333089212808344, -0.35012400256417464, -0.10711930673637715, -0.27851942477819114, 0.3864620421748054, 1.0206773101153288, -0.7058871255734256, 0.6364579149694614, -0.2497323377163124, -0.6989943731755199, -0.7299515029353529, 0.0027482286370737086, -0.15862208688764518},
    {0.6534711476037244, -0.14343955075117137, 0.2912230947927046, -0.37954818269665097, 0.2860714436562899, 0.0770512231908228, 0.5545127654780104, -0.4304347853969619, -0.09772542679833959, 0.11339766602283147, 0.7476061698888481, 0.04511751052867769, -0.15389549171597255, 0.4662647408555058, -0.4028403014000956, 0.6635000750839128, -0.5462283515076866, 0.02984085157660589, 0.20342994761717345, -0.7536175490779595, -0.3615438714164789, -0.40796497050555586, 0.23804879621981534, -0.2113936379540058, -0.1609104963341737, -0.2114452471853728, -0.09492966190699727, -0.23304619524591874, 0.428458034562998, 0.046141586474446265, 0.38481885335865373, -0.46243875284050556, -0.16852467459238762, 0.45113345479878053, -0.7550455997371597, -0.04395767961579066, 0.028703935669866294, 0.006332762354894292, 0.33200486788527367, 0.4375152388606251, 0.3834736998503321, 0.04601766819970315, 0.11251715296294126, 0.20531850163341211, 0.09671391965391118, -0.6664601106366641, 0.1137315257480949, -0.7905994610803102, -0.45380271832832736, -0.5884569174375566, -0.09230688605835967, 0.18222700986496282, 0.2348523198129282, -0.4418432250529678, 0.5063998696607676, 0.1546883024275369, 0.017110941294081278, 0.2794491644066029, 0.40356158045089985, -0.5048272391859011, -0.44832345321383593, -0.004403145309297274, 0.5197271425065815, 0.29429991100122327},
    {0.010164690388709268, -0.7320322310053262, -0.04096513522469158, 0.41379864468120925, 0.5626344655034434, -0.49242101683857337, -0.4260488170291398, -0.6162864610572912, -0.16858812178534477, 0.302030857050192, 0.5805046496120199, 0.23500103490563196, -0.17413409629084944, -0.3615899713575525, -0.26576497549223904, 0.7147315570006395, -0.4928942821539544, 0.568244345611981, -0.030025879211762706, -0.40383804059729916, 0.14331061127473796, 0.0399807606012504, 0.37706373462655585, 0.06433802998803768, 0.46861818618520995, 0.47265939151625935, 0.27684145906511853, 0.2593160103753898, 0.6499280948259839, 0.12013623436549521, -0.008269750726078152, 0.16458842139300198, 0.015087522562076452, 0.5191919869834194, 0.05074339802123627, 0.1612470516378017, -0.1081695531531849, 0.44489006565517464, 0.029409964627341956, 0.4638888227991651, 0.42243629588474674, 0.5004164086313031, 0.9769087533153691, 0.29172629603312966, 0.4171358200289587, -0.12887488605595734, 0.9560354660893837, -0.21751973920473838, 0.6046377385232818, -0.05949885228631751, 0.7221580526601956, -0.33352923101872073, 0.21837468525025736, 0.22509759603861187, 0.2565936028330495, 0.48763874078371794, 0.5369204891838874, 0.6975355598243922, 0.6755903032378838, 0.10841877357387285, -0.2101366768083507, -0.9111603537738152, 0.20260486429821714, 0.41342864218446124},
    {-0.29267565361406045, -0.14053128943549292, 0.15298194875955515, 0.39993792326153615, 0.03719535460265769, 0.0015423812183107206, 0.09175091511573008, -0.45182524272459573, 0.22403526679561406, 0.4647903743700022, 0.32348098455879093, 0.053571381056702595, 0.11488129058153512, 0.23090061413062843, -0.6617611331238353, 0.1769753189644234, -0.3362956769816056, -0.1483876819838141, -0.2812273770204271, -0.3121612504468279, -0.0880281313480558, -0.12674476187921524, 0.13589043661612019, 0.35703793775675935, 0.24840265458566418, -0.14502895881905276, 0.17004997386839013, 0.09810087622276792, 0.31566883753529645, -0.12383909317644078, 0.27801419766920576, 0.058802383414247886, 0.19667987314430832, 0.46560839151135025, 0.08099086429531348, 0.07604163542432825, 0.006026755890628078, 0.3857713249135147, -0.5962498822470113, 0.31101960471449075, 0.21031490271604747, -0.3236109755250527, -0.22158447689223562, -0.5033282216921343, -0.32638079379669965, -0.052579398112046906, -0.1848902089028173, -0.02941876904889569, 0.5218946652085185, -0.023417676435419667, -0.08611771020429725, -0.42840951781228853, 0.30715404394856166, -0.17099466326185556, -0.17222516873890698, 0.17047539037860152, 0.09294318848696553, -0.3684935735621233, 0.44125660552735585, 0.1447863478253131, -0.018750027385513922, -0.6209258566828523, 0.7288216361799275, 0.018996509767608468},
    {-0.04808790648399921, -0.43718198598199326, -0.2718945529136949, 0.33624272496582586, 0.10929735950603237, -0.039739342142049654, 0.19353910391034665, 0.14895420434985715, 0.7141030603596609, -0.07976218691672342, -0.5276381312600812, 0.13365855730171194, -0.5033816993239275, 0.14064212888940344, 0.5436757232277188, 0.6429662399385652, -0.26618222556723153, 0.12520883143154254, 0.013120259168536954, -0.1006796567414238, 0.6217373448215437, -0.14745536994268568, -0.23115249522393025, 0.21709065029702457, 0.420209796213461, -0.00427703667868787, 0.1555966231681587, -0.21573939265635916, 0.27172359844751887, 0.3431466812435383, -0.7122075568269145, -0.7831131776358733, -0.1498446088835891, 0.021695657057032497, -0.20655199217810355, -0.4591503490946604, -0.24774247575675215, -0.02995841815111492, -0.06176294691243081, 0.3044379666304438, -0.07546013812935956, -0.29386524073617654, 0.2577938979512231, 0.03117716399690718, -0.14402771295618166, -0.6656371348267812, -0.43680778371359735, -0.34816615831038844, -0.22411290565611605, 0.6578763215885107, 0.13486730820334517, 0.6378826910008224, 0.017740870936643838, 0.32236120466730583, -0.5552240963894605, 0.04389452006389859, 0.168177642701883, 0.5501818440037392, 0.3189655945883071, -0.05272897440069837, 0.05087357482218845, -0.2694905587605719, 0.10013295386390712, 0.2646418026075604},
    {-0.27325646815551874, -0.09822328006257702, 0.16769682952365622, 0.05182662099918424, 0.20496173293274758, -0.20459096665600124, -0.5962540576430113, -0.20895171240180527, 0.384787625084647, 0.41383199611811666, -0.3032105446830825, -0.5796578077319982, -0.4457772878264346, -0.8571049994325591, -0.16968840972714128, -0.09128813401509214, -0.04902211746747674, -0.5450170599671473, 0.4150019134613877, -0.14316713745202486, 0.018454882133599537, -0.40931489636953217, -0.3820122209562979, -0.1488957094441204, 0.20167692695844622, 0.2538727484610004, -0.21112604752566688, 0.0026199412134068245, 0.7839204125165349, -0.536672509539627, -0.045066639494227005, 0.2989618111541724, -0.49058080232900403, 0.7151031686607674, -0.4385919590492434, -0.3156108681934511, 0.29638367118198977, -0.00604322678518224, -0.1856602679254778, -0.060429936805347174, -0.29475614786173693, -0.30164760344637914, -0.29593684598264836, 0.24163555164914882, 0.4235710337601613, -0.31954714710920223, 0.01812553255277074, -0.6078769875777662, -0.6694164755616118, 0.2409860497220537, -0.16971756816534114, -0.3804504034701875, 0.15549986780777453, 0.18364489066118844, 0.15000245023027312, -0.07945849962776745, -0.5189194852194744, 0.30427815051020074, -0.22405395635941416, -0.05106896947539755, -0.19276363660591334, 0.4736978877705859, -0.004835277659645041, -0.018239899119691424},
    {0.09862594953559643, 0.5436841087850364, 0.6772977995842533, 0.3092178850466437, 0.1452406705632874, -0.3516968536009557, -0.33594609203179787, 0.3094937036220495, 0.8842946846820378, 0.7275221930601884, -0.23041622654611368, 0.21423468024914327, -0.10147437067819962, 0.14167579362488103, 0.13986341427470433, 0.2947097292599977, 0.7055641221557232, -0.07500198102802152, 0.03230440832921232, 0.534810575630812, -0.075686694298936, -0.15199089563975726, 0.07310221844905558, 0.1155357833437308, 0.0759226966656074, -0.39810617020401523, -0.03889573237961015, -0.8686209263839485, 0.23052115799136594, -0.13343354979306976, -0.12159060584647684, -0.09103443087347049, 0.02585444807761923, -0.12686139767156754, 0.19040701622846662, 0.4354261459661538, 0.07456504967151555, 0.0022720606248728976, 0.3136173852057893, 0.5519505118128795, -0.1652794716720137, 0.5545581957930739, 0.10162920911966618, 0.23613146900001297, 0.41852009288673564, -0.4356857401779005, -0.47038096098838295, 0.3080933694154148, 0.028279729082768115, 0.39696764729472, -0.20955836066853523, 0.41469672671872165, -0.12379874366416625, -0.2552272225758453, -0.5767964176279543, -0.08871045585962324, -0.4382008400244514, 0.17992806763479863, -0.06818090808469282, -0.07697807043135482, -0.09499980999275494, -0.10682388035938008, 0.032855454248666136, 0.1479746056843682},
    {0.37505478676184706, -0.14211236059786594, -0.46825294612434937, 0.23325156608907213, -0.5154410308465005, -0.5564836308582942, 0.24404483586003622, -0.47767280674571, 0.06141223436783427, 0.782087837150609, -0.5928561416518036, 0.2172308616940432, -0.510127003443362, 0.5520309505530585, -0.19240971455190287, 0.18754599348950887, 0.14319856021474284, -0.8305266992856664, -0.013160319464685221, 0.2547806424543164, 0.2540105875060536, -0.19518230205245138, 0.21677991581460704, -0.4532243703766431, -0.09518475376936206, -0.3453778282837314, 0.589540540335859, -0.23170053601222554, 0.07507005520380361, -0.3220050804997142, 0.0924020635827434, 0.3654011935179825, 0.481531713062194, -0.22426012614663104, -0.3486327929741372, 0.14693591180188229, 0.1400836612494826, 0.5531770144270857, 0.10366399881809218, 0.16854101310096317, 0.563950298434728, 0.17452421707523777, -0.21204776272016165, -0.6403816185327527, -0.32930771349060123, -0.09418959409699927, -0.18007049340575362, -0.490223116192968, -0.02760071621811026, 0.297087759563414, 0.034761982387817025, -0.5943404071347278, -0.5010448586745645, 0.07544157220036456, 0.21566341956019108, -0.1731537377121823, -0.32404123021001385, 0.4135660930693025, 0.24087876859505922, -0.6427486551922171, 0.013543898197199446, 0.2121323831893321, 0.6292256338214923, -0.7135389766004941},
    {0.09156183934052163, -0.5289993653913805, 0.19378167485546074, -0.1447106422921966, -0.4314977303083539, -0.23604834406113953, 0.41140832485793216, -0.06726546688375049, 0.19226611165246277, -0.14555346893687054, 0.030288295317658927, -0.09472059722502936, -0.2988420881170397, 0.2532156458579706, 0.3846555010694718, 0.1682605220665794, -0.24417323492634677, -0.18226305936530612, -0.6043392310166904, -0.016593676916993594, 0.11309431588267076, -0.6814951701119596, 0.47197833163971115, -0.2537803386925574, 0.22829182756399205, -0.21952157540677597, -0.45025232972348084, -0.839829965210118, 0.09506653463068541, -0.45605790593804574, -0.8283083576982703, -0.20154582470783933, 0.056860254082513224, 0.08090806567860724, -0.19139793284558418, -0.05038291334539028, -0.3086624565950311, 0.2758831249193643, -0.8229144113358845, 0.25126063109060465, -0.07697361827850228, 0.5029831304989456, -0.23601021099716857, -0.3780434928842492, -0.9031795429758237, -0.6837687456585066, 0.20473884249742375, 0.27428626964346225, -0.18319711948684947, -0.25006933173730367, -0.3466205874405828, 0.24952522168573, 0.3467357870319789, 0.07048832280694675, 0.5691672902706723, -0.3555221589219226, -0.3912483907238394, 0.7859933909233577, 0.15452767903390743, -0.5297396977920849, -0.2680409710944723, -0.28171868377901926, -0.006152144087157582, -0.24470224255903042},
    {0.002976386611857126, -0.19825022480362808, 0.047491825409587976, -0.41571408767445384, 0.12194028736587105, -0.20549831986113826, -0.5625605352079497, 0.005398686447767919, 0.5232192642894418, 0.38075106537677755, -0.14262580819737686, 0.13865916504474726, 0.014079115609207259, 0.4740448719402218, -0.6094981710096566, 0.4604584103861032, -0.016503214309976318, -0.06524579654676742, 0.11673381864073624, -0.43973302802438125, -0.2093713588760734, -0.24978419249513145, 0.09321609346150427, -0.6747332060537091, 0.35680100941871373, -0.3586168104109188, -0.36854840269772554, -0.3517962905504604, 0.4662471304907468, -0.01580533279487832, -0.3434008210240784, 0.2521947002517527, 0.04672974370007853, 0.08050739114443188, 0.08302156691768968, -0.16618144408347224, -0.1424827008943328, 0.4780970111890798, 0.3743499796577033, 0.6366724891034556, -0.5098124332838374, 0.2738476843035452, 0.1975899321826983, -0.12484869486020239, 0.2181666733161334, 0.5297126635775208, 0.5257677494898914, 0.5899320098194212, -0.37506780584069116, -0.022128780760907966, -0.7101534001619252, 0.2816422387338519, -0.15084220924734532, -0.4443445397472603, 0.22540859817964887, 0.4572239859187227, -0.10675521702909674, 0.12491339839200763, 0.016588997527122475, -0.5593159653699693, 0.08648087483262336, -0.41048707084621605, -0.19769175016908042, -0.02537278271894703},
    {-0.21272452561354901, 0.17730321765956783, 0.16467371769651518, 0.48938302634062847, 0.09995836263162883, 0.3246622083312956, -0.23400162746284603, 0.5895916178794882, 0.09277848506895847, 0.03729043211556725, -0.334636759022212, -0.16580968567767715, -0.2829845298945313, -0.24790267224089732, 0.39034759121660756, 0.34250262209381854, 0.467182564502853, 0.30299457758197745, -0.15952814829761178, 0.05576172674382232, 0.41790596021778675, -0.025832446138212593, -0.36479163699175254, -0.1766891527020974, 0.013402926492964325, 0.39011846995589344, -0.07583036889795235, -0.35981984200174044, 0.5819265487856328, -0.2716408213443057, -0.17311108462542524, -0.3485246749123102, -0.10267014071065861, -0.7614943781137351, 0.2627841233462634, -0.9048709311210583, 0.3424446174036443, 0.44368778332521125, 0.33922917878511843, -0.15119709842748053, -0.955945809075788, 0.4561436176932559, 0.43282710285866455, -0.4578044593846457, 0.25672116761044045, -0.3411801370803995, -0.15724140786266227, 0.6160411769205499, 0.20950195610035494, -0.48402165145251846, -0.1518303837527646, -0.0076176459324502795, 0.42640589543473995, 0.3567040703780577, 0.6555724436953176, 0.7132901488589147, 0.27754171184624404, 0.603878562345384, 0.5590761222846719, -0.1477399761034985, 0.016312982996175573, -0.0746847454389365, 0.2686087951411001, 0.12157240750863144}
};

static const float b1[64] = {1.242681029559142, 1.2107305599009772, 1.2384323168421594, 1.1676626810202548, 1.2856485850842259, 1.2717575500963254, 1.230015854477283, 1.272124899911349, 1.2270116106910036, 1.3091841548434815, 1.1145885740167665, 1.2985631088288372, 1.2592325596702814, 1.3553646730598383, 1.1932093103943877, 1.1690525589029284, 1.3206109425663315, 1.2948700109853235, 1.2208970024006032, 1.24176501162075, 1.09549174127503, 1.3358256638328725, 1.3562248511954251, 1.3146627880338735, 1.0949475922611727, 1.216924498309735, 1.2702657843857836, 1.1405448535784, 1.3005262825937192, 1.3642978649670703, 1.219831163960826, 1.384637689707689, 1.2829502616228285, 1.3092502144843783, 1.3358377357919746, 1.2972222419510524, 1.286676010793207, 1.3399899895146388, 1.2877960928565944, 1.0885485480198227, 1.3033926561515312, 1.2494115814320352, 1.2568949108664544, 1.351778532168632, 1.2978874033574348, 1.2997837648635777, 1.351778430237613, 1.3321277498305204, 1.3403504478905421, 1.2072253094419492, 1.2449699007017943, 1.363767328552469, 1.1875382194294188, 1.2775301324513206, 1.3533732098171654, 1.1429057776180376, 1.3938967679041094, 1.3603186132012763, 1.2893075259066555, 1.350030292766122, 1.3379845921982776, 1.3158567390022804, 1.2278706833512663, 1.3122547454951896};

static const float w2[64][32] = {
    {0.29019887825376295, 0.07983514203642508, 1.0541635103389908, 0.05641087424552682, -0.06138653808502898, 1.2856449597274602, 0.9502630463333671, 1.1345113166398937, 1.2875060060540855, 1.0585246364784267, 0.7893954708080821, 1.1725760334193716, 0.9660780020375738, 0.4919522707555111, 0.01992131587808061, 1.2637010176566763, 0.12240033047493379, 0.8120027921277546, 1.304282454213191, 1.155788161820367, 1.2499727966639638, 0.05678661313671091, 0.8947362301317435, 0.9985093511715696, 0.8463218602161215, 0.8085845132563352, 1.3098646069417943, 1.5554341171738975, 0.9165200063446466, -0.026407647305322995, 1.1917843339372978, 0.6089471540605018},
    {0.33656312708959124, 0.003255229627379317, 1.2105729460420505, -0.0397734066826843, -0.10222150532313806, 1.1159214728318805, 1.1336220489089912, 1.3004388449816413, 1.223492269761751, 1.0797380590495758, 0.8048673713715686, 1.1455179092599677, 0.4857580507610328, 1.0736146555858086, -0.1621814714934184, 1.2852693629520606, 0.08141630041705364, 1.1577227082200447, 1.0690041803499442, 0.8967598034199631, 1.1158201649542758, -0.1772714364526496, 0.9916625447889862, 1.16137651508788, 1.2535168755646882, 1.4448591351589013, 1.3537081992316888, 1.2778822571332689, 0.7366914083050401, 0.040460287826021034, 0.7947462188885317, 0.8430603142568729},
    {0.6739227015453628, -0.18637175413810994, 1.2556647159163001, 0.1066003090306689, 0.16933453999760692, 1.453872146635779, 0.99242852904203, 1.1507653995082574, 1.02958888465965, 1.1310437054842652, 0.9699733717844446, 1.1604753551000582, 0.9992436293275225, 0.9807350481041089, -0.2766964834553197, 1.2218355193092079, -0.18140913055986002, 0.9151529930929578, 1.1376364781409578, 1.036394000306864, 1.5927467511679303, -0.10933811361930611, 1.203013925313488, 0.8906083661802768, 1.0975478485473393, 0.8969387097488989, 1.221845614702699, 1.2915022546536141, 1.1276251330816867, -0.054767704681511944, 0.8827747419359944, 0.7189413545825207},
    {0.6049796076829523, 0.005819920945369378, 0.7332252987193837, -0.28925402433470965, -0.042667108080184445, 0.9529389522925411, 0.9023371938077424, 1.0378047297058073, 1.1422189895420798, 0.9498584283863114, 1.057956730540649, 1.3302297049380245, 0.9110903203045585, 1.078276164760916, -0.11373533772687304, 1.0002480843191823, -0.0019606064086000767, 1.3833140005681401, 1.3268738313786819, 1.5053088723488304, 1.3377714124146471, -0.07448074238720659, 1.0128302124470618, 1.139009520857548, 1.0395609038905562, 1.1189522360263797, 0.9011449470515622, 1.2406745513601853, 0.7605662530848755, 0.2599666272865839, 1.0243537055312524, 0.4866862864891708},
    {0.2712187661024224, -0.25185572193793426, 1.231687115062055, 0.18593370722697394, -0.3469481536598356, 1.100900364713872, 1.0755861990439126, 0.6359839042665215, 1.4650087121637991, 1.2367526097922052, 1.0308128167423403, 1.029674563337193, 0.8098092422702797, 0.9166559388928066, 0.006575304082042695, 1.374399055159131, -0.07216757373717977, 1.0718900339073876, 1.3864947767757168, 1.3714234547927135, 0.7235182800225027, 0.025684074085894713, 1.1042005894353697, 1.055726058767397, 1.1253187168107994, 1.0513226890998246, 1.288554510924889, 1.226133152196633, 1.0470558092313136, -0.08422140584691003, 0.9250433703272635, 0.3527629116384072},
    {0.4300244333665274, 0.12181825641115174, 1.1706747200355763, -0.16970234141614599, 0.05359704171768473, 1.4825793687636961, 0.6850400914717999, 1.0490604452279901, 0.9900410988831565, 1.3429874144126628, 1.3239089549787437, 1.0910796615247604, 0.7437466435907921, 1.3045322182650338, -0.1697235865735824, 1.1124141591247625, -0.17721987109267578, 1.0524977829510325, 1.4296447468801057, 1.2060259351572586, 1.1048809316583368, -0.15630820596403167, 0.9856438669768064, 1.0708289634511103, 1.1281701208168025, 1.171368032647598, 1.2674160066453688, 1.2694932806059755, 0.9657269669830064, -0.16120199665823845, 0.8538565689029989, 0.3534199963113399},
    {0.4885424312581192, -0.06652908462127272, 1.1188295782022744, -0.03554015440897209, -0.11778508498041838, 1.2846593239634103, 1.3718826787380738, 1.161260303649914, 1.0132319448506446, 1.3872346986114754, 0.7702901565499846, 0.8703015054177087, 1.003782314012201, 0.9506556998505339, -0.49358122371481467, 1.004087096844569, 0.18229038941943507, 1.2714255606657807, 1.1263992052310725, 1.549295441667886, 0.8559189195858019, -0.07619232172998852, 1.0170622599377823, 1.1629900253360468, 1.1241105280984056, 1.1543887478674066, 1.0053045623489034, 1.0598151627317793, 1.1861921933591804, 0.0681074287464145, 1.1937697990211225, 0.5181267002625526},
    {0.535991471966336, -0.1792738633996416, 1.0630534985943119, -0.010924461637545504, -0.07634180991052701, 1.2887529954076131, 1.2151110587072997, 0.9054989522780423, 1.1855945798226364, 1.1881621159608013, 0.8426768983592453, 1.420295025281785, 0.9427996285048101, 1.0743694248129187, 0.10847052187955673, 1.341876128984602, -0.0028396330343629325, 1.0493360325451873, 1.3443831601550038, 1.436089903012256, 1.2190624157297365, 0.003147321195955095, 1.1919477141585246, 0.7596316363564479, 1.0907213442723163, 1.0517200537434677, 1.3088262941289395, 1.354220158049535, 1.2501808753022845, -0.251157378124932, 1.1718828676960045, 0.7189349301686631},
    {0.5611619051365792, -0.02009086458601094, 0.9055164957303107, 0.023085535010808338, -0.12766143685596523, 1.1321309544830889, 1.2495949347855202, 1.2240226812910935, 1.1636629885508833, 1.380515454474868, 0.8526802294722993, 1.5174665545668067, 1.0612462891162637, 1.1023786854832975, -0.17195695334696925, 1.095366274722725, -0.07283535651738678, 1.0392150456356475, 1.0501933472447385, 1.273371562079704, 1.1103201605971442, -0.07850380839887593, 1.0842038617924075, 1.3224905472818258, 1.1847039318939796, 1.1432497688989443, 0.8365913209875626, 0.9981468681946857, 0.9523120650812676, -0.13285565829722137, 0.8965433433009219, 0.999631539948146},
    {0.2012624949071468, 0.013714525053008833, 1.0519395289257631, -0.21832136351321438, -0.10172438556591996, 1.6388312071131885, 0.8200506800830112, 1.045645467140764, 0.9226818446866336, 1.1309889928163932, 1.0458973737842305, 1.2704950361297571, 0.7116595381581521, 0.9802327422185362, 0.16457553774086947, 1.3797005129774076, -0.15552726621843055, 0.7600902103456084, 1.402884870802857, 1.4690429589164573, 1.1270539997227047, -0.22127918093995855, 1.188413297957936, 1.076801324174041, 1.116464207493369, 1.246967519431476, 1.3710663473411588, 1.0722424754723565, 0.882266702896787, -0.03324453269567526, 0.7938260095247718, 0.6588833646879376},
    {0.565317642115769, 0.22588599461192915, 0.9579912421126604, -0.013998512502124099, -0.28602051817861596, 0.9771180744358564, 1.130711155258635, 1.1444987193994134, 1.03845646264568, 0.8941578495411394, 0.9985853623629581, 1.030434937930293, 0.9923585285165815, 1.1730868808015167, -0.06884000441339068, 0.8937594571455045, -0.1730171112599747, 0.9390672191476022, 1.1052510373613005, 1.5386505973823958, 1.1597040957048745, -0.08853459546662981, 0.9391479933882168, 1.1183730187173575, 1.3164767154860295, 0.9308572199922232, 0.9794623970624554, 1.1982962674748088, 0.7496706503155779, -0.19006842007499453, 0.9004805338012799, 0.4720917398446854},
    {0.27408775067170627, -0.19455623785012327, 1.1203698462471616, -0.13264614463289714, 0.11967863650474174, 1.1642478685056308, 0.9891148363602257, 1.2588801415529611, 0.9800911037499824, 1.2515740807648825, 0.7912078850295498, 1.1162153076235608, 1.1398138813825949, 0.7339893339421074, -0.21955134741000565, 1.1235858701392634, -0.20556481496750853, 1.052678128469272, 1.2680367918096231, 1.179187900026024, 1.0212688745404492, -0.25164574993367156, 0.6816350217217553, 1.1310557976426836, 1.1738761022111817, 1.0356728809941942, 0.8576489410165729, 1.2739054316081, 0.8788993422413833, 0.0269350931720576, 0.8560508714033178, 0.38844342607372206},
    {0.6599855506638088, 0.08030763867117788, 1.149247566646743, -0.40186202741384736, 0.21704819212561477, 0.7974081256239751, 1.1380126591291664, 1.1002991862016962, 0.7994816410902078, 1.1468109490360756, 1.0658177291785789, 1.7321053477446366, 0.9141853174961535, 1.0879790584173037, 0.05266740172427634, 1.5545736006858448, -0.09662378138628275, 1.0872588072846425, 1.0950223559527812, 1.2328999660308662, 1.2202495576642036, 0.31154292309079373, 0.8591982681824184, 1.4929340971540408, 1.3449289413919079, 1.1145727827053575, 1.2940659704032975, 1.2494949687771708, 0.9510519624696601, -0.05787943007194589, 1.3423467417419894, 0.5636903210545543},
    {0.280864004842116, -0.06413148492493458, 0.8598437286441425, -0.29397760260080524, 0.20254106530915117, 1.2453573247072307, 0.9269386333373989, 1.2853317009401406, 1.042974523013297, 1.299427444815864, 0.858602562358922, 1.2935865163986935, 1.0906776707674188, 0.8805823161843307, -0.2321682235366841, 1.1211392897093244, 0.005610420575334785, 1.0739025026146745, 0.8561718353049824, 1.123777389195818, 0.8323054404688944, 0.18297267483763463, 1.0283327081847236, 1.0383659431519827, 1.2772188845679946, 1.01150767408331, 1.5836186321088266, 1.2859790891242973, 1.0324529871076966, 0.1599986672634017, 0.8577170805288946, 0.6370734445118093},
    {0.41499058552534346, -0.07569950199739456, 1.434447451108286, -0.07074478826350997, -0.00130226190951021, 1.0528306724784315, 1.044808970909436, 1.0782619970849008, 1.0533168872271046, 0.969714003661999, 0.6481756337351908, 1.1926666297418682, 0.7794368433253434, 1.4329560102515377, -0.10146450104494946, 1.2763682431788286, 0.2046232685565708, 1.1151208552375615, 1.3692038743728168, 1.0713415938115949, 1.0616116679146637, 0.0990428707810097, 0.939401221345412, 1.4786151433409105, 1.2501258016408379, 1.0772436997421113, 1.0759747919008393, 1.3997000131744053, 1.10263365910825, 0.0203403818436783, 0.8865156161884885, 0.41345076117141194},
    {0.33084891476907186, 0.1543450393356753, 1.092112229579912, -0.31037476412861914, -0.05424469291486187, 1.071223434788326, 1.1008048573733653, 1.0226684401799357, 1.1950013141919456, 1.079584083921547, 0.877636566744551, 1.1292468176627282, 1.0587433974774552, 0.9608311044766453, -0.1797352063843167, 1.0622120645360071, 0.04218731765723512, 1.123987376686935, 1.2264261574092545, 1.4183292979782174, 1.2417082037873886, -0.027846198866707732, 0.948239807068589, 1.04126279126713, 0.9474322194506931, 1.4171028877752019, 1.0831406029918562, 1.4869610537616051, 0.9960498688170683, -0.1927943920200727, 1.165322244580605, 0.5864828352065584},
    {0.4816601991161482, -0.1557728223996862, 0.8522443027559999, -0.08583830473869168, -0.22510820086330985, 1.1166694834731123, 1.1515196387022018, 0.8530115268864455, 0.9957949317824367, 1.4600607989806096, 0.9587852706585382, 1.1115517953349296, 1.108696271050306, 0.8884850171795784, -0.12129310549770682, 1.0752870049109335, 0.17153636410263434, 1.1697996502200751, 0.9432159827170506, 0.9474743239466942, 1.3242705378082587, -0.38719578405817673, 0.8991412289931701, 1.2419281346977837, 1.4343112049236064, 1.0382155386750331, 0.8928803624556252, 1.3092701686853645, 0.6712432560420195, 0.02063308949829753, 0.8637546957619483, 0.4875607719395281},
    {0.20493405172874235, -0.20195862532447473, 1.034905836786374, -0.13562436806337227, 0.006843472719513789, 1.6272000679640874, 1.1068454974234956, 0.9802250371664522, 1.0648164521442405, 1.1646149417814653, 0.8867491111045299, 1.3975620661868395, 1.1189132422659382, 0.854231736535218, -0.17790390064792358, 1.2382439847747937, -0.1116861687116271, 1.0902570411989445, 1.5452203940042961, 0.8013982735229996, 1.2329189349781964, -0.14252529611745007, 0.9857145150031739, 1.3270903981896174, 1.1927256608338739, 1.2127116428634672, 1.376688292882045, 1.1123695309086719, 0.685647041935124, -0.14396403007124056, 0.8973970687078475, 0.6690508897642449},
    {0.5702865729831623, 0.054390571011630334, 1.0129570650058313, 0.1523138314147462, -0.12432345975384938, 0.8418139106751248, 0.9588062793967917, 0.8252253008616147, 1.1017736687386073, 1.0814907105899818, 0.6675997745657768, 1.131814594921791, 0.9776766696097884, 0.8582096984882068, -0.2449931763974475, 1.1882788764711174, -0.32104606924504353, 1.2594412774273194, 1.138477729217769, 1.02088745346349, 1.1433342532239767, 0.2093933641573907, 1.1513617808729846, 0.8267102956887179, 1.3937134989353384, 1.285439651172864, 1.3212707932248011, 1.629204238633853, 0.6585757008922237, 0.07897001561899912, 0.8110445807987792, 0.7024132804499394},
    {0.5796230699884686, -0.06376960780351215, 0.8518021254469093, 0.08291684479132534, -0.306002872903631, 1.0483300073379633, 0.9678985568006544, 0.9355199801085298, 0.9759807448642014, 1.2757524142625427, 0.9732441293494942, 1.0169864352936095, 0.8171714537185607, 1.1226714293670763, -0.21858074883276118, 1.0609084303022178, -0.15477860156727188, 1.0758909676828823, 1.1315330709729448, 1.3132356621979218, 1.0669147990705283, -0.027090405728681835, 0.8917616016557892, 1.0236961019849755, 0.9750031383909231, 1.2699830257730107, 1.2679094350933362, 1.275765459970281, 0.9617896282898168, -0.16515721821697266, 0.814167757109282, 0.2669739734636779},
    {0.8498374932039722, 0.06485306356267855, 0.7887598112133566, 0.09535491118503948, -0.11200109618646725, 1.0147817741594354, 0.6748200963566539, 1.0029687555532156, 0.9511501815599583, 1.1907776303236632, 1.147198560303761, 1.227116942940328, 1.0178212296876668, 1.0708328327482828, -0.14374237913713012, 0.7731279300697746, -0.1286700107909759, 1.1154616052101445, 1.0611552513680893, 1.0206735215751632, 1.2791858961286686, 0.27170988982039995, 1.0554891163819555, 1.2541152977048013, 1.177958783628468, 1.114179690979947, 1.0863166386138805, 1.1745563449697076, 1.1972651250277346, 0.10458203264105664, 0.7696809857601962, 0.3158791356703969},
    {0.27914788882920033, -0.049671092967681595, 1.268976456282059, -0.07385892883774507, -0.22987870757047438, 1.3532566818984129, 1.240961781372325, 1.1298403778756525, 1.0590258976079079, 1.1678619905081602, 0.9046235635568479, 1.222064576252209, 1.0372573914177186, 1.1887264172130962, -0.18207844925410577, 1.296919582480194, -0.14739004241575715, 0.9970722515855062, 1.1992590150895721, 1.1351815328170254, 0.9997068547601444, -0.4318952414675343, 0.9475473807648841, 0.8281947016907318, 1.329448874003875, 0.9810375435694136, 1.4510999721072146, 1.1833927517310259, 1.0086848681839196, -0.0001461505216264601, 0.8493832709381481, 0.489615697528802},
    {0.38603251721949855, -0.32561646146282364, 0.8672705258982898, -0.0599438337538355, 0.012714705341540875, 1.0429251532208317, 1.0600693922125248, 0.9896159748429586, 0.7885479989437554, 1.1445011084866832, 0.9296581650984086, 1.3063630371220134, 0.9170143632775039, 0.4428985083381566, -0.09347690948056901, 1.3364504295100008, -0.10639097930578305, 1.0430956805534068, 0.9876476628109008, 0.9041695789036286, 1.498069902160164, -0.1374865471351483, 0.7886312766276469, 1.2469811709611855, 1.3132897516037836, 1.0991900781429804, 1.4901214635175906, 1.0496050916817923, 1.2237824762890246, -0.0019456320489362683, 1.0847815573947979, 0.4149320388319306},
    {0.5145931115787801, -0.05063259822250883, 0.9392413647036116, 0.10078812935625954, 0.023092097632846083, 0.8557351892194367, 0.9212036141890196, 1.4729500525785049, 0.6575561006193187, 1.2243923678697328, 0.9468452434342945, 1.2535257217851294, 0.8231662578551675, 0.66385833930242, -0.23151289621459034, 1.1968442994213835, 0.18793464516349204, 1.126691780232443, 1.5947518474054765, 1.221212817598961, 1.1382151317996108, -0.06984299524512254, 1.2201867043890182, 0.9626137454782284, 1.3623051053117623, 1.0476287432006737, 1.2747245408859142, 1.136033319962934, 0.8839192232542608, -0.11440097315018555, 1.144426240906895, 0.3947184405899656},
    {0.6252012743685366, -0.08520174917648789, 0.857269964481473, 0.014421878698528508, -0.13320137683287717, 1.1292101934545782, 1.1395684153409613, 0.9603292710938993, 0.8262104644912113, 0.9402986562379232, 1.5293210533368937, 1.2301391049075745, 1.2187680553215265, 1.0557857033154299, -0.11672768247275908, 1.1249352186209989, -0.07106191528866457, 1.2134968641668946, 1.1664861101247515, 1.0046818878420287, 0.8637649876325098, -0.03470342693422097, 0.9410463433453503, 1.0588263610745026, 1.251595580287642, 1.2309885897041497, 1.0169140779635624, 1.2828400208242925, 0.9600546253355734, -0.3154057055233546, 1.0221608992715072, 0.7453584229505651},
    {0.2238946620515878, -0.20651599126723238, 1.1360112875618633, -0.20016169851844848, -0.09415044971486346, 1.3417170179634692, 1.2475928963772378, 0.9976191314862319, 0.9483752275801892, 0.9293606718349232, 0.8448142730852367, 1.3165331268034561, 0.971326513841001, 1.05831145593276, -0.06459696113544768, 1.253523771107223, -0.19009407273332296, 1.3938428028651537, 1.1150375347673191, 1.1907648192814604, 0.9274086646446199, -0.1610281474755097, 1.005636021431454, 1.2623461729428687, 1.216502670086706, 1.096840764400927, 1.1046653385610612, 0.9965156961728595, 1.10475769228586, 0.23766797252971086, 0.9712293447003116, 0.8396803139579363},
    {0.4640916846702628, -0.09820724800749808, 1.0358683581943582, 0.2512377721059578, -0.06731990963241176, 0.8971036499642633, 1.4719144703147045, 1.1835630194958595, 1.2045015535930412, 1.1817098815078606, 0.8041088868362182, 1.3214385461770406, 0.7990480757139052, 0.9828040864925738, -0.21682402452917865, 1.2539929729031685, 0.04147815905663437, 0.9191442502348861, 0.855408377126316, 1.3039806403751015, 1.2286823071686035, 0.2888540256410066, 1.1495983091727962, 1.4022908127303917, 1.2980367667724573, 1.0761972822315153, 1.1543187105319146, 1.345962559822759, 1.0968206156778884, -0.28217673054021614, 1.010890836161936, 0.479243514054424},
    {0.29418854526136834, -0.17737480505084077, 1.075663358638615, -0.297786654946271, -0.08450109187543203, 0.9538589013072186, 1.0435403413860005, 1.3687221434776746, 0.9089514881796826, 0.9901344056213136, 1.0334660472997004, 1.1791803846155244, 0.9094513017384245, 1.1914461249762691, -0.03550281078952898, 1.2389800583831065, -0.0344224509169978, 1.1053526264263454, 1.1004008925220987, 0.9543404939862008, 0.9768122252528041, 0.044503913447953417, 1.041417925874631, 1.1642510812757099, 1.232226392703207, 1.142821166088177, 0.8984950929198648, 1.1107480841268262, 1.0096270166782224, -0.017865569287982153, 0.8311250545787376, 0.4210385417447528},
    {0.3708269725136829, 0.032499166380145085, 1.1045677709036028, -0.18026109796625192, -0.2714055589611957, 0.8390796442502982, 1.0852001571831915, 1.2237526695043248, 1.1393423362319692, 1.337474946068014, 0.4919175461999981, 1.0193721101812547, 0.6607718898287362, 0.6894189847216613, -0.034877432291496195, 1.3414881298498826, -0.17132283481698227, 1.1605615479773617, 1.1452123961367717, 0.9777643354784248, 0.9320665153694406, -0.3179189161324982, 0.97679979236978, 1.2138404861130418, 1.196717315345956, 1.166459229323253, 1.2180964565610553, 1.058976597468754, 0.8692408726527409, -0.29288700962879793, 1.0225724086235448, 0.4963913950273533},
    {0.1662163251528981, -0.1889637436744564, 1.1239275409574552, -0.15499044584879365, 0.03086042097966205, 1.1450822894841466, 0.6591243867506973, 1.0044349713767466, 1.1292911639518242, 1.245798234477431, 0.987994435380134, 1.3170880571546297, 0.9341758606597431, 1.2184129836663014, -0.3203818376442045, 1.224010742658905, -0.15325460898135004, 0.9325836483385727, 0.9698179763082978, 1.239095843085624, 0.9092037650030892, -0.24540147366653187, 0.7681876662419171, 1.1410698561498112, 1.6510108704256523, 1.2183660317363867, 1.7021582193281692, 1.1755356626426394, 0.8385943147114234, -0.3059372680484729, 0.834596555441551, 0.719148130805513},
    {0.3151996272813514, -0.12975930111653394, 1.1912368571224106, -0.3710008450165733, -0.07176960479738374, 0.8386030415072719, 1.1657308526264576, 0.7516507955697692, 0.7808277926437996, 0.8187827437721525, 1.1266768669483451, 0.9426471959580252, 0.8853512243791354, 0.8786930536182469, 0.3229014724696819, 1.4940006369431227, -0.252991003130581, 1.1073021569559482, 1.0991137794942252, 1.2548682418539912, 1.3965068398277687, 0.11406336832332174, 1.03661001553757, 1.214878730299485, 1.2172638296563334, 1.0210433683425888, 0.9643233188676461, 1.6798069351446807, 0.7822567295159609, 0.003890161709895972, 0.6927544736799575, 0.8270585720558216},
    {0.5582926760707771, -0.02863447765616541, 0.6568384359053578, 0.18984375322370248, 0.1621064687328243, 1.104328928489601, 1.1308837115069852, 0.9848331615009902, 0.9146027540090469, 1.3325744475600354, 0.7586434597092819, 1.2495815336756293, 0.7074441432254198, 0.7973959163573296, -0.1206392727621748, 1.0568559812546745, 0.08137083299152283, 1.1477071811527508, 1.277551054902588, 1.3737876926351573, 1.1957119738994608, -0.18174748565352408, 0.9918059327364335, 0.9532718016338393, 1.5521625130876342, 0.9029612623896001, 1.3234385197208731, 1.157637746135932, 0.7996513949131578, 0.06625594297715702, 0.937499123728842, 0.7937523076249043},
    {0.3977150068870992, -0.07480622175133383, 0.7012269642899939, 0.04915809010655269, -0.5588832197056646, 1.4146344890704483, 1.2802098770555121, 0.8514831604786973, 0.9685752495930615, 1.0236112139765057, 0.8197650204889976, 1.39003017717703, 1.033188169002009, 1.0379838713900909, 0.13073573230503432, 1.2757603596460443, -0.033789439569419086, 1.3535454985584803, 1.4540582319639015, 1.107623380691865, 1.3102321054007646, 0.0826478948955983, 1.0785267459955787, 0.948988588544175, 1.4000632899695713, 1.1736828861100457, 1.2824629675297998, 0.8777405851913517, 0.9598637892100937, -0.017347219736395088, 1.0396434832008625, 0.720791259499588},
    {0.5161084272769163, -0.40327065351509833, 0.9877432342910785, -0.014272260115894409, -0.10479055380228156, 1.0780934463010854, 1.2622035588287797, 0.994006357739711, 0.8863352637939309, 1.4052716658011506, 0.8072585527353551, 1.38298522685356, 1.1030868753808787, 1.109933319742733, -0.10688083560677002, 0.9750563032694971, -0.09789606376437864, 1.1520572829521099, 1.2562283127438354, 1.1347385313345502, 0.9860765293019627, -0.018113335308385287, 1.1477439884569969, 0.9685834298788885, 1.5455927931705675, 1.0445795051720361, 1.3769262478878557, 0.8926530790791545, 0.9466240694674719, -0.011665452292178304, 0.737732637408468, 0.5306422515525377},
    {0.0675461262850558, -0.1900579531610312, 1.2376777726122608, 0.16570131752803924, 0.2376855675590266, 1.1018786570834196, 1.1106316912532006, 1.095674374974819, 0.9163614075324644, 1.3171925705251508, 0.7417168756384313, 1.2784633646114547, 0.8668045021779944, 0.8078762128119259, -0.06143416109228218, 1.6085069579084286, -0.07164683578551198, 1.174675048700572, 1.2312555023947074, 1.557720842660392, 1.398345688979207, -0.2727796224394078, 0.8969097760068612, 0.9888795615463183, 0.9153905043953984, 1.1273449853789799, 1.5225873970116102, 1.4674764802241405, 0.8860136611941096, 0.1465871576076271, 0.6396030215982105, 0.26904394079430893},
    {0.4032193411454546, -0.27923404419339465, 1.1865557096705481, 0.0437030481989525, 0.2130597211455636, 1.1033895801615607, 0.8908859221659472, 0.943960835839462, 1.3299091694579457, 1.291523495945603, 0.9524804621742536, 1.621115526029423, 1.0325009730074397, 1.1243650186277536, 0.14163686706714795, 1.1227521850265958, -0.312905390058848, 1.099924811478979, 1.2916022442260624, 1.2939519361874134, 1.0593217565112678, -0.06968391867361526, 0.9252108160369107, 1.059271964402279, 1.600867767534397, 0.7524936411604252, 1.0402442791719928, 1.4210137208947438, 1.0859742361627893, -0.2043029376151584, 1.1748309075760694, 0.44408729781312506},
    {0.34634432028424855, 0.18135949121823153, 0.9725551655145489, -0.12390899136012967, 0.06806852839060024, 1.1352348115584532, 0.9016240166583381, 1.4732171670374148, 1.295355111031615, 1.3576962446479477, 0.7754253653259573, 1.4444175906109247, 0.8945221235034345, 1.2527805909627456, 0.06847691876736242, 1.0620369117747475, 0.17116240316131487, 0.8976070882946756, 1.3857916484021533, 1.2735033859627576, 1.364191545642683, -0.3364323021192643, 1.1407030211718923, 0.9861313664198297, 1.2279523943362107, 1.2811577216600176, 1.1638646921115898, 1.1215037724193058, 1.1958642651829956, -0.1119784265138662, 0.6064605073029649, 0.890298944375567},
    {0.3639971023935249, -0.062156811184738696, 1.2332063052275406, 0.1713640641370429, -0.10257608598936342, 0.7924632993965823, 0.8157028502589558, 1.2452586305232412, 1.0931079548629181, 1.3612305081672527, 0.9218495312638111, 1.4644470289782592, 0.8517958375201891, 1.2203909153778676, -0.08566201883473219, 1.1651839776726785, 0.024241462966542403, 1.226812801212556, 1.3527738917667713, 1.2619729902534562, 1.170029247594511, -0.09484766588502261, 1.2894493010650485, 1.1066360934058348, 1.2692567364113576, 0.7503609317550891, 0.9735727821631535, 1.0160053503982402, 0.9948725988323499, -0.2626398384118367, 0.4618559239569455, 0.5254802322737153},
    {0.3965240003706798, -0.05192217274492825, 0.9129846276757618, -0.1651091337628252, -0.29609475941187124, 1.2135352562217228, 0.9106981271086777, 1.1820249742924671, 1.2424031391092218, 0.9954378754704317, 1.1048340783472315, 1.504854493047165, 0.9001289188203025, 1.0849821334961345, -0.07073218727800937, 1.5147228140008777, 0.2801842625596293, 1.0888112691273417, 1.297710847542004, 1.2467858618448702, 1.2203854186921377, -0.19513668538570256, 1.0161681082106684, 1.0895405158489724, 1.2595417625846146, 0.8416830627576821, 1.331056874217739, 1.123083878139301, 0.5650764412641898, -0.1702743831769679, 0.9468397492744834, 0.4788862602170292},
    {0.371839162848641, -0.13561297896120003, 1.0371857829892377, -0.305950531149514, -0.2011983961120621, 1.4622628362390444, 1.5240152282636243, 1.0869264490841888, 0.8363401403929234, 0.8413450201198625, 0.880002306011206, 1.2081178533210575, 0.8701806112267196, 1.0797073679789677, -0.13943845083064124, 1.1054371711431779, 0.12412944410968137, 1.2780695377847564, 0.9877989403997713, 1.0546009813700186, 1.002420255865508, 0.3256611176435113, 1.0443339320753993, 1.2334609322309251, 1.3499078982476862, 1.205893082304308, 1.2188475561972332, 0.9531971594764133, 0.9851056256302584, -0.2676855376657827, 1.167057630363555, 0.5847551693883117},
    {0.1450099110193759, -0.20350396047453634, 1.2128165832436522, -0.055905684763731756, -0.27133951983046517, 1.3189192116521906, 0.6778742378973626, 1.1449544185454328, 0.8715170023497216, 1.2700465066460223, 0.8955734703885856, 1.3636303969367463, 1.0371802306303748, 0.8145453801936052, 0.002218851278372836, 1.2502291301062354, 0.10616079403397823, 0.7876904333129346, 1.2356719781278345, 1.1723914034426324, 1.225306478844699, -0.25924206530078914, 0.8297403345044536, 1.2623521005916596, 0.9256845749622413, 1.1913909628831043, 1.2080892417157105, 1.1157241543174756, 0.7341552477473651, -0.263789779359578, 0.8371832269045808, 0.41142330539068817},
    {0.2477825420116193, -0.13386092500458327, 1.3061444601113412, -0.003224646992008111, 0.1157531392254523, 1.2222937432478935, 1.2210142347082404, 0.6474113580491728, 0.9505536949092289, 1.5108820774173428, 1.2261580606677562, 1.2107695945958785, 0.8726947020558444, 1.0362273990230264, 0.19099262957035917, 1.04072347576991, -0.08135725277975137, 1.281700034243311, 1.115898033364007, 1.0449321523897053, 1.332639469367837, -0.19915911285988744, 1.1597481726301901, 0.9016748916863513, 1.4274717381316469, 1.0143742152870114, 0.9589679519540494, 1.0704704915111556, 0.6624922174356107, 0.17112669532683927, 0.7428057129804638, 0.591076638316531},
    {0.45987511636264217, -0.053996193947775925, 1.0088695712561198, 0.2692413138836834, -0.26763898895821253, 0.9103186865871408, 1.0915507460925629, 0.9358138712421424, 1.0733126562636153, 1.131833597838521, 0.9990058736954309, 1.0933684989446044, 1.2870169343206406, 0.9851607245632851, -0.07854420751385717, 1.1597126307886634, 0.21772797934603702, 0.9985900904133619, 1.1082503643210524, 1.2398174313544303, 1.163984763395994, -0.1172963567774553, 0.6935075380983547, 1.0109193246699937, 1.2102599503792175, 1.4120218279740204, 1.4978037201670533, 1.198932260955395, 0.6728738213691023, 0.1545594383596839, 0.7896557892902349, 0.6637760771606213},
    {0.5852651309770481, -0.10584829162880997, 1.1735582868509582, -0.40590716866769394, -0.11922236818411157, 1.2389326570071038, 0.5630756107587942, 1.016373888323735, 0.872261821102836, 1.3414336415463568, 0.763688001581616, 1.3047671700078198, 0.5892302505091135, 0.82992640224664, -0.38246363423771274, 1.464512278128532, -0.19913353721232832, 0.6753610304805735, 1.2098710770539363, 1.138030718715886, 1.3748126953282243, -0.01640850560354919, 1.2304857685659363, 1.0417499685133935, 1.3749083851918806, 0.9992567042090552, 1.000969159254451, 1.390070735773133, 0.8188327205864729, -0.17582224488463188, 0.878127799104609, 0.4869665505532338},
    {0.44589481238599116, 0.00694956538309939, 1.2490163440438475, -0.29335127947181416, -0.15720264719702848, 1.3063961504333979, 0.7966081210453773, 1.3171279697736458, 0.851268429463181, 1.1269312412543695, 0.8791792710108737, 1.4633936919355275, 1.2818813615764895, 1.0872448170328772, 0.1314505958404567, 1.1439859172011448, 0.07338807113608595, 0.9827717438697454, 1.2464899738277069, 1.290080394650849, 1.329856459541989, -0.0754079746659063, 1.0533771395621556, 1.023734624846785, 1.3061881501516277, 1.0032634853443911, 1.2976393269038833, 0.9055514295555477, 1.0415801850017432, -0.17083766693693464, 1.0164143466227813, 0.3565640068290497},
    {0.6633986976063949, -0.12675741009818245, 1.1904045380706167, -0.07992144373602356, -0.0710296638058712, 1.0930094715865013, 1.0374011590437584, 0.9580434119409321, 1.322832328183362, 1.1319750356525866, 0.8054133949968274, 1.222611807844048, 0.7797441633240986, 0.843156139089445, -0.6363037119505173, 1.3105720482815173, -0.005347748031079885, 1.0072420248832867, 1.1523160471403635, 1.3945189417398478, 1.3660764025765706, 0.1968830422076989, 0.6674880260448096, 1.4126505218960637, 1.4745061243556588, 1.2784989156590059, 1.0953695022137062, 1.3524379003909275, 0.9539014664832351, -0.19666859549504337, 0.972119247094177, 0.7001789078478037},
    {0.47215464615465585, 0.18529415467420848, 0.982953162131346, -0.05179298019783724, -0.05954241934227238, 1.196183691160385, 1.1765771297047436, 1.0276695948365928, 1.1061004253094808, 1.3508690530380654, 1.285770603967079, 1.3206719677372634, 0.836104435595117, 0.7360265797571061, -0.05033001114517794, 1.5086239605868113, -0.04047151667662373, 0.9573292988936841, 1.2415503434426947, 1.1560062987849173, 0.9185797116476938, -0.21173562850788968, 1.0283010731506883, 1.297936531091966, 1.267040803169828, 1.0824858129971744, 1.0598336963702106, 1.2267881491242902, 0.956318188666391, 0.26157184241839393, 0.9844118095589363, 0.059719165581099076},
    {0.3314549805448204, 0.17102775786536623, 1.313100079594206, -0.22225315396493292, -0.10551357493262425, 0.9655349929586693, 1.1790507659241491, 1.0821680142638184, 1.0085165231056508, 1.042152498343086, 0.9716994065043836, 1.3529785431340056, 0.5307184254451606, 1.0232640115559712, -0.012929220739942748, 1.4355782907143113, -0.17525006678375002, 1.0387505699851478, 0.9614551005657261, 1.3392647420452646, 0.6989819199166357, 0.20989123344013655, 1.3660625078669282, 1.111038206895088, 1.3077199386144573, 1.1268805883851065, 1.3561934591931368, 1.0125211710465112, 1.0571039452830393, 0.09527054716711873, 0.5163329919003729, 0.23758378767371538},
    {0.4476079333586956, -0.017602985893106306, 1.1103432184156248, -0.02087748271388967, -0.1371321260473543, 1.1460519828018088, 0.6715734955944644, 1.046718565724975, 0.9957168299724922, 1.187986991842321, 0.6696008586541233, 1.2598643895716028, 0.7604427722658753, 1.1209350581436055, 0.025777844051420352, 1.3389487638240158, -0.20848941261465834, 1.0964736736302945, 1.0184247245766596, 1.1338005467302887, 1.3048559700604774, -0.10056339304419021, 0.9418753081088546, 1.3295641563455893, 1.3064374817351672, 1.190434776535329, 1.4481095941996642, 1.2116873172703906, 1.2711406504460177, -0.04025670085610101, 0.8805132395297448, 0.47584459244029415},
    {0.24590666096634076, 0.11486204238600842, 1.273894376546915, -0.09887112937596441, 0.01464009270410393, 1.3082473755606483, 1.0414483191041963, 1.2552868226149438, 0.9584567760876124, 1.035766539051257, 0.9428383937269511, 1.4337463759633147, 0.9271277507714885, 0.8595744381126248, -0.044268453821390885, 1.186369793866689, -0.33266963836312513, 1.361108802111977, 1.180494800963151, 1.268041332013731, 1.153636312266196, 0.24610376286547017, 0.6709832167223446, 1.2208198994589095, 1.1179397649200413, 1.4112827639789702, 0.9964685368040925, 1.4503391430614947, 1.153314991616128, 0.15499694517314877, 1.1128698291044974, 0.3502246223111976},
    {0.440023336478162, 0.10948090677965272, 0.8628342350818223, -0.1298571225307671, -0.17314606808052693, 1.3102292535855875, 0.8577586874534154, 1.2855020564550197, 0.8035366781422324, 1.0905596581604728, 0.7116389173001058, 1.1773683042125533, 0.8489986426021942, 1.0246270056164546, -0.304226993935536, 1.3261228402760352, -0.03266180341542634, 0.7379281570111843, 1.4605527072333289, 1.2660993184213394, 1.2605858821315663, 0.006017008328286843, 1.16535800078568, 1.1025370118101563, 0.803342693517775, 0.9788622097302013, 1.0561017289943817, 1.130566551241648, 1.057603421774523, -0.4575189464133116, 0.7545940203226499, 0.44491398433735246},
    {0.4312504520275034, 0.1282942197865654, 1.1671559164773542, -0.37275205125776656, -0.023339049415823983, 1.207601019323701, 0.7831028772082678, 1.1776357029904732, 0.7941826432343986, 1.0117935871768122, 0.7997462221104937, 1.4301048024975374, 0.8052438976603461, 1.00117182601962, 0.19069950694714394, 1.4434882237926847, -0.2118894476229771, 1.3519758939158728, 1.157468539890356, 1.0544146836121804, 1.0918523668403777, -0.21519041984653536, 1.0312956239315307, 1.2862044249117723, 1.1015917521735528, 1.1037886632139953, 1.3134749056623742, 1.1944742861743083, 0.8452048276885096, -0.07877006055176083, 0.8513343500399042, 0.4549365254824012},
    {0.5593235581917817, 0.1061774981866856, 1.0734932973305968, -0.017860550985185655, 0.1765462049030145, 1.0299061944567431, 0.8037890738988348, 1.104834975609433, 1.1996891302796735, 1.036778507928114, 0.9201438019852686, 1.2713929764494176, 0.7589577489625716, 0.8471813691473881, 0.10868280601458509, 1.0825557270804724, -0.03608079116896318, 1.3200315631048243, 1.1743897354289394, 1.3541289502178233, 1.4496502644661848, -0.14928655012940056, 1.1591108296188188, 0.9724258129143059, 1.0705856038984183, 0.9841158773321194, 1.2727702829739251, 0.9196217833039037, 0.9807049501923625, 0.0607711365014345, 0.9296421523213656, 0.26285222898859445},
    {0.37927578924865807, 0.06727788160882746, 1.158812077179652, -0.13351184854131573, 0.08344193979942341, 1.0105385990754483, 1.0874756503587293, 0.7597579167466605, 0.9146885152791797, 1.232811700746797, 0.9970527487506822, 1.1668322084483778, 1.1815800397234781, 0.8879222266658461, -0.21348996041086146, 1.189484349633015, -0.04247711566000543, 0.9262455197853706, 1.081715938464491, 1.5705156078356624, 1.2426572578733748, 0.11228508184659997, 0.8929378979790322, 1.0965150717312744, 1.1588995218250855, 1.0472437068065226, 1.2600787249306722, 1.076420076245257, 0.9649947684914414, -0.3350979013242476, 0.845437950757444, 0.525882574281469},
    {0.427672494481231, -0.2229993196972341, 1.1827549372189823, -0.18320522830920108, 0.31518853160966637, 1.0389727249341556, 1.037491720065966, 1.2305000605259668, 1.0683413719291723, 1.240002311432893, 1.0238025480690212, 1.367439881812775, 0.9898252603398948, 0.8619365442646935, 0.2521027505196345, 1.3828412609322926, -0.07687417756985504, 1.0881522448888943, 1.3168342837285394, 1.3012505518505937, 1.2849192169609465, -0.26412244239956695, 0.8849989454044777, 1.241945914174604, 1.3481025483785363, 0.9732530206155374, 1.7074721043873562, 0.7899496494372957, 1.0342049531252229, -0.3696729572310202, 0.9879776061517365, 0.6208749250401958},
    {0.2418423039648477, -0.06129394659553224, 0.8344266698095232, -0.022116515435898775, -0.11760185389056808, 1.0205066392241335, 1.0763895509308257, 1.3028572382172061, 0.9135539910967208, 1.0244523362765732, 0.6836177608954636, 1.2183776319662925, 0.7483677460095306, 1.2675638435259655, 0.0342533503764215, 1.4837379331776215, -0.243948706622317, 1.0233355432395008, 0.9317878118895792, 1.0235832618084248, 0.8417397817646082, 0.12523155493151533, 0.7856548312157422, 1.1792586084958347, 0.9399277123366618, 1.2447928968902273, 1.3395097155747944, 0.848098519809586, 0.7614961786608665, -0.09695345108512396, 0.7277604248515593, 0.7513073777186988},
    {0.5103729192825014, -0.18402174434772733, 0.8422924121201684, -0.16169821637615284, -0.14849686395808748, 1.1176625899717367, 1.0450749511233748, 1.2120026103494532, 0.9734212500290342, 1.3817152039507636, 0.6774701288570727, 1.4896174566219673, 0.6875981891883939, 0.9367597051088271, 0.018751791442354806, 1.0641657503253612, -0.07612410530940951, 1.0285865810513528, 1.3156428430119775, 1.2721816068519072, 0.9028802274235204, -0.2148738267394454, 0.8853934373244304, 1.085267625223329, 0.9959736981832729, 1.2003076602926332, 1.0683247609384976, 1.183605863031693, 0.8848731918747323, -0.1144447919209712, 0.9327283338407807, 0.561716938152774},
    {0.36383338369510365, -0.03709725279699087, 0.9036429792029161, 0.005276781009765321, -0.19281160889638382, 0.8578666226676673, 0.7553510789951873, 1.0684896611157906, 1.0582675067325238, 1.0612591475438815, 0.9132686754744351, 1.0901052656279915, 0.9642421041117053, 0.6631112350186027, 0.10355455969697012, 1.0355571740044651, -0.07946193609401368, 1.1829772419365328, 1.154346091646055, 1.1798803835857494, 1.2412301938355261, -0.055424330940738196, 0.7730558702984723, 1.091712997927615, 1.4195634505942714, 0.9352185383563001, 1.481458910871479, 1.2477258057250837, 1.0682823565250124, 0.1916141865828733, 1.2095598836240942, 0.5734621321722063},
    {0.19873516359351392, -0.12499911611898915, 0.9936580518547995, 0.2066177275241564, 0.12738440806059875, 1.2631209477954577, 0.992588256958186, 0.814075897034714, 1.126710738855211, 1.304151853857259, 0.24866764329320748, 1.0634448966315977, 0.9277746272702034, 0.9496257793614548, 0.052336114423627046, 1.1563938490322663, 0.039393530776648936, 1.2237045052753333, 1.0580483686836908, 1.061077971749636, 1.2146408274389464, -0.06599552985958626, 0.7654362586208119, 1.306750937463144, 1.15197843849273, 0.9114179173689764, 1.2869123789591401, 1.3346075852153445, 0.8040846684314396, -0.041818245619308025, 0.9865771959691663, 0.5768560861121822},
    {0.6146473435571598, -0.07864077209488456, 0.850760570889378, -0.3915653047798872, -0.19646576339972838, 1.2085042476873236, 0.9042813703221415, 1.0645951197504426, 0.9690782695411169, 1.204070444384102, 0.7047921292919382, 0.9828257431372659, 0.7453798658251715, 0.6883345203035319, -0.30425081430336215, 1.4607674593896764, -0.29670509399791517, 1.314758960344696, 1.0322801208859007, 1.0572786073980645, 1.2517304517565853, -0.23062606351451934, 0.9193553747762155, 1.3259566116400965, 1.515855050117106, 0.9325734161383499, 1.0522572977413636, 1.1445947192516035, 0.9298272225952176, -0.13423322398229748, 0.6189799374133799, 0.7006162906978924},
    {0.014329279488002234, -0.06861909567117273, 1.1238442647082878, -0.382830952554052, -0.18265491702070516, 1.2340504239655705, 0.8040825805484578, 1.4228947712642728, 0.998725630118582, 1.2735363647246072, 0.8945504394802967, 1.390590755618917, 1.1688898078547856, 1.1542201426936354, -0.21462548259573913, 1.4292445954734978, -0.14302121259697317, 1.2420667554142157, 0.9621903378242692, 1.3722129269990242, 1.7387220473193017, -0.0657259621416375, 1.1373683699560089, 1.2133207902014376, 1.2299602275741357, 1.1109998916298989, 1.2941861692394432, 1.1789145496580151, 0.4375423688649056, -0.12891212982963104, 0.7998918751522949, 0.35500061822886},
    {0.14994123487116373, -0.009878903612019263, 0.8724052717927148, -0.22954767334088588, -0.0770897345373507, 1.2216959499704143, 0.9742471483537167, 1.3450117821158458, 0.7540064144687755, 1.2197577487271363, 1.0673859219803492, 1.2412104187457997, 0.6526289950748357, 1.3608183110952434, -0.3064934497889617, 1.2806313179687794, 0.06264528369193485, 1.331412487923159, 1.2698074534334995, 1.1399737291760594, 1.1678371314360796, 0.19573657610362957, 0.9784009989299078, 1.323322529413824, 1.370572153579457, 1.2359951097004322, 1.0296222141430995, 1.3191124380635868, 0.9046564030345394, -0.1230828936555575, 0.8861754364330623, 0.5742713706336897},
    {0.34130923013906694, 0.01050061450548838, 1.0994898801567239, -0.03353360371321009, -0.27047756805383943, 1.2486519784679573, 1.0487483306898884, 0.8719766471350886, 1.1714103505560105, 1.2044458709531922, 1.1608700818298843, 1.1965693043310883, 0.8926346372844155, 1.3123851022831146, -0.24309171957998907, 1.1718934707298285, 0.13461290230276962, 1.0872234533549447, 1.1701563971462996, 1.0649623807680986, 1.1388742387299031, -0.25911552780249847, 1.2085579461839249, 1.260826522154495, 1.2346977837926951, 1.2542071398224246, 1.0786864901857816, 1.3014873005719458, 0.951599222460057, -0.36817230821359404, 1.140507613357271, 0.7416647029720599},
    {0.636117336802756, -0.1080084828170899, 1.167565264737098, -0.04245034412210405, 0.15365963337446095, 1.2466213254758236, 1.2615833454713272, 1.044197694012888, 1.2146073137743438, 1.2391979879681296, 0.9932236843140165, 1.3552020974826704, 0.7930888313414223, 0.9821214970520044, -0.3774935082105611, 1.2884246226730471, -0.1211845360346175, 1.0012111995466497, 1.457189273717196, 1.4142491822774403, 1.4119710967417134, 0.006409670646886119, 0.9542114349458795, 1.125689798403641, 1.359599181482571, 1.0809707770540795, 1.1041207594682831, 1.0173092769263987, 0.5029704425605204, -0.31747677297017257, 0.7369165549734622, 0.6968000355859035}
};

static const float b2[32] = {0.38279980535433694, -0.11146813394647871, 1.0041168104305567, -0.11484240656193788, -0.07016761274811734, 1.071777611984315, 0.9772362695600599, 1.0249236478800385, 0.9517344226688328, 1.0572284041679914, 0.9435084800511615, 1.1604321375195186, 0.8894771619436582, 0.9581154760305796, -0.05152126939988882, 1.108759880223347, -0.054157613478212005, 1.0249159849503382, 1.1240623489532504, 1.1366838708156342, 1.1005895460135255, -0.09087954043212916, 0.9294871143358802, 1.0508542997030499, 1.1365661835508214, 0.9746605013257403, 1.141316185689964, 1.099586770110597, 0.9501706022270984, -0.04236784012437398, 0.9286706244652484, 0.5719243944193099};

static const float w3[32][16] = {
    {0.21916793861181474, 0.720828164528691, 0.4910831254475388, 0.5507474340584326, 0.5055711399091899, -0.028269502442034522, 0.09191972842547622, 0.2350138884039135, -0.07484650357371635, 0.48612921599302755, 0.08974953325855317, -0.255949547688231, -0.14497361282603474, 0.011753776111137948, 0.8680195334737112, 0.7067445540646748},
    {-0.04181229220671866, -0.21382707732093828, 0.16287713453997935, 0.0352544391021926, 0.06988335807997721, 0.2143824380089936, 0.09393039600389451, 0.14371072460116238, -0.046493921053034536, -0.3220108018827936, 0.14343006052978305, -0.1655654039431324, 0.23535602378549383, -0.026469270236590764, 0.05421291880247827, -0.24367792941007488},
    {1.1556524933310035, 1.134919540417399, 1.5570305954123107, 0.32949892160636696, 1.3680421328797903, 0.2966021435989903, -0.02185322444449098, 0.37821700408981007, 0.1247594284208359, 1.0584067561442994, 0.06754966187188477, 0.01330750617502763, -0.21254245307732555, 0.07954506600046679, 1.8473230215049639, 0.8584505718994941},
    {-0.061376652148266625, 0.25653744388732835, -0.19293021348014286, 0.029580996775743173, 0.08161958277597478, -0.08053074902252633, 0.3121535097407648, -0.1442079633663238, -0.0005221265799110304, -0.0092474815655521, 0.04332483667870591, 0.2623731804201962, -0.27219312974477705, -0.061542318110061514, -0.005714646228388351, -0.5819204076851899},
    {-0.16345855941859516, -0.07310031172266974, 0.09666649482816807, -0.09621855071405987, -0.017112408153781702, -0.2525536947110728, -0.3831899598759283, 0.24523701919359858, -0.17063640119190146, 0.077059934692105, -0.016818696380149392, -0.01966565903700184, 0.13941418966516736, 0.2673978337124078, -0.2321027446855925, 0.19053014691655318},
    {0.9662251816608487, 0.770711088294942, 1.1238521936048687, 0.23994189651323553, 1.4020888932701203, -0.49961021499558633, 0.0629155688083072, -0.0043151815759885715, -0.300185568651472, 1.1131012609846755, 0.046961172065176145, -0.5368512618019896, -0.49036664331428353, -0.24864179893505395, 1.4461030395645793, 0.8771277497787436},
    {0.5838398788363681, 1.1949147421791968, 0.8181843521278791, 0.06335448233644195, 1.2853818491159446, 0.21217547338351875, -0.006185507498703144, -0.09837971855129343, -0.11215981624997645, 1.3190850159400902, -0.249109898724731, -0.16211772615735018, 0.12356403921332326, 0.03100287233384401, 1.0122525492782395, 1.4840312473611665},
    {1.8344170663391992, 0.8755979813181929, 1.4590947050425525, -0.14980212030245382, 0.9102240204023031, 0.00746954837897006, -0.1457739295223333, -0.24254807067499962, -0.12814154076265805, 1.2084247922615678, -0.09617412783125759, -0.15566615194882424, -0.561001321652911, -0.288946512957134, 1.085495786615832, 1.5229097872696906},
    {1.2867774031550059, 0.9841502665149465, 0.8694749110591067, -0.3309145051304043, 0.9717095763165778, -0.33587123036844463, 0.25094510029735917, 0.38532321057027163, 0.15575329483958503, 1.7169212524965778, 0.004332294572308944, -0.3470897386411646, -0.12672443986923282, 0.2397869015889968, 1.1953222046205514, 1.4796690360751068},
    {1.737564755569533, 0.9667077444726576, 0.9768054950119465, -0.08742515792774012, 1.4853565641187652, -0.31302713696569784, 0.03557586067436163, -0.4473525527656193, 0.3796755856756133, 0.8676802869150197, -0.26435159243771206, 0.11103425067459255, 0.2536055713906499, 0.10185666082829309, 1.388084683468201, 1.5778281286211733},
    {1.264329020759637, 1.3109687102892091, 0.9499526719479433, 0.28675919509954495, 1.3259712505872383, -0.22507254401416865, 0.48509133168359275, -0.11286900273471197, -0.2168061656308603, 1.26338219434752, -0.12263795432636408, 0.28943814085256286, 0.07752841242608924, -0.05735904634559366, 0.886016077924086, 0.8292329953721425},
    {1.3607741278103023, 1.215794239127908, 0.9961488072839887, 0.08757555076337557, 1.087322611417842, -0.24335213830820246, -0.16986083294269202, -0.06610258671024809, -0.016346530966007355, 1.4735941879627128, -0.27989733770151703, -0.5756844643550469, 0.009726524996039893, -0.3031938809084905, 1.3043880937602321, 1.5442480864387926},
    {1.1881695799721403, 0.8900475957465764, 0.8954728380015932, -0.0629993335106691, 0.756230314224253, 0.07836057819836113, 0.26113157499357903, 0.0009425970307781742, 0.35558534493388144, 1.698703186931657, -0.6990313073961717, 0.1221829450407307, -0.09438364192355161, 0.40760336574589173, 1.042473256730175, 1.5519519667225827},
    {1.229487745186264, 1.0941843198506378, 1.134894796603261, 0.04886097283679233, 1.1942140162345787, 0.20207973007651506, 0.3134716489694763, 0.19899703405669, -0.14866146739286434, 1.3835091985542198, 0.13023458716551556, -0.05331759982365288, 0.003096750597975108, 0.2614310100769853, 1.4250988262874875, 1.1115082285809497},
    {-0.21594158844336775, 0.20739586656600564, 0.12001025287971782, 0.41716587342247125, -0.5894727543501537, -0.03899870862573423, -0.2502956553606877, -0.4638567402829355, 0.13358271174036632, 0.15575752703065035, -0.03018438249406223, -0.06744362643678631, 0.11717910749859044, 0.27196231802420073, -0.26153456563058897, -0.332912755694954},
    {1.5192949845452162, 0.9417997109550225, 1.2778000373239287, -0.5159979931536094, 1.5688204098525318, -0.0177435183491877, -0.5149458520940403, -0.5757986103375925, -0.03186160973626683, 1.1895987372938628, -0.1551478629936324, -0.07689929594647979, 0.13125316675880414, -0.0343931896886376, 1.1595380529841648, 1.1695791419866286},
    {0.16529048706539268, -0.1973583186169413, 0.11406146069416367, -0.13999593631831408, -0.21248287723648754, -0.15493706891481537, -0.28565910146523804, 0.001779888075422476, 0.0966370858360288, -0.004420273741914921, -0.35456246793607527, -0.2206354985758902, 0.025603316713964114, -0.41853062891549414, 0.19268022223131576, -0.14621904205736874},
    {1.5463716079076957, 1.2661553282114835, 1.0644850413650147, -0.4090280535542884, 1.2149901571874238, -0.13615007257226125, 0.09390704495220681, 0.06826929503226176, 0.19926712504168234, 1.5673442955804333, -0.04903230241935894, -0.14970788491019843, -0.09387368527186021, 0.1197470582959469, 1.1497862747300491, 1.6979055837619927},
    {1.4614150526412126, 0.7928326178332472, 0.9665960568021816, -0.2553327472312151, 1.2507301883034196, -0.5484923409999374, -0.06160531429332072, -0.23206378054625204, -0.06604236899418077, 0.9053685232052305, 0.18021798970938807, -0.38999966429335353, 0.3050580871666807, -0.14593921655988568, 1.4821943570208262, 1.3367432012125222},
    {1.0702035331929007, 0.9361597681498671, 0.5545472675067477, 0.09834422578597504, 1.3820490312147384, 0.11368626209505049, 0.1762117724802478, 0.3749668111035932, -0.4018225655795287, 1.091634395289043, 0.09180845501837603, -0.11290765130725328, -0.5483738749363835, -0.41034852553207046, 1.3384164736154247, 1.3939043815862424},
    {1.2341203819110682, 1.172649586141721, 1.1384995860659786, -0.0741789571327175, 1.3653706338401683, 0.29891503893771015, -0.22861524016395773, 0.2214307826392995, -0.2047749316425578, 1.5968782408796565, -0.33380312437419607, 0.2531041292215962, 0.04233349970389249, -0.13853560619323885, 1.3465324359377746, 1.5156022819274066},
    {0.6164718846898413, 0.13338402193508886, -0.21099786516844152, 0.1028363256077725, 0.06995513768645076, 0.02636225575819603, -0.025680160160397987, -0.03635002454304903, -0.286482454208073, -0.17665172890166167, 0.6197703095364562, 0.11082370337578897, 0.05482918868318222, 0.05508810991853447, -0.4184476259855726, -0.5236985759895533},
    {1.2835321581764993, 0.8254793005936216, 0.7168836805625047, 0.15342587547647996, 1.0252817791486664, 0.08608812648336472, 0.3446158635564762, -0.015484771685593923, -0.4332790312837756, 1.115525294967877, 0.2826954765815032, -0.15643681536273765, 0.01587857443675367, -0.07715966305700411, 1.023288491733853, 1.3029866514138997},
    {1.159929288924164, 1.0571531059048533, 1.5878336580310515, -0.03955565933935224, 1.6482152899750844, -0.1437139216453509, -0.3383545879149876, -0.3371861229922265, -0.14969587007926635, 1.27772899508326, -0.5750925838947023, -0.32424742134549334, -0.06291339221641294, 0.2655290710886059, 1.3442033871912482, 1.3569454143913096},
    {0.8768685628412064, 0.7236938157543374, 1.1803480380586058, 0.20915765304958897, 1.4757572697216108, -0.45518776648648757, -0.29278180097413853, -0.1176738906161816, -0.19638599468242582, 1.1071099381493383, -0.04965563040618461, 0.14418211006862502, -0.07529746857316133, -0.2880833874818776, 1.2106154137200895, 1.4313423874583613},
    {0.9949327196418339, 1.0121560111336294, 1.2416455746648971, 0.00369043918785685, 1.0227141213176736, -0.12138263922523025, -0.2732388596115291, 0.07027703099780294, 0.13297733545979218, 1.4219583287428474, -0.12856287706620795, 0.18240921377228503, 0.40498281917546275, -0.033438205739609775, 1.798600239411665, 1.5762416776260106},
    {1.6849401207519594, 0.5092975014799206, 1.3286361887847904, -0.08575145590926143, 1.4507907398484992, 0.4017821115647436, -0.27167791151614684, -0.6756025102319839, -0.12956381090647917, 1.2628407217276543, -0.48835546217543224, -0.3069024390879443, 0.04485790559087327, -0.16096078395483607, 1.21833382280215, 1.2829325057198622},
    {1.224673744493241, 0.7223446398397246, 1.1563412677662894, -0.45060386018443566, 1.5411411509482953, 0.02993672606606013, 0.24245487422123205, -0.13632729943363023, 0.0345617244953603, 1.25326184834179, 0.10192286091936335, 0.22597188280471228, -0.11219582978294858, -0.05594493878406918, 1.4074057611005155, 1.15035874941572},
    {1.0311244962013577, 1.143206504999531, 0.863709489243377, -0.04701174642173742, 1.359140585947622, 0.4373270150450065, -0.08290389875240321, -0.19047012585391843, 0.16023238662148095, 1.56114679163681, 0.19744150568524377, 0.005436838902971043, -0.27201988189008103, 0.28792990239580596, 1.1902011423800098, 0.820066552766099},
    {0.12489506883036895, -0.263866640371867, 0.14668672181923212, 0.11810777259415683, -0.25175569855898333, 0.06746881352177435, -0.36234755203582547, 0.09181144309112597, 0.10990419333769197, 0.23589807048111924, -0.18497573821994628, 0.1388759519786165, -0.038192368371177864, -0.37856234507175285, -0.3703191127247803, 0.1751178034732986},
    {1.2817876904466496, 1.0322025931971277, 1.0868161140840238, -0.5811785720923865, 1.0075774044182149, 0.4055257673746488, 0.17934181151382073, 0.36087228776243785, 0.0746443098336375, 1.2673228308209454, 0.1935511135412658, -0.1632642508426487, 0.27958399544636603, 0.09678123712941686, 1.5932707690203463, 0.8456618633965675},
    {0.7852544127854745, 0.6681760878711388, 0.8078031419648658, -0.060177337780941226, 0.6729875661343987, -0.07260505087577898, -0.03857163110396505, 0.301230980859418, 0.04863060027933545, 0.782797658690596, -0.24108674847594075, -0.27633314066390025, 0.2903815960445689, 0.3007256620913502, 0.8690744483713916, 0.6210938240708325}
};

static const float b3[16] = {0.8648931289504088, 0.5946678745302664, 0.7590846631661832, 0.014840119229870422, 0.8237024556103797, -0.02576870445716636, -0.0359634220356538, -0.049182361868590665, -0.03539850935233682, 0.7916101931579868, -0.03237134354204235, -0.026690877721002617, -0.02770626650810964, -0.05849681098515625, 0.8297054017115298, 0.851412882782844};

static const float w4[16][12] = {
    {-1.0300001604490812, -1.3247848904143442, -1.3280638085866596, -0.5221891743320588, -1.0089732800691265, -1.541860843353787, -1.2403679234340432, -0.6858465088197055, -0.9525492252667324, -0.8059486583147876, -1.3562508506212303, -1.1995382596898934},
    {-0.3725645597965648, -0.42359500991637955, -0.8201096413039577, -0.3864492157147171, -1.011122253925471, -0.753132140856808, -0.7018608471583839, -0.510631851299105, -0.4589072213797345, -1.1237173280100201, -0.8378593023065826, -0.8653709723597004},
    {-1.7297160449727627, -0.4792224430928402, -0.5069538682807951, -1.458599961922495, -0.4745396522123375, -0.9826917540602648, -0.9564691637900169, -0.8826323011098328, -1.3193484185126938, -1.3252742821467984, -1.1525346584708016, -0.7895025944652633},
    {0.07299824609481392, -0.16947274334264487, -0.556447037696007, -0.23974463402378168, 0.06012586816457472, -0.010879111859475286, -0.0807348851551384, -0.3726366307953808, 0.1690748253235582, 0.5658630675184166, -0.3584899220724757, -0.0019703039236188685},
    {-1.1076138980816883, -1.027676436348075, -1.5186221716667876, -0.8199348665846371, -1.2646385352387353, -0.9074377401358893, -1.1040208661119733, -1.495857583221115, -1.2102013316875109, -0.936391006683738, -0.9382492094053122, -0.7693754151313743},
    {0.5109141665054879, -0.3807111572699247, -0.10327888748880101, 0.07833801390239445, 0.2362496760999264, -0.113700300122547, -0.10220967340121535, -0.5778823155537535, -0.4495413503513468, 0.3583622817401424, -0.37500776240822614, 0.2571529910184185},
    {-0.4775482707541848, -0.4651344628215194, 0.04669842682917871, 0.29456799449294513, -0.035793670389162036, 0.1166611250278042, 0.20428856898322476, 0.3081440950169443, 0.5042887655531728, -0.2265837660449143, -0.439160273516716, 0.17735723812234944},
    {0.46793007130777514, -0.45354319028262746, -0.10766827147662927, 0.1362398735800437, 0.05495917747993451, -0.5248298850581878, 0.1401776934880367, 0.7934107117779929, 0.2654041078200993, 0.2965449110026699, -0.5001381497233018, -0.09168586002307598},
    {0.158698628650095, -0.3012531409425918, 0.15160464976413154, 0.2239101812187847, 0.3586591119270733, 0.14290782671571228, 0.03323278006737684, 0.15738952315712043, 0.02226755809999439, 0.2841358217027031, 0.15465489221073014, -0.6895296910648672},
    {-0.7798272538991404, -0.7776450784523332, -0.8357466443051916, -1.23904807696019, -1.4187410983943685, -0.9821253417884672, -0.8788394535804958, -1.0022985169533514, -0.8394810452436209, -0.3280600154251663, -0.5045240464612758, -0.6088192036202067},
    {-0.09977898654316385, 0.3185912360601421, -0.23204321330781255, -0.5156850758763595, 0.34968298864526126, 0.10961101274494632, 0.24928723509073786, 0.05946710857486405, -0.23111355268347183, -0.06804402778179088, 0.5296243619541909, -0.16794762603414054},
    {0.32816251697061183, 0.22538769126211708, -0.31690642032550836, -0.40062549061853736, -0.07947132400110277, 1.1167883255304465, 0.03784100036454346, 0.2666069907278694, 0.23029799388892186, -0.3943319640097239, 0.0914714250260805, -0.0295985718174577},
    {0.00442842982328462, -0.4797745030500185, 0.4706909294081422, 0.30932208124762434, 0.05277851646703547, 0.21801199773291202, 0.5669505503426039, 0.5019364271303, -0.30675797334566013, -0.35188962785604927, 0.08690096207667997, 0.25835925097649903},
    {0.5662534999923965, 0.20352287630587484, -0.14941857247709714, 0.046619788152742585, 0.278291964949616, 0.2904977610980081, 0.5613673512959771, -0.2051902783491114, 0.2323777799846257, -0.4396502602116675, 0.20662847976359416, -0.5805800900454251},
    {-0.6303353265761008, -1.8693922472360311, -0.9682417326514924, -0.919547713337119, -1.0810544176595382, -0.5052245293355682, -1.0614073496811678, -0.8627780552859873, -1.418879973684838, -1.035589923891156, -0.4884672772098308, -1.120113975826521},
    {-1.360304975803018, -0.8219467728479609, -0.84823353816388, -1.5435254146533461, -0.6559104190492042, -1.243048648627495, -0.9489218178520427, -1.3692681560949025, -0.6703131911179312, -1.5046881310476568, -1.6862145328367213, -1.5327309152937107}
};

static const float b4[12] = {-0.29212271643675747, -0.4553728186081084, -0.45572024823721896, -0.2922267817067316, -0.375895535144647, -0.24923783435039418, -0.26696873801207016, -0.29347921954686945, -0.3363039841655059, -0.402248997873012, -0.351543886488088, -0.25154278675030495};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
