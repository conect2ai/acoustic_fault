#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {2.600878254395626, 1.8099266531973996, -3.430212849517973, -3.2340926158312158, -2.8784818280062026, -1.9244749213215946, 2.3346282889411585, -3.758876881038176, 2.6571469163735144, -2.7973447830810594, -3.8572987856227794, -2.574204139246079, -4.045685623679132, -2.3251302290283333, -3.009948536105073, 2.3367015914150113, -4.19126338622669, -4.261370446980807, -2.4883984093487133, -4.460365073896926, -3.6690752702785825, -3.8622470159295688, -3.903264241100931, -3.9716885884414763, -4.157704064128144, -3.921887412327073, -3.91228396180447, 0.16219445426088547, -3.795496891806882, -4.0998835059541285, -3.44434432944171, -4.014874998303457},
    {-2.8977778796305533, -2.8101161459529864, -2.35498580703072, -1.062588797324452, 3.9084862492942785, -1.944632213807879, -3.2692060995858956, 1.534648450350075, -3.5049301513486824, -1.780078886760181, 3.0794519851485433, -1.455930009014121, -1.3543791563799665, -1.369264722289936, -2.065528289241376, -2.754051002207516, 0.2056994352018503, 0.5056192567358482, 2.2527795319310835, 1.6962759955702256, 1.186172556120502, 2.647576985498102, -1.0480346940768477, 3.6878450274527586, -1.5985239288120299, -1.5207568013078236, 2.276327873523667, 2.40754545501759, -1.48537669061851, 4.136030009235743, 3.5761222720213506, 3.499686766400279},
    {-2.193592592105653, -3.4171844338457538, 0.2276840976697623, -1.518581890943293, -0.22996201952585327, -2.1917458163055485, -1.482796735262346, 2.296480582386158, -1.104406319991716, -1.4153759466204794, -0.989454211920225, -3.11636986671764, 0.6377500949375086, -2.6828950816900625, -0.9634359600428957, 0.7907179535053189, 1.3507345096912595, 2.204547994328165, 0.5362655602319378, 3.6314474658783022, 3.10609506120888, 0.8285113560147682, 3.9414381317709632, 0.4535362189216464, 1.2188655276011704, 0.33881133061594115, 4.100835348110691, 1.5490170826248912, 3.393453813554557, 2.7950572517527434, 3.0644142431670818, 2.5375270645298933},
    {1.601551578719372, -0.8391816725023726, 3.6077203644944036, 2.4122547477424487, -2.4038971551904744, 1.6963108466780947, 1.1302857745154145, 2.3318486715490923, 2.1890910242297834, 2.919702473301631, -2.717436940599351, -0.05974331291929203, 3.82085962519817, 0.9233779303584575, 2.582314210006316, 2.7802843134941293, 2.350806944008078, 3.6263395031196857, -1.3837528848246243, 3.407838632118445, 2.7679260791284666, 0.5149403915185636, 4.474906903249146, -2.126410065514684, 3.5308379231758584, 3.121750841686076, 3.175326181044089, -0.7559224832739275, 4.253046618831316, -0.1473927589333858, 1.0192768153174705, 0.5494452885998382},
    {-1.5791868399979168, -2.1209431982130167, 2.3350292491749385, 0.9908986233011408, -0.18242300369735898, 0.8748351282512069, -1.276985425003071, 3.368849488101378, -0.8262033666497527, 1.377101064221589, 0.3306117735464547, 0.46441462457903215, 3.754894046366927, -0.0940296910185165, 2.790190792124884, 1.912657121836215, 3.6453669650544223, 3.5526585174025285, -0.028289440588635795, 3.8194828866155985, 2.9162599894249017, 1.4457408126560072, 4.735297040356963, 0.5324121665977068, 4.10857508469438, 3.1961685410209553, 3.400460272514416, -1.514380469247309, 4.183992374021993, 2.0474080574497844, 1.6107771486021971, 2.40795675397575},
    {-1.690550169825261, -1.6320617606023287, 4.496353812543646, 2.46742457887664, 0.5120226438441065, 0.31003191852902534, -0.9592225545968344, 5.219022820415236, -0.8669561840079018, 2.5957643597510907, 2.9218563892885987, -0.43032986675507195, 5.468324589210448, 0.8234919814023134, 2.991255433105766, -0.43861762582147207, 4.635441457677299, 4.996435827236547, 1.9704818780455704, 5.528518617600817, 5.228797814889997, 3.976546856924739, 5.624584335702459, 3.348997929377426, 5.114850678403734, 5.306885795789532, 5.090954309667554, 2.764830387003357, 5.044859158567949, 3.5344457851550724, 3.8945937829503445, 4.489338170416893},
    {-1.9847963733942589, -2.578576797265084, 4.193831583181834, 2.3414815774172393, -0.4849964066799319, 0.42839301004503333, -0.8988761385998781, 5.087294071059173, -0.6858948863097327, 3.0003984345190133, 2.2848340012769657, -0.4562358743481711, 5.037085794969031, 1.1952563691688263, 2.9129270314927846, -0.9649788270594893, 4.212290008165076, 4.706273508859498, 1.254932833949148, 5.112506391251374, 5.023515424686758, 3.306503792612524, 5.263818382221246, 2.6731027457074674, 4.744792996188143, 5.051081410073849, 5.0666852075364455, 2.6690474868783145, 4.639612652105721, 3.0590652056889978, 3.600249387833869, 4.3099686561168316},
    {-3.593542527853389, -3.925745539808254, -0.2880032312105958, -1.5373360987338551, -0.4337372139715024, -2.6626025587255855, -3.395877715604589, 2.1448563644418, -2.3243429204865818, -0.9682476060639456, 0.4625044996458571, -2.6232402126091983, 1.51873303039035, -2.3015571356822893, -0.5641385856117312, -1.0799419970995079, 1.0090100158970459, 1.3420218379550404, 0.7855191610648583, 2.1954177205483707, 1.7603512287114478, 0.08027621576471927, 3.0998835103076576, 1.6308221535096794, 0.302710373130859, 0.36402930062552064, 2.626985212703105, 2.025752255876138, 1.0191932615795534, 2.673821358620159, 2.1932483218943437, 2.3240066999781916},
    {-1.1780376318927555, -3.7055130868061403, 0.8136797201926954, 0.0994851328638318, 1.9970549101919781, -0.43152270815173654, -1.7918008929112563, 3.038120925718421, -0.49692434028577925, -0.13883507707363008, 0.509311413394399, -3.116466959218209, 1.7761272797565915, -0.5265089828561973, -1.1418299568382462, -0.5821129637926621, -0.1981368092994881, 1.516447143727796, 1.185992839440811, 2.8626477850514878, 2.6003761386627446, 2.5961444582260897, 3.0576090595139327, 1.4474940372518081, 1.3745862911690478, 0.6874302888489575, 3.7666809694140193, 2.2268429225347055, 2.504353581603872, 3.0930177223339523, 3.1963310702608876, 3.4144335598082445},
    {-0.3064381713049731, 0.6086033998625543, -1.5911386166292432, -1.326060411007959, 2.6371110416490318, -0.2557579457544853, -1.6465895703647428, -0.08580513284516948, -2.1587809962113504, -0.9088485942716878, 2.5543903966026367, 0.8511821515909392, -1.1877868054636311, -0.2975235742525051, -1.1037819138673957, -0.9919814598415553, -0.4435389546283061, -0.5670970194990733, 0.19435642517636892, -0.39743777434415495, -0.34900655230207167, 1.1845136533993081, -2.483226531851399, 3.2342381300091505, -2.4804744938385612, -1.0347038844825327, 0.40149973384556664, 3.136107915076698, -2.761670428216696, 3.9359692622159823, 1.6795558365265466, 2.2350473957690156},
    {-0.9652649268032683, -0.6181463829227823, -0.5422606002873726, -0.835965000713365, -0.6595000493509156, -0.6854798444847582, -1.9312653754162465, -0.2608537910064319, -2.6139310320866342, -0.5045695831296544, 1.475469194663972, -0.1847800086814849, 0.14889287337505694, -0.985436084850777, -0.08240383348125223, -1.4045966422318177, -0.6100586954825851, 0.05290522793837876, -0.27333933393481896, -0.25085562286408325, 0.5728203022101355, 1.245179254773521, -2.0077654038401023, 1.3354294989405397, -0.9754644669027557, 1.0142551916546227, 0.3351176766708125, 1.4608401752571256, -1.2724281559456332, 2.138559460198618, 0.6162088519297769, 2.058772069543774},
    {1.9244360183255433, 0.4517472600665842, -1.0296888382287472, 0.14756141595362063, 2.159065147614827, 0.011650094473489999, 1.1936872805326941, 0.1333642750345376, 1.8044302405550787, 0.010839021089557463, -0.691463777524961, 0.1640278064622367, -1.989853687971388, 1.2683401650890889, -1.9780849251442287, 1.0986766845945792, -1.8434287661148498, -0.5258997951787626, 0.32110439492812715, -0.4922412015858323, 0.5588613538526664, 1.131768306019441, -0.7137340570418097, -0.4413714426253809, -1.4902909827938358, -1.6932682203918383, 0.5053480942230858, 1.5528344047601024, -0.5189566353860426, 1.287442201039798, 1.7452960837102942, 0.32137251532331224},
    {-3.8618227341343663, -3.0579896625767518, -2.4223556431132023, -2.2853069179468073, 3.0569892176282765, -2.9793206056067496, -3.659921407607643, 0.7779456403139037, -3.529726347362391, -2.529273716525413, 2.7585718205362975, -2.286340732080553, -2.0477236030070705, -2.249782835122704, -2.990384618334936, -3.8734442980306993, -1.5571444937689614, -2.344007808603506, 2.2203822759753415, -1.3883407862513546, -0.11061288416167543, 1.4548390782436287, -2.853860567212074, 3.24627710349852, -2.1322282805213373, -1.7709854118769417, 0.2879347786918399, 1.7967189925805724, -2.6446031417364075, 1.3896746477895123, 1.6979139579851135, 1.9815882513498326},
    {2.079504818954582, 1.8046392558565163, 4.426751357349971, 3.9123458900917516, -0.5672448699715124, 2.8683085410627283, 2.087513450225631, 2.848665698282891, 2.6452619445731274, 3.542562738699148, 1.4297976021080598, 1.0705685804420417, 4.180259990976221, 3.609996537791226, 2.6612159612651896, -0.6420658839342717, 1.73656379765302, 2.970638224841487, 0.6347653798098083, 3.3413191486401943, 3.776451649643372, 3.5971141479968005, 2.9217587712876245, -0.14692274600449431, 3.58851420323204, 3.6447640382631987, 2.4679632405085385, 1.6839638563334947, 3.2202837229621, -0.11992299876225772, 2.417512072944038, 1.8584638294878841},
    {0.9774559480716809, 0.17103219658935911, 4.3081806072789135, 3.3706578408655226, -2.8701434817021574, 1.348331522723586, 1.938086669171886, 2.9058638096841767, 2.4423980701053893, 3.5645697704462034, -0.3487289520491521, -0.6568029669951603, 4.033629178850837, 3.5239473055666273, 1.5581260254140037, -2.4736549553894043, -0.6719178773092936, 0.9752479976690013, -0.23198716643906253, 0.6852201474548807, 3.3021017609624304, 2.2627511580467936, 2.325927088788608, -3.3454485952297492, 3.98376882830149, 3.168143273640429, 0.2387255890410454, -1.5129177238013205, 2.2152243682399444, -4.2986535046139664, -1.0971778176018276, -1.9372168372664735},
    {-1.1279746445185563, -0.24387497051140677, 1.382323399798307, 0.870888248760033, 1.2903815221102846, -0.9024462089078948, -0.29266619136210487, 2.1887908517587977, 0.007821631708747674, 0.5332751642239788, 1.961164267499039, -0.9594781196941464, 1.2348186667277417, 1.8652201594836118, -1.5457798137689616, -4.351427095035423, -1.8304743397376824, -1.5588772626484144, 2.6220159331895685, -0.15731502529293598, 2.216591764940698, 2.8763876087808464, -1.0233524734406356, 0.4773350980316582, 1.1860878031008382, 0.45374431709497137, 0.6347306487399603, 0.834310702201738, -0.6538076013755258, -1.78628616117519, 0.6255972396616954, 1.0057228069725357},
    {2.1112062457004397, 1.6813595426820795, 4.932746547023454, 4.469684760433467, 0.02955744760907212, 2.6974205796237176, 2.049339277396629, 4.122112636718519, 2.894576176756722, 4.31897979921872, 2.1673781958811627, 1.3610333284655667, 4.824043247082769, 3.971384403439365, 2.9412930153259054, -1.323344820315073, 2.615282844986799, 3.750575635493396, 0.7817109564298323, 3.8285991374782884, 4.423648055419968, 4.02416426446299, 4.299280510330608, 0.5687134441180044, 4.665084068366372, 4.45803325106788, 3.67194612830382, 2.00876365440658, 4.234369006030567, 0.17706043278001796, 2.6427624965162124, 2.542356071630953},
    {1.9343262081694592, 2.004151844677553, 3.7808244636137, 3.4541286852597977, 1.2532481546689684, 2.226641228604467, 2.0494306823688366, 3.533392883558014, 1.9538325305211892, 3.4542304852086945, 1.8133638017272498, 1.5293049541556838, 3.606672734921687, 3.4711746043647596, 1.5589495978643912, -1.9328443934239468, 1.6319379561851257, 2.761108718427519, 1.6545209430134447, 2.853580570072654, 3.4546833479171997, 3.728632861501912, 2.107636643498174, 0.9762502418478793, 3.726757637770428, 3.9535674966257814, 2.470129779007375, 1.4697315553841874, 2.3009451045225746, 0.7199780642673084, 2.3804709510766204, 2.07251257415276},
    {0.6190685324295787, 0.03798746987548401, 2.243285493606424, 2.9434564938695833, 0.014702126860968634, 0.7959434623469549, 0.9907005008413771, 2.503740289181944, 2.3371016647327147, 2.7256868003008874, -1.188855192708388, 0.43960414142592724, 2.8391929377315916, 2.7367969580298794, -0.5360375156238977, -0.9920769666424138, 0.7483009684009289, 1.3911647694518157, 0.4045414952152405, 1.9307567201506424, 2.5669211088175063, 2.1073632559387097, 1.686436934946299, -1.4619017315072476, 2.837359483962249, 2.386349046149008, 1.9911451322390998, 0.11866671970835069, 2.2968588500814975, -1.654507010896643, 0.7071178442883598, -0.4448593641430568},
    {-0.35370134504641615, 0.17298074641432792, 1.118691500202092, 0.5744405858498616, -1.1066521962605411, -0.513613496931323, -0.49122268989563955, -1.1784305634450367, 0.030208748112222527, 0.9363416942206394, 0.11034808115804175, 0.43853794597164697, -0.14977481157701772, 0.25941727010359084, 1.1948899871881011, 0.1318086386738489, 0.14699489280699463, 0.01754961096472067, -1.0314192159435416, -0.5969484192641784, 0.4253810578211863, -0.6350215432064027, -1.7191418368955487, 0.3010399046560029, -0.6246127614681023, 0.7314033088765384, -0.4626992018538377, 0.5226453531481144, -0.5664291842465276, -0.9457198994451006, 0.5999473957781488, 0.3057202440130336},
    {2.1446922229278487, 1.980748041659902, 3.155101217111568, 3.2760016906316833, -1.4447548447898304, 3.3531196173317537, 2.792085564761053, -0.10707698288711061, 3.018961042380705, 3.3317235313727487, -1.698043128502518, 2.3145164089214165, 2.3690610170861954, 3.465342118577213, 2.9587555192964023, 0.45372988254354124, 0.8134510011544831, 1.3534949828575513, -0.25488579584787563, -0.5091837198663387, 0.31654350693576794, -0.7739693626208187, 0.6650232800003946, -2.2226790808209143, 2.26827416009109, 1.8423308609064786, -1.6370606629611162, -1.8636639198655784, 1.8694351067858666, -3.3651915328982, -1.1008771523335645, -2.410643913237725},
    {2.19868723216257, 2.882541577353856, 3.236341763352115, 2.999067492527103, -3.473903834071956, 3.036463204910581, 2.046885631921607, -1.359973163393162, 2.254933780780595, 2.844015452336697, -1.0181862231484526, 2.922253017851417, 2.8743946387239645, 3.507216491658363, 3.2965849467072688, 0.25614394092507553, 1.3299260267433752, 1.3428527680756435, -2.6146650529507363, -0.5742861502918579, -0.11428809292333598, -1.81455162936897, 0.42817097656854336, -2.324361407347021, 1.905606659029898, 2.2932984852585254, -2.5206586910841207, -2.020802414094031, 1.2458712933981466, -3.379170483540794, -2.7811835480960174, -2.5070758716133694},
    {1.4891964911208024, 2.1388353417274373, 2.715949360597881, 3.539697168120473, -2.0113722222625783, 2.4742114741633934, 2.3666588510802704, -1.3994964716180909, 2.2936522717182406, 3.3443610747434565, -1.6849119584018966, 3.022346923272479, 1.3682871203248248, 3.036099346606168, 2.326933572795732, -0.05936286563409635, 1.545183331380916, 1.4220938526222882, -1.234288451286659, -0.7739570106139415, -0.5583235541571703, -1.9590805667207258, -0.834393146946346, -2.501992352615153, 1.8672906238002211, 1.4040186579331801, -1.999183277109794, -2.122199601915803, 1.3247124821894396, -3.5161177189395807, -2.412770450036858, -2.8707222821783454},
    {2.372908360296552, 3.4248435367227597, 0.9041904221788309, 2.2362637720117844, -2.5659369447003617, 2.522276053287835, 1.7048484476305295, -3.6325726609047755, 1.6029705561545016, 2.1362240323809942, -2.016845401208215, 3.795396424592938, 0.03456814486025037, 1.9838778709063856, 3.1069858597503504, 2.05218763499231, 1.8534078733711734, 1.0781256215128738, -2.7873458787941487, -2.023238963223184, -3.350313457271863, -3.9631483266805656, -1.967027489492223, -2.0083241235548335, -0.15433610972027234, 0.22804923585122236, -3.3752303890768856, -2.4921120229269453, 0.18305407401245566, -2.470634313944874, -3.360578529684009, -3.1480570150915823},
    {4.096240288718984, 3.6600885324424883, 2.8413210986490633, 2.763207157145162, -2.772956927850772, 3.9893167791968045, 3.702730471972949, -1.5366672502005838, 3.7288493245274483, 3.26812853023629, -2.27012442314313, 3.285424209835633, 1.8294131107943763, 3.018712594354875, 3.931747048304466, 4.1649977659460315, 2.329523850807893, 2.4157841299175433, -2.3883115791561607, 0.584175354366912, -0.3977267079103418, -2.218912550723283, 1.1502316158687003, -2.1456454708365134, 1.1243005137992275, 1.5531217193153684, -0.4900487470399455, -0.7062236302794166, 2.078666875006664, -1.059201459347263, -1.1502588929669857, -1.6726082628246919},
    {3.72336568357847, 3.6892231637718385, -0.21146863112552775, 1.0207538352492214, -2.5338662625985986, 3.178733580960651, 3.541295672549946, -3.764318306451112, 3.3459247737446787, 1.9478389098832007, -3.386485265846938, 3.1984835365417235, -1.4153624776544118, 1.1898316011642573, 2.9633893200074106, 4.8316716802392605, 0.803191369380714, 0.2761019574751269, -3.1113260793329025, -2.430236049177428, -3.402382944297889, -3.946354490419236, -1.4858376161069078, -2.749799765217663, -2.011776187772746, -1.1401714419823192, -3.397219037705781, -1.7547313034681995, -0.12457914687143207, -1.7861945538860107, -2.8305115310455267, -3.2173769173493887},
    {3.3194884342996676, 3.678639877729119, 0.36101989444308374, 1.6949837188927623, -3.864137912161187, 3.342478280207951, 3.241513637190232, -4.4189978154013225, 2.5061666944460406, 2.3146800540148105, -3.1821768635555405, 3.3747815244966395, -1.6519778257201612, 2.3129716850896056, 2.7396609218119528, 2.037605325624335, -1.432925050021277, -1.153952060385822, -4.073280857387343, -4.155400820030298, -4.441040269351864, -4.119293422633861, -3.6377913023232953, -3.8120615248154612, -2.181607011544128, -1.1025824694938917, -4.787398452276343, -4.221373624055466, -1.6391031876596078, -4.019633877109738, -4.803505338967254, -4.681351008261804},
    {0.8783281294752882, 1.6259508297962346, -0.22004041983104483, 1.0997695342133127, -1.7669087070929073, 2.19121050449468, 1.9536664795262717, -2.1347819794780665, 0.5652819233943515, 1.1327281235569642, -1.0941539015859023, 2.4059928039006655, -0.3167432945264347, -0.008496120327772845, 3.0614847732361516, 3.2336998389916363, 1.8713494904906336, 0.9777358630242786, -1.8454488075968873, -0.8678853421352601, -1.7507048460282175, -2.738961566605288, -1.2273612814512511, -1.7619164704991968, -0.6369192236207089, -0.3748441567009776, -1.96024595348068, -2.6792711417393145, 0.3128504793257888, -1.3800255586958863, -1.774395044568191, -1.720318716060229},
    {3.3261340451513606, 3.0787647385194923, 2.7867251708543854, 3.1269658131913163, -3.601642754709769, 3.8547177999951048, 2.953610000196416, -1.573384964892113, 3.3679483451081955, 3.627392576270648, -3.1273673659427317, 3.3971465250697337, 1.8836515228870914, 2.639561956841017, 4.040113714955868, 3.2376930598282256, 2.1678559306511977, 2.2345930732401054, -3.7208502636171628, 0.37580262245348633, -0.6912127147283281, -1.9490084459213628, 1.4576130437640247, -3.2404769346132234, 1.1023167690269942, 2.324564424226539, -1.3147838778596437, -2.0562111487103096, 1.980668047650806, -2.0013898990253964, -2.63474681195014, -2.8006035139313603},
    {2.776456308729825, 1.3142659622541542, 2.5593208462925796, 3.4693571853779552, -2.0237760136141785, 3.6706842035689964, 2.5456621846694953, 0.7122384343785205, 2.2732244717184695, 3.651329766885121, -0.8783478401411283, 2.829877328270508, 2.562963287500899, 3.0391953386261794, 2.8360014977269583, 2.3091108337168618, 1.323118246653264, 1.7011953325597942, -2.5361071091358953, 0.8929360914986474, 0.44305037963894767, 0.11639451964565982, 2.02797035038042, -3.211572459428383, 2.4836264968282933, 2.190722868093107, -0.02418114214777292, -2.547641032224548, 2.721781358154592, -1.648932432218846, -2.028895916461968, -1.583093067804941},
    {1.9194527299842763, 1.5737783072203193, -3.9760430227071963, -3.808146280850002, -4.56948516492967, -2.461768278466565, 1.6480482296109769, -4.641963356492572, 1.4125386803023834, -2.748842268276876, -3.4538959985702538, -4.615516313757993, -3.9003560448338437, -3.2570468488576156, -2.204778617089806, 2.119420862438755, -4.142701668800922, -4.3009388434594555, -5.017842367420642, -4.944990949100639, -3.832628325465477, -4.5383529004508265, -4.3753383982465905, -5.158882157468758, -4.347774583449356, -3.534695428900945, -3.9212300137596627, 1.0025573389376425, -4.127124154140463, -4.101021520620481, -4.677782568850104, -4.744899597220627},
    {2.2995984485999323, 1.0614821181447855, -2.3758260417772585, -3.1042546364704884, -3.7765609512964953, -1.970903818165105, 1.9413628553334157, -3.066455175413762, 1.6870825674673693, -2.6565474757935252, -3.981513235680983, -4.229294170594955, -3.6428362895963113, -2.594255145436, -2.2442265133454127, 2.601586851183125, -4.257973297566293, -3.7350965684130535, -4.005495052040797, -3.8155106933440166, -2.4587722101039886, -3.2489344720688593, -1.918538711696591, -4.01574473771944, -3.768756268680598, -3.229413577736115, -3.136566634684069, 1.7410326974141932, -3.0350362011220917, -2.459706642869792, -2.8216112679444203, -3.3831150112559696},
    {1.7353341308573618, 1.6195244946317893, -3.3751666812586962, -3.9255838710280444, -2.52908102265887, -2.9726010308789275, 1.4266430959711935, -2.5013356160918514, 1.5803757500965552, -3.14935173773346, -2.909492341769003, -3.7621550962569463, -3.4443985813331026, -2.3964072423297758, -2.6240929901584713, 2.0710944381413356, -3.807304992213122, -3.6552683998584485, -1.8088213964868454, -3.5111879436311897, -0.8459052518502128, -2.527516300930337, -2.1923597703113016, -2.7488927600845514, -3.64632255650744, -3.489235582827026, -1.4488949229976764, 2.7823059839312965, -3.278247805999926, -0.25088346589534194, -1.3461693798652374, -2.548491693970761},
    {2.204042482151291, 2.1797379147403264, -2.9879062721906955, -2.957707092753817, -1.8334627748336338, -2.363349559569775, 2.9684004287458294, -3.0939641861309926, 1.9306336549000296, -2.2409393101060537, -2.4769915322850418, -3.0547187780397977, -3.1760015594715774, -1.5606462348689314, -1.5566651070612272, 1.7062738565103437, -2.885090159870764, -3.2754513607532787, -1.7345667275844183, -2.7074735767103815, -1.6782511527017645, -1.6593225264389297, -1.2045521724458714, -2.9980792877866795, -3.178991534657735, -3.537223903396646, -1.8408036475593617, 1.7650400950409442, -3.11583556929497, 0.22803687178833157, -1.5622014068706287, -2.082274657616617},
    {2.345590441991913, 2.3919027422015677, -2.051143358827689, -2.041878740003422, -1.3535143291933625, -1.119377664372967, 1.6627503226932168, -2.5709397671274656, 1.620560554936468, 0.11339404071217934, -1.2841486873596066, -0.9226767994446329, -2.1947930629906467, -0.37811542318293145, 0.09770126321274077, 3.1425600963629874, -0.03565811884570986, -1.6057519640635736, -1.1141255137785364, -2.632647959228723, -0.47840246958982663, -1.478875423247772, -1.474526501046567, -2.230957068302435, -1.6234485466978599, -1.818958924938619, -1.2493552679532045, 2.335523248702959, -2.3616691877324776, 0.8100248796628176, -0.7139054722353758, -1.4343953760276893},
    {2.6557015000648647, 1.9387575302705577, -1.2712101983448847, -2.4552060589915596, -1.8537444398953866, -1.641553022414855, 1.8468296426223008, -2.2561471583419386, 0.7696461092199467, -2.1234087174003564, -2.2857260916929105, -1.0659922510406057, -2.416898107508874, -2.2794884511963143, 0.7184830850129185, 2.5879748167117747, -1.6385376085930687, -1.7536899407340993, -1.919920593865761, -1.699379521707078, -1.607349958025855, -2.2219974207372255, -1.1592549067340876, -1.031480769079733, -2.158456089345655, -1.4730407188014951, -1.0580128755226068, 0.49957374074766553, -1.6313255287606228, 0.6647845724683132, -0.8289764180207159, -0.9573346200522524},
    {2.611429391907898, 1.3824275417725163, -1.7506255684458154, -1.6797392443782049, -1.464845715200034, -2.0120579391994604, 2.4247355029599813, -1.1888832965875888, 0.8050105518483751, -1.023578570664382, -2.7144898279172023, -1.1307618143313738, -1.6625667615627449, -0.40867877010912923, -0.2650188708669581, 2.683783453121466, -2.0393203811434493, -2.4608331121589435, -1.8935724767347475, -1.7295563627031196, -0.692890713962685, -0.998537189587981, 0.243811855094657, -1.4390578878326463, -1.482927766460066, 0.41289334727353416, 0.4519497006910898, 1.9789851450898284, -1.3409130672628053, -0.08705742496400257, -1.3223217632985913, -1.402406320735192},
    {1.21053109515779, 0.3002154567578259, 0.24011801472795946, 0.23297350394820834, -2.3272096634106045, 1.573446648572406, 3.182948126626253, -0.019950591105748462, 2.845297463155857, 0.5634243169606408, -2.9768907549130716, 0.4578287249134037, 0.5538609160267597, 1.6683356497699318, 1.568533348868445, 1.3025874518538645, -1.4032112265545218, -0.9012071522862172, -2.047684940770935, -0.44372853341359, -0.1672691164828661, -1.3372442768018697, 0.6703981252165766, -3.381884137867606, -0.24754033750882684, -0.2632306466509393, -1.3124181063813107, -0.060199338572822496, 0.25457007181219343, -2.490693627350369, -3.086412421830767, -3.3233219525449478},
    {1.5263111868523467, -0.15371471323598274, -1.2198878353928662, -0.5117846225137327, -3.11230131356943, 0.8918322579621113, 0.6418414842242485, -0.4227508192633696, 0.8711386578369008, -0.5969317636939581, -2.7649992006452258, -2.4705730941886777, 0.11116401932183013, -1.428460814142442, 0.41050295709499657, 2.205402115582279, -2.3014808336729655, -1.0794946346458607, -2.6256885631303475, -1.4090662708455641, 0.48619971640730103, -1.9063156518315811, -0.14805686824168782, -2.81625518815646, -0.07133224526945801, 0.019704482738430444, 0.3484113468092099, -1.2957125112969294, -0.771697641343456, -0.6868662021298144, -1.2688710008568187, -1.153257966515474},
    {-0.08359428860435422, 0.017533483108229546, -0.44929774307144527, -1.3918244512080529, -1.604130671861539, 0.3891270467649069, -0.7781359891400833, 0.038046450595098834, 1.262006072431679, -0.4138642671485856, -0.6593961734300495, -1.736128718134288, -0.4399609765489839, -1.6904365990061185, -1.543043067566341, 0.13247033065473954, -2.6392416605814883, -1.6645521995673773, -1.1470201557779487, -0.8809490648138814, -0.4907960745875306, -1.4328729477101956, -0.7909531175235727, -0.08501242674165047, -0.6518683841000551, -1.1503060197455035, 1.1553885925743776, 1.8709543375105873, -0.6130557295924299, 0.30804512227068875, -1.2352403845925743, 0.6104096733488472},
    {-0.13419682120727364, 0.7072720397370521, -1.0484013815186737, -1.916617392388959, 0.17139565122758502, 0.052445370845597625, 1.7835046065434195, -0.04555399962436095, 1.2005044256080617, -0.9587048637275015, -1.0974011116349662, 0.19514914570263253, -1.907701215845989, 0.7315413492024506, -1.6800219712880966, 1.4330682071853382, -2.0495663776143176, -0.8611057160113672, 0.7255074955852071, -1.7727431051404694, 0.11258998234825393, -0.385235914068047, -0.6206219613215782, 0.1295193342978698, -2.0620873750993876, -2.5742023956978572, -2.0447022889550697, 1.0581809865299128, -1.6092991218968289, 0.7860307877887174, 0.4263708271731908, -1.2588361810968463},
    {0.14076621095948838, 0.14944586937871007, -0.602677368687346, 0.21107066620416168, -1.878531715173153, -0.7530775682681128, 1.496018901846739, -1.2225088392589076, 1.6594093702876997, 0.1504045087604313, 0.3392849467871812, 0.8180952171356297, -1.3866893215366667, 1.3430100417735067, -0.1734264264692364, 0.7279477334567936, -0.005269751995041251, 0.38907331115793814, -0.6418968120452331, -0.6449510235566223, -0.44156116155049213, -0.8576564788072801, -1.3433750884895155, 0.28444598408699096, -1.6755578228762433, -1.837336824177436, -0.15003139753364256, 0.45443474757489294, -1.8505481647057258, -0.0024306648695812936, -0.46901167601799276, -1.8362928098409965},
    {2.567125744325021, -0.017974220963298544, 1.2241625184912384, 0.4839648692028672, -1.195781789275923, 0.6700638212128992, 2.545906079727966, 0.7539652034183727, 2.245413237707713, 1.0184293592620848, -2.1597132477019763, 0.8534206846577779, 0.8440849023110444, 1.6093653210103143, 1.7736213830169687, 0.5234065689482665, -0.5958599500525125, 0.7021581471141852, -2.1652737575316423, 1.4805164546805847, 0.9080825139766308, 0.9244360941251106, 1.4785183844545882, -2.310698141271768, 0.6250104606499446, 0.3631361129191142, -0.7472750215667091, -1.4431319221976415, 1.3811363466034854, -0.4090358084753732, -0.2829309195072365, -1.1058472075642456},
    {1.6268689189579957, 0.058119595688128606, -1.0051706646608063, -0.257153475624629, -1.3699096327246625, -0.3564460599178551, 0.3670345810353358, -0.9288297767938476, 1.458865386736026, -0.2146476507929132, -1.2416298216371444, -0.17371019471902333, -0.5865387233746885, 0.484202435795367, 0.589627730198207, -0.5242786534008917, -1.5413140190028451, -0.8841455758567034, -0.2643220757716557, -2.1394025429577077, -0.06372758860248329, -0.894444784618559, -0.7851446614026685, -0.2243054104776549, 0.20115063447681128, -0.17645894518992822, -0.5702332674425031, 0.22594669746599877, -0.29313992736588507, -0.9298177778998521, -1.6826151771477071, -0.7666499141183145},
    {-0.5646675644725444, 0.12644821736168171, 0.21676627639804213, 0.24415996310260432, -0.5074080521703703, 0.39460053876846757, 1.8764098036628194, 0.10200475021435497, 1.428001856047677, 1.108224251880324, 1.0203820391673084, 0.48707424290503026, 0.4590947046572486, 1.8453276695469472, 1.5408772872482837, 0.5162116156681714, 0.5930238954206433, 1.0823634147216852, 1.6020343966660902, 0.7593347144626367, 0.7055729245667317, -0.8244996379106108, 0.9205994459570348, 1.5848145012800974, -0.12508620463575032, 0.07175694248124377, 0.37029218774803835, 2.0105179355351863, 0.5585110811820129, 0.9462769439943769, 0.4181529651777112, 1.4082806937124894},
    {2.219644721109281, 0.7787745403280284, 1.0848678275046548, 0.45079946529375425, -2.1266720783348445, -0.4542358424513348, 1.2873330591785737, -1.7369106766938662, 2.429975584898243, 0.5353348650785027, -1.2899283118518685, 1.199679110631141, -0.5664233275729027, 1.681865649445564, 1.1072050106930689, 0.8095043227231489, 1.2171180561979447, 0.027455748949483383, -2.1917846908841963, -1.1017559427607904, -0.620765684740535, -1.840082260146231, 0.5748390530225077, -0.9108674915987621, -1.0366225860049674, -1.0279696308545625, 0.17424099696992043, 0.37310216176509564, 0.12479898097554992, 0.935568636018948, -0.6435852536403869, -1.0076360529615207},
    {-0.8329193631108195, 0.6772271144331004, 0.8658625326364245, -0.007095950102522921, 0.24939848697242456, -1.9790273598816344, 0.378069862116806, 0.04808089625244094, 1.0824833052845952, -0.8902312571004578, 0.3351935713751836, -1.2017748000780368, -0.3942100007345571, -0.3034365665126118, 1.45100095473232, 1.0302000380926364, -0.18997444197464863, 0.37998824006257564, 1.505678392024611, -0.3483979070361804, -0.5396086487320011, -0.17645196173506242, 1.0723484100054876, 0.16702552954877184, -0.7126083262180557, -0.05926380686586152, 0.6259079418526057, 2.227577694214968, 1.3211125178505005, -0.028393321954024102, 1.254893348360408, 0.20592704659218838},
    {-1.6074807204081853, 0.12552124851936958, -0.824029248203924, -1.237951570012999, 1.2290068305610629, -1.793115799404861, -0.26828253505981886, -1.1654648056673347, 0.8426004306188745, -1.5957635720376047, 0.07772518839815162, -1.2454454889029034, -0.8917105237248208, -1.8070545285013198, -1.1902734593041775, 0.10887900655754366, -0.9977679852091587, 0.28923984239499145, 0.8179327359707059, 0.2517887965986377, 0.2482785131808628, -1.474459612889909, -0.6383949823917784, 0.7294525653916063, -0.5110296717443081, -2.0431385482825872, 0.3755607988532898, 0.6701490616191219, -0.22359557450731748, -0.2187919281548989, 1.2261985481365607, 1.3234234337759552},
    {-1.0498153540452348, -0.6629678884278537, -1.196089609008774, -1.781606273799766, 0.8946239614940543, -2.481861511019564, -0.3324951042713493, 0.9457172167633665, 1.627390174109374, -1.4332674125207854, 1.2655538416471495, -2.3447801076381722, -0.9312215761412979, -0.33465148691178465, -0.9753044154507251, -0.6170582620868913, -1.8196849375423634, -0.8601376706782399, 2.1729898260318525, -0.6531540962223661, 0.8532476682199153, 0.03828716010183546, 0.9359715393029922, 1.263482366506599, -1.1401104659274797, -1.6384366123526317, 1.1899547120205198, 3.286808861528915, 0.3795469168795639, 2.3833340658819813, 2.2409618329327197, 1.539459487748288},
    {-1.1265605181105347, 0.19323520965997842, -1.3074728199527181, -1.6481499856163948, 0.8171035396224514, -1.4175945985582243, -0.3370589831249355, 0.7259445717841478, -0.8806091140938003, -1.269227895029897, -0.30756009545206975, 0.04357041897810771, -1.0710480769510677, -0.9837734639622976, -0.8414687100006063, -0.23420336304534067, -0.705111342056472, 0.33326565562746807, 1.6860968733347648, -0.2668406736449122, 0.23456268021660018, -0.3555348194319035, 0.6304408568895467, 1.5173909035061306, -0.7695707393036443, -1.6531415438867405, 0.933973695810214, 1.1783509633391749, -0.783816241316892, 0.7555712868675857, 1.6731773880739058, 1.1672374153906027},
    {0.34205526098269834, -1.5697253523129944, -0.918689996568196, -1.502853917975675, 0.8749870451720793, -1.032585302162057, -1.1674146173730664, 0.9113706827114433, 0.06466804840322157, -0.19326877355387156, -0.649101714807943, -1.5424091733267318, -1.0924718983257802, -0.7842565096704712, -0.11073090527113734, 0.4465688071000061, 0.37813987950422534, 0.43371988339989925, 1.1760200681001893, 0.7861065915780246, 1.6330192152572953, 1.7498403484943232, 0.9421848339529225, 0.5286576005745365, -0.30825054344594455, -1.960597203327724, 1.367469612624765, 1.269218201016417, -0.13773536109403078, 1.577483185516821, 2.5968627806667612, -0.10617871217596489},
    {-0.2595994199834232, -0.6845845343969523, -0.13063186744708472, -0.23198657097306746, 1.0133597508997798, -0.5998244061656586, 0.33482377058431156, 1.2819983307902574, -0.4986832444477289, 0.6591744778741856, 2.3702165823108925, 0.060519545024441776, -0.42600587283032687, -0.24159031179919999, -0.5429051340680298, 1.0114826655647269, 0.900652917110974, 1.6001162312688733, 1.5400865543505398, 0.9446589100892956, 1.4366670458742656, 1.8854894931471324, 1.0517821690476417, 1.4484701462230534, 0.2217588450563932, -1.5232739205795465, 0.8087077328001132, 1.4741622595468866, 0.33827417444794383, 1.6999162336599987, 3.076031143811474, 1.7945948985218279},
    {0.4518900838654593, 1.1255451971293278, 0.01390865732978985, -1.3205221836669156, -0.08961535202047223, -0.6986355826443997, 1.421979294329592, 0.6117161457881386, 0.8285560185218735, 0.7046840543245032, 1.3669090173197986, -0.6417368796893682, -0.6992653230238152, 0.48639853737766686, -0.2761651559902694, 1.2625162244609525, -1.4966921966442923, -0.25158553377953047, 0.047180302587677976, -0.43915908447524354, 1.382820558142873, 0.8667407326617085, 0.4093487559804643, 0.8663901854272777, -0.49586313762133327, -0.5270526652147058, 0.698371427131764, 2.4235743141588633, 0.05728844386085272, 1.306822413349394, 1.5498658737098439, 0.8233118356380793},
    {0.8327465495858392, 1.1777789532259344, 1.0641975281033091, 2.0430071830878913, 0.4919936816205021, 1.5452891728021632, 1.2667281260218732, 1.1971585502319209, 0.6277428432211294, 1.8140143022651063, 0.5956505354994032, 0.389286830915826, 0.6050991704603245, 1.5046195449777315, 1.9147271244729087, -0.12349589507739117, -0.5615861107273045, 0.6070862836668761, 0.03833510656685423, 0.2882065034094431, 1.930078429042429, 1.921631541853744, 0.8138022469428329, 1.2316080321605842, 0.1756203604032337, 0.5722778691824916, 0.8224093647845558, -0.04017469269184765, 0.3219298858514913, 2.026351555926091, 0.4254340184427543, 0.9871098368839457},
    {-0.12376754145794473, 0.40976807598770204, 0.8446066970390165, 0.7890848637297122, -1.235997726565346, 1.1990920588128595, 1.1500171650649733, 0.28062033184544544, 1.2732603401827711, 1.5690254739420129, 0.6323620243606927, 0.415079056613987, 0.46924161187519897, 1.9515930057329285, -1.1850850852775898, -0.7248174766220004, -1.0870281726164888, 0.6893557857266779, -0.5897555894267889, 0.2531682035992539, 1.6291316316213853, 1.0789788096768804, 0.1562809057754214, -1.6971546236443995, 0.9827639468377661, 0.04923361397931245, 0.2248624065243137, -1.6628556617769465, 0.5960753871500132, -0.5584561276476028, -0.10602059066172058, -1.0368729091208235},
    {0.420000418258687, 1.1154592574942455, 0.2682920888352889, -0.2993081769729855, -0.06498617574402016, 1.1022458490096234, 0.9814498426145042, -0.3690452000387929, 0.14468322586035173, -0.06759509444523956, 1.6833455775262367, 0.5033352518450183, 0.02480219903105811, -0.31879106100036525, 1.1379873963042912, 0.05290102701917084, 1.082319845187446, 0.3871957112366592, -1.4516584554553353, -0.3416150619312836, 0.23037828115861755, -0.41259918975129073, 1.0854125011208497, 0.08382696570100105, -0.031808941253737955, -0.2026739497996888, -0.2705473556839462, 0.3128223588695964, 1.1175761284217125, 1.457248402407285, 0.02821362904624314, 0.6451019530472025},
    {2.81019573920601, 2.2631864231846546, 1.0174456678113175, 0.46698930043641396, 1.065874681958454, 0.9738419231948843, 2.191017660490043, 0.17568995927634137, 2.10239809170417, 1.4262651199612664, -0.21826729270690734, 0.858228063778535, -0.5519767364189627, 2.2262270847580234, 1.3811480588827512, 1.1286353178839617, -0.4454466085299422, -0.1759026346841912, -1.0883550029188875, 0.3975543667242025, 1.208550678194471, 1.6302459615289484, -0.2653702337846614, -0.8268501302577189, -0.5140755530005533, -0.6178578764548961, 0.25782685929219545, 0.20008435376460387, -1.3718613796333368, 0.3982672056165327, 0.4834715149011469, -0.6811425489656823},
    {0.9866291477138621, 1.9128670642483943, 0.06379260772663797, 1.4823873726240826, -1.5429712630126433, 1.3005219309881566, 0.9379226152080591, -1.1893489736130847, 1.7732360374433382, 0.359269299819505, 0.20446150964614707, 1.2910843123940294, -0.39066704086827464, 0.6894370320650204, 2.348782694926123, 1.2124362206632604, 0.37513920512152105, 1.2780313192152644, 0.6862369825826189, -0.9719508548000656, -0.19353691364716677, 0.2387038409586265, -1.326813670039706, -0.4456032116979877, -0.5741337706033266, -0.28060637554872125, -0.9586979237651064, -0.6507662028315435, 0.10731104680747204, -0.5990257110556385, -0.045152973027837794, -0.1634310565385778},
    {1.6380403204385239, 1.5346440806141437, 1.5105741558708312, 1.3952447452406849, -0.33772864739268066, 1.5209603936239884, 1.5800683844787584, 0.3993520019761708, 1.848635266593901, 0.34278212335115915, -2.1580614693669213, 0.794488653022864, 0.6801491883086956, 0.19961522444088672, 2.3520985868217923, 2.177806714915287, -0.7068060690785892, 1.3406119898278934, -1.6551183583535347, 1.952623179625551, 0.7158663787250796, 1.0779228327968164, 0.6703968911193527, -0.7868786716785675, 0.758248278257349, 1.0664266429325744, 0.8743351185924028, -0.5828707103538183, 1.9372074527412586, 0.5996521180696399, 0.8505821072520453, 0.851226974866411},
    {2.2816709945222207, -1.1230870806325879, 0.5693545750429471, 1.3488291185184547, 0.6549144432384524, 0.49977691876298425, 1.410307648551359, -0.1633201843776178, 0.5826705492385985, 1.6888458936937705, -0.9157531867380722, 0.2491531136741677, 0.885240923326869, 1.45678116087287, 0.6196748950943063, 0.86997067315709, 1.1600965510055883, 0.7006523633429124, -0.6240271243857523, 1.083628681377553, 1.828859488579898, 0.137440919122906, 0.8674883506910155, -0.3954310080211248, 1.4372330465549288, 0.4136737262276985, 1.0761334088458452, 1.2321345806625714, 1.7596380892379628, 0.6109678532278537, -0.26457713575454317, 1.368564449300101},
    {-0.9937086202438856, -1.3285294824407798, 0.8474510997242592, -0.5871105288767224, 0.010909896263501176, 0.2322962444756498, -0.7484022071412297, 0.22860813858514928, -0.1735291148362249, -0.34754491491121553, -0.5750200567108048, 0.47168865232517443, 0.18783213300400137, 1.1293994065928439, 0.8530926054193678, 0.32380441994331266, -0.055833231918595724, -0.1480496007563791, 1.1076874936142627, 0.693677607165571, 0.4521200926355912, 0.45517531773059344, 0.3367286841825281, 0.708029838476444, 0.11560371608098369, 1.055455428790181, -0.20171345797729937, 0.028939573609931418, 0.2502824217862109, 0.2796775241686324, 0.6267160826165412, 1.140671570790388},
    {-0.5150163803132293, -0.22505605899805686, -0.4957973842845973, 0.9379255393452566, 0.2800536251427896, 1.2593035487971802, 0.3831799411739589, -0.489792222423557, 0.26934748580339546, 0.93783863778503, 0.4829173813034388, 0.4293519220065699, 0.4292551444347263, 0.19972597679945098, 0.3649752711356662, 0.4932610753958632, -0.21695565950559234, -0.15788067929621447, 0.11478323307610905, -0.33382947141223085, -0.11169183896190052, -0.44241987717882286, 0.46255403167659487, -1.5366481660000022, -0.07922851318764434, 0.13212327763437817, 0.10163704768741956, -0.9113534209236172, 0.009056004198832115, -0.2578643256526295, -0.6277213571879533, -0.6160229413943},
    {-0.40391455182751296, 0.45470951886231137, -0.6917352700106951, 0.14778922742517042, -0.17152392155637705, 0.2368412106011341, -0.1291135763568936, -0.71340480665759, 0.4734476319586258, 0.31704303300284303, 0.44647327871060366, -0.559166813980289, -0.7140793598184675, 0.23189759852842856, -1.0435818556852294, -0.6325817189055589, 0.24160335320534493, 0.184557009111397, 0.1675761278802921, -0.7805713729761369, -1.5002426775259743, -0.06533506856469687, -0.3507264505570947, -1.359432035473848, -0.7400006403281904, -1.0751667230631057, -0.6734957084156591, -0.7315779644039162, -0.22221570828722556, -0.015352457214255042, -0.34981859500036494, -1.2233384082040468},
    {0.2169013047547116, 0.476448718548305, -0.4964784016118976, -0.1005048644500156, -0.5683967459970026, -0.9177938192332409, 0.4416758414416131, -0.42651055809308547, -0.4149207925224294, -0.05641587473033987, -0.1369654245615084, -0.5458642951192789, -0.07314486721604316, 0.22589050011090925, -0.7589320045184469, 0.11527489264337074, 0.14400430467310946, 0.7201812017347066, -0.10037159683039197, 0.03616777479468771, -0.8926894078062143, -0.6935535486166728, -0.42299949280905025, -1.1152286656788406, -0.0504080364801843, -0.6202825068971276, -0.2860703021055035, -0.35547150474214345, 0.3347619694820916, -1.4201308454755344, -1.6442646024927572, -1.198506403173923},
    {0.43458107468268686, -0.014121808742466956, -0.5627310615548003, -0.7939702584173016, -0.4843531159311671, -1.6722955737810583, 0.16167510981509203, -0.6604334895382413, -0.16885084467648692, -0.8531507643909441, 0.07198867433815115, -0.43690835281676793, -0.5501469984924676, -0.8651171307111823, -0.6285939137825968, -0.366031543839501, 0.7191926696398006, -0.3380820948301339, -1.525069520659515, -0.374855749471267, 0.3171931646808299, -0.3326432030308046, -0.9578220454169827, 1.238067157231754, -0.815868420140716, -0.29068329754842215, 0.5253519729082964, 0.5613021674315178, -0.6688904840163487, -0.12432152163887471, -0.7758128455155714, 0.8353660679747579},
    {0.05155634227675086, 0.12765314712611694, -0.06993665147413686, -0.2109182108240901, 0.16642521425143011, 0.4646523471840295, 0.3863754212100788, -0.042251435036792614, -0.6507120386697427, -0.2314362884664207, -0.25997715682857847, 0.4895213617695076, 0.17030044879233638, -1.0851194968124804, 0.9102810535593742, -0.4975860308423242, 0.9839698764207193, 0.42785688046579695, -0.5199086029612928, -0.1631141324315578, 0.8673210643892867, -0.10325937986545985, -0.7611520497406233, 0.8724493663393089, -0.09101949892028406, 0.6763037378614767, -0.30350943780325923, -0.9665831578213938, 0.2001162143067562, -0.10042885750847622, 0.48120801027887145, -0.2940596608299289},
    {0.3789162623838982, 1.2095582492263177, 0.6638551891494806, 0.6022923617852018, 1.02688526728485, 0.46715843328008666, -0.22729565227129278, 1.2432673991995218, -0.4177534642790766, 0.7172208053888843, -0.5314413040736146, 0.5275513866954012, -0.160413662205278, -0.04614206238734655, 0.769135027446471, -0.3219002411930738, -0.5275997301772397, 0.12457789812244355, -0.17530606683515587, -0.01678736959439294, -0.183600833499959, 0.7946189493939284, -0.10898556816560476, 0.02419399523421341, -0.6405302409051966, 0.7328780918251843, 0.3767071695314548, 0.29324462443068955, 0.10558830338356805, -0.06047276391141982, 0.5110022000184781, -0.16189308720881437},
    {0.4719355602242672, 0.23558997373529916, -0.46974419325369493, -0.8299758461610497, 0.5523304619027725, -0.802584088466868, -1.8012371598390726, 0.44309582211557824, -1.0539079484435419, -0.7894082799900215, -1.6276178575580633, -0.3724806019033758, -0.829236104806028, -1.4701462295019312, -0.32283351497284796, -1.1427157723605248, -1.6338257970031327, -1.8197563439012072, -1.1183930894677994, -0.27668188479288647, -0.9925238894418771, -0.12664609008287048, -0.37976486550517036, -1.1275972865893034, -1.117412912731624, 0.48802182319923987, 0.029368269984219632, 0.20357595407678528, 0.13847939504370452, 0.31262986921069646, -0.563647713713563, 0.12233342693662244},
    {0.8385064700575132, 0.5687272079987924, -0.2695364615508197, -0.49945118515935305, -0.0927842405229453, -1.1358549112634087, -1.1206463928354469, -0.05412952890008559, -0.6954047755010243, -1.490568927830383, -1.4752925135948514, -0.6698542736514052, -0.3831411570960933, -1.829519831240303, 0.5994709494774896, -0.8736601689976066, -0.3971488919974615, -0.7761047296805482, -0.9669360348813765, 0.17922930484838076, 0.3784942133838649, 0.39738520756287554, -0.22776915258976305, 0.5033907983000613, 0.15410913200734916, 0.2673012284390723, -0.7703453677521094, -1.0818938563539628, 0.30940078584111513, 0.6480502941332955, 0.21614781162652344, 0.3344771946620399},
    {0.15139038505757413, 1.1533180288318496, -0.6386238361056825, -0.43322302154135334, 0.25255101211418984, -1.0901228517912431, 0.5537188442725717, -0.3972082093587537, -0.11507240311366387, -1.3421456411226775, 0.4026490327562771, -1.269691586890211, -0.6391040517813404, -1.0838288679019543, 0.21295366349738612, -0.0721131926522999, -0.012977689319654265, -0.03333731710412236, 0.5337283914687001, -0.48132182969137116, 0.3000550022293209, 0.5914942269140084, -1.0128830385427994, 0.5918517606239077, 0.06690419274322615, -1.1815888905202119, -0.23555680265793663, -0.46091188028461755, -1.2613783594918122, -0.5129335659957636, 0.26613146829477885, 0.4658447368976842},
    {-0.3819915028765352, 0.7352476995201083, -0.4285026471153553, -1.1882110435435858, -0.53244932078463, -0.16163969858541896, -0.6389811104928379, 0.13225478332269505, -1.3901419366968029, -0.6793162742023823, 0.11119035663111729, -1.1949680770294477, -0.11369441146882789, -1.0488288622842303, -1.7027188367427177, 1.13334196136592, 0.024135636485058932, -0.49082813857059826, 0.644481584793875, -0.5680945573892733, -0.6977504931155689, 0.10773554863161437, -0.33088063749699237, 0.059051372280708794, -0.32288329960180673, -1.2675394175865775, -0.013049889389661163, 0.7246280788124656, -1.5026471772823953, -0.5107209706420446, -0.30721068893163955, 0.19640607485609657},
    {-0.5616954218056044, -0.022228516239415397, -0.4608460906769116, -0.5016123800310338, 0.33867023924120276, 0.967788758396376, 0.4050813981227508, -0.2695071329008865, -0.1735276018269576, -0.5801453464638314, 0.1803084576403956, 0.40463428718344713, -0.1592630169749569, 0.3280884023478188, -0.6344037748562419, 1.6475216214912416, 1.4162684187775056, 0.9806036171530372, 0.522892920977679, 0.47069145495648684, -0.5052767118809799, -0.959347786780133, -0.11079577081470553, 1.1005135242340893, -0.13899259039533277, 0.6096725031256633, 1.1612729810002365, 1.1853478840386447, -0.7160544473543002, 0.6312654372019295, -0.4205081999906764, 0.26938184972350904},
    {-0.4011289432526587, -1.3351502757719385, -0.45671114676503155, 0.6726249086927412, -0.5228520990029717, -0.23482490386370988, -0.07849798998638408, 0.19384432510297303, 0.7777033401166845, 0.9596711725653905, 0.2852050077162615, 0.25465688920065216, 0.5548528865706579, -0.224215516843532, 0.8664499016989103, -0.4408833617119822, 1.231182367905691, 1.0936671357826062, -0.24652129272406628, 0.9191367021149459, 0.21775754300904376, -0.4449474902772678, 0.870801091230964, 0.5128180851825491, 0.671068713684006, 0.9668085873321437, 1.4158222196778851, -0.08613407778233478, -0.14010719318740353, 0.14683396727996056, -0.7322524693688811, 0.3766726831216124},
    {0.9950333717428828, -0.35118191441514984, -0.5325010816851339, 0.7331691706779543, 0.8091599269043449, 0.8122367852076479, 0.984615569136793, -0.8513496303160936, 1.3474359593591572, 1.635373203866594, 0.7656599343324428, 0.33811913562770246, 0.3314813254561835, 0.2257489408733552, -0.044842483479396886, -0.30585236015986483, -0.5196526782674269, -0.22417788291107918, -0.5712560658619754, -0.15926878530928643, -0.6508145323976589, 0.5818546288527758, 0.7342773291443062, 0.5073166190976388, 0.3307788610565769, 0.2347210868483347, 0.5123261723420254, -0.8005207255800381, 0.5720637693589011, 0.3093930127098369, 0.5330533329549013, 0.39900191052508377},
    {0.78406058457819, -0.9081374005527988, 0.2611316158851586, -0.1258161839761467, 1.4714717969509576, 0.10751004950872767, 0.050429316514511886, -0.0594380537187152, -0.35500719994761765, 1.124227105274962, 1.017431267567329, 0.5220950615891876, -0.09056138697798033, 0.7508544876548013, -0.9667170220407288, -0.41222845246378786, 0.00682151158018444, -0.812529495394732, 0.648577691531987, 0.6081288877635825, 0.4037640558549345, 0.7372864371827333, 0.6008381742002041, -0.16736731365416369, 0.08790159041907188, -0.38388112744354397, -0.11747467409880341, -0.21013237278461178, 1.4518436631378433, 0.7871307471593535, 1.4113005008181647, 0.9135665621317317},
    {-0.2584229511954903, 0.9418695442071026, 0.739724201011805, 0.42226904314317093, -0.5509602180962785, -0.13117746897183413, 0.8790934463145977, -0.33690909138224606, -0.07393537695962563, -0.0907878014911221, -0.36101280267551716, 0.34989467040646555, -0.09345720717916765, 0.5208059555391928, 0.4276912417107233, -0.4930636646872507, -0.025801376637860765, -0.3064986547933397, 0.9963688803286347, -0.3799922967684052, 0.04473363432095642, -0.07308852133081442, -0.6113506298785105, -0.07779070921478032, -0.7487051682423448, -0.920767988321781, -0.8803384965179285, 0.6042071965062683, 0.3726811161149706, -1.1964703423113336, 0.04216067171701456, -0.29776670111423814},
    {-0.30433533046961453, 0.05475787588055861, 0.2880449173674479, 0.9154619148827445, -0.8454450730557898, 0.35938450925055715, 0.40265313523721213, 0.8481136689349482, 0.7784185529850847, 0.9498099687278517, 1.2244253126056626, 1.6692624464059045, 0.1322308545690627, 1.7900549857200747, -0.0028369384153397047, 0.04727530919992174, 0.06802928648380144, 1.167709563023575, 0.6725101784562556, 0.01236790520405324, 0.9425636435683189, -0.4534154190403983, 0.5788217083986654, 1.3274142205421562, 0.44199629394626716, -0.010235243735794243, -0.4813406493174206, 0.022710389795702494, -0.28568994141043896, 0.3448614968322225, -0.6528452792629279, -0.9404086677415756},
    {1.7273087063116257, -0.1046763413252647, -0.018314339270886045, 1.2530818089776183, -1.0976589872726235, 0.27218812508029466, 0.8979993386287162, 0.18602518697414885, 1.3939515374664038, 0.902207965108027, 0.5057623655028373, -0.2679913712995652, -0.03078969901641228, 0.5927432775968214, -1.1134129559150117, 0.6435830336612288, -0.8699302195415285, 0.4018586812812619, -0.9437410834934491, 0.08511895413782479, 0.3866165086344986, 0.031246331201081733, 0.012798062885344677, -0.09867031825231173, 0.5775786626843101, -0.3511233826702286, 0.6866267838787158, -0.5535846753158397, -0.555505219249089, 0.5688005337337835, -0.4620059195620474, -0.60111526374529},
    {0.23021445654972453, 0.642857994531451, 0.8757469149802235, 0.8039376428312713, -0.35440762910878887, 0.9092638095677098, 0.2313602687602697, -0.19185976680219477, 1.1257827684049952, 0.01802842758690472, -0.8212222553861028, 0.07834402483476023, -0.2502199558877785, -0.10575084862422028, -0.35784349809989063, -0.8723152744303151, 0.09896013074338278, 0.2292642821355137, -0.723021248934032, 0.2870084913005465, 0.8346086477046829, 0.9223969005169026, -0.30988674796862975, 0.0431021842036201, 0.7654407097764648, -0.8110716999307162, 0.2627613225837478, 0.7279639452721747, -0.4540125068473121, 0.4800869540330776, 0.43252523893102834, -0.8938955791747335},
    {0.3452186611803503, 0.04851008036295386, 0.2837182089360821, 0.2638178937924868, -0.004409677317422455, 0.9271507138481438, 0.4384528451270303, -0.04204666875416767, 1.3251261752880288, -0.41745345706646597, -0.709171973053832, 0.5509079614725013, -0.6946688209942545, 0.6818321403846858, 0.09197537658843358, -1.0709979220934274, -0.3116124596718122, 0.3978308010799065, 0.32960387263752566, -0.7704256404320599, -0.4333676151684841, 0.8162689582525234, -0.3767529130800509, -0.3463041991152283, 0.16174734839027416, -1.2894658636365792, -0.3145666247431517, -0.2794541378188862, -0.24886134966887663, 0.24473540570010216, 0.7237063205331398, 0.07673889688425667},
    {-0.9096394935054792, -0.1340120267466292, -0.5178035310020228, -0.1457714587763056, 0.7193179094155284, 0.3326622604678805, 0.1335810074401188, -0.18071676337924641, -0.8049437177282446, -1.1168411405985037, -0.04033825643031013, -0.7854076283294568, -0.7386228928912915, 0.4760510353962034, 0.5595048395575469, -0.12382052715574651, 0.4425508156874513, -0.2505414781816658, 0.2815899926158396, -0.5188717540157591, -0.2143236554136912, -0.5665096029690478, 0.003117325135322287, -0.7550455393128838, -0.598917084031371, -0.21374397257657804, -0.750175462064571, -1.2113287284451384, -0.22866748327970246, -0.44676931774102846, -0.7529405131529994, -0.04350952246887402},
    {-1.5339295707590765, -0.06687850374404719, -0.6659464728405735, -1.202618775971966, -0.26576100920750134, -1.052885315482513, -0.5095626770912144, 0.28880681179390644, -0.9739644382685534, -1.192812372424273, 0.5750616577160619, -1.124311943134111, -0.30063531128190935, -0.001454642198097347, -0.06745790736078706, -0.325627883167814, -0.9087080816549397, 0.4630510546224582, 0.5535473201370349, -0.09750520112625576, -0.7954988317559185, -0.527162735810539, -0.2803307573751751, 0.5519777886950192, -0.5741321373772952, 0.7678525220492042, -0.8854112538345332, 0.05651447480589573, -0.025086686746369647, -0.057809870338503655, 0.017638360865895163, -0.16279823417294856},
    {0.5389156664719946, 0.9912414125435749, 0.28242256862691784, 0.012194799749459542, 0.5252144774860985, -0.1462393091635492, 0.7349312030086232, -0.13208900501393928, 0.7423360183610673, -0.11725649882174644, 0.8311237195204119, 0.6925725565262068, 0.4328932769378747, 0.3928680474174728, 0.5118767806004799, 0.9040958271662001, 0.000414961766896241, 0.7745674426457231, -0.5120433571929905, 0.48505969255184256, -0.974995892574525, 0.05928482182313816, -0.4146550467919668, 0.5874628778302344, 0.8259267098700966, 0.6326238589566261, 0.8081530060598604, 0.41044423427181065, -0.29102442616342933, 0.11644570483267652, 0.8638954807164592, 1.2406774962003586},
    {-0.1591085590537947, -0.3929873471722109, -0.4579106199913749, -0.4471349225785325, 0.9317004441023473, -0.13547373767648116, -0.4289694763369289, 0.13841016299993145, -0.26605092899177046, -0.35873455739086635, -0.5774766762331965, 0.31935542295273395, -0.1742454243872821, -0.22269732990353425, 0.6311854220078857, 0.3242628293571855, 0.734937807432361, -0.05741062630436399, -0.7317476184773247, -0.5611131171060654, -0.10308945518356794, 0.15905767974871357, 0.020334783231530224, -0.23595625882386875, 0.15090530831332105, 0.5584763647552929, -0.15971551271821355, 0.2661002318169191, 0.406802129220741, -0.17402265046358678, -0.6084767285803234, 0.8844771590584668},
    {-0.4882796132686662, -0.6356566284018856, -0.9144814612768991, -0.8382397423288976, -1.0938938431759895, -0.8240450941133793, 0.27991071396333306, -0.26560660394403474, -0.7106718322908905, -0.9994932975981777, -0.5644586909989942, -0.534295662694906, -0.31824466577909705, -0.5463543709651153, 0.2543017540018621, -0.6137812647553261, 0.6215455602179385, -0.44314548610340004, -0.25083613743491995, -0.05253043975652806, 0.5889525877086479, -0.5801612881406678, 0.5380847116189785, -0.9396324894155679, -1.0269112992498244, 0.1459484015112278, -0.8404213732946904, -0.014268229589631374, -0.8250866869102926, 0.5327886821919123, -0.6284260643970341, -0.5714119035252183},
    {-0.1793686592169256, 0.36851121925114944, 0.29616556263719035, -1.1496492540062473, -0.21835095605648092, 0.6865569916256837, 0.5838763493708157, -0.6981101696947456, -0.7932961231701765, 0.3255057427771595, -0.6927564309205771, 0.5956543863553474, -0.7173455675704695, -0.18912056117892462, -0.6258221676239322, 0.13597846659481982, -0.18643831612173528, -0.9366097491983689, 0.37861235189266285, -0.3336709150815949, -0.7025364240731279, -0.5761197713485864, -1.1320913997669126, 0.19394412330731678, -0.4118155161339316, -1.0988061217261538, -0.8757229591130364, -0.2773083369809359, -1.3114885384100905, 0.2429429000998479, 0.40611279253678284, 0.41047114046798727},
    {-0.6752743703737515, -0.4574679185593217, -0.4109593125983386, -1.358225837674033, -1.222795824494511, 0.0037713304850239076, 0.6207745706674613, -0.7059747131821594, -0.023920370363794605, -0.44245916307532474, -1.3394457387277576, -0.4261081012118131, -1.499587195726436, -0.7734442391886316, -0.20542281100228438, 0.26435489683239044, -1.4290135745629997, -1.373694296799761, -0.13147618380731727, -1.028421869939598, -0.8407785511376994, -1.2570863003430763, -0.4621508388691705, -1.1177127223981687, -0.9248042136018524, -1.1594643692975453, -1.7814013364207024, -0.13722107106088682, -1.0480912425297, 0.31190607022573735, -0.43177745741114654, -1.045028679304633},
    {1.3217980678012866, 0.6724772180250727, 0.7103375191991802, 0.590957420692206, -0.10036157789125523, -0.19122574507010404, 0.006219162192355741, 0.9804332763265258, 0.7460822123935235, 0.2924853878970653, 0.9520585714947595, -0.05886360439874032, 0.2506018456844533, 0.35782720253708444, 0.08243298052298711, -0.7261821684033963, 0.20700938197179128, 0.26574544325052274, 0.2765017446845837, 0.5843526081530783, 0.4746114794375777, 0.6239200624271609, 0.8560276502932875, 0.7521741153741034, 0.5903783007962973, 0.31856890614546346, 0.35520705388480467, -0.7416261293588682, 0.10297919512141161, 1.1115183303306104, 0.1568631856285668, 0.24988618319663258},
    {0.10887789447168116, 0.049127234041835714, -0.6410343313516247, -0.1917174262649947, 0.4014028336693431, 0.3201475682238387, -0.957216671115607, 0.35074476631231344, -0.6231377950255947, -0.5380413420515877, -0.4074964062843125, 0.28225939209144296, -0.019102588619309035, 0.038944704675947094, -1.0307160849136034, 0.41205682295802587, -0.5019524376484239, -0.12177271929067436, -0.22136407919920154, -0.25769613765853033, -0.12191823289911925, 1.1477842518639423, -0.14692729585660158, 0.38135779310318213, -0.041370028671911245, -0.5978542374436849, 0.24588469714976416, -0.37876359449034225, 0.11535245175198133, 0.11466233158034202, 0.6580139394846449, 0.6604607834103384},
    {-0.37236892938620647, -0.5884751325983337, 0.3415155106227145, 0.05077964966622458, -1.48945533098899, 0.8134018556027588, 0.6444369496830166, 0.39711825162097797, -0.18733195907620817, 0.5032641057959958, -1.1375948202010864, 0.6522894169699328, -0.3554341600509599, 0.8562079170996844, -0.2665212258460179, -1.0198153185212215, -0.39068811205197707, 0.105931108484394, -0.01281381573657169, -0.11174384306348946, -0.5070017467680616, 0.054305198287462185, 0.16163699927309388, -0.17496368831879902, 0.14802670856096523, -0.445738772134127, 0.04935769622930174, -1.1524369606553748, -0.39074397374986797, 0.013212618112580617, -0.9590622259148899, -1.597719783746752},
    {2.099422587435009, 1.7556949945768676, -3.347073064006783, -3.0730493806456143, -3.5678769900372593, -1.7042863530285621, 1.0961491434013693, -3.86560685641077, 0.7085171542681888, -2.174918444147928, -1.907257921968944, -3.524317338996488, -3.061723798972699, -2.3852384923806964, -1.4285440387007855, 1.9602810700446769, -3.5678626157297693, -3.1619649775857313, -4.642502385420465, -4.1697759063186535, -3.272928123323523, -3.7096635149123354, -3.3071488581062063, -4.0057931522967865, -3.424080211951893, -2.705069123294116, -3.2520279078086376, 1.1653437747223387, -3.5554431802296196, -2.4099708435766503, -3.3919915617156353, -3.0809834109367387},
    {2.2931319471766525, 0.8620696966309674, -2.145424760846561, -2.1981614031245873, -3.8775387955771308, -1.2070825556066411, 0.8103738248939648, -3.0913949611069476, 1.0348086249222859, -1.6859276585703413, -2.819668845576267, -3.557427897025226, -2.7633118958618286, -1.8303882270170242, -1.150767802960543, 2.2567622586860887, -3.756645368871729, -3.209546249158232, -4.539707933462925, -3.4362407739414262, -2.3089480012618764, -2.768048838210602, -2.135081336652016, -3.8241217260871667, -3.355268258584077, -2.453958936031329, -3.1416183042684285, 1.2963488604247309, -2.4198869223793222, -2.0730014785220208, -2.4943116180714244, -2.630255871192222},
    {1.4698461730343038, 2.0182168574110415, -2.6299645562989435, -2.8911723859785954, -2.0418727471583042, -1.7449886795533913, 1.3768486763044545, -2.6336589255943705, 1.325930460505646, -2.1156041598993593, -2.569270103337482, -2.7814618844374057, -2.4830589852164837, -1.2993400653426368, -1.970564651506064, 2.0721916088482635, -3.0609584361695865, -3.242582800255525, -1.7610788817487717, -3.2960719523393682, -0.656211427746845, -2.000042424354659, -2.041254581750455, -2.435250420194026, -2.995724562023302, -2.1458657330703215, -1.97261652193762, 2.2910017642205247, -2.558293055627927, -0.2074111276601681, -1.603798426617101, -2.270445047777626},
    {2.387983033335885, 2.4835230408269013, -1.960818067613901, -2.079396866064265, -1.4676994050505108, -1.3416980992328549, 2.8928020965360317, -2.5638512199075563, 1.8202127390969187, -1.5046933749223836, -1.1552942355482023, -2.2435377205100364, -2.244487744618761, -0.8384969709526635, -0.2866376118719622, 1.4407757173293643, -1.9656629312542073, -2.645318091962175, -1.8800635284124083, -1.7212020738551246, -1.3227455666501133, -1.7181877466258497, -0.8242921608588121, -2.2927076597300737, -2.5908187097647195, -2.277017903326419, -2.0590616647376514, 2.124970321957589, -1.9787108002240674, 0.7297634127157168, -1.9957777972062773, -1.5717079022410048},
    {1.7251792107089898, 2.2267136571492268, -1.5095396052417165, -1.2899882295899148, -1.2442694449680463, -1.2405472923661809, 1.981640129266683, -2.087802465266933, 1.8883171246677266, 0.48530015223447565, -0.7762175407611084, -0.18028238666442625, -0.9852212393001345, 0.3733022344894933, 0.02518752638636179, 2.2519886795653736, 0.5451173366783844, -1.105857171505634, -0.7834179962067207, -1.4161239724855328, 0.01391383820145369, -0.8615707515414053, -1.0458989271876242, -2.21845705003508, -1.2024210666384187, -1.3610207196242794, -1.2972738331576665, 2.509226085897394, -2.0944460941088106, 0.5289507261375233, 0.13338619822231462, -0.9312135718087243},
    {2.212998896667838, 1.6760303063146638, -1.1585333545914736, -2.5114212187619653, -1.9659941954711946, -1.475919956548279, 1.6556755827970544, -1.9841401209240246, 0.41630180042387777, -1.9052400901492295, -2.0054771896520918, -1.4566107349262143, -1.834528621655613, -2.0602884682325255, 0.16023036491055354, 1.5588836478031167, -1.9564600109517822, -2.0032319150270634, -2.1593353899526955, -1.942873156043507, -1.4282823032378733, -1.933374251566532, -0.7990551282142284, -1.1942338289995225, -2.311203335740774, -0.7338383072174687, -1.3696476289443333, 0.46665933006562704, -1.4903071455836767, 0.8260133900560895, -0.9553477330356752, -0.6812255978790621},
    {2.5081911060664654, 0.6213159319164339, -0.9331653234820965, -0.6476305461868646, -1.5713368158484995, -1.6716113729559383, 2.0032246738831927, -0.4954078630729043, 1.1226070095194136, -0.4372329974308526, -2.7364076644487456, -0.9461660099935273, -0.4090332109781176, 0.04368136226072548, -0.28615719441230875, 2.2442309881500586, -1.2603535943191657, -1.8024986531969416, -1.966407248343247, -0.8950236737795939, -0.14137306993108653, -0.4975425487950189, 0.6241681555673017, -1.44994521283072, -0.6287250810334937, 1.1543074262397461, 0.9731504411575844, 1.4029964587449317, -0.0750685088244919, -0.6004605615749757, -1.3408155323825137, -1.5803055025297135},
    {0.7409232717170424, 0.29195978768879893, 0.15720425376631614, 0.23360715454272735, -2.201817956377272, 1.2312389323690194, 2.7774888806100098, -0.20112867170438953, 2.309257940074975, 0.1646138802659574, -2.636600941861316, 0.19453022186003965, 0.7149264964480293, 1.3390070455550422, 1.1898839029765156, 0.5705120276044893, -1.7054183124902755, -0.6369155219951148, -2.0868256716726226, -0.6144103283498346, -0.46643854829291737, -1.6683173731015544, 0.2196685750031047, -2.4973823304568783, -0.49657197948246706, 0.19829345214468955, -0.45461148571365595, 1.1982218308943324, 0.7038912297555017, -1.1515220590448652, -2.488868702062122, -2.579641721477836},
    {1.5031830888255593, -0.2011838642993196, -0.5618946138283175, 0.3381571384699338, -2.2231212359608308, 0.8044161555646263, 0.3411247307075367, 0.45592355520352484, 0.7806025438579001, 0.08502092678164576, -1.6451222994743273, -2.250290055849932, 0.5028319419395368, -1.1396400171109557, 0.18787099600382542, 2.0694791005203625, -1.801743654443409, -0.19200834463124553, -2.191830940510009, -1.0910057006839236, 0.7945714207539007, -0.9428724496808621, 0.4678152927691067, -2.0715735129833837, 0.3162997739576733, 0.3364773750749103, 0.45081255499647976, -0.530151703988154, -0.12467158956539195, -0.7184209678177486, -0.6757444461468363, 0.14606472723169167},
    {-0.6764799187651784, -0.7548887346303317, -0.24214708448191974, -1.6259030241859314, -0.6456417454415775, -0.34336515437868853, -1.1731929054528774, -0.018380826573583666, 0.3245443263047259, -0.5833449246516652, -0.560016185542038, -2.1391075534428694, -0.43934460119984475, -1.9858647454317113, -1.8818563654665306, -0.31632866382232017, -3.0048137277800873, -1.962822147203336, -1.2230873270452034, -0.5901501419668189, -0.09183535765275888, -1.0662451840664529, -1.191986521898695, 0.23036840022868418, -0.5176809434207651, -0.9830872931094204, 1.3308210336821535, 2.1804628624701925, -1.0350455529470346, 0.14181242728395382, -0.7028852380683525, 0.6634150555951467},
    {-0.31909091023830416, 1.5416082148141916, -0.5589940406081229, -1.7825809077558992, -0.34636350629433, -0.02239486560524649, 1.452246549225088, -0.14527242220620595, 0.8708833288511894, -0.4488225070279967, -0.7541231282679122, -0.07506149499923609, -1.0872471263238128, 0.29098695629053034, -1.5476873183818844, 1.0710617069846204, -1.8188123428258927, -0.5706568529443746, 0.77536529706689, -1.3972258717463337, 0.3745511805193051, -0.79577345978866, -0.6624455772632374, 0.5606988634256814, -1.7817978587146808, -1.5773638327508723, -1.7293704655276716, 0.8046169971476428, -1.9455516591442514, 0.661507466109776, 0.8590358235196823, -1.3253580531419302},
    {0.8905537198632517, 0.781019680609488, 0.34809144563567246, 0.7249688335380895, -1.4343738010753027, -0.2947440006843978, 1.433431965741525, -0.2285237030968543, 1.6432612216195412, 1.049058376090071, 1.3561692285442277, 1.2111477677454345, -0.5493962834041194, 1.771723803699553, 0.2990840419818643, 1.1413689166904093, 0.14109809343182017, 0.7506067115438053, -1.109218732694489, 0.24843963432448718, -0.45382111595113733, -0.4652143614949687, -0.6928307921617666, 0.5219272712526233, -0.8300139118436833, -0.38261802331964506, 0.19339388327545093, 1.222018351890708, -1.198534404837809, 0.7814246313456618, -0.6825295775060488, -0.6896565678857816},
    {2.3215242336571227, 0.16306771279311624, 0.8930922500431708, -0.6772339958586171, -0.6919624453700082, 0.301217287660641, 2.3316328129737456, 0.37783226824407135, 1.9779616014368784, 0.6295043725429198, -2.2921420653444677, 0.696644662055065, -0.26753327918378716, 1.706252028660164, 0.9288278185584695, -0.07213835660177495, -1.2243338108617825, -0.7982275348416359, -2.3949170770332353, 0.6200367186033499, -0.09767008908982014, 0.8510446995347, 0.6631611169971109, -1.9578520455575463, -0.6614435539981725, -0.12419754128810181, -1.1053050686822392, -1.4469970593185213, 0.11599991784234522, -0.48416111089422337, -0.8066479572097834, -1.7619587420226113},
    {0.8231266066465613, -0.6284002729325291, -1.3807713497834269, -0.3673320672907402, -1.7558221198258728, -0.718089125626396, -0.572672278762743, -1.0449977802582098, 0.7540272709446979, -0.7177765940689185, -1.0149262876583334, -0.5191416197979446, -0.6735050623368343, -0.05817371568906949, 0.2808531540171192, -0.6171697150117271, -1.641739494881061, -1.2909688374377941, -0.9035745021204542, -2.0736668566633893, -0.501336639723749, -1.10353584203332, -0.8730255503704819, -0.10252545943730212, -0.2722027935099729, -0.2273170355223258, -1.0301365041980728, -0.5440878298010773, -1.0758342322866816, -0.6247515048440828, -1.3915446670119214, -0.6547808914804816},
    {-0.0785176623990374, 0.3285740631768255, -0.30767465912504544, 0.3410772497135568, -0.7566943390466832, 0.1080082238572999, 1.6467264858538033, -0.9940827340477618, 0.9078154306367741, 0.8079211627112409, 0.47941115028595954, 0.10718605069501333, 0.07199968774398013, 1.723059455467486, 1.1484753114267068, -0.31302000544361197, -0.21377654884461264, 0.3647550901765166, 1.2557237969066632, 0.12547299000607334, 0.10696048916104477, -1.1032110473432193, 0.12790777816175916, 0.6995151670635309, -0.6372299095700483, 0.2482927855490434, -0.35978609239083953, 1.6941359548450816, -0.09094960670087643, -0.13814823434220644, -0.5291257575990468, 0.18297248253927434},
    {2.1342839781063265, 0.40364277548863325, 0.9254881840330453, 0.1497874916106345, -1.4358045009389533, -1.1176135294605076, 0.5134423534703755, -1.5796091445978122, 2.150466011536129, 0.8077362121044459, -1.430027023468032, 0.48040060639565074, -0.05364707419647024, 1.243503398730109, 0.7654480227121235, -0.692181167585231, 0.3913151125960342, -1.1058097856184115, -1.98890944421602, -1.0723232438595331, -0.3541226489117783, -1.6114370331109233, -0.4340347565257993, -0.8532819253218298, -1.2768108975888974, -0.8306813429187303, -0.3984781957150059, 0.6935146018039458, -1.1032824363441815, 0.3868516824540139, -0.6039346651860039, -0.21798903758577545},
    {-0.5903788194733641, 0.5866577693586679, -0.13341652712675772, -0.4258797627489013, -1.3468213480376117, -1.8904769984730765, 0.102411781011525, -0.8723955796523569, 0.11690514936281661, -0.8255495196452739, 0.5836454449024262, -0.763875895368549, -1.0162964468125968, -0.8072615991351972, 1.3944924793390299, 0.6962174072975689, -0.26206982945331564, -0.18813708665366558, 0.36187959800614605, -1.144276476634823, -1.7333513978888029, -1.4510909602239628, -1.2117504888851882, -0.2623760047056526, -1.9817308764072488, -0.8126437853213769, -1.2769859613862347, 1.745130692900871, -0.4710140482939944, -0.18827840617099847, 0.17251887558359683, -0.7175315286818948},
    {-0.30882321726918666, 0.9472601436867606, -0.2671152674999211, 0.007305426226371223, 1.0134123347063841, -0.38724236885146646, 0.09267674986474589, -1.5982266001691334, 1.1836354040768315, -0.153761605063334, -0.056642114588333264, -0.4774948174573652, -0.916640404843506, -0.8500000298648738, -1.1130118305607795, 0.8830944418051845, -1.334944864203733, 0.28965546894333627, 0.8352861073690013, -0.39368851421927065, -0.4963943912028733, -1.3669519681371833, -1.448307180334967, 0.5430134664398859, -0.21905259461693113, -1.7558037464162048, -0.017834140670771242, -0.5036604049966914, -0.8046856559653831, -0.7545289499317133, 0.5899266333965351, 0.507995598503088},
    {-0.865660318595111, 0.31041112917297725, -1.2659057557893936, -1.3881365854925842, 0.559804075339717, -1.4003427285066112, 0.5305510870416648, 0.40361375168495445, 1.6156667642648153, -0.9473762649383547, 0.5819313682087796, -2.198628120453982, -1.142118149690722, -0.6002429587602147, -0.015556258457853741, -0.2053954965685805, -2.2183042689977395, -1.2776335052391687, 0.6945580162888049, -1.1064749134793264, 0.31161382813366034, -0.1779481623141226, 0.0787927006828455, 0.7178243130237916, -1.6218034565068622, -1.0070148262770993, -0.11446505125947595, 1.742259239210477, -0.09916672058482527, 1.812897960975402, 0.7105309854826863, 0.8583897319472404},
    {-0.9809496351261346, 1.0533261621469712, -1.144443167997831, -1.5520415975278432, 0.4234442509119485, -0.8822543547222444, -0.5916461397602665, -0.33923482593695886, -0.8339908452207724, -1.1801745470885958, -0.48211029445232684, 0.0008415374097132615, -1.0151206526928571, -0.9843735153580326, -1.1505964810023535, 0.40964082327488144, -0.7152877669388753, -0.8028947453488665, 0.7413764374633495, -1.0754019148083143, -0.3620460063705731, -1.1068388844668462, 0.07993928091473332, 1.09003077074638, -1.2110247754327137, -1.4709066774002024, -1.1279910055137299, 1.6783396565113349, -1.3689793881550065, 0.593238779950384, 0.6530143561907057, 0.21689141114226665},
    {1.0619174802097289, -0.49598086638110334, -1.7882216562120852, -1.6340757150495369, 0.11293235486142794, -0.8864145348916521, -1.045116021341023, -0.5044270459157516, -0.6471391049413401, 0.15417947917009778, -1.0726107261029934, -1.1755903560035348, -1.7539600642600666, -0.08782252202746037, 0.4455103725931991, 0.7376419171280197, 0.004384403088949589, -0.06477311103090941, 0.8798285650163422, 0.18548579453064057, 0.010480188347995457, 0.9633263295189954, -0.4004871444204079, 0.4977798368528957, -1.2023381752395197, -2.8336725063907076, -0.32040951614415164, -0.3787991247831427, -1.0450757145473366, 1.4530975171511957, 1.200447501581868, -0.6085375810733809},
    {0.58371968183376, 0.6746027656304916, -0.2567374097621405, -0.38736964940730184, 0.7596433184807888, -0.4500751771402779, 0.3955536548653689, 1.0461474422137595, 0.43407327019150893, 1.3851211902022091, 2.355417443081098, 0.16579609307490292, -0.6104433672495984, 0.16991903361978833, -0.07578397310019827, 1.9346716254134806, 0.14181545072431112, 0.9491971701422133, 0.8857556723378898, -0.20521276274799893, 0.4373192626347046, 0.7786728333493712, 0.244983205668616, 1.1930411776154535, -0.1912353683606481, -1.4399090793208986, 0.5823208526687913, 0.794406001082183, -0.33600713625960477, 1.3061445453546365, 2.329627811404403, 0.8011770367173051},
    {0.3904883448798294, 0.9938433061371218, -0.00901534142225542, -0.7488598680870381, 0.15333906026778882, -0.877360049042159, 1.2817849518327609, 0.3940417085627243, 0.42851770074179024, 0.8031282533522196, 1.173030197550174, -0.1291146007007485, -0.44151613567345427, 0.4465515668650833, 0.16431093693874144, 0.9193566649207557, -1.3931722801761546, -0.6150388612303643, 0.16321049448595226, -0.9334076018943308, 0.6549376576493908, -0.1263109042257881, -0.33112090347129874, 0.368298900377939, -1.0540675331242038, -0.3024275004827133, -0.10838838250469435, 1.9703802681100213, -0.5505893610471836, 0.07395808474064262, 1.3388999917473323, -0.10736789697795333},
    {0.4657463710665393, 1.30604611624892, 0.44297898104461053, 1.552058934898879, -0.07762418618556048, 1.1611244060841663, 0.9500919042320787, 0.42506855884031863, -0.20385653241438406, 1.1164930748573456, -0.04848305985699739, -0.35049789055457325, 0.008669049406332558, 0.6525591037216506, 1.4905812645632557, -0.2712785679070104, -0.9536956812294826, 0.08907735574728998, 0.4845791722952409, -0.07622867731359674, 0.6921945667227883, 0.7886997311938903, 0.5857407160338898, 0.9802920140960115, -0.25584715349207976, 0.14091497890701227, -0.37328816211486054, -0.561942914632659, 0.38307326827593285, 1.6778408788401995, -0.15624119948528173, 0.5476971673292126},
    {-0.15949818885377487, 1.0645543051621467, -0.03142011704601633, 0.503902729526145, -1.6295357114621518, 0.5465132801566982, 1.2774962653612105, -0.72992795561443, 1.2054676081655753, 0.9210905308497176, 0.28228583194469986, 0.33101264188713586, -0.27001655910022115, 1.7485986967186409, -1.228231200360838, -0.10715266431174399, -1.825328584009205, -0.44108907763464394, -0.7158961993194325, -0.7980439738640934, 0.5437376519267031, 0.13962697108355462, -0.14186756862112246, -2.040734925486572, 0.14166690015538294, -0.18216210702921332, -0.845605780828178, -1.6579785028383187, -0.023307963593613156, -0.16152977291081724, -0.9934006147877295, -1.4009736000169832},
    {0.43564127346765, 1.4497368671944448, -0.2940751041221495, -0.27837805096997553, -0.34392654994989197, 0.688126491669397, 1.1282391500920714, -0.6550635197128436, 0.5056862622942151, -0.008204213205556239, 1.5715883611029529, 0.7101446278893943, -0.43238583147491755, -0.31847275394101787, 0.7599541876992714, 0.375264725185277, 0.6468119532456198, 0.23612953988354915, -1.085372690424795, -1.1526072069780344, -0.2617355866769836, -0.4816572159171034, 0.020840950359841872, -0.4290471982800303, -0.6306554384354084, -0.26479067008333007, -0.8613582329896491, 0.4574150439652429, 0.7311648794021582, 1.2031511936620174, -0.42765174299024633, 0.09328827547925744},
    {2.2439554335249943, 1.593259102615895, 0.5097638917519582, 0.10162276909873268, 0.8555127338439621, 0.8681587827035611, 1.6524711126054934, -0.900096268335983, 1.5642896604841476, 0.35475141536250154, -0.3872761798977002, -0.12602330807960818, -1.4826833433452862, 1.5531592548278055, 0.757500728136736, 1.251950329525336, -1.7051967687032148, -0.9218187397436387, -1.585762020714085, -1.061626855353973, -0.00815557462707471, 1.0809538136368182, -0.8569909781940749, -0.8278760108039076, -1.5005337513689954, -1.0449162655224709, -0.7192721722381994, -0.2816892228628431, -2.252122542756547, 0.10821621747779027, -0.5394897423499275, -1.8508490978714678},
    {0.771562947411051, 0.9722899900646204, -1.2592688331767217, 0.16523678898152158, -1.6473804624571153, 0.6050781358774471, 0.36442566653828695, -1.7874464347165928, 0.9615467514567314, -0.4768874647539213, 0.1143985647197498, 0.27116687199188333, -1.1143469737445988, -0.8508687505108281, 0.9492145077297965, 1.2552812113363916, -0.056396390926216323, 0.7122104584374873, 0.22218793790891023, -1.4763982343574222, -1.537754820090553, -1.1573480456236596, -1.863481247311101, -0.47202952440215956, -1.2126188198495915, -1.5525269305881477, -1.053306524714178, -0.69398494519958, 0.0669037578045496, 0.10801722650672697, -0.18097510523310464, -0.39083933241692065},
    {0.9306461101833605, 1.2207586205567984, 1.2771237250883716, 0.8361879462632121, -0.41943119728668116, 0.15022310487938845, 1.1169181765439002, 0.062195106342235094, 1.2428474968926067, -0.415842966906429, -2.256614386515429, -0.13343805719632457, 0.20853010520569878, -0.48123192998898917, 1.416642637392048, 1.1583759204046202, -1.0895500552636932, 0.14850264758910364, -1.8556979479121416, 0.9945871497211469, 0.06913104865185937, 0.5016914531408332, -0.1711618270179209, -1.193595666293244, 0.5619024586102912, 0.7107127935203836, 0.2913729189875794, -1.1218992277469841, 0.8955207219446026, 0.09265089743657053, 0.6778955998311349, 0.42746265072872935},
    {1.6822349463351922, -1.7423705207599298, -0.4682176394840145, 0.11869058472952529, 0.9406344187024808, -0.9307152508303007, 0.6791942615783456, 0.02206122506479249, 0.5079084854587772, 0.8098330366344431, -1.1000916167946497, -0.584931635143839, -0.006835376670091021, 1.029843854305421, 0.6236553091528123, 0.36282332862309474, 0.1242770858243295, -0.07258868601252302, -0.46651938776956964, 0.33478036419644386, 1.1669754907955696, 0.4608889302206858, 0.06324574079435452, -0.561537365772196, 0.14943391031893483, -0.20725306453913805, 1.0755251865940463, 0.9595534728371449, 0.6844654058209664, 0.89565926270802, -0.4283043561926086, 1.4113803940671508}
};

static const float b1[32] = {6.247129359146568, 6.231640627874097, 6.0649347807131715, 6.249435093174012, 6.250726273249649, 6.244845448614604, 6.239948229681639, 6.121647148746341, 6.236442684906328, 6.112974452439819, 6.172469069361957, 6.1074804579882285, 5.934458525587459, 6.240022382313146, 6.141585321687499, 6.374382185957495, 6.24212248558482, 6.221585775520865, 6.240100047559058, 6.3258059145261685, 6.119159198504416, 6.22879715717119, 6.231548991505873, 6.355454851450245, 6.108178680579439, 6.244845492451481, 6.223574126599772, 6.342131788095493, 6.123098395766362, 6.36701920677333, 6.176215569739358, 6.329389154055886};

static const float w2[32][16] = {
    {5.688132767207817, 5.0837091084230535, 3.9696602484914902, 5.591583285677921, 5.555873250873458, 5.502081087279055, 4.903534583456974, 5.259434194657545, 5.659209163068725, 5.532904164462483, 5.137723015625143, 5.508707686241909, 5.802250762793868, 5.259029713773421, 5.646530060487564, 5.467783525190846},
    {5.790518184596373, 5.589578607651751, 4.074678737693967, 5.873770851141347, 5.556530416778585, 5.69435817516051, 5.397807127526549, 5.433564689758803, 5.294801254236142, 5.227678563336252, 5.568637065029118, 5.38709713725942, 5.40117181856343, 5.705843407714859, 5.735456842266901, 5.194140758099211},
    {5.617011881966831, 5.175236665689051, 4.141993992158403, 5.218469105403399, 5.318966527245107, 5.193036381606751, 4.942303384782853, 5.766723409050456, 5.900028841442928, 5.592700317150876, 5.473839519218502, 5.686374224277097, 5.805850861243558, 5.664108068303263, 5.850256717975522, 5.27053913773308},
    {5.292867964773396, 5.2335767342984205, 3.80490435430868, 5.521638386093427, 5.674656432951116, 5.640230444554836, 4.947386051246218, 5.60692796399877, 5.483987462232772, 5.323175729985896, 5.3880691290446014, 5.213390287585695, 5.41656972880922, 5.415745510048597, 5.276197082948705, 5.164738291593095},
    {5.820968638047264, 5.707361080061913, 3.984441055565172, 5.477176512516788, 5.9344977793404246, 5.769688311724933, 5.080460211035197, 5.908366343836106, 5.89820999096994, 5.49188934880138, 5.51773472039266, 5.684766341990874, 5.443177154140892, 5.52051445987751, 5.623618936737982, 5.852691082641073},
    {5.802211485207504, 5.187983253886482, 4.30747668322341, 5.771935072728344, 5.58374840502623, 5.549461445219058, 4.753946522627887, 5.178702573598914, 5.557180622860742, 5.5631600065931694, 5.475064961120817, 5.388131020356285, 5.554077006522685, 5.461045295985222, 5.741850408518757, 5.127139122030454},
    {5.299769744742236, 5.267998795637167, 4.137782405850997, 5.25003492535617, 5.386344659548788, 5.558396111049784, 5.2661236173580726, 5.425039705662676, 5.331821751038093, 5.88133400451782, 5.344015045104124, 5.620700111947259, 5.709857727903834, 5.659627615323854, 5.654441800630936, 5.468834934606653},
    {5.770740495671014, 5.492744890689329, 4.246977470214452, 5.558424278508706, 5.794535187022846, 5.775948652629394, 5.1250462379658615, 5.4220184903300614, 5.525867540260767, 5.7959495501476015, 5.4177842697816425, 5.782565404883662, 5.648878159942667, 5.3532471122257395, 5.928721167054668, 5.885878624731576},
    {5.358799491458668, 5.479397714829265, 3.8700429486567236, 5.437796008421926, 5.85950279089962, 5.2496474650029015, 5.360629147396015, 5.284466468025067, 5.819029808696089, 5.267867861916188, 5.180366083764647, 5.894835676072722, 5.743502313615564, 5.383799985171415, 5.909374165262753, 5.674220100429782},
    {5.587064844472665, 5.429293976965203, 4.178857570170941, 5.702935853128256, 5.4540884200498425, 5.766280450208927, 5.1875663063790105, 5.129325166734613, 5.752963214077067, 5.728208037863259, 5.609897788378473, 5.20733951602488, 5.899203339174713, 5.57626076239795, 5.849130568863092, 5.510793263907955},
    {5.435600103252513, 5.253874152901877, 3.6088090433967395, 5.367036280247786, 5.338476272935679, 5.496949357005377, 4.971704255716894, 5.722956792018758, 5.637653950077377, 5.406323805073808, 5.764245492346175, 5.465069323187358, 5.85810912023462, 5.55354427295241, 5.307642313774746, 5.547180297154886},
    {5.5148320459065845, 5.53280023412714, 4.1197659651187895, 5.297132154369814, 5.268723944891815, 5.526150169241848, 5.091189484263776, 5.800053224931993, 5.5756271716245385, 5.713065889091204, 5.241686897177007, 5.496789136207791, 5.431112273056358, 5.611059848391685, 5.498602956193476, 5.414818083145712},
    {5.91126809282119, 5.414281663410465, 4.1109095049772515, 5.7189556052634565, 5.422204299555678, 5.52912624412439, 5.392667752307127, 5.379306002309071, 5.875203115943634, 5.390083477728014, 5.745366957051646, 5.515959959176091, 5.777731618855679, 5.363406944153972, 5.567870997779547, 5.508376253720893},
    {5.868510252532383, 5.091327225372887, 3.6389331810942984, 5.620040995570709, 5.810596613330732, 5.439562268586252, 5.096033294586755, 5.3487230399795775, 5.251596188220693, 5.21757173245077, 5.5772712250844725, 5.185902104444589, 5.42515753264024, 5.436211256222236, 5.5769107340967174, 5.413380801971953},
    {5.636957908894248, 5.410210126428689, 4.0607692805269755, 5.490901195436508, 5.5127449420630885, 5.497458632247164, 5.141879740020017, 4.975934647170719, 5.787967501132227, 5.4279134001556315, 5.484497897449638, 5.280315987527581, 5.582887726801316, 5.154495897268914, 5.785499007307535, 5.53081923230827},
    {5.6288116728625575, 5.155259888168016, 4.167867032417873, 5.461574173474246, 5.811574072783158, 5.95616831665201, 5.42348602798242, 5.5902561547918825, 5.620949478323049, 5.89845599525659, 5.754197418260482, 5.524743326701069, 5.985694562664393, 5.716206532201954, 5.509250776800469, 5.267940367097434},
    {5.734580758213575, 5.305679802974364, 4.338170273894758, 5.747855926208805, 6.055335312861018, 5.6746975569174944, 5.126694508016029, 6.029910954117198, 5.417365713089777, 6.078079520544873, 5.698148405011351, 5.89612396913728, 5.649292737219431, 5.808932698108227, 6.0900545487298645, 5.842799262494907},
    {6.029952772840426, 5.812528904370302, 3.9729684939508148, 5.972020708563539, 5.698333794145734, 5.537061500465397, 4.8631370284160305, 5.324165516044312, 5.678051801770788, 5.5264085662921545, 5.635120685174621, 5.504972498645034, 5.729991449287112, 6.050376545764757, 6.132771403493152, 5.91941302799536},
    {5.391712488041568, 5.565137888256775, 4.210594702245918, 5.5319258573220935, 6.006665543961407, 5.571046583014402, 5.202812939351178, 5.88008256665706, 5.743600857029932, 5.459202188338009, 5.366333430495817, 5.5765317020431535, 5.9607176721084105, 5.857214371781777, 5.764294270734704, 6.062697156141473},
    {5.715823108062225, 5.5872510843021725, 3.9092599123388228, 5.65597558521696, 5.61224930904037, 5.422350700096958, 5.173155639292493, 5.3622376970605075, 5.331841327832079, 5.792207453968749, 5.529347754127784, 6.009434464218665, 5.335212836359374, 5.935212889097971, 5.613633220368993, 5.534388977953894},
    {6.024808824477928, 5.771738699625523, 4.023497264644637, 5.511552972325375, 5.404764714521531, 5.715294582924739, 5.222608356022527, 5.996339845240112, 5.558526260181651, 5.986614417764483, 5.9255620461759815, 5.946971427210406, 5.984444928038371, 5.484723573303845, 6.023600079098063, 5.8289145127888},
    {5.543458291317904, 5.127835278230473, 3.742465131068753, 5.392870092349487, 5.411638160556536, 5.638225201868269, 4.93738465457097, 5.560907417191068, 5.357300038789581, 5.386951127571849, 5.302093346488769, 5.88013441137328, 5.2873271265914585, 5.171825882852681, 5.370222405416898, 5.6351076930590125},
    {5.941094245992678, 5.402026561755041, 4.075262794597136, 5.583383621821036, 5.612655915849814, 5.864245899166378, 4.898545194464197, 5.375512791810915, 5.964425425778902, 5.878889487257859, 5.271923979838165, 5.750367363586208, 5.5340709687275496, 5.4666435225015615, 5.8173858899638615, 5.614815084306982},
    {5.489473428029473, 5.390943283617231, 3.8507320159628167, 5.809512991067308, 5.621337446103876, 5.613419681996617, 5.01238411583413, 5.469297245908944, 5.509971870507553, 5.678394683198802, 5.719514935559096, 5.595806667969862, 5.245273832159546, 5.280357858969617, 5.463521976209496, 5.767475450891134},
    {5.740863037569489, 5.365348327934685, 4.14136896641199, 5.344523459523964, 5.650458166793271, 5.422702399115481, 5.186976040786389, 5.576693778247654, 5.9131577575425185, 5.935824475706304, 5.22117526514857, 5.6797253317807375, 5.939139414285966, 5.357996903243597, 5.715396167754714, 5.798406846544977},
    {5.941091725845802, 5.504224337416241, 3.868038384982807, 5.67470061063929, 5.737891793978405, 5.201201535030893, 4.873833316686564, 5.6564781741568355, 5.59907106260378, 5.660122535652474, 5.17522654435135, 5.63775050830728, 5.530230757231427, 5.86888452515934, 5.3729017715902145, 5.893841321934452},
    {5.854928614294174, 5.744311656206854, 4.366734226178405, 5.272242969598461, 5.960680368013275, 5.572549364528434, 5.4236682035692025, 5.516663559405226, 5.584322496711248, 5.373642563603931, 5.463834872543466, 5.629669774598061, 5.383462615144225, 5.78201503469449, 5.819970020883816, 6.070415110093413},
    {6.01957436495392, 5.707503166700583, 4.351044075974359, 5.704321421665797, 5.558729736348718, 5.890387392534229, 4.88703689248663, 5.383050582165776, 5.454230479715917, 5.774778420890579, 5.756984980268357, 6.03031079616018, 5.533655675086872, 5.80510013430307, 5.882961198601967, 5.676149014330197},
    {5.6886857758657765, 5.3231228358924385, 4.214868317432234, 5.830316185394875, 5.844710709590085, 5.694845447941954, 5.359308616116858, 5.2954987756941305, 5.352175734694334, 5.867932020880608, 5.575935808499702, 5.440909088458795, 5.677136257097058, 5.930066616408122, 5.890682780889369, 5.966909252397893},
    {5.98550664819653, 5.961337534194511, 4.237393873656726, 5.554360722990411, 5.603299013629233, 6.071618445980339, 5.215767111940517, 5.857902391901928, 6.196303651872987, 5.823493718774815, 5.6359334113620045, 5.905857575973731, 5.567607167115576, 5.468494468524497, 6.137299131243805, 5.663222576723179},
    {6.00074559823658, 5.778824150242556, 4.378612687048501, 5.504597434927807, 6.0717303930260025, 5.457104699879068, 5.020401187028825, 5.859364878867617, 5.501247772950906, 5.780578317160412, 5.713575552397137, 5.5005178772095125, 5.487194023839464, 5.970514880112362, 5.884140452505828, 5.598241177244809},
    {5.990309180411507, 5.404288225108162, 3.7133788066886817, 5.4651523940158, 5.598361411619372, 5.321362462599988, 4.696690131360627, 5.898120346231988, 5.880184813363741, 5.435626356630861, 5.24595228274891, 5.347978166089387, 5.458097531635185, 5.4932558254677675, 5.5250704248261755, 5.847085859059029}
};

static const float b2[16] = {5.008945973258988, 4.882562095836887, 4.199588966723098, 5.059095359978926, 4.863394715152463, 4.791973318460027, 4.82622683451042, 4.972776859827073, 4.996955063902945, 5.028499429044183, 5.050088253882353, 4.851468908398189, 4.999955373716502, 5.018807168346878, 5.051966603503471, 5.066795937106607};

static const float w3[16][12] = {
    {-3.739331718304863, -3.6254617091129937, -3.9801751174004747, -4.219958176682457, -4.178227026685994, -4.110265140803143, -3.841016511693768, -4.5222610544615645, -3.9881463572677402, -4.202727218762601, -4.107015040038671, -3.899732375325669},
    {-3.8964139976854044, -4.018285164936135, -3.4822126471548436, -3.845100033325674, -3.4063876099323442, -3.1328670903907594, -4.528298965163277, -4.031666874060704, -3.9881640203562974, -3.796320723883121, -3.91885757896031, -3.685961194528441},
    {-2.8832985866483356, -2.557276442648504, -2.687837261647209, -3.2283358116200773, -3.0687019859135893, -3.190775092614374, -2.492709504129858, -2.6067300282919335, -2.4914909070387026, -2.5530905716525685, -2.476699519144965, -2.4825791311415872},
    {-4.3206366524232855, -3.7814671371719095, -3.669843296844745, -4.198693436741822, -3.934876471026094, -4.230675162984177, -4.079152785652771, -3.796757093824103, -3.4915333500690284, -4.521637865064408, -3.9887479520538154, -3.9807577765491837},
    {-4.034627749888761, -4.28304236850576, -4.479306105015173, -4.314101682118259, -3.7304144369932684, -4.149192680541835, -4.010869422101834, -3.958383594889291, -4.244369417923725, -3.9607424771473956, -3.9261723202444236, -4.051859543802847},
    {-4.033569416475264, -4.4156692555037, -4.18989397426342, -3.574967388009432, -4.4032698334221, -4.205732116948445, -4.120672176210738, -4.229056586478959, -4.398184911340488, -4.360713774527576, -3.695314560377019, -4.210055832123446},
    {-3.904515767399727, -3.712207423074289, -3.5917130612827317, -3.352641324808709, -3.1377775473574485, -3.7017937274719896, -3.255357682765972, -2.794986884627405, -3.4091146833613126, -3.3038978129994914, -3.5375161550428977, -3.544831177823066},
    {-4.182988283859549, -4.252076474153569, -3.793202603256833, -3.7659124603576677, -3.814862689889254, -3.8510889807499487, -3.8133296262273597, -3.630722412383742, -4.1939853965019775, -3.8688892666687, -4.320837016531345, -4.668210778185937},
    {-4.271011755406402, -3.745000602503968, -3.8226596669759356, -3.848405399340003, -4.555931297969377, -4.3267732585069, -4.216708910944538, -3.6947969199679283, -3.84471414004692, -4.5372702535403295, -4.146897414722939, -3.9774280970021616},
    {-4.445797814639645, -4.484300478892774, -3.9695223512899678, -4.295473355677799, -4.1423979711489025, -3.9331923647707954, -4.0641715601375505, -4.431891843067044, -4.310187865565875, -3.661007632408166, -3.942604047087224, -3.825369665966003},
    {-3.817325438482935, -4.448855438862264, -3.851166598116126, -3.707750257324612, -3.591470277732654, -3.851441763144263, -4.118450623641707, -4.26917532780108, -4.111898178014952, -4.329759952358733, -4.233103737814876, -3.850353611241751},
    {-3.8569484892093593, -4.05880724795342, -4.28407989530659, -4.158415369400696, -4.203634065847933, -4.31167457675431, -4.295607014776303, -3.8120825138959638, -4.187162243840814, -3.978630739171084, -4.013540627952256, -4.443248756821772},
    {-3.6057450121913424, -3.7729280781506813, -3.955667017645743, -4.446871308135636, -4.256405922913426, -3.7304643394316788, -4.245853955760993, -4.510498126016062, -3.8743462485347733, -3.665534964587062, -4.130038370502224, -4.427424731817393},
    {-3.578609364007543, -3.8895133369327692, -4.5386998678834605, -4.262280403401478, -4.330913898206748, -4.024523111170472, -4.291614109781784, -4.514493574250692, -4.198961128446719, -4.349183771559448, -3.8642986905978662, -3.8398665508461938},
    {-4.286753539129555, -3.982028899722544, -4.38581342562963, -4.03548720965181, -4.041476858282825, -4.063313566446859, -3.698379530317037, -4.283105236062571, -3.757660168797095, -4.147237380558136, -4.127336242311643, -3.72160646590898},
    {-4.242451457618702, -4.012174292349785, -4.269450364602954, -3.85197120263583, -4.097116281046282, -4.322744023409908, -3.8917319830103967, -3.805073829796072, -4.407405795826696, -3.658415584039113, -4.49573864460537, -4.251534287182172}
};

static const float b3[12] = {-2.481107167262019, -1.9279128723781562, -2.4727596869959685, -1.6689257377366926, -2.461672813747788, -2.496353441734065, -1.9402464973895606, -2.0412353296148935, -2.118540743028015, -1.528235131789642, -1.4304432174888748, -1.4235394486182216};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
