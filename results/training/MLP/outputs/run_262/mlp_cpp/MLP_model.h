#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {2.086066944551388, 1.2825781936360932, 5.053722952840305, 4.062868320556726, 4.841520780016048, -1.981747527943488, 1.7993972184143003, -0.6450917049291514, 0.9023872563468223, 0.20954700054554104, 4.1294037384231075, 1.5821456449560918, 0.7643790290582388, 3.3767188664646413, 3.450573429853575, 1.536726485720967, 1.2288761407304047, 2.1710167270282588, 1.781592448001611, 0.3227512610791601, -1.7309409658627486, 5.407531271358203, 0.7386859973915899, -1.0182933412544877, -0.8212529813407639, 1.2574402306928059, 2.270346206915695, -0.5939621207665491, 4.039215460634156, 4.2870036154507405, 2.253807573440529, 1.8713834169816073},
    {1.8629191299509638, 0.9766878183254524, 4.346211506431628, 3.8051192337090884, 4.21425726853067, -3.0234145272084962, -0.03750379910338428, -2.3743514901300826, -0.42247675128522605, -0.27698388077822117, 0.9859065860248898, 1.0893657039568048, -3.4913438161154766, 2.982755393914395, 1.2468939603287923, -0.22665756815675892, -1.2619295096353702, -0.08965545873156076, -0.2242821998121427, -2.7594478956812094, -4.120658527515881, 3.3768935851774136, 1.0752975671504252, -2.884307956257008, -1.4185880485792655, -1.7022950655718783, -1.422557453296171, -3.766580438742328, 2.8447420685761693, 2.588767012377982, -0.5514194966160745, 2.204630389673889},
    {1.6660471127027554, -0.1187658350425588, 5.583083173406938, 4.392739927258529, 4.921263430677724, -3.6659006819427447, 0.13964658051379086, -1.0040572621158497, -2.299584627611281, -1.5501196543286764, 1.7428088121546188, 0.9731932116248933, -3.4744664398489937, 4.166923373525757, 4.509587938713085, 0.11978165953886097, -3.2717721447051233, -2.0301865869276106, 0.8164920134718469, -4.070742614649538, -2.97941339676757, 4.585458457827651, -1.364039819227075, -4.062362381219568, -1.7401403007772382, -3.4111675876385754, -1.8032429598436885, -4.017863584813633, 1.5735328490270035, 4.851145696861569, -2.0979480296377417, 1.7796672583138355},
    {-0.2855475409147185, -2.5515964670060383, 4.881098702745387, 3.7317794469396266, 4.772065628896219, -4.519489424089905, -3.0573788398040875, -3.80168260445958, -3.0830988439834837, -2.254165051079507, 1.6105409424477006, -0.42094594143734343, -3.5774352019119466, 1.3744538018647565, 2.931229652665597, -3.16407063608044, -3.455870072038718, -1.2544997526456276, -1.2992109628402988, -4.032071504852921, -3.607300889843833, 3.3642948306007834, -2.700746524387431, -5.058340950925326, -4.596857343878, -4.416130907928118, -2.536709551466513, -3.6977518031787016, 1.8032988060843693, 4.35694850131504, -2.386953261178091, 0.4917384321204768},
    {-0.1528861008856954, -4.161587255842654, 2.229952767424856, 1.6956687096966718, 2.7425114429070114, -4.337533685967883, -3.8560106263780436, -3.491765575604062, -5.046705604233179, -3.1026120303821285, 0.25708473816018257, -2.242994763685757, -2.737207116390311, 2.338081816289442, 2.7674719087530586, -2.2945258862054407, -5.257227357122223, -3.3049528105396244, -1.5360189852143666, -5.670189084679586, -3.3928930333905494, 2.7814433549835833, -1.870571622628039, -5.047181349516155, -4.248177411512097, -4.894483606913457, -2.7390550685244883, -3.501758439589119, 1.7175865559543975, 3.3100037004738727, -2.5829873367733343, -0.7423526516175881},
    {0.09924247620589209, -4.39163532829838, 2.9405342708326336, 0.8436464158662295, 2.4500692755255313, -4.346029701788798, -3.066085097976315, -2.9609211186414894, -4.68343328250728, -4.785004721426189, 0.1117932172217718, -0.528541136499785, -3.3301669542075554, 1.5156023450701404, 1.9158892552687765, -1.7239720219728045, -4.778474567083177, -2.982781607075895, -2.341982784914908, -4.986508071347332, -4.685784393542206, 1.6976847284551628, -1.8798360322007615, -4.36272794423884, -4.767612091346777, -4.763056449240124, -2.0459685482245917, -4.471064449026587, 2.3426941486976984, 1.6397287006765935, -2.455831690462144, -1.6952055565271924},
    {-0.2991038708076249, -4.214080498972289, 0.3726169376419459, 0.7869592552426, 2.3099725081712768, -4.716448672586017, -3.678006250754705, -4.075389804689049, -4.932759905166306, -4.625951772049326, -1.4967274159339152, -2.477347235368161, -2.910914551422814, 1.780087502358911, 1.5057927930371358, -2.4758598634749176, -3.431650546010666, -2.7533844982586095, -2.586899989833777, -5.443841400053618, -4.9061111652620495, -0.2874358561507657, -1.6801846811957433, -4.608185339531359, -4.811012585665531, -4.365826762753048, -1.383094479689503, -4.329579925723461, 1.1695051245882833, 0.9816924749081114, -2.55850439026438, -0.8552329606553519},
    {0.22985514463567003, -4.3410470758210105, 0.7913081358661992, -0.3926154662981908, 2.4585330732741384, -5.101025990311988, -4.148727441150856, -4.806201497798478, -5.439770101554774, -3.8066492809307397, -1.6812133165790148, -1.3473415684597347, -3.337872108351138, -0.3360679364691436, 0.11218953233703695, -4.095961450335268, -6.009298264130625, -2.513204765523251, -1.5272344082635516, -6.265008656226281, -5.492142108848042, 0.24480720887043755, -3.768098473810992, -5.440072507302928, -3.5511081132396862, -5.5423625090284405, -1.8539058051484465, -4.245757703955597, 1.1408311251328644, 0.017855890815232815, -2.399910357053251, -1.62928856636019},
    {-0.6227827038550535, -4.186361161003144, 1.4173910026713494, 1.4446228134059178, 1.881820502329764, -4.994707454309709, -3.2223789498798716, -5.546896865688726, -5.617596915827461, -3.0335131311722896, -1.0841487925027007, -1.472690150320248, -3.869020546579543, 1.6857773628612729, 0.6172669640902843, -3.4757162169163354, -4.522424349234483, -1.7388657107551955, -0.4228958067072788, -4.457988288903297, -3.697019530515077, -0.041977338887129734, -3.798089571577086, -4.732384122984762, -4.46121622581507, -3.348043402966118, -2.2917337326617924, -2.802045455392962, 1.591560588050133, 0.8235274198330139, -2.228129862463032, -0.4917325020200489},
    {0.9606191812956641, -2.1319486270648196, 2.99933917250069, 1.6883892958283213, 2.820210450071662, -4.600202782978706, -3.120667076881171, -3.5834301296703646, -3.9703480124041066, -3.9034282441731567, 0.736274525477017, -0.7716557941318697, -4.419640496276381, 1.7372466322793245, 0.5859370548460063, -4.162041953224079, -5.109785110164564, -1.6717691112351802, -1.3238459130800921, -5.8660085171964695, -4.859747761996225, 2.350601677573235, -3.2644596414997804, -5.141280979803114, -5.225525936610956, -3.154807774750285, -3.1586450311032124, -3.4861306769957494, 1.1144593429512821, 2.373825806297772, -2.4445216812408037, -0.46438378719966966},
    {-0.4885310519931036, -2.4965059240783902, 3.0073164184985446, 0.6651099768399517, 2.904072256173046, -3.242924103495527, -1.9806826280994194, -3.8145247312120136, -4.126986563386304, -2.4113475380264386, 0.5591903500834331, -0.11633496348313781, -2.7079459772716072, 1.2660827959969974, 1.8710275635353917, -3.63717312256393, -4.450932615316352, -2.998982228293338, 0.33469207747295543, -4.506578546575506, -4.505460179153709, 0.13095687681515114, -2.5996440908849285, -4.416158850604911, -4.023756057138531, -3.6644596305805432, -1.9074658650008047, -3.6281442809925135, 0.7629520970341209, 2.463215057821515, -1.7278093064900486, -0.6625347718647446},
    {0.44294083203867174, -1.817527283632952, 1.6855636126317721, 1.0814440389088722, 2.3670369876413617, -4.068748000982354, -3.5558639190185115, -3.417361469627307, -4.701015817176245, -1.7864248881078129, 0.11604019201488018, -0.9152435859789783, -3.318733394593849, 0.8880185275687842, 1.636741908264894, -3.2538465817656124, -4.688581615763086, -2.3365130822604483, -1.5287079117785904, -3.9692090959875252, -3.240076916938045, -0.2501055649582496, -3.3700489376657643, -4.769285478468338, -3.757864867056394, -3.817938272947453, -3.173830907313351, -3.7524115413434522, 2.224783122449092, 2.165862983150218, -3.6074948351277634, -1.1581056125766014},
    {-0.7505984150536447, -3.350216401197835, 1.3244063570166655, 1.696507359097202, 0.930397255534901, -4.922552981627283, -2.4420033840228332, -4.298307754376478, -4.22764429854364, -1.481688550492147, 0.9587624117886528, -1.0499249045706736, -2.7604521635772046, 0.00028668571277675197, 0.6178877961552199, -3.412845429856654, -3.890909072073236, -3.210801044637991, -1.2721378222086195, -4.987108329842432, -3.938370454518756, 0.5457017734370601, -2.934874759263358, -3.588964209795503, -4.541221682249378, -4.852669396403007, -3.111258752548469, -3.6307785129757986, 1.3610995278016178, 2.0000193592638746, -3.8286926603601126, -1.679548074484426},
    {-1.7663709033778525, -3.649787825824552, 2.129351296937551, 1.701248734275842, 1.683481934891438, -3.415239575129426, -2.6287918041227294, -2.844951346717637, -5.0863825776782114, -1.896904066643677, 0.5301412482146708, -2.2138522350979244, -4.025922070942125, 0.20332633639857453, 1.4700375845431557, -3.541269164027169, -5.046332720507683, -2.597659979803786, -0.8137646997124577, -4.068531628279975, -4.15685302714719, 0.39802242918305425, -2.8521697885686517, -5.213185410968916, -4.406109219141294, -4.31113960114789, -3.3896647566356153, -4.3249114631877745, 1.6534575217821896, 2.7465154721993743, -2.7344216956388805, -1.1272795760468797},
    {-0.5224382236036977, -1.6558822102057615, 1.3393050977865528, 1.8693525787788092, 1.7324293668924677, -5.215020116441314, -2.1431483227684556, -3.4961889192973272, -4.971003776140669, -2.0080039303525288, -0.5052006972254081, -0.5864318376346487, -4.052512736275018, 2.035719796959956, 0.9517532893170687, -2.5268109478340803, -3.2536064541502356, -2.1009320944957097, -0.09228181280172526, -5.423127799509932, -4.086375070317954, 0.38581063170797064, -1.96227622727247, -4.864492826986324, -2.70344892226319, -3.0225987734570294, -3.436429657380141, -3.855916352732158, 0.8477677067576368, 1.8268020098175195, -2.348507616107996, -0.7730881136481322},
    {-0.3551189785148071, -2.615929034249441, 2.805537155541681, 1.6233645861334893, 2.0011564518309237, -5.570995677619065, -2.1615552600646866, -4.694144240792427, -4.838076462735228, -3.623173101273322, 0.7393298741456957, -2.5383725149267917, -3.4792414145156556, 2.445446542923173, 1.9585463074416967, -3.2023839430514647, -4.9755260477140855, -2.8418304477167053, -1.8857637993851089, -5.462320805754369, -5.062799692238013, 0.7492019277259938, -2.411142663626575, -5.139430622766103, -3.5442622647898814, -4.729016108573212, -3.729565836543501, -4.728650924139682, 2.222642645510744, 3.317101373441747, -2.6872826444111464, -0.7411729662200727},
    {-0.4816075529834801, -2.661955932563397, 3.484126711825156, 2.105659537625485, 4.26755857034798, -4.49824696234265, -3.4283285685901723, -3.2832797821077864, -5.0861485202913865, -3.128163709657775, 0.9903292076776435, -1.646170929007368, -3.8626861336689435, 2.1659067392253983, 3.00032601194594, -3.4159520565764647, -4.436190486025455, -2.823961962031137, -0.9992315943701867, -3.7897816794899515, -3.3459168334327107, 1.5755377341393175, -2.881101338345464, -3.652244828808036, -2.50670368003412, -3.9286268951574095, -2.6456813111415562, -3.726148240709336, 1.9332868179130116, 3.98616585171692, -3.226602918428878, 0.326308478540885},
    {0.2380404009564784, -1.0155736494477516, 3.709844849878893, 2.8703753790442983, 4.962570729697532, -3.078696122106758, -1.4224708203362957, -1.4330315039773365, -2.0208524076059065, -1.7446023032996132, 2.0889379607282446, -0.7507244054812402, -3.390859219986015, 3.199329968095876, 3.7967347429692326, -0.3303155056188678, -3.7625123138035255, -0.8121276893045531, 0.16633718774106343, -3.2775542811877254, -3.2608854952161517, 4.507228390874046, -1.3721693459552589, -2.8163296618915235, -1.4981688560164208, -2.1470164568108534, -1.1134712667231592, -4.250967362621863, 3.277169511387796, 4.383213664442496, -2.0870740489031014, 1.589295522802773},
    {-0.7673044724797055, -1.0678322359580785, 4.603692949292952, 2.493207751730297, 4.275253518998848, -3.671018923996939, -1.4679578938723263, -2.4025434783918507, -3.6816113783676934, -2.513522031049572, 0.5498878246935719, -2.2909585274167417, -3.1463163097512323, 1.7123273451993755, 3.881468803064938, -1.5300566860751565, -2.984719004188393, -3.2144529918048406, -0.4845253064779155, -4.210044441614813, -2.2287196498392916, 4.035162005200056, -1.1963365012307423, -3.902158880370466, -3.7629427239445534, -3.1792748547741683, -1.4184969926936204, -3.6513997853087834, 1.9769491571999551, 4.330554308039845, -2.1980877612979226, 0.7958402270212886},
    {-1.0670656413769741, -2.8731673221758918, 3.7897700302571327, 3.777557346926251, 3.1701238837583605, -3.7444359127673112, -2.329811562089506, -2.841875838773204, -5.018307002901651, -2.5407319589408917, 0.6383196396820319, -2.531651107183214, -4.562794709303726, 2.754882505339689, 3.5186679326334467, -1.445615912281601, -3.752071676822604, -2.6676263482237177, -0.8986046581707408, -5.504615596934664, -3.961455610673198, 3.0403053794680166, -3.1177780384529896, -3.4824385030771143, -3.4640473322737044, -3.9233036337406832, -2.3772744941192467, -3.8893388145525107, 1.3605552421543228, 4.230345226710089, -3.414544513982338, -0.9528209747361577},
    {-0.19152567550730987, -0.7098242066033308, 4.6482060144763375, 2.1339324693841997, 3.1756197508642052, -4.0343183366901725, -2.8801971652063862, -3.753072425573749, -4.0037377234252105, -1.572869398934561, 0.8220216138126774, -1.6363577865228227, -4.917669508776799, 2.2662075531241213, 3.848291545085607, -1.599361801828194, -4.126208759317244, -3.251608680563743, -0.5023869037553013, -4.537401709334371, -4.053868670010501, 3.8785981877770683, -2.482814032833319, -3.239888444620394, -3.5473179488691686, -3.545532072415737, -3.7221218708391874, -4.93297201146708, 2.41310077802401, 4.2252382415480465, -3.935130108645321, -0.029932775337578536},
    {1.377243687004158, 0.29324754253505264, 5.888365253167644, 4.222328455996137, 4.150317528532651, -4.063970698604617, -1.9678360589178676, -2.4754063351404296, -2.4788876997791003, -1.0609308123772643, 1.3441260160936346, 0.421406622385477, -2.501034082606946, 2.39001310681456, 3.664217409246094, -1.9199423374913867, -2.577429946627436, -2.6831202967061643, -0.19356813024657793, -4.321340117424543, -3.9734996051280045, 5.263750825966491, -1.9304675993040912, -2.7878888996733284, -3.402479113693766, -2.0421169930068652, -1.5800897872718795, -4.013472968707254, 3.008045810476678, 5.415218685982697, -2.1848967771251457, 0.8198802553764218},
    {1.4602770989513125, 1.164562316102928, 5.342525722884679, 4.840580960673951, 4.695542342206226, -1.65027947578527, -1.1587800478150427, -2.037837381553867, -2.5045715490344347, 1.0482800586135532, 2.2591071338336595, 0.9063557840328548, -2.435599579658382, 3.832071713766986, 5.2080571708923316, -1.0444671302577444, -1.697593762037012, -0.43903286964551913, 2.006454177077108, -2.4296155972110425, -3.1892907120773297, 5.033952368394509, -0.3865640692996232, -2.447869049010691, -2.0364026858025057, -0.9142017717331112, -0.80763116104552, -3.80082644066085, 3.1452495834510437, 5.340624939929309, -0.16790310803351033, 1.8893157389515443},
    {0.36873831434664905, -1.0333122538838557, 4.557355833277135, 3.688092407465615, 3.230038710403382, -3.0328576815515333, -0.7912359746211023, -2.5316266391893474, -3.4462304964264603, -0.033494874450828244, 2.10392217577605, -1.0898202474444492, -3.7472758148935568, 2.5333879869254905, 3.1783746831795825, -2.0241401967335615, -2.9202023829501713, -2.540510696387809, -0.3584401793462923, -3.888193967131333, -4.03621965489626, 4.407486136939667, -1.5421449941065348, -2.53026944449327, -2.3881814606500154, -2.942276821487806, -2.794480733699088, -2.700691682072286, 3.056180142169003, 5.352688500096766, -2.3375802848673857, 1.371263462903792},
    {0.4887706764833992, -2.0130898699919135, 4.266088870763891, 3.1400912889228616, 4.451257609420243, -4.679208165831992, -1.2490756297459522, -1.9455620721182432, -4.53132497190427, -0.4328826668374332, 1.139356217005073, -0.8226465522120843, -4.652599204870123, 2.834632088565343, 2.082033057914652, -2.2885132013425618, -2.4774118343488682, -2.1281789138993537, -1.1099177712870503, -4.480680079650695, -2.99408314722741, 3.791880256903851, -1.7741388217242924, -3.2129205098686406, -3.765092432906173, -3.6987439230856074, -3.480300204164003, -3.6592736401899364, 2.0780130681242652, 4.801867977169405, -2.3824410605799695, 1.693099641448412},
    {0.6726583282055832, -1.8765971782429693, 4.835366210407901, 4.212541112401055, 4.432912567024593, -3.2536053543955865, -1.865119566066028, -2.2116468601537567, -3.66419605922888, -0.6180142838426529, 2.216841237437758, -2.0808399764271335, -4.264401255357522, 1.845265578203224, 3.117982597539794, -0.6465475097938251, -2.5443194456094873, -2.4001964855268705, -0.17542737998521402, -4.22996235119859, -3.8320201978208916, 3.203408145331143, -2.515593080669556, -3.1586207400010706, -3.3044481712383367, -3.5379589843001464, -2.230781260426954, -3.1129767615674475, 1.5997881579805762, 4.334740401571791, -3.0678471333423722, 0.45710294153614706},
    {0.9195516794785038, -0.2846595929385834, 5.050305392113996, 4.428117298846772, 3.89628075847554, -3.980576867874574, -1.5580183142406618, -2.6594938185701964, -3.6406583345781893, -0.5249516896894247, 0.9209204395687183, -1.6413716558300289, -2.8738762921251912, 2.889976656712512, 3.8526175048029203, -2.1932793565324213, -2.251323157362122, -1.3136569761651982, 0.7431437373668187, -4.5770414524272605, -4.009663057339053, 3.0469093384585753, -1.9083808787468683, -3.1583715132365944, -3.246568395432371, -1.9676118307538042, -3.0150771679694457, -4.370504157372106, 3.6544112975723317, 3.767616170807435, -1.4838023117680799, 1.8130387557741963},
    {-0.25677659878949094, -0.7940449631120711, 4.054154663490068, 4.4599262218050395, 4.822205875138824, -2.7347544594920308, -1.3131971479387563, -2.8586592150113628, -3.612982748733909, -1.448253378035618, 2.2877127364922285, -0.9533545151799381, -4.657425648067971, 3.621528944484545, 3.4577003396554304, -0.9104406983582797, -3.8360379371788, -1.6652599609520622, -0.34559180893102276, -3.978318441995314, -3.662455634705217, 3.784187165480939, -1.2438724871975972, -4.3018735422029595, -3.568280697202677, -2.540602519423099, -1.8022955857533125, -4.404546342278169, 2.439042256705032, 4.798251279251996, -2.6356639902890535, 1.3220227293957163},
    {0.7737765965227955, -0.9224071586079496, 4.1413409826976375, 4.4281142310259165, 4.14286777589681, -3.2611326470375714, -0.9971669534579506, -2.347172822763005, -2.2781370432266925, -1.1444421578970643, 1.9294520567884965, 0.021357661611289637, -3.949008565305421, 1.808952498017767, 4.320249906964135, -0.3358061129252586, -3.6317249633320157, -2.277807593154375, 0.8002694699944025, -3.109137791404519, -4.1042969293000775, 3.0426030843434235, -1.7641195911389154, -2.1964091464056272, -3.4762003793760297, -3.819317894928791, -2.3550542412342743, -4.577821389796464, 2.2142308831502384, 4.959855450047021, -2.4651448842784123, 2.225622261353353},
    {-0.025140413803314964, 0.5151503719851239, 5.1116801439143424, 3.1819949239728613, 4.077221416002096, -2.8965484987245276, -1.6149640895074715, -1.4851583277425173, -3.9437798599397946, -0.9920438903130976, 1.1107662737032507, -1.0338470631030272, -3.807429337366664, 1.8875621548035137, 3.682727934110627, -2.255344734814659, -1.6053113916992072, -1.078529931047061, 0.11537505671693155, -4.322854159970351, -3.5272417051258227, 4.20630980232579, -1.133995407504598, -4.038269625693979, -2.6583536986154255, -2.4437091052056035, -4.016334931739021, -5.0244141589720686, 1.8014795408419961, 4.840370987662031, -3.0379009087309297, 0.6824883312339888},
    {-0.32419672543508754, -2.04306117187759, -0.26722740713421067, -0.5098210437923897, -1.0711504189259264, 0.8378666953652077, -2.255702283977772, -0.3405139711153079, -0.3328776037468102, -2.324538300164133, -0.7825646413511782, -1.587205998202952, -1.2178526913677, -0.7626777043636713, -0.5297854406926836, -0.837774166951334, -1.132007189300399, -2.1413720336434325, -2.0149886230691667, -0.5669849067543193, 0.523960010676153, 0.8059892359312085, -2.9139608296667334, -2.2242093179156366, 0.06579019787663101, -0.3743174841980507, -0.2452746634612316, -1.748796834483983, -1.8059523623700569, -1.125686074864487, -2.0961109771461435, -0.7031443296693909},
    {0.9829380689351129, 0.9468114294375107, 1.122025440306477, 2.5361485942450015, 3.092437162136798, -1.408275501691919, 1.4258366784682692, -1.8315590264746324, 0.3491623248211665, -1.5888317753734365, 2.1442882668762224, -0.41105041128884423, -1.0097098773322306, 1.5555561417546695, 0.9188086361195523, -0.9406274219635334, -1.206731412642992, -0.6025719775145483, 1.079125152780691, -1.3474523682877644, -3.0826275187477314, 1.7219117936170054, -0.9419530377074634, 0.07253512746800958, -1.9323757510298358, 0.6775748332546359, -0.2805853866133616, -1.5429483630615806, 0.676353311677254, 3.203702409259734, 0.2915321971201451, 1.5834147798169536},
    {-2.154022348759969, -3.6229788099865443, -1.2754295371466817, -0.3850953461120041, -1.986524476108892, -1.264286985499444, -1.643275799902756, -1.7987747513990922, -3.2413530432335196, -2.60401664063803, -1.8141282924773172, -2.7833181673704703, 0.4260464999767934, -0.8381354683669883, 0.5065759403039666, -0.9493463058331076, -2.727723701090708, -1.0724983032099507, -0.46822246400461154, -2.1583645481131635, -0.3533711376757462, -0.8892646251100672, -3.629188954480143, -2.7266922958487494, -1.9631361237734217, -2.519007799417848, -0.13231615039005556, -1.2301719677298841, 0.6359843922569012, -0.04954832319518765, -0.8581874735088293, -2.2876902220557396},
    {-1.2146541711251537, -2.6199664706077845, -1.3251018237666743, -0.38738543566885636, -1.2083197495448852, -0.8828530054094643, -1.882168163752817, -2.2805010348098307, -2.4669558417575987, -1.0397454120895493, -2.05275160653143, -2.468748935682989, -0.8106077208719242, -0.36310300105944, -1.8859516230926916, -2.6001411844773825, 0.10179158439149125, -1.5000404098267108, -1.3272320272449791, -0.9676231337378449, 0.4203022273997231, -1.485668114124201, -2.3499532858046654, -0.36733472839657266, -0.430361465603273, -0.08920763935718959, -1.1822018678293111, -0.03763334431791899, 1.1384358148374507, -0.7468012976353047, 0.16018384146163422, -1.5109582043442784},
    {-1.0933613837779284, -2.23723180748613, 0.8159661323168536, -0.5887557768943805, -0.7048402035409393, -2.449480791010994, -1.4543668753108108, -2.9969450376198283, -3.12980354414575, -2.359678775121885, -1.7364415493679393, -1.115401786406741, -0.6175746562559916, 1.3729536716845907, 0.6826842176050207, -2.04054801328593, -2.196837610032252, -1.3671337965647223, -1.1233123431838181, -1.0389109248418227, -1.0668330959897117, 0.10862319678419913, -2.797442221010928, -3.012723105863032, -1.6322978432909725, -2.551020938893591, 0.1873438000524997, -1.28989351182236, 0.9732735491814469, 0.8485016149281962, -1.9222196309297306, -1.4096473646901093},
    {0.055647213644433036, -1.2243424050173632, 0.5808382838302456, -0.5404686495180555, -1.2535017063995253, -1.436449002854072, -1.5055422452835387, -2.1593848155638704, -2.388485152881452, -2.9038270406706097, -2.9068996919705383, -0.5003707415381841, 0.5336006297799325, 0.8158864415013686, -0.14010165574854472, -1.358368365530746, -2.58120838781905, -0.6756200453901201, -0.6897637639418177, -1.951116370906924, -0.8411878256052682, 0.5484273268014567, -2.655243183631249, -3.040952361808471, -2.666788919682935, -1.901283933782221, -0.7488467979286975, -1.1289216603556194, 0.7610280625047758, 0.08259140463235258, -0.7403679252558742, -1.7855608670858898},
    {-1.7346278284045606, -3.4741509354955413, 0.7792131126910082, 0.48121643704884914, -0.30492198560966033, -1.37292483133785, -1.6632756231327943, -2.1946558345327425, -3.0639378325726896, -2.2845028676338934, -2.5976396395846937, -2.2361680525861134, -0.25470037275647156, -0.32552964232555354, -1.0379965123664199, -0.9256784030839306, -2.7699567009902824, -1.8715480258079706, -2.0474048346961666, -2.0100636745741376, -1.068990246074617, -0.32541520722069506, -2.790105091520965, -1.9774068646957752, -2.047862804380373, -1.5306214824113016, 0.08598758973238523, -2.3328570055428735, 0.6465380363580647, -0.06134965670594747, -0.8849967717917177, -1.7923288772983244},
    {-1.029311797918071, -1.2351344599904694, -0.13882410926518393, -0.15373829230581662, 0.06261888557002368, -2.540894540898793, -1.6736271768068187, -2.319455549491306, -2.659957293757534, -1.1715803908912281, -2.0379776552360713, -2.3472541701615093, -0.9447688569434823, 0.4353664494653666, -0.8888434947455137, -2.8323131521003466, -1.5558819779240416, -2.277456353303056, -1.5971327897412273, -2.7127070632985877, -1.000585880445632, -1.4420754853552753, -3.1244059720003783, -2.5955953952166246, -2.086127075311149, -2.094171225403769, 0.004391742301802927, -0.23407557467852128, -0.6396647173450981, 1.0698519752676139, -0.5336997027991572, -2.8520397983228003},
    {-1.9484579436760054, -2.643761408451863, 0.5040914284601852, -0.20800088866825367, 0.8870661485365713, -2.094287543398894, -1.867166247086345, -3.707230368003227, -1.6639545084889986, -2.2417787875008486, -1.9646666777056452, -1.468328109375091, -0.14116914802206887, 1.489975519238662, 0.8984089409065322, -3.542933959945297, -2.6279945088864265, -1.9485800528857629, -0.4470089853527884, -3.005565801444371, -0.5583582585266674, -0.8645763532041598, -3.42742688688942, -2.5769508152560645, -1.2351149899072835, -3.029026638805415, -0.017726877764401936, -0.22140940884164623, -0.3750365361844624, 0.5700805603639388, -0.11313519495618601, -2.4045944291383567},
    {-1.4303290508469957, -2.5604631299420286, -1.0414413676691425, -1.3237252583152013, 1.1736655923567831, -2.8792154280932025, -2.6001497082355094, -1.7089547342801523, -1.2272916791468618, -3.7782821410225473, -2.4881399823541797, -2.6867576738428895, -0.109428743991685, 1.3595446547923542, 1.1602395579765663, -3.0634597640685253, -3.4206377799498493, -2.075560115035187, -2.2974181231502793, -3.388484163092556, -0.973408860096527, 0.21337240371916305, -1.794565695268963, -2.457965635714657, -3.2276943040894537, -1.945696362057765, -0.45474627066891654, -1.7453549155755959, 0.1936347292440261, 0.9364064024358874, -2.355776422812293, -2.3883715824488627},
    {-1.9095358911732345, -1.3905193311121222, -1.5160509494202938, 0.04663369450170394, -0.3842262211643941, -1.117015263810467, -1.9338558510051833, -2.038176605209516, -2.1026969877368895, -2.8358096819723255, -0.8593809594030778, -1.062651735556552, -1.3803339033623556, -1.4651055797403856, -0.14130743258484466, -1.9202652187393308, -1.4876018340957076, -2.528856875629647, -1.3307718791746994, -2.258718684626777, -0.7855131427300437, -0.5089312337123961, -1.6007628052742353, -1.587984049368165, -3.4436708896648627, -2.8105838908326266, -1.512937109818514, -1.7289042301852355, -0.5756166922766632, -0.6778829408747994, -1.9135917043648463, -2.7336389741802356},
    {-0.9183901778799867, -1.9428693695725585, 0.07482438301032525, -1.1815190298948353, 0.23936900478604473, -2.0609085528123465, -3.54232085549761, -1.7019007223738774, -3.91424702273739, -2.4711128629934604, -2.552645955806961, -1.4344894499778853, 0.6478145740408457, -0.4260157885428203, -0.2066565522418912, -2.868614094192226, -1.725359361014373, -2.6475031379659706, -1.1830799112852257, -2.3383854853578985, -1.1944617827569832, -0.20197921947341302, -2.8722092553334146, -2.7116067877049623, -1.6913330494340995, -2.8227188435210264, -0.11084816730981153, -0.6722989697653584, 1.0071768450322216, 0.021628451308251178, -1.7215582178505233, -1.8697202012726464},
    {-2.6159004922471145, -2.6694577422641395, -0.13577400131773307, -0.45592767574562265, -0.23450351217815044, -2.079827440455949, -3.2220467286647665, -3.7034858265345543, -3.9044733515937926, -2.9680438496086157, -2.3740344518752488, -3.1664842166295712, 0.5862517205818942, -1.013779413067982, -1.244287433183474, -1.7355299090451601, -2.3173819616751454, -2.1970541618536563, -3.3626294339967258, -3.889056534100009, -2.291510946723522, 0.36418775258495345, -2.218691588238498, -2.941654121261847, -3.2095235826183726, -3.509527937242102, -1.1615564208272071, -0.4496887776888302, -1.0175085024521857, 0.28045332553641067, -3.4804428650579764, -3.5616056108936194},
    {-3.2610747419999, -2.611561818666952, -1.2961018087588008, -1.1432553570740565, -1.871217509211081, -2.0163681059923695, -2.1678825296151936, -3.0843282416078934, -2.3439758769018435, -3.827479294101915, -3.681003167859139, -1.7283078439557966, 0.07543196804816217, 0.019356965551337944, -1.0690448266164578, -2.683524846451789, -2.560327741510253, -3.3405052689856123, -3.2893590091772307, -2.6612653858274617, -1.6959611699860995, 0.2953136889580628, -3.327083448484843, -2.3672663461521086, -3.4675202228217272, -2.3501739908637265, -2.422783867603739, -1.3908851089067762, -1.5803197177631247, -0.7629801341939066, -2.418926228422029, -3.1139554157994342},
    {-2.5332932413186895, -3.777516488597399, -0.6021534091977631, -0.7049226390423986, -1.011929983659117, -1.9708723963360848, -1.507350144469213, -2.747316050547226, -2.331509309670201, -4.581761862900182, -3.025637917607792, -1.4392747223574696, 0.3557153084650102, 0.7775540096001279, -1.4709530749997024, -1.6724982430276112, -3.0492911162404712, -2.0876097176271764, -2.870449475032148, -2.3839418635403837, -1.8372317785082217, -0.4827203892709291, -4.117269118207166, -3.612819281856432, -3.7465262661385865, -3.679390200351204, -0.6326994657801449, -0.38721308404311583, -1.1220331053946537, -0.6698168280577635, -2.4673948885247072, -4.005537944397277},
    {-2.520002630237075, -4.059530123594667, -1.558979991637426, -0.692889828649823, -1.1147963921878299, -1.8700253493106118, -2.047587713371466, -1.7512418097837745, -3.673865866370079, -3.355159476009357, -1.9822439048717262, -2.1015876459355294, -1.3702543585600706, -1.0328520436772914, -1.1459244104690773, -2.408066553435273, -4.1739968767431845, -1.3638441440906737, -1.6349652051052257, -2.1005005398759775, -1.8465174252376584, -1.091347901745687, -3.729012227392795, -1.944550205254138, -3.466323271251512, -3.201255435381349, 0.1004207971412981, -0.3575298701260624, 0.5167203883146005, 0.29979563048260455, -1.1338872978049146, -4.124510990146055},
    {-2.7383479998906655, -2.8965393362540293, -0.03095641379798806, -0.24727792747825317, -0.0006125613820022997, -1.4734575818575946, -3.1612328968306613, -3.2451779251331856, -1.5220093988995307, -2.3105094084352618, -1.314046551240411, -1.4115775453240305, -0.46846567114066784, -1.0594197655124453, -0.8894697393699322, -2.581591017876448, -3.1003650747003855, -1.2498893780925606, -0.7112135426340137, -1.5545177422288177, -2.5172218000997475, 0.2507055062769589, -2.428038217131571, -2.1715144666806556, -2.0508797522471425, -2.4450623793908783, -1.0811145456502238, -0.6758400553267884, 0.6660020921171628, -1.3086092016529982, -1.3348695706212692, -2.5033927196015107},
    {-2.4059849110611515, -1.7992689691789596, -0.530663192124024, 0.7560623095767373, 0.09320185915892194, -0.9795841535625655, -0.7523731981335853, -1.5811700023409299, -1.9325473461574136, -1.962194748188403, -1.0933322559258, -0.40848942574500413, 0.5545001651151487, -0.9370316798855263, 0.3577850029039158, -0.5727684989481734, -2.653004837068232, -1.442805492518745, -1.0477875284919207, -1.1950770774246837, -0.31821204043149187, -0.17090097850000927, -1.9604703334211186, -1.320081535064829, -2.885637396693312, -1.4487180447806154, 0.5904750024756066, -1.3589142692051317, 0.692244328650908, 0.7599163566890951, -1.6219429896777735, -2.976213559392485},
    {-3.194639113483475, -2.7948443342650506, -0.4461053013658218, -0.3596397414650187, -2.013928392568915, -1.505788837836239, -2.9978718473550727, -3.1058234837286944, -3.209066279363115, -4.112970141235538, -0.8656185130884475, -2.8134851314608595, 0.3088526001856933, -0.380403447661411, -1.1116155022108758, -2.1052832860952915, -1.7803935728480922, -2.0245879475913324, -1.0033094566746446, -3.1632729519761233, -0.4506910424408632, -0.29039344840889514, -2.048038003272882, -3.168723966615797, -2.6126781866607702, -1.8950813019036732, 0.39285238952174745, -0.2584027512780746, 0.010459177240032466, -0.23023823116414996, -2.4052067281480305, -3.90216100938502},
    {-2.9450587418721645, -3.0141219139601985, -0.3900441478641832, -1.31351746733998, -1.7132198698791186, -1.3654603401222998, -2.7562423739224746, -2.711493291682384, -2.2566092801585507, -4.335088882662351, -2.1214469763449464, -1.5789781351210783, 0.1897822185882333, 0.5078723723143376, -0.2500330351033868, -2.822144265308741, -2.8256173919468215, -2.2443740968857324, -2.1498455476658056, -3.78509994796551, -1.0653745336593465, -0.5133034591524719, -2.901701951913068, -3.8893635230776455, -3.6002486584200115, -4.084853577727689, -0.25966511406177023, -0.8956369088196251, -0.957789896260651, -0.650030246589295, -2.9687347093484315, -3.787537278362043},
    {-1.5591175457571735, -3.5685459526625345, -1.360890977302087, 0.09126596045728155, -0.6833267068344941, -2.0796520751019485, -4.27828210453746, -4.371782447014788, -3.442537679771728, -3.1193679035805983, -1.4809957121909136, -2.976866680405317, -1.7439166046909542, -0.6922868204699213, 0.30234622285841123, -2.8095128480243674, -3.6322982452877675, -3.1411073239782956, -2.74337314506313, -4.295706789146227, -1.8399169463851146, -1.6540018580955933, -4.081144523482503, -2.7976781554273678, -4.244108269396386, -4.581994854067056, -0.2524627918231243, -1.2656378099535408, -0.6889273349999123, -1.4134157615621379, -2.6444008920690494, -3.6721200112523147},
    {-1.654744674529976, -3.5145146208889955, 1.82401912351106, 0.07677202612449835, 2.4147046376017793, -1.5679275635434218, -2.6302664586772946, -1.7883443624949367, -2.522924178185487, -3.118976201022662, 0.43092158306905026, -1.0795280684455908, 0.0840596643325498, 0.92104095635819, 1.1840603261358846, -0.9248301383718235, -1.568309564459466, -2.827230775780979, -0.4042491412647673, -3.5666836560574113, -1.9332572010459923, 0.8038842196054556, -2.8440088899625446, -3.0680787358292094, -3.456919684043673, -2.1545176682732317, 1.4172372811206642, -0.6578918363542324, 1.6064930759068774, 0.339776292123782, -0.6311808938597752, -0.88728620798134},
    {-0.13439903041106765, -2.3817240051300916, -0.2606352371715871, 0.038908254452992536, 0.6315718303019066, 0.925913460596044, -0.9223044528426981, -1.4859366685938917, 0.1907280838532326, -3.367773455029476, 0.2790154454108209, -0.6036979853372603, 3.1402299751844702, 0.5179489096427499, 1.046029300060058, 0.6040037400607641, -1.197623072398485, -0.8333153398476284, -0.29979825554160444, -1.378741799155062, 1.0109659109485005, 0.6189431555033639, -1.4792859135812986, -2.161706157287378, -0.40576575811076654, -2.3961032895088077, 2.3549550875160827, 1.7653048427736353, 0.9423997278125029, 1.3339663457983293, 0.24433246487056604, -1.545340216447256},
    {-2.506263741115169, -4.066039361258969, -1.8493341553925393, -1.1996049424293722, -0.7841363642503453, 0.012466656921694675, -1.5162670852026627, -3.193662021510276, -2.0429259129054715, -3.798928062084814, -0.42300477006049136, -3.158239048949171, 1.407280068430203, -0.6824535085615595, -0.6898460668438228, -2.0747189006614697, -2.3327163531152766, -2.5530247137190596, -1.7048930462166583, -2.6689169598947386, 0.0971036765047859, -1.0539170907552364, -2.985586369536738, -2.3102217758916037, -3.2449603768445097, -2.7485397170544115, 0.4586901400709399, -0.023285249300001927, 1.0928855255098593, -1.1519089736134969, -1.6009867852198671, -3.0409038224727496},
    {-1.871391177206357, -3.867201898899705, -1.2448621409489211, -1.7947681296478, -1.5677223693998268, -1.071323560577179, -3.6495959003263767, -2.999070725357909, -3.575397607310696, -4.807051581975133, -1.6229586815330952, -2.1133133027419437, 0.5510991360701927, 0.15742042485201238, -0.2692854796679182, -3.3709360413469334, -3.4172107534876637, -3.7109918127599277, -2.6138628503425614, -3.946709769257691, -1.390692774820849, -1.7855601183706227, -2.7649668975920245, -2.8257014707081125, -3.0693173406720744, -3.27920502422388, -0.898325298559329, -0.9392675085072422, -0.19718000209355563, -1.547510567113346, -1.8673007939454127, -2.7509216029501395},
    {-0.4509282667904023, -2.7287132363184585, -0.2950913054310295, -0.4876678817775401, -0.38383391549910106, 1.4069967392827665, -1.416891666808989, -1.5076073184446501, -1.9824492877586648, -3.225389390014014, -0.48975577363443046, -1.9485765004541769, 2.604544318643069, -0.21224849872007362, -0.7907998137329532, -0.8946818850041232, -1.2247901863095134, -0.766118383926465, -1.388303299234253, -1.2761512329090128, 0.4547300970896929, 0.8889540139524937, -3.5987553913712143, -1.3805524801736833, -1.1452816946819668, -0.8850404828253299, 1.4705715563542396, 0.5310272019311401, 0.22341479346142568, 0.13517589698106194, -0.23827439226017672, -3.65767699684342},
    {-1.5536549647092008, -3.969142739027173, -1.1321828749442486, -0.5018958025830631, 0.5301646441862793, 0.5423047320709595, -1.7364352438141002, -2.1597964640310847, -3.1339511491145204, -3.8085237167585917, -1.450706093646416, -2.678927617133848, -0.19656586474856896, 1.2440990349927559, 1.1452605534982934, -0.7958249791555689, -1.8545943765654598, -3.2066080830350456, -0.20336074149831093, -2.585833727436893, -1.0193975439508904, -0.006657820435686275, -3.3968067813172045, -3.896074058572569, -2.7389262088367086, -3.434255141124242, 1.7686306759045805, 0.8233210207389895, 0.8491241562169383, -0.8052696208716031, -2.1510851389117245, -3.7251919507522113},
    {-2.376360047363145, -3.2409107831442996, -0.8531345550771106, -1.4701534048459834, 1.024452865855175, -0.5779017604268993, -2.1753431717978082, -3.497727070738643, -2.0515711507198144, -4.170175089480335, -0.2060046711080359, -1.9811287352905014, -0.6398297323259882, 1.3158159734802632, 1.1848960701656976, -2.6113469723721856, -3.047986203780412, -3.421821461065399, -0.9949770673223741, -2.271569074963389, -0.012767621179877175, -0.5358528500313984, -2.6811320232196523, -2.28250473699625, -2.92167743712679, -2.5861118299392567, 0.8621526441333928, -0.3532082566534478, 1.306111348192491, -0.12598605798934878, -2.401154867005755, -3.841323563420194},
    {-2.2474881724632767, -4.877821961640239, -0.744708766026083, -1.1950194058649064, 1.1121473497449799, 0.009011943980349333, -2.5497146232445873, -3.1868562529910287, -1.467397667031372, -4.7990226955004465, -1.6700578840663771, -1.547686591112096, 1.6576578347229451, 0.7597003506154065, -0.6375518741922156, -2.160928463163351, -3.882549942426154, -2.944999032702816, -0.25525247193216594, -2.6630696540955214, -0.8248668144926762, -0.5544838136719354, -4.016960975463074, -2.2013861711983025, -3.0136633121106664, -2.1925588689943156, 1.371080125433884, 0.4109995398252824, 1.0714117656062425, -1.2802841062641983, -0.8556712175831981, -4.396799937424476},
    {-2.351734206665375, -4.278824521557298, -1.6502188246567357, -1.391251798897149, 0.08661336053497705, -1.0724310070947243, -1.615658353847759, -3.0076951509130456, -1.720691827675858, -4.354142802651249, -0.33990099198780976, -2.143586002206399, 1.209153476252612, 0.7990603297735626, 0.7692123366182918, -2.3312003129808208, -2.0610725267879704, -2.8542977596119123, -0.584886602669091, -3.925124161685774, -0.6980752156752168, -0.19718924065589483, -3.744260940380419, -3.3823388383214463, -3.3364705708010103, -3.751253079225453, -0.47163749808931044, 0.9592815062517186, 1.4838145529865705, 0.3997970364223209, -0.9077067707469647, -3.961610151635823},
    {1.3482560494600964, -1.6956646575593652, -2.3448135207545393, -1.4085022970386547, 1.6552604157362456, 0.7029216691728549, 2.2155366244635646, -0.6546994427637308, -1.4596739278317423, -0.6309580116286135, 1.0098365266037632, 0.21903019553430872, 1.020241514714993, -3.204214269680442, -3.18930104588089, -1.7292274757814954, -0.09580548017350582, 0.7361190789372257, 1.0627787471552945, -0.6307608149157845, -1.1368308644485783, -3.0485824688956495, 0.6606053436003144, 1.4459748819227962, 0.4315066467258289, 1.2086183992695103, 0.39738915776365136, 0.9970208066564122, 0.14339201460427, -0.19339367069925578, 0.5450384647042251, 1.3142791853659264},
    {2.3636811647062252, -0.9934423792324026, -1.8880670113304139, -2.0319732562177912, 0.8908708533490093, 0.8816445786170937, 2.7466958360034073, -1.735379010564339, -0.8514828248677805, -0.45755448147390765, 1.3960860287232515, 2.327685107945629, 0.42888451115137377, -0.660531018045875, -2.5911327071806056, -0.7134461853468024, 0.8745332362655108, 3.0115745839172976, 2.8640295531055573, 1.282893177062602, -1.4095189605661946, -1.6104808867600977, 0.0838741316388377, 1.7394491481574945, 2.167687962451131, 0.35602021265860584, 1.2822763420457992, 1.0875917670575272, 1.4744518018174442, -0.23602623067306294, 3.0473488868200307, 1.0597585423257205},
    {3.358136315021308, 0.35364716753174036, -0.9944191717615483, -2.2475311225608148, 0.039954989443671284, -0.09323656252038039, 2.323230977168986, -2.9697963867071175, -1.102653015533253, -1.0873152100614973, 1.3643592081269775, 3.7584984625854565, 1.1437982912786897, -1.4826125425368457, -2.4509685157080177, -2.9805860706539975, 1.3238458054583035, 3.595791021401781, 3.9504225718363974, 1.0662450330383946, -0.11663515590157904, -2.8100488731916946, 1.2209741951606308, 0.9936703178302897, 0.7556948109748848, -0.08653033683203316, 3.037688653531042, 2.405635169708698, 3.54382402507197, -0.25363077960358965, 2.0369680375625916, 0.7111994996210347},
    {3.570531860632622, 0.9541563874300917, -1.6574833733717578, -1.2987627500355252, 1.254027681251881, 0.7705010578703032, 3.273040144322837, -2.217986638533127, -0.7469200378860791, -0.264773713998514, 3.136225963895907, 3.716013568617546, 0.9518087286485444, -1.5811622476492648, -1.2575675727253002, -3.2414640465726943, 1.3422858499074921, 2.1232363866295456, 1.6551327523258432, 0.1410129130562112, -1.957521023880399, -1.9127895049875467, 0.008468286225516583, 0.6093145155752269, 0.6455045986167461, 0.046908965748652436, 2.355385177952652, 2.2079665313987253, 1.7809521038606906, 0.07281643343658205, 1.7117099137164, 0.46784054855318125},
    {3.6362777420520738, 0.5794209087625602, -1.543338870587884, -2.2525717401803163, 0.025271188932479212, -0.5469645416870837, 2.407848769380317, -2.5353368600404576, 0.3893415084229729, 0.9831817097156202, 2.166095707038969, 2.502103186944136, -0.5889800629691319, -1.6519423205119785, -0.1214153214826127, -2.9776212627594996, 0.37404841254453736, 2.2697207820455785, 2.809246018085117, 0.11825447883170273, -1.628510171059438, -0.7402819448977022, 1.4564636480898348, 0.7731832890661396, 0.9602251216489672, 1.2206291972544352, 1.3600935089514306, 2.191810238911877, 2.6421909438014852, 0.5458975672462002, 1.564318828885794, 1.3943745411189719},
    {2.2060905639943935, 0.4712044412377217, -1.8625181698364581, -2.736404768356265, -0.8678659268809193, -0.5178293616551615, 2.169388645660052, -2.7700620899435737, -0.8206806276569758, -1.7287726293507273, 2.0012762263808863, 1.2141660579782723, -0.03333368214390861, -3.10124049360155, -2.6612362962388287, -3.9541270132393067, 1.1483142760806724, 1.1525818287491736, 2.797335057376148, 0.9048830866024157, -0.6377308183578524, -2.895345584826925, 0.6364486279958612, -0.29755045282745135, 2.1958329649994375, 0.027569967092994415, 2.860621153930926, 1.0371046844968745, 0.8406485251986762, 0.25975415139263225, 1.6692743372604035, 2.0561903856324206},
    {1.1789364162489269, -0.560420348337823, -1.280230407401324, -3.3853095323146287, -1.6418344637734599, -0.28979145881539686, 1.77771650573992, -2.5350377201122942, -0.684803240403793, -1.78102827223693, 1.2875277655196113, 2.6581888800478115, -0.7671963288219333, -2.4120974722101964, -1.6531752375032776, -3.185741465571854, -0.6251366288663732, 1.8227312986781685, 1.3720889874872142, 0.6578336916489713, -1.424283465953141, -2.1763732676785374, -1.0393542756076963, -0.42788592082710886, 1.26963747051249, 0.4947496298609468, 1.7865345194501145, 0.5049985987204035, 0.870965639225585, 0.002173019817194942, 2.1864700580934695, 1.7751759569416647},
    {1.4563389265144515, 0.23154034074457713, -1.9474674446838294, -2.4085473932153634, -0.8641275927492235, -0.1787102871748401, 2.1711634612710253, -1.388298260264153, 0.2534648807064635, -1.7204044293558554, 1.810460695242905, 3.0036351784363005, 0.3386290278053861, -2.585435295265744, -1.7531327178603011, -3.8628517095044406, -0.7054007691034312, 2.5649685658379693, 3.422109877903083, 1.310618911232471, -2.132738620634822, -1.7342793188983197, 1.4972524314594926, 0.5524035300194119, 1.947141251891708, 1.5353785094806445, 3.3945587316508785, 1.9704130024877626, 3.172038097047089, -1.3125980903656238, 2.316113488949332, 1.80082750157774},
    {3.3990239908932223, -0.7997202736605857, -2.34518754990862, -1.4720124457380364, 1.4261515549928232, 0.7892512736563875, 1.912118035671373, -1.438638956175493, -1.4476377980657436, -0.7961814529345759, 3.2344121470240226, 2.2969355958105404, -0.4390525968870493, -2.389073353125917, -1.7792431477712254, -2.633690218149319, -0.6050822102676926, 2.808740717379868, 3.916085189839244, -0.6857397400951369, -2.3480824152302993, -1.0174281169163066, 0.4114938096178134, 0.4549228988665666, 2.059968655357813, 1.8131104950189307, 1.2823293213695892, 0.7582135003006, 2.062183318565784, 0.7132314511110712, 2.3020285525848156, 1.980496427270741},
    {2.0620226582136283, -1.7256613452089253, -2.0837823135268017, -3.4306372762623383, 0.784700218630797, 1.172634767068901, 2.1688238021655977, -1.4267915564225673, -1.445753003824872, -0.1916500020736013, 2.05284889821552, 1.4473045990326108, 0.8332052283281729, -1.9909995461613326, -1.4971735254561782, -2.328202366444789, -0.9219521365151555, 2.723644078962909, 3.555999910779748, -0.3652433158892684, -0.7358602358435363, -1.9479933122267978, 1.0441622784565918, 0.1761969139744947, 2.789766802598557, 2.2682634703422417, 1.3182447061000777, 2.235558057321632, 2.125011769481231, -0.22133432693956445, 3.0323471045312007, 0.8654513990029183},
    {2.6056285178728626, -1.2930128903385045, -0.5329087414200038, -2.6576434631321453, -0.09082078356722555, 0.8840979344557232, 2.6540354511115893, -0.8732022865665399, -0.9101014753582461, -1.044616954220165, 2.475353621141977, 1.8556358146399423, 0.6354874455814661, -2.449137539267767, -1.454757119083327, -1.7346876887459612, -0.07004227813621822, 2.8573191498780472, 1.4822602564499534, 0.7139047559176588, -1.3645921755904442, -1.8525774382272766, 0.20371453597109626, 1.5741030286300397, 2.0657482435445864, 1.6181896486037377, 2.561266213945199, 2.8683716869604132, 3.5137202883906107, 1.3941376702862984, 3.3549643075369935, 2.1893094845409378},
    {3.373899656336351, -0.5945454920971811, -2.325611703403917, -2.866865219795903, -0.24344023390321223, 0.47198282250842793, 3.2460295235559, -0.9712245036804946, -1.0990242034742186, -1.4043497211977578, 2.9169625275646416, 2.9835689563319034, 0.24257731801577595, -3.54414349349302, -1.3183139403617368, -1.2777444475117656, -0.40763879425998073, 3.8594989502417905, 2.42747786907012, 0.8635111313883866, -1.872019379665475, -0.7134997471613516, -0.023816451371775488, 0.392361000910481, 1.0780255950505222, 2.092985353626248, 2.496391297768391, 2.83621318558708, 3.1700416756760514, 0.1784204907057901, 3.357221521675287, 2.230948628607933},
    {2.973400998946077, -1.68444773548544, -2.157267317828726, -1.9495271776989005, -0.7216431220609157, 1.1076065558731172, 3.1121525436367214, -1.534438912191282, 0.026575303901387272, -1.412750767213086, 3.255526650869034, 2.145725512717434, 0.5794863818648074, -3.2818257241154383, -1.6196191265288382, -3.2567475351744033, -0.015149835939594708, 2.5488128745867558, 1.4613293503136962, -0.122605916357397, -1.7717353070973718, -0.895139961434665, -0.1563169757880004, 1.8628756423044182, 1.6011546074497751, 1.3309553835032177, 2.1047279839743367, 2.0975941705789416, 2.905803862396628, 0.3499488143074424, 2.998515877763094, 1.1897284763098743},
    {2.3514256570977015, -0.4911109160944605, -2.5680172791330125, -2.8215468979698266, -0.4922950006314937, 0.2674340965091477, 1.7161921595008847, -3.1565949624051632, 0.1953907755619048, 0.34219468876414993, 3.7314153486846324, 2.887749471692917, -0.2573900751272871, -2.295736409126599, -3.3807003651164074, -2.1427721113684735, 0.10072078666088932, 2.323483170910504, 1.5959216618308811, 0.09233746003342458, -0.5343512642690101, -2.385110064685226, -0.19949539996648524, 0.1510891100010358, 2.975396834058321, 1.1763123691449089, 2.526367563629397, 1.6726767183534315, 3.612014828942831, -0.021457328353698558, 3.356032291368095, 1.66177665645415},
    {1.9590185198493173, -0.9864573397783932, -1.1683713248318197, -1.8990153256117797, 1.0698259938794819, -1.0758391161606948, 2.83037815294807, -3.0963967727039683, -2.448797326264425, -0.5144638571302131, 2.4407154772105786, 2.0311352582447624, -1.4786077289897623, -2.3178607496367167, -2.9917081946585835, -3.2584532400869004, 0.7659040847620373, 2.424974242141235, 3.3377531976505828, 0.8396856577464913, -2.8152104540629863, -2.765339122514535, 0.17778861148770356, -0.10397936780338304, 2.5409450824328115, 2.2617772048315574, 1.8505993375966103, 2.325132561665677, 1.154016478272556, -0.4559123152266295, 0.92448099012598, 0.4667992885850849},
    {2.488461835051853, -1.5881655150073881, -1.2183342669086206, -3.443401835761624, 0.7664420313927951, -0.5998792785750272, 3.251486700907928, -3.095836721033061, -2.3853711965177338, 0.2421794315878362, 2.685493646852942, 0.8300241522188998, -0.3088130416585256, -3.473634885987058, -1.8280923543364938, -3.5957362931870165, 0.2607743629780953, 2.270012825729963, 1.9899331334897807, -0.17346303648947117, -1.0289999678581265, -3.121222839326956, -0.012462234406146487, 0.4224961934665715, 2.1006920724383304, 1.3229487266999664, 3.465964416762174, 2.8832924573908105, 1.7410660753154872, -0.8383138681519874, 2.5810410539815556, 2.023085946323275},
    {2.075015261611551, -1.2566765297023312, -1.0926985804509064, -2.905790411168653, 0.28405346346623006, 0.1965025733844386, 3.3441233749161374, -1.6529022784406662, -1.3035880527427326, 1.0000716284600055, 1.712021704087666, 1.4125266513386074, -0.7870646943038339, -2.59632465276464, -1.3384511289345238, -3.7677439564371564, 0.8186924303237938, 3.657047394650814, 3.6495163094634298, 0.4246125849717102, -1.7353754771869574, -2.3350101850004887, 1.385184551662374, 1.1698058143224457, 1.2059768311953987, 2.4260362338288743, 2.4147086004769283, 1.8150363653497918, 1.8463493964393045, 1.6655885058503967, 1.8066647120349129, 2.1860301056170175},
    {3.183400004747828, -0.7180050225515706, -2.3206974935681965, -2.3996598230140447, 0.16336818881136125, 1.4131931053415945, 1.4288529115552173, -1.548991580105189, 0.19346197402690848, 0.753783057174619, 1.943728382189413, 2.7911605795138312, 0.5948127597756908, -1.888074426112685, -0.9098938572347276, -2.7788052052611616, 1.1337922788791082, 2.639224398782817, 2.0228789238589298, 0.16416868122895217, -1.441998995803597, -3.1712064289366806, 0.6220316474415335, 1.9573538082524078, 1.5748082964270536, 2.033969252133002, 2.1021633984316317, 0.9305320593592248, 1.954600004274128, 0.5779617459676203, 3.5857623380836907, 0.8392329704153149},
    {2.8971081640098078, -1.317716713961093, -1.3620641934125033, -3.004863621855238, 1.6852041581822896, -0.46423161847614214, 1.4094460039825352, -1.8651617335798116, -0.2635140747407446, 0.1712194515191054, 3.6150497584767014, 3.118149804563946, -0.40038468050846854, -3.3331120109495274, -0.9840647817799787, -3.7005268646704135, -0.0762964348195457, 3.8141247852101445, 2.7783869186982044, 0.8720773827325387, -1.8350563308915726, -2.926389401415785, -0.6446839351455735, 0.3274846422361666, 2.9129197376339655, 2.113876340100074, 1.6810511798105718, 2.258404384943632, 1.570690708222231, -0.3401806186122328, 1.9810790717044457, 1.5695989916309872},
    {4.041917905069479, -0.28182544309065616, -1.1951632751590682, -3.411583973041735, 1.3994043807712957, 1.6494476207298163, 2.2730998487229583, -0.5474406863568573, -0.6947460818119703, 0.7981038608295283, 2.919477776874628, 3.2352806515754717, 0.07499093940865177, -3.551424134548261, -1.4402665987618173, -2.9105822939570984, -0.1948951590105265, 1.9365070130153452, 3.634779148281084, 0.8649931697698285, -1.2617593373783202, -1.760495300880252, 1.1805597519269961, 0.7103716105475658, 2.6796287058115213, 1.6611882252841959, 3.962855232411251, 1.2689780995787399, 2.373373592097195, 1.33969848494453, 2.548499993145925, 2.518856341738125},
    {3.334233654807303, 0.01219928943568451, -0.6237813852287224, -2.9088654503080775, 1.6148395412302472, -0.3662709078378512, 1.6957583024648368, -1.550631192090349, -0.48717562223133043, 0.4654015301468016, 3.469926552772593, 2.305970332866811, -0.6548260546182845, -2.7772209817877243, -3.15307182699168, -3.0903105706254896, 0.9133161752190078, 2.2519907402450188, 2.393313710612399, 0.5171142402444378, -1.983835027237934, -2.4987527622026593, 1.9147123692068295, 1.578292621258117, 3.1446767261865474, 0.9348852955503926, 2.5518829681878645, 2.6945338295819963, 3.1851465231687, 0.9486321818967961, 1.9566595853788629, 2.6178714277078847},
    {3.61909250889384, -1.5374593571899908, -1.0874624858627209, -1.5931350642725712, 2.043390941997479, 0.26245004264030564, 3.7524113870376348, -3.350366233704559, -0.8327400893819283, 0.6551236298583101, 3.3682236076254095, 3.1427418739954387, -0.09288011116301358, -2.301687271700476, -2.4270537195940376, -3.8375385158103152, 1.4917449757237418, 2.8276957608466593, 2.5037634032645726, -0.2127487011907194, -1.874342004494871, -2.504936280208578, 2.0685211479528363, 0.6423407032884314, 2.748145761273379, 2.6349065431806693, 2.6848905368096148, 0.9529531649120776, 2.757296163063355, 0.2943858518980772, 3.374307357151122, 1.0512421184154703},
    {3.4104908934438667, -1.0303947993760836, -2.0592524533994156, -1.909781865106693, 0.6430973711284136, -0.053432170762995085, 3.551716309306606, -3.359131940605223, -0.0483600182374007, -0.875065333480793, 2.736533390118384, 2.5480764158066376, -0.8054684138409969, -4.0562940893750445, -1.9821045413396363, -2.7075537712616433, -0.27993513083851956, 2.151097943556058, 3.0743468186801386, 1.2638545971939878, -0.6256101570010524, -3.961721122802055, 1.0033263898876228, 2.085430875701366, 2.667475688920012, 2.8217712685749787, 3.512583623946721, 1.95082548269814, 3.113975757435869, 0.5143144698123334, 2.4663026277544864, 2.020156951054003},
    {4.665748643058001, -0.8848813376294817, -2.3174158904624904, -2.9943859147315632, 0.4230720667695721, 1.1409512300498394, 4.167378103084044, -3.6454928446963026, -1.6535464531423278, 0.1535950734008751, 2.770371611297246, 3.9216209778247753, -0.7882331283468738, -4.622334659719011, -3.8938574208177794, -3.3172945770448075, 0.29081807102433216, 4.163096530285514, 3.7335218410683897, 0.873071657999989, -1.8129207624545955, -4.2327357622173345, 1.6900468670226614, 1.1966698008715058, 2.126683302224959, 1.8703724537555495, 3.935955595033075, 1.9319839748091767, 3.502348878537696, 0.1755241068772924, 3.4166437948629613, 1.4296839508717654},
    {4.562147338555914, -0.4261094225975649, -2.17856034978466, -3.0485597836620655, 2.3205785203249634, 0.011757034524668057, 2.87883882105659, -2.8096231481644205, -1.3654775254622948, 0.6870036837176343, 2.837862741180066, 3.6319292329368587, -1.2141693166335306, -4.151245718222832, -3.0553534366445505, -3.965401287583263, 0.24228742990830537, 4.029461443034896, 4.637432253749514, 0.5096118338833081, -1.2328615390736841, -3.8324970333387145, 0.8360104032462771, 0.8708892417797709, 2.430724468335868, 1.9783267484284606, 3.8038238736077035, 2.980378501207805, 3.0559197388798607, 1.1700411201262486, 3.803356407661642, 2.086487985928805},
    {2.7017755541816406, -1.9268946876482655, -1.628712041792118, -3.808037701173834, 1.8178516176655832, 0.3942015408838443, 4.259223030333792, -3.7439767257142185, -1.9773826431088255, -1.0595427405799727, 3.723312377982054, 2.985475406004781, -1.103824451430442, -4.262644749393933, -2.837055768097785, -3.888476025390755, 0.5672937587812212, 3.877659334724625, 3.3066163704603424, 1.4454736893588507, -1.6626077384533284, -2.7694627361946207, 1.8918908148561215, 1.7176819139992348, 3.242949105979667, 1.8847726296894771, 3.4297075503297774, 1.8892417657405431, 3.1109485841782316, 0.1916651383911458, 3.0927407976788315, 1.1980773327039351},
    {4.195101262507476, -1.9347878967571053, -2.9028853405113217, -2.171067481444403, 2.1252370734681407, -0.8342608932167804, 4.154211639345153, -2.6174016058429297, -2.002475070963188, -0.9222823478740837, 4.001477761105258, 3.0646965508090838, -0.12409629136961424, -2.904937655932977, -3.375955643740689, -4.293200774294018, 0.38965738587515764, 2.6769286541159616, 3.685012515539057, 0.04194438896296621, -0.8933825869121708, -3.1477496555241196, 1.0511124809395789, 1.4675911944943023, 1.2870147604837776, 1.9498717562162147, 3.7638699024751494, 2.9641193799860064, 3.317532338227514, -0.8053440815115204, 3.806534772234422, 2.658084873999215},
    {3.49454166098883, -2.4236238815087634, -2.070542246656824, -3.9051405387313713, 1.259441094363684, -0.362341974675653, 1.8559292799827056, -3.27560589565392, -0.650605688893633, -1.2776599234568637, 1.805436220853326, 2.71510921219711, 0.1859967028359735, -2.876439248325399, -2.3344443909790953, -3.9645466281209494, 0.48942346406248444, 3.9881970796237987, 3.4842938425999597, 1.2367087212045005, -1.100975340075215, -3.1902437837752973, -0.13565603477916444, 0.5897944328740056, 0.5734526275214545, 2.435622760780939, 3.548772672963068, 1.0785399818704715, 4.016746132878058, 0.7357189781015155, 2.27114709567808, 0.3702197426239826},
    {4.362229028639782, -0.7882286912677321, -1.0721645008591194, -1.818300933465956, 1.6842793177495285, 0.21274969723776635, 3.149641457300238, -4.032009742026294, -1.2891447056766805, -0.7912143317639684, 2.4009425514240528, 3.3414115495947154, 0.6412764554987935, -2.468793859676595, -2.310378391909868, -3.2876084237938197, 1.336453915541434, 2.845909802644379, 3.909548046765363, -0.3025668663472071, -0.7182530649076958, -1.8827941394429966, 1.4127435688585823, 0.15251465324757657, 1.085743118471167, 0.8593677341823907, 2.6869319776742397, 1.4521223398249825, 3.0469086540024577, 0.47050443358923477, 3.250539251902683, 1.2198418177313244},
    {3.1783728167098984, 0.057886767749761675, -2.4268568689639265, -3.1420308601437266, 1.2814553047970343, 1.5435477336766574, 3.3331100947878958, -3.7556683795019126, 0.036898986076991325, 0.8954918364395529, 2.7831803279698963, 2.3568438478874825, -1.050378946016859, -4.2417779605622306, -2.88006778641488, -3.739614935336607, 0.9589111812945235, 2.2506542311371778, 2.850654813206627, 1.1242710194396528, -0.7370712636284247, -2.0559084624795028, 2.228828674508674, 1.567525572095988, 2.8150540543342784, 2.2693332603391068, 3.147489665701168, 1.1550036970823079, 2.285600736106288, 1.2984814781538416, 3.1246090596185914, 1.2718174777609972},
    {-0.9166751098425637, -2.109545576907716, -2.3420735950378186, -0.6319642299582101, -0.5390536757415436, -0.2853160118005651, -2.1782234743454505, -1.0871516932754446, -1.6066927327067604, -3.130607645778031, -0.406553533982073, -2.8791913841401504, 0.9075097231115747, -0.2108962884938394, -1.5171963067562455, -1.7789616046352752, -0.4899075874798146, -2.785433136367094, -2.0468837087181133, -0.35789973469305486, 1.3558370010751324, -1.6742059244870777, -2.1737331010331005, -2.8556906756936606, 0.035696801260837394, -0.9397761979044622, 1.0803331424419755, 1.2607600097988862, -0.25691933979158, -2.1434121352161704, -2.936776101866749, -2.736943552696966},
    {0.04920831978528172, -0.07805815271389796, -0.04200608573255444, 1.9121612624644329, 1.8615538818840822, 0.2381633481995508, 0.9368900881187964, 0.2785258190977614, 1.0572777830699214, -0.2314202420772393, 1.8846915061306202, -0.5127079994640613, 0.6606335565843106, 1.6164029203315515, 2.247070808551332, 1.651561290209094, 1.5563754198070463, -0.1408001161988077, 1.8584890073319862, 2.431504380953196, 1.690527549126595, 0.5284837973424954, 0.7503907547782211, 2.2601414297880247, 2.02143593030927, 1.7626503099295883, 1.687911399071734, 0.8952378547938686, 1.4143376745105243, 1.8607553367774263, 0.9007332950546627, 1.7093956408396704},
    {-1.805369893084657, -1.9976054447444906, -1.7373427168757187, 0.014216396231720581, 0.00021194257274269036, -0.700944939441315, -2.786712106329695, -1.5753230318505753, -2.8279472596226043, -1.8394653814968547, -1.4371856643720233, -2.4349577505703124, -0.253558333855784, -0.6975189288842099, -0.4331061965446456, -0.5482152671918631, -2.5976045130673304, -2.845030629482613, -1.4667396264631827, -0.38193389871350136, -0.016683516322090506, -0.4983980405369722, -1.6951538896218858, -2.1851213394545916, -0.5318102512284487, -0.5064601532987095, 0.8571562893737786, -0.5858542588493603, 0.5393802279330753, -1.3696583433941218, -2.3364136482417184, -3.0984950613724958},
    {-0.9353806790568105, -2.883140570322156, -1.7148410302784654, -2.3359190076549847, -0.03020999380138701, -0.4861641945380338, -1.163142017019793, -1.240152247217312, -1.6816968932220513, -2.673004005412328, -2.16633866555623, -2.088576780616943, 0.28209301853499186, -1.2203463248650877, -2.0341845018643223, -1.3274231310428481, -1.9493480866957908, -2.4831995952203703, -0.7941012701725947, -1.6227883309395685, -1.0861663307254983, -1.038715384416259, -2.800852111937845, 0.23929412223453358, -0.31262256882952416, -0.8453180202311227, -0.5930774111558448, 0.9026244599406134, -0.6484968084450559, -0.32620995122505697, -1.0888416766917188, -1.2857042146773006},
    {-0.18846216207152786, -2.576573119830677, -1.1004062294197492, -1.2364076417380623, 0.7446139337081515, -2.0978641081203757, -0.42331413242207155, -0.8773782337631458, -2.6710669259318696, -0.952181020385212, -0.8247610108238783, -0.9056438770820812, 1.2240429596324245, -0.727544189125107, 0.7504910803564917, -1.7230433344272962, -2.6510943685769357, -0.08839051471917403, 0.7609280109799873, -0.7180507486808806, -1.410773276915903, -1.2505950962800392, -2.626221044628526, -2.0511426221620077, -2.3373015887454893, -2.0411876877332498, -0.8471019190117581, -0.20636440513284135, 1.7047423174212908, -0.2766803484626391, -0.35893299255334976, -0.13700058755688882},
    {-1.0054147788673904, -1.846870383403906, 0.0907154817413537, -0.726089263681453, -1.0577564086153541, -1.4215018896262819, 0.033573221561507945, -0.5573787865636541, -1.9850348275009628, -1.837733562492818, -2.785262921550328, -1.6961767752873766, 0.014403474386545597, -0.15658663722588462, -0.4044718343161808, -0.4722359622385959, -0.849941101261875, -0.3091139414478238, -1.0138026593668634, -1.3202084838815937, 0.2667396828357668, 0.5669559659996906, -1.5619777790911125, -2.3596584923418193, -2.6309934756913105, -2.0144507737181914, -0.5005988751782782, -0.8803816842674353, -0.6430856371299446, 0.1435002001635719, 0.2201146595100252, -0.8585088887933852},
    {0.2665326838307292, -2.266925167957528, -1.2917074497371548, -0.6305891661789123, -1.2450580382398568, -0.7916962646450937, -1.1572129112228187, -1.2780045828843847, -2.3087718231619343, -0.7021362952646755, -2.3358506699693193, -0.6568132849183712, -1.6186207006680657, -0.0297785335871091, -0.44144772787618275, -1.4505509651372699, -1.876641564102234, -1.4555101029635982, -1.5580148055373546, -1.4972704957913534, -0.2782425549217619, -0.09399641107039428, -1.6413389292892264, -0.9059465718354239, -2.841952421693223, -1.9963081260440871, 0.42433068050346384, -0.7046638150065543, 0.11967017860993401, -1.0281172727523749, 0.047582158575788, -2.8556874097766345},
    {-0.3117025811430622, -2.6362917562640926, 0.4678777528193682, -0.659115099005806, -0.3036701985305027, -1.7893786528693836, -1.9252097703112057, -1.8729078951541582, -0.3796613935291337, -0.32144561820911943, -1.889577203469164, -1.4953405786326293, -0.00781032350754415, -0.40824954303999994, 0.20929857189824866, -2.163554645617084, -1.4548685619962491, -0.07514411083210737, 0.005939341625566565, -0.600773340509049, 0.29402838577900725, 0.6730518629840508, -1.7217375534243935, -1.9297450844029984, -0.9227449228277967, -0.5480271435218025, -0.9512138957806499, -0.13086231675962484, -0.9089988124550236, -0.6558004619041675, -1.0924045722798057, -1.486544241781774},
    {-1.5925430903683724, -1.7258028733633621, -1.1604438097082015, -0.8088527792648595, -0.353740293588963, -0.20148083102607245, -1.4092282206413442, -1.669435088202448, -1.6863619088099848, -2.734207836999388, -1.303481705096089, -1.1367289118310573, 1.0443854913592625, 1.358611831699307, 0.2834259326256724, -2.7988935051291155, -0.8058947010601188, -0.7976068662588058, -1.2861327074600317, -0.36406016645740746, -0.9800242943893651, -1.3480289213564314, -0.8036290427666167, -0.8673013391010802, -0.20313784876874272, -1.6665682705526934, 0.16791163533606743, 0.31704656635931, -0.6512782069776772, 0.061209191580812616, -0.3831525138439249, -2.2739508293248774},
    {-1.2362907002253278, -2.5444997178728466, -0.6038690187340658, 0.4310406430024042, 1.0268764951804512, -0.3363023048433516, -1.1429470785530171, -0.7908488474302431, -0.09319078076986131, -3.2548679633343793, -1.6675489792902871, -1.7197091430691407, 1.3530674604812407, 1.8682264275293214, 0.36674152222043266, -1.3969169284335619, -1.621571941400714, -2.211908501753181, -2.002800739904269, -2.6657206966688047, -0.21436100762964502, -0.00350512697848316, -2.6315837058289735, -0.5712633641008453, -1.5736613538750237, -1.467755273830803, 0.9795188218140772, 0.5880049329605452, -0.2300057366266691, -1.176499753176652, 0.1793473134907099, -2.52770015876809},
    {0.24052189621728737, -2.052947603710249, 0.22289953158855894, -1.1633243041674135, -0.07702555679264655, -0.8562328547846733, -2.177720862979976, -1.9496602277507025, -2.329987973794783, -0.7919716307659046, 0.12379300996728548, -0.35423220375105097, -0.4629978553626386, -1.0039109351049416, -1.4730153696836668, -1.8550258335645735, -1.353793867692517, -0.8927549430081627, -0.9412736377378548, -0.09647317812697066, -0.7339860859378788, -0.44317854713653504, -2.051351712829827, -1.5583752226066372, -1.1417702128226888, -0.7509511434087465, 0.3761485013782611, -0.5669474986809575, 0.138300678660057, -0.7436505377149317, 0.047945435512218096, -1.3459334571965555},
    {-0.8834477066470194, -2.2698183977746935, -0.4775469690708818, -0.10026793181456407, 0.12327969332350505, -0.04758160276900794, -2.740021104653125, -2.9528059328673804, -1.644591549513022, -1.4005561676204676, -1.530757846798056, -0.5464870775682232, 1.1980286948980998, -0.6510583083722351, -1.2154891498078362, -2.4708940269183883, -0.8596320378871158, -1.2696867861435548, -1.0153036437428489, -2.5733678475815522, -0.25162224075836076, -0.2219748436195236, -1.140462145749098, -1.4050696881817777, -1.4293208117989686, -1.0194952188630828, -0.6079125594714104, -0.9762546362144162, 0.6907728870951185, -0.09138255327478126, -0.7073111288130964, -1.0580487723432581},
    {-1.4634811984645972, -2.530225743413782, -1.4043722390549298, -0.6147231681061461, -1.314217038771573, -0.21606033217127052, -2.348792317591983, -2.452019089257612, -2.923852855087498, -1.919396013438514, -1.6206360799008988, -1.8098826361718547, 1.0354817722647638, -1.200307768461155, -1.5763294591140091, -1.0188305405006899, -2.617114600877706, -2.0555334054824934, -1.425252687608647, -1.9586676732040544, -0.12005525258583677, 0.054317934182009996, -2.8924283906642763, -2.9833630192603593, -2.846361821481306, -1.7806706466070281, -0.6527076887726183, -0.1882290601018155, 0.09272776059257078, -1.16981615730121, -2.745292633326393, -1.5170606863555667},
    {-2.415680840770264, -3.2793923311998476, -0.02112423827442311, -0.5137140288694149, -1.051379903980695, -0.33687060439194444, -1.366596370030571, -2.768720347319146, -0.7530886612143022, -3.110284926160165, -2.0066228797271863, -2.258101354108732, 0.808591176843737, -1.0387894878999027, -1.187796597274052, -0.13411078973093157, -2.7215800387325446, -1.355486889644928, -2.095229085835312, -0.5242278960863345, -0.1419785873176171, 0.6655694503372552, -2.2476171888638325, -0.6947457966558189, -1.6737666988519084, -2.7541499747439895, -0.4710257430195609, -0.4166363975758296, 0.35551392762677214, 0.10252214544629953, -1.855531932930984, -2.860814798092551},
    {-1.697894795702399, -3.842922395175628, -0.4391717003661039, -0.23669256495748353, -0.5751441950269915, -1.4204844182808742, -1.292238321841373, -0.7908660788341803, -0.9414609960809581, -3.4681218595780128, -2.059872327437909, -0.7562742449468388, -0.5837519024343871, 0.7286903352658262, 0.5894548894901889, -1.363733079280493, -1.5926839696439057, -1.8701981738809637, -1.1039527647526532, -2.35196021128833, -1.0282421002986963, 0.6597643008022003, -1.8237512800634177, -0.9033706533857648, -1.1259866382465422, -3.07353854775424, -0.06772740907572349, -0.1749240197951614, 0.3588890198923795, -1.6730781824307839, -1.1669059349931836, -3.2552508493503374},
    {-0.2906590402826814, -2.1801491459698314, -1.3440864219132118, -1.1343518984776375, -0.4237079057935803, -1.0820998194411298, -0.4795749268762534, -1.1356238633502242, -1.784767883480095, -2.193084599363585, -1.0236864235159886, -1.4562360815508044, 0.5990936364937937, 0.45024451164786355, -1.3407476841926442, -1.6159127584412736, -2.6088317739646305, -0.6318014539647508, -0.0032941891422264887, -0.8831664860247896, 0.3582478216057185, -0.3140597675435453, -2.3563392624388206, -2.2309079419497655, -0.5865839651450712, -2.4056295228531446, 0.3678546610397006, 0.2954650030853739, 0.40143590030915, -1.3900442700033748, -0.3842237631863825, -2.4045692106780487},
    {-1.6527626912338653, -3.468628893132168, -1.4130104154503509, -2.1719826611407087, 0.120631707577292, -0.12967617440524895, -1.2149908883231995, -2.09401284724375, -0.022957681179981024, -2.925645917925892, -0.18354324254104457, -1.2500104390158713, 0.5806252505073524, -0.3779680160179087, -1.0087011291181618, -0.5707369132453985, -1.3918614781885728, -1.0795544927260412, -0.45320712808373903, -0.44168528349398956, 0.5540263735258549, 0.18747298090808523, -2.392303930449034, -0.799894083738368, -1.3977027833434936, -2.5491708980387293, -0.5956877703731891, 1.0826238503773122, 0.916287179312033, -2.108801092794294, -0.2454101066699408, -2.1629504524883294},
    {-2.1934374029104924, -3.67018767166605, -2.2005593288443674, -1.282521599872087, -0.28459119685251605, 0.44392022808808596, -1.608948628031559, -1.9140470570740045, -1.327963470601027, -3.220798694497952, -1.34744301322748, -2.134626822694895, 1.0390931576045317, -1.3795300634577483, -0.2879042888435581, -1.188210000315456, -0.8220007584341907, -0.1401728664412098, -1.1853117714195154, -0.6719319618566881, 0.1931855654948573, 0.4667772740051018, -1.0455731552692327, -1.813050889265968, -2.13076655663998, -1.9816018982025938, 1.2820887660325029, 1.907375607037567, 0.7445587381734422, -1.1749024726973036, -0.6102048659582663, -2.370117794836016},
    {-2.3024599358794786, -1.8715165624630927, -1.0978252521292255, -0.6328510588267844, -0.4766354245580532, 1.3716845605493595, -0.27838999321074237, -1.8254873964628833, -1.649871248228177, -2.64045063214075, -0.7588184747711978, -1.5027243031936828, 2.0656520782911896, -0.9248021748686047, 0.5223257429835564, -1.68347331773719, -1.2652840742850477, -2.1750602113034594, -1.3108338804142552, -1.016611992155889, 0.5596163659027886, -1.1171995088067062, -2.4855072126400097, -1.2777039392165097, -0.4932036049090413, -0.6132672673813386, 1.6956560465205424, 1.6593187895188708, 1.2034422964365097, -1.3686780289393394, -1.5646283336595186, -2.707026666627509},
    {-1.4465612897213518, -3.358107031296474, -1.48472944939002, -0.5366641522188622, -0.4359600203111566, -0.4038774403013487, -1.6808342786995198, -1.8423476303172703, -1.0787460989235633, -2.870746314838015, -0.9337353581583255, -0.5735384476956926, 1.224385487668049, -1.2586847045574667, -1.2735863624661399, -1.5614669664351208, -2.4381872104615336, -1.7732504904685982, -1.5846397973992727, -2.5338480226007216, 0.18389564923249188, -1.3871356753666995, -2.505925857353363, -2.803276645473726, -0.9837849648364143, -2.1179609151830854, 0.4971455172665444, 0.3216555830209868, -0.6647036152280894, -0.8748930964717885, -0.7692677961506804, -2.5818387470663273},
    {-0.45146844947863923, -2.93498210916329, -2.3879857938330993, -0.9945838659405515, 0.07026794581292604, 0.5751507054258127, -3.253496184730717, -2.9036297860721234, -1.457123574708021, -2.532718664406533, -1.7040251669852522, -2.479689461459693, 1.505697468969357, -0.4886886754904277, -0.11350838325458455, -2.1865781472324266, -1.810674161460207, -2.213886074364781, -2.971908436937211, -0.9744440428485249, 0.7086693414187749, -0.1101857280267093, -3.299827282998361, -3.0390886601229123, -2.8887512232243227, -3.2531782705975103, 0.39015697429136037, -0.05182021801744748, -0.29363335800481, -0.7020173395537951, -0.5994885762345141, -2.3133213026701216},
    {-0.2680265423422396, -3.5410104025688907, -0.9365117306196661, -2.1415955655747916, -1.548609364739381, 1.4047023345523277, -2.6575925080939156, -1.2875386623900404, -1.0271406251492716, -4.837001992002642, -1.651818385468161, -1.6264180740615075, 3.3327568941768595, 0.3201429300369757, 0.7620074423616647, 0.17101430679900914, -1.9497977111349971, -2.3614066414631663, -2.3373683960076495, -1.2590144956662004, 0.6553734625823158, -0.06049123393897952, -3.3631579460130356, -0.9649049220408622, -2.182593122713868, -0.8333499282545979, 2.886837749485544, 1.7971941461423122, 1.6882029343674425, -1.5231517777750652, -1.6475037317210741, -3.874221579676927},
    {0.0736432833270853, -3.580546299579748, -2.7497997722606824, -2.8402100992717694, -0.7476425108089281, 1.1537269781473125, -1.5407412303282833, 0.5935974743951918, 1.3550466868404456, -4.1236467897828195, -0.07307231170752804, -1.6820964325291228, 4.371200292314356, -0.6881420116541298, 1.2563008536337152, 0.1824098179322279, -1.7575566011249257, 0.2703570015411031, -1.5927952036890174, 1.4014587009575563, 1.391613570807175, 0.5780190898411632, -1.823187246341337, 0.35969795172014074, 0.9873383674998596, -0.28393665670262364, 3.274598149160598, 2.7997893046256563, 0.9603875590531847, -1.5112173231089376, -0.4167921601784453, -3.6996244790186275},
    {-1.3675587158401008, -3.0337931818158825, -2.667269087810478, -2.413238458180005, -1.3975726086683216, 1.167268333580582, -1.3734057464322043, -0.15449269826556403, -1.123231241466216, -4.1121308813759665, -1.3278614381237277, -2.1718834861343916, 2.94266167717294, -1.208516431236315, 0.7622779697944949, 0.16241247703341946, -2.5270433027703714, -2.2586859611475596, -1.6555098813044336, -0.007519088093603338, 0.6017658515320864, -1.1175675127382878, -2.6680210979667334, -2.4408680312256017, -0.9238057252595743, -2.5492863615738597, 2.057364692158419, 2.858082762961488, 0.9809013255640862, -2.113792908864375, -0.3035086820863902, -2.7185138323995446},
    {-1.3059644671722725, -4.836624323616213, -1.4943955023250448, -3.0511449801135937, -1.4688111005149522, 0.3132661424806868, -2.8400071548781387, -1.731206226395143, -1.7757060138148293, -5.097492159973175, -0.9337651389607157, -1.9859135861644963, 2.6081088242571333, -1.3504692393405835, -1.4331921955959563, -2.323974273517364, -1.3857680993122126, -1.6823765023143302, -1.7286562559371965, -1.8489223622539772, 0.9627129617901462, -1.5023440701627808, -3.907616263929702, -2.0407445103178223, -1.7545984089271616, -2.4170771719692783, 1.7428535870044715, 1.34949342263775, 0.7570647899533224, -1.6497853125619972, -1.3380391359039765, -2.9067976832820364},
    {-0.4318195166018539, -3.92468407324186, -3.51322254967422, -2.852601238287224, -0.7282390082900477, 1.0171926426265157, -1.612491623241902, -0.5153667271812087, -1.2945269932687526, -3.3880156412756635, 0.47047219940780405, -2.4388396947159463, 3.87405544072436, -0.4271937282870312, -0.37127087085806115, 0.7299244903167346, -1.2286582871035254, -0.9779703604460009, -1.6640026992782457, 0.27167807404885713, 2.3779691264399183, -0.46664961649903597, -3.4637401410217277, 0.07758069139781662, -0.632570699428722, -1.4344365070184626, 3.414745472755677, 3.1797829297856963, 1.8400689227277869, -2.2462150556047886, 0.4824888778356096, -3.9922568293708722},
    {-2.004515486490756, -3.5395511092495244, -2.7256279766762006, -2.6864697719170927, -1.7675294286662393, 0.5709205787837643, -0.9445854195518926, -0.5324913457114959, -1.6200359877349852, -3.786069277359861, -0.8295610116219745, -2.536671188700428, 2.56770898623708, -0.024976447620516894, 1.1653586828415892, 0.12691422013119222, -2.3876495598014875, -2.163411673723831, -1.180664968642884, -0.787639434381352, 2.3987914507002213, 0.15257890496150908, -3.0029031004656983, -2.130666988716834, -1.2890223688299345, -1.8669177280192553, 2.0527466302905117, 1.0099320642235572, 1.2754484350866835, -2.779816320113884, -1.6950784109570536, -4.50547512039278},
    {-2.321557898905848, -4.057854488182704, -1.3834062882993237, -2.5622554103535613, -0.4051401611577671, 0.04895864962689887, -1.1159791476395968, -1.8705453812971635, -0.9127191066884318, -3.200423030616324, -0.5060914204887013, -2.0704817548015213, 1.725703751779828, 1.1429643322596383, -0.06898970568324228, -0.6541720829951405, -2.8776733933671914, -1.4731673247253252, -1.5864086384972333, -2.0153592824893134, 0.989216112168152, -0.17634101709308034, -3.885800075646303, -0.9852066571754876, -1.5347947772171897, -2.595647940603764, 2.330408104954104, 2.06544274784505, 1.261020157930028, -3.015639983147303, -1.1525362290749221, -4.182817214332011},
    {-0.8172354113152068, -4.265431016899975, -2.2846926935522562, -2.8437059700850233, -1.689212086316709, 1.3342253319847306, -2.4819073098707345, -2.272783414497381, -1.6264434040950237, -3.5703146219398434, -1.4074422000647269, -1.4046128744005184, 1.628662383952026, 0.10510764352257011, 0.049802544614654984, -1.6983298079169002, -1.7804871225830978, -1.3548325961688457, -2.376596187261789, -0.7759609339066756, 0.8704089496891669, -0.4782231673745702, -2.295664096514628, -2.496221822540693, -0.2690769707830841, -1.0977795178650627, 1.9861496732904647, 2.9406464652739275, -0.15018001000418552, -3.456582945053057, -1.46718564774442, -4.665763658683167},
    {-1.3311629058192562, -3.901548721225699, -2.1221235872912003, -1.8190260141228285, -0.9813950457938033, 1.6124141260309341, -1.2603727257514752, -1.1736458690425122, -0.1661464924987766, -3.9384928511205866, -0.7198329114145596, -2.8190322443870213, 2.426851783744205, -1.2846296012766296, 0.18853808306084957, -1.1263544184054743, -2.865516868770474, -2.7897040248012797, -2.3452281779470536, -2.0848280048004604, 1.4591741818459651, -1.8232544497274605, -4.003070850433934, -2.439199395653102, -1.4687605208948376, -2.6310828360751053, 2.2951035544824125, 3.065506519704202, 0.00044488942318895986, -3.6102237713179575, -1.9399663760837056, -3.793260010484023}
};

static const float b1[32] = {6.719318907989013, 6.914415109709328, 6.720020427192773, 6.697858566397002, 6.656199775343112, 5.9917327127826825, 6.906493759659336, 6.881276983267313, 6.830284459421713, 6.997276966804867, 6.670322493677412, 6.540707026783005, 6.321307307099497, 6.481178542484244, 6.640457423121414, 6.8475380627371685, 6.529080611222314, 6.487580361075277, 6.696248301431439, 6.641533558816555, 6.488650505718981, 6.970463904066796, 6.4716920208257065, 6.670147235261168, 6.58316055396901, 6.674560867435109, 6.700818811513899, 6.51435730980297, 6.332051020858871, 6.461021714535364, 6.220425941101465, 6.721297065975831};

static const float w2[32][16] = {
    {4.798497398224102, 4.443180194801135, 4.780962664267325, 5.321502177003159, 5.852408975937047, 5.135881405622063, 3.726251103381826, 5.630596729371611, 3.823141324950601, 0.16991399169437998, 5.44995499790031, 5.7500303468504805, 3.2937009809099114, 5.814362501907383, -0.389332606676108, 6.136865657170936},
    {5.909481726360304, 5.476646783631392, 4.665820334683441, 5.48243560205015, 5.41329821550834, 6.514160352818889, 4.261361738539578, 6.145721362818261, 4.066761508176137, -0.2322246894463338, 5.418558690715645, 5.264187967099584, 2.948917149993724, 6.527691709276499, 0.11995644651712474, 5.204762484364914},
    {5.578537490510307, 5.250746188269888, 5.616630223461867, 5.925547297543634, 4.490616133470873, 5.718179111444374, 5.025454191958032, 5.40948159512303, 3.2266391664419642, -0.40537025124304565, 6.3031715965584505, 4.726088398891565, 3.9729893986769405, 6.301942566185779, -1.0295323202228746, 5.969801780246726},
    {5.578580054851331, 4.678365495098374, 5.409244207156126, 6.123058721813388, 5.069201970401752, 6.067661077529455, 3.8648423271233407, 5.333271821224694, 4.345789761595283, -0.19627451779381155, 5.523552769285384, 5.605233288643069, 3.3007259551178945, 4.839392192764876, 0.10179481559614938, 6.426169741000902},
    {5.655566728393111, 4.713809105739627, 4.452829890320324, 6.000586808236569, 4.756725529488758, 4.651504325708617, 4.8082824277814, 5.629908148627094, 4.249517116800299, 0.4254033071436099, 5.168063569657521, 3.925046948875374, 3.0979164126490937, 4.864494589852338, -0.7852699221018073, 4.455275679956333},
    {4.905360322149297, 5.239706327346329, 4.181886231781864, 4.652632539145849, 5.978732685244255, 6.055556657405832, 5.71388975934149, 4.991189062844419, 4.735834311974051, -0.8414353848202883, 4.715429942050561, 5.848768980825267, 2.809198169694693, 5.9172445405211285, 0.7344659296264878, 5.587658339060278},
    {6.446576264370968, 4.186945078981704, 5.176214373291128, 4.706167079205761, 5.4248699534310605, 4.807702058013079, 3.988202089054462, 5.08240489879706, 4.394463398541688, -0.7989777991526967, 5.321394974682722, 4.494325467481648, 3.7490924322438115, 4.58955411018515, -0.024449747861196528, 4.787152457625561},
    {5.162137218139838, 4.570134792251983, 4.716498045200769, 6.541057284354155, 6.488972730497671, 6.146745777811763, 4.6621050575291365, 5.6161887303352405, 4.450263260894426, 0.41673953798191515, 6.409025812395842, 4.62561099894704, 4.024172126303505, 5.939161063860692, 0.5648870440919176, 5.744239508942566},
    {5.530015113211445, 5.314254572442068, 5.131848711030817, 6.150536588346503, 5.894912806631092, 6.258217951242082, 5.60971728677281, 4.69500752217015, 5.075514411347546, -0.2341818294309971, 6.389150285163335, 5.728137565752434, 3.578316867057762, 5.7941783478504, 0.05889743975646624, 4.858296439074226},
    {6.362863439018652, 4.916214841328151, 5.458998502556237, 4.851817682053889, 5.666275861834385, 5.249906941806323, 3.975763589950468, 4.793798899969117, 4.665446987349803, -0.2745750398453297, 5.831268860941623, 5.965819508176432, 3.038432429894461, 5.299812940152192, 0.5873737600664989, 5.746454612314461},
    {6.093352804217537, 4.303837530853054, 6.031593125238642, 6.682862911821754, 6.2663992795557135, 4.792621411082864, 5.146463487643881, 5.731957132964232, 4.728230512580905, -0.6515861493531339, 5.85960615443132, 5.931892610133928, 4.053938101173546, 4.662007310534729, 0.24106984309765778, 5.30324399169669},
    {6.419460451450872, 5.535309698825433, 5.967946334613909, 4.920636269770425, 5.27809069482361, 5.68048246476338, 4.674799836141323, 5.6492959848750175, 4.574913852913013, -0.3406023967279802, 5.460517162214913, 5.935197361472205, 2.9084520735413837, 5.105783872534146, -0.5799502709350164, 5.0094452314539595},
    {6.327624736551379, 5.878547888020222, 6.064858112941338, 5.388305509399024, 5.716695751309395, 6.041644468656317, 5.034299504596406, 5.688408235736522, 3.876368699716762, -0.907937577954441, 5.160022651311575, 6.25738862216033, 2.9523717912687015, 5.1725662226306515, 0.09536968561823271, 5.120330592468461},
    {5.219220897927499, 4.320410936180686, 5.745599335738837, 4.869897442066826, 6.040613466599312, 5.448781697702959, 4.571928337640955, 5.046990664668679, 4.8079626261808865, -1.0397790794960486, 5.0922686166326105, 6.013128442048549, 4.1145039797262575, 5.66046444711676, -0.7132100886719257, 6.161976482748733},
    {5.006090996071677, 5.588600009424179, 6.067691215447635, 6.300775934242047, 4.646746640466387, 5.237134935748593, 5.777807254289552, 5.924718392306053, 4.845936098821686, -0.12242247196466473, 5.497690682388204, 5.5388410495922455, 2.43342849394062, 4.893806584278256, -0.1637213226641269, 6.408215057405029},
    {5.468867836348106, 5.55377617657265, 5.823139625352768, 5.598316606181948, 6.0043266079602144, 5.173140598905893, 4.490051042803549, 6.031633724393953, 5.884166696884718, -0.08121208048433767, 6.285156745907434, 6.2881305231702935, 3.7011758528939445, 6.611130293926023, -0.1455357381642533, 6.298289554755444},
    {5.068679882668358, 5.1847331083705726, 4.711869832865673, 4.681260328705328, 6.276080808371745, 5.9794735516781525, 3.974670961613245, 5.124882844622594, 3.7378604368409083, 0.6366926513277394, 5.9753692535124205, 5.261059330149275, 3.7860121862699736, 5.764348541876289, -0.6936906425102526, 4.987080049120687},
    {4.981777771596019, 5.095064739867914, 4.692026536546133, 4.947247564835512, 5.381226429734587, 4.439575687164803, 4.776375507077189, 5.82340746968553, 4.336649912014653, 0.5878515317769698, 5.352810563791331, 4.563451038721147, 3.7578519638003054, 5.117507465327272, -0.9710380043938723, 6.120742080358159},
    {6.359664229668084, 4.09262315518669, 4.273428931146911, 5.814857768820062, 6.144975923000624, 4.771358187738468, 4.068622431392885, 5.437849782605295, 4.919011551522198, -0.17565827550133437, 6.219384803937911, 5.9172788185040375, 4.314034248291346, 5.542341329730624, 0.10961201359910112, 5.07828885196414},
    {5.577938249044508, 4.737751477389501, 4.606879807628898, 5.494195823245598, 5.906398209266071, 4.242560660136488, 5.3659066661085495, 6.165160272887276, 5.165172091037596, 0.27004387180373624, 5.286814906983228, 5.172131518985297, 2.746725171859223, 4.394759331313859, -0.6324166002550323, 5.374857039371563},
    {6.064213513162713, 4.402478029133939, 5.984680750896442, 6.215455367030886, 4.954906693157051, 5.31383727567743, 4.83742821783627, 5.082862409818986, 4.525349898890367, 0.6343480488505846, 4.996917232306175, 4.837268632063738, 2.8906386021753727, 5.998803145340318, -1.1103329425138604, 5.876710806420131},
    {5.413650968628667, 4.080103204787924, 4.570574357116997, 4.993058613757542, 5.028754781707456, 5.585879827456188, 4.737317721336304, 6.256888312214843, 4.976214540516997, -0.3908228965690624, 6.090031436198355, 5.6235230697082, 2.9853929413065585, 5.57327925724958, -0.7612682459330699, 6.087406861066067},
    {4.77364545627636, 5.66395786554552, 5.851990742860506, 5.372101710760219, 5.999580533822184, 5.3525457875393245, 5.0300698940804, 6.228534135167191, 5.213544656326472, -0.4946114908029903, 5.376255209360602, 5.420832972132083, 3.678367798128789, 6.454174549926065, -1.0100340344937688, 5.258472465837563},
    {5.511959888918126, 4.837371030648203, 4.185151177814419, 5.78193524765807, 4.973195603564697, 4.465248909742655, 4.7203258846061456, 6.167577749342728, 4.178697045191111, -0.6141984115297003, 5.003454406881744, 5.339625847621208, 3.430010654264467, 5.742117394082092, -1.0854004482831265, 5.0717378019213655},
    {6.19748744643909, 5.135009073648981, 4.758300952498072, 6.19028215682367, 5.3120909831143, 5.18717345257254, 3.6562666680452267, 4.355403509555297, 3.859139610913654, 0.09897541452389261, 5.558789578291783, 4.262631098257722, 3.9956199595174535, 4.351580174923375, 0.10629832607334569, 4.702500914286834},
    {5.0703163721554985, 4.509580233454291, 4.27959163229868, 6.054708422829507, 5.866553241669378, 5.630560755423114, 4.244164152016778, 5.726740190482876, 4.711485857911922, -0.26766678577724606, 5.40534282130095, 5.220793897749489, 3.8387660035364544, 5.724024344420951, -0.10359542799590511, 4.788470499704205},
    {5.891741555247194, 4.981383902767592, 4.3435131721491915, 4.62680765752881, 5.081559738085599, 5.338275564150984, 5.007333427720422, 4.198738550201249, 4.173412672907665, -0.6405578954544741, 5.017129190640634, 4.035474985495481, 2.82864116329531, 4.8241766767575935, -0.7321372043643792, 4.360627462822571},
    {4.8296253140665195, 5.137616744447232, 4.37712332505341, 5.322799405735207, 5.143460049607079, 4.551483470400221, 4.201698609894861, 4.3887025895815786, 4.672628307268477, -1.1752349786809124, 5.82980649819451, 4.391119662507487, 2.4859573420727963, 5.544974392879603, -0.8395775366102936, 4.631726947911236},
    {4.650661255360642, 4.913516456046112, 4.748799483020589, 5.802696885644514, 4.733989175459853, 5.239818404519646, 4.071781994701337, 5.509754889912503, 3.625550191151492, -0.6748595290056281, 4.860287969571226, 3.630062618371118, 2.7659664708361253, 5.0676670075140935, 0.27969035245965473, 5.278020634313498},
    {4.734077111047115, 5.189731347442614, 5.370212166572383, 4.9683318249329655, 5.37883916892472, 4.860412216689127, 4.560156130289619, 5.954128722575827, 4.259792294427992, -0.38505336241909827, 5.7790563536559185, 5.18515211110211, 3.2473485821698356, 5.651761756618481, 0.05180902711503835, 5.355538532298263},
    {4.573114471593557, 4.104212952621648, 5.499543827467935, 5.229900040953192, 5.181882236477777, 5.456575255485223, 4.3043730311522115, 4.897111772919869, 3.9840052463606925, 0.39401696642224165, 5.237950320939696, 5.323118731228593, 2.8730964032640847, 5.670857832607477, -0.7365439688872796, 5.116047439971582},
    {6.002709131356392, 5.495423903959618, 5.659011962086145, 5.880761294216596, 5.364166873992059, 5.757802168824773, 4.604690416521951, 4.953028852443668, 4.74265099061393, 0.5728234215754343, 5.544378774994575, 4.592594446029715, 2.9878220043797707, 6.07314126728073, -0.7049724928372751, 5.09494453472577}
};

static const float b2[16] = {6.060341267221141, 5.4837788617384415, 5.7407348370808355, 6.082892860000402, 5.762808026061865, 5.899410755002713, 5.695521727486927, 5.909341866565931, 5.524068442604257, -0.2502066979682304, 5.924113016740138, 5.813125128549876, 4.258160925537084, 5.91185816237023, -0.3870549780320255, 5.932815010540048};

static const float w3[16][12] = {
    {-3.8014147895195123, -3.632030072921419, -2.8076238551788197, -3.6581035317482615, -4.354204473436414, -4.1950631734590855, -3.848031553100363, -3.7015412288724563, -3.3870343305001804, -3.2637463452738746, -3.558041760569092, -4.257040387037866},
    {-3.7342555867726834, -3.209397008908596, -3.277138144419227, -3.8211302408620624, -2.8402066526506067, -2.9003215291594278, -3.960261853105545, -2.4340054840168968, -2.701125821385716, -3.5166053673601563, -3.602646425859281, -4.258012131709544},
    {-3.359821926140981, -3.1193658834436198, -3.249733571585631, -4.129809012249288, -4.364913315238958, -3.0366259274762064, -3.34616512815488, -2.5944210681914264, -3.2778308663274203, -3.15467845602525, -2.622718016447374, -3.0927072092746495},
    {-3.6083175687149422, -4.182783760304862, -3.6253393902415367, -2.994334243252693, -4.132164199546622, -4.1616885757675615, -4.083240137662109, -3.015982251937283, -3.5983623514127925, -3.1158989043787018, -3.4845839043352003, -3.5262066332162076},
    {-3.4958501244648645, -4.062490771648883, -3.735951425558537, -3.9379732850774443, -2.8100806274828676, -3.4279182352858513, -3.9808908639646106, -4.2012535973308545, -4.411632362037043, -4.013255831380761, -2.6127982739333535, -4.251146912780214},
    {-3.6437186414395537, -3.0809983868771624, -3.3523682184614554, -3.7413424325191835, -2.84350384179394, -3.9787054392954606, -3.0569031614647297, -4.296110326296522, -3.905291736440953, -3.190793299163071, -2.9140063919714145, -4.282549195527135},
    {-2.4975993865403097, -2.8838394929567457, -3.5261365529319932, -2.1586503222394744, -3.185320033844453, -2.9565069152894132, -2.78615749893272, -3.1290477944519193, -2.747031770799692, -3.912090845148001, -2.9924544067640104, -2.2106987466309236},
    {-3.1725465718714556, -3.166888023693583, -4.279160282751524, -3.5076786971754217, -3.4009962739929906, -4.058372533473816, -3.049856580517413, -4.064954507834788, -3.482702862367655, -2.519413546442704, -4.724627812159158, -3.284905160305463},
    {-3.3286796392984312, -2.829889828366926, -2.9003775961714644, -3.719620420849859, -2.6102417919117116, -2.682672195929577, -3.8254822612028234, -3.805460168086301, -2.0669638591165076, -3.087185220014287, -3.2224000090504563, -3.465423096788748},
    {0.5213758178492348, -0.7343656249877365, -0.03615082099541127, 0.26362746337849013, 0.16322341024051082, 0.3916526702486816, 0.03647259329657502, -0.49033617317249967, -0.00446911870677565, 0.42252117385574767, -0.6888479119446037, -0.7080703838166186},
    {-3.7912728898807537, -4.53029740180797, -4.835764038910355, -3.603155541403776, -4.139663324849549, -3.252333424068782, -2.704402151038654, -4.118621515368197, -3.606264163751173, -4.3301570039736745, -4.544382735711566, -2.6773180778297894},
    {-3.3820904315732645, -3.122718774565252, -3.0017796338607825, -2.9521455113797788, -4.014001005790965, -2.8375862710781883, -3.927229484822307, -4.357964930667766, -4.417156404174845, -3.286082723514483, -4.4397690036965844, -2.8357517430889088},
    {-3.3277171643178045, -1.9410929877602723, -1.9129272593682223, -3.1561629921998566, -1.9836790343056083, -2.565487899177134, -1.8096481835094766, -2.6211156799389963, -3.704462167846532, -3.135248678596425, -2.330491217229321, -2.0195212551210195},
    {-2.9077295748144265, -4.620274601166775, -4.474881614804257, -3.6254258608861214, -4.334059731597567, -3.9197498745123593, -3.6167263221896464, -2.9414795358406014, -3.640670983201266, -4.040264333595085, -4.088929024458602, -3.739713972646633},
    {-0.1777840175424809, -0.37091438145555544, 0.4611310463835763, 0.6226184565900823, 0.6281822968242178, 0.12649595209401973, 0.19520811272190638, -1.1028181339642207, 0.09741743723022953, 0.7784700689440064, 0.8648449092242646, 0.5085455352490316},
    {-4.672213791683943, -3.590838775109719, -3.208767990109768, -3.693086261860699, -3.2007016107086423, -4.24039205753741, -4.270371606087803, -3.1772260291155163, -3.618394302803486, -4.152319819483236, -3.160374593405774, -4.308113522903945}
};

static const float b3[12] = {-2.466798364369034, -2.967826259602789, -2.5011320587202754, -2.4249785880173973, -2.240373048257521, -1.9953366891763114, -2.0368168340921686, -2.354534364833694, -2.1399534314772675, -2.6207690630456333, -1.9866047989533449, -2.3153843358433925};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
