#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.127268979096193, 1.0866566693342425, -1.7039689555179933, -0.10889038737639564, 0.3906754429218915, 1.6059226148150747, -0.8736507891889186, 2.211197194679503, -1.1372427018017426, -0.34010571969180015, 1.546979992597823, 1.8834187352533043, 0.6032178118478265, 0.5557476981153013, 0.24609421723664188, -0.46923865364984707},
    {-0.13674628447371473, -1.9978877060515536, 0.8043044245050763, -1.2584565037334658, -0.17508893984788956, -0.4933949176776317, -0.7009207674800915, -1.8691225253018253, -0.08963804715001647, -0.3362244613721558, -0.1279096472130438, -0.3329869892405418, -0.9238625018282591, -1.7455472561284957, -0.9519806485959392, 0.943301880494622},
    {1.5063809503865881, -0.23719892025528844, 1.1270646532817294, 0.5966874628581711, -0.7221305835226669, 0.4767445097116626, 0.8541185464703603, -0.14999363673121918, -1.1157035242305156, -0.997941615708779, 0.005595046089346089, -1.7686347511774085, 1.146409246523772, -0.4145147290895275, 0.3427177842567928, 1.6124127239614077},
    {-0.5182403985249194, 0.11110300345088994, 0.3507531549334709, -0.7295558414650732, -0.2679319210457805, 0.9168436863840502, 0.5792531631446314, 0.8248920187779398, 0.2770050632657716, -0.3411473707552978, 0.8014918889644445, -0.8177353884358314, 1.613831617004198, 1.4107581616511684, 0.8558393962676174, -0.2620118471736354},
    {1.081480808777135, 0.6071848317356763, -0.4238022285959917, 0.7639078508527548, -1.0875332999031337, -0.3276147677887007, 0.41566417207654277, -0.07873632473762532, 0.024756146335014946, 0.4680358690529119, 0.1976782625665774, -2.428059723612768, -0.34660838096812135, 0.9573609270716675, -0.08134421996859419, 0.03162332035537383},
    {1.4167496353085305, 1.2300899347604828, 1.7019434848994586, 1.9039531573627553, -0.5751678753874812, -0.07785495815711002, 1.5068559106438282, 0.8429463172841927, 2.014811081609462, 0.548489104242034, 1.784980333453801, -0.775420346665664, 0.4005145719048903, 1.4527364155054605, 1.0282853077420775, -0.4587273060196342},
    {-0.27960454838944426, 0.26142127798694986, 1.285777737389621, 0.9418214974924733, -0.6945789545512622, -0.268124632976028, 1.3657335868586478, 0.6395138966369286, 1.328292901603318, 0.23457740724866938, 0.9651354517542088, -1.6709228916897112, 0.3582147965505346, 1.2008320626581397, -0.04154449533552732, -0.32076020837082},
    {0.9136737691646435, -0.7654988447474879, 0.017279504975073627, -0.031190939135991975, -0.33611107540227914, -0.060603068754301985, -0.49494023478268995, -0.5885016628222032, 0.028189614730003684, 0.14062239937132584, 0.8569845461839358, -1.1863658849457719, -0.5475086809263536, 0.6351280450924262, -0.7219751042058464, 0.14015729181017333},
    {-0.05852090462929263, -1.6289870479141535, 0.5963502426689226, 0.47568213646180507, -1.0490606499208992, 1.0387843079115149, 0.28273318023752647, -0.34367295432965417, -0.1716236752148969, 0.08154162109301351, 0.9938985010864876, -1.6276691294504144, -0.8257645203095697, 0.772542532598768, -0.46728333108275144, 1.107743676921296},
    {-0.8729429448569177, -1.9107833320657719, 0.054277625941821776, -0.8823431563659365, 0.6506492874950871, -0.5117001671286822, -0.6218657258573774, -2.1311208061314724, 0.7684723822423641, -0.3271164008138863, -0.6716637725477883, -0.22661755690683902, -0.9030831676813617, -0.8634376229639542, -1.6744396901903802, -0.06970176675138713},
    {-0.05323185901065779, -0.855877330626401, -1.0264767026114399, -0.642795709660959, -0.43263144115967134, -1.0871445080371727, 0.13346082020458588, -0.34363838136278574, 0.598345282543386, -0.6100621314399215, -0.4648754027206114, -0.9662210495946113, -1.070459745561164, -0.4754213859246632, -0.9866729604606168, -0.8889563262251846},
    {-0.7311599554536828, -1.1662000647074324, 0.03004649879303831, -0.2853051815239838, -0.7967896812248405, 0.8369010815065694, 0.022127845134940368, -0.946580179947719, -0.2343748228363174, 0.029963052654190882, 0.05419194438047021, 0.3080199598596213, 1.038949987856077, -0.3213052675593479, -0.20178029845511503, 0.6420169943467575},
    {-0.1083853422053618, -0.23891794299978691, 0.3144632994745355, 0.6220007398072293, 0.478827723016202, -0.6746998544789585, 0.5082107860351375, 0.09596233947189715, -0.3840032594447169, -0.6637061833348841, -0.4526420136218614, 0.3441898247694143, -0.899274367218063, -1.6297937071465085, -0.8077251219273716, 1.1818272416980515},
    {-0.2763707862024177, -0.27652536124418564, 0.8867943957071708, -0.518821131649213, -0.6747395362336183, -0.11045233709288832, 0.4175025390244572, 0.8053119973105215, 1.801446071982534, 0.2397124046729471, 0.5374450998609869, 0.669742056013764, 1.2142861040936714, 1.239532482054766, 1.3531598074011273, -0.6450805420209659},
    {0.5038732085904155, 1.3919970508602093, 0.7033311752463727, 2.0918769660714505, -0.05109198354946343, 0.7096278518362693, 1.0936514714757555, 2.0871708666108892, 0.7186407967184911, -0.044341119821287064, 0.6591885039276567, 2.059298567099216, 1.7613722826726421, 1.4551241218501483, 1.3806144026805007, -1.5089488339733397},
    {-0.13461682346059195, 0.2289029498781698, 1.0937235804658791, 1.0153278875321055, -0.30505934215141184, 0.02650159869003052, 0.6247116045948315, 0.9070224524260804, 0.2943910751411816, -0.13545240353662208, -0.0961619052940607, 1.9200462476198517, -0.24766715971244319, -0.5570971063005572, 0.45426958642158827, -0.1989542887247745},
    {0.4605565305105426, 1.0508525661670471, 0.9653404571718669, 0.1455825416237566, -0.3369470025008848, -0.18354693877223724, 1.3153184470519623, 1.372156025425818, 1.726107342596442, -0.09552618368037304, 1.5028007678458943, 0.9510688337420924, 1.4494185491247742, 1.0831854752427734, 1.566018741788414, -1.0190709119257113},
    {-0.454575724066456, -0.20655473790130532, 0.6797405020913908, -0.00577876942922822, -0.8689218948957035, -0.09201721544296265, 1.1244123574900269, 0.42023309347329174, 1.1300871083621757, 0.2602587126421099, 0.2798538233914156, 0.02919575037024594, 0.5954612337869083, 1.0627007918874207, 0.8562865628028435, -0.45548599566111797},
    {0.4297514612500199, 1.1143527807258262, 1.1224152828265033, 0.3152040528823757, -0.6355453352509087, 0.279364971188835, 0.5869800698215912, 1.2412190470525049, -0.1147281819192727, 0.7162033081125654, 1.2082112579466873, 1.0190950359726043, 0.7091294279885577, 0.6362232368761191, 1.2827122532850894, 0.3640667332060705},
    {-0.1434952597623541, 0.34945544989947414, 0.09954111866042242, -0.25736219638841784, 0.8269949536856094, 0.2154580191198746, -0.18742267990960484, 0.42098824111288086, 1.0391724316370567, 0.5268537681483507, 0.291785869113178, 1.167043681799547, 1.4223621239319126, 0.7430344231931298, -0.23479760653494056, -0.21368419517876758},
    {-0.13194149049313697, 0.5991840468588148, 0.11934872590519126, -0.3957663498730617, 0.3546014505122665, 0.23248624863898698, -0.3043048092256013, 1.3021736835890634, -0.12615617265787443, -0.09942675578756029, 0.43271244550688415, 0.9521883120678128, 1.0358841130815482, 1.1162672721391478, 0.8213519929438545, -0.7262734932807297},
    {-0.7663241050153954, 0.7020321412236934, 0.026410423588623194, -0.5949697726715684, 0.5575033845759392, -1.0657706115068315, -0.34509433079534974, 1.2023253074865583, 1.6428616217375518, 0.857857350805017, 0.1901569808447899, 1.6848376453799054, 0.843068172777591, 1.2882575196745822, 0.35862774671092384, -1.4074236973557535},
    {0.227423901429057, 1.2165544550307754, 0.41441117191716254, -0.5750746472215108, 0.7009827011262536, -0.3086211413934801, 0.060627988660581986, 1.549708873261577, -0.33695592439305344, -0.7852291445592895, -0.5867297791939131, 1.367165622784944, 0.8647662166318083, -0.4764470250519689, 1.0276643223956736, -0.30077718707613393},
    {0.41972593391332885, 0.5667919092948005, -0.031964528216814184, -0.9625356663623985, 1.6929571738024138, -0.8680356456079547, -0.7006913616281512, 0.4976371657976456, 0.9032753543740067, 0.7600330349593525, -0.22323179185486097, 1.7502429143073674, 0.815604076865702, 0.052792460970416684, 0.9864089357306886, -0.2701892529812552},
    {-0.040544454001559704, -0.22335134249582717, -0.713193411142649, -1.2032540641016016, 1.01446329474219, -0.2780191966210082, -0.14424697164243616, 0.9285944127965063, 0.5155372193906678, 0.372504065809951, 0.23181062694079635, 0.6917202986654679, 0.9409823876199201, 0.6101397045939655, 0.7518516927612693, -0.3592114811373849},
    {-0.5236862470605805, -0.1603643940102791, -0.8382094304475862, -1.4571886779712955, 1.544343773268965, 0.08931134325560063, -1.1701319179260516, -0.232126179682102, -1.0273037594185612, -0.19598966488980135, -0.14707268414020325, 0.3278011625695444, 0.4910471945293849, -0.36932792758257527, 0.1837073905599087, -0.27613062681318473},
    {-0.8786619642019841, 0.13759140439684855, -0.9167017068685396, -0.7004543655096552, 1.6846312056315627, -0.8192974154897469, -0.8201780472478399, -0.051578408149970445, 0.20592953765113137, 0.4609352522131057, -1.109536625622223, 0.820447424099049, 0.4717887291993548, -0.40224747318900816, -0.41736922194765286, -1.5256222087921418},
    {0.2436949794080987, 0.6163049759914028, -0.10847305069947291, -0.29360878331767226, 0.7286854705332956, -0.8439952516642004, 0.519547518113454, 0.5280654848455615, -0.9267344941024742, -0.009261947875279418, -0.8252861360384416, 0.15654650281105453, 0.2379019330083198, -0.47778125877023125, 0.4157085430291766, 0.7171356813653561},
    {-0.4547692535870963, -0.08091015108941635, -0.22873583459750446, -0.9323988471315617, 0.3524017301886703, -0.7985170095749466, -0.3105849860151523, -0.3294746001335563, 0.935952150437508, -0.12082601057502639, -0.12740317419100933, 0.6323456182563524, 1.4300922874440285, 0.906888641881444, 0.5924355369939021, -0.7935893965788002},
    {0.45568205243682475, -0.1269444508877393, -0.6460550758593885, 0.18258748149300325, -1.113736667344493, -1.2100042894865362, 0.23054168648631654, -0.02457710672930121, -0.31075281145025185, -0.14325003174056852, 0.06559772332086529, -0.7317072201938282, -0.058887272470837256, 0.08329733452074307, 0.6220649738674638, -0.637928648080785},
    {-0.7045723719367726, 1.591917231589323, -1.6453547937537387, -0.5262088443392359, 1.1442986116368494, -0.2290969919234422, -0.9258422506526482, 1.607363418192648, -0.5960746146875433, -0.9213903850815333, 1.7341625542993548, 2.0336963389810094, -1.3585845344298508, -1.256411174326924, 0.9911037242929752, -0.9933045768367208},
    {-0.7164180825831695, 0.723321579136402, -1.42632929994227, -0.489064492392268, 0.7797505132023794, -0.2606441520353142, -1.4350940813325244, 0.9786218484929189, -0.7574381928661782, -1.5913849816643506, 1.4250542948690825, 1.209031312743441, -0.423833834822043, -0.8361857626792552, 0.8664151429824757, -0.356011544237125},
    {-0.16400987311406415, 1.716948046963321, -0.6456621276722486, 0.31821471276043617, 1.5879715488916042, -0.23942789744885637, -1.0212736853796625, 1.3090220943078712, 0.050554819449949065, -1.2050798180222004, 1.5841593071208493, 1.4406115002754214, -0.4147865926615491, -0.13871080868700325, 1.8862444959496165, 0.453766359137602},
    {-0.12182354130793606, 1.2932886830013135, -0.7867932309451978, 0.13271161269230558, 1.2036087320050786, -0.36874392105751075, -0.7411230715477054, 0.8931274874510134, -0.6181228091038093, -1.310509353042323, 1.101771909453313, 1.3636665465119677, -0.9640148275106202, -1.196604919911867, 1.6554254108205098, 0.3043538544033264},
    {0.15100569588684137, 1.262524762790434, -0.7518869699268129, -0.5863520009392785, 0.9613079496002227, -0.15192895559268965, -0.017157361816343916, 1.070050555783472, -0.44370491081732893, -0.4565933012616145, 0.8481714648443187, 0.7902577534222026, -0.7010181612570626, -1.085864947192842, 0.8208227238308108, -0.2539043516442582},
    {-0.023091690534341274, 0.7876806118681557, -0.5551334171410116, -0.09175335097493022, 0.5258922223026193, -0.11425800416780106, -0.09504161111942856, 0.7602357984449191, -0.3260732949164235, -0.829360400834755, 0.45064883633304803, 0.5378119709429686, -0.6773785867557948, -0.610671879121679, 0.45943215647598823, -0.026358828203694337},
    {-0.4209315590213086, 0.7753801824590874, -0.3172859233628746, -0.009509728080633812, 1.0992397264148166, -0.04470657609215343, -0.18366943739435554, 0.5267496706825899, -0.24950462842322155, -1.3049593782754856, 0.37544755758560366, 0.6054627418776135, -0.6307793728785359, -0.8194002084064582, 0.9527467680058224, -0.29217270412418006},
    {-0.29248609811449844, 0.9699651638813205, -0.13760255135970623, 0.4330218433694926, 0.14450212939632961, -0.39493459033028455, -0.021457147464425626, 0.9754993077264914, -0.6249223586895071, 0.02538096717712276, 0.3877424467579869, 0.5356486522156372, -0.173158045617818, -0.19727636269644339, 1.0546078101787617, 0.23625228983688368},
    {-0.17183440527425844, 1.188888496929404, -0.4867448247352905, -0.42039757077871087, 0.10157935782432212, -0.5859641782748014, -0.35889840652297106, 1.2493569562715703, -0.9246414829880384, -1.0816410696768886, 0.5007539697343174, 0.28146213587754976, -0.9858774667902668, -0.5505435318936969, 1.1613869679547573, -0.2128190018588464},
    {-0.2780559598807551, -0.2923435144339552, 0.2819374546419245, 0.31877316495200697, 0.12568036869715396, 0.1939603562014958, -0.6244362661889151, -0.4425086091844744, -0.6542203886187773, -0.3159412821765044, -0.1747087400369297, 0.015437323733634614, -0.40178290537207284, 0.05319358125322032, -0.042093402810473995, -0.05388488256242465},
    {-0.13862365219216652, 0.4128319343707318, -0.17997138837818127, 0.15382105226394796, 0.5130157260710682, 0.4640514410951475, -0.011914111553879572, -0.24873716613350744, -0.36241600145285846, 0.58335291183203, 0.21633213547124205, 1.0096834958137806, -0.35901791297239705, -0.39592426713853, 0.5792363253187609, 0.28537181752128393},
    {0.4966785833596465, 0.46021110554355066, 0.2880233723899298, 0.35756907672985627, 0.7309467385023167, 0.3012330043064358, 0.8136562447807092, 0.7825587350663281, 0.31324883495650296, 0.2212387640177797, 0.34726473439703515, 0.8812614759861174, 0.8676977931881015, 0.4925838175600334, 1.0985358267467504, 0.15367153843785822},
    {0.06728769393812915, -0.5037326707188495, 0.2683760998457791, 0.477847213783141, -0.426104901051839, 0.31990463154668336, 0.06418109757865932, -0.1500418098815589, 0.8892685499680546, 0.8452212758046223, 0.11792874452177377, -0.06669596825029664, 0.6083695021500773, 0.3627664555386444, 0.5247747417530693, 0.06878045467190494},
    {-0.6809202994227852, 0.24495969342459536, -0.28523690865113244, -0.12793176865995204, -0.4877255453828878, -0.198273490268711, -1.066859047017393, 0.020374872094112637, -0.8379362686056107, -0.08711150540507029, -0.1195487025887494, -0.21858277750924934, -0.5183953179709232, -0.5288026961566956, 0.2888951333896374, -0.24866129611504467},
    {0.1872066277310085, 1.267011580853755, -0.08882949014163398, 0.5376707898981963, 0.36463371201511546, -0.03293011269675477, -0.1492765346625221, 0.9084363289205752, 0.01949771605833338, 0.28209139568344005, 0.9374264927065883, -0.18633309399560682, -0.31646367387397445, 0.16904777748560657, 1.6652796128091285, 0.1123352315540275},
    {-0.16879837407243106, 0.44832504638108445, -0.26470299221165516, -0.3029836318900306, 0.7656631488528916, 0.17496889780199915, -0.2425099592077361, -0.0021816654999080877, 0.20772877912777032, -0.6401236758639419, 0.5072983357440217, 0.1685877737051684, 0.3760017225599647, -0.47937702995864234, 0.8041692134319288, 0.010814794799389032},
    {0.0039484886643730375, -0.467645152738439, 0.4239084684353383, -0.3298019689813463, -0.5579200958560983, -0.03894856815458892, -0.12465811430631468, -0.31660040707002335, -0.34470329618989143, 0.11297179831407637, -0.3640572261406341, -0.15988648508675093, -0.03907787595072436, 0.7401004876303221, 0.034711273663771317, -0.32619656626217225},
    {-0.21764562215068953, 0.11988698791661266, -0.6124026701781543, -0.4755210529974613, -0.17626154205920908, -0.2507488059042291, -0.836590552779068, 0.00788849228569959, -0.6369320528500069, -1.0608887879234956, -0.34637551525407717, -0.5415253088870277, -1.0438113824387072, -0.9264937865144597, 0.10972474597472413, -0.25610901306506145},
    {0.3843588359724856, 0.2761827904043319, 0.41081543271773735, 0.13986289730294907, 0.4955000610211208, 0.46850525492598394, -0.15449670033047658, 0.44355558716480925, 0.6023467893580107, 1.006178827942148, 0.5423757531508301, 0.6115378887429965, 0.6798833287940688, 0.22331820147159942, 0.9257253156144438, 0.6357131405224036},
    {0.3207436368307661, -0.6367336831076753, -0.39776951830559437, -0.005750646621731642, -0.8616706012161239, 0.18446353269895135, -0.25309871289060587, -0.41606843015151834, -0.70809398609839, -0.41613731929221076, -0.3972799890532063, -0.7808782838361636, -0.42669227597260523, -0.6210749821929661, -0.2248323655075455, -0.12722197368343352},
    {0.30740609294394006, 0.05705657069065571, 0.32821635908123775, -0.11351383646484811, 0.27020290190018004, 0.4584605210475459, 0.6059990671531759, 0.6325464595237572, -0.35560013022637155, -0.09114477066108767, -0.2233505509469941, 0.4613986236315477, 0.1550662460429665, 0.26366466398166494, 0.953730914331773, 0.5858152895116463},
    {0.7943828117885645, -0.16325498429095292, 0.12538505365905145, 0.19380562347168392, -0.16321817665602184, 0.23913442046333433, 0.44818461094035555, 0.5629879697356966, 0.16752887996481358, 0.34144756354302425, 0.6029297776136939, 0.10740354038961412, -0.017462679629633323, 0.1158418802329214, 0.9337620759012518, 0.4032125769758175},
    {0.43425680396843214, 0.8405108780145019, 0.4069354044622756, 0.5662577775530143, 0.9471284445780396, 0.44205197368793636, -0.09435034101141851, 1.0695292541714112, 0.6434237954874569, 0.4925109672950551, 0.4939678369972227, 0.7960036475262064, -0.04579562112327143, 0.3532334293635959, 1.4406447675553653, 0.015508398883969198},
    {0.16502395818791693, -1.0852870248401902, 0.2670435555072596, 0.01614605557022926, 0.0156080880607931, 0.19687167874884937, 0.3664218556431119, -0.11601376186854284, 0.37588251805878203, 0.6913740695624115, -0.37935999065557247, -0.07375844638842094, 0.11040437980211769, 0.026418482843686385, 0.024251159296511827, -0.3999094479349898},
    {0.39028170911393134, 0.10022259200163591, -0.06163250089233575, -0.17302518112385395, 0.45684806254019417, -0.057341614162009245, 0.16823042435001825, 0.7459705691363705, -0.25738098434040935, -0.8543493503300317, 0.17969326614152706, 0.4175560260108773, -0.033181464749838276, -0.04775704629784736, 0.7012639280259815, 0.16653181032909928},
    {-0.08727265972140083, -0.8087730555711868, -0.7306736712732596, -0.6625829146254173, -0.381577128588578, -0.5836613765344729, -0.008460579080286414, -0.37327417358260245, -0.39429876228774335, -0.9726318575726474, -0.19188664205119937, -0.9073514116171556, -0.9451472026342006, -0.7054042313443529, -0.0899414654724543, 0.11722437203505133},
    {-0.5020296158978274, -0.176723689989548, 0.2082156087963384, 0.3001289011193562, 0.17455375934916129, 0.051980971232765294, -0.6713950395359118, -0.3242063073272479, 0.08007204139290955, -0.30360464086912026, -0.20417064037117155, -0.3852788885842229, 0.027539596946410186, -0.28910882978920954, 0.16240651745237925, -0.24555985931652333},
    {-0.4143798972355485, -0.9804980399012169, -0.40308662017656527, -0.5056911430080864, -0.2389697612396204, -0.30272184864833124, 0.1382291551484293, -0.7017462310395125, -0.2893635596741379, -0.7851575564524034, -0.7535751368690644, -0.5588106143786469, 0.3439120691981049, -0.28372233414148423, -0.6301565399208796, -0.23992949794325902},
    {-0.3127615466384485, 0.5882071116514627, 0.19611079511183285, 0.17860086000781478, 0.5715907880349573, 0.2772485163933797, -0.5497781210629902, -0.05276268090657622, 0.44921283449373056, -0.7566241987633622, 0.32561046506429153, 0.2965282999467211, 0.23476609695822967, -0.1439997058681343, 0.33895712632110336, 0.016070264468848655},
    {0.570910332369714, 0.7546917923042625, 0.13330161263715457, -0.040816437837851355, -0.11579365096063886, 0.34628709905673805, 0.3623961958057426, 0.6323297200747413, 0.13004278977013076, -0.15763848225383204, 0.4869653276996917, 0.4471983693532132, -0.2982211004511334, -0.3354306355165417, 1.4286314083672598, 0.06565062583112981},
    {0.15380695061942914, -1.4103894198603062, -0.14054736288650818, 0.06116506188614756, -0.9968681942336666, -0.24481939724790364, -0.23860460993664045, -1.200514505946492, 0.012044842982019651, -0.7132475932024461, -0.8032266509977414, -1.3499693328838982, -0.3014310008707958, -0.3080765512891469, -0.8930404541954541, -0.18208188104584053},
    {-0.21111563913216555, 0.8205012495148881, -0.42721397449368825, -0.49982704181518206, 0.01796653710134728, -0.7768325741935701, 0.40699781782586486, 0.6670894863201778, -0.7535419324533168, -0.24535279229792886, 0.47576238486368716, -0.46985135648110127, -0.8422779508198808, -0.4177679261645508, 0.7275249690396501, -0.435653764565513},
    {-0.27722474880790304, 0.43748441471582217, 0.03396732476778408, -0.2563987730027933, 0.4766521939018577, -0.03299863603543909, 0.03173928714317907, 0.6618718534240696, 0.038422252675751827, 0.24670494108107768, 0.2282193294345358, 0.5261938125721645, 0.08116983937866798, -0.30942969504792506, -0.02569294551500917, -0.014435240250983855},
    {0.4470094231417593, 0.5743628674530359, 0.1523883664206222, 0.28843001670098256, 0.02209319931362598, -0.03621070732916875, 0.5586040782647015, 0.7640495002013017, 0.27827139467093015, 0.5484639170783525, 0.5612957011764264, 0.15334321385620175, 0.06713301488540847, 0.4272500938024858, 0.22666180699329727, 0.5864057150546161},
    {0.40013732514086175, 0.05613477671348314, 0.5850061535441521, 0.4419685536435319, 0.27496167825917256, 0.3511560042226841, 0.395027320332693, 0.7272928833743516, 0.16902308676537192, 1.0410894587833814, -0.07244022440938344, 0.6482476399634463, 0.5840390057216283, 0.44294907780855214, 0.21005440984634285, -0.07024765587367732},
    {0.05432100502864528, 0.5001677616334578, 0.1837480064597399, 0.09267566442242546, 0.40624138949738375, 0.21262406831654648, 0.008209073473654798, 0.4139642899347771, 0.21810201811832905, 0.30856653551252605, 0.48716643098319967, 0.5089900436807474, 0.0965998252759783, 0.31351786018664407, 0.32573818067237403, 0.1858669431245513},
    {-0.1338500880817945, 0.12243801033960512, -0.2969290656843221, 0.29834583392073893, 0.38672692221152877, 0.052551103893710364, -0.4217436669273809, -0.013192183555345047, 0.007755126899668785, 0.022590504123501172, -0.14819997078820887, 0.22140682675924606, -0.20806689550802246, -0.22271334929845946, 0.2980466357017954, 0.11468380053226256},
    {-0.39988259925822006, 0.3706308144394364, -0.20867529933511128, -0.11594391819177108, 0.22722924571359354, -0.2281804454251451, -0.37149253012763245, -0.10654723951756241, 0.032602061046050186, -0.3240011689126225, 0.14762517113328896, -0.13702539208993825, -0.012479807004126939, 0.04653774075027205, -0.22925434863737676, -0.35213067416373706},
    {-0.2506968793398254, 0.6642073790791967, 0.1469585402746802, 0.15904963736385974, 0.6416156121713146, 0.07621896921008466, -0.346430153858657, 0.4872181966455043, -0.1807384449739923, -0.14494472870900296, 0.2647919642245088, 0.2470836019624069, -0.1006065664729013, 0.07095020325368705, 0.503237897667699, -0.05498897256785274},
    {-0.2128719130850557, 0.032120463897991856, 0.3403989956416978, 0.10160963512094585, 0.24915716692670858, 0.1890058077525283, -0.27210830866786345, 0.050034700530160243, 0.027985766040342527, 0.738430822741624, 0.0021903401166799303, 0.7844986415551817, 0.004811251522335926, 0.35604063577788836, -0.23478260263469714, -0.21711200848745552},
    {0.021070937681956343, -0.5820747504231215, 0.24568130311752162, 0.3146426071735465, 0.2728739177304752, 0.10826131836111516, -0.28468709661003744, -0.11757494515351358, 0.11359966499632124, 0.9320578508682824, -0.11576659667472972, -0.22627239595452175, -0.11050319027852579, 0.16919588546500253, -0.30645945340274316, -0.09074591199812869},
    {-0.09547800566240854, 0.32650682628422245, -0.1837963847149306, -0.5178917781930613, 0.0999666371623749, -0.10844785668574417, -0.3102173954714637, 0.2420898398634777, -0.35601864889901497, -0.23033296964793876, 0.0356503362926111, -0.39322011396256906, -0.6461612572765255, -0.8775400088998276, -0.27830602954655653, 0.06700014745807036},
    {-0.0773764353208136, 0.29560871304110736, -0.39292615156110966, -0.2650969067914546, -0.7506748784396577, 0.001289474535308112, -0.09242754131657038, 0.3639784291676309, -0.19325001521165913, 0.29546354418176807, 0.21752337702650196, -0.30098775277327916, -0.6486897619872386, -0.5596853413282106, -0.27334596231872954, 0.2874691324372984},
    {-0.0010466077705380019, 0.39793007658234036, -0.25607963709792486, -0.24115167420159433, 0.028923095838276926, -0.3208780362457011, 0.04846715075185252, 0.4971602803938151, -0.8015172661772845, -0.5465018424569243, 0.17287698913966454, 0.31764595814693447, -1.0728175330772918, -0.32793372422058403, 0.2817241476037613, -0.440663623266447},
    {0.13226953525255136, 0.5342422511316037, 0.3172172884577956, 0.24990809696570793, 0.24454967131385585, 0.23040161171669102, 0.4616972891889771, 0.1169412803658322, 0.06637888420947882, 0.07584968934605585, 0.26238763241743374, 0.7058100264035716, 0.30119640097695016, 1.0559983870358816, 0.30312206161470073, 0.32654880722396856},
    {0.11909506866194429, 0.14091534989608803, 0.2868140280865501, 0.22760776700302, 0.4472648957687595, 0.5124668075549687, 0.38210957475753515, 0.10247682955916966, 0.5339232404132132, -0.26692228180630917, 0.35817600811841405, 0.9257923103248881, 0.2103869272674428, 0.7578666154279486, 0.5645417339631694, 0.5150970602889486},
    {0.14218431186114508, 0.06344635590231762, 0.1952019909015021, 0.29357128351200823, 0.17450932983600015, 0.09904122947830368, 0.2968912898380472, 0.07183833085668408, -0.1406677125211135, 0.46399387280849724, -0.1738493720304048, -0.18659896208186294, 0.2820521270395713, 0.27738359431896625, 0.47336267003794325, -0.09646884260489792},
    {0.064994241596109, 0.08669821137018065, -0.454068071146346, -0.5465134813352223, -0.008989233423552175, -0.2608079102284848, 0.38719380985667695, 0.0660411723919887, -0.30800255122955006, 0.21968767146991483, 0.10255109661900996, 0.18428640211678515, -0.3998656758363929, 0.006307839569604371, 0.7461761784372802, -0.3777250963395484},
    {-0.0859074406059152, 0.7764218792426674, 0.447326578923252, 0.015569621147733588, 0.48777786280123353, 0.30054049018109985, 0.3071533851422906, 0.613276991848666, 0.23531558202911834, 0.7691766837989975, 0.3781949306161, 0.727740503297654, 0.493175365940968, 0.2418745014272885, 0.8814828516741297, -0.16287916584848042},
    {0.35818352478946747, 0.24906541993861112, 0.03160435297592734, -0.019511460895474182, 0.43360619464324446, 0.2788175837101108, -0.3560020121987192, 0.08595624620338638, -0.006247378724973904, -0.3046275175837989, 0.038460486951243184, 0.3262404438445101, -0.025967859664717766, -0.183878597246064, 0.35992989013210847, -0.14756123041197622},
    {-0.5069702857809703, -0.3620893382492022, 0.030039841187796575, 0.003366878278347046, 0.26976209864587924, 0.173754810626245, -0.7275129219392618, -0.15679581181290636, 0.1138667589161894, 0.21828336705147733, -0.34704078471775734, -0.12878385765804776, -0.07202951261119109, -0.5337988637842828, -0.6375679695135081, 0.07151279700505922},
    {-0.24686150971200765, 0.16112222365962733, 0.23606054872116897, 0.2842367036104929, 0.6386212709915314, 0.28836271097499544, -0.4453074896773154, 0.3238701614839312, 0.5702654724392455, 0.31163475519493283, 0.26865800869716777, 0.36819805277339157, 0.4016121862162539, 0.10891330674249035, -0.056223421839529, 0.022339917617688384},
    {0.0026424685170426112, -0.1102128371513031, -0.4355998238447295, 0.01416142969061868, 0.07221207080474336, -0.24392574926074123, -0.03875108148982205, -0.3402623445948729, -0.1681183453115906, -0.7137643500792068, -0.019057633777932452, -0.14837570040013673, -0.28946281711070526, -0.7154767745961724, -0.04196475478991916, 0.233627486586712},
    {0.7922903813622233, 0.3408115656496521, -0.03242183928831862, 0.004621236110107275, 0.2553641016082638, 0.13336462711484778, 0.7837052029523752, 0.8139832877185572, 0.8563597876235912, 0.1282345129839261, 0.3361417982635681, -0.09432111765319565, 0.5827057957399339, -0.18414465888968748, 0.8179827065536154, 0.23202344301243635},
    {0.2359773579483874, 0.5883105076641444, -0.026062450027869825, 0.044407365304014346, -0.00133596724145343, -0.08371547195109348, 0.2630878739842852, 0.1712044552707663, 0.1933449627238956, 0.15592368041517993, 0.4129431932289495, 0.12989319650270767, 0.32169393905963, 0.07919216006006675, 0.6902065003866088, 0.23972499643180312},
    {-0.4284577352465219, -0.08072714388380779, -0.09052331948162184, -0.17762816979426171, 0.04713784333924407, -0.05233990911502171, -0.42190427991645774, -0.3337896773678365, -0.3137197789949908, -0.7867967925956416, -0.262087039352151, -0.14637625934404125, -0.11033032562052368, 0.3906159277687478, -0.14118865741131414, -0.23034995624781746},
    {-0.4654149306442824, 0.34954142907259944, -0.07125733899450058, -0.38138541491113276, 0.9530313392750418, -0.3454139717437982, -0.6400456991255972, 0.13395093730907306, -0.1483375914271166, -0.6893953999041105, 0.07946730557361671, 0.741981104689707, -0.08665524111120751, -0.07586097125962077, 0.132349938787424, -0.4994194592822801},
    {0.47761389970334023, 0.4376414409812882, 0.4903990084631328, -0.07178037314386773, 0.09975185219043535, 0.17594900697200858, 0.4005157199614591, 0.28522975148399565, 0.12225306392059995, 0.2826214380203827, -0.13726317738368982, 0.7716914779116917, 0.35384328815195054, 0.5769506857150164, 0.14082225246209115, 0.18290650618220974},
    {-0.04647528542702351, -0.5124097444446432, -0.5468923364413294, -0.2569049725349776, -0.48851294202442386, -0.45049056798619375, -0.5385141152771136, -0.7131543967013012, -0.7296149043715625, -0.4654147409673585, -0.7503727480921585, -0.8196157811549528, -0.9861707365382949, -0.4015554624518869, -0.3339324876160458, -0.23285552200560614},
    {-0.2057015185987503, -0.3260200656719967, 0.05723955142973379, 0.4304046568307069, 0.4136437125543096, 0.10051504857982314, -0.09908183708695506, -0.15342755782291692, 0.05029676132109747, 0.03130152558662964, -0.34562033293831984, 0.1841380976319705, 0.23536712846916202, 0.42321386149762985, -0.03830516483160572, -0.2735592193384564},
    {-0.9264768248292775, 1.2368737219607442, -1.6012951151449548, -0.5806132763096963, 1.864898152114893, -0.5327273841916128, -0.6965432274016495, 1.4065497939916634, -0.3777139251468122, -0.9973327018877832, 1.929832386871526, 2.2755800246259468, -1.2952831966093716, -1.7266210706179694, 0.4475910374658476, -1.4037044910420424},
    {-1.313261973694689, -0.42919349268508483, -0.5922757643909846, -0.4240894923204752, 1.5045221418431074, -0.9026746413267861, -1.0050241913782434, 0.10960604966619876, -1.1615432535517034, -0.8990447091905854, 0.9757072517282591, 1.4376633754073445, -0.144440513735273, -1.297038855206718, -0.8270935131294437, -1.4204623319684984},
    {-0.5992570644558557, 1.4028706460274547, -0.5579137712073754, 0.06537564096741921, 1.4003112923159406, -0.4948940344123789, -0.7404032604418632, 1.2158051278301736, -0.4208533128888775, -1.3260870131307028, 0.9154834923698429, 1.5136040896669511, -0.9347207367938059, -0.4942752014282923, 1.1505280622642045, 0.15755267786802807},
    {-0.3116475209791383, 1.4452303589323547, -0.4646777665100767, 0.05816141486708547, 1.355064361874977, -0.178670028415864, -0.7682530602030072, 1.068901485249111, -0.08322356750847551, -1.137461717830234, 0.9583152129474369, 1.499599991666055, -1.0205883364489157, -0.8804295296982257, 1.3702213303533397, 0.32357471502860624},
    {0.004095753125487422, 1.2891857829336295, 0.2973122619413931, -0.17180798619269938, 0.6807278415490948, 0.08136782547167894, 0.1353616305729839, 0.7927376131659155, 0.18261079735487484, 0.09367457742776694, 0.7577957230997959, 1.5883774724694188, 0.21957859757833192, -0.4444821349874129, 1.1804415687789753, -0.22868403226935774},
    {0.1865941384433876, 0.7043516407015231, 0.05757392964819059, -0.0028398740574167008, 0.6970985166162605, 0.04561487437546175, 0.22926730625406044, 0.6638681968569133, 0.7320408847746396, -0.2467321583172769, 0.39521805308474345, 1.748590314148985, 0.2951979407840855, -0.014513341036321136, 0.5014453697878578, -0.35268873293100494},
    {0.01952612984396373, -0.11865251617960712, -0.17287142690239693, -0.03472700093078057, -0.21454545090403854, -0.2931158960615744, -0.07022972442802325, 0.2556863708014989, -0.28324720214154714, -0.9192070009932223, 0.20396307602317376, 0.7268741129895094, -0.2353546546919313, -0.014718375897410872, 0.5904108561449916, 0.10790008609733348},
    {-0.3293688563384737, -0.01949769423610752, -0.09513961053024701, -0.2493254271320914, 0.2268355571122865, 0.09546308706032525, -0.7923180922889594, 0.3921056317796369, -0.008577424510214616, -0.08216393566652085, 0.07347733925913097, 0.4019444778985054, -0.04656829020370627, -0.0810487306349927, 0.39287006346853703, -0.44059760253710045},
    {-0.14046150084942194, 0.6726717289873696, -0.10258570226944148, 0.16251547383104795, 1.2070993269821084, -0.11915301042938971, -0.48575122803564774, 0.8369249285779646, -0.3596611223495305, -0.9748832205343348, 0.7122423929094889, 1.4801393033924344, -0.06333823427896353, -0.8650420687193057, 0.6128761536727515, -0.5958986932350779},
    {-0.5414887223577638, -0.5754109437380925, 0.22126197066127024, 0.5026185208973422, 0.4262664501039342, 0.029445708130286536, -0.7554977588858419, -0.5375800974161761, 0.4853354453166694, -0.1731806039985121, 0.30130318469916556, 0.07003443042492509, -0.11494692268460613, 0.4243808863847497, -0.3416517810133709, -0.1904366385673102},
    {-0.49087793451329925, -0.13223882048624094, -0.4123801398693521, -0.44826252511588244, 0.5316003928742172, -0.32596449741736055, -0.9429320236711569, -0.17164980552074505, -0.6223115440391472, -0.6773371849141514, -0.03437345812940526, 0.019367192189856865, -0.8819939072092808, -0.557089287196141, 0.08274316043140606, -0.7668016092250902},
    {0.07214728761259302, 0.47858292203875347, -0.05329715111616577, -0.09863855904358004, 0.4702755222069916, -0.19152221314235085, 0.21199220953541517, 0.5936107464626603, -0.35102299949921667, -0.06692491423873916, 0.48938734509470566, 0.36595394930253505, -0.19831314844096312, 0.2322481259702885, 0.3705676694760806, -0.05661625627865403},
    {-0.04347612680823879, -0.5290592150153289, -0.04533378115673944, 0.394945167838432, 0.30175926618292614, 0.36135587240285766, -0.4170744372033576, -0.365943624282454, 0.3797766469709657, 0.6088154843733629, -0.0812490653891848, 0.015813720111053996, 0.2988778393134972, 0.2172636013774123, -0.015276271572707566, -0.4270918732993512},
    {-1.0665748695456196, 0.013332506858447092, -0.48370494122283914, -0.5613896815185946, -0.3719956460811189, -0.5524933177661312, -1.2107070491976295, -0.04467767480086384, -0.5677970437136693, -0.7192807035633876, -0.168599994319963, -0.18191969279158182, -0.8611201306198222, -0.6309047135512805, 0.4096591404677444, -0.37380178294681876},
    {0.1332722667715403, 0.6243204604541192, 0.42398272853907604, 0.38844658776523067, 0.5596376564535366, -0.14586244121836517, -0.08873612367426348, 0.8182180038689371, 0.22228181884191284, 0.08001592467481684, 0.5390358608456569, 0.5497607840828688, 0.3029849189140544, 0.3056535204314415, 1.0445943535855622, -0.17218089323952007},
    {-0.0679446298968324, -0.4813554857825667, -0.5456365825723763, -0.39439703636775286, 0.1638569774026093, -0.39646180561338773, -0.6200909588371776, 0.0031160902532110044, 0.2805071748062357, -1.3067270198869745, 0.010523022035630207, 0.36481557576129503, -0.2086492342097488, -0.3275025667710186, -0.818946834483714, -0.4049600207903282},
    {-0.5126846895630315, -0.6814179657141086, -0.38182334048106553, -0.271011682637896, -0.0940881270927499, -0.41086647859303205, -0.2915037054880306, -0.289779747658478, -0.8051007730942118, -0.4534319560101447, -0.09063793334864113, -0.12258514395457348, -0.36132390801095926, -0.14297808149555943, -0.4601439578878008, -0.7508698157670289},
    {-0.8023552718814505, -0.020553836940546594, -0.6448028118884951, -0.6223210930348124, 0.3631015128580947, -0.26826060647444244, -0.6388713947665859, -0.03485633774181483, -0.7944163034348525, -0.7757643848244541, 0.045009991766783546, 0.13812088956145815, -0.7793469186271178, -0.9107713686083189, -0.24651588091812757, -0.5398507259276005},
    {-0.058823971714392013, -0.024337571645857002, -0.39714831219222385, 0.018652078990194543, 0.7746240619687416, -0.3171326574437248, -0.09336398455813048, 0.8310019956883511, -0.13097019340964275, 0.0757192853058853, 0.36361247338191965, 0.6128769613404007, -0.7654945762651721, -0.29253966351142024, 0.6828057423105681, -0.14160271719898243},
    {0.011344667041067732, 0.3831379093884492, -0.25166533756549775, -0.046632237318466684, -0.0033247559478356346, -0.21998535166054425, -0.34469413439644936, 0.19907417056544197, -0.2822120724896955, -0.29265850539751465, 0.205780379888551, 0.19902152246596597, -0.32653907081397626, -0.5760804580090523, 0.1305717649255024, -0.19542460319769583},
    {0.379309693253117, 0.2664132750090631, -0.09932815490949455, -0.02990356663631919, 0.7835403000024638, -0.2667641780586144, 0.48775510543184575, 0.6196696157392231, 0.14149328490790725, 0.5397292042927658, 0.10302729596455157, 0.49027410792201664, -0.29294465739415476, -0.16322425838053806, 0.7472299885345786, 0.24468606123377684},
    {-0.1460047846154881, -0.824547024404331, -0.03975891011247389, 0.17538762982238515, 0.06335619797777053, 0.21436692317512335, 0.10376004328327781, -0.46376130543971855, -0.01343670544890564, -0.12749279986868264, -0.4077569311716185, 0.19393199338992287, -0.009750438835016395, 0.15059342287596314, -0.6655465938196736, 0.16042799629254093},
    {0.2362720990825989, -0.14581196777092245, 0.16648505226640006, 0.5056633533958508, 0.6791699987700288, 0.3493142404557003, 0.06585687399889852, 0.36793341719125056, 0.2314341415195353, 0.547768754150654, -0.19179806310783334, 0.7499754306233671, 0.31149020328519367, 0.4266398551741081, 0.5649152113505762, -0.029751256801083287},
    {0.6604234155364577, 0.06151112744158902, 0.4566576129462262, 0.3138547890601177, 0.6829000737248765, 0.6517552943059497, 0.6493650429098641, 0.5118393847842982, 0.466840554569761, 1.1459022642378893, 0.08515481433529659, 0.7179762406782979, 0.9304452852567209, 0.9314642379600339, 0.9954531991165825, -0.06259840127602069},
    {-0.08610531381681578, -0.18772061349475525, -0.5438921927655691, -0.42174745266139474, 0.776128918112524, -0.24744491735075164, -0.010461924733128592, 0.5469022205970718, -0.12210771682763212, -1.1433325804410805, 0.3038285724527621, 0.32290589851760954, -0.44440067842033554, -0.15065132738717102, 0.7456984568343316, -0.1177526250190876},
    {0.3751567084021716, -0.35332810644985774, -0.38819724166835334, 0.116517158730198, -0.02141785231417103, 0.044872808506503596, 0.4415663812274034, -0.046204134225483584, 0.14517669052613522, 0.26157949059888175, -0.23273656056484265, -0.13165130358733085, 0.04646545133855586, -0.2769553052994976, 0.052834427617434586, -0.24593675543762275},
    {-0.22530970394030056, -0.18979272576902095, 0.08455114764578471, 0.08052061938578939, 0.3389881395386889, 0.3885951281731677, -0.4873894077359141, -0.049239381853241705, 0.5738427462775114, -0.2382348190416859, -0.043169071255930634, 0.562442933215918, 0.6678155808177486, -0.019544960120848956, -0.5424901691031238, -0.324293706473664},
    {-0.14497335897583602, -0.6140264355900615, -0.49284538280616186, -0.391326446820636, -0.579297533010799, -0.09394566921041832, 0.16140844493002385, -0.7442325368526629, -0.6310803985212042, -0.6558678828149037, -0.3090339858856359, -0.6571880142879464, -0.4588595696473529, -0.6065199229272963, -0.08148713488309131, -0.07890020959930846},
    {-0.6072222210901109, -0.049525707777430844, -0.31390445278066414, 0.23598979760208824, 0.26061161468521415, -0.17991390463703233, -1.051009102881138, -0.3097756937360622, 0.1891630989405644, -0.9416478788841639, -0.1396346207152607, -0.1653723489963319, -0.2360369487354805, -0.6545230397059901, -0.09631055162125265, -0.31624141910609976},
    {0.24583672423526773, 0.5026019760698305, -0.13296418086116604, -0.09738623919142578, -0.015985921601261745, -0.0432584333497619, 0.3064954138692545, 0.4174630172755954, 0.21455548571091007, -0.02370445637293831, 0.3660787665798813, 0.47572172428650794, -0.10177609898666033, -0.6032885874578205, 1.3166263326182899, 0.02599512423067047}
};

static const float b1[16] = {1.9515263650637809, 2.255388076593472, 1.9930864668672479, 2.077599171982671, 2.6649619509269984, 2.1219643795125287, 1.8807919377599684, 2.546969571563849, 2.1923402273022177, 2.011959737997932, 2.738339802561519, 2.860688797690796, 2.3242367354592743, 1.9017930060301083, 2.3555174822735236, 1.744387765084134};

static const float w2[16][12] = {
    {-1.5845798344007302, -1.2632305818901144, -1.2950110083991977, -1.2031734055525996, -0.12634582633303645, -1.629638432920754, -0.8382032732272475, -1.3747049038671333, -0.7963515144588409, -1.643725386535894, -0.6629756039483967, -1.0265790201127463},
    {-1.7059242380047581, -1.9202059255348143, -1.1806311344463805, -1.7058299044030076, -1.371390152856433, -2.180365211779039, -1.5380227236153061, -1.6999962493037224, -2.021732408920686, -1.1081009779574549, -0.9255271086817155, -2.1801861177085833},
    {-0.3875715855097847, -1.9329669869179527, -2.0649275356559054, -1.2469135187413813, -0.2605044371481726, -0.44046243465813145, -1.4046041039144261, -2.2846813742565346, -1.2652154037632675, -1.4713026453142524, -2.2236712173491635, -1.1491577697456907},
    {-1.4493792582779395, -1.0075838995034923, -1.0557667202790963, -1.6709231579332529, -0.9740467320614744, -0.9620754904067282, -1.4047677335771014, -0.3552375389930397, -1.460928699323246, -0.1804155958592975, -1.3451657025537003, -2.436628556849853},
    {-1.7886353047132266, -2.145596993153605, -2.0806212205302694, -1.1281484252631022, -1.7901609366261773, -2.0710885072452343, -1.6548611930723014, -2.3440793491018206, -1.148549205436907, -1.8595556002881806, 0.03295561407892651, -1.6308459575292762},
    {-1.8225369207720514, -1.8172453709182284, -1.8546208686991135, -2.4285033552055824, -1.828907846898871, -0.7399893003182694, 0.16620065047907268, 0.2051841661347153, -1.651329234668224, -1.0191015541782327, -0.751324135240195, 0.016699845230477798},
    {-0.7599270788935456, -1.0755303028052021, -1.552522044387564, -1.6402701413032446, -1.5751576312888607, -0.8731342182951296, -1.5253253196382877, -1.2477667028824273, -1.5744105975884097, -0.6852178305985404, -0.8007053837566317, -1.5593901572123274},
    {-1.8892658075709812, -1.498285877254874, -1.4315470399538464, -1.7127038363375744, -1.8124645736703633, -1.6900715518044134, -0.88292188299145, -1.9477702466783733, -1.5281857405084462, -0.817431476799732, -2.5881296869332653, -2.1815747916656654},
    {-0.319931972639, -0.20540304682174781, -1.2077073822143987, -1.1167369577418276, -1.567950669130429, -1.4874550699182882, -1.6785317465418688, -1.7120156679197442, -1.9015943519469174, -1.8779147303658064, -0.8112377294216158, -1.597465022828259},
    {-1.4565623585771852, -1.1378677115214058, -1.0906656509459498, -0.5510989568044958, -1.4496919810651812, -1.3261832890372203, -1.4390674647366497, -1.235712804922526, -1.638920389503701, -1.424352951532217, -0.6829083499495147, -1.5503471397222643},
    {-2.3575673829671593, -1.1417362906853947, -2.056581591671595, -1.8408277799466446, -1.8088952623566212, -0.5234031812375743, -1.0569222878146538, -2.466652944771231, -1.8945094588657887, -2.2207878531630962, -1.887391380599389, -0.9858579445405722},
    {-1.246893199894755, -0.9782171273553179, -2.0279894619811385, -1.7246204811084558, -1.3827617078577057, -1.4244539079786105, -2.4658270688178985, -0.6662471631629324, -1.4442826791995993, -2.110391159928019, -2.4627340926946437, -1.7637023296329748},
    {-2.4225969327232826, -2.0947877935975536, -0.8827158442815182, -2.4629775200709116, -1.16198463077904, -1.4885403149325052, -1.5763475237258626, -2.1350521335467456, -0.6703598090020985, -1.0603691562242212, -2.410558936864627, -1.0686520126922248},
    {-1.393838482053644, -0.9068157371027713, -0.7826460796985554, -1.1960077042972244, -1.7471484282477199, -1.6096922612066153, -0.5995688855079391, -1.6649939800529667, -1.312917393457286, -1.3124377361900517, -1.2575653118073828, -1.5305816978116977},
    {-1.282257071994998, -2.0801573403557314, -1.1296755909431446, -1.7138691901783631, -1.615962229614295, -1.651771744531467, -1.8948195229889073, -1.7448069724493889, -1.6956424051174377, -1.86545652386879, -1.9609680488146741, -0.9557796073488374},
    {-1.3341339489993882, -2.2672115274322335, -1.2912969238637206, 0.07121038061639885, -0.9063603425912803, -1.3215854486086953, -1.3637430970835438, -0.8345258707435814, -1.0236173007369984, -1.2657000978109074, -1.8997930811773136, -0.31271373094503707}
};

static const float b2[12] = {-0.991217270667993, -1.129180424441691, -1.1619106610271792, -0.7278554796667469, -1.0720293743966638, -0.6242634381384873, -1.459232918428506, -0.8522565346053492, -0.9218195772211438, -0.8868028326730232, -0.5180815878684624, -1.0592328258512154};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
