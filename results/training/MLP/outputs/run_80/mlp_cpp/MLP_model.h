#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.1890986602527703, -0.3501216968107012, -3.4079768518370996, -2.0228856251246823, 0.11847881714902207, -2.6173351149586477, -1.1373499864823824, -0.017359184561419053, 2.7265337272489085, -3.591184711030539, -1.0876867163925026, -0.7395653165117452, -0.6225826181922434, -3.2672430754447634, 2.8115545759353897, -2.0403430492225665, -2.28393697481641, -1.054490491949275, -1.761650101699427, 3.294262565280897, 0.4611181234170279, -2.815026061732967, -3.107012611983511, 0.6292353328564543, 1.3912477952166424, -2.1692612488621843, 0.28843867581213817, -2.1489735679358595, -1.1535377967396274, 0.2044927215785676, 0.709576605664676, 0.7864437581242667},
    {-0.5859024358706519, -2.6497131815309882, -0.9637106053136649, -1.1603548811896987, -0.9142309119640917, 0.041526018880073776, 2.8358452185684064, -1.4556353923735998, -2.9901646067049983, 0.5916868620127739, 2.0414273514901478, -0.01995577812463873, 0.8247954771642075, -0.8038376580503263, -2.330361804693381, -3.009380176427494, 3.4998777185141696, -0.7562317982523061, -1.4904701387599955, -0.4151248453306426, -2.120328296155141, 1.8341363382846034, -0.23356249017415506, 1.2043322901866687, -0.7350531073122453, 0.8933840282927646, -1.658221458435627, 2.709527927874451, -0.02735800479579315, 0.10862141862442298, -2.1835912126875514, 1.5941057809533832},
    {-0.08980926144500799, 0.375780460802066, 1.9388848702805004, 0.2519616661044213, 2.6600493674622188, 3.603483904434878, 0.1382167626017222, -1.4746246956468714, 0.9941681060652768, -0.9642360016896282, -0.22089986329831332, 0.03815288893751101, 1.3769633119643951, 2.631773536411998, 0.7535649911654391, 1.7770944786702934, 1.404546943063724, -0.7109642886540749, 1.5804135185596804, 0.08423478476970875, 2.5281787051866846, -0.2763777958286594, -0.030526984408669102, -0.6886917274564595, 3.155805435428209, 2.3693269225150875, 1.5270086708251032, 2.4417838729526866, 3.131328829752324, 0.7734300997887285, 0.11086108805260347, 2.5383630255353866},
    {2.5303019484229643, 1.0554808633344808, 1.3909588932302615, 3.776743540019562, 3.0058860433489634, 0.6078742025820139, 0.41888271715641817, 4.8071460850613805, 1.2455251892445194, -0.29370625738866235, -0.2000405643198749, -1.2496346024656915, 0.7287531669494818, 0.8445256978545566, 2.271135536814954, 3.4450889506999807, -2.588675976651032, 0.435167430126445, 3.9053625626314354, 1.7359163154443047, 2.2537548836811734, 0.47728276273151493, 0.8923000018675008, 2.2517446316977177, 1.4787169272099132, 1.9820088902375896, 2.608192645953204, 1.39454554882446, 0.8315556906440503, 0.37591412745340796, 3.9275489799610184, 3.024077925751626},
    {2.4077706351707873, 1.3056031691078016, 5.216278864642197, 4.389046474876663, 3.8398694169571823, 3.2305621465952, -1.946369491806619, -0.28063304293811653, -0.38458743496784303, 0.7056789078393522, 3.8482013595403397, 0.1399298239882946, -0.6512456945893732, 3.9130221449096196, 1.5109739744105288, 4.199571884996876, -0.7615374999589176, 3.491681156914409, 3.1019341157139237, 1.0062218534274332, 0.5256588946660835, 1.7608661386049438, 1.4229719808158499, 2.2601545977789868, 1.0079390665744066, 0.6956195671301687, 3.7312717489368286, 1.6837035792696264, 2.458405805696013, 1.8271117163518336, 1.5918627854867173, -0.9732334358639834},
    {1.7544262824617283, 0.44433052677999957, 3.3257584241641363, 1.4978291989858064, 4.306303290261943, 4.777826122280097, -1.2972368114764876, -1.1477277911217318, 0.23878637975798678, 0.13770577581745794, 3.8697145933938693, -0.48120612360195714, 2.055034703478631, 2.791907486204227, 2.301749141394516, 4.104793437257554, 0.03091979626753681, 4.660719523914486, 2.334220069139459, 2.990723715237933, 1.2702636438660575, 1.721184021684089, 2.2821757348969314, 2.202414845048816, 0.49286492551006494, 0.953353626222262, 3.1397735485892846, -2.077112320162872, -1.3851452899333334, -1.8682888974606562, 2.7364558169653614, -1.1767767417814017},
    {2.460088693791883, 1.5306855023917287, 4.031240296460125, 3.7280005136196483, 1.3303188854970611, 5.681600791363599, 0.35332028442645674, 2.034583917074223, 3.533300993530557, 0.42159519677484764, 2.2928370097916817, -1.673821371156614, -0.02061121392220347, 3.1294491681090144, 0.2257362059801329, 2.5294228208683394, 0.3102754069487292, 3.760925319032134, 5.287273299545217, 3.1119951103996963, 4.227336461940617, 1.584689185528007, 0.5518963681986951, 0.20697814618891194, 2.859867139524055, 2.5193756567185805, 3.8849479649030525, -3.588693274414282, 2.5450410129782153, 0.4138168500397842, 1.6620891395458444, 1.308349383850485},
    {2.356931827729657, 1.4731283670584017, 1.8579806626626076, 1.733646119042472, -0.5681429228587133, 2.5168226258288895, -0.9452742963802839, 0.060459186214345144, -1.1358117624453337, -0.8020889918033308, 1.8681936149700356, -3.603195635620666, -0.9678744044315579, 3.0546105893032878, 0.5707013168483053, 1.7251863518969612, 2.572030429108969, 0.6599433896995326, -0.7640903124926846, 1.3089771562929207, 2.355979770301144, 1.2558020574217559, -1.3848949787862705, 1.6690222093562028, 1.7698229928460136, -1.2727325541106096, 2.6999218526883, 1.1320568780892908, 2.2221311675706015, -0.8553313583496834, 2.5542279673099646, -2.7076952148836626},
    {2.3893208726627315, 0.5947231596435192, 2.5085142861528973, 1.4509197812397154, 1.2297724329847435, 0.5079829621749646, 2.1678357419699177, -0.5489507755053088, 0.2320034783959649, -2.283241714956109, 1.2731956277239012, -1.8530502893945464, 3.8417219777046876, 3.1494771593331357, 1.6340137110398014, 1.2322407094284593, 2.3719145924498375, 0.362288087084501, -0.23874345521601545, 2.858375546840986, 1.5823408253366975, 1.3056946589800607, -1.1157099007100786, 0.5563247509288958, 1.3248356045900087, 0.03542299343005845, 2.115512946851648, 0.914077254836237, 1.3969122146249715, 1.4099819443936241, 1.9360305112969174, 0.7810340628776968},
    {1.3198140367637294, 0.7460698166601861, -1.0211641962854145, 0.47566942559738445, 0.17900895770408676, -1.7488129023462067, 1.3506316346446103, -0.7843126407425594, -1.757435934915333, 0.3923868385234887, 0.7564428099452216, -2.6797359364435023, 0.8333882351083305, -0.9843915296430064, -3.4809200969881675, -0.6209071816629751, -0.359687371952045, -0.9021605727185161, -0.7985069695318168, -0.7180669336990263, 1.4052448477348216, 0.34140202549859, -0.2187206780427544, 0.5526528012436169, 1.231686766062914, 0.5635104790567105, -0.7620854588055023, 0.4898050652727637, 1.7061263469092662, -1.156758525344853, -0.7952953580045109, 0.36590974084881217},
    {-0.2725944214114713, 0.03581996873598242, 0.6012440595294177, 1.8580959995747286, -1.3589732213821755, -0.28735137793645876, 0.42817885243774795, 3.7480796289249714, -2.3103749645549034, 3.753930101916941, 1.2652139631631223, -3.0193684650688826, 0.8282152197549464, -0.6664363684661856, 1.2246673283181084, -0.8687179079308979, -0.5814324458729323, -1.2763047226862547, 1.3239351437387838, -1.8606022904790411, -0.32335689293749714, -0.38138336402121764, 1.9736532796668034, 0.2804760361879251, -0.7244877379820064, 0.6850081744184421, -0.08305079045518028, -1.2349884195958052, 0.09987590208275782, -2.06524484235825, -1.0500591988488952, 1.0712968631330981},
    {-2.6534663552073288, -0.32551635466494144, -0.21364405523633442, -0.8618163992475476, 0.415066327727248, -0.5230484736656147, 1.6201133844717026, 0.4658874077358011, -1.8592367098115887, 1.0733285705588578, 0.16095913809104617, 3.0261536024042903, -0.4025931090330176, 1.960771454858406, -1.487411990424236, -1.7445794899091425, 2.6943907347846134, -1.017819852737034, -0.881969613777421, -0.10581661951108316, -0.40204409304140254, 1.4678145581960544, -0.5184517602313362, 1.5798015875491558, -1.021905251242735, -1.3868383891618519, -0.6040473929594173, 1.4460097577806612, -0.337235227253147, 1.3141947481269773, 1.6828557039017946, -1.0110411062202944},
    {0.6892358375931633, -1.9538551096864456, -1.4486510090956715, -0.6763219142216798, -2.4079403782182136, -0.8960247164595017, 1.2996927877301865, -1.3799051430079998, -0.9349884289851215, 1.3965991441892756, 0.0578112576201952, -0.7262424231909956, 1.0707325392206424, -1.6263775539103205, -2.3313566465203035, -3.7784382450575884, 0.7771898437969501, 0.34811316235891665, 0.0010294682043412618, -1.6707290999794748, -1.7003927731172328, 0.16777356074911193, -0.1472916768640811, -2.4458970863370193, -0.19006759921484623, -0.8118775119966695, -1.8010890832587296, -0.9424110689745078, 0.9198644187548215, -0.31347546977330093, -2.13420850155711, -1.243893017508806},
    {1.0211900389503137, -0.04662982333549117, -1.0282389866264516, -0.12289989565800935, 1.8627755391380079, -2.298454664066451, 1.0394431118473701, 1.85433558595152, 4.121468191121085, 1.669661034806524, 1.0601919290750346, -1.2516169573687712, -1.3642459982978759, 1.1107380353556309, -1.4264527092656096, 1.6119828408581445, -0.011848322316848977, 2.949710595097016, 1.4318439231487967, -0.30070517761994164, 0.8602136596581299, 0.5504560875490356, 2.156596458065826, 0.9762539384990572, 0.2548996919372838, 2.2602111359312715, -0.07448436837777127, 2.4835731513384647, -1.3932766837077792, 1.9824282309451877, -0.517449541866391, 0.021379123551042666},
    {0.04344038784870485, -0.14649887305238263, -1.4595592199809841, -0.4803036064087678, -0.010710140758577817, -0.23355403498807517, -2.012447222709826, 0.7388988388493841, 2.2339208246794477, -0.18705334317996516, -1.2867015005161402, -1.2810254475805594, -4.059913614617965, 1.8699244728676656, -0.622512221390489, -0.47821026582879306, -0.08888644678410489, -0.7925440133847043, 2.0478162123937267, 0.9645278105692987, -4.500994207841429, 0.05186905175572726, 3.046790205543718, 1.1129996287654047, -3.5718347719615107, 1.3253202606274839, 0.1341619000055098, -1.2343192949380246, -0.8786997915149817, 0.05363801013358421, 0.6175341979765145, -2.2497717335190117},
    {0.4878251499710424, -2.789392791147922, -1.4015007008689278, -1.5808146220531631, -0.94093432331351, -0.5760258140021292, -1.6741259919194713, 0.8189515466883406, 1.2603381234042452, -0.1712904738063396, -0.6557585438458258, -1.4665668950644193, -1.325279784003723, -0.8786698519766096, -1.9048998861042779, -2.551792470849396, -0.5714142754654011, 0.6628535717365212, -2.8173085642490943, -2.0824773100641165, -1.8175793716888093, 0.41196413142609, 3.6509942973059193, -1.065863302436663, -4.941382264274996, 0.021650718768908343, 0.862695872060074, 0.7951401370971402, -2.462393164726601, -1.2795186840547406, -1.3614588942491184, -2.2406355030886864},
    {0.13118865922597356, -1.3152225736252767, 3.7722438229624418, 3.0088119867500493, -0.06276187659119406, 0.8112066676604294, 2.756811992316448, 1.448682982628661, 3.024157716225817, 3.3216011282159505, 1.0032562899775017, 0.5187650248652473, -1.5059149731963495, 1.179967929840269, 0.1334349502866308, 1.8114012151818721, -1.8632527381918584, 0.45375981647428026, 2.4661451509071957, 2.544334078718558, 1.8997640168552794, -0.6313268982422081, 2.8722590581012435, 3.8131186271548727, -0.04702298328615915, 1.0220584157793986, 0.7854052833815092, 1.8101469885118309, -3.082488448729041, 1.7876678147238876, 2.4908702067190154, -4.423978005482189},
    {1.8055248313749142, 0.41520726023396026, 0.9404045021001595, 1.740907413247494, -1.4111456025021107, 2.239372720527949, 0.09717627904767698, 1.3675840107473332, 2.056589793059986, 3.5426689400285474, 3.244415081383327, 1.1128024776921055, 1.0293083411555635, 2.2274168604474798, 2.1534021207032694, -1.7794040752159734, -2.666546113336813, 0.5448704701244117, 2.291143112149063, 2.4787163672040897, -0.39802599406245137, 0.1688137387029605, 4.789292317303836, 3.150341918524183, -0.6537926634038363, 0.35414721507073393, 1.055915610400095, 0.5909013779788722, -1.8527383128805655, 0.6879308962530077, -0.721376146755225, -0.5018320933095216},
    {3.3442403840955763, -0.9190958360147402, 1.1505329964529305, 1.6841916388132228, 1.068740167976094, -0.980486607815533, -0.15386170318715053, -0.3831927448026077, 4.2772459041958735, 0.9586528303273781, 1.4021210826313206, 1.305478598105315, -0.8018674022490971, 1.8538168674839446, 1.0082397324944123, -0.771114304294267, -1.6771819040971974, 2.3141299388743137, 2.777998393983937, 2.0620165494392935, -0.17242513999994408, -2.706611108923976, -1.035227270681775, -0.6803743423185175, -0.6984417586164933, -0.44097540049265077, 3.743148665737779, 1.1354564713422692, -2.0727604851001553, 0.7570790994330435, 2.0966081291358334, -2.181636114877594},
    {-0.699856516675063, 0.2659852365670645, -0.5492164523138805, 1.323973319905884, 2.262280907188242, -0.43808737576051454, 2.2286817325867236, 2.921453429647513, 1.3799969437242159, 3.0471372365462197, -1.3821314042742427, 0.06772394293879135, 0.09793233411817845, -1.049180548850732, 0.1275604765134826, 3.3305990292620016, 0.5220473082048549, 1.0886986601910538, 2.3070878992339923, -0.013049021484414784, 0.8455216902949204, 0.5809150307908464, -1.5324302471792044, 1.0405685647074032, 1.9762664119095583, 0.7131789077576807, 0.1101695267903261, 1.8103046476034923, -2.3299331144187407, -0.6702600364324336, 3.91417392859211, -0.746527792970321},
    {0.6421206485647325, 0.0390551140448171, -1.4581473160993996, 1.5985056266426998, 1.8663526141666587, 0.872141796820784, 2.5514235242027796, -0.5524547644550669, 1.3869862579287089, 3.2106123548346974, -0.25836533828692543, 0.9731307842061125, -3.484066290653318, 0.7199277744198991, 1.1702177912407523, 0.7833480343873314, 0.5663999378122975, -0.07098765592740643, -0.6790435638893463, 0.6371548105434607, 2.047954116465131, 0.37166309224551125, -0.7172031796749456, 1.9921197093238292, 1.5287640568750784, 0.9370617583444413, -0.8799263945653478, 1.5825359946683386, 0.3021801027631968, 0.5983037508178187, 0.9827211254559719, 0.931964045207827},
    {-0.4667656855432477, -0.2878525145719868, -1.2701921822489979, 1.21018903373388, 0.2609813632349272, -3.4006454659071155, -0.6817487268119452, 2.963832667094297, 0.1447646307770398, 3.060260463781271, 1.668323109578383, -0.08712679960129431, -2.00922532095042, -2.1074750452836093, -0.567177763269092, -0.07233968414548185, -2.422776001981936, 0.5697687239165729, 1.9080553372837625, 0.34510467191277505, -0.2612178155056262, 0.4025887175485463, 1.4266388912997527, 0.9150430685261983, 2.0089583941835287, 1.5719395583717604, -2.0788903553887277, -0.22226714611438755, -2.3267834227642443, 0.18063011016575375, 3.034630634843922, -0.7369207389524313},
    {0.04918947782739025, -0.746608605728558, -1.7052280493214695, 0.675610146388585, -1.6402705630028496, -1.551967774340123, -0.9126674469196115, 1.991856280607516, 2.3817474027303143, 2.7278835848148275, 1.306416283319452, -0.14433521165580712, -3.4706631526374254, -0.4982898209719169, 1.0302604113064362, 0.0843405908555964, -2.664809740438921, 0.04871651329213433, 1.2322887439016301, -0.6346390697340196, 0.4293928310985371, 1.2641187811628016, 0.27485214953065273, 1.7215217209878555, -0.49522299337793274, 2.320955453301375, -0.16336462232795043, -0.09136029550201002, -1.8778168238397965, -2.1268337079377595, 0.8445707943274475, -1.9074224781590259},
    {-0.6229253029709785, 0.09982839953220055, -1.3946184294436554, 0.7334775646272438, 1.3884756336573627, -0.5440515161039122, -2.143554805736823, -0.33281006554162973, -0.36615801526653874, 3.424123947012746, 0.9066632076752374, 3.589184082512742, -1.2398381949552106, -0.6836759904391893, -0.1923981373074297, -0.48708851168778183, -0.933920795892203, -0.28743842188854035, 1.1684621030337268, -3.5965011039632695, 1.4007411573552129, 2.610391076284126, 0.11221619902764408, -0.48252406168714823, -1.2766937852553746, 0.6132793193390507, -2.5388108955505517, 0.16824629949920633, -3.091995357671863, 0.9274130448563684, 1.2930471183840417, 0.4988805035239474},
    {3.1365283985216084, 3.0857919507290714, 1.2204078695868896, 0.05366756067662623, 2.0269111899051984, -0.33445754702068753, 1.7140381652217527, 1.4146083029026275, 2.15800264599053, 3.9257140597853377, 1.2352033993112475, 1.4952243854915386, -2.983521203242117, 1.4418521911825948, 2.7312858147089076, 0.5944453011353096, -0.9017415125237603, 0.4335378561186191, 1.6245783839443069, -1.4392192326895914, 2.189473502095115, 1.8063960381368112, 1.281132829292831, 3.221241435958701, 3.5624873128967347, 2.4862946728704607, 0.8708894895158217, 2.036406242454852, -0.8143711091552491, 0.23111042621936428, 3.3869358558233715, 1.1603684162515175},
    {-0.68758575063949, 0.6681431765077042, -0.31824447482063983, 0.8637234240872336, 0.7325671326126805, -0.4550921732174899, 1.546736002278527, 0.5349683561305715, -0.3128291913042797, 0.8359018812840594, -2.4965765542126057, 0.5637952093874974, -0.9335460260436759, -0.4350334206717546, 0.31875757791907927, -0.6139379005315231, 3.0262484262342997, -1.5207641141858375, 2.309203778144874, -2.7570745849246334, 2.6670690008194877, 1.3443708667585519, -1.1837652746240275, 2.1393388254669143, 1.7010946730401664, 0.2565664360146167, -2.7378791875690696, 2.2214572201116067, 0.00583083587560012, -0.2077386236605941, 3.4245730723500247, 2.335240554724097},
    {-3.366761239866508, 0.301022657773761, -0.7420438314723742, 0.3879600688890412, 0.31432985183356144, -3.6880862466903443, -0.1905693213476858, 1.1776749879458428, -1.3595020347644993, 0.726429737870078, -0.9014019179587646, 0.8759159034784169, -3.119657441616619, 0.2546681170586591, -4.1842857208781465, -1.7196438534856546, -0.9607211329590637, -2.129525061443522, -0.4695310179787754, -2.242198911454386, -1.5285484679101047, 2.53788708197723, -1.2792458996720861, 0.8576307849376451, -1.5029797126162865, -0.5069725041049923, -2.3308426203757566, -1.674561715056678, -3.907712513515771, 0.3796455741290565, -0.8005790397864962, 0.24202268933581272},
    {-0.22344836734690013, 1.8332290509841234, 0.2376214783694451, 0.555274773189704, -0.9474216618140656, 1.4411636097310452, -1.6205931704327068, 0.3441280784064896, -0.3399910212309627, -0.23479550581292324, -1.0790454034655506, 3.2844831885583767, -0.1512415436703524, -2.628574808546337, 0.625223439614118, 0.3841010640553559, -1.3120443556725, 1.5929341916550042, 1.977264600688812, -2.94276094481063, 0.4195546170599686, 0.323891543183457, 1.3183868995187416, 0.9108142940500865, -0.40199742844849484, -0.8237243191085855, -0.7407403630289872, -0.9317374737319885, -0.4344027512188813, 0.24185442744112287, -0.2817088124682091, 1.2117450876385567},
    {-0.3332271218954841, 1.7158579713466187, -1.3737022662004432, 2.6405167754431536, 2.0927822046818187, -0.12611483808448412, 1.1033559881694304, 1.981164469394165, -0.46161992923924333, 2.57607903877369, 1.285223859144411, 0.8028786120906133, -2.4762014919632507, -0.4325212345507573, -0.4552333863628076, 0.148044391643302, -1.5948978047623061, 1.0084188463906931, 3.7931910127747366, 1.5050325486175937, 1.1174914834928913, 1.4968782937282283, -0.8395019132042366, 4.265216769274097, 0.019905084178806626, 0.8695446532437446, -1.4961404849079143, -0.11843424893209496, -3.40688300414441, -1.133993126000044, 1.4436782049749755, 1.481878914179462},
    {-0.15944176810640143, -0.3867854556637941, 1.2844233911658278, 0.33278956373992996, 4.170952939141264, 1.5474471369077445, -3.0237801848459127, 1.514262301803026, -1.9670875483497374, 1.4279761852812753, -0.3629031619809105, 0.04833369358620203, -0.412137719281388, 1.2947329810877277, -1.2819556064632953, 0.6730124932975566, -1.7123443896367265, -0.8770277176825003, 0.35992620284676113, 1.2441811673488863, 0.13753834955580396, 2.332908113808591, -0.27395882919195674, 2.508848098350242, 0.6857167144426841, -0.608365081298606, -0.6621294044289074, -0.24702885437885155, -0.74689635636441, -0.2069981901237202, 0.10961043641205083, -0.0656780857066831},
    {-0.7611463795023392, 1.0466343047475877, -3.667896268549605, -3.391684868553325, 2.7839848092649637, -3.4023207561320428, -2.3985310597774827, 1.7526399239828343, 0.9094812275459365, -0.46632505558526405, -1.4323007450092597, 0.0135624184571889, -3.141713551304976, -4.317210064074994, 0.5604298138090155, -1.7754048737159844, -4.221623723300425, -2.701436794020738, -0.7986806273630354, -0.025256330605228278, 0.9010905647318601, 0.5111858637881491, -4.4476707818021675, -0.9285380339622776, -0.3198668655171564, -2.1468932226833717, 1.7332023877634637, -3.1178602434123297, -1.3695444538752046, -1.6939744430895534, -0.1345000416424987, 2.0157390250969733},
    {-1.0449745029306003, 1.6878416239728604, -0.7710883533085009, -2.773096433870246, 0.6931912028302752, -0.8192679954792256, 0.31021935349868485, 0.1238278084337629, 0.03286091320884409, 1.3167404570133192, -1.639076663965163, -0.1910364084645856, -2.4443572333054937, -3.902006393876269, 0.293609787852701, -3.2225393667771915, -1.2584170566098052, -3.061806209669572, -3.94940662528401, 2.4983306796954587, -0.04277818206493965, 0.09429315130219537, -1.6993037280146253, -2.1204186325745513, 2.1669560785437727, -0.9037430762852035, -0.2160021425458609, -2.18758043604466, -1.3683651363325893, 0.5574518134181029, -0.20359938384869705, -1.4164369280528997},
    {-2.9917084947747226, -0.847666403126901, 0.48412138394799786, -3.20360341379605, -0.8631892902403867, -0.3474768669792766, 0.467604234598221, 0.023556373842129653, -0.8523410161984092, 1.3092937171392545, 0.5110633483410045, 0.5529055076446088, -0.9405641785621037, -4.393234458149823, 1.1981611434152875, -2.244965004978989, -2.0026603181475884, -2.3727511405920247, -0.39393976053592594, 0.4905862263344468, 2.9777338706048053, 0.4979963684648798, -2.210919528036713, -0.4315477919731719, 0.10590560270325254, -2.356020987459944, -0.10209974390994675, -4.135116336661832, 0.12099432911680695, -0.08782941943809122, 0.8549363891103408, 0.8427280823536863},
    {-2.5623850377356163, 1.5432306079354736, 2.3212110594777435, -3.2023050027669315, -1.434448982536682, -0.7183732356870723, -2.3171773304599625, -0.6993604412171477, -0.11348294499637997, -0.24307026823895722, 0.4325927203247508, -0.43164365786431985, -0.7481012483917876, -0.24992847754416964, 2.4785163235824283, -2.6929661169163355, -3.585136691622664, -2.30889078930554, 0.7247436586560599, -0.948120733908339, 1.857612068462088, -0.25115353792300643, -0.20400787744908677, -0.2697026940210728, 4.726585527677991, -3.9874941092002207, 0.4409783970358904, -0.41527683571699503, 0.8635556207714288, -0.26510931442828833, -0.0472632529458771, -0.27991592614333455},
    {-0.46773408641860964, 1.0379674484458659, -1.7236190980033668, -3.5397044103159714, 0.07044735237826254, -0.24094916483604897, -1.676939612565232, 0.9265874893977143, -1.0761056109552907, 0.2609032170267087, -2.414099835158707, 1.6400561340317863, 0.574631122798816, -2.5056466989599007, -1.2425775790280211, -1.488991666858538, -3.297502684609759, -1.2856993315772607, -0.40797656652935005, -2.054372835544059, 0.2127095513467122, -1.8445993923499466, 1.1113343256112311, -0.462874599534715, -0.22469136076605906, -2.8003588507662975, 0.2194067592072254, -2.942636270002331, 1.2576083059536214, -1.2740997328893553, 2.2597492599601776, -1.011523386705953},
    {0.19730027318890142, 1.119170533670525, 1.3816842810231598, 0.6298571687627372, -0.2580658288500682, -0.27525065628014195, -1.1630336237955503, 2.204592617871141, -0.9604945968731559, 0.2815405637656295, -0.02447231213291066, -0.5507235455000247, 0.008657473394021899, 0.8502480188997209, 0.7845559806953399, 0.8390541715468147, 0.9464752817728733, 0.46693782676161893, -0.8974022805470585, 0.41593404539053486, -0.11299367153960914, -0.37196575614745614, -0.6268247998061536, -0.1255963086962936, 3.1069581627218392, -2.287723272233018, 0.43489588240755134, -0.7502918000245572, 0.9542505809497821, -0.8206583424253237, 2.0363750698746266, -1.764589803365038},
    {-2.2082554501658835, 0.5178089513536208, -0.5159645631709833, -0.23087569054480594, -1.2060440676743822, -2.1270722182697064, 0.2889888474710721, 2.292191127064321, -1.523558693122627, 1.6194781667775195, -0.11943153330138763, -0.32651703603566246, -1.7414403519632857, 0.2911667256755272, 1.156433895951439, 0.4310790427141943, -3.2181373148128865, 0.42556650007583785, -1.514331109937609, -1.7533358759540418, -1.1505493281498225, -0.5444359399235711, -0.7565881460400715, -1.0756646672366201, 0.5583395591194461, -1.6078283484142102, -2.271561917088191, 0.5072174441454426, -0.5097858622600134, -0.5647366837395141, 0.3069167981793367, -1.3427927796116081},
    {-0.5903288328700019, 1.3417553321932156, -1.210605498079523, -1.6454334031307511, 2.1757101697166426, 0.12528139012326256, -1.9512664895044054, -0.8370761373663744, -1.8765600946357817, -0.8352967602298565, 0.4746815522476011, -1.0140633149686054, -1.4637717973253928, -1.5293294108477493, 0.9373779093757932, -1.563307659072329, -0.7644338911116965, -1.309299153345602, -2.4085613318174204, 2.2137538774771177, 0.32145411125606094, 1.725112600158721, 0.017020216626097377, -2.795252356258288, -1.1225042838630035, -2.151715169776609, -0.7409471253803814, -1.0062601942004734, 1.158545311916945, -2.359875087305881, 0.8725953432316156, 0.34729540013302745},
    {-0.06571034961884802, 1.7970001227339507, -2.6197093192124528, -0.1196414345765956, 1.7185413705321047, 0.17990164649200713, 1.489048926146789, 0.06376276246120324, 0.8912671086057897, -3.615084882778635, -0.886723305885254, -1.4507968445084223, -0.40506729510551, -2.391238920052599, -0.08673063948613442, -1.0429837141405764, -3.0109947882487855, 0.3422811983220211, -3.04666638492605, 0.2725597880884469, 0.1774793488500224, 1.2397586312048874, 1.9999138006982788, -1.7170208677850172, 0.7787793266124756, -0.40313157249153914, 0.5476790436994015, -1.4633137219544012, -0.3281962200974984, 2.0501446448030918, 1.172004140894735, -3.2321207372107157},
    {-0.4581829502006822, -2.2600790453252, 1.1246786955540908, -1.175481587411866, 0.1828003028932734, 1.6783453230234724, -0.7346321349869078, -0.4422470115150386, -2.9931408932853723, -0.01468712380742004, -0.5979605516442098, -0.06591947392222282, -0.46724246824169574, -0.18302548724884138, -0.4505587063958848, -1.0806173096261389, 0.34894568375262075, -1.3303982901037674, -1.310352557153907, 1.1084356064193892, -1.3699401318123516, -1.8662213584558647, -2.635224177486191, 0.14802930199171876, 0.11683485030779552, -0.0172039686110722, -0.8689476977864472, 0.419709761115831, -0.7060931746012841, 0.4888294698245107, -0.5252663829758919, -1.604707143488022},
    {-0.14912282109802233, 0.3409411003622762, 1.1915752666761672, 1.7301906025412757, 0.6965885659677415, -1.1834456628713836, 1.321208163364475, -2.5661761239796297, 0.8975563639470536, 0.3469202902239828, -2.2123464676560176, 2.647947324277373, 1.349340939966926, -2.5706329723299497, -0.5507340244064588, 1.2030347801642827, 1.7945489094746543, 2.657394561791434, -0.5848906546951523, 0.13135533377797323, 0.5271428084314936, 1.2176403275130117, -0.4789369525285116, 1.919790692849378, 0.6474704760842315, 0.04516655644510771, -0.3306607950859095, -1.3950419912203147, 0.45002339856197104, 1.9023232990594037, 2.5777977634807354, 1.147164305922104},
    {-1.7948387068268652, -0.023303771074133728, -1.7456243362403467, 0.7158280811796487, 0.23517911532519756, -0.9015511764114382, 2.458188651702115, -0.021659258718212938, -0.6883697281878616, 0.8865663833917978, -1.1823315660938565, 0.38063144365196067, 0.6377957601096054, -0.28297568907423554, -1.5725752566626154, -3.1080140272093004, 0.6308770744413458, 0.7503915989621561, -1.1138979646919331, -4.690671210238851, 1.8557081009311256, 0.5442063039269511, 0.18151485603798007, -0.6021627104440644, 1.6129188481511858, 1.2886483526876709, -0.26908327326038023, -2.019709645896591, -2.242512563040144, -0.21390474296012202, 0.8979763264945733, 1.2408400882072053},
    {-2.014038215823455, 1.8970714793519003, -0.615733976562907, 2.544155845197461, -2.0663862493799385, 0.16578621530668572, -0.7091528163678588, 1.2726780076939712, -0.4069983147133174, 0.40694893047112396, 2.2594122485309054, 0.8761498770370104, 0.2270939570129604, 1.4981292361855045, 0.08769937382223808, -3.1345541152015963, -0.49255282311919873, 1.1700389423451412, 1.2121945758746246, -0.03524339490796758, 3.6549787276596977, -0.4672393793177803, 1.1255025716886204, -0.07082144666374939, 1.004251878633174, -0.27551147437193957, -0.6181602091019194, 0.9738490155248237, -0.3962965818939033, -0.5622771735488087, 2.602172723310105, -0.23647992756287053},
    {2.4172462791970317, 0.43213747308396105, -4.593208217737446, -2.4510187499110287, -0.8627182844854754, -1.305076800430117, 0.9398401865112461, -2.175648987625627, -4.302779711333656, -1.4496905212543603, 1.5661169599721354, 2.000289886320212, -0.735662964120807, -0.6925935592613218, 1.3786263160946064, -2.80983985933603, -1.4774100102092946, -0.4494164784210312, -1.194121937861405, 1.2516657866358663, -0.9189510075505524, -1.186339243396575, 0.2351774113235206, 0.24047050707377346, -0.2000500301701914, -3.1541549815089334, -2.7567191611796, -3.4512830631131175, -0.2195387132130756, 3.0768925440228947, -0.6786914155380865, -0.5866113002304517},
    {1.9578808473242906, -0.34486717836909786, -0.8128738480563384, 3.0881741944949943, -1.5409174168208064, 1.7897279183359793, 2.490469245641571, -0.8445803116399726, -0.9272127086096179, 1.2473340379118154, -0.08428260137412764, 0.3503971225636438, 0.9125821706838716, 1.6661729463552228, 0.7258647439817195, 1.7424624637111585, 1.0816706963706737, -0.41321000628411375, 0.3353198744893233, 2.9393498294865013, 1.9931607313375994, 1.5919937905772903, -1.7087651716286105, 1.9330628517427468, 1.0869916829837096, -0.07501785289122494, 1.3121652742314003, 1.933308165553646, -0.7041621095782318, 2.2066079741646374, -0.29461249282379803, 3.880960667230069},
    {-0.3829191892956497, -0.4808047446070897, 2.3663667334254996, -2.416280970082949, 0.6443666184649016, 1.6698262954742205, 0.7335510378168894, 2.4739982436979435, -1.7626758012059394, 1.3276361415706275, -2.048887536585003, 1.1683832764465265, 2.6222860300546342, 0.6273608343325473, -1.8056164600629858, -0.3409087720578663, -0.6851488675786065, -1.053697191123977, 0.7436981694658532, 1.8712324029256915, 2.2969742402689737, -0.5393099810253753, -0.2506915821560615, -1.4669045441344504, 1.2568577634783582, 0.6015247367908946, 0.38148415692126125, 1.2216677387081663, -0.22710565146329975, 1.860314886113128, 2.018853357845817, 0.4004828604823783},
    {0.5742519279764077, 0.2389399688493585, 0.3278273762869738, -0.2688094678613249, 1.0332333619187632, -0.1591071867919398, 2.869056624964422, -2.381978667452546, 2.002079420856958, -0.7328121096841245, 2.331481375219121, 3.0787106785519933, 0.585181255679847, -5.64229337109233, -1.1670751316926673, 0.24279887036259856, 1.637342431723311, -2.5099803592409806, -0.07848326672535796, 0.5555012383645519, 1.5156276174239134, 3.560165322321999, -0.38718305021017435, -0.5009703785827911, 1.4915713874186878, 2.327857545497673, 1.172278348758542, 2.2857772305206523, 2.6181353196188994, 2.3197360667253215, 1.848867255978095, -0.5472406244661703},
    {0.05352075156633244, -0.9878077892406475, 1.2829489972575872, -0.011347770775840878, -0.15590142813599803, 0.4024540999223612, 0.18017760094424387, -2.278455356375657, -0.8223378405778384, 0.7660415001724638, 0.4970114991804888, 1.3808161126018093, 1.0728191939257057, -1.0080995403045718, -2.0449534813986254, -0.7775800059754636, -0.5275799256017389, -1.7996906452613168, 1.07164939307442, 1.1079296229796658, -1.4051023147801174, -2.7495050984132416, -2.027260264596451, 0.695733405671262, 2.448542392808993, 0.20551092682074534, -0.9593197373818533, -0.8477843215432269, -0.7834757627357013, -0.38287047681296094, 1.5563758095486608, 0.14666857486566087},
    {0.4440340195721275, 3.918871621932785, 0.9342578130347675, 0.9851451398169617, 0.9777915058564661, 0.48478589446504006, 0.29670791029256205, 0.38837364714659167, -0.8296677774944292, -1.8162854813392377, -2.4681471077273303, -0.09523842192204753, 1.1306578205283306, 0.2958755691788854, 3.4053336132013574, -1.1075221270631794, 0.3020993756612913, -0.9020142891044862, -2.404199052085005, -0.9165213425022383, -0.31455554266424957, 1.1493965471869922, -0.44690720062648165, -0.3500680963012553, 1.0677931695008782, 0.7794173628349209, -0.5811603154640935, 0.833876769296982, 2.855075372791522, 3.2255379666167636, 0.26443291365264077, 1.4941840150049013},
    {-0.6849584129320785, -0.1542280010854223, 1.7418716371879341, -0.671935410526337, 0.7088022438038692, -0.6879787670553834, 0.4791336852393356, -1.7028563880619916, 0.11184533317885292, 0.5781532637166821, -2.2668704273334335, -1.1168331572653942, 2.7461577087907294, 1.9707019020663759, 2.8368954034936147, 0.8544263832162241, 2.5964801911894027, 0.22403868747700417, -0.5058307762765376, -1.120901486664019, 0.5571331010415218, -0.04883729069026449, 0.0936692725752646, 0.362238878076629, -1.2861778941476671, -0.3087063973716825, -1.2070347878959709, 1.1838595497330837, 0.35622679656538775, -1.974875670354754, -0.4068710130364043, 1.3166582214018692},
    {0.4145266489154482, -0.7691855708283095, 2.1824566515224033, -0.6494910248895209, -1.36575686209361, 2.08296538691337, 0.5275880021929258, -2.1381045844896627, -0.1436482241546586, -1.8197379335560477, -0.20828920665859726, -0.9777484040427346, 0.12148365697583453, -0.6673975720616329, -0.10836940693301476, 1.9031589416040346, 0.4240608926643959, 0.8255161723886317, 0.1941422466329597, -0.8304470809798391, 1.8225586569485812, 2.2337993193456325, 2.2967727668171203, 2.497287868371233, 0.5670643428389829, 0.4719406529095359, -1.8171428089058996, 1.6898167319058395, 3.2896770194887424, 0.003408873736842171, 1.1250527492026023, 0.5574007923844092},
    {1.2361703008582483, 1.8898962424967038, 2.9371175560715637, 3.1044549494390763, 1.2088492355665006, -1.1870991731646838, -1.5342285562324818, 0.14894611232312668, 1.3417677815548947, 2.5077845645168204, -1.614229160818155, 0.998078419635899, 2.5279646811845735, 0.14496180572145392, 1.036975579486205, 0.9802340382692344, 0.6728721091627728, 0.2460323095750644, 0.09258944117126285, -3.0185837111542857, -1.897631042206229, 1.4740144759372076, 2.047877640868906, 3.2307170946361414, 2.6646077242359976, -0.020141833981849672, -0.4506969539130395, 1.82320581796107, 1.626276414463968, 0.4456847677294942, 1.4512706175284433, 0.6301933423173631},
    {0.16869192301871194, 2.3899569550899744, -0.6032773506755278, -1.2133410844796635, -0.08245940138565158, 1.076922274692423, 0.5637187423149652, -2.2669379071758606, 1.8238677889150785, 2.0972426713701404, -0.22601019621837948, -1.7075534181716316, -1.3405520582456796, 1.32739445524563, -0.08171857290870091, 1.1099732351336058, -0.07088743875009722, -0.6333019523475458, -1.3162138707500748, 0.2632462641436502, 0.9428189818027297, 2.892342036926478, 0.46966237051498355, -2.517395710782626, -0.031167519373767112, 0.4981302769112618, -1.192154387099413, -0.8325012703875989, 0.84395156878611, -0.14857637238769839, 0.20539250902992945, -0.452322223985134},
    {-0.37545495675465473, -0.33431991913714454, -2.6050749484043436, 1.4221984510265904, 0.09355466375000675, 0.669973443253311, -0.3534676104561707, -0.12396304493722113, -0.2056433779890474, 0.30077886217963823, -1.9411702141527098, 1.6852071523160808, -1.5522415096493387, -0.5374884815607235, 0.7211936745837078, -1.8676573370235305, -0.017034777417803945, -0.7900691164854347, -0.21989285737570916, 1.3118193744221955, 1.0084702402724464, 0.9120788650799867, 0.32414508837422523, -0.9432711479061837, -0.3770367172530926, 1.8071702116875958, -0.8434232271442788, 0.7988188850164729, -2.3347567283642126, -0.007531847358739912, -0.09401003718107974, 0.15606115493149392},
    {2.3612984542587667, -1.1664405636901436, 4.690728265093712, -2.3868720238139325, 2.3439626224076013, -0.6514225204506932, -1.8062432095810022, 0.4486205686554807, 0.6782605030181095, -1.6378141063554994, 1.9070860266235823, -3.115297798730593, 0.7915024567090946, 0.22461494254360467, 0.08232471191742541, -1.30750228564671, -1.4414485986077825, 2.3853567556702076, 0.12761591380797987, 0.46974566919472677, -1.3575246213104577, -1.4907570251752422, -0.08081504601553795, -2.7649930542337566, -0.8133145514877775, 0.1685975620751082, 0.7289218439742541, 1.141922434804523, -0.026310843356567342, 1.6406206042119373, 0.1570761313490013, -0.9137696090895053},
    {-3.8708558463019727, -1.4535636286455837, -1.1361108507579414, 1.3810858550799001, 1.4110302101303607, 1.2635725568216745, -2.603540080411211, -4.862342562204424, -1.5138272150047163, 3.0007270408163964, -0.3782231534485787, -0.37666337170217595, 1.1808527204873536, 2.008527996362787, 0.9551450983396064, -3.811292971715763, 0.15183196078138128, -0.38348708473975246, 0.3277261916022435, -0.08136876177273711, -0.5275997293337923, 0.019319969004998598, 0.9926510489763438, 1.3262408911710701, -1.4347443566016354, 1.4194952865646067, -1.4133255559045752, 2.5935872356689145, 1.2714049568552896, -0.41133714802033994, -1.7474395331541852, 1.4866122818165188},
    {-1.2881094911868805, -0.135177981548517, 0.9458463393407971, -1.2097967270252201, -0.21780898240967742, 1.468550393681944, -2.5620447636594648, 0.576753788388045, -1.1254082370658025, 1.6928818194641575, -2.8095411354312043, 1.3290528848014562, 0.31420355194678756, -0.9965841753493184, 0.2944001799389669, -1.4229991844613485, 1.7321908327973008, -1.1190382701514805, -1.2399825039323533, 1.2014656880061352, -2.264156639635132, 0.4789394821398787, -0.9217997661733182, -2.1549208688078436, -0.7156366312219827, -0.7809624946441789, 0.33442801834921254, 2.750578645500138, -0.49188327079062705, -1.0603564496108293, -0.7042284340737769, 1.157867114319241},
    {0.5660367619641786, 0.06529924682901415, 0.2711733477288101, 1.1828280951973615, -2.1509284897537526, -1.5798289516294686, 0.9418131216674847, 0.03948250870689377, 0.6119645503753428, 2.3314348497258495, -0.827332547796917, -0.6513926095260791, 0.7461334318842252, -1.8810624357454049, 1.011452985692889, 0.5501148059164481, -0.21586941527594672, -1.3616388246053157, -1.2631382196404726, -0.9118148468342079, 0.40808480110954, 0.284680959158861, 1.0073500909452504, 1.022653744711769, -1.6545265254705428, 0.7035386418346489, -1.511829509895986, -0.17965680915095097, 2.4214452700044276, 0.9197976146339548, 0.8603543191475876, -0.9289611497645307},
    {3.643700040541581, 2.058222284545887, -0.9112758644277937, -0.7193372547501151, 1.0469238899644444, -0.43486640929163123, 1.3785354003148018, 1.3136127677119456, 1.4021118343913932, 1.2315168030972383, 0.323407182063246, -2.6455276273128248, -0.3375718714915214, 2.5683776325830965, 0.0576217282185745, 0.7080207986500855, -0.5594387272210285, 1.8466910415966558, 2.4560974058882215, 1.3295162684669117, 2.091793809317857, 1.388830394585435, 0.7090780426578235, 1.6119580865396437, 1.5716560811263962, 0.287889794590159, 0.5718672690368874, 0.6326994922716368, 1.7094117746301918, 3.514800035170955, 0.9997811406526953, 0.9283342721105778},
    {-1.244304176841075, 0.7011676925045269, 1.0857125132253098, -0.9098269347374596, 2.28902473420329, 0.11559876131088363, 2.364611324383956, -2.612918203230222, -0.8675086879329763, 1.6604541359929208, -0.3364022638858583, 0.759206439128628, 1.4154772410881866, 1.4015400472446313, 1.353320726412293, 2.451490519412252, 1.4336563461168939, 0.2913954656082259, 2.2229676853729186, 0.5124094240145862, -0.8313134939225487, 0.7212215949758599, -1.9549526676055107, -2.0005746209189197, 2.0887292266089497, -0.8054545740018311, -0.7662299070097537, 0.37306962331796995, 3.571149638239728, 1.9809819451105537, 0.42559289663005534, 1.235149857899447},
    {-1.8998485922037558, -1.1261416529410664, 1.4685125183494059, 0.93348029647158, -1.1524678340370558, 2.0881844632161646, 1.8915705555080276, 2.2391254279635793, -0.554601399465332, -0.7571149719125764, 0.09516155746321708, -1.5087618778244247, 3.577635581253278, 1.3282710440171022, -0.5858053884671522, 0.6401438377440745, -2.112362054615034, 3.2123687059024078, 0.3753281707298039, -0.4416515820752194, -2.1316109837019694, -1.3070232731659528, 1.0731900176344427, 0.5983516954844313, -0.2319275470123071, 0.06542384612482696, -1.2949688812682598, -0.2206302976816337, -1.0819677238217447, -0.6049097693769454, -0.9011928767742367, -1.9890904835700558},
    {1.838252984788998, 2.009767523817374, -0.6750458274101119, -0.6716203632305922, -1.0151918058711376, -0.16469552125408554, 1.4658432783223256, -1.2036812438721949, 1.608642745425827, -1.0091444756057166, 0.6434190410043034, 2.132117141639539, -0.6416558804628731, 0.29058187789131396, 0.30460551442883255, -0.37283136868465283, 0.12845176720754817, 1.7199013584723137, 0.7374596738255108, 0.44146858036664927, 0.8205508827160857, 0.013086624325681832, 0.5007308123465681, -3.10534608987733, 0.10281090996347206, -1.2067415922595663, 1.062247429451827, -0.8828055787931539, 1.071405209413028, 2.582580576380757, -2.446728555743085, 0.4896547487302065},
    {-1.3288362078319476, 1.9802284624857516, -2.2556770036312224, -4.533092070361316, -1.3271934162590615, 0.31769865859941154, -0.3034028784762153, -1.1322943362969895, 1.266464625585729, 0.0738363708651124, -1.1206306729799973, 2.438379037549304, -0.08901027305393812, -1.9662359356295311, -0.21525971148118977, 0.49686056599692546, -1.3260153126702359, -2.0342788023340925, -0.0723755822890071, 0.04766022784229707, 1.82061905886665, 1.2516497587510684, -0.8009664909238328, -0.1623749160288619, 0.8825679368710433, -0.6634721789944793, -1.359676757955683, -2.2029626720305213, 0.2693865382630552, -0.7978722419468344, 1.5245894088183447, 1.0902588194253167},
    {1.5028420267054625, 0.10408526271646205, 1.064556235810262, 0.34692976889775307, 3.3214989505942754, -0.7004646622824822, -2.353234285981305, 0.4149361774580598, -1.3137894509450065, 0.0868068955335521, 1.943041765234081, -1.2440089494009876, 0.891461157164979, -0.0418664527305903, -0.4740211420734236, 1.456943087328456, 1.01925064148255, -2.0610480610534787, 1.8297774422643587, -0.560423477241019, 0.12485312406936894, -0.7131663362433172, -0.758010721212651, -0.9489871167204464, 0.4569946461477035, 4.226215602859414, 0.10299906598867013, -0.3205478865032672, -0.6881198332117631, -1.6196123402279863, 0.8345383783691457, -0.49328952199798104},
    {0.3947316830930704, 1.404103951798289, 2.0529596416402116, 0.3310409139408859, -0.6158234056740737, 0.9655995140105036, -1.0896283246821385, 0.6548233038835792, -1.1191011742342856, -1.308137981909963, 0.28232242769557214, -0.040745600384993516, 2.375042871711348, 0.009357219465796672, 1.720984140127181, 3.062982992708831, -1.5554937770718422, -0.7663515479950976, 1.156060838067441, 1.1989598632693927, 0.2271056662525385, -1.0388189988873784, -2.2055235685020533, -0.2762698801885794, -0.6425962781658892, 2.8397112581356247, 0.6201995027400599, -0.7556803692140781, -0.6966700913252968, 0.41502540733312776, -1.1288592596132356, 0.4013639290224061},
    {-0.9292053761701142, 1.694023802407859, 0.06253903717529356, -0.09856375699806412, -0.690806078898537, -0.2693200578872003, 0.8162520032256236, -1.9612757805556815, 0.1715404797940514, 2.585673243391146, -0.28538737302283107, -0.09310587032783126, -1.901934209796405, -0.12649560431181173, 2.746793525506009, -1.9277443613088776, -0.7097244588937857, 0.40392548814778023, 1.4095452966347455, 0.33627277488136215, -0.07560678691908743, 0.7393378109027804, 0.5761319101251476, -0.38515514571114734, 0.4299812264493808, -1.3777090810062738, 0.6886591306191965, 0.014643560155907924, 4.552428934616969, -0.6860547459925437, 0.0864106595389768, 0.7147570463684814},
    {-0.8658477863875568, 0.6591816093192546, 1.901538058411578, -0.7399240417714323, -0.8542710233633499, -1.5412074272484273, 0.7592860642741225, 1.2762139259567602, -0.37243208639735775, 0.3391659043862025, -0.6493813249797746, 2.9264752151026854, -1.496216572021375, -0.6803278982022201, 0.05319020361682626, 1.4441877539224182, 0.07420465069084708, -1.475475952794569, -0.35200202786379087, -0.38884997371829155, 1.439641500428004, 2.1551764582230635, -0.9633871536806992, 3.1863847737466706, -2.031234634655762, 1.2348078095596189, 0.12517721619271927, 2.4074316950959243, 1.3112699317335434, -0.46251856740777025, 2.952562216275215, 1.108611949531638},
    {1.2005909516760795, -0.8481096436149224, 0.018973650535389228, -0.913743559922163, -0.9312402824997975, -1.1384745093423925, -0.14094773700080898, 2.3886813868883876, 0.8529256366046449, -0.2860662120988864, -0.6425018907814389, -1.5846415657750825, 0.12311991688431369, -0.9569581814104733, -2.8561934548975714, 0.8554114894923545, 0.7499986638759258, 0.4736581067788465, -0.9768355217707747, -0.1479697407287431, -0.7120244334683491, -0.49617746989216727, 0.03220693385078818, 2.710475748609852, -0.7230003165520081, 0.859110742474653, 0.17278060894558392, 0.13974543033034162, -1.060405907361168, 1.0843388327728607, -0.10359396799860864, 0.8532244312037046},
    {-1.7737684328437382, 2.1302283757687266, 0.2738276332675496, 1.3702486765550794, -1.762304080108263, 0.40950648365387426, -1.6787689737350824, 0.41202214296658796, -1.6888723016671934, 1.6281383091827908, -1.690326314227127, -0.40248154309795753, -2.748150445289473, 0.14837417957068344, -2.2498969020174, 1.0549198389862884, -2.3936360998361113, -0.19375268722337632, 0.17559248726766574, -1.8813602897749302, -1.6046190804118654, 0.32972106113857413, 1.0486776107241342, 2.190007621461727, 1.2928343412042058, 1.0934519670456693, -2.0041462253790328, -0.14814848840189773, -0.16585035223073408, -1.099109517269892, 0.03904694073823876, 1.0864623444352923},
    {0.04318421098404348, 2.9046263826767276, 0.581788189122656, 0.7925011870382558, 0.431296088605679, -0.7877085083923561, -1.6313078607366065, -0.22424705271448453, -0.5001645603058048, 2.6530475720964333, 0.9829720840513917, -0.8843141668883806, -1.094328850785702, 0.9882942143345276, 0.5861085189638043, 1.531735411116813, -1.886399042696987, 0.3660169601337938, -2.6132718284202454, -2.770015843026874, -1.8859255842922835, -1.0112342036753994, 0.8799236771426971, 2.681057897435138, 0.27581004370616496, -2.093851013483471, -0.24522904578924726, -0.6508405016854161, -1.3374635587661903, 1.148990470740162, 2.1022328215904253, 0.42964337553105125},
    {-1.276493373993206, -1.4921582066171604, 1.1609286321267305, 0.22013996825440027, -1.1658878769741625, -0.737702217751244, -1.2669603665042457, 1.8496231738544007, 0.17382697310201176, -0.576212555825054, 2.112607350435296, -1.5689109646912853, 1.1775822945347227, -0.48556438598146456, 0.4117465700848662, -0.46922129663185164, -0.6444029274263674, 0.6924625603907882, -0.6436455866891195, 0.35164968136196123, -0.32308270661587335, -1.198072099812231, 2.3902524445735205, 0.03361769313424736, 1.9682687908125556, -1.9190611745933532, 2.844330369467735, 0.9498027051112052, -0.055490558672991776, -1.977242714151123, 0.3841585206072339, -1.1004456388279296},
    {-1.1663737148005304, 0.0009827416630529924, -1.6093606971624752, 0.2841992756901421, -0.38083642812544405, 0.4148701961145339, 0.6260638183745206, -0.49876384597211204, 0.7807785222342538, 2.0151265939418055, 0.38256431479948105, 2.0704651707427177, -1.5117172759417294, 1.4324734934312353, 1.3281371065438163, 0.4631705182921223, -1.145933703589879, 0.012471706215947894, -1.669887079125628, -1.4547539439403656, 0.36907595249946756, -1.8399617649462006, 1.1633617991413465, -0.43191507725017164, 0.9661983618442279, 0.009619358207110377, 0.2335394961375721, -0.3570317520246568, -1.0638561954738464, -1.7927635605225487, 0.5762321915251958, 2.130355868936152},
    {-0.02727165614843522, 1.169170258614397, -2.3988279355180833, 0.33203056802582726, -1.8439195638843284, -0.14568165333295297, 2.510063440942898, -2.040242230740528, -1.7633480315076882, -0.11585808472177576, -2.737370627662115, -0.6723209898359095, 0.6192771205964982, -0.5986691690808278, 0.05717664839385636, -0.40232006821310956, -0.5866417218367679, 0.269018253914504, 1.5385942473608691, -1.6557790652236708, 1.8927081635453875, -0.1722539143154134, -0.6752333319105702, -0.9209673829714742, 0.652865751002176, 1.5036817309033674, 0.5430770959346325, 0.24252337267523266, 0.5060308704766158, -0.20525892779873992, 1.0207917223074088, 0.0614140988546005},
    {-0.5077538177965129, 1.1462551233067335, -0.009567531349477604, 1.2904569293330796, -1.719141429978357, 1.6489911062202542, 0.5868037195725345, -3.2249577993878122, -0.5866281829543988, -0.21572168591308769, -0.9236695330004918, -0.03923524301182206, -1.7770955194929277, 0.23711141354146456, -0.11239737493357616, -1.52822050082405, -0.5005672004095202, -0.05947890612873234, -0.9283661203706529, -0.059211762441668724, 1.8547320496603332, -1.2450640416128982, -1.944286790668025, 0.9344990846532418, 0.7903525167881307, -2.6201538497019756, 3.5737498170762114, -0.319982799856107, -1.0367156002411437, 0.6825746037181039, 0.1788283222117778, -3.3596335555663135},
    {0.1830170251924351, -2.1479945081193073, 0.3161474302417542, 0.49931082197784765, 0.7675157713114834, 0.33660494040751227, 0.7128589991251895, 0.7991766952291519, 1.7801908771848929, -0.2836148015106992, -0.9019307008476265, -1.4210165731585085, -0.24250998900904702, 1.3523508736014573, -1.7754054976072118, -2.3534167149533003, -2.131084233948655, 0.45604437725989966, -0.5447777521273316, 0.5103175056365877, -1.1439940942609954, -0.7682482090585782, -0.7204019916320543, 0.30586846938032264, 1.5178042028608352, -0.9708345014805428, 1.1742496609610515, -0.3351406774219938, 0.30513909548163576, -0.07036077667171398, 0.7591657958818093, 0.7014627598672156},
    {-1.0536252386446159, -0.672579136819525, -1.4543788616083022, 0.4765928648622803, -1.3332284818450701, 0.902361692850048, -0.9522143404486945, -3.0717870041717217, 2.811889326795504, -0.9934989709314045, -1.3691143672512947, -0.626966635065303, -1.95242012804499, -0.2869283485567839, 0.013984223037550885, -0.7894891501754712, 0.9879264874321312, -1.5020918013642504, -0.9626454765742551, -2.088837612956719, -0.37667182932022114, 1.7089972532341038, 0.4841774860562634, -2.333392418946018, -0.29117112396562156, -2.246174083127107, -0.41996652080640046, -0.1537051276203955, 0.09743819184709825, 1.8871295211683652, -1.9102953931588966, 1.160545760835601},
    {-3.29579060347034, -0.9787490285250247, 0.19814105327320305, -0.24992996192503658, -1.610482332368796, -1.0949437372202486, -0.5228938857971717, -0.5201306380138293, 2.690123122939322, -0.9722087783171847, -0.406769129410927, 3.4923343333621997, -0.7909373901441016, 2.2279500271732964, -0.8680968005429002, -0.49524829432891365, 3.2717132903530617, 3.6908437097087954, -1.6766775359304817, 0.3877362004404883, -1.4455272462257513, -1.6250841467375698, -0.21614933936316763, 0.1887000399789319, -3.9689609617338966, 0.6205505064978435, -2.3275131441083645, 1.1832196655048215, -0.13647184801729753, 0.02727383601412841, 0.3541266656210239, -0.5712727042612422},
    {-0.017675453088113618, -0.09537879068324093, -0.05283284757598705, 0.5355493356383136, -0.9014302628403636, 0.9315418290415564, -1.0172756285303879, -0.1477603602848269, 0.8958375729360253, 1.4555690752159707, -0.7490922325607843, -0.6967484529595166, -1.1100445475791132, 0.5562564275060582, -3.6077887397269124, -1.9314996785816774, -0.38966392538235156, -2.048861447469084, -1.8445107940711611, 2.692254710991705, -1.5649432864006605, -0.47653898466214545, -0.28882673147564086, -0.11801862102685892, -1.749583796707332, -0.35403282167035915, -1.2801348356229791, 3.02103032578759, 1.2448554326981045, -0.4576544687242857, -0.7516520241896125, -0.2723170730328179},
    {0.19632412519151315, 0.2815100233648344, 0.5610887976305381, -1.1430604820427102, 2.1749424217791558, -1.0144627235213723, 1.6589560136135046, 1.2111978869055888, 1.2185635010298421, 0.3753563439781451, 1.450594365941097, -1.6416699951157172, -0.3653864836105603, 1.0974945926766175, -0.08628293152083646, -1.0519413593149596, 1.5875288352296872, -2.921884905059748, 1.281696020453387, 0.30368550898927804, 3.8426491674597556, 2.9442695715410614, -0.1369863843478281, 0.3908823164155994, 0.437549597339697, -1.050179937968627, -0.13204525915556212, -2.972254388890712, -0.7714677734903838, -1.0610907925544317, 2.86734486458377, 0.10431673045655263},
    {-0.44044858121022973, 0.40826503241775897, 0.7358907408856582, 0.8970437248144898, 0.31419105594070357, -0.7029480721406263, 0.6694262190894565, 1.9740418235197363, -1.194514742373823, 0.6945849948622898, -0.24088750909791262, 1.587758050433899, 0.6823445628547481, 0.39005231697500603, -0.4192437192824508, -1.104950503573369, -1.5174114388460695, -2.978909464257323, 0.3424439797809043, -3.2365007654368787, 0.12964477769720492, 1.2630451762096833, -1.413020403405263, -0.08196078033562654, -4.554644689371012, 3.3662960868139202, 1.6151525168055338, -1.4207652482143673, -0.5468346385377556, 0.3968103457649607, -0.7753125921581263, -0.127914350748943},
    {-0.9058895583904121, -1.0796633635797583, -2.6490991531608286, 2.9639354023590445, -0.854323071930261, 0.948458086473353, 1.6655784394375726, -2.021133432770337, -2.376389807579801, -1.9875715221209311, 0.0378222853777971, 2.2705992332051603, -0.25207282900845346, 1.738087703240462, -0.34795833798781967, -0.15542468975786158, 1.2792570488587092, -1.1923514388751038, -1.89519535673269, -1.1586450618496387, 1.0763228787471428, -1.5385959699641714, 0.33930762234075185, -2.21058436081488, -0.9617582030413009, 1.214006659256824, -0.3527147399024281, -0.8200862425866912, 0.2183268980174813, -1.4609883730582356, -0.16699433246429693, -1.3409306563751286},
    {2.2410250287882088, -0.21201259965556282, -0.24446899477014591, -1.1680129912506323, 0.017072228838210027, 0.8741916508950113, -1.0302993504237352, -1.5317660793711956, -0.6980954978401079, -0.0359125970731001, -0.896985849369217, 0.49424091845277623, -0.8883588394812055, -2.4473683254682648, 0.2561074233022042, 1.413756502466963, 1.1978687316432362, -2.8333975680822623, -1.2336514823440514, -0.8371209608423517, 0.5000731615780787, 1.2406227069946156, -0.6036909429270055, -0.19900430332996807, -1.5553106186730599, 0.481743677907208, 2.333564555888913, -1.1934318378139421, 0.2647395090453187, -1.5988850120414895, 0.734144301577735, -1.3080513848425084},
    {-0.20283734470709688, 1.0000901210347373, 2.1602061855051797, -0.4117351896113946, 0.53857042484348, 0.33360408720614715, 0.15809674665309015, 1.5088430131711468, 2.6298946288756695, -1.5113108618232967, -2.107414633161543, -1.702114872627867, 1.1384031060940707, -0.043341125433957794, 2.57667769410212, 0.7202688126451278, 0.21969542632756314, 0.88217643207003, 2.1866586292228507, 0.6437141121513185, -0.016326778910783386, 1.6046062356616961, 0.06534470305977527, 1.4375803541485797, -0.12549707439546787, 2.138193007729411, 0.8686759400522271, -1.422046730260516, 0.3542186995839081, 0.2237792275603095, -2.1139288894225845, -0.5000612952741544},
    {1.0260473952193359, 0.8673577588980373, -2.296327699199501, -0.6684911305787374, 0.08920422381200145, 0.09817382447144488, 0.36102890070335825, -0.04949975234882341, -1.8780781317264907, -1.889288434554315, -1.2182218296356415, -1.0908097651683593, 0.9115567352586963, 2.829612834767658, 1.8031971695287183, -0.4334317576669767, 1.6298264798429063, -0.17277160532490182, -1.8287511113221613, 2.54264507407125, -0.4560969005524945, -1.8824926816948153, -1.5362375543733011, 2.0282299366230507, -0.7441796055916395, 0.5758467194827726, 0.6228016396839832, -0.5105881454535661, -2.3694104720677713, -1.1710142690952352, 2.512883724213021, -0.37568253970529797},
    {-0.21038828206015953, -2.273765962149286, -0.5497604274390313, -1.1698474878000242, -1.2971341218139165, 0.4274098175319531, -1.4664653601582334, -0.7539432471364237, -2.2252584337875545, -0.267253881847219, 0.7881937401852905, 0.7186749745844607, -2.1073573951895086, -1.0429754299788985, -2.1336289110294566, 0.8769834053480834, -0.31914227744466594, -4.24632592371347, -2.855767732727829, -0.7050390886384533, -1.7030875020816443, -2.4590778174338643, -1.0071746781706956, -1.049294855574366, 1.804965595590234, 1.575733542641909, 0.1558628142862524, 0.0984347892571361, -2.7598938117574026, -0.05566121130351791, -1.043043726799202, -1.7943270924291115},
    {0.7911177629778022, 0.5185549756182946, -0.16806329639584858, 2.693756757589412, -0.8021619484856172, 1.7510536564264652, -0.9809578702867878, 3.1204403164595877, -2.1445379137268152, 0.837462604987885, 0.8041248765426683, -1.1653665116735243, 0.6016086950214398, -0.9256786472930091, -0.24518846110635317, -0.7169357533989299, -1.5119817730616087, -1.1103514882803216, 1.0135295254523395, -3.667561068202488, -1.314204095519535, -0.511454132224653, -1.9028080802100416, -0.26626894732034107, 2.1589965026687534, 2.4157033632894347, 0.154824388783672, 0.19891445522596765, 0.7468845881356793, 0.6019228833540727, -0.4307839347942662, 1.159647073576911},
    {0.8159732605022201, 1.1638432818109261, -0.021011172435440872, 0.25116299792757335, -1.110569856680029, -0.0936064453606494, 0.5695105134999104, -1.8461958381152979, -2.0420000254888477, 2.073840239918337, -0.9477019135107176, -0.6654001428643002, 1.9086360165725047, -1.855468102412563, 0.08321817114812755, -0.35428064031550555, -2.3375894261989676, -2.318663735384573, 0.12191144881341519, 0.23290177607302412, 0.06129861871322388, 0.3863129484025431, 1.0399812131740196, -2.612819485042799, -0.49890136839345306, -1.8554004864142328, 0.977658392316192, -2.1489169027649773, 2.1464350808597663, 1.0823151216022746, -0.5298924925098775, -0.4256361387511635},
    {-0.29481875559283693, 3.3958047615827107, -1.6897049773682584, 3.103967242020899, -1.8697775509413226, 1.0749415945073466, -2.4464417961611042, 2.8459966379838453, 0.8820124434123114, -0.2015447722762775, -0.3791461151194485, -1.183276638841472, -0.9250089272076538, 1.0677433448402844, -1.803860623737309, 2.123074592194904, -1.0627628655816515, 0.3840328144713853, -0.6148631278730202, 2.5669592838473143, -0.519987590016665, 1.934606758206849, 1.3570037237757984, -3.0905963169360646, -3.449581906990875, -1.2417338109765845, 1.3416712470889016, -0.26645684546354, 0.3905795357343937, -1.1395267799812117, 1.9028726779397032, -2.055223102783099},
    {-1.384372302673812, -0.1357006556601613, -0.5807094749136872, -2.765615602217949, 2.8194788365525763, -1.3833462880252012, -1.0060341950485603, 0.7385772203312475, 0.39292593220694555, -0.18556285961879732, -1.3143260730571613, -1.935549041926153, -0.7228899501036203, -1.9757884514413535, 1.6127868383627546, 0.1502532814975459, 0.9571657604454213, 0.4677271018886457, -2.225194006553022, -0.8391285269262853, 0.0006219108728630097, -1.4047160986836311, 0.46359811065787315, 1.3276048519663513, -1.327128930530573, 0.47765880793893734, 0.07286275905354318, -0.2792598640332901, -2.4575857088190083, -0.1369620436036974, 1.3573309906300552, -0.7219491974137424},
    {-1.5614210627721843, -3.158367596174133, -0.5920263820980387, -2.1751608555604536, 0.7687315044497204, -0.8803486555511627, -0.3758842592330032, 1.1266268704299687, -0.85103807602092, -0.4432915709952712, -1.0216468600065363, 0.7926319015072759, -1.5444035106813792, 0.27098173875451553, 1.9315009839082589, -0.34607190172614527, -0.5123490183454505, 0.4599400438124519, 1.836454191812319, 1.0991465090351726, 0.06656130848043146, -0.9217274733197132, -1.3199177684544758, 1.4376359824430587, -0.2528297394101888, -0.4787730959304829, -0.46254873535626756, -1.0715118139231246, 0.2655231951193959, -0.8255120427816588, -1.323148510738443, 2.609931205704655},
    {0.06906240294247641, 1.527358266114508, -3.509674094873582, -3.18461186082463, 1.3392210840935803, -1.6775583178103044, -0.8548493533776379, 1.2110632209470107, -0.4507667852381858, 0.3611248312008363, -2.0192810623414443, -0.3122057529548351, -2.734389458154833, -4.500967180093728, -1.8960691937364411, -2.0822154089876874, -5.21187898577368, -1.3970099919075043, 0.603084460589235, -0.5237639259923197, 0.2685532482164265, 1.8615069256278123, -3.5050411435310096, -1.520472383709883, 0.1952992254104442, -4.93214962807659, 0.044845775212331004, -2.5215443721297186, -0.9448888206419157, -0.9898563489971333, 1.5596807842587828, -0.27813263360126733},
    {-2.3664739271808406, 1.6754647166381555, -1.9596300372096591, -1.12411381493129, 2.9542485114424046, 0.745342715428102, -0.7932116717169728, 1.4551301558388134, 0.6423337930500544, 1.0875580702833259, -2.8337474954097677, -1.0774429298122992, -1.712572370032545, -2.0447023929271366, -0.5340463046009059, -3.376827714676523, -4.280665686251843, -0.49635806905007807, -1.7170666318402543, 0.4382361544454881, -0.8996208375936122, 0.2527509185687059, -0.06866848172097215, -2.8745627072349746, 0.9958741485861714, -1.1900717321031327, -0.506831732591074, -1.061465202688361, -0.8661214483207389, -2.3780531029278755, -1.4453326641742696, -4.025179756837572},
    {-2.9428510104858705, 1.0184254382852118, 0.48020819445149876, -3.918679070981136, 0.7611955569550605, -1.127821128795883, 1.4382637300573173, 0.019574792125734233, 0.11067562524319544, -0.11515745943852877, -0.13216318927111742, 1.9473953500155279, 0.48602675579969545, -3.4706533684295735, 0.8331264088248856, -3.968089829784555, -4.170921898748958, -2.601227062105836, -0.8736220885294997, 0.8959512831487167, 2.1623306187199414, -0.9926192101660188, -0.2773489446284163, 1.4648175666427006, 2.75292667933587, -1.2554124965439428, 1.7505361392350496, -2.1432462543325768, -0.36372581569979723, -0.7308161482641449, 0.36426617732371297, 0.8910884096852011},
    {-2.356326953699829, -0.7725977874908743, 2.170354268746395, -0.43803708080891846, 0.15509303875007605, 0.6364446290946004, -2.471358843879876, -1.3940780081778787, 1.2715936882897783, 0.47870248677613497, -0.578549142463967, -2.0956707499440905, -0.2528529280241748, -0.058366375851142266, -0.5078393851373619, -0.040323276530260056, -1.4656284520139047, 0.7548981975466158, 0.20478067950056178, -2.723448962414985, 0.12913892582964276, 2.2712255932395795, -0.34323956234923747, -1.4991818900173204, 0.9709461588232213, -2.1180343323047848, 0.5037934534437765, -2.4386781451760715, 0.5821107840755365, -0.2848701171481248, -0.5760746394000574, 0.5098912612946064},
    {-1.2176077947123898, 1.0673041728568822, 0.640312009326439, -0.778384099803209, -0.2807701216099253, 0.42087588729342024, -1.173615683844731, -0.14776970650453763, -1.559818019108102, -0.6762129377161546, 0.28995631909337116, 1.5736954490031079, 1.1471038448818307, -2.434408493661962, -2.396194565241121, -2.1965908914342602, -1.3948594548780922, -0.5387484476046268, -1.2558451533358372, -0.12031297984011574, 1.3095826049533952, -0.9807775756114208, 1.272475926015349, -2.0163601514751974, -1.0169671926542896, -2.0604514499344933, -0.47528439983222853, 0.20459070620956754, -0.6332381488094255, 0.1295653553462644, 1.30642762278765, -0.0015575079412674367},
    {0.8703236508274594, 1.2578898767089375, -1.5882655570048496, -0.5479173073516984, 0.44010229291014696, -1.2631457766457581, -1.7246695804177128, 0.37778782689288276, -0.44220358288121897, 0.7495321015173616, -0.13473181657630093, -0.20886405085844117, 0.34228641992472936, -2.3182580869107796, -2.554367536481297, -0.3079442259864348, -0.6468287110036137, 0.23558065099922942, -0.39235804466863483, 1.1185193730442493, -2.0958098432759282, 2.1238288699312435, -0.14576320439982715, -1.6525639768055678, 1.3073505215809182, -0.9367779300040212, 2.4798052939500512, 0.9476750019889056, -1.2676422137702028, 0.9353587348149284, 1.026615226009244, -1.7554705868686604},
    {-2.034584790683436, -2.1989351441896567, 0.48530267900934104, 1.091471466828425, 0.07739070331000293, 0.5966457317754746, 0.25265854443902463, 2.212539982721078, 1.402717072527898, 0.09579795854909538, 0.710118581076519, -1.4596295674486064, -0.46122921605371436, -0.7242645588426567, -2.4497197506340775, 1.0739707885650793, -1.0330433358435922, -1.1118595791700936, 0.2879900663700126, 0.468365711374587, 1.2450024952037364, 1.0654697885140698, 0.6817060753507822, -0.03536038674955313, 2.185565420199384, -3.275913896307395, 0.21254418352590276, 1.2147533362420315, -1.174062484919257, -0.7689698964523222, -0.5340866619400526, -0.44545470295350703},
    {-1.4296882484924938, 1.041463668516597, -0.4474068444950537, -1.394976289472242, 1.2607411617117796, -1.4155403914468478, 2.2695754776211134, -1.685151122892811, -1.1432483543982033, 2.8549054705760413, -0.6847146110047984, -1.6868626392901225, -0.9417092102083725, -0.6125996165131706, -1.3716133749186359, 0.2691716032527962, -1.3125573144077511, -2.9777286638128233, 0.3134401314399078, 1.0039235662852717, -0.0042209853259656946, 1.4533060697309668, 0.010712748599037888, -1.7660193771408317, -0.8239215529040428, -2.301215950551457, 0.7252873874540791, 1.0433784653051241, 0.6823913649307185, -0.26740865930383156, 1.3876540656163312, 0.04696112400186267},
    {-1.3161457970540165, -0.21741414088801664, -0.7247307737701103, -1.6024289153873958, 0.9138960396088783, -0.8403889855626405, 0.9998934690460066, 1.2070280769618413, 0.010841806151814425, 1.0738097664598574, -0.24326888615454423, 2.7520015149337507, -2.2573672382273617, 0.049007826296656634, -0.5073997978570637, -0.5161326525493259, -1.7828955338118953, -0.389643417193406, -1.8807597217725205, 0.15118792787968233, 0.49792420983131847, 0.3088264161344121, 2.245066096002432, -0.10421410729560476, 1.4965751381724257, -0.7472530013588652, -1.4061300422316851, -1.578694352588279, -0.9981088095810681, 0.2485496909919611, 0.9141151349886084, -1.2312113101392028},
    {0.5640903689171127, -4.967029165495838, 0.5076954208433734, 1.3102625241850148, -0.833462203362516, 0.7783300532426659, -1.2815163124654358, 1.83283566793778, 1.1102534372691042, 0.4966699369525156, -0.9149434037128492, 1.2552540350417678, 0.8846472520778819, -2.1540903974975416, -0.47900917079635374, -1.5117858788912106, 0.3646030556115151, -0.1292649500500648, -0.49251410940417045, -2.261023915145594, -1.4833194443720679, 0.1419218345614027, -0.781804176406984, -0.5466603676765447, 4.821299524709049, -1.2783319855321051, -1.8138130886988986, 1.9337409529943732, 3.3611521380138836, 0.9714515436047969, 0.7318735088876146, -0.47531721588411074},
    {-0.9357832430089867, -0.584723236178033, -1.5179889386683936, 0.6589529433988003, 0.23796124394404697, -1.6026226798847187, -0.8892445099208689, -0.42366240433720453, 1.8948423956713842, 1.5726989742733835, -1.5594820088313432, 1.738404890011266, 2.125783961567765, -1.8050531827235259, -0.379098329014766, 0.15396826991325588, 0.7225762486004181, 1.3664895463793472, -2.320663763852589, 1.1374531219867905, -0.46734956364295593, 0.47249593747430524, -1.0902975708168932, -1.2031435143368294, -2.35698410078645, -0.7804414113469395, -0.8674609147186653, 0.14941266551179902, -0.39979754350965613, 1.9971099190404147, 1.9252610853204568, 1.4556156418901303},
    {-0.11456796633686947, -1.9793580173578933, -1.1921102133906243, -0.43534373729540216, 0.7076748954134973, -0.08484508088048062, 1.278573246736472, 1.5200984819410586, -1.05122043745214, 2.3867270435352324, -0.06613841568519675, 1.8589642324468918, -1.8426984865996543, -1.6541578502631633, 0.012929693297115926, -3.238701929377874, 2.4118101319717264, 2.054248265016535, 0.5736274090699083, -2.1893570851146587, 2.224361052403893, 1.296918068958115, 0.22612401867861318, 0.6235347114095435, -0.24185821117720382, -0.9297415899526279, -1.1788808451325783, -0.8912737812450658, 0.26054986469554636, -0.8544777942770253, -0.13855433583211688, -2.851665195202131},
    {-2.071321757733842, -0.718704743995322, -0.4884543070451156, 1.0554459532606806, 1.978464035649885, -0.7739389319313532, -1.1714084827616298, -3.1834730879832422, 0.09222522009239871, 0.9809468183267085, -1.065886808440189, 0.6236674768784359, -1.7035239453838804, -0.8330645616102581, -0.6467581612677089, 0.5904604690018452, 0.36767656408130905, -0.32682213979235103, -1.1755766617483325, -0.32575539527377023, 2.1514453320843794, -0.8323922048127337, 1.1032316258517716, -0.32693132393322827, -0.8724946895119278, 1.363384923214003, 0.09857646138896492, 1.6499423720322068, -2.7290510450951144, 1.4821166735858662, 2.879265649492888, 1.0142920395770285},
    {2.0513020119393657, 1.2144553703947325, -2.52681537456363, -2.75143338443921, -0.9713868337481062, -0.6869138001983172, 0.8557967847101547, 0.25288534709181765, -1.0738022690683926, -0.3586293158168073, -1.1745803768923966, 2.269873555072974, -2.523593224732532, 2.3321805683736088, 0.4072277302720638, -0.14610545151956217, -1.7880355002752308, 0.21760016117774528, 0.052759638420709354, 1.284364745737118, -1.550674543024157, -4.1505937375436455, -0.8444099240002576, 0.3738173878690802, -0.2298328221015792, -2.520115624235707, -2.3689668591052007, -0.5109577607631607, 0.05552927680862114, 1.1507862535732465, -0.13581843124614598, -0.5213260332722021},
    {3.7981595464014344, 1.4244063053247535, -1.5319410823588673, 2.6161074877149044, 0.9121994627323657, 1.268763453796888, 0.8624146151748837, -2.2586688851351178, 1.7426951365654448, 0.49466784439807454, -1.0929111714783997, -0.4066507635163549, 1.3531756743933994, 3.4571935013760977, -2.6670336666358274, 0.4424269305623551, -0.29473216603919583, 2.4432988942523726, 1.6312964161067753, -0.4019813134971139, 0.7500627701111828, -0.4797255805941005, -1.5394072755320887, -0.6308460508751778, -0.8882840406726924, 1.0063995942606272, -2.5850254349434962, 1.5431377257413021, -0.9120956351493993, 0.3672119045390976, 2.303520881591128, 1.390842616132578},
    {-0.46205986823636447, -4.663551222614963, 3.6567570888307825, -1.5203956791491053, -1.0902893439996126, -1.2534162536793731, 3.06115292701562, -0.14863073353350817, -0.04687810067663625, 0.5553389319577251, -2.091082518141956, -1.467519615879154, 0.872691638879953, 0.8367154401169823, -0.3379176834472295, 0.4768154945280815, -0.9289404835468971, -0.9565405182726937, 0.1717280932818797, 1.0195348788908707, 1.2066878846965974, -1.311798122786703, 0.9764857132922158, -0.2645131151176543, 1.6428539166707414, 1.8283441493079167, -1.5673933244292155, 0.5810230701043244, -0.34370521582157104, 1.2572249955542705, 2.7360792101022704, 1.1853032664457512},
    {-2.5086023077622674, 2.543202268553553, -0.985767246059234, 1.205574286461467, -0.029976286971680855, -0.315057172865572, 2.9338300799288937, -1.24744065061631, -0.8775522094076892, 3.0374016236721433, -0.09546657057185756, 2.1594929106473137, -2.0786428657938583, -2.350225541643653, -1.2236359927996892, 1.6855429210214952, -0.5621439897041776, -1.9128522283438445, -1.31535794572108, -3.2250472960250463, 3.2286758108961973, 3.8773771485979016, 1.4804841902930101, -3.1115405334352118, 0.4841274818272923, 0.7381026390207529, 0.43015120402658114, -0.026645807603241256, 2.231437858652435, -1.2177309714107758, -0.014731961624632292, -3.155816367834964},
    {-0.6197912940652547, -2.1597951734731278, -0.6769787170194062, -0.11938431964141828, -1.6105849987394674, -0.7347016796119705, -1.4460476769562078, 0.39929134906619373, -0.6523272403338105, 0.533810068429275, -0.07326317122654247, -0.23400706218270334, -0.24391123613773294, -3.2586004468179937, -3.6057644443649064, -1.4115845772442324, -0.08315329864040823, -2.4382904821921123, 2.26220103193913, 0.534125336736828, -1.28063675137955, -0.425936171519061, -1.518469351140083, -1.3105485577374414, 1.8070616117605065, -0.12971673885252483, -0.23181406585954972, -1.6087169113565836, 0.5723116036067484, 0.9854481005938321, 2.0753857811358065, -0.0062059570648263776},
    {-0.36536714089815975, 1.1702631054064812, 0.36213867280802564, 0.9116891375532344, 1.3132571717691117, 2.203749652507895, -0.9056462294270184, 0.9227873818113985, -0.7053361894017017, -0.600806504967978, -2.379517228050675, -1.3945734875874847, 0.2893886946450841, -3.050226875437804, 3.19898939486408, -1.4008979755743045, 2.3273018891144703, -2.639437518307985, -1.9334517471959243, -1.495840220149557, 0.07183656237807905, -1.1390722246981022, -3.474403479986697, -0.7329206622372678, 1.5987791664443798, 0.2357238020458304, 0.6959869561836366, -1.8897283444274888, 1.3903286366199048, 1.5589221198700394, -0.9946766759211431, -0.033979930939001604},
    {0.5618840333416564, 1.4704685542691973, -0.13703619261894737, 0.24371668559143791, 2.07371496259622, 2.052388117526115, 1.8274545884735554, -1.7314643636528282, -0.5440623577276683, 0.8491704019241462, -1.859958573867468, -0.6037365062260021, 0.9652288363364335, 0.24478284387980467, 1.1421159077182788, -0.09994264801678318, 2.0473698704057783, -0.8205837295957443, -4.010458791469629, 0.009135034427674325, -1.6658367265443867, -1.4405347500630674, -2.734894147831486, -3.3546026928108077, -0.3078240123243697, -0.9645833562552139, -0.46366383520351584, 1.9322937723461304, 1.4049899687327065, -1.8268662367274684, -1.3317012007511462, 0.33963820431558545},
    {-1.8278438295369432, 1.0970393104862441, -2.0964136396576847, -0.6334360893637666, -1.7710472908154211, 1.4385810506952994, 0.8680719885286954, -1.6541250652393458, -0.34428643151117355, 1.003840041007201, -0.6441573676845105, 1.5307168653035146, 0.6370100880250688, -1.3011120247498773, -0.7967659303741963, -1.7331676604040376, -1.0432349301807942, 2.3018158723329942, 0.13344412237356826, -1.356898698156817, 0.7648848994436014, 1.29877506785187, -0.059357119393513354, 2.2159528916860634, 2.6557822375522124, 0.7561118009545283, -1.1827450471396932, 0.07609012680337855, 2.211838111149335, 1.8521510565591368, 0.9052758610475026, 0.37529249170315737},
    {1.3626733860009286, 0.19927581524013813, 1.2378746193633778, -2.274020263066494, -0.07747357328254781, 1.6162036666799466, -1.1280295619049296, -1.1516541176813737, -0.6101632399263759, 1.8840068442020985, -0.4444570100014051, 0.9260869550978155, -1.1639416872675956, -0.487091746296831, -0.5229249258258504, -1.9202673932600434, 0.18101878606062535, 0.872681851524004, 1.449695813732734, -3.527476277845967, -2.479625464278938, 0.6428303584054373, 0.08532124764066444, 0.5588918233651664, 0.21005772848571302, -2.101274740470336, -1.4396543297646531, -0.33210694261610907, 2.9191899854657413, 1.0094711913392496, -0.08661689862996913, -0.1610584786564431},
    {0.8607006391602569, -0.7108908232327132, -0.3065704507235912, 1.2885994515273147, -0.7742382150038972, 1.1395211529355493, 0.404231248621185, -1.7927487450624944, 0.14673600268402498, 2.3981287738035015, 1.228445131272589, 0.671400105870983, -0.5064138762178649, -2.484202228803472, -0.7089660363864342, -0.5719965507662012, 1.8746445785422619, -0.6083668730497012, -0.7978720498940576, -0.0588079655819851, 2.4401666196457543, 0.03950737196435741, -1.5452659544034166, 1.2341612929942263, -0.5113271115614848, 1.3373076604735665, -1.4280842634137383, 0.8305874567749583, 3.1660369550747, -1.2353611769278927, 1.7756198746652918, 1.6150123778347434},
    {-1.1792654364687865, 0.349247398420251, 1.69623516288192, 2.3360335385801707, -1.4578962514101546, 0.4364421505451268, -0.5996047165734891, -0.4610440384149002, -1.9730573260529118, 0.286116935268117, -3.5033421390296793, 2.6418907338996624, -4.010211936011519, -1.5547034863633287, -1.8965844088348882, 0.6146212257604272, 1.259179316178516, -1.048323274684522, 0.9435457531315953, 0.6301467849572263, 1.4652396254436202, 0.5004481857528521, 0.844027516642505, -1.1721995650908072, 1.579012237325467, 2.669717295208407, 0.4479921661151162, 0.3738611042847894, 0.07096508223259784, 3.7196112772043928, 0.1413731091402185, 0.5940898980360356},
    {-0.34795473367537766, 0.544470183792305, -0.1977314093129921, -1.8245746446125946, -0.8499116967732796, -2.431057094025022, -1.3957782380031218, 1.9340305047545878, 0.4105849380216614, 2.455934948924738, -0.6378121359085386, -0.5832162606101337, 1.191997075699161, 0.17588435331066649, -0.059736006773836454, -0.8181839930720911, -0.6738349773496184, 1.1555011047755894, 0.24010760044133483, -1.2088271277303968, 0.7119655143799237, -0.12589236424296166, -1.7911224046435767, -1.0063065867172833, -0.022763679380411447, -1.1923985285657341, -0.12116268806056707, -2.9532296335909964, 0.877422487877824, -0.952763645648681, 0.6877330572900818, -2.122050764809248},
    {-3.2313274536827206, -4.174496052960898, -2.1603243107463848, -0.13251720344183454, -0.9827090227097632, 2.363999983548084, -0.49875998789537623, -2.793562854806215, -0.584927584967922, 1.9681789228234854, -0.9913008623390478, -0.006559962908669245, -0.9958642804891266, 0.4053216625925514, -1.155931201011089, 0.14006067532127364, -0.060870409266876806, -3.249414022448933, -1.844715608782862, -2.1810062066994402, 0.030649254798213916, 0.42814864229352856, 0.2413451178038651, -0.166205653249305, -0.5033945773530512, -0.21131395212499043, -1.5969996348568125, 0.29027329144504344, -0.5831912014077414, 0.1258889096723025, 0.5034737798695255, 2.449200539506772},
    {-0.8116381447279776, -0.6571969286385038, 1.0854480078500386, -0.17858500120303292, -0.19787208810847584, 1.0500915164630247, -1.954240712959447, -0.8850973424155741, -2.451119673922212, -0.2468979603684209, -3.218781119547783, 1.1660367893514714, -0.25608134251187714, -1.522659416227071, 0.3163702116343771, -2.8394604765600806, 0.2901077813039372, -1.2698937225596316, 0.751911561009979, 0.6567950648924035, -2.119066969302207, 0.7340065749619017, 0.40705419256855796, 0.5935184168549451, -0.44629713649247604, -3.0395472952199882, -0.30506656198577414, 0.8763259777695125, -2.0460449181928246, -2.0929737510507542, -1.9651171174304698, -1.798909948977261},
    {-0.6065336696045978, 1.8007519890192953, -1.101891877472891, -0.7856588082754133, -3.6334456749828856, -1.1756809635982874, 0.8945982606348253, 0.44095865633910847, -1.3053418677536848, 1.7603672299340924, -0.6235028785346025, 0.6095505971832991, 0.943138475056607, -0.29714499519631743, -1.3547209408023926, -3.4483898877329793, -0.6258395610747679, -1.4367750729391078, -2.585293508604445, 1.6847022022764775, -1.967726306862775, 2.68792759343296, 0.9434819975317128, -1.0854202056540525, -0.24614571143523953, -1.2853856251948872, -0.3158993364763103, -1.6691093143288862, -1.9846427456498636, -0.7774650146940295, -0.556650158482078, 0.840078127913736},
    {-0.08270462635123069, 1.8051812068430473, 1.279813657989307, 0.9808270883357656, 2.2683482069443546, 1.1695988374671324, 0.36047913913462093, 1.3983206457777664, 0.8005520351023886, 1.0385258226827463, -0.9160025911399726, -0.7224454425253342, 0.2208216236370743, 0.05164169414943854, -1.6566121014247819, 2.1402480278246943, -1.1073014376569186, 2.490469389622866, -0.05480224727274118, 1.2847466454839955, -1.942979150406224, 1.4622400801583022, -0.6618570529970925, 0.6232021002746547, 0.4114604024967611, 0.5334434323363174, 3.1615546230973712, -0.4752523704465083, 0.05005458231661872, 0.8096634461492918, 0.015878182487241252, -0.9362006178416572},
    {-1.8911339165962218, -0.7951000025824133, -0.3488888609517432, -0.8278800673499727, -0.36861128981331975, 0.8075650636258819, 1.7975244933883967, -2.2427585268170764, -0.7477059133767339, -0.1197158421730651, 0.7926945136071832, 0.4380493996928674, 1.6860719989410304, -0.6938143861671536, 1.6961312229380046, -1.2713072277514395, 0.5436706283208015, -1.9829360894265373, -0.06611344019887368, -1.8181955562163472, -0.9797461992853385, 0.17672577962942343, -1.61313219967154, 0.24169966880609697, -0.8500215483286798, 0.3101947726594521, -2.5352953469420365, 1.6625369535193528, 0.3478573849341091, 1.5622633473276673, 0.9432126729521325, -1.2277653589258626}
};

static const float b1[32] = {5.897109420110491, 5.838312617556148, 6.616380185924037, 6.1896397771677405, 6.169268833172204, 5.208928748636524, 6.054665848003291, 6.473933145231403, 6.537675822987725, 6.3033026039771585, 5.4346492734180725, 5.241216942975736, 5.891850159154498, 6.499027952477371, 6.108189317377481, 6.466378588749032, 6.470591591628896, 6.764220554040107, 6.887685238883434, 5.047108728017601, 5.97167311079593, 4.837023778451883, 4.187556205291009, 6.506507199558919, 6.155558252321642, 6.62963181207376, 6.041833918404105, 6.2744288386461395, 6.37781757499098, 5.085924085821879, 5.5919485229385035, 5.769104002238313};

static const float w2[32][16] = {
    {5.31800995472882, -1.9553313676601811, 1.0046978040815278, 5.66133005741212, 3.4230315424362217, 6.173235320903504, 3.1174889148683325, -2.9334503972041204, 4.588542299472855, 1.3901412511773228, 2.929106538100399, 4.702450138178361, 2.4431956580580527, 4.629009123419198, 4.037969217180696, -0.6420693836678754},
    {4.7968352469201445, -0.12232685977937535, -0.4936819598429848, 2.6812117524911403, 3.1839295753504655, 3.8291250250083793, -0.6227960868417821, 0.28794385646125864, 4.60870488198703, -1.1861502849108743, 5.5498928790536, 4.085724675598307, 2.5629793000422354, 2.7080987758679216, 2.0670523936284657, 0.05662885127322467},
    {6.514742305873963, -0.7191390032389844, -1.0663801809086222, 6.429033543276942, 4.121768789739088, 5.808634711080854, 0.8552398928299277, 1.3071337071049942, 2.9629508927331596, -0.3261582296877628, 3.6607300587691873, 6.392539457601259, 1.6594316547961165, 4.931354088373322, 2.494249909578257, -0.28334134356217655},
    {4.830275767254072, -0.0997055647677955, -0.038679315462371536, 5.646448111569059, 4.270165249759295, 6.132024406922275, 1.5901352349751676, 1.9488094501655884, 2.621939379330092, 0.5301277850625647, 3.8879009253465253, 6.262620443282126, 1.5434959100851464, 6.289329771843527, 3.5923689626164585, -0.4218638709472874},
    {5.2470246346586915, -0.054078200737503815, 0.7748689693030882, 3.450673262723387, 3.904857596615602, 5.027590721688127, 1.0616709354085898, -0.4927184512910653, 2.810312811415988, 0.9234588111543479, 4.341336706776982, 5.381808882906579, 1.9444350175605507, 5.143917716264959, 2.7142130733851113, -0.8994792515218244},
    {8.993521709183074, 1.1833397796648886, -2.3553957272799035, 4.666734551517357, 4.798934026200576, 2.4618225366623285, 0.14635140265069327, 2.089180389933867, 5.22553697259304, 0.24731291021889515, 3.279618376404704, 3.658640022554431, 1.4412353875089179, 5.631796659869304, 1.9097016403921705, -0.5575313669645304},
    {5.544709480101578, 0.9284411436711144, -1.323265283435164, 2.979598542200895, 3.0770083185718997, 3.882237161590919, -1.0935524586598608, -0.2445927048374284, 3.6223511618675612, -1.1229970121714794, 3.6681316717165675, 4.712535583741434, 2.3940686438365457, 6.381707153020105, 1.7504235042285379, -0.8163183611564694},
    {5.408814134434657, -0.10903593516541292, -0.658688144802884, 3.875489279358395, 3.7240735645619107, 4.296485287374216, 0.3070167892619397, 1.91467791056449, 4.845723924047956, -1.5797577943861905, 5.190575776084429, 4.350792016884717, 0.4199722358927788, 4.945372824269857, 3.029621913181097, 0.31859375931577816},
    {6.861547028350183, -2.0727255882977658, -0.907121118403862, 4.231614601958438, 3.406163029089293, 5.197143091530777, 0.2800291803502699, -0.1668919007299149, 4.404438474123081, 0.10979363451851527, 5.090161006658045, 3.9321958792057043, 1.4198041124314074, 3.24287919130996, 2.871648654256087, 0.3459368697927154},
    {5.998927960227683, -0.21110127249707625, 0.5099621971532189, 5.533958564120329, 3.8339540972369233, 5.29789162688646, 1.4406437144439623, 0.5404224429366054, 5.47662240452851, 0.35000290316911836, 5.883525944428446, 5.26155993266224, 1.4206852870833264, 3.4615008725956082, 1.9704580118716788, -0.8476329709641011},
    {5.547763912323476, -0.29578456279079085, -0.5821399173215697, 4.963774116659039, 4.54876177608619, 2.994100120250074, -1.0222592345976889, 0.05203517477625369, 3.928517954856719, 0.16038681962468515, 3.9491255055748185, 3.978581566377614, 2.591565955589784, 5.287867894425489, 3.1449146516039383, -0.9398065763480792},
    {4.757730742677718, 0.8147291459618095, -1.890523723755421, 4.363014503715611, 4.728654477207943, 3.6686213072223905, -0.5162199530599513, 2.689825179966301, 3.00514912095824, 1.174045789676915, 4.767792580755329, 3.461126752184292, 0.6153843470843189, 5.009705710851976, 2.074323799204243, -0.3897656003973266},
    {4.200549847119984, -0.921728423875496, -0.2618438220030057, 4.1997002810800845, 0.7908954690463778, 4.3316302928674695, 2.0647205643221973, 0.34871386511007607, 4.267684296842319, 0.2819862324236829, 4.787886305817468, 4.522952970856811, 1.912252807474255, 3.9957803960768743, 3.3114030549928355, 0.7872717776618828},
    {5.491648701652851, -0.9237522740037756, -1.0052485113513698, 4.935524116910001, 4.185332383228109, 4.985074127879209, 0.10859347704648535, 1.5662268937373698, 5.28729611488078, 0.19601946945642354, 3.740655301758883, 4.563494757777092, 1.9820575754485437, 4.8928562961002084, 3.9682597015432557, -1.3338936264488161},
    {5.256804792667533, 0.7186419149566655, 0.023458814768404796, 5.476564042876522, 4.853973993630513, 4.5663758288577885, 0.31591337643948225, -0.09842444015736568, 3.750749054014426, -0.7232848391407151, 3.7683395210075963, 4.588080095367447, -0.2825194536553789, 5.298820752173638, 1.1762640708130738, 1.2929854368799167},
    {5.7476986032822195, 0.11119289694993824, 1.0989140145401453, 4.0284205283733305, 2.891578373393647, 4.669131650955735, -0.1522565930899826, -0.8461228826363082, 4.319341779073334, -0.4088207470322412, 6.057205051466768, 4.038444624080243, 2.940133613728613, 6.362391209547685, 3.4327950846797997, -1.0806901234522222},
    {5.056399860139906, -1.6169271416179718, -1.9714011974523562, 5.048502944234617, 3.0632337723591787, 3.9133667817364586, 0.9301887935437387, 0.09402569560387526, 4.760727022590642, -0.8712248429731666, 4.243235665966608, 5.193824640592429, 2.9735038087843977, 5.442074564359584, 2.4943498892794236, -0.4606075602149352},
    {5.034673248099635, -0.22185582645275187, 0.7542573109364793, 5.187631836286582, 3.8829924311646864, 5.468263893842745, 0.632394396950581, -0.14269010835197057, 2.9925232443142664, -1.6300228127755607, 4.654935675460286, 5.669864292744983, 1.662361072183903, 5.974625705103485, 2.295879498333224, -0.4875582067287995},
    {5.151647403441494, 0.14107641681654345, -1.051612722289464, 4.104639619894494, 2.507260943747892, 4.691106827102935, 0.37106403854212666, -0.4502663954703414, 3.6899235292205868, -1.864362170954275, 4.946810023017857, 5.253715058344682, 0.16154184894398652, 4.694193742446626, 1.3858715494434115, -0.008330178019457757},
    {3.0702827621622966, -1.2045650813328244, -0.726374636700647, 5.243720875931692, 3.7000735365358173, 4.594376295296379, 1.3673092029796927, -1.6867074155709716, 4.129877324766156, 1.0441646511347256, 3.069162100619201, 5.177425909749509, 2.7131621926761764, 4.281803937751379, 3.32623541417615, 1.2111924343075289},
    {4.088312188376099, -1.5377252240739974, -0.9224407053596457, 3.8836575844357117, 5.162987623937191, 5.09075790333145, 1.2161142835719219, 0.06931068583848177, 5.452016896436209, 0.08641869246162526, 4.173205243895634, 6.019911683839825, 2.1532692152523456, 3.075190604760557, 1.0035894756921038, 0.10253434868186696},
    {4.21195540194279, -1.6462358303564544, 0.23687575217704884, 4.11446206884586, 3.609401398807623, 4.015823692655857, 0.017447723700649256, 0.36337749489535004, 3.096078820104465, 0.13073470020676253, 1.687036194650221, 5.202421381374021, 1.6313764431877935, 3.1871551535060645, 3.3319583909142523, 1.0340618270495334},
    {3.721282472931412, -1.6737752427213761, 0.42335661162797156, 4.078307313233673, 3.194508703493315, 3.2626917483257594, 1.4780560117736719, -0.6560388622723465, 4.496081901752315, 0.8909519625833187, 1.8720641600177925, 4.758076484373904, 2.4036632048902917, 5.627150323545357, 2.8414227363680284, -1.2274954402565565},
    {5.382056433458795, -1.1141695446171394, -1.458932683244929, 5.74324265546183, 4.798616153222144, 5.09769193145798, 0.8024484383720066, -0.8236864350028523, 2.9437785390238846, -1.5441147248638563, 3.194185436673414, 6.279895538566751, 2.033068000575086, 4.7890589961642664, 3.3076903907465076, -0.9708118053162196},
    {4.2255157886078925, -0.9091214834851625, 0.28878985065336404, 3.482186686220581, 2.284411559389327, 5.845115771834128, -0.21144020957448112, 1.1966809386867625, 3.9615219214851516, -0.009941861126959968, 4.334895370847917, 4.227716503773877, 1.6371215416572853, 4.825029291647072, 2.411651576387069, 0.09133977523822687},
    {5.621520373294758, -0.5906261799307293, 0.40455025615432505, 4.4411052830393345, 3.260889214678008, 5.571271238765865, 2.1577365657376446, 0.09659250091636577, 3.3233999983141684, -0.011695731767879766, 4.980293921877569, 5.421608456871634, 2.1319355568586587, 5.098989007949993, 1.5920447795091446, 0.6438171187315637},
    {6.572514833781913, 0.8143114019268215, -0.6438955042163748, 4.960338323636781, 2.924142173433675, 4.442241233772451, 1.8754697024839369, 1.6386472598896236, 5.110194960829328, 0.09266881956861471, 5.082676024562366, 3.3826862853043536, 2.0767310262597216, 6.716002653989693, 5.520474315842079, 0.06929187571749594},
    {5.6575865124307745, 1.4978493427908437, 0.8347196891110387, 3.029782316869371, 3.7290459500258186, 5.492461332556321, 0.5153316804744573, 0.3340894843666902, 5.033668745218946, -1.5176645256445178, 4.769113931367851, 4.894650259499927, 1.9782365219217262, 2.8496403734872304, 1.6204417225834005, 1.0670278318396524},
    {4.7761476886851515, -0.6755733098184353, -1.4936025735100724, 5.445322872628486, 3.654594340909056, 5.649586945799181, 0.6250626446813258, -0.05070678393748116, 2.466931330693359, -0.40866938936296354, 4.846588824160783, 3.781579421922703, 2.8333703812061075, 3.944694198553205, 4.294565775792506, -1.800412759424864},
    {5.0190400263157615, -0.9420420990993714, 0.8438116159955288, 3.6363399310196685, 2.454512441343444, 2.6172528852450596, -1.1002488373865762, 0.9935724136709883, 4.781229968050648, -0.561609665964059, 4.810072682856155, 2.8080206121562665, 1.6784828982974656, 5.504235965300024, 2.5387429020538765, 0.16635727062956837},
    {4.921980648394209, -1.1195996749967343, -0.6670495597147851, 3.638740439233046, 1.6842328150012216, 3.833292909839446, -0.8228195899614481, 0.03053492712590928, 4.0735126345334995, -1.2562240551579325, 3.274492850952535, 3.7296153273255523, 1.1000484112064475, 4.052797479376754, 3.925412281341296, -0.7008804982857031},
    {5.769827571457023, 0.29518318280963873, -1.63450288596272, 3.2502344827984957, 2.69302679637287, 2.735359369306138, -1.5479612395007127, 1.8853854568964972, 3.1192274324550935, -1.6783440931570335, 4.035743765358028, 5.283591060146357, -0.4125690547343314, 4.768640565187145, 3.393402903460653, -0.9005552077717264}
};

static const float b2[16] = {5.913737943517532, -0.8227647312414373, -0.3880006272078537, 5.374518755532175, 4.305802116491179, 5.751975539005127, 0.8571041266927217, 1.1304713571863554, 4.9913310930290695, -0.7846551110015388, 5.327132848297525, 5.728429592726915, 2.3731878580861334, 5.530813809135057, 3.2664943350776117, -0.22891057079338883};

static const float w3[16][12] = {
    {-3.082384457646859, -5.416353749102884, -5.185783221052244, -4.176715573197573, -3.6347448695123448, -2.398016178630594, -2.4403725109577223, -4.833723873071627, -4.601351643651469, -2.237806889881446, -4.30247454046827, -4.846419696098481},
    {0.9323792768956144, 0.218809147936736, 0.33321206382093055, -2.40066529135503, -0.25137334935209066, 1.7978964206159886, -0.23132585840275247, 0.38293897059678794, -0.20131105735810395, -0.8257923005922497, 0.6271602526083192, -2.6538320550047296},
    {-0.7916929463483293, 0.7390957538279944, 1.3955831629227688, -0.5304531136000117, 1.2252540659122797, 0.2813279207133601, -1.7277138658467093, -0.5832170842593841, -0.08548557979642185, 1.8322737606690518, -1.6440157291491082, 0.2996492351624313},
    {-2.7444415481625386, -4.3379515025405375, -4.045787567513457, -2.902541177992192, -3.899458868242229, -3.2251137422444565, -4.11216755183486, -1.4638429061191347, -3.0514535667157916, -2.951156959424742, -4.468780556097655, -4.659554302866757},
    {-3.105965770751731, -3.4434142814871107, -2.0592038187583483, -4.071194657345838, -2.617920770060443, -2.787739673131496, -4.478292356018724, -2.630206841109234, -2.7941222684259057, -2.087986195620037, -2.1804428240201843, -2.0143180930205316},
    {-4.025829706842171, -3.0428206228304844, -2.66667434959796, -5.456963447589304, -3.571261354468973, -4.415106784797186, -4.563992091166187, -6.57015312189154, -3.594801831801715, -4.777363436631847, -3.607074884091497, -2.002748096419586},
    {-0.8043476806424279, -1.5838222265960935, -1.138302506497012, -1.9056893218190092, -0.6928502772697083, -0.5869412748122497, -1.8673065647522207, -0.6720250819987127, 0.08354695993957074, -0.2438686665631139, 0.23997084964322243, -0.8133458786111541},
    {-2.909646851738045, -3.164495899492635, -2.0723921433187455, -0.45873245539096325, -0.8838009834459798, -0.7342920561167713, -1.3807338978859447, 0.039183103967116016, -1.1794040057431656, -1.2999510966231411, 0.25628259971215017, -0.9460054152864095},
    {-2.3296872019903136, -1.9504996353034132, -3.219177075848442, -3.326201159253577, -3.7885457539141836, -3.298356189102603, -2.6177747032141414, -2.9697141326353407, -2.359665389619647, -3.2882157225740385, -4.050399733515908, -3.413790214105313},
    {-1.9668535830167118, -1.14520897004911, -0.6479000416785521, -1.2622201723946889, -0.42769504157125166, 1.3183668113718747, 0.3932919297207692, -0.23422253066742502, 0.762589671970276, -0.6944615441109537, -0.24450302507628435, 0.9172529817109664},
    {-4.027553951409597, -3.5144139140474846, -3.309557251736717, -3.457844829150448, -4.143854033045567, -6.251838014960265, -3.3935421058415614, -2.1061021055423255, -2.0226280439541866, -4.417993732252449, -2.3060433944457586, -3.9860097503047194},
    {-4.052922440338913, -2.916724119423437, -3.4979282768401316, -2.1406209172791675, -4.240264071009126, -4.333582635103964, -3.568432592446798, -3.871732645611418, -3.738328020929942, -4.869610157295838, -3.7031214891348054, -3.881363074932819},
    {-0.4836912989956735, -1.2139150918246502, -2.105289563558016, -2.153569606071671, -2.2815068818582795, -2.114265286667475, -1.6467322183489976, -1.3058941511102868, -3.7857999791196693, -2.9579927810886826, -2.1293675276302064, -0.9199156009551066},
    {-4.431730926014443, -3.2940244674089474, -3.7087128266211695, -3.366511121258408, -2.643443371558296, -2.056943516623756, -4.023085949637206, -3.627976067635709, -4.575909394212298, -3.176139583017821, -3.720108405979277, -3.8906505016678654},
    {-3.7992501043846696, -2.5380035281446833, -2.1656707852924524, -1.3712698867538282, -1.7593194528241114, -2.0920210321664285, -1.5909212903630572, -2.4803371311488, -3.0258588920558, -2.5817536162369157, -1.8759640953409076, -1.748566140198777},
    {-0.2291897861333142, 0.059999533799358296, -0.811172559533042, 0.529204585702764, 1.4276306404035943, -0.6574168197358032, -0.9149236508215665, 0.6233645699326292, -2.2826204522862845, 2.1834813655326, 0.18795504170060062, -1.9882497306013631}
};

static const float b3[12] = {-2.7129201144657884, -3.25707056376914, -3.0429870924870803, -2.9628773326396813, -2.683057467495912, -2.6411714563347246, -2.800129434680044, -2.8296115143192297, -2.549596424208775, -2.622754324624672, -2.844200298295576, -3.0570970005566553};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
