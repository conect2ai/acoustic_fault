#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-5.583899748741762, -5.1732961374398725, -5.432413550888531, -5.16119262449662, 1.072797362949335, 1.3582697916667914, 1.1151561213623888, -0.6114476092002684, 2.919833228725154, -4.888600445765151, -0.11536860587592704, 2.320450897645739, -5.300702017485717, -4.9723428093348385, 1.8537806930855967, -5.0335534365634205, -5.668770236716984, 0.5452218218591116, -5.281340198251683, -4.971130250570196, 1.9825943802727977, -5.575925484646457, -5.410127396144675, 1.7751451628215207, 0.20636977389300912, -5.500674920877614, -5.334352085530225, -5.4485025818988495, -4.569532182666787, -5.656158434469721, -5.664521793965163, -1.7153149349335106},
    {3.6665492048126844, 1.669599294778786, 4.23396839073123, 3.991604824993421, -3.104173463059198, -2.299997331317913, -3.665067412986516, 2.3955371466462108, -3.4508277785784744, -0.05976582205723078, -1.8029035030729028, -3.0151290932892314, 4.226024154160942, 3.9902461842130323, -1.340783057894926, 3.1846907492187153, 3.6620950480711048, -2.3690185754212982, 3.799094504998731, 4.362818226609079, -0.47600414652260575, 5.330065088102715, 3.695113923232455, -4.390891240424029, -1.2805011647655153, 4.387838881942647, 4.001390220375961, 3.2307659066551606, 2.8523555247847336, 0.7039783616668575, 2.1443855972836228, 3.253136412026289},
    {2.6016157346228748, 3.6536423464632595, 3.4374183721415097, 4.001451754064486, -2.3059040383242464, 2.216484702408748, -2.6846844946460786, -0.6633759807872648, -1.047910585185079, 2.96561195441749, -2.378513576564008, 0.3017954753249746, 2.42857609435156, 4.11346987192638, -0.11660969532633697, 4.124660872652211, 2.3270826212323987, -2.4744506343126127, 2.197868302632801, 3.3718070090276444, -2.669946535607504, 2.2740606385018514, 3.7303959890236964, -1.2274133045468758, -1.5852680757942355, 2.123334708752321, 2.7372316382111337, 2.5380923896429826, 5.04559053047721, 2.3654483547269716, 2.6688983053692548, 2.8709202292978904},
    {-1.1120002853172797, 1.8252876576569141, -0.980666899984838, -0.5769319346157816, 0.5690549337718322, 1.993315299737106, 0.30543180226533284, -3.5318994953712686, 2.5313783329633477, 2.539106828582878, -2.003764375820545, 3.146448156033464, -2.545528372007614, -0.03139686922588705, 1.8529427162795171, -0.23807620719446448, -2.4178515505796363, -2.183829960095588, -2.3285099797276048, -0.8913997689120445, -0.766765502421687, -1.5429134176532446, -1.0985226996383537, 1.9196751981447404, -1.082533653292374, -2.041235567650868, -1.1161039597892053, -0.9509910494168224, 1.4489613022771628, 2.733476382507663, 1.73342097041367, -2.410683493872876},
    {3.4593602050464427, 4.14821278702766, 2.392692145225312, 2.2281188393577347, -0.4419527648115702, 2.6555704952913786, -0.7966978776030118, -0.8680901793376363, 0.16384403802112857, 4.898023563519099, -0.8754635965152973, 0.530842301450143, 1.656194878369127, 2.4918663427846806, -1.475250971864292, 3.9107173922463137, 2.32831343008328, -1.2445774874880187, 2.0051206937357446, 1.5512052462136188, -1.5205905581651809, 1.520907738922825, 3.2392307782347163, 0.21967922926083347, -1.2443164682963892, 1.6542247636867702, 2.0854207802283415, 2.5784801168574676, 3.4154945878055933, 4.935833091995039, 4.147684479287258, -0.8285868430299249},
    {6.436198165197137, 6.669167904462444, 5.951682167936432, 6.14432202774078, 3.656147672830867, 5.814329844621852, 4.542780663162827, 5.301759192627952, 1.37737330150585, 7.010679355650057, 6.291450438405302, 3.6212725970863686, 5.242544973279932, 5.917559967223129, 3.652455377719607, 5.230973915618141, 6.236160945017034, 5.7765908532217125, 4.945551985903021, 5.385844964895294, -0.9798595795516827, 5.1941458082497896, 5.5020873960099435, 5.066376876398972, 5.492106227033321, 5.531874371131763, 6.3369608600996, 6.295533583073839, 6.02402557567489, 7.295304355442088, 6.6584914989426975, 0.18651484250196818},
    {6.164917299482319, 7.055913468843561, 5.754656726066522, 5.748377509470635, 4.058047409432665, 5.999907037429019, 4.87280956788239, 4.7980750374033345, 1.8876769918193934, 6.874707170184615, 6.16494885644086, 4.15854255139937, 4.9093732583609615, 5.4181650381329405, 3.553820404457534, 5.316613777985672, 5.63289263566731, 5.56995547328146, 4.9278747406899885, 4.863443774352201, -1.06316196326782, 4.805426734773239, 5.711778885526985, 5.196083351739485, 5.338435796603751, 4.847072796818032, 6.215968450545873, 6.318440371121351, 6.257031065998726, 6.599084542317559, 6.450199226364786, -0.2230932298909511},
    {1.5892009482456906, 2.037435876775075, 1.0246386081873302, 1.6639820795477844, -2.4809588319657814, 0.3687799912018743, -3.806873967189768, 0.25125154302595065, 0.12433734084617554, 2.4961736603010807, -1.5657027676754194, -0.995960141399867, 1.3941065432337891, 1.561578340881366, -2.2613794881524747, 1.9627351963447017, 1.7077028470210387, -2.6167274510480443, 1.125237838241831, 2.1084122375784156, -1.0991397780967143, 2.741785812886124, 2.0236989201072575, -2.1720167369506305, -2.4086536130367655, 1.3514019448457406, 2.153229656696124, 1.1748825792534154, 2.1626010312169486, 1.061506093421999, 1.3153653488576225, -0.12147838176183716},
    {1.1027626441915641, 2.208631298117543, 2.025643434398806, 3.182083531055075, -2.5020873867222098, -0.38013860791229903, -3.273169324551579, -0.11946811460260377, -1.0421850273376, 1.382525240037346, -1.8097345652538046, -1.0518903693825175, 1.430302074269111, 3.2299000929379176, -1.0108589291858738, 1.053006986836026, 1.5933011540938788, -1.9221434495221554, 0.2561237197445698, 3.7371854165503766, -1.248168124825204, 3.7879517450684053, 1.8021294373646848, -1.4874215847313705, -1.7322026986029662, 1.246117736431111, 2.4440975856215794, 1.1737151222079953, 3.1378711753024406, 0.795478482350835, 1.320525242144457, 0.9837328292281913},
    {1.9848203662589279, -0.06781347708403312, 1.494542439280931, 2.1636223153392304, 1.0774949355517258, -0.3391068248107812, -0.6129621158215858, 3.8595352430297734, 0.0325892943754998, -0.09769822836606011, -0.7902330489799843, 0.729635552207153, 2.776203316655289, 3.038106598165359, 2.301058367229288, 0.8261968008754816, 2.5301541578102253, 1.4689836650449482, 2.4712324686356877, 3.5955449016209786, 3.6989544815326725, 4.604608899979178, 0.780068454162956, 0.008191969637845643, 2.4920750074569273, 1.7961341450674095, 2.138916889574203, 0.7276935045871764, 1.2244045507012333, -0.7588253801163284, 0.9143996841102512, 1.7297265120483964},
    {2.5943263510693293, 0.9723872409803636, 2.3061335404206242, 2.3930094891718188, 1.8176586422122019, 0.6354791101423358, 2.2776737649517846, 3.8544923465223246, 0.7434266246233823, 1.0948727226195876, 2.6956832757298277, 1.3212155826873158, 2.3364492986236676, 2.5985754402378176, 3.251419708581045, -0.5373283377708845, 2.9105931671543983, 3.5119058276815447, 1.9367767849904627, 2.8573134917049994, 1.8679569353016698, 3.36764768387011, 0.7915745180696652, 3.12814490851767, 4.735495351784037, 1.3149646358447171, 2.568320092516234, 2.856766442156992, 1.5106028462631476, 1.2458323237251498, 1.8571677838900518, -1.4647110153005956},
    {0.6720659278607599, 1.0421837261809677, 1.9594802515715328, 2.7769512134828895, 0.07807811729940581, 1.4783419426525064, -0.48343709811467683, -0.06599051297538958, 1.069391874058926, 0.4370301496321152, -2.589774116196656, 1.9878054712315, 1.223146552576655, 3.3263019440995443, 3.20769591629896, 0.4740546959827522, 0.5235661434053408, -1.193424471876336, -0.5107021955977032, 3.3745936874824625, 1.7134193622311669, 2.7955841392712815, 0.35164882528098873, 0.35958902609287635, 1.4249870174056711, 2.0357139482808937, 2.396352270726708, 0.24000464909727734, 3.069457166330395, -0.5966072320402698, 1.1935579625852941, 2.255055103016882},
    {4.419218720303708, 3.0025987377711623, 5.4039032915120995, 4.103518784541055, -0.8046279052152426, 0.14267274250022893, -0.4047954928362234, 4.331622532143662, -4.3065506008463945, 1.9140527623780952, 4.019342823088883, -3.1715998873000535, 4.933509403316129, 4.080312377500606, -0.43862617259891346, 4.430714604045728, 4.520037391666891, 3.0832553339204174, 5.034816445571265, 4.117571594110323, -2.1401719472715155, 3.9628476859193995, 4.92335326620753, -1.2715254213722968, 1.9806471409716944, 4.960123441829258, 4.461537792343126, 4.421353027665733, 3.8249768701837086, 0.3859488784200856, 1.8545618189344797, 3.801256377798061},
    {2.1320389020702875, 3.1883408053217592, 2.4512681305421364, 2.6286273522437296, 3.5189281925755767, 0.5720371867259614, 5.511879180194161, 1.8666204116393637, 1.9753330164622365, 2.7033977680760763, 4.994178770594497, 2.839716821713135, 1.3581499169317555, 1.340667364781303, 4.970475545443961, -0.9885716294434332, 2.4202207580469994, 4.290246261132991, -0.6807587707931159, 2.784870490801147, 2.1078053187817, 1.9273954741166592, 0.7948373999944998, 5.588032375657852, 3.7446538959358184, 2.016049950808382, 3.229574994663541, 3.276765670546939, 2.119157835276392, 4.144592542550703, 3.124383162165201, -3.4014244192363337},
    {0.22007967403544548, 3.3457340445200905, 0.2863929724662441, -0.24337235213603806, 3.090515676269149, 0.011410974621909702, 6.10528689264875, -0.7308458923289773, -0.3048744048212669, 3.179686259452617, 6.29418479334739, 0.4059618050885185, -1.1412675924332736, -2.049031581396278, 1.5390716724955111, -2.9471712389727642, 0.1946213596461722, 5.586868311860493, -2.65372052982511, -1.8637323980844565, -2.475370257782029, -3.0612775369627725, -0.8277463119633307, 5.209540023103744, 1.8266839280662057, -0.7610479962449818, 0.684396420364883, 2.6377292603116533, 0.6762954486869998, 3.7114028448568988, 0.5095011216498111, -4.495135112378489},
    {2.1770126533031595, 2.612771004066381, 2.6616431938751295, 2.3781281871436666, -0.15230181946987087, -2.307724083478635, 3.2147874514271306, 1.719384566333584, -3.9190578017502244, 1.2291996153078513, 5.9669078560610584, -3.4542639866951608, 2.3044451517774602, 0.041707859955008565, -1.1154725077646865, -0.442382037697883, 2.8354737472880283, 4.280281108059394, 1.0185869439096733, 1.1247024751302774, -3.134554003584804, -0.07411573878790204, 2.531292898656348, 1.484000911770605, 0.7850634733230686, 2.7135477380549644, 2.041115566210911, 3.738413480759261, 1.5067614318859606, 1.4455796915183128, -0.21310851134304684, -0.5077633618365505},
    {2.714440520541479, 4.429305979747407, 2.630471485683641, 2.5453093907816853, 5.413116973726169, 2.3147993332357086, 5.885760057250091, 2.6481628198960516, 1.7632832581631803, 4.1879735277978, 5.8434649100541085, 3.8262106298542986, 0.9679978286553714, 1.7360045049207093, 4.305233388734733, -0.2152167659700844, 2.882542290727248, 5.387622447894302, 0.6799992835438841, 1.583557889375385, 0.6800880558904182, 2.2509463210442644, 1.4036481348205732, 5.493583285623174, 4.957631184324422, 2.4497806464638243, 3.0648765577396144, 3.7618502433303806, 2.332077316024719, 5.0455891560136115, 3.5023016915373875, -3.9808755651103995},
    {3.1928733346731715, 4.018330972704017, 3.276446322082772, 3.0152717085650145, 3.712475120578076, 2.3604156407516714, 5.487273188808154, 3.023318549126123, -0.6827202249716371, 3.667372974114542, 5.168686854046971, 2.6370957749943806, 2.3883982390637524, 2.6443301141425875, 3.9990262137377623, 0.6561649662221362, 3.36120395248803, 5.617713111392374, 1.997831205212543, 2.8739716640816035, -0.14598641767970166, 2.6316095522144085, 2.5149782960323543, 4.844790525345467, 5.025911902330968, 2.9323840978874705, 3.9322596367758704, 3.9115970562621385, 3.427004716576543, 3.755139206686883, 3.270467918388345, -1.5749876028013983},
    {0.4574469121125143, 2.2909298102596996, 1.3831084123112283, 0.456422956092371, 2.185009448560684, -0.24548862450744632, 1.940352725589798, 0.04959132303022621, -1.0554795597626625, 1.4228702859743412, 2.0838439353993494, 0.42040543812276576, -0.9357717373848109, -0.08774407754431711, -0.1670616228524145, -0.164437738949324, -0.190885276094438, 0.6589057335209908, 0.15685790742749345, -0.6695934876704616, -2.620124574240143, -0.6748352062684517, 0.9758104279169806, -0.2573604447419204, -0.806575690697893, 0.83938384447114, 0.44714209035447444, 0.8674520593691132, 1.9307936252473528, 1.755520016650161, 0.6578193230547047, -1.0358144384627832},
    {-0.5957640246150078, 0.02713070208893694, -1.0436686535490116, -1.6574449002673528, 2.7962399632931314, 0.4105215465259963, 2.1844384154195495, 0.20943804596983143, 1.93121600432929, -1.5823207363289653, 1.9228994440306406, 1.8567132092409715, -0.20597848033092953, -1.2827940890434546, 2.696299815337816, -1.3356858433330268, 0.6343508737754916, 1.612642515740725, -0.42651182008006283, -1.2955319076082326, 1.2028060046628672, 0.011874648955209245, -1.2055902462220964, 1.4066109821795012, 2.424517797360511, -0.08604882233229, -0.43570281912735653, 0.7225813078089619, -1.7150990989470436, 0.09140897655594633, -0.5903913265923518, -2.588519193434926},
    {-2.9219734579973116, -1.7319103196848564, -3.366544570729477, -3.579560075841178, 3.4891905407685755, -2.144489286955565, 3.9939827920238966, -3.8883461693331576, 2.7759630937234268, -2.359750828796872, 0.8821838246916566, 1.6590830455296102, -3.82921033516691, -4.1860400814305345, -0.3497176129070608, -2.706271972552031, -2.8097855978933404, 0.3443161773434018, -3.055582241987462, -4.51148334307184, -0.044987230001484003, -3.939975886281051, -3.1678335941800233, 1.079332685209835, -1.2871901507266503, -2.863329181175543, -2.8771031196507244, -1.2337189720789885, -3.6151351062480974, -0.3580330740387069, -1.5210072242154287, -3.408912075950203},
    {-1.595595939054206, -0.8513713897071784, -2.637083741313443, -3.552780340317231, 3.4621097921580453, -2.351031596926952, 4.542241169976786, -1.8267464948551, 3.3746968102457293, -0.5557140574705506, 2.6271272821299885, 1.7699191862949313, -3.3560566590086403, -3.960365658491089, 2.769443938744623, -4.273026657892038, -1.485636666749384, 1.6898654362327237, -3.359783933255498, -3.409024849988821, 2.8592515431455237, -2.805078197552285, -3.6175278533041437, 4.338415811057363, 1.6252090976873537, -2.559636426127138, -1.5920397021788184, -0.3096320896664803, -3.9162288376929655, 1.7747983660264877, -0.06557299833581762, -5.58399165580858},
    {-2.145992248006134, -1.1154720995820064, -1.790769319673866, -2.322960616007686, 3.0639210319546994, -3.263611581641219, 3.373774603409916, -4.158248378400437, 1.4761788282156385, -1.310548921965521, -0.24983231095825675, 1.0870563781467038, -3.2234118661926665, -3.8736086571415034, 0.0882075420394542, -1.4985717045627507, -1.956217892495265, -1.2274715894051698, -1.4530596546125718, -3.951600054238251, 0.011637567788324452, -4.1165509618994305, -1.7885241493149848, 0.5024666507099149, -1.0498445758430248, -1.5827283449305587, -2.8426145709147383, -0.5011092387718826, -2.83139101094383, 0.9327850231159347, -0.9241812970477831, -2.721992239300504},
    {-3.2884841248108136, -3.1688583215427446, -3.271781914014609, -4.522912716230799, 1.315496125637494, -3.70083287305081, -0.6024507239381295, -3.7940598246357475, 2.8774986415848796, -3.397717699066253, -3.807496163753133, 1.6841125165394635, -3.787615090120978, -4.687008517641284, -1.1005015884498033, -2.507381484131258, -3.3178416319587773, -3.665388754220654, -1.8294328830113302, -4.5303670145053125, 3.4633980936746616, -2.98583396082964, -3.5099938361764713, -2.0533399615960883, -2.4442503409987766, -3.470734469802853, -3.383140110243605, -3.8544881549839474, -4.976812485691196, -1.0320094238956439, -1.0106325030275092, -3.480918412709568},
    {-1.921189834089449, -1.0508892191990284, -2.3305260816161018, -1.8660324703949147, 4.996714224994442, 1.8565780125860392, 2.6497014672355697, -1.7282744127432847, 5.6073600728006205, -0.4543316233724469, -1.7537913389550712, 6.220057561779875, -2.69460418275297, -1.3393499417395731, 4.459956247997519, -1.5556779432101435, -2.295032319316685, 0.2381953500261615, -2.667779270131415, -0.9222865145058394, 4.656715421888748, 0.11468053518446618, -3.159876971588121, 4.32510725527145, 2.689117423323528, -2.3279946900044863, -1.7016598351962446, -2.158409436615868, -2.214458412895762, 0.6894393886688814, 1.280193496024165, -3.369132740376034},
    {-5.028214034751192, -4.660265555303595, -5.061108692545653, -4.550616683061957, 2.6739204382735307, -1.4761139175582798, -1.0026676812129922, -4.276915082553161, 5.395828277773324, -3.552086806046539, -5.643270288380309, 4.650633922270758, -4.367387430445426, -3.9331347697530843, 0.7994452322172739, -2.6516838850467472, -5.199251245208138, -4.029344796656245, -3.2244432048021165, -4.229840644264881, 3.8119305053329815, -2.83915842516559, -4.7502691900490985, -0.7968480509615059, -1.4496229737700244, -4.533350358881579, -4.984290963827767, -5.2330663194206855, -4.534814414671422, -3.5989105251324864, -2.519437204747589, -1.921028736160849},
    {-5.506185548577881, -4.884080766440709, -6.209626414769026, -6.406119168853986, 2.9666948507378303, -3.8436598842908856, 2.148924048186249, -4.608286448950867, 3.8678224588833423, -4.668275824110917, -4.05703007480652, 2.817896343968779, -5.439608479483207, -5.685846992979205, 0.3772018430915727, -5.0186290247084395, -5.694263069225722, -2.1138752731045747, -4.745440746150161, -5.675446339095001, 2.8979784698196402, -4.833180519737776, -6.302935031776397, 0.7163848795762006, -0.7661616676842555, -5.896109743869123, -5.547604690376825, -5.348781665288489, -6.427608798964009, -3.4909894424863057, -3.743800115300798, -4.613432062951564},
    {-1.6472581487720244, -1.6081211095168093, -1.110306368427449, -1.069687693360831, 2.0211699797205696, 0.18060869267729365, -0.18032921095082458, -1.7277312137669245, 1.9032790288728814, -0.8595658262381504, -3.1599891568547047, 2.643188224246177, -1.969652182289691, -1.8625525922023556, -1.6337620810714297, 0.9239192374366635, -2.061679172416633, -2.3334190643867387, 0.439572625526584, -2.896042526257143, 0.2999773312950522, -1.8686918825048675, -0.7179968126281655, -0.8651385417069187, -0.4323037185310862, -1.9624855458350488, -2.0901530164740167, -1.5793141285137813, -1.9926601517665081, -0.6474996009429792, 0.8158017346125627, -1.9154347933324483},
    {-1.8641474822212498, -0.862238487377455, -3.119745495172487, -2.027174245791446, 4.624466104095182, 0.8917785249307432, 4.288964523296854, -2.2860987537727993, 5.234944093560986, 0.24556170015451032, -1.1938538272680568, 5.69065819450834, -3.8370747210830087, -1.9056908253594071, 4.396802290792335, -2.5905788024663012, -2.374682870577876, 0.176877821593658, -3.1862144393456013, -2.2247001578173413, 3.5895257570764247, -1.614295624764481, -4.138515604458069, 3.7080433978447407, 2.477191027414931, -3.1234147594572894, -1.2565186928269614, -2.095394130710933, -2.4922996612644828, 0.9813352339726207, 0.8144438912232314, -5.035077803593535},
    {-0.27075617468164664, 0.42616860016085395, -0.832684843941796, -0.9655715548395137, 3.211442314059218, -0.18920292201543776, 2.9353532652421257, -1.6555588139869717, 1.813906684878868, 1.7416638150560169, 0.043281566062086496, 3.0916190180999767, -2.3558376252745474, -1.0960780053857886, 1.5780585313667936, -2.0869915642765666, -1.1111598526007325, 0.5563665940358183, -1.9587959670244508, -1.2084581560145857, 0.20802880596627885, -1.4358317894534185, -1.8577257357499442, 2.848089756409052, 0.8452150231237812, -1.9113318592352961, -0.34580142799228814, -1.0801907076458228, -1.0020847162247946, 1.9841820997140125, 1.6620679916381687, -3.4149990388398233},
    {-6.259248354829973, -6.280570607795802, -6.655782816895299, -6.68572275058441, 2.741613155626456, 2.152009210140038, 2.227460138475342, 1.7008456803015635, 3.042649607364591, -5.20934495808254, 1.7087288226661, 3.0821415540739574, -6.058477187534055, -5.059500782153624, 2.6630074657500313, -6.651022899875745, -6.594547361325698, 2.2079837511504286, -6.724539435705865, -6.079135755229178, 2.4186290323083637, -4.714925988995004, -6.79104123292763, 2.558176080800621, 2.093860366151012, -6.749087986751169, -6.614240746786867, -6.219202451421448, -5.846247422857688, -6.503359650710835, -6.244329117291845, -5.531042216948992},
    {-5.56328430850502, -5.540320206156665, -5.55788795554909, -4.265073574315665, 1.9196446809252787, 1.7322240474537542, 0.6934127708478202, -0.3588054087621783, 3.9166979037688265, -4.947391894807837, -0.6883194949830069, 3.302129119256825, -5.173420576734984, -3.666641934366515, 3.1507296854321707, -6.166930642294321, -5.735670179144735, 1.3383473533828698, -6.315498061683555, -4.333460295256895, 2.9048203814553357, -2.9851196585020743, -5.161136428701242, 2.3489694503162433, 1.2578441963712392, -5.934980132846564, -4.8398288689485565, -5.271176909702393, -3.725491037077798, -6.031556448767137, -5.819537014979935, -4.362031912117628},
    {-3.4488950973182373, -3.234757434810471, -3.0023955155229194, -1.2426512398433633, 2.480095442791653, 3.273173623847499, 1.3663208884775346, 2.5013012949822175, 3.3508475891971607, -0.5079218668600806, 1.6718369303580862, 3.187463451781816, -2.0633901452152816, -0.13581085343355978, 3.531614477639127, -3.3176357115208566, -3.3436905961605765, 2.4721138445433493, -4.1102855854413205, -0.8111966580388661, 3.353025761179269, -0.6092325596149613, -3.334864710797985, 2.664392687785144, 2.6896888884381474, -3.220009762615019, -2.406680828439172, -3.398646788121133, -0.2527945990143141, -4.816080174872452, -3.5219984353252283, 0.007235451706125938},
    {-3.525472987806697, -3.366094853833705, -3.23951608676282, -1.0253258979406918, 2.3401787939489647, 2.44729985459773, 0.6830403949551093, 1.897556440714017, 3.0979800005160523, -1.0597878810063492, -0.004173534681263329, 2.7015811108373855, -1.345349080077614, 0.07066458492345583, 3.25729195653812, -2.8042396173973314, -3.214920387213821, 2.072409992641989, -3.6594829432964477, -0.8031122821346179, 3.05943625875326, -1.1247191842307878, -2.780345228044011, 3.1120546577834656, 1.642341986604276, -2.5256296916834717, -2.9095945636443714, -3.5810712662486006, -0.18685153079397895, -3.719094797923225, -3.613276178059439, 0.7983689747698678},
    {-2.696317430263062, -3.0903373623730888, -2.490540415273001, -1.7545393524656754, 2.8670493400187076, 3.0584852151580955, 2.2272655024336534, 1.2421769036730075, 3.595067511627196, 0.44167690980720653, 0.764275864653584, 3.1721541200925647, -0.9233922224993242, 0.028726786969301026, 3.0020998578488833, -1.535139361410876, -2.9405273140463812, 2.8199722335475785, -1.7584446172021821, -0.9556313719919486, 3.339355970011002, -1.0124774374874217, -2.5738593327963004, 2.0786719800438793, 2.560873687057172, -3.1624933213160897, -2.5721175831121244, -1.8298093014696322, -1.4346888166671108, -2.4177546599979736, -2.256151825919168, -0.6138318431191023},
    {-1.3169740298206167, -2.8812788221227263, -1.609663998118848, -0.8894427678198596, 2.459076861234785, 1.5598807962723626, 1.104006045952225, 2.3496341987650964, 3.3340966534732015, -0.38099318763911905, -0.052373134239881776, 3.371919413735583, -1.6723942255450932, 1.1241546935930593, 2.9772154437374643, -2.5251896449680844, -1.4399940706615024, 2.021315329585053, -2.7394696676360435, 0.12689018941128613, 3.787378571747617, 1.1985140430127403, -2.6835902779325003, 2.3151440574444, 2.8688269783673035, -0.4646498749825446, -0.6426586958120467, -1.6783556574437868, 0.09829451021664874, -2.7760010917331464, -1.6611244331298631, 0.34515486187045424},
    {-1.227759512953357, -1.4042041552884954, -1.299868863679176, -0.5687204203454628, 2.3874942434304183, 2.7180915764853615, 1.719236980085053, 1.3017837039891567, 2.395008216796765, 0.8338263387671172, 0.13382710158358282, 3.0278224145608226, -1.724413248372166, 0.1787139406017713, 2.1832863334925947, -1.318107968232637, -2.5492424498882977, 1.5588687452815853, -1.9601200646544303, -0.5629237472530617, 2.092479694790338, 0.2691612138843935, -1.1323094484340692, 3.0525617995045735, 1.3271397010375476, -1.5963156159981136, -0.7693485085925891, -2.0563761565643803, 0.22785225670505907, -1.867205033570359, -1.5851688633332877, 1.9859112934151057},
    {-2.792791095158438, -1.4975364403979188, -2.3125884819748554, -0.8455634071409458, 1.3742716709190004, 1.9931599459444662, 0.7598577784683399, -0.09609254725733167, 2.2058968323894113, 1.4697381487800119, -0.13834123315389085, 2.4288395546552204, -2.1656156612942064, -1.458828617118878, 1.9558585529425105, -0.8188075091021125, -2.5231389568598974, 1.7240700211184692, -2.9450256606728025, -0.5986613147699716, 2.555194913359086, -2.1867127312729835, -2.4921285271632323, 2.8247311565781064, -0.7075503404102849, -2.2295180853611316, -1.6868069773133019, -2.8326646269233486, -0.6203350383011185, -0.26337318798151277, -1.0412667043172759, -0.8784866355490297},
    {-1.5781304125556548, -2.017241784526235, -2.351916920879902, -0.6751488160126241, 1.2441656731372295, 1.5141238382076854, 0.999449794094458, 0.49447190503500094, 3.733222654349297, -0.18091178778141617, -0.48898898601365304, 3.011480316921993, -2.3051218968318383, -0.8517193122544912, 2.151676179011209, -1.633196997822186, -2.537194115828287, 1.0110262741469846, -3.160678473943618, -0.545317173219817, 2.115288957820617, 0.07271589385253449, -2.348593503446894, 3.402952891227851, 1.3335459055651167, -2.390684666319314, -1.6817284190860189, -1.9067645245734064, -0.8698262808105202, -1.8014962513020887, -1.0674573861705743, -2.9168833945968586},
    {-0.9945874106141224, -1.1463886328816495, -1.2312017075279211, -0.3146969457274919, 0.7151341672615888, -0.5672673388457591, -1.3596913651521159, 0.22852939120321564, 2.1572260638361023, -0.6567311535535786, -1.115800997938951, 0.6295696034788612, -1.5011912873248374, 0.6893039523351021, 0.6723175661550576, -2.3703314488288214, -2.1936470585246557, 0.397035723638201, -1.3865993435662707, 0.5820638752401126, 2.036481457651768, 0.21812629009798254, -2.5328815442789097, 0.7295153131861069, 0.607475887714689, -1.4072176894097388, -0.5605911635728615, -2.0522239682824526, -0.16308670133784062, -1.41819326754785, -1.0146654671462723, 0.3714689754816839},
    {-0.04889169430219432, -0.8657394790128485, -0.6773684442357221, 1.552574265237696, -0.5768163126465181, 1.8706290662225937, 0.6289491436719862, -0.49999274129788857, 0.6078616571976654, -0.7103317238537873, -0.9318372402718671, 0.101555649378809, 1.2421532831306115, 0.6867718100132546, 1.25656112307619, 0.8667097649550329, 0.9629578684633195, 0.6518397063870092, -1.481764966519497, 1.3594061147532683, 0.6980870926559757, 1.078716008468684, -0.5741286848569047, 0.6418418095678154, 0.6892644201735946, -0.7279930578861726, -0.5605623385921893, -0.7177076713167924, 0.8701099003978662, -1.9155508394049592, -1.458232467820999, 1.8353492527773076},
    {-1.3685339118907494, -1.4797555129110218, -0.4774185074735349, 0.7425345064780969, 1.2399333301839168, -0.23261347699032642, -0.7730698441401688, 0.18519148179290162, 0.5402029088245365, -1.4391208325580584, -1.6708694241398863, 2.0986434206382527, -0.8530613194120501, 0.6706909948931402, -0.5005918039017887, -0.4120645054909758, -0.6569508555329786, 0.40110387520460034, 0.09259019209275506, 0.38381950236095536, 0.7821809416044749, 0.9473377512862615, -0.36821453924459463, -0.1357762740581173, -0.8916277655174546, -0.8010582000320141, -0.7904180692373495, -0.3537279150546145, 0.002186137241602881, -0.7499364322471516, -0.8768399335751009, 1.7624268945192343},
    {-2.090827597621651, -0.1005964162600074, -1.1289468101368505, 0.22016274428277005, 0.23834646356750638, -0.06949704631279792, 1.2086492880212396, -0.7922664984180372, 2.2094785690836574, 0.83220427246141, -0.8042810925953868, 1.4396910630928241, -1.019698240589817, 0.13645281698951905, 2.0219122764417925, -1.2867103520859489, -0.012802155140450381, -0.8943413701904788, -2.510450074529167, 1.3968621685081144, 2.857688503007668, -0.5756863972834844, -1.941194432213347, 1.5847364740807863, -0.8148095368537804, -0.11579978320077518, 0.1603386226162392, -0.671645408252625, 0.26378722595623955, 0.14102083108233385, 0.2982564922187347, 0.2465438221156659},
    {-1.6817533705219212, -0.8143279350598098, -2.2953381416946015, -0.6084760070150943, 1.532734504105715, -1.6143956360848002, 0.9954528765280081, -1.904117386759053, 1.3608303508558413, -0.4328120000559945, 0.06528831862336458, 0.42008126091263703, -0.7140158544439733, -1.7705484453647626, -1.7601635682504593, -0.8384032481271795, -2.4884200446344233, 0.4349992142790621, -1.063447205671403, -1.9201329405760053, 1.172387409190971, -2.386175797479566, -0.4511789348250275, 0.720791082877153, -1.2218604446621895, -1.3116428160635918, -2.521955307127853, -1.396304544644212, -1.2862821921047303, -1.0085056582418765, -2.2608828702246377, -0.054110502586300194},
    {0.5570474808337093, -0.028923315698504454, 0.11363978321254949, 0.4430301120061159, 0.22104392838106215, 0.8418248738237712, -2.0780108037189553, -0.8875364053613239, 0.8976976232575634, 0.6423722673615516, -1.0671526378113168, 1.4387034644640062, 0.5690956944693455, 0.3179719127379059, -0.14089245616161858, 0.547671254455996, 1.3607836630726389, 0.07594276430327085, -0.06263401936113891, 0.29195793587233265, 2.0439580296323876, 0.7684233712927097, 0.7235849123838043, -0.06709699143914175, -3.090389743023076, 1.538056531176585, 1.027116227096155, 0.9015076536830878, 0.8567644971536125, -0.5669652085034768, 1.2843730895628414, 1.5023344884419},
    {-0.58741139004351, 0.16156814044369483, -1.1930027842978943, 0.5883225713155159, 0.499620544024927, 1.2070112695885313, -2.1941031585988466, -1.675746714022845, 1.0240355288767384, 0.3627703633735579, -1.8421728175634204, 2.9440426550393495, -1.9291028206555312, 0.23930590972269172, 0.45554199742409324, -2.2451250715991753, -0.876992635872742, -1.5030693377052953, -2.123491721441202, 0.8481262492812969, 1.7439217443773591, -0.3711012644771818, -0.9964650421683454, 0.5162160370708747, -1.9187377842150055, -1.8021891985393186, 0.07476947047576056, -0.3984341283157861, -0.6960584905871621, -0.7387749124612045, -0.4445636063437081, -0.15495536809587498},
    {0.16689917026479956, -0.8599804878102547, 0.2025057638348853, 0.3755959908997913, -2.7555967189857817, 0.6468828564529381, -1.7520754875452307, -1.2732939490771409, 0.8661471641478905, 1.2672955108520727, -1.2800396230175701, -1.4491805418872088, 0.9105109914675621, 0.20994286850974173, 0.9815049004932855, -0.16495965033477933, -0.06336341480425708, -2.7383356714647675, -1.339206096136307, 0.990324141925533, 1.0556997536766395, 0.26504895032712517, 0.757889350312684, -0.40668650243002413, -1.213811092000274, 0.6883842724950286, -0.1442117120709843, -0.17732209305292818, 1.50377798274522, -0.8128209506435393, 0.012696107561391523, 0.4935069461676186},
    {0.45246441027607326, 0.4835014023059132, 0.5041991339627058, 0.3951573500796359, -1.444449820617046, 0.9354664674985319, -2.9874717253381067, -0.07695009817536752, -0.31709823053565755, 0.007160417378513149, -1.6688707531486997, -0.9224582854836542, 1.0875499035395348, 1.7729300602877904, -0.555091901909367, 1.3317623296232082, 0.9512214806804763, -1.799611837346457, -0.3476802737012885, 1.693753569422784, 0.07442015912788036, 1.842169154562469, 0.36273624976059543, -2.6971961338013033, -2.233751380801602, 1.2912363905118467, 0.47600150931172225, 0.11511824699771454, 1.8279620401807903, -0.8305670802478042, -0.0831583955258343, 2.8679236730465414},
    {1.510091926229325, 0.0028057525531060153, 1.3049567469555086, 2.4059494941740938, -2.2051425469790598, 1.5450542529530094, -2.07443774763712, 0.984837808548378, 0.4893266183061107, 1.476851283164195, -0.6614134553629231, -1.4842811070553124, 1.1558907055044527, 1.8610765775396634, 0.39534902712119757, 1.6832923469995755, 1.1825926923896297, -0.5634737867472657, 0.014140045246501294, 2.1251527730186424, 1.602464457520145, 1.9911540639907588, 0.40966111849094233, 0.4369020258910932, -1.948931177746817, 1.4183905068978324, 0.908053409216057, -0.15360221591305462, 1.1229603628869953, -0.8679326417354282, -1.1261684887986887, 2.718236105601709},
    {0.0374470137728172, 0.2758841313605952, 1.625946222972662, 1.2644102685241108, -2.834351059772716, 0.9873566829573129, -2.4888179266848756, -0.9680263363275178, 0.7908480860169115, -0.7499188037044232, -1.7734761611697691, -0.9141057760061044, 1.6076402786487458, 0.668759284528791, -1.8848733452381201, 1.0043812998317332, -0.1541654262471783, -1.78169342238631, 1.0018508082711977, 1.7869507800505617, -1.3770019015522459, 1.0073887648285051, 0.5494656828985904, -1.7155383104167825, -0.766729192491366, 1.097432656671504, 0.9053804876422538, -0.8472976468131626, 0.8709567207867727, -0.004694756779153412, -0.36024709172734976, 1.663056831034085},
    {0.4850056468479014, 0.8200019188011396, 1.738778539611538, 2.623699371410068, -2.2013947920946193, 1.4169744337202863, -1.1634834851039517, -1.3540554549199306, 0.7125669714943526, 0.6236609561788414, -1.2414964462457143, 0.8006551433805137, 2.470448082172891, 2.0678854195821916, 0.8802620052254077, 2.6456094555397716, 0.4974268189221265, -1.774420669903339, 0.14414021220124137, 2.517897662840249, 0.22805048500051497, 1.246967388815937, 1.3773217515091738, -1.3857090587451326, 0.2953811426934439, 1.9115574346458797, 1.9757215150800422, 0.16739744238779675, 2.000709739213364, -0.1305663041957552, 0.9449640103693058, 2.6715022100361026},
    {0.5217338572814472, 1.0984199813960043, 1.485956747801216, 1.4132447296733162, 0.2034084317911156, 2.003693230906296, -0.5769087416980246, 0.9330471135431339, -0.054522539245601465, 1.5069558150105247, -0.4183336151198686, 1.0833518108226274, 1.33805118217108, 3.142142320425027, 1.7150471615594751, 0.5466218633756394, 1.17843862552628, -0.1659408698570886, 0.2058202187995037, 2.8528483577524355, 0.6555449609703184, 3.5438686543050046, 1.7799873893348563, 0.32900574789601816, 0.7884761655044968, 1.8379341144927164, 1.8944766011534517, 0.25549111166654737, 2.1582240330693625, 0.2321183913649033, 1.7936737927909863, 2.0009073556781405},
    {0.2650381130043356, -0.25797918752221727, -0.011064534281710815, 1.787902288614039, -1.5784606245497825, 1.2682719467056411, 0.2682615823794861, 0.40485066105632206, -0.06357876107044265, 0.5753375781085386, 1.3536273966509698, 0.36111065114584323, 1.6696782357165647, 1.4696366791800128, 2.887146606739647, -0.3555850090898657, 1.3075900367460462, 1.8594286230733403, 0.2680366062535056, 1.822042635701152, 1.3931106160140978, 1.2304604934978667, 1.4885595309578035, 1.3850777084419081, -0.3349022256054128, 1.3574994761941626, 0.8275689575642313, 0.7483590378263206, 1.2055574526236519, -0.5861908470576117, 1.1050888203361637, 1.4218704446043333},
    {-0.8113780270871176, -0.7190518554383416, -0.30120092323013586, 0.8454571683769211, -2.6368131418225738, 1.3574875092794798, 0.00012818541958436438, -1.3271271080809648, -1.694332504750317, 0.08896379052703536, -0.29694370105034507, -0.27651339268052666, -0.5139022210769119, 1.0397386629631191, 1.560095493780614, -0.4721014088024486, 0.969704222640261, 0.006729039022800834, -0.7322359437834418, 1.0491391970175765, -0.3494054953007563, -0.08605017539390387, 0.899085192805214, -0.40795354005833817, -0.7219688503378342, 0.008453415427297347, 0.7613787468522137, -0.2698598085826207, 0.15393398985318846, -0.057630480555091415, 0.5948142582642285, 0.02738612031343462},
    {-1.0780526754043613, -0.01562616287898479, 0.5628832894134851, 0.9831724585290481, -0.189662300956859, -0.7555370644576279, 0.5615488905306257, -2.0981073952425846, -1.388021266713356, 0.20852748512273048, -0.039057260988267624, 0.9433493939645713, -0.46951245234913624, -0.31071086661253755, -0.0851009775295443, -1.69223054447899, -0.7340738449103443, 0.9517576738382709, -1.8562371009206737, 0.5305161450437572, -2.022877944920442, -0.2851571031168808, 0.21348488503614568, 0.06600336133414425, -0.3270901954344436, -2.1928382905005224, -0.8157614285159374, -0.1474405921880537, -0.11728921893290933, -0.15438676602630616, 0.12466827182973074, -0.5105925955074945},
    {0.6386974203813672, -0.0910581737087907, -0.3221859834034265, 0.4745090962074302, -1.5533975892203329, 0.017985592414590277, -0.4585184467598267, 0.4410140815570396, 0.6575174871749828, 1.1344839184840319, -1.9701792991046054, 0.3208562669411164, -0.826694777938097, 0.9068630592513359, 0.6831393735706918, 0.1281904480613333, 0.19627999874453192, -0.5708900701403533, 1.0360444387870489, 0.3034353928741582, 1.5053623806805851, 1.5229192726555674, -1.020149271733641, 0.7108994212269962, -0.593930794725689, -1.3229310016793758, 1.549216722966131, -1.6559804488909085, 0.7415841369818781, -0.7625398298482559, 1.9510972349817781, -0.34671205529938115},
    {-1.1844216891514432, 0.7069758656883274, -1.7812087531758227, -0.08298596255484127, 2.215988822800162, -0.03049230597654417, 0.9723985506790854, 0.6224090718592618, 1.6856568440780757, 0.9096487697831928, -0.7607890461128717, 1.5300767364502024, -0.6232895740870686, 1.1537729975300137, 1.6624644889441669, -1.8243765034620454, -0.6595363641701079, 0.771438054082256, -0.8696979452490119, 0.6019777159911947, 2.6909979548363205, 0.4314374270020282, -0.8688777208790098, 1.8923517441360762, 1.8788856651201489, -0.19642884198980026, -0.20709876319087644, -2.017677304873345, -0.3030536005199388, 0.037375697013831234, -0.08052083336239789, 0.1726520544564103},
    {0.6452585181975392, 0.4266052042764266, -0.31913578664324294, 0.7166031362667203, 1.1995248341077704, 0.4858246417953504, 0.981729985204517, -0.8062231131565819, 0.4167128255602058, -1.6344731147106528, -0.26542978937766615, 0.5794109214556606, 0.5881736424282846, 0.880954819117994, 1.3087666899344774, 0.0238584138525476, 0.11036380140334275, -0.1737101642503133, -0.5355496252407883, -0.014704941538118898, -0.11211330218963164, -0.21516579783803907, -0.4080261752275403, 0.5255977547470841, 1.502995787878659, -0.8634584279033991, -0.5514159771153796, 0.8730328956388963, -0.7968405239396459, 1.185264249289544, 0.21676433684176677, -0.060016919311854856},
    {1.3340217483906556, 1.2885254207030996, 0.6270015152962423, 0.502844214044533, 0.23742505425339103, 0.6543604015773395, -0.6121965048014906, 0.5586602800205506, 1.5908097860203574, -0.8864629083243057, -0.4588336376164042, 2.3796663150066935, -0.40730330426504757, 1.3467947817798485, 1.552291187207825, -1.0611327777446249, 0.8653111101956255, 0.743544834552785, -1.4301975581717117, 0.23619571747244916, 1.6958162717678034, 1.435732448265734, 0.371146173353428, 0.9806940718567435, 0.2940649425760303, 0.9155458309522124, 1.479438789683905, -0.9125802573099491, 0.19081260437858788, 1.3977290488394587, 1.3317419704377382, 0.013857664805080381},
    {-0.0011811628699618735, 0.4119446882847713, 0.5911764232364072, 0.2948018740296982, 1.7093244368700364, -2.231721678204259, -0.4807918162224651, 0.3797612915386724, 0.671334634727565, 1.3479110515216535, -0.7675347691769872, 0.9383185492444532, 0.277992839017373, 1.6942182458250004, 0.6302347136898112, 0.6587869188970823, 0.2763084624445138, -1.4297944400643656, -0.29640747908394377, 0.36404720736228413, 1.066300089220158, 1.0458883967964985, -0.9822530670647335, 0.9599890776728978, -1.7099880122007656, -0.36180387538061876, -0.1489289235505088, -0.4305709663152101, 0.3887429731638989, 1.3684286927833285, 0.2882908586202754, 0.5460554023854087},
    {0.816948183537151, 0.79919189421368, 0.4013668006908875, 0.6992516599270071, -0.7170152123089234, -0.6904676021651411, -0.830818013003266, -0.05456701835963155, -1.1436182840011482, 1.0491607299631314, -0.45686666350928473, -0.7596088075791166, 0.1123316647316889, -0.4084407153447823, -0.26151575713062997, 0.18029660936174247, 0.5849288783875961, -0.47722835519046675, -0.060252487182289066, 0.08880104585065408, -0.9828293516359042, 1.5069158790802804, 0.17679458391623834, -0.42801209544143376, -0.3401919285011828, 0.7295273716176772, 0.9476197622416906, 0.8434910469104056, 0.8342073262106767, 0.7787707284971952, 1.2529937523864685, 0.12904123189915287},
    {-0.7422659485257217, -0.18396713276892412, -0.22707205759298155, -0.6524974488585098, 0.04538664779538064, 0.15887682826237462, 0.25107464658805134, -1.0548980909290464, -0.7941914648818461, -0.5109243017635363, 0.4190502643010302, 0.004206926951999687, 0.2816364352153538, -0.25107219471351466, 0.10481382057735425, 0.9781793314014354, -0.5648091379130544, 0.5938053587217148, 1.5893668390258997, -0.7710991153011267, -1.4987667182473587, -1.1944981665582262, 1.0393017530759534, 0.24278152793962318, 0.0681471287497375, 0.7758146212395881, -0.7715456108135431, -0.9874740961958353, -0.19794465764103975, -0.49045732893985755, 1.2771815021287942, -0.8368832972218481},
    {0.22481158139279836, 0.39372807316482084, 1.3331941596298864, -0.250360838421354, 1.0647387990401094, 1.4895563218656487, 0.5017958963713062, -0.19081985883881994, -0.14631921158013741, 0.11468969274360787, 0.7377566218315295, 0.010825916757558167, 0.38179208521010516, 0.7103527168796834, 1.5180994958581402, -0.5200574973425799, 0.0420729788385581, 0.5522357506312641, 0.4792293723448674, 0.3800618130019039, 0.5779336033636311, 0.06847673675729495, 0.8484723137351664, 0.10050190805037773, 1.1019763301458414, 0.29056452057451837, 0.495256564409994, 0.47605424642351674, -0.07136259056246035, 0.3512694377094595, 1.391533070857071, -0.5585811560417224},
    {-0.14824421252445774, -0.1809738526342846, -0.1882116368336734, -1.2954955317390795, 1.4698323781745903, 1.9117949917416668, 0.6259686394570735, -0.3280457698530076, 1.1706218125680814, 0.31469248897948665, 0.5852292435461306, -0.18702828527160653, -0.23539481257812364, -1.0512468808263316, 0.2955078006417866, 0.47145732834651494, 0.2690855959542669, -0.26238179561912117, -0.786546930578378, -0.9000689437382656, 1.5393632743917194, -0.6097280911061523, -0.3516798521127129, -0.2612794839574566, 0.040152911501748705, -0.21202198220455873, -0.30607485591079836, 0.8857177646364283, -0.9473596297350723, 0.3420167385195968, -0.9014820212214405, -0.5819720210903382},
    {-0.19485405352824708, -0.2436803217934882, -0.214075091894877, -0.6156157394194951, -0.5007287421108668, -0.597637142614962, -0.24412722093398462, -0.48035981317331894, 0.6479683467413173, -0.37812415466137006, -0.2993853586592079, -0.5898517231081173, 0.11499184912162574, -0.4928219340705402, -2.0114938448135455, 0.13373460785574268, -0.17000947497410313, -1.04517881814062, -0.7739653919559776, -0.5980939600707086, 0.21480273320936952, -0.13419252834780615, -0.26036785716247524, -1.070956198714602, -1.1936046358402208, -1.0680057283591995, -0.6941153918152753, -0.5860712385471204, -0.5734959874744613, -0.2679235917292773, -1.385763267567886, 0.762446232212098},
    {1.3563228939607292, 0.28805702485068757, -0.0816395471071031, 0.6403576837246259, -1.262731924053867, -0.7895366913570715, 0.2820867681099959, 0.41765439365333773, 0.754656129598961, 0.5414489959955211, 0.2536756134150055, 1.4579675704893325, -0.5040382316444652, 0.10381618420498073, -0.2660056226010785, 1.1617263510346556, 0.4172009983674368, 0.03795191755235493, 0.5395073422331416, 0.545574645203563, 0.1661597317207676, 0.7311937545619756, -0.0389499058649645, 1.440887594648201, -0.4371271574779643, -0.4040174669005478, 0.04606617441369227, 0.2074102038789239, -0.34298004902827456, 0.2892148867030451, -0.9908425576154453, 0.7125826854573704},
    {-0.2548989564349973, 0.795721059181472, -0.24332696732363931, 0.06728580654934682, 0.239182286751813, -0.18578492246402417, 0.039915609288021334, 0.5218274462765182, 0.6166124463046391, 1.039556338144914, 0.4855743219645184, 1.511970284587727, 0.20955858642480804, 0.07439967782750198, 0.11262608034090626, 0.44944473586730593, 0.14802286665873776, 0.42942106472615177, 0.2865564098817515, 1.0524903067973617, 0.3635890906756775, 0.31870652656344234, -0.35439797703056103, 1.1762229076496131, 0.002965466164831642, 0.035340666702371085, 0.11606035510452252, -0.22342030163538293, -0.503286104092181, -0.3399436099578287, -1.3434379572918713, 0.2738840520262668},
    {-1.5886119395487945, -0.33948727405097406, -1.2439779595378946, -0.7759308594302496, 0.42551135493616843, -0.2611322796766654, -0.4825469273774242, -0.24373596753390558, 0.23525915737560385, -0.6572135828261194, -0.7280877401743221, -0.4316167142199791, -0.5468264617481183, -1.1745237336899794, -0.9344282530371888, -1.8853125777917956, -1.7412367343501147, -1.2321594513914278, -0.9964936871818384, -0.06483084760128768, 0.5055224619879017, -0.9343994952448373, -1.418902644947989, -0.8880244268238139, -1.1161026497430968, -0.4657612087708301, -1.0302342078213491, -1.191537699563603, -0.43197175419701767, -1.598697766432115, -1.5841645943633376, -0.7574929504632295},
    {-1.031908278186766, -0.04309890859132041, -0.9841367599369059, -0.15101868456217812, 0.276194901454146, -0.8663602757253691, 1.0282567996572223, 0.7728091556936156, 1.079470098948122, -1.1182754959421766, 0.04127365867070569, -0.6751348733272053, -0.38365817400170066, -0.2849243793371375, -0.3070830223333545, -1.3150350499286354, -0.7605648160594007, -0.08237037003827165, -0.6392375462926423, 0.42480421164841914, 0.6279703200322955, -0.6649677680872197, -0.08694445359624565, 0.21947682595867904, -0.2820360209153242, -0.4598002082313809, 0.021431321874625476, -0.29068579328653726, -0.0234675012725014, -0.8505056642680849, -0.4679050812693916, -0.8645036145769021},
    {-0.7846648816806314, -0.7146920950484398, 0.10919257696625596, -0.15622025565673828, 0.20326463512600051, -1.106548338185916, 0.41509213359812375, 1.4900606934155611, 1.0783800278268345, -0.42600465910043206, 0.35831747940687736, 0.1767786716281231, -0.7562857339869935, 0.5220041151310387, 0.7707285726145768, -0.5140465654261994, -0.4992723046081726, 0.854845986123794, -0.31952101347591527, 0.4031048622837554, 0.22525367368169466, -0.20487271136416169, 0.6696841672871285, 1.305891634269358, 1.2655139425072992, 0.5623289611284641, 0.2859181747952718, -0.18740407627405897, -0.39396466621920023, -0.3961105070702233, 0.7898716920358666, -0.19802553869121695},
    {-0.17159104851478935, -0.8683383391060561, 0.087042605884966, 0.050465613627730256, 0.8580918792276497, 0.11037699397538553, -0.09895423756149935, 0.7886883277465057, 0.9969115898205226, -0.19260134742978685, -0.28858473570713333, 1.67888580753477, -0.11619600800889951, 0.39731593394787884, 0.2019424787148038, -0.44102639716014574, -0.3838235003935183, 0.09754750870765196, -0.13562717046438316, 0.2324277195127245, -0.20064754951736327, -0.24677106890766815, 0.7062746576426582, 0.6356791291249132, 0.5172776205006542, 0.05713017114714681, -0.06456528531600422, -0.22006474105822457, -0.148992247544089, 0.20027274651679491, -0.2889283383969889, 0.6081687926661005},
    {0.3326935038643096, -0.41526360622830544, -0.6226561820697807, 0.19560731432779674, 0.36043464614037585, 0.5229176058976078, -0.20592729601475848, 0.267646084068478, 0.022427235647813865, -0.15038901562674054, -1.1451397162950319, 0.2761500016403172, -0.0022528188399679764, 0.591447086777955, -0.27909598613844977, 0.6054119548311475, 0.16819285289613034, 0.21344917599684332, 0.5915968584718294, -0.8085012176597858, -0.4568288808890975, 0.2599432609363992, 0.2277718619412001, -0.8435634237376821, 1.59950838549014, -0.21757712888768985, 0.060044046347933276, 0.0698417856093073, 0.004375183630296744, 0.21916901754297263, -0.6776390962835371, -0.8713815913906469},
    {0.00010457276467335544, -0.19232987630673065, -0.23908083064455826, 0.08860748635969393, -0.05392063847480677, -0.2976167136202299, -0.21967013542580677, -1.354837284840633, -0.40199752983358744, -0.4531735800255967, -0.4239422559056986, -0.4055251874635989, 0.6028080949592073, -0.2276086434574873, -0.7631376942673873, 0.4783691079118877, -0.6416281108931524, 0.5139072982087501, 1.1788678826780201, -0.5427544033158055, 0.18575341583386887, -0.38375749496964956, -0.006911746701122467, -1.0184432013849878, -0.00852816504215296, 0.10508027944792168, -0.20758898993920777, -0.11195396678691646, 0.06770562572873441, -0.0799088140368022, -0.4706930686284922, -1.1974645360350753},
    {0.2550292228508951, 0.078768482407042, -0.22640440781874177, 0.1884547875350229, 1.9151615404939257, 0.3770842753859347, 1.277495365938393, 0.6951283962713652, 0.672992729963595, 0.41282386295261725, 1.035706501712662, 1.2156821244415001, 0.4185856548955698, 0.16815168061280297, -0.9035641453133223, 0.7504327717325763, -0.6311926173166186, 0.402396984091552, 1.2653306504070494, -0.7904395621037147, 1.1359673441389742, -0.28268592569154144, 0.04508656601135376, 0.9032496597132254, -0.4887620309646153, -0.3844618935468496, -0.42125640104076606, -0.9943800832228037, -0.3404382193739052, 0.5171186707707862, -0.4121060843324262, 0.6667434525088091},
    {0.6194430121177135, 0.6005842498260717, 0.4092921714842232, 0.3593208480014603, -0.2585355995311791, -0.17308350337039366, -0.3795947768046214, -0.3952762148378769, -0.7601680461342567, -0.27090708882381903, 0.39820480612376236, -0.9786077997311191, 0.6807859720187647, -0.3946300695786618, -0.9331044603924035, -0.46134272404746307, 0.20655817279100863, -0.4382562476993123, -0.31963618157322216, -0.12745344137651615, -0.633202670573952, 0.550781823826916, 0.6488990590265071, 0.10836298473093889, -0.6873140200872341, 0.49350434000158416, 0.29070872555629135, 0.702242711957002, 0.4334966323287601, 0.4569202378568658, 0.8275989455710548, 0.817914068239723},
    {-0.12762730115189, -0.16765661848750874, 0.7898194945089421, 0.13919805441339103, -0.5347843309177517, 1.0413991475552502, -0.0436174060276386, -0.4322843546122552, -0.22794757600885981, 0.3316130455382301, 0.48704138428291377, -0.9988378536665268, 0.9433816989712798, 0.3467038814082998, 0.3828789720686998, -0.5356620204465928, 1.1498915585323592, -0.01149660818109102, 0.04967646291711234, 1.177803207680286, 0.014627041460333142, 0.3420021040402924, 0.7843761534179017, -0.7483443637570614, -0.3590663087578974, 0.794576183331822, 0.4099413621789458, 1.1646928747724201, 0.6286041423711688, -0.13974796595334568, 0.8467636632292578, 0.8250326056057997},
    {0.37155203192768926, 0.36098020713724105, 0.374604972051318, 0.3727080541292121, -0.507444596712823, -0.7010621745454583, 0.036008163261206476, 0.2926913424586743, -0.300059861479941, 0.09179531205330167, -0.10360544314897663, -0.2568114240144822, 0.5537037026897383, 0.4427511315246283, 0.822452947039391, 0.46351301209089435, 0.9376398851245467, -0.05608432949933154, 0.933674791646333, 0.9817024135029302, -1.0381938620133777, -0.3324865643110996, 0.20694274019577788, -0.8756505793385508, 0.6510096453261218, -0.7422136267477621, 0.23580289216940342, 0.27495088103828846, 0.04318456515356926, 0.864927605424521, 1.2146372906427538, 0.8117400712542533},
    {-0.07789160007008691, -0.2586295823386267, -1.1493873404133084, -0.1180040192767279, -0.239803727324084, -0.21870422872180212, -0.5531120938419992, 0.2358037975896733, 0.04931984574522885, -1.3814000972736609, -0.6873749551760694, 0.05723123972947546, -0.9957597178189165, -0.5961296917352017, 0.6547439949051166, 0.5093443676321118, -0.7630464085563745, -0.03853749484731651, -0.126976530856507, -1.030892219658174, -0.04009719044979339, -1.0519681333412987, -0.1833132356709972, -0.29546296721777193, 0.22577555383328116, -1.1955719710399533, -0.6613348768048601, -0.6484039928481558, -0.7046750532171133, -0.3024646478708303, 0.31247479685295604, 0.5878595237673315},
    {0.28021443515782724, -0.09836637647687745, 0.23401703942255425, 0.8395954797757574, 0.6083837689416309, -0.2045314824063691, 0.9914063559063606, 0.3250243217818739, 0.0959733104164575, -0.3923483073143665, 0.19123040027602142, 1.4304332112902203, 0.576356074102736, 0.06528738745157464, 1.0802201157429299, 1.0462998667227337, 0.236150645549463, 0.9095253211987093, -0.932047725977707, -0.9973251619993033, 0.4673228376400331, -0.5848394274045605, 0.9533644176838828, 1.269670110003606, 1.3058732603068337, 0.0722408440587661, 0.39310886675188683, 0.1594809160719169, -0.033202324098823816, 0.14749658600409976, 0.018310718275780354, 0.0016606097873387547},
    {-0.5073129264234804, 0.2183436298701122, -0.39247949149688904, 0.021099277487714053, 0.5203182754754437, 0.4889295825628415, 0.15578911268938808, -0.1862969461112911, 0.10483021351853546, -1.323861546080903, -0.5021060891170903, 1.260427874567785, -1.2483850049180136, -0.021100538368225615, -0.5572785059805144, -0.5606709404986193, -0.8778209270134766, 0.0026121485628832707, -0.7973289237509731, -0.7423940460470446, 0.520309338795578, 0.7381318586974895, -0.38593030082559243, -0.007921842362829598, -0.5993899942054659, -0.24307129602714178, -0.10386530968141153, -0.1308496150092013, -0.6189679894040259, -0.41800950943953474, -1.0935872075982156, 0.27199891135902743},
    {-0.6410065845303025, -0.7717032431956266, -0.7296597741863218, -0.46084108585624894, -0.5544636148349297, -1.2065588825268596, -0.29107358710957837, 0.1845916011475358, -0.15199113453245514, -0.17645908153697928, -1.0632788625240426, -0.9326443687027742, -0.4013985831551595, -0.005749346994661556, -0.612080543715125, -0.6624518178045775, -0.8401073091990889, -0.48341110070965426, 0.1868086127966929, -0.22846464048336557, -0.27433314849443247, 0.24747426372450892, -0.643264608905368, -1.1396940025313218, 0.3548651489076501, -0.6025571844865152, -0.4721179026858337, -0.3432737929220279, -0.44928373668935867, -0.7193752896393975, -0.6700297902448236, -0.48555703839344766},
    {-0.007461708727026729, -0.46639407178543013, 0.48636308545455453, 0.5762199284955963, -1.259092030125155, -1.4010404352987649, 0.0031970044286321257, 0.5270798858666105, 0.23699276300190988, -0.37676499804246505, 0.6720823215215715, -1.3382578572100887, 1.4064331812412358, 0.2960900042569961, -0.5937374042619142, -0.27640250208587347, 1.0393100848418857, -0.6083888848645717, -0.23408982045135976, 0.44083008086096553, -1.0278097093698533, -0.04559292073458683, -0.36232523934877175, -0.6005353161904926, 0.8713905469401028, -0.46914490774737344, 0.4325813906569124, 0.8833043850656348, -0.28502131549488785, 0.46520847955016525, 0.06976429283996352, 0.1897091540786699},
    {0.6901809451530951, -0.21760878706650286, 0.6599031294521536, -0.06395934293022999, 0.38607237563979047, 0.4694382503706738, -0.14098023462915263, 0.7443049926644817, 0.8148157789947845, -0.03949600201868172, -0.23856473809361156, -0.08091930384596528, -0.2799877068103206, 0.5275400714725983, -0.18754230848997244, 0.3960424637995126, -0.24101353643456636, -0.4778457251752723, -0.7462422879728793, 0.021062193853812725, -0.08235779677865054, 0.09016717030818092, 0.00521414820563006, 0.523087945862246, -0.26447559458034425, 0.09112696315278881, 0.6123192939731452, 0.5596866152831219, 0.004512088707746537, 0.9919234755263625, -0.7814311052810822, -0.13115583537310652},
    {0.9697744962241043, 0.403330814890914, -0.2819961788078495, 0.6204635588729259, -0.04165240564853464, -0.06960442272289796, -0.12295409989919602, 0.31361862675768293, -0.40102440717844146, 0.034905452762705784, -0.8155109326573547, -0.04233043437791453, -0.007117798919497532, 0.4453241860235468, -1.0459498436709915, 0.5944240616986158, 0.04696872836171431, -0.5002150983104268, 0.014822760167567164, -0.30185422038642995, 0.5685914305152262, 0.6262183806998359, -0.2213470121979728, -0.8457689605125741, -1.4723093214622816, 0.09643261079570269, -0.35589550856032737, -1.000967186152761, 0.345985731619921, -0.2376741524930147, -0.8007176255246651, 0.4769727081952256},
    {0.7694276195896272, -0.6789628144962603, -0.3086308688201272, 0.5840200913543409, -0.7965543401693354, -0.013952019103664972, 0.4632444196896795, -0.475542085537735, -0.09723751328257528, 0.4318488664198156, 0.2643616467353517, -0.25886434711010453, -0.19428968436846483, -0.3298733242480693, 0.04034566541766467, 0.022301913901550143, 0.01432715019797625, 0.44453509621403825, -1.2018986536311846, -0.26751366379509633, 0.011380645316089476, -0.09037602985646027, -0.16148339254133326, -0.030715713931158295, 0.1470137728207134, -0.7861525713800849, -0.10757404481195142, -0.378104758898156, -0.25204436834102556, -0.32627239370944866, -0.40188178791470125, -0.5585486100170308},
    {-0.23059959223288307, -0.7926016055345849, 0.24930351331335462, -0.06406471923401337, -0.3343009738851577, -0.8112373167597466, -0.007177916121222111, 0.7537970181628441, 0.5931631125948068, 0.07284697107480374, -0.33307274505653856, 0.5269496024917103, 0.0693884831962041, 0.00037837879650165073, 0.8437202866018542, -0.23865781501665803, 0.24152167755137463, 0.952584702524437, 0.0812878677572399, 0.05898827751309395, 0.39322975302956303, 0.28298517588104743, 0.07864819638301723, 1.5163751504186718, 1.014263441816091, -0.6946759347007888, 0.43358384768541147, -0.45301997184682863, -0.2761824646560434, -0.19913966006317163, 0.6583539191263328, -0.16922873844156452},
    {-1.1611401485693378, -0.9472080621371802, -0.6762589909430697, -0.6345581974042304, -0.6237598993652681, 0.29927543832115244, -0.45046681206512124, -1.0765131715561698, 0.23426655667267493, -1.0463880559063636, -0.6964916345073086, 0.19395831339089056, -0.7741223293175495, -1.3312608712356697, -0.5821601850330187, -1.3003758856397567, -0.5058674219014552, -0.8042376045772124, -2.412685433646013, -0.8933532615088345, 1.9685534228625154, -0.6484304715746725, -0.9292355507180844, -0.953944295737799, -1.5230187050768675, -1.2519553851962733, -0.17303850151236824, 0.06632223259924577, -0.8847244061983099, -1.0967731780238659, -0.388173815621262, -0.3886522557680647},
    {0.7116195991299716, 0.41562539135590426, 0.4798721722005505, 1.1487402991934639, 0.6626201783175247, 1.0702157260304557, 0.3747211355860276, -0.7656046518132685, -0.21992319727384324, 0.07473520433501592, -0.10206834907741985, -0.4572628488065938, 0.1575465641819724, 0.05816098090813629, 0.17859366615069014, 1.6417429399361292, 0.40407540715038637, 0.3085979694911278, 0.17275264215406275, -0.1874954547751927, -0.6142230503212576, -0.5822146464487541, 0.4043048218436492, 0.4560186318747551, 0.596381876439218, 1.2664821109180697, 0.8957106459898245, 0.4400876853176079, -0.06194700184884802, 1.015646585308686, 0.1198952982660787, -0.9432921414100519},
    {-0.6160321380312767, -1.0218958679587276, -1.2212020528767222, 0.23019700713751554, -0.037995113425095754, -0.9414886421628833, -1.0745296084543863, -0.7011756367118651, 0.13434298641583095, -1.5196246478108044, -0.8264739268543603, -0.5026382906938099, -0.5922262706865141, -0.8044055282180581, 0.3237092936192996, 0.033899438002073685, -0.7027062471376719, -0.15559516296029938, 0.2225803316364997, -0.054816158790381916, -1.3558022765345157, -0.5729907934635418, -0.9580377777730583, 0.8359283018669275, 0.03587141778590126, -0.38783138655726856, -0.9085843492774694, -1.0581429751067184, -0.3990179782306772, 0.07760835632227377, -1.6724651746252208, 0.42989049639769633},
    {-0.46186695777413544, 1.0955548513852682, -0.5965574579755013, -0.0004054710733935827, 0.8052543504002784, -0.03764710335056005, 0.19434141073288289, -0.06548506850579815, 0.4906686178258419, 0.4365988946493964, 0.09776772984572271, 1.5175154336408143, -0.896647863663724, -0.059109019152493655, 0.8073073990572337, -0.6264919972761345, -0.40156427914477055, 0.5511294370632365, -0.9233641556820794, -0.4176956410784558, -0.07244792960542422, -0.2618125106238145, 0.5941582278187734, 1.0096875001846757, -0.4246876604950898, -0.28185382351684457, -0.4055102970253959, -1.195739260180062, -0.47562121151100945, -0.5031217818507578, -0.4430723392207966, 1.169347324264525},
    {-4.87078786590094, -4.997084609024227, -5.817421122147756, -5.240748415770054, 2.8674247197122074, 2.06919811171272, 2.0950871969723597, 1.8439323368900251, 3.328747927680987, -4.213843119027274, 1.9040952683965726, 3.349200993281609, -4.942120082088483, -3.540901667211591, 2.7386375368221456, -6.277787306513378, -5.2279370607998885, 2.6053473894716426, -5.961142380284816, -4.511537578983126, 2.8803751992785895, -2.2410157005092155, -6.285930444137324, 2.662832885219595, 2.421549605532177, -5.774599570585277, -5.006124511809847, -4.9480805805174, -4.856145331409314, -5.246428701792981, -5.152844906607371, -5.445538510970729},
    {-5.207235916224722, -4.712003765634632, -5.43489825547858, -4.760016853329019, 1.802640348127868, -0.17297203260069355, 0.10930545918031151, -1.1132258861785411, 3.8797634547007602, -4.771429735908599, -1.2899307793896302, 2.7165060149060154, -5.552555922181093, -3.7865015745099324, 2.288527315657019, -6.938960320513743, -5.387308747438554, 0.8862111271792361, -6.346728378714761, -4.438792014894971, 2.6969941155696193, -2.2043573010374313, -6.129507705607657, 1.986511245086895, 0.9121113323578087, -6.026389084092287, -5.081110566468823, -5.088623067170136, -4.711422759531281, -5.232251873327997, -5.520414030640227, -5.940407851530628},
    {-2.7765202430285516, -3.1461805113860795, -2.770880905402889, -1.785977824797219, 2.350106911275352, 2.972212518669434, 1.4062413478201066, 2.8740679199215693, 3.162886635944415, -0.2861666641009954, 1.4811527869002918, 2.744272481000902, -1.9870700910189198, -0.9076227479421649, 3.252382487454632, -4.105517229395663, -3.2859695454829643, 2.021621678601105, -3.953852575539789, -1.535745756979004, 3.0507425830150092, -0.8477338233180028, -3.947533001930293, 2.455418930543409, 2.0084870212422232, -2.8972496386919118, -2.6510324335284867, -3.1651944906986587, -0.3708002866735752, -3.7002597976257507, -2.846821955998178, -0.5307054956799561},
    {-2.45477259020457, -2.587961490677341, -2.524101291974918, -0.7606414309523033, 2.3966122439686908, 1.8397766817811254, 0.7943424086524744, 1.429619633559113, 3.3715152695559496, -0.5307006139811381, 0.18260535715278695, 2.3837095965734405, -0.7880097859138946, 0.1362586154033541, 2.793985721730645, -1.8864163410336199, -1.723256373983538, 1.5697627886941532, -2.8200412551249845, -0.3613573227006073, 4.172525476561748, -0.34206631063693543, -2.387095338698178, 3.1950950932371596, 0.810241925617657, -1.6717430761540544, -2.067667905694709, -2.254665844304751, -0.2099139557479931, -2.2433904763400245, -1.9315128980196736, 0.8497783467675527},
    {-2.340540301505868, -2.669124505216177, -1.8556150660801367, -1.7089817993162335, 2.79631897520453, 2.3004449328787406, 2.070896242118642, 0.9647623812510542, 2.8892676446770444, 0.9529819264160108, 1.1985466627647807, 1.9819682883365497, -0.004443172347426999, 0.3541742770404507, 2.8660574595304813, -1.6899676436369744, -2.46574869477816, 2.742120613776625, -2.1820673051424677, -0.7404897226392757, 3.0194216142854504, -0.42624922331297815, -2.5262174143846954, 2.228086065253748, 2.136620383317023, -2.615716584604007, -1.7917803432896382, -1.2724278234012683, -1.3552935465708076, -1.699688939729609, -1.342163733852543, -0.8968773792571304},
    {-1.3015549850183, -2.026850976986516, -1.5393544360902938, -1.038037230757217, 2.2090725297701828, 0.6932468272204051, 1.6081133621404933, 2.371843041182185, 3.207851715815504, -0.2147744555731292, 0.6022647938971221, 2.69638815758973, -1.9401843343549943, 0.9202383174373965, 2.13806979950711, -3.315579951027933, -1.265687647667551, 2.4021337074621316, -2.9134630867855367, -0.038997314750145465, 3.630480404947995, 1.379706338837654, -2.800382324891563, 2.626069175144051, 2.411793021219178, -1.472091202515523, -0.4740725896824171, -1.2902378720647036, 0.02868565847987682, -2.3012382113375374, -2.1475610926898905, -0.469806888811142},
    {-1.1733899335281928, -0.09437126434459181, -0.6192392247228743, -0.48157502134850727, 2.3566526057663046, 2.0630590762416876, 1.989175996699693, 1.4575566307844443, 1.8735030353586395, 1.385097140567763, 1.0995830035701264, 2.7824766521222966, -1.4960796729891108, 0.01861155886913904, 2.06463491371114, -2.267542324537004, -1.828917721400875, 1.8344773430755767, -1.9113282028091905, -0.2059398324728919, 2.2840129262432094, 0.6135770715407884, -1.0226993562595952, 2.7252791082115864, 0.9022626090739008, -1.5050365388367881, -0.5048088437989127, -1.4998898771271771, 0.4383761483304805, -0.4534418793276648, -1.1475741144565372, 1.239845956002054},
    {-2.204586047294984, -0.8860573883368753, -1.440083523400499, -1.1147810205933186, 1.143017741892309, 1.9432399993677558, 0.27580221581075676, 0.6333738209469058, 2.2354173670895157, 0.8965168735738435, 0.5119189598152, 2.4882153505773377, -1.9496084529156545, -1.301720849170142, 1.8843264113558458, -1.529624515796894, -0.8927524124922502, 1.9473865791099119, -2.80984033231069, 0.194124162747651, 3.0898521812734545, -0.7391132249217149, -2.322081666188123, 2.676245597847245, -1.4903244849815398, -1.5449881307885707, -1.090338624478814, -1.96573784693867, 0.002063184867729673, -0.1158487572780923, -0.723987847206304, -0.8282003205291584},
    {-0.7602504366594086, -0.8827606287171402, -1.8068788367461157, -0.394195259464006, 1.4032240552685697, 1.1726076197866346, 1.73750808086592, 1.443607297670041, 3.753665090017359, -0.48187153020625545, -0.146051543879407, 2.4879817639304633, -2.3735358407865434, -0.2823002994898976, 2.6217877487983716, -2.711973903638071, -1.390948440172073, 1.3151858316546634, -3.601035217830661, 0.039400423196660296, 2.399944759534962, 0.9131756804741754, -2.4492810550399264, 3.230660207986303, 1.220915731811855, -1.7246077546531107, -0.06625919612015542, -0.8421150312473981, -0.16918819086139456, -1.463314817183156, -0.8751071957158485, -2.8720317565836666},
    {-0.4799400079502536, -0.37386769250214336, -0.11619263740253774, 0.4633073742809168, 0.686085679271291, 0.17080086906738678, -1.1160927908877398, 1.0108670486559006, 1.667742372070779, -0.6699750470396287, -0.11083836756247444, 0.5274209240750667, -0.4834211585446268, 1.714007093340728, 1.401830145754651, -2.115854151186733, -0.7814631253218266, 0.38698927486781526, -0.5527030270534196, 1.2589849870046834, 1.608308925055144, 0.6240793630947284, -1.206988978120882, 0.61684507385393, 1.6541837970746003, -1.027128883289242, 0.09110695120522952, -1.1689797125831858, -0.13220366280598916, -0.5451565380121398, -0.9406717989713239, 0.8195522032393969},
    {-0.5367962346772154, -1.0222097197513678, -1.6832576075930636, -0.005270114486091463, -1.7643573727051352, 1.0522323378089569, 0.04162709057720128, -1.1399159262174932, 0.6278641422772848, -0.839787701176564, -1.9205572254030145, -0.2819422190056466, -0.13649041798631115, -0.29493194366669256, 0.09140559515524321, -0.1876960499139223, 0.33868989094184265, 0.13595275497507664, -2.2255280174520737, 0.12300550538036088, 0.24869572204200477, 0.3731010255677763, -1.0151736556375979, -0.22939725287039572, 0.7640011715518491, -1.7400657690922703, -1.789521825807494, -1.1491294065218918, -0.08641337259244229, -1.7831532414602302, -1.8621339174827145, 0.4007685940582464},
    {-1.056425099226569, -0.7157337011170107, -0.7167653145535694, 0.024885051875211468, 1.4962999800776045, -0.46812299729704115, -0.08825273485416114, 0.3930335771174139, 0.06751138148869143, -1.3975560906514972, -1.4956699479760716, 2.708034141397862, -1.6843102265246355, 0.4595912160698582, -0.2798735279045066, -0.3240234169144354, -0.8399565774345082, 0.914911692950284, 0.2114806487642325, -0.7785073574032982, 0.6388150609367252, 0.5816239281277928, -0.4419826219097835, 0.6496076470007316, 0.03367975461320321, -0.799297313407116, -0.47870889422112256, -0.5004574676724325, 0.5874217229817651, -0.15361887629484952, -0.7060171292488818, 0.9842090088179374},
    {-1.4181792538274867, 0.5863582107120887, -0.4693990077428296, 0.6483718452767543, -0.0740563111646853, 0.5645955634397033, 1.4854432991490822, -0.6879958825417525, 2.0776061352532396, 1.0228511268301295, -0.36226159816723486, 1.1305163800950886, -0.6142274337589417, 0.6892147306693842, 2.4576701776922887, -1.1903099856219463, 0.33619209640025344, -0.46822540655640815, -2.073102779344607, 1.28518433339153, 2.8292343703717435, 0.012332021930881539, -1.3202219108781152, 2.1552664023999255, 0.04813469190521363, 0.8122997909173572, 1.0932298767514648, -0.7295230053728647, 0.6219553135746025, 0.3822078910238579, 0.2132861528422222, 0.7338091468418576},
    {-1.787324457925121, -0.8896872939439987, -1.5341998478805228, -0.5393420370221345, 1.6404392884349934, -1.5993135729183723, 0.4164109748074035, -2.0446562114175255, 1.4541944575175365, -1.2106081407871427, -0.5099675603331261, 0.7770370362913441, -0.3248455817735849, -2.147468633112073, -1.3153241831193885, -0.9032448501899227, -2.339078332297602, 0.1244414036127178, -1.5791506126538017, -1.6779448939127204, 1.5871999846838467, -2.1552237595367774, -0.428292333261364, 0.8722675493406379, -1.346445485556731, -1.0983302690691885, -1.9585402394103109, -1.7249923006388868, -1.6444288207990274, -1.0927729997515203, -2.472097848018871, -0.5448916058311827},
    {-0.11767624365159453, -0.09177440695280899, -0.2848446801918209, -0.1268358310468871, 0.27878873589240843, 0.5818712430793422, -1.290331019804271, -0.4633124197677225, -0.22427719304653915, 0.24187736062099177, -0.19953476817262145, 0.24193275740513356, 0.15643194450492176, -0.4007580392545192, -0.6110884227378088, -1.0153354577585432, 1.3136558156834262, 0.7278871798619013, -0.31408260119677756, -0.6081893121576176, 1.8550771298437105, 0.6138039851773186, -0.4070816472837307, 0.06283271761128777, -2.7093534016184537, 1.2224589833094974, 0.6943646945357648, 0.47187597183647495, -0.16130369957291968, -1.0193709967527587, 1.6880261893007882, 0.9855902617805066},
    {-0.12123754345751885, 1.0648277728805209, 0.12139543215188793, 0.6585965740147481, 1.2286916992441934, 1.5023613058703646, -0.9449223199196468, -0.5730950275602306, 1.3440255998162611, 0.8669837747447795, 0.20693873864067588, 3.166146786714365, -1.5034185047994566, 0.6065047193766128, 1.2762948906115004, -2.739724789393687, -0.4547205781447048, 0.4823387026426944, -1.287468355304362, 1.0237192043434105, 2.614461927679451, 0.20408672650582588, -1.2160452589822168, 2.141635922686841, -0.459852989363871, -1.4404999284310673, 0.42848833513885476, 0.17303100538709953, -0.48650160098044853, 0.16651755957218106, 0.24263788433318817, -1.0273850157976474},
    {-1.0343593619640676, -2.2069961117750156, -1.092544908430462, -1.126013030267685, -2.144039842038291, -0.748703611309494, -1.2602189368119403, -1.7155166033838072, 0.6375368644685665, 0.7318366672815901, -1.6259168653516098, -1.245006228187166, -0.2784959891356173, -0.856860255818615, 0.8857041862407392, -1.8760061883617474, -0.8345027926092398, -1.779045471806975, -1.7924994897492053, -0.30120827385873966, 1.4309794304386676, -0.19242378444679892, -1.155913354722808, -0.10928163523681828, -0.47825639783664664, -0.8127165419333541, -1.6280271394562678, -1.0158943384888914, -0.8015002428981012, -2.1007863321878064, -1.0104233223833603, -0.9413843860861264},
    {-0.6380639080142074, -0.6645581507673484, -0.4871191518202224, -1.465861821262166, -0.28349209521373525, 0.20496107691698326, -2.097593647877282, -0.9490852610552029, -0.46388851142993054, -0.8813679019629876, -2.057077493384153, -0.8330366089774949, 0.15780958615426532, -0.12935428006036903, -0.5492490456292641, -0.5315524192802032, 0.18787065793077384, -0.8686551823212849, -0.9775492524693684, 0.5205733236547369, 0.6995816475843499, 0.32707540225226817, -1.0748328726014962, -2.1547972667401942, -1.5712775395619956, 0.030043184951367638, -0.8760139062544758, -0.6437743456154755, 0.1192304155151447, -1.3505886416638784, -0.7882192296016101, 1.693149024388909},
    {0.1306623084969215, -1.3104640301585224, -0.3260618215053044, 0.6970338805934886, -0.8513881086921619, 0.6842309552525631, -1.6835581072779002, 0.8355859788436067, 0.9129529378700475, 0.8086512160601399, -0.7970711943512317, -0.19355565301457062, 0.1401635665226579, 0.6009884932985058, 0.0841015115731707, 0.035591378622513006, 0.27916481402609367, -0.6450999841999969, -0.9829420464714437, 1.1263558433869474, 1.9532085674206447, 1.4407806323660863, -0.6303072924188392, 0.5080647264327104, -1.1701430156569552, 0.019685379939035387, -0.7557022687776389, -1.1436404739632169, 0.06706525971995668, -1.2460287149011482, -0.9738458015907565, 0.6920068923281535},
    {-0.6825672792375617, -1.4139272025718184, 0.2847378253861693, 0.5719343681571221, -2.2514756816505703, 1.0440523982047762, -2.166875078012045, -0.4772064443888317, 1.619143983303176, -1.9416590884664395, -2.1686609090392386, -0.3551293164467091, 1.130083827596834, 0.2101568858483637, -1.4592357716493145, 0.14403488368013767, -0.6107270742391839, -1.7118677162763174, -0.15561686671789252, 0.9082852087765825, 0.5979678781058884, 0.611626409750279, -0.6689025037901835, -1.8706995848320298, -0.4320995096153955, -0.18013854007773014, -0.50643534336253, -1.7795679273217033, -0.39537098087935996, -0.535856176159491, -0.4615962414102225, 0.9750664548717077},
    {-0.6051024852986694, -0.9474805389521531, 0.20099758199983975, 1.2905051597603399, -2.040963343072823, 1.2895408023159305, -1.2174134877118077, -1.1561353171079576, 0.7310048516352374, -0.6722512990181448, -1.9332876892745592, 0.43239789848968474, 1.3535189158820755, 0.7287241695097604, 0.98097750086441, 2.192366606859078, -0.3415538855187265, -1.911464824503765, -1.033084458546221, 1.4814861583202217, 1.26515409459335, 0.5771937053064359, 0.09203256019465882, -1.2005007397624714, 1.0603170361165193, 0.6466836996575382, 0.8629273976684108, -0.8344650713400982, 0.2073345502111428, -1.2008863884778402, -0.11866467424729009, 1.7530196451872981},
    {0.45734616200573325, -0.1781564730158214, 0.3384677350677044, -0.29954635858812445, 0.39924559008241395, 1.1781749184386228, -1.3483178873836343, 0.5454807523225012, 0.7771533318737456, -0.1486962339348724, -0.41964614492033603, 0.9166950174582656, 0.16444879073363164, 2.0607142768289624, 2.101641464189734, -0.07665179927723352, 0.30884209170155735, -0.19282334963910164, -0.8121474162325277, 1.8923355983571688, 1.7726195453983922, 2.6951228926619404, 0.4599481592452008, 0.6301723466416739, 0.8519938446815264, 1.0920068370386908, 0.6198213100771605, -0.810780901021587, 0.8703658714723205, -0.5291810275009474, 1.3359391208041562, 1.6120736303767582},
    {-0.4600759641063657, -0.9702902469099318, -0.831985604664403, 0.6149996292019446, -2.063197014653331, -0.16291367187197958, -0.28984644066631443, -0.9960648949475993, 0.46052425145950493, -0.9092727480292744, 0.9113688875974845, 0.657668282442985, 0.46660931895250035, 0.0038988442996381813, 1.9581311131017565, -0.24647800135919645, 0.269107512071011, 0.5064508095239866, 0.2693035231264251, 0.7878835882394574, 1.3482056951480674, 0.30756739839591646, 0.785959317932479, 0.44861826384819403, -1.5783539348108664, 0.672162786164119, -0.5326926368772609, -0.22797084027722206, 0.5668656474221285, -0.9558028199069408, 1.055297846169523, 1.6830072536713703},
    {-0.9492803380798455, -0.9148795094627213, -0.44076525571403075, 0.6124060158860379, -3.342720471531412, 1.498571653783813, -0.12701068744238084, -1.647440955349278, -0.811501925735466, -0.7031857777078315, -0.5458899646973764, -0.32088563015177873, -1.1041771410585797, 0.5369798738218171, 0.6730684633530888, 0.20511535451392954, -0.05354970653525574, -0.24257683833688534, -0.4202900932948436, -0.05150975851837042, -0.171133327408572, -1.531765047870603, 0.6471612442958427, -0.8293484017353072, -0.5078056642075869, -0.4491632930961712, 0.2548253768367596, -0.6797586889513453, 0.02435536625913785, -0.21852634178672092, -0.12141251817171707, -0.690781561760333},
    {-2.088576694638472, -0.9072329792792481, -0.16069145322050343, 0.4193446122122191, -0.012860609760682854, 0.3477789555416336, 0.2726631001356426, -2.1309548010907524, -0.31413824787567657, -0.8600389180581677, 0.010014494605967442, 1.1366638856821003, -1.324649346946638, -0.9760596139945351, -0.0625923924133362, -2.067194755237988, -1.5567007989879371, 0.9481273697435032, -1.9291878691596984, 0.06835864006963521, -0.752968510926505, -0.9007191270367353, -0.690979416439712, 0.09181627097385545, -0.13816453297518494, -2.5475862331488455, -1.6424429645487013, -1.1064366806336507, -0.9813887526759631, -0.11820461326020053, 0.06248704743644116, -0.6579987303497339},
    {0.7316896802189758, -0.47963456731872106, -0.9742744433171784, 0.43109347428755684, -0.8655533610479439, 0.09743566469959695, -0.29710049541078987, -0.1548977401465836, 0.4697110623263031, 0.17674524383773607, -1.3521215410633949, 0.6987073763167435, -1.1386498969715608, 0.22253575158993555, 1.0659182012804889, -0.5908542676095038, -0.2511797869735389, -0.4992466066894504, 0.7210726512766289, 0.4133569623738757, 1.9570308681727913, 1.0098221695476466, -1.555912875784115, 0.5460464976027228, -0.2473539092250426, -1.2725860416162402, 0.7857578125074923, -1.7153632490550066, -0.0036212484662186814, -1.07531558207462, 0.6255210837963533, 0.008357586226849227},
    {-2.050218218062706, -0.2997989211147921, -2.5934796065481023, -1.0993446156940858, 2.1530488258626193, -0.4659592035385166, 0.01155919293407596, 0.35422411386069014, 1.6848458683780838, -0.3540391160276295, -1.337648978487402, 0.7921835377981026, -1.202775740776457, 0.2832809306933646, 0.8172288215286582, -2.7912682291162922, -1.6577835692665033, 0.1132157488633471, -1.798323366726833, -1.077734902755202, 2.721169374618071, 0.35638679759506864, -2.165835364820276, 0.7538069486441241, 1.0301962011388166, -0.9272170057608564, -0.9995511513174588, -2.046437254913689, -0.9145300883424309, -1.347995971569074, -0.9474147247740645, -0.30097590129867724},
    {0.4131887132569457, -0.2879653914410463, -0.07004459113053464, 0.44493380578742253, -0.30424820583604056, 0.735050133384062, -0.649470256529289, -1.3891074351773012, 0.7114593320653221, -1.9464139474712248, -1.892272844136782, 0.05422650552882486, 0.5305734812547361, 1.2433486162499816, 0.5096964271403133, 0.5732429544801516, -0.6638443477295205, -2.2214824123671715, -0.40498719346682344, -0.03603852347559177, 0.30635955114003516, -0.10430071705106919, -0.37460215459588847, -0.9276898576368486, 0.043766969958580204, -1.3869503074075842, -1.1664218600913072, -0.07948785168483115, -1.5929878939125623, 1.0576634942821006, 0.4898369925400825, 0.7632492430423964},
    {1.3849209689859068, 1.311411555003763, 0.8746248771427001, 0.16471920201532156, -1.0696819217505407, 0.4502053402271927, -0.6459616885580023, 0.38506348392992307, 0.6422770781972508, -0.875713030274114, -0.19771709117752165, 0.803561899943578, 0.8049568221644546, 1.5080686031372208, 1.3882585144996389, -1.0449550220139376, 1.2934958413474704, 0.8303703782793761, -1.4320316050139479, 0.30480787087371053, 1.5492811540650202, 1.127095803735673, 0.7928344359057404, 0.6633135008329477, 0.6354780069851966, 1.897376458959588, 0.37570902248986765, 0.04479085787801117, 0.8772884492954502, 1.2653006803685984, 1.127338342329242, 1.0802998763429474},
    {-0.34682930819182384, 0.4201116164761026, 0.3948704641510173, 0.3042695573579413, 1.1071261756595, -2.424107810351977, -1.0386672519016937, -0.031770856769142784, -0.3244730175105686, 0.4134132362247444, -0.8999716742101885, 0.187900440370609, 0.5634557690560679, 1.0187083837378452, 0.5263149058577145, 0.0608386335788975, -0.20533529555943555, -2.00958790948838, -0.46918358301123597, 0.36407273193799594, 0.8136330356505866, 0.46613531746762765, -1.0420746124593534, -0.2167632959583604, -2.2670622153829285, -0.6313062334107625, -0.3061170654446853, -0.5998593775405958, -0.44239288395873355, 0.6779891412696293, 0.17266865376242857, -0.0505030808931605}
};

static const float b1[32] = {8.46074834121065, 8.268701565891847, 8.286514855826, 8.44866979883174, 8.555797438469883, 8.42949056170994, 8.491058984514249, 8.24482794562559, 8.148151547606554, 8.38701584384798, 8.181766134632554, 8.542628549568397, 8.160159640217794, 8.424322758024894, 8.564309175523226, 8.45261111592792, 8.32705523606972, 8.137841611256844, 8.360406219314306, 8.376740315678013, 8.217682894924074, 8.44112986436684, 8.336762472395526, 8.406190028632615, 8.419605854891087, 8.352119224037015, 8.300210445440614, 8.245205508543876, 8.429570008700427, 8.438103785443264, 8.496548281551924, 8.073948983480363};

static const float w2[32][16] = {
    {7.952140518421129, 6.636788655596368, 6.934753700025094, 7.593019170628548, 7.322132670652891, 7.0278006837424725, 7.6024621144260305, 7.855781264366476, 7.356711503358661, 7.0522036722598775, 7.197717823824632, 7.452457237899861, 7.401291420308142, 6.913090404570971, 7.205762374663742, 6.430346525417696},
    {7.425877833098833, 7.054341574064318, 7.807535033827917, 7.414384063663713, 7.3502558926319965, 7.752029189712638, 7.644494669958063, 7.500696316285241, 7.559750202527318, 7.5687918108117085, 7.101150861864156, 7.839581702589295, 7.675667153449171, 7.213875453127755, 7.392870531658006, 6.63664561144184},
    {7.4206462773160995, 7.284664875825025, 7.022373075188788, 7.096392828616525, 7.700106417347869, 7.497917665666601, 7.829987238153699, 7.390046769203376, 7.042861847291731, 7.401438626998586, 7.24888678287364, 6.905170490429668, 7.323849864718745, 7.045492595549953, 7.37242621040885, 6.872262599268562},
    {7.413760122783146, 7.220481337852988, 7.534272088750764, 7.74765520921753, 7.292400641928633, 7.633713462132715, 7.778428678262435, 7.012966005817267, 7.665951941131734, 7.041331175020652, 7.353106415116577, 7.451345646311381, 7.321581762173805, 6.83786024468054, 7.498071062352088, 6.862266315710214},
    {7.784463200625627, 7.500761351597729, 7.762019183289089, 7.338537220925046, 7.382823551705827, 7.949269071176913, 7.753883264000864, 7.450478907770492, 7.144511738959243, 7.515979927860517, 7.503840471909272, 7.43722469342025, 7.6387608369363145, 6.5803912043990165, 7.9184635745646235, 6.460648804527687},
    {7.863584321600629, 7.247426502091427, 7.356070848990151, 7.790374235975034, 7.791642720756538, 7.945687032520449, 7.534016564508733, 7.518282522406085, 7.374166330962849, 8.120498601510432, 7.796183056907956, 7.657101285447815, 7.57274266478167, 6.859387461368983, 7.400490777931704, 6.942838252213142},
    {7.776286762055984, 7.28765160493661, 7.509009037239736, 7.975799052449198, 7.340600608938386, 7.732148831443843, 7.6949577380972585, 7.620171774403144, 7.635634440650908, 7.350512855597351, 7.5208311590374315, 8.108699400030455, 7.02033620480742, 7.654093411738379, 7.93168884412596, 6.5851470137626995},
    {7.334921816933138, 7.088162421631319, 7.389907771228118, 7.735077224993469, 6.964397580558946, 7.423111393009656, 7.630893366070764, 7.3721966252197255, 7.412263868095408, 7.160116503590683, 7.468398052295823, 7.308162673588681, 7.674557822582408, 7.45414345596005, 7.636288541344258, 7.097375062167336},
    {7.362728748230413, 7.374536035618815, 7.645244311800968, 7.085384905692071, 7.827856893141608, 7.377173574544519, 7.574187645276803, 7.777607899985164, 7.684659826556278, 7.0816961032755374, 7.153417742507624, 7.405175916943028, 7.4288594804413, 6.912626543917411, 7.248406936291135, 6.994713100952169},
    {7.392323477056053, 7.428561326922445, 7.362783018825187, 7.962627171700296, 7.690958822755952, 8.024336111721162, 8.023041551403333, 7.308597359431529, 7.556622005210462, 7.621029128807175, 7.510565972917158, 7.477469599370797, 7.929785880176148, 7.293131560039535, 7.8334532251006195, 7.098567993167733},
    {7.670643869987035, 6.9867975668800035, 6.990876309546917, 7.283464967274497, 7.465561729421775, 7.49127614103992, 7.491678034046274, 7.1445303451025275, 7.244302585159099, 7.1956523683977105, 7.2804618019741385, 7.156447965030291, 7.437952804112291, 6.184413991602927, 7.213371263548845, 6.542610993785585},
    {7.279343928639162, 7.302365390990851, 7.620314935537283, 7.966271996181029, 7.814230305588978, 7.734313531069555, 7.7552358903211935, 7.5167920056565105, 7.251562305098483, 7.59783538928167, 7.196412679724028, 7.349995464000676, 7.681353697479648, 7.460273385773141, 7.901343004315884, 7.093628953349092},
    {7.422888254874115, 7.320707760701501, 7.827821342774901, 7.629869876515902, 7.8453017713549835, 7.145484984750094, 7.2556347128390755, 7.554172171450722, 7.769848106688201, 7.492346525540882, 7.7441028959925635, 7.548391618487392, 7.247050433369232, 7.078962198332414, 7.521924954651155, 7.06786934065948},
    {7.650226168657332, 6.711921597970327, 7.702484089650229, 7.551775321935247, 7.851171075477488, 7.595282870659754, 7.075720025094363, 7.243658628149475, 7.596878946451039, 7.705851715155912, 7.500924182318427, 7.194996358823597, 7.727033331580636, 6.898271357087295, 7.90147557020143, 6.804271532250869},
    {7.44953777739249, 7.451506045544232, 7.701792318680856, 7.46443646591795, 7.2682702256439, 7.595382764087106, 7.976862624651241, 7.715047013904024, 6.925594341561224, 7.196670488571677, 7.356136211790857, 7.3087465748873095, 7.184568100206542, 6.733756571266787, 7.357429017538974, 6.6026380744879845},
    {8.108446176713556, 7.276972615914751, 7.508545259875453, 7.558047548045101, 7.398527379607173, 7.3263528073357564, 8.055648933592138, 7.6296333471902615, 7.700137025541919, 7.781690398126392, 7.376206956834852, 7.465435219856083, 7.725489907360749, 6.819835641861997, 7.956765164434986, 6.999080466087768},
    {7.563812006198269, 6.7896151941965615, 6.97645702492836, 7.8585616372161, 7.4066728744642045, 7.507551167415009, 7.56123026642585, 7.097191259197048, 7.605111281630658, 6.888747815807442, 7.259414297886001, 7.169066897033064, 7.69172094454601, 6.598173255871559, 6.978399122526777, 7.128529419096559},
    {7.593094303970758, 7.323501869080256, 7.02033782995022, 7.4931504206696795, 7.4869615650552275, 7.567403240752841, 6.941235162321575, 7.055821322358955, 7.188613065237236, 7.356482968922558, 7.350915807044749, 7.107792517401707, 7.507194841099172, 7.01090061643166, 7.163936895774595, 6.299873915873917},
    {7.766224257637883, 7.132460228608548, 7.927964034943887, 7.36380646945433, 7.136561663529621, 7.833135882540708, 8.16129214572409, 7.281457228112576, 7.466604170248154, 7.397014622498943, 7.780917615172917, 7.548561399782868, 7.438140932801025, 6.594804852534463, 7.680559299254181, 6.723278765655879},
    {7.758514506630585, 6.755759916205573, 7.273037362627337, 7.05796454752536, 7.713216106589501, 7.3870448464305545, 7.691385407949778, 7.519457288839985, 7.252504504360255, 7.2779519431633295, 7.472620264973014, 7.625196551572804, 7.914369476611872, 6.806966368614646, 7.748805887459685, 6.273480914083361},
    {7.325806580844585, 7.2338903432254735, 7.461557812337278, 7.161864498134643, 7.684609870892264, 7.6656476297828, 7.7926374233878, 7.278943792874315, 7.259669093234432, 7.26271736986314, 7.47628791412859, 7.3771474102781855, 7.1160542627159264, 7.1987223017132695, 7.187530087901747, 6.736475641109582},
    {7.046791192764858, 7.189655423518614, 7.830987760454292, 7.781671767069994, 6.929585551473138, 7.5317617156350325, 7.847442701270663, 7.507267396291009, 7.315059653895394, 7.409924323627007, 7.603451274496121, 7.4731820933388535, 7.381280129810884, 6.441154932875536, 7.511828067168049, 6.955766034829439},
    {7.773735637721451, 7.271442452280414, 7.270189888406594, 7.25034824968895, 7.371170782099857, 7.38217240818037, 7.7930564357894765, 7.455162048206239, 7.392274618639938, 7.8226352063399744, 7.493917522943227, 7.005109822014679, 7.364649011344795, 6.610455705968387, 7.478924502090664, 6.799412921464054},
    {7.583989190027427, 6.337636504433702, 7.58641809305788, 7.452889608308087, 7.719553975131222, 7.574410237877712, 7.577647667702191, 7.116372129322508, 7.319460863801372, 7.821946795537131, 7.491047223325881, 7.413661046766139, 7.44104848491887, 7.13433102524003, 7.570648274679579, 6.383171616890839},
    {6.943976760304202, 7.034258107213094, 7.556006443222255, 7.351543574369015, 7.313631990997593, 7.407866680993867, 7.753730019267775, 7.078282534758703, 7.073659844576945, 7.316216031879391, 7.532706788690294, 7.4358263110966485, 7.563868157796276, 6.568309438012401, 7.593659355134601, 7.036622019612406},
    {7.542191995350058, 7.2848547207242245, 7.480884058875517, 7.4262767319035445, 7.473317177250775, 7.395880677267764, 7.536711610108683, 7.282939027323602, 7.1422087892020665, 7.092403144924303, 7.365693911667599, 7.435162568022207, 7.344722924182053, 7.046681517003175, 7.457635873345411, 6.702760140997646},
    {7.430576461607641, 7.041302783572469, 7.337641955367152, 7.470073011393507, 7.594790804784851, 7.3883877671580445, 7.399507202868536, 7.268113871664209, 7.312607289192776, 7.191969242696272, 7.446515680622529, 7.596713137013894, 7.1236199579723625, 6.683674181918487, 7.4622451217401515, 6.930305646604878},
    {7.402179095153674, 6.894215982326421, 7.54097343970547, 7.350473866270146, 7.505484146025981, 7.540809410011226, 7.75503524249619, 7.3012190201776646, 7.544796013963493, 7.205783228252733, 7.33474114925117, 7.663316748362212, 7.529464655211412, 6.86204589241528, 7.54737334860157, 6.627775098513394},
    {7.445208013941516, 7.47875578913841, 7.743599346985433, 7.333057168152746, 7.781281691836624, 7.165370508438157, 7.822139068045583, 7.0801551165011585, 7.5878351273957945, 7.46741182734295, 7.234949618395091, 7.287970266826446, 7.707629692177973, 6.615106228190516, 7.718558665238347, 6.272139328470104},
    {7.644520395053808, 7.163846642785678, 7.41349451778094, 7.618735796714505, 7.228524638745357, 7.74617083315164, 7.438667204683937, 7.399161130464333, 7.765664839295683, 7.169409595125096, 7.208784065956838, 7.747300610363924, 7.889745709683474, 7.254508440624044, 7.511693611211085, 6.914019627266545},
    {8.314686949549149, 7.1536413869966, 7.6600237985413635, 7.466975574155041, 8.00217308432147, 7.684301324711279, 7.533287404034981, 7.786139330758922, 7.439808984152924, 7.326701181737224, 7.0192295257006805, 7.643330424110747, 7.81736356771397, 7.268760903142103, 8.14618867992583, 6.703042790157026},
    {7.490615263555376, 7.783909032467243, 7.392723244964037, 7.417913655927563, 7.9656336847739775, 7.518294964021544, 7.327092045229087, 7.463368828284094, 7.582798320410525, 7.3810874360197305, 8.208262138718064, 7.909705644428898, 8.125704293314106, 7.275986357842709, 7.400301629743164, 7.075174118174683}
};

static const float b2[16] = {7.154560920706324, 7.287337357002783, 7.244046150193343, 7.155871962283849, 7.256106197229122, 7.2804041618809165, 7.177740581925091, 7.16504485675868, 7.267904239601901, 7.1530233305564765, 7.130932302812448, 7.229340148939124, 7.254559544046869, 7.175339809896833, 7.1586445238670615, 7.041446406314245};

static const float w3[16][12] = {
    {-5.287252753339758, -4.730611513082165, -5.263861513499272, -4.947631991522161, -4.873119003974587, -5.236266892685154, -5.212656637739275, -4.974510720428303, -5.335590552314633, -5.284141887182726, -5.12145309408338, -5.237209517977961},
    {-5.111063075185487, -5.022085366645989, -4.792011416931575, -5.359238453694561, -4.4073996949712955, -4.999526483462682, -4.9102606362396815, -4.732541731563291, -5.111446109453491, -4.961136041242615, -5.052241758561922, -5.259303696379608},
    {-5.181708518538807, -5.426580920259273, -5.837982270581619, -4.888631534670901, -5.417796487129521, -4.515122407944698, -5.080755566248709, -5.321063292920897, -4.759823981360915, -5.011440712388267, -4.900787634713594, -4.4604896963782545},
    {-5.281418681590994, -5.138891810205518, -4.9657709894743185, -5.508494647693696, -4.7066604792582885, -4.770566447884238, -5.647154342837873, -5.327009405849931, -4.903707406454206, -5.523250144447592, -4.8716740205922155, -5.250578157813955},
    {-5.026051760130143, -5.144741423190558, -5.3194949192530085, -5.763051188686119, -5.629692858477806, -5.208277576954179, -4.8148678074088975, -5.25505239522068, -5.124278011314989, -4.434838763300063, -4.663905826373219, -4.8403764966098155},
    {-5.4056848847953685, -5.346108897040657, -4.922310260710458, -5.137995599360138, -5.203323279435958, -5.513713927821579, -4.881905285773003, -5.4908477026833085, -4.759390068176946, -5.26611804762965, -5.196454872756199, -5.120510437457585},
    {-5.225098390584897, -5.167272737498282, -5.2863215835701345, -4.343985316902573, -5.29506486392851, -5.159936411021711, -4.692254417878056, -5.120024020549351, -4.967558693607257, -5.061012232258593, -5.4011235015549035, -5.630251675854973},
    {-4.609323876720001, -5.241225728196291, -4.824003033566001, -5.135494164367313, -4.951188778263668, -5.143796524330206, -5.442647571033625, -5.312016637080515, -4.457460789642404, -5.144365754005982, -5.100297551444735, -5.212985857942382},
    {-5.054119427595359, -5.381262872915004, -5.163058395789832, -5.4170478708227945, -5.1357680264022205, -5.212296850591801, -4.399287093443321, -5.557154413805368, -5.2220211647954065, -5.231435465547997, -5.86625216702481, -4.916766166683415},
    {-5.539035952859665, -4.551068581942972, -5.852438672326522, -4.598971314136498, -4.580184527637579, -5.286182443018989, -4.818380515605103, -5.293268487885462, -5.6894735459415156, -5.1916108475853155, -5.088241957745661, -5.372188450626742},
    {-4.5061600968158135, -4.59743625685811, -5.608508476805045, -4.659542785437278, -4.957168127782176, -5.563895172478262, -5.730195969367273, -4.519504605378508, -5.487193961660919, -4.884446424600922, -5.118906072242317, -5.110554165253119},
    {-5.351292792008393, -5.186153811861989, -4.609520825648659, -5.784091439117678, -5.281414289503371, -5.2225388682373435, -5.327252630013158, -5.113306536839632, -5.3027538118091355, -5.20921508808509, -5.320044145330648, -4.832942618034542},
    {-5.197687398915906, -5.461320983123646, -4.858212517678835, -5.242508911515388, -5.0780872414620255, -4.6509625180156595, -4.910066680557606, -5.178329015393068, -5.367373163632484, -4.96872648596635, -5.284400728509654, -4.965406286054658},
    {-4.222312597850146, -4.634777313604061, -4.170057878265035, -4.512902725568335, -5.095645317836223, -4.585786733890389, -4.770262197657878, -4.190814078642547, -4.829857715315953, -4.868608562301136, -4.865280592365599, -5.207997115469959},
    {-4.913999032140485, -5.420727277726672, -4.818366491581756, -5.536347354197755, -5.152100600385035, -5.057056101887409, -5.3833510615942135, -4.993910974174457, -5.175665344980843, -5.2253925600106506, -5.682837195245653, -4.945911988337017},
    {-5.138834149774079, -4.579176742129489, -4.684191473239584, -4.127434844258338, -5.228237510080588, -4.797312637619765, -4.974043182248387, -4.563336186643646, -4.546495934200796, -4.749821025615802, -3.4101177773105036, -4.738108276572436}
};

static const float b3[12] = {-4.194875878794393, -3.615491973963708, -2.6728372827869045, -3.0956582188972392, -3.3372123992335205, -3.604213538998907, -2.5554505687088414, -1.4542666383104579, -2.079771644979399, -4.189854209566974, -2.83212777586788, -3.279738092804552};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
