#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.5123383140772737, -0.839857811690325, 0.28437598297877337, -1.0739232077947136, -0.07953892134804938, -0.6713101459336189, 0.4281049709704774, -0.9272062560541342, -0.84133790049669, 0.21208387236490467, -1.1460507332509864, -0.06106648005643958, -1.005997653420614, -0.7247325983305625, 0.3325878032548916, -1.0542270678542218, 0.5281087460060566, -0.5470439259470191, 0.1162901474344122, -1.0510962323558013, 0.15467758114716926, 0.011834028999564945, -0.6673612815482102, -0.778606411420165, -0.5831647987402633, -0.9778275216449092, -1.1451250738834091, -0.2396990056136331, 0.17479775380303578, -0.7706796180069216, -0.7676472387398734, -0.6547224236035114, -0.9829167781980064, -0.7152236244409392, 0.623498611893642, -1.0776776955354301, -0.7912500272753439, -0.7254550741332214, 0.3563020832794651, -0.6448479088117748, -0.037304176821364415, -0.9421440702966288, -0.9600927805072073, -0.6753851059690051, -1.090794283724512, 0.27161952941743117, -0.8748707790869092, -0.9251874521531314, -0.6286668685754219, -0.7162335442064873, 0.2089785418679423, 0.214983042370124, -1.0833540542777498, -0.4984810432614596, -1.0568343474079924, -0.29382155431633616, -0.14018080224878188, 0.373747228134564, -0.658632668519629, -0.8414950788611056, -0.05806621270830818, 0.3751423711247544, -1.1374646953059901, -0.9808389971829159},
    {-0.39752045251869267, -0.4693497348060417, -0.9059269933908667, 0.419460827473195, 0.3197726992429379, -0.36570508187274875, -0.9166535541328835, 0.35658641285205955, 0.6690865763888668, -0.7261388290095657, 0.7052567132138351, -0.535620324940559, -0.36721923435543, -0.1622917784840117, -0.9990856092251575, -0.16707110519652282, -1.0662257450343104, -0.49659990453637676, -0.7122801043610817, 0.15020490649330848, -0.7555440146387662, -0.39841072124622023, -0.11018802575154381, -0.06071137653454813, -0.5845695806759833, 0.1935935252491802, -0.027885090118056736, -0.6289495991659859, -0.5104301452852883, -0.5126458735690566, 0.4609496951039825, -0.9147539207008968, -0.13628171641472558, 0.5306647959753492, -0.7852387108144097, 0.7771285506201226, -0.05640378397700277, 0.29495001673499904, -0.7971118668381184, 0.27732868713758224, -0.38335814236524873, -0.3880999423475651, -0.5209142238189621, 0.06839231046021749, 1.0648692004356777, -0.42810915897910734, -0.22078424926336304, 0.6445608754517025, -0.7205378239324564, -0.9747281950798716, -0.9089909471281505, -0.9249595543666825, 0.11898035745709991, -0.24515075923609816, 0.36802241250792006, -0.40583088721057475, -0.6187816937497916, -0.8901661714762006, 0.022922446947097164, 0.6850827225337515, -0.4046882497158624, -0.8813531437464531, 0.08110869540141263, -0.2556486231914731},
    {0.5624761869440258, 0.24266493174645515, -0.035282353552473195, -0.44773804025481995, -0.34827507204431835, 0.5679789570614535, -0.4077821150827654, -0.2775463757411934, 0.4168591203023404, -0.1834579032284373, -0.6440649418191805, -0.3612873841017527, 0.7574106347366542, 0.5083583925450454, 0.2736286506152369, 0.4533018276237319, -0.749903050340598, 0.43639009681786967, -0.3504670001911777, -0.3175286764422854, 0.012955873951288126, -0.07178973049086372, -0.35714620480260856, -0.09785262294010513, 0.6700914542420191, -0.056931666297095146, 0.29865202668557655, 0.4316497511675405, -0.9545538218596838, 0.04207978218981318, 0.7753986872634451, 0.04994385311519317, 0.05706919273405131, -0.22096078571849775, -0.4425257842371274, -0.02943325991519791, 0.6999873777565384, 0.6441352124344236, 0.04035047675832704, -0.12910657151956145, 0.6244001555805383, 0.3620050901912332, 0.23507936577669716, 0.48318832783756416, -0.5712300419485605, -0.2616588078097135, -0.1548054062238856, 0.5255323392119571, 0.49668832349509195, -0.3307804706954614, -0.4370595871923075, 0.33793127803117307, 0.8030694434906385, 0.18283755875486646, 0.9806428589264553, 0.2693180116092906, -0.26901480017012164, 0.10110239472880977, -0.3528147346973254, -0.7557432395869402, -0.5369638328186983, -0.11802837561529614, 0.21827997895581458, -0.1883013648908725},
    {1.0215611378306717, 0.6770306790723372, 0.555805920061063, -0.48148745336432575, -0.8978388718919813, 0.23615820691936687, 0.7007170236906648, -0.2164448611831675, -0.3911489528232635, 0.190938271833619, -0.4800775643638511, 0.10683433776761657, 0.3008321244311803, 0.6450572692585281, 0.6879625387306099, 0.3254991136297936, 0.21776881501560655, 0.5725367257096594, 0.39437018722184464, -0.3275293655882822, 0.36577465990491165, -0.41569955384281837, 0.5119676672476546, -0.3319207596690731, 0.943801825861487, 0.26045034775610715, 0.09916414507380376, 0.7707691228250755, -0.7369627487616369, 0.5558173124223389, 0.22402197489461403, 1.0156645201884258, 0.5348507943779894, -0.7243599225561909, 0.428677340134006, -0.33350884443735423, 0.37277502228956416, 0.4820392802131073, 1.1044560329483686, -0.31032972997700997, 0.8788258862357113, 0.8185760356216876, 0.8506157205748651, -0.035361667190316665, -0.8865906880522211, -0.41996446830354317, 0.5901266913533073, -0.5206389294935472, 0.7210106799746695, 0.7803062258564822, 0.02155301454034105, 0.7148157821370156, 0.15953375015298646, 0.40338279179877207, 0.4926320032175393, 0.8083106727104196, 0.48444535678980805, 0.7985475866939132, -0.007365917620786076, -1.114090167351249, -0.05228514236158743, 0.8358706018995151, 0.3640193542736193, 0.7146835271556059},
    {0.5668715489944366, 0.712353387850369, 0.14745118569912447, 0.5357042556552621, -0.12870328008709278, 0.6753514604429748, 0.39688900315475245, 0.5118993082665027, 0.31780074288285837, 0.8620859720571084, 0.6798888065798272, 0.5298844307653745, 0.9399164078588028, 0.7220859454944658, 0.28188974600546773, 1.1040108893090042, -0.2654117234275993, 0.5113789665602464, 0.06508610185872629, 0.9249259040811495, 0.7525480519526108, 0.3032655549644036, 0.5398644459326207, 0.5692950094270628, 0.9338087114895324, 0.5763459152962496, 0.6133321401234433, 0.902474447111716, -0.36308238589371034, 0.7367629177673675, 0.8351574521688858, 0.6659000378602575, 0.9105378189525172, 0.38518594886913177, -0.33253500194295044, 0.8216800854707181, 0.8588926563377045, 1.126249244145865, 0.28367945560966534, 0.7797802224010801, 0.71539424728536, 0.6382407924785752, 0.6388436388386803, 0.3755784273411468, 0.3823956000125987, 0.0062588321786702875, 0.42559319659163236, 0.6179261884740829, 0.8924760475128635, 0.5691263084922158, -0.38447977343713685, 0.7767188934486917, 0.8555195280723923, 0.9397114901681672, 0.8285331194547404, 0.7125164859064028, 0.3516846891375599, 0.22136798896138116, 0.44028526667760287, 0.1902502441377796, -0.5467648948020977, 0.6890509520598915, 0.892581292995377, 0.5577877950554809},
    {0.7627583004031154, 0.5862289528945837, 0.7560783911605564, 0.7884489153791439, -0.02787320360017134, 0.7876647538133191, 0.844326973881931, 0.5946736224148426, 0.9299853565445992, 0.9646880841191215, 0.8594524162906284, 0.6691804831058216, 0.9226291335359621, 0.9148797922922911, 1.030455584792722, 1.1847600393378708, -0.6876292946081451, 0.8864817359036031, 0.8333519145867043, 0.3720218200385906, 0.980825008941436, 0.6019641018734463, 0.48264336669179003, 0.7481477321722702, 0.9419009169078989, 1.1092505463661848, 0.9065498774666728, 0.7786745823529317, 0.24831225341308233, 1.0746030050680129, 0.9852509283234516, 1.099933035955548, 0.8746577495007234, 0.612246283986063, 0.40669359589475895, 0.9163205978525449, 1.0249673973209685, 0.8581707614856238, 0.8600037514690337, 0.7502478751153875, 0.7390189268474042, 0.6028250777308236, 1.054753934118451, 0.7129070006533942, 0.6611694822905253, 0.012496935283551332, 0.587151272737247, 1.10696324785137, 1.1179530961469963, 0.9052767381694458, 0.7123218454261838, 0.9280367125229737, 0.6279169443622685, 0.7257121718061847, 0.8429992383625592, 0.6075435090468713, 0.6472743931620747, 0.8240104315474786, 0.6796059619175373, 0.3553616421957666, -0.02194656103179921, 0.5838578877619722, 1.1265297491588688, 0.9709375482509082},
    {0.8116941248344399, 1.0008288723449787, 0.8969685677801127, 0.8426625838615945, 0.1170509008375881, 0.8864951925530153, 0.88937102756661, 0.4841895862327268, 0.8574325735083678, 0.8994632936122212, 0.9181003348182737, 0.49635105191387063, 0.7860296542252586, 0.7932824751467691, 0.749854293297644, 0.8278246618658602, -0.772520800405133, 0.9594892897000933, 0.8261783662605878, 0.8111260802476038, 1.0145535418077696, 0.8375085157514226, 0.5635005312339023, 0.721318187568804, 0.9256276630803354, 0.6865485407215965, 0.8951418479846259, 1.0011424208059436, 0.00879926708392673, 1.20863849652968, 0.9178575635568804, 1.1006664988906778, 0.8211747912716436, 0.49987704997600585, 0.3353654777928836, 0.9092037341179856, 1.1714134223676531, 1.0871061503287787, 0.8723329550219852, 0.2576380522267773, 0.9996080826995319, 0.8724129063553728, 1.1526418546220718, 0.5573543533431243, 0.45684408011073874, 0.06486151031700256, 0.6698418185871478, 0.5348133235430805, 1.057794795704352, 0.7218183266937718, 0.6355814775405737, 1.060475248730598, 0.7684801060117747, 0.8595264992711914, 0.7701527952736713, 1.0191658673077852, 0.7262984224097563, 0.9001113876169472, 0.4912631299840019, 0.5283438977907113, 0.1602567327225425, 0.6219820281942219, 1.0357296288984308, 1.025343542236206},
    {-0.15335872547274826, -0.2748425912334909, -0.8819072171377366, 0.05376116003001587, -0.09710672790536408, 0.43231720312500593, -0.27454635615793455, 0.35859258516891823, 0.5621135142966238, -0.3819181882107344, 0.7613966509907601, -0.47134927395243653, 0.16267315169028831, -0.17167477297614528, -0.19072741047089226, 0.37645917221869646, -0.7589615016490923, 0.4477333384068156, -0.5906567440785138, 0.638957901987026, 0.4104342489833045, 0.02195897951662422, 0.612479140727703, -0.23166597066359385, 0.3258634046663093, 0.13339379581924793, 0.15294694279022497, 0.41406942019771714, -0.3252570823372092, 0.01580651122089843, 0.4991075928252176, 0.028962843287038458, 0.6931804075582053, 0.26023387584764995, -0.17530254947689805, 0.5267299952649561, 0.5055744970138444, 0.7993493366904313, -0.3776515854836882, 0.2967714105386537, 0.6792459344404271, 0.5713507993991997, 0.03945179424403712, 0.1831765921765003, 0.46548054725335375, 0.24713450227345676, 0.5546740621026105, 0.3495156584439042, 0.39267473926180196, -0.01978747474510031, -0.9512770512401074, -0.20612124549915828, 0.8386938996690211, 0.3747316675305563, 0.43719556323853315, 0.6750047416964434, 0.2988250196707714, -0.4585135621948875, 0.5066134468352812, 0.13498190362067597, -1.2641863053812687, -0.19353344855718693, 0.36143701083175406, 0.446592667827598},
    {0.40467248014116375, 0.1546857705184823, -0.5382792911359244, 0.2765170123638556, -0.03241404812038568, 0.22407436927528837, -0.24925377566946624, 0.8447882535132847, 0.49004045533357316, -0.5386768066195603, 0.3302371663092304, -0.168585168210497, 0.20770486442621758, 0.5118438251713999, -0.7013235536860682, 0.48744382254298185, -0.8666620086990594, 0.6129145975075364, -0.5715463894289404, 0.5747673909775346, 0.32612394685478074, -0.5485932174560163, 0.432820058100067, 0.14557885202307055, 0.19404743046198786, 0.2747329873772747, 0.3338593531919052, 0.15252816300230257, -0.08790726732806844, 0.34367890841055226, 0.6281983463747113, 0.39214159075536426, 0.05398746609559256, 0.5964622900542703, 0.36575797765305534, -0.04425521957186557, 0.4860361012851847, 0.8050720921120481, -0.35729921254230973, 0.570382795224237, 0.6264503545608104, 0.6958297343633763, 0.5053099235769454, -0.13296751236322407, 0.8505829358365472, 0.6065225131758903, 0.15179976872631856, 0.44347496490915794, 0.3904619016722081, -0.42429532379469354, -0.6258937585564054, 0.1850353365764802, 0.5555597478730034, 0.2488393869279872, 0.21535482366491893, 0.44123528776212395, 0.35335625608643323, -0.3804723453190028, 0.5003997931616683, 0.17925949450356557, -0.7288862233204767, -0.24462960488523405, 0.6984174229674317, 0.48570662329792913},
    {0.04517989843636273, 0.014237744930384747, -0.29904095254273205, 0.9174620138706637, 0.5109048191595438, -0.4998875206858899, -0.22355401311175724, 0.4216335874592423, 0.36074784861619563, -0.4079177251952186, 1.0801117250218797, 0.6058381471702291, -0.4591618349277489, 0.029117686926882994, -0.9571357732103338, 0.11461033399262396, -0.27947315111204896, 0.14875208924571845, 0.19114263580725793, 0.8260241210140166, -0.20425186326515804, 0.11661897699071148, 0.7999891002094478, 0.6063335715608539, -0.8294237127057258, 0.43796247765038965, 0.5860036012129729, -0.4975975880786316, 0.5701054793263888, -0.45857469134487305, 0.1585591062478807, -0.2248934995711455, 0.5967248995456734, 0.4338488902281398, -0.0009705158148421328, 0.7176180516547367, 0.049507612157337684, 0.4416598530872186, -0.826744350454284, 0.7110499851283146, -0.3087029103302582, -0.39361886695935744, -0.31508767319915454, 0.20400327746908625, 1.133310419199625, 0.24716442779919873, 0.3859978136699271, 0.46567648424627117, -0.32185074604926917, -0.0067367815544838875, -0.327459146950825, -0.5428856429624547, 0.5021453244077276, -0.4680324506426291, 0.24664856793276052, -0.11566946747138207, 0.04310336497243954, -0.4521491105311196, 0.757948491198802, 0.6059809230503532, 0.405590841147819, -0.6579612733619777, 0.0023645713870418367, 0.7735407300427716},
    {0.664566817153387, 0.415530270801124, 0.47089600564301065, 0.8653643215001282, 0.32080513660028687, 0.2090076196275922, 0.23809507607140296, 0.5828709010846914, 0.18345653522311958, -0.052803523332678994, 0.6514033089300356, 0.6784841386234182, 0.5231547495452404, 0.6128778446536343, 0.05386935223786286, 0.2717526696937497, -0.5375415496717537, 0.4892662471510885, 0.9439009274221584, 0.5538245092189795, -0.08135783757047636, 0.7363370259589069, 0.7372682104803384, 0.5173395152387045, 0.19323969574429534, 0.326526126120509, 0.5101848879797313, 0.39820663032111264, -0.0035898944726553703, 0.40277956201961934, 0.18390505960911296, 0.38762598542986393, 0.5448427385185874, 0.6737313071115679, -0.24075806102441416, 0.5082287186584012, 0.11124442433119314, 0.3150538854431278, 0.17494296576215282, 0.40184502872026867, -0.10216889596912966, 0.19748463271642355, 0.36152554081195376, -0.006494821943517048, 0.5929272060395824, 0.0821149424246177, 0.5758993353087808, 0.3807881396532066, -0.17608120280470965, 0.4649626546549775, 0.05686120987428537, 0.6985256856602069, 0.5870167083615406, 0.24494794814553872, 0.09761814080440576, 0.3145490543735409, 0.3560867455762851, -0.14593998645267373, 0.7952269451541335, 0.31158125648904417, 0.7692666474568512, 0.14432613733074268, 0.5243143290856677, 0.5465084084181668},
    {0.4463592710599767, -0.14010464489646915, 0.20436206781563349, 0.09557369902240506, 0.30222321406654284, -0.22578981013560287, 0.024625867250583293, -0.001975467804107322, -0.0009618318949733586, -0.5292933629303886, -0.22387604014974133, 0.18525730491166006, -0.5984894251789618, -0.03770065849789246, -0.5557154483830297, -0.3841594248770215, -0.21152667794458307, -0.09983278711021758, -0.35353955203335286, 0.030433572577818636, -0.4680093160638926, -0.5447625597136224, -0.38042911603376395, -0.9611246920270271, 0.10299078792582526, -0.5102687305455845, -0.46588674189675866, -0.30868068220776307, 0.24339824666987228, -0.37122380571472374, -0.0764108839960787, -0.020121262770379806, -0.24987868556911205, -0.46525809247565725, 0.5409542969919041, -0.270157117076539, -0.18436189257598656, 0.27433842548641635, -0.26018175724700016, -0.46009344071243646, 0.2809127672936938, 0.352037981770922, 0.169057939806662, 0.03126883350397556, -0.5737231904777433, 0.2907053925490899, -0.023675339312363156, 0.008440236062099536, -0.48574113607861885, -0.4963935314178654, -0.07120117493033454, -0.4399795006110278, -0.22361908065405992, -0.6324058250762142, -0.18722321823529406, -0.2164346718873438, -0.8007482546537027, -0.48535265638166075, -0.43194367409047674, -0.13916855519127286, 0.6126569295830502, -0.5350135438882729, -0.44362377071695364, 0.27261700640986725},
    {-0.43294097795850983, -0.07779652336820529, -0.6402400440496933, 0.3935829013108385, 0.7510716430138049, 0.5193998671358048, -0.586691362135805, -0.03285466545073977, 0.8079198952139607, -0.4790193071019055, 0.16830330736945853, -0.2511086120935896, 0.40939617120742516, -0.13015596548673983, -0.4332273420613715, 0.2742844841806532, -0.878877833103843, 0.05229337699378194, -0.07222028050016148, -0.12626995900031704, -0.8544467389062652, 0.4350157151830284, -0.3827012833162227, 0.5460604457765726, -0.44765869086622767, -0.2115621619175001, 0.4662874576941183, -0.5372909532405208, 0.23135001025324997, -0.10801501593433596, 0.7051098577571528, -0.8670848516278213, -0.4464610758902074, 0.9915245616389202, -0.4169424030679892, 0.5350989766451748, -0.06387737369927574, 0.23327869149793476, -0.4722318683555939, 0.2519286751777559, -0.4638315712618594, -0.09309907376336281, 0.4190320374505637, 0.28981640821224486, 0.9423523490038509, 0.30415356035985086, 0.021056682217216093, 1.1078105855948148, -0.6294680118533145, -0.46032018031152466, 0.1160080851694115, -0.6724171011528929, 0.2909054824978717, 0.22981598458751779, -0.5126642867258996, -0.4769054332861275, -0.3095829355187976, -0.9393827738496612, 0.15927521150927773, 0.9156922301231334, -0.049401949366214344, -1.030956885015598, 0.08785954871319622, -0.4643215771181866},
    {0.8660846182352459, 0.8763590084301279, 1.027374355194877, 0.518737396013423, -0.8047852400494548, 0.31498406592449907, 0.7594401574410606, 1.0498080665090126, -0.0659285911756697, 0.23607675983249093, 0.2039986736666912, 0.6648503228330278, 0.395473014476772, 0.6860058107391642, 0.7175063415416908, 0.4627634721068481, -0.3261871159473912, 0.6501243200749768, 0.6433983230756154, 0.6400903249650735, 0.17907247653956754, -0.15603853735311166, 0.6014584252138667, 0.36705830428062525, 0.15658152554354407, 0.6923036671757685, -0.36107473248429456, 0.17788489831505017, 0.21391271704926965, 0.8574737813364797, -0.08918912443364799, 0.2827810637929249, 0.04742742399339526, 0.25932263296965413, 0.8420282675269799, -0.4467133156248144, 0.6109864226114753, 0.5751135819287772, 1.0569132476326326, -0.14441353316796435, 0.7827447436287155, 0.9447030783861031, 0.8066130193151697, -0.18246062657448872, -0.21741105786964962, -0.8261975725973938, 0.4447728940139521, -0.2002923415221994, 0.9863997735428738, 0.5737415547096324, 0.8276349796215436, 0.23626342786252882, 0.09778706752941832, 0.3185563750353556, -0.8080697834782589, 0.6711320410043485, 0.13454114253872196, 0.9494961970397782, 0.25808563196812284, 0.07529515448214688, 0.6705631014457175, 0.41714313484420396, 0.7572557785225519, 0.7790805449840108},
    {1.0570754292911395, 0.5458583229198868, 1.0274311721744465, -0.5475654436991515, -0.6941156757682873, 0.8060587644750438, 0.9436028014953443, 0.4653274423662075, -0.8885763860032784, 0.004443087916958725, -0.7599413863763049, 0.36501127648282494, 0.5239428953516375, 0.7309724808314341, 0.8774107309944125, 0.08924836362722478, 0.2165774969258504, 0.5115388340942002, 0.9753863783161395, -0.47435091544743896, 0.7637927619214315, -0.05787516576385501, -0.31788524814926516, -0.24107827895875078, 0.7596355134624149, 0.48581383183428817, -0.08191814153135839, 0.06405858411550416, 0.5831935418778078, 0.6029597687827722, -0.09131745732468033, 0.45600684343775727, -0.4653827819677466, -0.24771253794926718, 1.04576348131015, -1.1639724751406963, 0.40728172867237894, 0.27023588390011477, 1.0115988578716122, -0.8306921332378683, 0.6394029694661584, 0.8459113106702202, 0.716779359181133, -0.7122247442784211, -0.6733833900269331, -0.9000299811202215, 0.06464459392442405, -0.5048923390988588, 0.9964909079183513, 0.32501688684186186, 0.9859209026793947, 0.5366780886565761, -1.1727935647458552, 0.4833219182910625, -0.8925075420429602, 0.3731494090900076, 0.09002384847995523, 0.6004826735681474, -0.4169561364021216, -0.3248305679315059, 0.7240678036364987, 0.6116023992147278, 0.5788473826144822, 0.8866015963060784},
    {-0.07641867786870118, -0.11452474047583469, 0.17816206400063897, -0.04510491813394894, -0.01069050298832605, 0.32818169130358815, 0.48584802399355786, 0.23933436983813397, 0.1164519804032302, -0.6608510947186027, -0.44822554330240527, -0.20055126777998633, 0.7976105696392303, 0.32434322519611286, -0.4480361893341569, -0.2855728540942705, -0.012718152630723461, 0.18398796690283034, 0.45902071816471446, -0.47381821951891134, -0.04728128418401263, -0.5379546482661681, -0.2805004463357533, 0.1395423189872924, -0.2743104867279115, 0.522658848168787, -0.2898523103187039, -0.819318156324159, 0.70162793830531, 0.33908278194875424, 0.20790057534641385, -0.7273637409764497, -0.8994759125171831, 0.7838395655380788, 0.4863275969533262, -0.4647841432190439, -0.16168588905172718, 0.31275780864149855, 0.04095155178365771, 0.22501931897686628, 0.17039565446733296, 0.3238545805910137, 0.4019498817891792, -0.3114598419551575, 0.3062402132991663, -0.35501599688843566, -0.5115889977949363, 0.10480831846021814, -0.28614470081812887, -0.012906738045291017, 0.5818840427895351, -0.14195160335097765, -0.8409092165791189, -0.022272246454251684, -0.9181043234964742, -0.17802087578970618, -0.606069192604358, -0.5654463510087009, -0.4657777625185487, 0.3754400925930061, 0.29599614357660164, -0.3622768376206112, 0.464190221595182, 0.41852200291801855},
    {0.8975067692660041, 0.6855150562010474, 0.9493882811468538, 0.574284763599688, -0.8157453694358171, 0.6159928350780839, 1.3027406588412493, 0.895593283969106, 0.007823834015416697, 0.4233208059904919, 0.28244896677092907, 0.6967858266354552, 0.41508418030409905, 0.9179681820032854, 0.8653339464077356, 0.9026773404168309, -0.19491408346610564, 0.8941670092717341, 0.9042788399327636, 0.2599865798639788, 0.6725956165139875, -0.02057067307693601, 0.6468672010939583, 0.1954558287753487, 0.6624544512686034, 0.8559768379825147, 0.23260822151349558, 0.08121988537779457, 0.5579807447082391, 0.9455111555102763, 0.31961072708695415, 0.7768007774479446, 0.4665174033483521, 0.20581163556858398, 0.8944002531392347, -0.08117891762372578, 0.7998530866621025, 0.3990418665320995, 1.0794252786266072, -0.06505589785898852, 0.9895059280362247, 0.9541998679736967, 0.726941438248733, -0.30736170695556464, -0.0956986501378778, -0.5205624725787598, 0.3816518650973533, -0.1274010033240067, 0.6249234167683827, 1.0734329923806634, 1.0215212536719522, 0.2635448508576801, -0.05348643771221552, 0.6656932967987548, -0.5249343893945598, 0.7537562449093433, 0.5761165310112787, 0.528794006149669, 0.6051878981785559, 0.15067515761386377, 0.8089422154573815, 0.7913584757674857, 0.895269449535429, 0.8146230372964948},
    {0.7681418351077631, 0.8105905531918608, 0.725081718013323, 0.3506593601682904, -0.3521058549809587, 0.5075783046191681, 0.9700058741717027, 0.44027454889875406, -0.13364920841111694, 0.6066667309976852, 0.4268496568295112, 0.6829858868854465, 0.6219546438325694, 0.6711324984813924, 0.6727826968429079, 0.3917608666205548, -0.3407850264012497, 0.6492141059333644, 0.6405545969451522, 0.1462056885916194, 0.5511662459952092, 0.15529015622113565, 0.5212741836355888, 0.28119546134738793, 0.6456585940654322, 0.4557030464223692, 0.6886062231256684, 0.3545538385249476, 0.4304518625502148, 1.0316959900055165, 0.1350102083575955, 0.6530602098174739, 0.08523561727628397, 0.5694483875702165, 0.6320227561758763, -0.056571444738050064, 0.9462620261574493, 0.798574786298247, 0.6535379822744664, -0.14891254553968994, 0.7461449519834346, 0.7787516111436295, 0.4930692846356507, -0.43096888603333033, 0.06774612626992702, -0.25668072222738036, 0.5270284330210269, 0.0039017538728653967, 0.8899555223484683, 0.6743670956702345, 0.8537949941964622, 0.5785018276604588, 0.15013556602714961, 0.13196172845542797, -0.6500478790835414, 0.5959698444932532, 0.6293336397667917, 0.6463596694739094, 0.25726861180557975, 0.5071604387805775, 1.0930508743905252, 0.2860746774197055, 0.6105094285890809, 0.791518501775168},
    {0.5129948832569721, 0.15261472920132044, 0.24816000714869843, -0.3384785623706529, 0.021760941592950132, 0.7394912340534401, 0.792069695774583, 0.09016973812013247, 0.0888220436675874, 0.07304711035002703, 0.3435961464294963, -0.1968547274683485, -0.3118124555203594, 0.5574061804948892, 0.24586880910581982, 0.22202366002170917, -0.05294195334094564, 0.5584683959006291, 0.37874229572464946, -0.11345016884996875, 0.2929606911995307, -0.11613181479805294, -0.5288304732057111, -0.16988179943770537, 0.78660824562213, -0.217949245159567, -0.07873729535887491, -0.030326915571210023, 0.38300484801352774, -0.0038602691647567416, 0.352847103856476, 0.15124168920887449, -0.23025573100786303, -0.07784214578982919, 0.7924105916650219, -0.7474168171875237, 0.4051243448842808, 0.2867547290232932, 0.5946313776527572, -0.6267529228934187, 0.8856884164968036, 0.7480959734709428, 0.11702786057108562, -0.001026094695586525, -0.5929941591446344, 0.02545134927584068, -0.3987986567885805, -0.5900691929779107, 0.1772883286245381, 0.37877056883520493, 0.7440366148765574, -0.025035705147625757, -0.2789274493188599, -0.04744380541769891, -0.0660245150304829, 0.11848779782078236, 0.042986328982658965, 0.448863335074804, -0.3454939641075927, -0.11190743233085745, 0.4656733189294054, 0.5231391487595879, 0.47058301593160307, 0.2989975089731668},
    {0.4526231479215422, 0.38260775970033145, 0.7955291221636855, 0.5084767625962882, -0.7270608790946376, -0.22240872512060428, 0.4312315915255402, 0.0475342685559193, -0.10703498998124686, -0.059048003587936514, -0.56471143319211, -0.04248526427521631, -0.41178606843457366, 0.26219905720483266, -0.04713682090179078, 0.1756326439664974, -0.437128931397665, 0.29336968797292834, 0.08028648243443658, 0.48563978945610214, -0.24442550742411237, 0.30683608216377706, 0.06340695087110461, 0.615132112988586, 0.06996504134826878, -0.45546624233906713, -0.15886365998664745, -0.08647625033029589, 0.30533050590916944, -0.10207872613571785, -0.7635324710073493, 0.39609656668368537, -0.16505977174323927, -0.23609087365684592, 0.6629876482979326, -0.3903295993779931, -0.5694591751954072, -0.28476601891963643, 0.5870199630374207, -0.5744731849543223, 0.022800242198251944, 0.5531041536957456, 0.19404281949389143, -0.23158050484042172, -0.22823582899867956, 0.02493638031862604, 0.27201976085605273, -0.12993693711103402, 0.15276408392678023, 0.24460626662599372, 0.7416147290976539, -0.08386535144818828, -0.24108209237147937, 0.3139222377649386, -0.18059100073654213, 0.01491423379918553, 0.29960285576084666, 0.5717489983682733, 0.424679948295012, -0.491806440643102, 0.5423755469925445, 0.5230227175856094, 0.2316060148823229, 0.1819588467686014},
    {0.48049907623848037, 0.4346659486816795, 0.46787181967871244, -0.58548669479986, -0.46185127523932673, 0.11398424563514489, 0.5441932659009916, -0.016569277408834425, -0.6832654330154186, -0.11266270321798919, -0.11484819192251243, -0.5050529249762419, 0.06032547453381714, 0.458412127267687, 0.6861566893212208, -0.3405923095302786, 0.3485094213427417, 0.44607791885943027, 0.8609268165738909, -0.03650749496020633, 0.40776163490723893, -0.34580176957862785, -0.2550619536985785, -0.43619142739202627, 0.7825968041206801, -0.16247702291915123, -0.23807216886479202, 0.0524376600771683, 0.33384921881977586, 0.46983126708474887, -0.6390105380411945, 0.3206534005421514, -0.11576318225195645, -0.44387220573225167, 0.8555151219752923, -0.8635486870953698, -0.13423847367668348, -0.3864078450241628, 1.0038416332368751, -0.8890557121347925, 0.18762715464610072, 0.5955124713926403, 0.48018999437469057, -0.5491733337862014, -1.078795386439503, -0.5548835766062845, -0.16730306664606306, -0.703877050595309, 0.4856086891455661, 0.6157143014064606, 0.9242136320458046, -0.03153000170271573, -0.42895784191604824, 0.1868905302078425, -0.3341716145945968, 0.4427659988161598, 0.19298652428936688, 0.5586234596785108, -0.21772459814667072, -0.8514640267812793, 0.7715661988346563, 0.5930602660217246, 0.28329626725359563, 0.813846276151491},
    {0.5759328130362165, 0.7208749380575742, 0.46552155338602896, 0.5996612928339768, -1.03961038986684, 0.17053632668888252, 0.9457898260390577, 0.7738897163885056, -0.4015432061820056, 0.17146903136439776, -0.02290229225275411, 0.6044761006627335, 0.12895125117332834, 0.9375519479488649, 0.659743145434625, 0.2610945068744912, 0.7122761071340842, 0.5416088030064677, 0.6909222947994161, 0.43067757544220236, 0.5890235007501204, -0.18457370371284743, 0.9186829844572534, 0.31303884570948515, 0.31122428474891156, 0.5100656334138761, -0.41571931441522636, 0.2292654526724902, -0.001798031638508452, 0.2926600133608246, -0.03366088204055125, 0.4688365509223418, 0.625349991182694, -0.12793734672273696, 0.9649703781572722, -0.2325457479588038, 0.29489994654621865, 0.06676690675783946, 1.290047684104553, -0.19932586415052247, 0.39729804816754566, 0.5486253554974618, 0.3644528437340087, -0.2424694376508414, -0.27314789611537454, -0.8669674254025221, 0.5418994262064124, -0.4069030568985708, 0.7538759284523665, 0.8155440728025825, 0.8793936016869177, -0.08767490715600793, -0.29583160084592375, 0.6651042650869246, -0.9858414112573107, 0.7506372705744875, 0.42072945816871204, 0.723269121662495, 0.7219243444209074, -0.09407754030499334, 0.5681878419584362, 0.7639471011532726, 0.3422825681353428, 0.7419944993410346},
    {0.6966299665760071, 0.6114400611081118, 0.6731338123218809, 0.2884873504977516, -0.873214236968307, 0.2858109874769775, -0.038660472659593124, 0.4891414839217091, -0.5469592272050978, 0.23381770882233316, -0.6580686183174317, -0.5062937412332964, -0.45265482610190144, 0.3908921232552169, 0.496981509097443, -0.15232726069655597, 0.6525456368078539, 0.34783888826319076, 0.5546869168526891, -0.3308901397874702, -0.05247433524814878, -0.46351148855818747, 0.14466866799065065, -0.10363601758429743, 0.21208418165027573, -0.16614950304989715, -0.6284886501775434, -0.3138221560372757, 0.0431809673162487, -0.3811370631044622, -0.3488815452142935, -0.006133318768580949, -0.21365563580127936, -0.3154831408694134, 0.34630920639734647, -0.4040861813519484, -0.14147882023195685, -0.6339045321596466, 0.9666184977745105, -0.7223463143766932, -0.5371019963204798, 0.254656668227313, -0.5093491413574767, -0.022351123067744744, -0.8389263261022124, -0.9437730910454065, 0.43749244193547887, -0.5379635061027405, 0.1809557079372769, 1.0993480101860051, 1.1361666156588675, -0.4875416958860175, -0.3946499316059031, -0.005129022845763165, -0.626737594947229, 0.470127946870853, -0.3777957129324539, 0.18059931715220692, -0.06193675244757899, -0.2351340425165464, 0.7312485077107653, 0.751360894943998, -0.1052017625679832, 0.17055739750671298},
    {-0.14275042523525372, 0.7292325668409568, -0.23441435105234223, 0.9884926129563425, -0.8622399869831887, -0.3488903676055116, -0.07829413476226209, 0.6097146022643314, -0.3691783188446989, 0.05645165750959198, 1.0366992479791568, -0.20160141203258253, -0.4929401226874641, -0.3489490245575515, 0.2510729469380663, 0.0499205648468044, 0.9865890951735976, -0.20552241264975643, 0.10694791719108611, 0.41470326780306277, -0.14352054032803782, -0.17233509679235964, 0.33329989301098933, 0.34853398270195307, -0.4839084399545403, -0.08914657444153194, -0.07233757247271498, 0.13062888891023697, -0.1248405595100215, -0.6316624803873877, -0.3996875963077923, 0.14507386150019835, 0.5834049927004675, -0.6153709864417288, 0.4005740591011629, 0.6297240354718099, -0.008876438756350675, -0.760465431943249, -0.12476223789608924, 0.032787200592522624, -0.5972742156915436, 0.1220257297129971, -0.37874147202931446, 0.5094036593187148, -0.317901347680959, -0.32081219967132224, 0.688829045438663, -0.3486791181508198, 0.12953306467914497, 0.6152052158931394, -0.1991497242311515, -0.34888725354875316, 0.02434482481718981, -0.12601178292371362, 0.23163065880614353, 0.4882279028233486, 0.02533690143215381, 0.024282365871839, 0.41551656658566494, -0.36446208062460717, 0.2503767844078316, 0.5432734167199785, -0.21126614909755398, -0.154811513984511},
    {0.5471110780609142, 0.8093360339918584, 1.1644459248779926, 0.16523954487030013, -0.7461092645812613, -0.12368394907663535, 0.9956036062280504, 0.5934100964816122, -0.34084020254833625, 0.6825180297734279, 0.4482081239028907, 0.8934198411564747, -0.23369614558471613, 0.6397754129771785, 0.7473469296707567, 0.31417413309001435, 0.6566798930841571, 0.6153054794933099, 0.6830355201409489, 0.8185938995744898, 0.39284799373194296, 0.24765294095004753, 0.8272657929335937, -0.20742238212574265, 0.08602129158906333, -0.09525111137919215, -0.286584450592375, 0.8929590444637493, -0.28227581374667404, 0.015158010030384757, -0.6546491349327691, 0.9200233708548828, 0.8755113365635161, -0.7408572302990423, 0.6251073126691904, 0.05054494819080649, 0.4137052222087723, -0.3445595541405112, 0.9513337575276899, -0.07290278673135558, 0.8518337733936575, 0.809536207715111, -0.4493590218140125, 0.4861384125848779, -0.5670882458928413, -0.4840813897385079, 1.1056040541836987, -0.8994239539424648, 0.9744595896788365, 1.0018866134862061, 0.7338692517418063, 0.7672610094215179, 0.1838658289132017, 0.23053031205989363, 0.5425429170652724, 0.7600034259361884, 0.9270554344756627, 0.8814493431819549, 0.8573740845742444, -0.67825556331163, 0.7347225911681536, 0.8888397550407955, 0.2194115177771663, 0.27052291402539125},
    {-0.1603840766259016, 0.41738728668979475, 0.18459783118473022, -0.15469789905011705, -0.49555022443723723, -0.7882841097002217, 0.30182624117694606, -0.41844061742286415, -0.45403961218733474, 0.5711451248123889, 0.19174595724843185, -0.1756374867417151, -0.8086313901729949, 0.06535348420306046, 0.4523781397690451, -0.08955523511194949, 0.9392748414864438, -0.2369049623239313, 0.186070121460565, 0.32614714247282395, 0.03803622914984359, 0.159637369030672, 0.5452569717764033, -0.464412013767573, -0.19036787354140075, -0.46834057567816584, -0.6677158800590383, 0.6190533767374371, -0.19926426743108314, -0.42962639244737794, -0.8504777885727617, -0.06897790480153435, 1.0152365919160513, -0.9547041353264334, -0.06632116708303623, -0.15686416386296081, -0.28701679733152, -0.6786926637775746, 0.426388193772703, -0.31376866872547354, -0.014012817012918729, -0.04135072065572954, -0.8318311596680449, 0.3860657571708372, -0.5406167984314172, 0.30166822213721395, 0.6092361213212921, -0.7460562729298629, 0.19737619937901948, 0.6944838396401268, -0.10785767299687216, 0.0031898188504959233, 0.5713614684398622, -0.4903943690823141, 0.354341165848941, 0.40168028867332506, 0.4081939164249317, 0.06281603408402683, 0.39570318968437734, -0.7745495718485595, 0.5978946315542609, 0.7244656453698691, -0.7688115037350949, -0.32554951959711076},
    {0.08030929292061854, 0.7283217134553452, 0.5170677962039736, 0.28808463157949865, -0.24922277082291205, -0.8358253407762911, 0.4378553373350121, 0.031480402341374746, -0.8953857678301606, 0.36985762157633495, -0.2736865848320424, 0.2799419437382429, -0.8217544483423843, -0.7161243219356029, 0.7185043583562595, -0.011697365224161954, 0.8938340525106129, -0.5280780314148606, 0.8858052809453859, 0.1533983928158403, -0.26168828412799633, 0.08318390108378032, 0.6364818457129143, -0.6557926777490742, -0.28018777367314535, -0.28222164670666766, -0.2805776906235344, -0.007742721470683907, -0.0903711751177756, -0.35395819836030795, -1.2192947043794684, 0.3896466298825683, 0.4958643364593856, -0.5530790177139345, 0.11346929311683582, 0.448487755474221, -0.6233205133647395, -1.1014889234025593, 0.6088667774432851, -0.2559740482345017, -0.0453133043880308, -0.08547465183232111, -0.6900598020035695, 0.23624397714334866, -0.7510493930529657, -0.4367595637962414, 0.6034077807132765, -1.0532300189288852, 0.06420651229494824, 0.7724214618133697, 0.5722885046501439, 0.16758926852044795, -0.5668370286244132, -0.14056271886861674, -0.13580463884505747, 0.16547212063192138, 0.4446369372169073, 0.22504364438101246, 0.4424874280417065, -0.8670781049491871, 0.912835481709086, 0.9316907349639808, -0.5583277402479256, -0.024294627589806942},
    {-0.37951917657608114, 0.583832884642593, 0.08077602917911647, 0.24334150816445385, -0.058478747795696895, 0.2390704289284966, -0.23189903639184029, 0.3003738192731249, 0.24102503149459448, 0.6575253001067355, 0.18085309230898328, -0.6523121557515806, -0.09496040542369451, 0.012793602467183912, 0.6426107775964921, 0.5112902433366538, 0.7826016898659472, 0.16530629784950235, 0.20055813032070122, 0.3195788333113305, -0.4587215528497243, 0.6703722287132028, 0.09873399267888082, 0.429739033850135, 0.4513073793880715, -0.654717440926965, 0.16530955661279542, 0.5016885283789131, -0.4588641455966841, -0.3299919200825039, -0.07357602946612225, 0.3743801037383993, 0.9794789142881567, 0.03088427377351853, -0.37472063719292975, 0.5513026205921452, 0.1946248894405645, -0.45069154814080076, 0.4184878272349605, 0.005223411062946487, 0.33876827188231445, -0.10732127048387498, -0.2294895794842728, 0.5203080092013239, 0.05220888164929885, 0.278730718584645, 0.6420437037982967, -0.13555693330510676, 0.27389476772719473, 0.38765829272774555, 0.34523793973820943, 0.08878150049336858, 0.35403520985735737, 0.3318386578219549, 0.7671562852925365, -0.13058199871707296, 0.22266029354396538, 0.0782586536313042, 0.7385945545685957, -0.3210673625779668, 0.9229946062205951, 0.43362695322986594, 0.03751221970724268, -0.34165251830326615},
    {0.7983819365925975, 1.009663568947995, 0.8941467404117723, 0.4787344665668509, -1.0425046906850715, -0.2262940480658623, 0.6207057902148193, 0.713742263811031, -0.7456288277246126, 0.7227672033141799, 0.7635037585877732, 0.8274762491993026, -0.5613586800867966, 0.4593845252718418, 0.4501457686664105, 0.31838178967239683, 0.33954853826213066, 0.4861404855275171, 0.9739915068520418, 0.6098831646765148, 0.6644072638727089, -0.09689383696097366, 0.609190388765493, -0.4584110025201168, 0.34872355075803285, 0.18609844193517783, 0.09151157627252118, 0.8031040286077782, -0.2932105123297751, 0.1220237000993687, -0.23542152425080565, 1.0272373450973131, 0.7408734495752618, -0.9052463033327459, 0.655017601366698, -0.11851079270941266, 0.2605598934530769, -0.2691908495401893, 0.9204684507213172, -0.558993276069269, 0.4633870800539295, 0.3401486046527233, -0.12879109769946126, 0.2369955016379383, -0.8486071517801228, -0.6228700410814411, 0.9636114948638121, -0.7352856076997232, 0.4156872123973042, 1.2284005964281886, 0.5149679639484759, 0.6354975516579195, -0.10137899003594682, -0.13844553843150295, 0.19931235279587173, 0.4901296620727329, 0.5942502197943652, 0.9907098432594663, 0.6975680544752707, -0.8554066258221081, 1.11953688757751, 0.9943693842867459, 0.5401008300881491, 0.7129419050216159},
    {0.5413536607081942, 0.6983856377695884, 0.6228181040831832, 0.5837664159800633, -0.6885427658059581, 0.4914785176312105, 0.4291737796320741, 0.579724258437942, -0.25342045884811837, 0.602950568479248, 0.3789514972703918, 0.5412393370107693, -0.08653125049079997, 0.5416627203158388, 0.5605182222370284, 0.733154139740777, 0.4136719073088153, 0.5438314759281883, 0.9200290778688857, 0.24826739951976215, 0.07438357179913828, 0.4115357043545845, 0.4649111333065671, -0.249410974220865, 0.42819724136756476, 0.38741941822356535, 0.10475839189509979, 0.2602408812017388, 0.08907018978991417, 0.15009637242124693, 0.401885041847754, 0.7223868039613979, 0.541202722848789, 0.03435146410389574, 0.3695126336319626, -0.21766279852514772, 0.5111777384639679, 0.3065047891229873, 0.813919903583495, -0.5647174213902021, 0.49339060621704167, 0.23605734938565373, -0.11428670681600224, 0.13430220034500878, -0.8539242308528838, -0.498075136064318, 0.8003705420693509, -0.3768153336031925, 0.23035476924803702, 0.8207215099407131, 1.1516389857148674, 0.5330714706746632, -0.5766274550155569, 0.6718831417686357, 0.18888475342068967, 0.2507538123090558, -0.00993250576840944, 0.38585133656515475, 0.5649706876399765, -0.1982595167685579, 0.7557524636816652, 0.6333863258751149, 0.5832362078291228, 0.6508382502444718},
    {-0.6851901082131123, -0.9126108670665165, 0.5600864265897743, -0.7506563542109952, 0.14231609687174002, -1.025301906970053, 0.4331879007533274, -0.9266389903260818, -1.057378288448939, 0.44822656462019256, -1.032904438714086, 0.4673080315019309, -0.9360989469881019, -0.5455027012580299, 0.3376881117084332, -0.5836446301153242, 0.3980760931654643, -0.5332160897224961, 0.5355886892652998, -1.0766483417648984, 0.8965144826779213, 0.46018093244727915, -0.4665009240569409, -0.7600100938425517, -0.5102885201382843, -1.0884320694812422, -0.5763104481377583, -0.3146617755522378, 0.0625888212588358, -0.6133860569338726, -0.9791018398068124, 0.15085616970116378, -0.5877745106219406, -1.1314819052571732, 0.5769094031982512, -1.0466667207236557, -0.9091584765585581, -1.1262162027575187, 0.48660545410014333, -1.0024913129210338, 0.6436808265810409, -0.9659892018185581, -0.8661670915227134, -0.12293558032958314, -1.192732083089665, 0.11726558076384139, -0.5959983442662998, -1.1572830583614182, -0.4846625991451319, 0.053414628198780616, 0.42242602456106737, 0.6042708348267114, -0.9891537022039111, -0.47807722718957596, -0.5505209752898075, -0.8445581141519346, 0.4950101341448506, 0.3823644145966863, 0.25120586180816723, -1.0127515511073661, 0.1337393727690393, 0.6681418586063026, -0.47449270832423746, -0.5242369118849981},
    {-0.4816912496647073, -0.5098633939217374, 0.7592592082183963, -0.5932087224496656, -0.3975923984280742, -0.7001402914903962, 0.6280850714776599, -0.9082126550653618, -1.0613358907114583, -0.0973207029801878, -1.2788479766579044, 0.5266516587105222, -0.965106336138379, -0.28613114804645834, 0.1433073056921869, -0.7718529940121401, 0.21906726242180463, -0.04385139948049892, 0.06153967552720633, -0.816632257812347, 0.44229365121244274, 0.1778920113076742, -0.08407858354397359, -0.9664010329626627, -0.5063442278360144, -0.8842786910974133, -0.45074023675227254, -0.5552828073721833, -0.12312865848043873, -0.9070736008051261, -0.6732076051750895, 0.2648074214259436, -0.6570812166032868, -0.8694837502536169, 1.1732443802546855, -1.01779268669234, -0.8788643914799191, -0.7178454403396514, 0.6519679634873344, -0.573368110545425, 0.7859330226665473, 0.1310463913284503, -0.747352830843731, -0.2849572176488692, -1.152825137893397, 0.26578434510184196, -0.5508352358746146, -0.8804758147087093, 0.026346815534760353, 0.0202383498072393, 0.29975373478795575, 0.8284628201413125, -0.6498873765852142, -0.5303631013643471, -0.42009595657414006, -0.4572654300797493, 0.029158614950224423, 0.6805161684060219, -0.15478346307007132, -1.0510436744560867, 0.5039405329585117, 0.6427954414793702, -1.1450925760043287, -0.5289888184882247},
    {-0.3665113876849992, -0.8641507642907684, 0.41204648468979493, -0.885407322968106, 0.07713082388745067, -0.5745072688946635, 0.04931313258461295, -0.46618585895188414, -0.6122514080975056, 0.1581279516655387, -0.8696687193303176, 0.3328513268317366, -0.8083782369574829, -0.02075971157401016, 0.2482959863264158, -0.5821893487214412, 0.04119820124375357, 0.13168256300033324, -0.10494993757148988, -0.7957974198423553, 0.1928930207782586, -0.10214588737750632, -0.6628232749171263, -0.2748058079044423, -0.21764818683312237, -0.7367061940665605, -0.7753869326996496, 0.060005943810853085, 0.7328910514806692, -0.6039380394908063, -0.8087211613714409, 0.24631855331382352, -0.3144809933620161, -0.6190399586508644, 0.119876525422906, -0.7492962904032996, -0.4474800850797447, -0.6405651004691074, -0.009035125063245995, -0.9510659946717027, 0.15352853899389207, -0.6659093733412719, -0.8655542642294645, -0.0025034572928676934, -0.40953974613522093, 0.4587910698085993, -0.653922145747932, -0.6143215531128691, -0.5224816155283108, -0.22032519885611276, 0.319629579703114, 0.4207605290524641, -0.2043236686072181, -0.28549316124066754, -0.3716819242952027, -0.7487411332186492, -0.3239033745165224, 0.3077574951606758, -0.3892421220803734, -0.45611913084430894, 0.3463366276300159, 0.4635133811664566, -0.7020712476391615, -0.7860696638895911},
    {-0.2063238756851436, -1.0516283503045378, 0.5397898566277645, -0.6502391786329067, -0.07958586813867809, -0.7128167648678796, 0.37805466066372956, -0.47639940191313157, -0.968470708236647, 0.8152739448592202, -0.5588568147711824, 0.9981865848189144, -0.40886119356648903, -0.3423676002507118, 0.018458248735869567, -0.0751746246970625, 0.22124294845508627, 0.154417006081691, 0.022803300460211076, -0.4890896730273648, 0.7467001155278521, -0.012437235798019405, -0.4213123509821868, -0.5702655482151693, -0.7963451379470332, -0.7963122141235146, -0.45377432335748, -0.36398180814129, 0.7330100711502523, -0.3268448598319496, -0.568337615387567, -0.12529322589666417, 0.36236177085734717, -0.601689897580064, 0.7089694802043781, -0.6608847979120297, -0.6232990138455966, -0.1935332960199228, -0.1523627336601101, -0.9057971817494915, 0.3145817858207746, -0.6389254223367322, -0.6536106642499704, -0.2987553551026486, -0.24596024583601192, 1.0399648557889998, -0.5430286262438456, -0.4714828577761488, -0.5477852122502969, -0.15857932971718655, -0.2441806327808356, 0.36131139652340843, -0.6659580434306759, -0.6556144688676341, -0.7767159298576529, -0.017143697990221203, 0.2976072855782622, 0.24463209316821685, -0.353276115043201, -0.8135728509215813, 0.4991963195291218, 0.3820218360617676, -0.6414307878855201, -0.29902945364978895},
    {0.08873408780318948, -0.5988045664479991, 0.12502088866622765, -0.4744918858617165, 0.19672335953385586, -0.40057831986631537, 0.6196174944575367, -0.815567570373017, -0.8564041305337604, -0.043065610122178036, 0.0522948690328612, 0.41732687944466595, -0.8533225659339445, 0.27260644468069345, 0.603775900104512, -0.049275806807997126, 0.855709437746493, -0.18409620453860884, 0.5895481857889646, -0.00878528961198404, 0.467469584017258, 0.5453898552351399, -0.5867456097207624, -0.11622009039599994, 0.7126952834918285, -0.41964439130508063, 0.20979064138542675, -0.4098512825116853, 0.668583159058888, -0.40595005165795467, -0.5088491620049369, 0.5554500303473808, -0.16131931203422123, -0.6604509266442719, 0.3219136111306769, -0.48993847216797737, -0.5396923614716373, -0.26332573720518604, 0.5944907538364268, -0.2622696683505098, 0.1878418529491307, -0.39838427416281674, -0.5236130468510819, 0.0661739148517543, -0.9581692407175659, 0.7632041354854162, -0.5939772387961634, -0.41334490479103553, 0.12527416993040774, 0.46657707842077806, 0.2346011637590195, 0.36762215641987317, -0.04956710974215623, -0.14197046047882067, 0.34397499534002907, -0.09465305495807683, -0.18540556656351867, 0.830435307484129, -0.2531313601550042, -0.6939112121922961, 0.3088975450314132, 0.7046133698509554, -0.5216130954058232, -0.4934773889845421},
    {-0.309885762786713, -0.4153281310531829, 0.04456062685825074, -0.7724402129205518, -0.43091635237960657, -0.3758452216619734, 0.5289817735338395, -0.546199377021865, -0.39735715996059306, 0.22504109754017634, 0.1045489796886862, 0.5897111171062145, -0.5369412672022094, -0.2772502566778062, -0.06493061131175516, -0.26432772527988957, 0.9332380240348144, -0.2925435539782867, 0.14513005768947299, -0.6052310310676142, 0.49030625090088903, 0.22876216437555696, -0.301289075263462, -0.1634104819732271, -0.3133997715020948, -0.5601740849928432, 0.07073472678569798, -0.2901028631883188, 0.1006817335351353, -0.6522341591333949, -0.4705264221865306, -0.2555440767110965, 0.2163820962844919, -0.3116719598669693, 0.4852962243662949, 0.11172540897935389, -0.591305747553558, -0.3639789597892866, 0.4890153168555499, -0.46600223023415827, 0.209385172956084, -0.4247859603746004, -0.4189275096078565, 0.033686079842175004, -0.39142677337420284, 0.7018144168126048, -0.5049731353250418, -0.772632519374274, 0.10681659568198888, 0.06032482706603045, -0.18373098629520385, 0.5522709714304457, -0.3199155650726558, -0.564083073800985, 0.6866567199151974, -0.23693941109378958, -0.2078682768481421, 0.7097502784535012, -0.9270534622133638, -0.5188691314257667, 0.05223188259993375, 0.19532996496124239, -0.86661304197491, -0.6314012869962256},
    {0.025643932550838595, -0.8621325470320377, 0.2910981037459293, -0.4398665015426079, 0.27998619100880423, -0.7634105858528318, 0.14637458362733313, 0.09150772767253432, 0.09296969715390091, 0.5332231188482627, -0.5981196914557286, 0.22831882961099584, 0.017289854610447745, -0.9103399725902959, 0.17110234207722355, -0.18442470062906147, 0.18370530954288947, 0.08918162010625677, 0.24745390027638645, -0.7997944411723962, 0.3585807936631557, 0.6680051759495572, -0.22506097759680163, -0.39304094555079977, -0.20446805821831865, -0.6451657414348645, -0.27539283355503713, -0.2845571532303317, 0.9235516003664974, -0.7224422316692706, -0.3468036524339394, 0.2631008360120077, -0.228604279135366, -0.5486900661494535, 0.3973256928721659, -0.6811022858679631, 0.02122751426147239, 0.23055201472430906, -0.10060968078866683, -0.8561401498553178, 0.7404542053552938, -0.6187704149203043, -0.08048595534412127, 0.039168619489728565, -0.5863823779149866, 0.7853028466504914, -0.8578029611200593, -0.22103982296380545, 0.5620945199919944, 0.02459306660886984, 0.1614345048499006, 0.1822432574609806, -0.1091243947664225, -0.4204076237604102, -0.3285101383309155, 0.02013240076800267, -0.3410979147246597, 0.3447057654937215, -0.5999589135263746, -0.13628891464669074, 0.24423508096298988, 0.06260427730292059, -0.8199704774315438, -0.7248752887387977},
    {0.1350465840743063, -0.10696813493486815, 0.601608642637613, -0.031156796692401525, -0.2731164706895328, -0.4920615268854165, 0.44470027703224396, 0.03186003335266431, -0.6375890465829096, 0.1922454634332598, 0.13229096523470538, 0.9896414034296849, 0.08258801194774065, -0.2548417848296685, 0.16586042585753025, 0.1292388599644248, 0.8632749017329719, -0.32943717241692794, 0.547607092149289, 0.22080599470015308, 0.18180976355855183, -0.1252291357271933, -0.19289081759294158, -0.27386033767607165, 0.16857781828782797, -0.10236264998337943, 0.20065025361332145, 0.04214040502408058, 0.6200247882495759, -0.06879874426719365, -0.8299254994198781, 0.251192349613004, 0.37917509709777303, -0.7322573999039917, 0.3803710555074344, -0.35458577688559917, 0.3389710595683814, -0.41572347996476416, 0.6725000938300183, -0.38092267418015685, 0.6467847100269353, 0.22332782230448114, -0.058346002011699725, 0.47307904448892063, -0.5777874185303035, 0.15588037357003623, -0.2692227452623848, -0.49708066089204433, 0.28651288873163744, 0.4401841272814661, 0.5256188524836602, 0.28555725350318695, -0.07579481394732371, 0.1921299565380467, -0.41352200262083233, -0.3862581610345075, -0.15346925065520153, 0.14033178222204395, -0.44297786333952704, -0.4906052337735345, 0.2365221196675804, 0.2793488345755634, -0.3884541645411393, 0.16864457583643827},
    {0.1372636760911854, -0.158384263071428, 0.70449193178394, -0.7586227202902583, 0.008723544370815395, -0.39842646328159526, 0.5577066950612509, -0.16957642027526457, -0.7637303487360612, -0.09958408728105397, -0.21557977699854075, 0.1705121318310978, -0.30047085372024335, -0.29032292034902263, 0.36417690830340005, 0.13311577869708757, 0.342973059586806, -0.811523606335547, 0.17601170236746075, -0.50951587253064, 0.14583510682594067, 0.1456975498379547, -0.06777266341886481, -0.6302708490325156, 0.2784129849500524, -0.28588464033362143, -0.48225732087047424, -0.3052251744716726, -0.35376847906091996, -0.22187559275884722, -0.16885021100184816, 0.2257624754397004, -0.24906904695120746, -0.6536443803822127, 0.17490704104009838, -0.7209088857903595, 0.03908138026554732, -0.370613262669651, 0.5390741937088815, -0.5403628861970365, 0.5081741188474864, 0.6838818233573589, 0.12685537138562028, -0.8200559506856271, -0.6160556190374092, 0.16862254649582076, -0.36483742767545113, -0.7346070682000747, 0.30090999687766423, -0.3132021009412047, 0.45050444098233977, 0.7284184607617336, -0.16159689526749896, -0.1620225222537526, -0.6878387627475925, -0.3133753187159008, -0.13137231355777554, 0.47202212471972305, -0.03719795401101262, -0.8378700354647418, 0.35771166943984745, 0.7304047419399988, -0.13758470845133883, 0.34340488345582715},
    {-0.07717033313774013, -0.16677181083278156, 0.014413572805221646, -0.0008317675010951637, 0.668544383968328, -0.07288290081296651, -0.12430663445705487, -0.2120912416848031, -0.34418947646398235, -0.006110372791143278, -0.4456505783496057, 0.30138256861391827, -0.24240000355558905, -0.47795365586847693, -0.2120497443758107, 0.08613859325987823, -0.14053991138130592, -0.2667914675528529, -0.12645166475006514, -0.11816227795437688, 0.20663905860388218, -0.28279545424056274, 0.27888924952531213, 0.45282095212920737, 0.032727879593975225, -0.3420254610075506, -0.03604600838594572, -0.12103989364791558, 0.41797837249783804, -0.29961869120580614, -0.1386653212775908, 0.36359653317166113, 0.045627992730917354, 0.001224170322137311, -0.2599164000024627, -0.4288032306242946, -0.21824108040549986, -0.20279320163122702, 0.32625876642449514, -0.529126680258616, 0.3062538537600225, 0.3790674273397672, -0.130158150247151, 0.25971057802006214, -0.1776298407072174, -0.34633602069490266, 0.41390234264723397, -0.39713937589729814, 0.3617759015221303, -0.422044711420597, -0.06454014595859861, -0.04917926469081145, 0.19314938169448684, -0.26564614500034217, -0.16003349077745796, 0.28408056865767545, -0.26786794138596853, 0.0329864351415926, 0.1692865996307767, 0.05243372697907438, 0.31852781424561466, 0.19080600695439667, -0.4992455028256326, -0.08932040303177485},
    {-0.8224614063799969, -0.6026415343309054, 0.31872897921586757, -0.4292561106467831, 0.47431739525935696, 0.11969727807312316, 0.27029204242475824, -0.5472378503190838, -0.24934985686958594, -0.11054142539346275, -0.2656952459747158, 0.15333371309808252, -0.027079144114511268, 0.1104646559526851, -0.23357647136998216, -1.0009109802192249, -0.11460297254918518, -0.8403825748344809, -0.480144447306411, -0.10974481089714791, -0.2887192283394375, 0.1134623372339057, 0.3629030837619989, -0.39128265412940355, -0.08638260759781946, -0.20169402758309604, -0.4446163515578645, -0.194331243546736, -0.007602496606640539, -0.40621373615227524, -0.5890392109323613, 0.25960929233870916, -0.4483713072656719, -0.12201864877251077, -0.07360992415103629, -0.3063548058006569, -0.5153999312403175, -0.02855136883415591, -0.22116648444466255, -0.14647925110134963, 0.3851860327174214, -0.1424919724593821, -0.47654943491282103, 0.31866085063521893, -0.38381818219400504, -0.37628148854341226, -0.09213302899293607, -0.4738305616953691, -0.19757041300449338, -0.1373786772548941, -0.37756198835604277, 0.1579716761479689, 0.03311952579439599, -0.4109815416261618, -0.1886820688401794, -0.18423591165345152, -0.5528304114625173, -0.13283188623976977, -0.4926595875639323, -0.7568653302999342, 0.5291809881316089, -0.13327063374558487, -0.3208124967936741, -0.026861146713700924},
    {0.5897406760610017, -0.10259424785739044, -0.13174302214654965, 0.1377787010136711, 0.20916769218484277, -0.601219974683082, -0.5597502625636577, -0.21131447248420662, 0.08425956509965749, -0.5225579671030046, 0.0492302242453601, 0.012009356642754586, -0.1677267967428734, -0.33607136754171013, -0.627514165138313, -0.3660019762542787, -0.22324890560534125, -0.45084439999394504, 0.16931153869200355, -0.2764863057277153, 0.02763949483312591, 0.1272372251236485, -0.022328834202390846, 0.002085749581069875, -0.17879306584167518, -0.20373709133753024, -0.09700700863760789, 0.03684453525442083, 0.3568967036734143, -0.24293856037776715, -0.5806371159159861, -0.09868628487113294, 0.002106927687742676, 0.09637750128791887, -0.20564398706353904, 0.03788560718330524, -0.1788772030578057, -0.37425117858014956, -0.27692010475315293, -0.7479584702166334, -0.11878885236989312, 0.15826001087344288, -0.6475188128837784, 0.23711535225230934, 0.11936108660776125, 0.02258406360975929, -0.04309525264501865, -0.10037449934652934, -0.15488079289334095, 0.1324009006208677, -0.6603395811289912, -0.2952224755971879, 0.43506612284304025, -0.3297449377844994, -0.04504538123193397, -0.1481954256586905, -0.3818086163030586, 0.3551110130779175, -0.07288846627097481, 0.5815923914492014, 0.37155857559742156, 0.17219974641071537, -0.06945464002095197, -0.21446193937704894},
    {-0.0300439885931419, -0.32471698717645253, 0.46243032121431565, 0.3867216577511505, -0.4333261774880159, -0.17007791809232556, 0.8015098140788096, 0.4329772772255589, -0.35000062527223513, -0.37702468574310827, 0.4448728198257366, 0.4696959746475929, -0.027494419921484364, 0.2817482509838609, 0.07624569835554035, 0.09547490878462024, 0.33993020239273963, 0.5476781505768769, 0.31478217099118483, 0.624536629405956, 0.5805557250238366, -0.27791829839143745, 0.35977225732389995, 0.2995592320501031, -0.42647260062095915, 0.2701732011530867, -0.772642021761079, 0.3467234390467341, -0.05699184472245558, 0.3972270902996166, -0.8204934140253833, 0.14237329763022108, -0.034024637279591326, -0.6078088136120019, 0.6439830316613967, 0.18322273420976198, 0.6032337899359347, 0.1903822789647905, 0.10555690663272828, -0.09607741578754042, 0.5765326325093469, 0.39780045614459697, -0.1152169774220695, 0.2555807115286506, -0.6489934740136815, -0.5858672405015845, -0.6832586828404812, 0.14631408304016935, 0.2546659364133391, 0.46833790439426554, 0.06088961811717942, 0.4785299428849296, 0.15871819767253095, 0.5894562101501472, -0.7015995456383627, 0.24758118099461848, 0.4016317251059931, -0.16159654925603398, 0.1310984422729144, -0.782499087772016, 0.7916542065620861, 0.12275811346489358, 0.3502720298983847, 0.22979700199182684},
    {-0.3299635607787956, -0.10825625852844269, -0.6219430724994502, -0.4000733724338125, -0.2757051783019035, -0.34534797850456267, 0.6233560979409961, 0.09581828530401862, -0.43856295090474595, -0.4282597762218665, -0.3457960900373362, -0.7091495479149814, -0.10967265857085462, -0.17302202812318446, 0.029253197530359466, -0.41624192613826505, 0.17296067882720317, -0.5748059061616768, 0.2141575448766959, -0.057399473442902034, -0.27379194470835005, -0.16480080819106943, 0.1066373090972606, -0.22430771177475758, -0.24143882044738982, -0.46831763226666745, 0.6366457949820662, -0.2236459024931738, -0.09747303659471197, 0.007257402803226504, -0.1486130882149872, -0.1854105911101093, -0.2773423543089392, 0.05837318442442852, 0.28774378623603664, -0.21930540079461863, -0.4417650413063533, 0.0382193151271738, -0.21876108456826412, 0.14079317750814907, -0.3534051054725767, 0.15073873332728477, 0.1997675768207486, -0.6522931016498511, 0.41632653715073925, 0.4962894683395558, 0.3108825272969158, -0.609172288441217, -0.17200162399996047, -0.07972022078887796, -0.22492081101605507, -0.34467644948334836, 0.42706913803816154, -0.4097893444304084, 0.1980959736947459, 0.40793596515251895, -0.7908576558297178, 0.2759372763749541, 0.2920704977940643, 0.0863981127398316, 0.21826566894286956, -0.40410949900669485, -0.11002587619502538, -0.04495666655841117},
    {-0.3443783608146876, -0.28305702373776603, -0.013172632813287124, 0.35393206129539034, -0.3929150502426407, -0.012436842479579798, -0.15819886277741307, 0.10864331272578409, -0.09237802579364054, 0.28190883658714466, 0.22047257084857522, 0.18263473503133207, -0.027761818803074798, 0.6396557500209852, 0.15839076347410266, -0.11878518019700048, -0.6041963871257426, -0.00852668873532484, -0.051302732008462804, 0.43350514859411765, -0.45137722374221145, 0.294346430685797, -0.03003660546765573, 0.3040226834552388, -0.6502741493125547, 0.5771160594105992, -0.10173241412175718, -0.36218831477373875, 0.4437579482792765, 0.008095603565441369, 0.18726643310282293, -0.2805725361923702, -0.13709980931358007, -0.04330153108941689, 0.031945774512289984, -0.249096557923892, 0.25971280792535456, 0.12933620467521084, 0.019301573511823853, -0.4435254525340596, 0.40508661794329476, 0.13342048523228212, 0.3163579157996441, -0.558267365530173, 0.2031278713264159, -0.10954414366737607, -0.0334879952991952, -0.6222083088176811, 0.23402712252157284, 0.06553637132441777, -0.17673736591050315, -0.34101401190491176, 0.29249014763324593, -0.42168834143248435, 0.037625843606325614, -0.18050839011575906, -0.18936434763012275, -0.636195102301767, -0.29852633906635684, -0.1178907362464261, 0.33336007083636354, 0.11011083445450628, 0.5263287414910284, -0.1730064762708128},
    {0.14007915888015124, -0.17523195222382504, 0.08636863487734286, 0.489058011994538, -0.11100937731794436, -0.6191863501483669, -0.1124549102455535, 0.06945392721854637, -0.3821946317858905, -0.7443224360234711, -0.30096301952095345, -0.10620296347352326, -0.2909845568670241, 0.2559348595397422, -0.3030813671790053, -0.4020718807701423, 0.3964797633812006, 0.11663370762947459, -0.6148835267483396, 0.2910503844482759, 0.1018254130676102, -0.385852040344317, 0.2828890267636496, -0.40459328710665954, -0.10759580274228353, 0.45560398021440135, -0.6766367247246821, 0.35632655666284313, -0.24105788854782603, -0.12533134893394482, -0.07423685204825077, -0.45060121188302665, -0.0518711409648437, -0.6170629812926028, 0.5306922157996091, -0.7908430088969827, 0.38090092478353715, 0.22381515102856933, 0.3282988121973472, 0.25704837531258745, 0.22322903342937142, 0.3937256873839327, -0.1664367988648105, -0.4263471482314558, -0.0701041579525121, 0.565670785463275, 0.05004936469927092, -0.3058419833140673, -0.1055172346650353, 0.4498905708421457, -0.522653269879208, -0.17919722021416448, 0.4384690603231039, -0.5361318751122621, -0.15576300179659955, 0.28766153826142177, 0.2999438367897021, 0.2399025030689434, 0.234675657937814, -0.6257731309702248, 0.2367875208131875, 0.2054628843554947, 0.43028211716999815, 0.3991917105213686},
    {-0.011866445442896533, -0.2744312055131622, -0.21772873829824518, -0.22414119867134316, 0.13107188917280474, -0.234850059172441, -0.33110173581727975, -0.05907091284876271, -0.5657320543653948, 0.2283541522594958, -0.4237061922167864, 0.02170468994205566, -0.19936621094950266, 0.45592276395464754, -0.21395834504887373, 0.24750662815442745, -0.3722806064307442, 0.6570456467684825, -0.6302399133038449, 0.3626839487847309, -0.19415252311247577, -0.773647527509417, -0.6633263584761528, -0.3982912008539078, -0.06285133706987445, -0.036327915129488804, -0.05161850561848747, 0.33491777197697076, -0.034507390299145804, 0.14972096871318838, -0.14635008864663393, -0.11643604081150832, -0.2713907610622836, 0.2790886383467767, 0.184020184644808, -0.6225917991110321, 0.16604071528644998, -0.07232820268238635, -0.10146805022029336, -0.19384668086853057, -0.12499777887897827, -0.031371384622078446, 0.22311261415854006, -0.32001979104666145, 0.12515598578417475, -0.36431592561292747, -0.3847974738406689, -0.5565236345037505, -0.39648764196626674, -0.18093477894498813, 0.0026264941827826285, -0.7980975710140256, 0.7642745218386878, -0.34307162844354694, 0.18857084043655864, -0.19128030663103807, -0.224740013867074, -0.7363697103894323, -0.021304941993405907, -0.09506588042974416, 0.037083830432743645, 0.2738504694021867, -0.2730623848954065, 0.05848453836084657},
    {-0.3282386810322491, -0.5058272484036219, -0.08845524517910015, -0.9491665751197164, 0.20373498164636, -0.30638857994104046, -0.49291469818273265, -0.37976002462071967, -0.6291087211172638, -0.43038979376342834, -0.2769020159581509, -0.5484559339325732, -0.4696546966813587, 0.31163321832413887, 0.4479668220113149, 0.16188040696595127, -0.564004359241673, 0.2889716916276043, -0.38194534844821204, 0.10258988945308685, -0.31247544245220715, -0.2773129388764782, -0.835656208325941, 0.07001785371479202, 0.09406613198236026, -0.35192767374491524, -1.1885830600490401, -0.17964616894901345, -0.23656338885132705, -0.16847500700947415, 0.007160841968879501, -0.23163793678676223, 0.09823047975097131, 0.07454036082723449, -0.6703313793797089, -0.4470949886717661, -0.14744551316041618, -0.3985832985752476, 0.21920228095482316, -0.11134399034316378, -0.4485911740099944, -0.4646932329047111, -0.5635945883974802, -0.06107676764767517, -0.11314190971690558, -0.39189115799518187, -0.12468196692236631, 0.06798501788394407, -0.45010171607912974, -0.5470095681770168, -0.7743209959306322, -0.2114736302725049, 0.4665424776225119, -0.7733129471187014, 0.3514386729889194, -0.5171266768940002, -0.2798041256349064, -0.5710292744732801, -0.9534441801443088, -0.06860148069704772, 0.1364008259685198, -0.1938878604711914, -0.16359423838328838, 0.16160687962792333},
    {-0.07692903987750614, -0.648336042552512, 0.08838615957765189, -0.3421062769990089, 0.05820851253154876, -0.2557009226723581, -0.33050023406781437, 0.3793661891141204, -0.22101565771516815, -0.5629413694327453, -0.5107353494544391, -0.0981017590427425, 0.2513379590267654, 0.08953673452831472, -0.9333933372344093, 0.19165430976577205, -0.17585718861345692, -0.04634106033955833, -0.05683199824805063, -0.0869986630988698, -0.05884499400814566, -0.3844078310086023, -0.28144445263598283, -0.07043203645532957, -0.482611563794361, 0.20832989175605895, -0.6884524533463446, -0.37863319992822214, 0.03144851693621493, -0.3801504515977149, -0.10349397657380799, -0.0684820501963156, -0.24707319523771415, 0.5607761914106001, 0.1292139302073459, -0.6250285317902693, 0.052684404427445215, 0.19459396503340445, -0.01891338832752427, 0.27639282317506647, 0.0035809273106317445, -0.1289114064373673, -0.26501889451048927, -0.21155481247418906, 0.11381646151989429, 0.6973729831842214, 0.1457099917883647, -0.0977052153702498, -0.37351244052619464, -0.4227412476285394, -0.49105487752452714, 0.22387138301614865, 0.12900839979522255, -0.46757519406020204, 0.6263267853585474, 0.15235723320384092, -0.8879854752400107, 0.1845794346229101, -0.8657280407561934, -0.7749896287264362, -0.4115169726759331, -0.07972388386994188, 0.08545844178424378, 0.14862336875262155},
    {-0.4364340547062154, -0.22419797999342284, -0.5206928367905231, -0.17404926606672308, -0.1683202383065519, -0.5568436372071315, -0.6811465435260172, -0.22727634501493948, -0.16120141193469034, -0.2688589629849994, -0.3133176807090152, -0.4621368843321751, 0.045554704880049826, -0.537801195032671, -0.22297562156908515, -0.5598946609989276, 0.03034938828656372, 0.21530096024720205, -0.3771326342194486, -0.2128355235974191, -0.4053911278614695, -0.9392626498482259, -0.5323799972584377, -0.026615434398733692, -0.3794617443561677, -0.4916227009587532, -0.2972312290810969, -0.6565099342796721, -0.5770034863938505, -0.5931783430116596, 0.011424599590345634, -0.21492995026438275, -0.23436014592423757, 0.16261374722482225, -0.1751166131468844, -0.1290986118897389, -0.6741516002288507, -0.26809299603195086, -0.44513755371569974, 0.11822692520597904, -0.5794266930591899, 0.2637065803668118, -0.05275860261952546, 0.2731621136400984, -0.3669300311159013, 0.48731487335335016, -0.5943639408035499, 0.09222868722811393, 0.023268258014907346, -0.5537198021529645, -0.4920675334367304, 0.336102648105498, 0.20421391540215972, 0.13203841019773846, 0.43006044143349925, -0.5253947262254751, -0.54031709140696, -0.2380585698589167, -0.6805114508886787, -0.4967730307090644, -0.02206019266915455, -0.18924054827962275, -0.14645202188082562, 0.004530363610452105},
    {-0.688862011453382, -0.5639197332546133, -0.09223103056139913, -0.34489269326276795, -0.7474135449654097, -0.052310546840527015, -0.6073665124180634, -0.04427064705266308, 0.04227579815551416, -0.24082666250503307, -0.3710887031644974, 0.1429816735897181, -0.0011029224385661154, 0.2946977772567789, -0.32145797548385713, -0.1330666527060004, -0.6647844660078461, 0.13344039121890072, -0.4197670567508339, 0.242877667770459, -0.19471609425307046, -0.5976350655108847, -0.6189574518176673, 0.09570520015927926, 0.4311011754554182, -0.4509597143812265, -0.5858598509669652, 0.13367702994241956, -0.007214640095078108, 0.02924012402248899, -0.3741594190178283, -0.0742718049369826, -0.08449558458742977, -0.07618572178677449, 0.2488259232526144, -0.17716394043123473, -0.08764232159306919, -0.7675389050681675, -0.07520392844541535, -0.01934692731273169, -0.10710941831968362, -0.21484350023598214, -0.6598945269486458, 0.9201887161143618, -0.38476492023357256, 0.5203302206911025, -0.2941331743389191, -0.341537840130846, -0.31834872899097455, -0.2888775582512534, -0.8553068270697332, -0.03393104166539238, 0.5620602412135915, -0.08771966842368294, 0.23763385667533327, -0.5585260983099924, -0.15024707051192882, 0.09191832009245499, -0.27571576492952277, -0.1336820207874442, -0.143120304617317, 0.358501760866831, -0.5577887413704467, -0.7523789769686604},
    {-0.22999547758147745, 0.07396112273587256, -0.04452721197085214, -0.06321666193857313, 0.3490688731402365, -0.6454855844987963, 0.022515817276082564, -0.026343937910274704, -0.09683713035594432, -0.5155004192755479, 0.3818457545100898, 0.20052242801200046, -0.026541658335873783, -0.02175148146053416, -0.5718154478231336, -0.22364447907338256, 0.4309540085523547, 0.5901607899088938, 0.1424126827064978, -0.381333736058524, -0.308788292775194, -0.4717789576106985, -0.1778752398450594, -0.4901515116722137, -0.04694486859488457, -0.5748049550692889, -0.2934797384378879, 0.04360452140289435, -0.5627547444955788, -0.2901481529251883, 0.12757286501811793, 0.0478373589994631, 0.20673397998628595, 0.47589861478206663, 0.029574959199776617, -0.2653936301906777, -0.15290872523755622, 0.17434592857672865, -0.3861493714292077, 0.1625722569284177, 0.34839616760683906, 0.20714122514931593, -0.19504155567403533, -0.07029287782339047, 0.2423205441266585, 0.016028801202690825, 0.2771539417443604, 0.16293866335448343, 0.0759754455789992, -0.18873914491461774, -0.2371093016701663, 0.3061499019340748, 0.27457326626989853, 0.2512218359621905, 0.49505123287309233, -0.747185369483085, 0.012331604028473438, 0.21993272937729202, -0.519637981752491, -0.1386016678480677, 0.11559195168393864, -0.001843701947074001, -0.042968266195291566, 0.054786895839510914},
    {-0.157634771000669, -0.57803841998526, 0.20972467591770724, -0.1882642406673931, 0.31741475262583013, 0.07950596872698944, -0.4711166095654813, 0.07839913932682437, 0.12600051510173832, -0.23729724325858545, 0.05005050939857725, 0.71327233638459, -0.03455165942625912, -0.3065751411396097, -0.36837724151053564, -0.17748748606498232, 0.07337710326795206, 0.1090787237065169, -0.1107478251695524, 0.14746898265437203, -0.010886537963569042, 0.08159089604296021, -0.020787245128836604, -0.1063074018927362, -0.562099831921191, -0.16331692361750177, 0.47393110242798525, -0.4893684543201628, -0.1815740827973782, -0.31157092050008406, -0.44136978630627294, -0.4103255185487928, 0.09615645591325103, -0.09052079242434047, -0.031909188734229425, -0.18680616849420167, -0.36999949588869063, -0.011180790805990087, 0.3681008649929979, 0.5727529367150441, -0.16074944485448434, 0.09875453827014347, 0.25888468532742254, -0.04324441970153026, -0.24880114955455246, 0.20436198689428323, -0.1025849494419765, -0.5847921018264766, 0.470519080233375, 0.17927438414284833, -0.2591335394612751, 0.21436175519794987, 0.21042927282952703, 0.09229144470750601, 0.3558899240615635, -0.19293091154161893, -0.6085673572474838, 0.6150151102221191, -0.30527724105210724, -0.41336225608913274, 0.6426430081533083, 0.20666451960750745, -0.04106206990212077, -0.02360109918875663},
    {-0.2531047722878541, -0.14432064944985107, 0.09014743478359173, 0.035029459197204696, -0.5561480460527273, 0.09270633163054558, 0.1254103931284547, -0.1345736097495154, -0.03767297538831838, -0.4773450172009747, 0.1189398710928617, 0.7962980148148145, 0.036083721984756005, 0.019573454631405814, -0.14988748769445726, -0.20582836218101186, 0.09737670584475676, -0.05147287797330916, 0.07758448576851942, -0.23482369108527026, 0.17204232730812283, -0.36582940627105953, 0.5544139688367633, -0.03575744219195706, -0.5060631060924955, 0.20807599622764153, -0.29335006849900747, -0.8560544479381083, 0.0072823368938438405, 0.08804662721206857, -0.5782449639018321, -0.041775367833063924, -0.24093220761908618, -0.13955811700067403, 0.13529174146465694, -0.031955543555630454, 0.3905971243341331, 0.43796790382824785, 0.1726574391301575, -0.04356955851531311, 0.5833457786908197, 0.47650940109220175, -0.26584773626626484, 0.3945631934791558, -0.3637634686713378, -0.5832638989415652, 0.10138649602375267, -0.6081879098895457, 0.4173229260382824, 0.5546529150940241, -0.218399702164028, -0.7486247413552475, -0.09668499610532766, 0.3964154363997674, -0.5708451800792914, 0.5395041866958492, 0.18943808897278022, -0.45718801080955135, -0.6935666294360061, -0.5092459087985374, 0.6068346244689252, -0.05397460441550279, 0.22838792314851122, 0.4290876336591649},
    {-0.06628771110860325, 0.13648445152242364, 0.045384614146066767, -0.10141044853419398, -0.40445165543486966, 0.2008344450198819, -0.26791609726401333, 0.2336283197567995, -0.5369146200771487, -0.6571583987565623, -0.009070628905638633, 0.14246549875837178, 0.044373324784148856, 0.007311500383861325, -0.563107418765765, -0.45249587032364, 0.0671643757725517, 0.30087776004206734, -0.23493047150340488, -0.7665266553199714, 0.0029686461587383876, 0.013008227041015305, -0.6344692800454438, 0.042829704837305194, 0.025907440064740175, -0.17021670730365493, 0.008743607161004726, -0.30965959381296393, 0.44453830311253323, -0.13010261566589887, -0.14919417708127244, -0.6153412171400731, -0.8407472655126872, -0.24662254407943934, 0.5372476930370963, 0.004285903105461568, 0.52791540469325, 0.028604570037038896, 0.38274196840760666, -0.41997546353469645, -0.10096946073143122, 0.6397118517502113, 0.3242808368704777, 0.17472424516156249, -0.18385005492157191, 0.03226914097718779, -0.1382185246112396, 0.07510815092373742, 0.2533081948915015, 0.35608435726329657, 0.12203143503318936, -0.12999201590082998, -0.06952311243722138, -0.357512857467621, -0.2887702604052362, 0.5404228999555818, -0.22091252648286094, 0.29885086749959777, -0.029685381856556704, -0.7701197709398397, 0.27818507861225794, -0.3399020200855816, 0.1428380225130929, -0.43701127276598256},
    {-0.32589681014461747, 0.30680530011591006, -0.24042209360683306, -0.14477514183567697, -0.618935631394106, -0.20917686205254918, -0.31342711950055446, 0.4290152209699578, -0.5271912037021158, -0.07594642168964953, 0.24414626269824474, 0.10604167422779576, 0.09841302161243745, 0.5353889596303287, -0.24865382700829866, 0.410520830787531, -0.2012140881204794, 1.0248716961402013, -0.37808114287807026, 0.4040115003600381, -0.10361519514095886, 0.2985434123892758, 0.6211909344318328, -0.03210358620686869, 0.1034713416649515, 0.2672301328813449, 0.4362960089010526, 0.5443768403180753, -0.07917370420586384, 0.1520769079125897, 0.27226103393073914, -0.19261015942355914, 0.6181955777615606, 0.06907322273252689, -0.050408690364824156, -0.5922445739465724, -0.014796087619635731, -0.24174238915664167, 0.2216334959937299, 0.438192737103652, 0.15954488013484944, -0.12369760004240703, -0.0923421008991206, 0.11251865644017718, 0.11311516499311292, -0.01594634607927151, 0.11938924869811789, -0.3422632517140395, 0.0010160365236241483, 0.7562797581591149, -0.44276794788026896, 0.17949694926387824, 0.37528541077555794, 0.20683600369599886, -0.05299977993101708, 0.03792982466749666, 0.46193572548478334, -0.3646602644897636, 0.19779022299032342, 0.08884740010922831, 0.2140906678319755, 0.11325533612675977, 0.11991798967306454, 0.22583040793566045},
    {0.43321986199742424, 0.3827550085501577, 0.5360193044003886, -0.38198119945114084, -0.055555210301730336, -0.5302298560447882, 0.4497598182642968, 0.05835543968307565, -0.09210383649077333, 0.10313068066697469, 0.1034631736976278, 0.709990927392342, -0.4382793992963288, 0.44831889624302396, 0.17557919734572458, -0.6154041635868067, -0.10998637069953965, -0.2920396883862255, -0.33838748707972655, -0.11616345099041099, -0.020218638090906557, 0.3216246032421125, -0.44602036215675883, -0.3731867671794797, 0.09318527393387924, 0.3912663281360908, -0.6847703567822618, 0.4126994975797915, 0.5492406035659109, -0.09262822744246721, -0.3139493100642052, 0.3299567147669994, -0.40281702509747175, 0.3725971104395686, 0.0879691806426757, -0.28665838354520395, -0.5911111259212983, 0.08965165334583333, -0.28198992788755045, -0.4582136152357988, 0.4113959338135424, 0.044600511181546613, -0.5289681585570296, 0.7348001363079368, -0.1848286638620014, -0.19361600251721658, -0.4139479713136448, 0.006335865070617859, 0.10968094581316458, 0.46517720015132097, -0.41381192547484136, -0.19068238971707202, 0.007045801744245185, -0.7356117161720122, -0.29041863646476, -0.2523449735986461, -0.2664344176705103, 0.14670172713731017, 0.0989210907948783, -0.2560124543840613, 0.210191064279868, 0.26862388759932015, 0.22857312516001047, 0.38688410003564855},
    {-0.18782384818399936, 0.4693230990643093, -0.16246679542425851, 0.2423709213241485, -0.32912517952823594, 0.28701682286781344, -0.3103274353945011, -0.19995552071850456, -0.2752873068138437, 0.21335695641174857, -0.1659647526348436, 0.1919761053644287, -0.32609470872809065, 0.2050662450251102, 0.08701707080123534, -0.12267060910715735, -0.07044510959976612, -0.11852805312219387, 0.6811567967632001, 0.2648282779261583, -0.45378054122571393, 0.0601897330477978, 0.12120367046174937, -0.09611875939478033, 0.1469572927001771, -0.5449746075858651, 0.5037909773041935, -0.2047655244308148, -0.07069807107162897, 0.2551689509937921, -0.40718777498214165, 0.13054832932294821, -0.0003563405286704072, -0.09439484100127882, 0.36409240532609755, 0.05992055922998728, -0.22036841799229706, -0.31829413954669844, 0.4617199120292892, -0.5840497877823292, 0.4268451385058396, 0.27256948844678225, 0.19114841192767376, 0.18194387841541965, -0.26260498130183785, -0.21480876717269864, 0.7754033557837585, -0.1304126441923178, 0.33007997924760263, 0.4095442840022633, 0.6089470332053423, 0.37533003815174637, 0.0438633182355989, -0.2956877103296215, 0.009941197743498564, 0.031212620182015247, -0.06340756904414137, -0.16296424365288717, 0.08845565171854662, 0.3943240855485316, 0.5442311869851906, 0.2512874546351073, -0.24986375804519123, 0.9634925513936412},
    {0.08616891976121804, 0.5472016553166138, 0.14363602734681855, -0.4157776380971708, -0.13659274241115507, -0.197877194850037, 0.3315263194322871, 0.3166141643028137, -0.5025200437918342, 0.014520678072849838, 0.22461804597872792, 0.8342595195366289, 0.0008019557879634908, 0.6349175622782942, 0.03810135625953241, 0.2784491212580283, 0.4142121148434973, 0.30116052496560264, -0.14672109266280378, -0.19363961738136726, -0.07765235644589102, -0.8239842214865521, 0.25202284492748583, -0.2820835325344003, -0.024154804326458817, -0.3789360175409722, -0.04724944537178045, 0.1903513091986776, -0.24660161267174674, 0.35887501107953457, 0.004464759292371667, 0.9896893227333201, 0.3949368441640672, -0.279549594852833, 0.6357859870356757, -0.6116464201443178, -0.01254844759709922, -0.025602575229345767, 0.4958758983239178, 0.32482809106310145, 0.6183023996814812, 0.10621540905710357, 0.5948785363736094, -0.0491556100333783, -0.363904990055559, -0.5537765177838293, -0.46613082931751876, -0.4396298889551414, 0.6199588887605952, -0.018054980523097227, 0.24099097185612883, -0.40477333248616093, -0.16843969700321337, 0.017994844528686684, 0.0875589909330619, 0.1894309954390901, 0.026321839577977364, 0.06190465627526125, -0.29276550085407144, 0.20732436829303463, 0.1751517242676518, 0.652546259147328, -0.23615826144271365, 0.43353088092269354},
    {-0.0074407246953713466, -0.19064763817763355, 0.6477600931529564, 0.15385834624659508, -0.1263248782127489, -0.012041670931793334, 0.3726385436757174, 0.10977229273123207, -0.18049358144451752, -0.32811346499855654, -0.08538442703675365, 0.112096155872584, -0.3454668087748181, 0.7276724728512287, 0.36410913378566423, 0.3401970148276751, 0.23619363580184613, 0.2486355585222886, -0.3069979040220621, -0.2607885066115509, -0.46292470238109346, -0.18447027046163111, 0.07049894343367208, 0.23872963140955406, -0.4296992516263305, -0.02282229760828212, -0.2527629169863238, -0.09612674002200688, 0.09943935611571479, 0.030079968538852683, -0.07377613943858034, 0.2309367914051423, 0.27429488474950914, -0.6614154228306263, 0.3581252808851344, -0.25915776294846177, 0.270998128610434, 0.06600751088268489, 0.0802908955677626, -0.44671504561328046, 0.01684889076853203, 0.32178263987796657, 0.1543657069697271, 0.5837926533748246, 0.30262033037874736, -0.14840413184141293, -0.034039326686964896, -0.6407387987593608, 0.35854024898716225, 0.3313594759111135, -0.24279251181656214, 0.04118954797172602, -0.48178601560196954, -0.7004663270088013, 0.1969837134912309, 0.6241851211996168, 0.5958639883512973, -0.09475587721216165, 0.6342987410339102, -0.07725956629498118, 0.7414856106945237, 0.8921106859209402, -0.1497138748996817, 0.4177672860972401},
    {0.29833867066478825, 0.06448556801380916, -0.27131151381580787, 0.807118907325345, -0.31615263893695755, 0.38079216702093494, -0.08865588885823333, 0.3568222766059862, 0.7066259978368402, -0.2551713875125422, 0.1007815202046406, 0.15441271449594163, 0.6955028256674187, 0.0015715139465135534, 0.3984401140851637, 0.1848350360456313, -0.12637925161126773, 0.2520231745368566, -0.15260771141480384, 0.5126651950676697, 0.1226461573664453, -0.4249858114750262, 0.22108630209996386, 0.5225346980883279, 0.1399130196707241, 0.10260009515483985, 0.3406657997181073, 0.5843385368265068, 0.2477955022932284, -0.5465471258973432, 0.16464288277762407, 0.7872704217941426, 0.11222638922510524, -0.1224100838760455, 0.20861081661658942, -0.0272171091106627, 0.397734350033109, 0.47335948690540414, -0.0800188113757732, -0.6289538466392164, 0.27345694140761595, 0.39241240454364373, 0.29326661548389027, -0.12623990955589168, 0.5935315090205397, 0.2859055309759794, -0.14642939714056566, 0.11910983870867846, 0.10157739449244646, 0.06901054361648737, -0.23451195647216513, -0.13397069942850603, -0.1802366131959536, -0.3656539345347512, -0.37861757307434546, 0.26761465884548513, -0.43937365109596693, -0.00496003309894649, -0.24954915102077155, 0.03663919364951478, -0.32892495559185414, -0.2964695770887646, 0.011038009707839278, -0.7280104255127503},
    {-0.5393661576211967, -0.2889871265837568, -0.2887432284326978, -0.22488034409683197, -0.022018200451346524, 0.053959532797827336, 0.07723676391786603, -0.2955482465252764, 0.00283509562672607, 0.47525800213750846, 0.23038942326699152, -0.5146867371155899, -0.005242438094586097, 0.46691606314313544, -0.21492646510191987, -0.3566876089044971, 0.18694459690699153, 0.41811000301354173, 0.03655166471614519, 0.26326816928448626, 0.14883201697381523, -0.018054304405276167, 0.0006615109265453988, 0.08610088125631139, -0.480977683604697, -0.6164809732737744, -0.533265096283042, -1.033442993454523, 0.46860848575576025, -0.49477531973734135, -0.038922250381447, 0.4913578314906795, 0.3622046930483126, 0.044053290300620135, 0.357627946591737, 0.09631269317013694, -0.4211493336905897, 0.03706382094888986, -0.18855589313431179, 0.30830590608986097, 0.3732210813060478, 0.13126195346208333, 0.25551301148573763, 0.2783303070791836, 0.1938512882791027, -0.29954724226707574, -0.28268253543861893, 0.1791074612556501, -0.02795377938264617, -0.34027259827457923, -0.0839488387115377, -0.24604766999101402, -0.028916456652341566, 0.08882649977516784, -0.04763024374433543, -0.10708024237348786, 0.09782589732673427, 0.02970656012621094, 0.15454290955950922, 0.2954537768743997, 0.1991316846989461, 0.31558045731040424, -0.15753835875762165, 0.03670616672727491},
    {-0.021790821810864083, 0.20556994524464178, -0.3852168526131971, -0.3581297637091272, 0.03840438965573575, -0.042587093281541755, 0.010224627966752968, -0.34750063919008145, -0.2339025661305649, 0.1172546015931665, 0.018800563369694698, 0.10958367028547217, -0.15612334171700587, -0.023291405071915964, -0.3013655762975317, -0.3070558216612802, 0.13993381066365967, -0.2255528447176989, 0.052139184499403905, -0.23730494277736855, -0.2214303654202141, 0.7350774990505711, -0.5493613297890443, -0.16052738408886438, -0.1520897289054785, -0.2751971543122989, -0.281504726998344, -0.6764185037527285, 0.5590384233364083, -0.050322364557617995, 0.27001083208821913, 0.6013453876088992, 0.13941612318443425, 0.19069211039695386, 0.1187835860880447, -0.44367859877568133, 0.18406644114669768, 0.09490050487128814, 0.2974284279528668, -0.2197570061049078, -0.5058157758146802, 0.08433179895635225, 0.21823745740655992, -0.14795206961076837, 0.15898785274525948, 0.10365727841194396, 0.09157838134669032, 0.1409468814298378, -0.4515228726607272, 0.10230637133000454, 0.06344931945209054, -0.35662142778874395, -0.03968713470327516, 0.15579817056974643, -0.6603712443560521, 0.19798805082548152, -0.4870334618555381, 0.003342155649452156, 0.11622979459548698, 0.3720278218965678, 0.1996547739130684, 0.07614565965427737, -0.18380730119510658, 0.2449460291617047},
    {0.4690848633525363, 0.2205163691129063, 0.46524910801985847, -0.4878842097293724, -0.518105297625951, -0.14379514560342108, 0.25562780490702425, -0.4215857985367426, 0.09658064346462637, -0.30480065223355385, 0.16415638933572832, 0.45353294526051424, -0.456754275529186, -0.43503429406661864, -0.09321701011637001, -0.10581080373944482, 0.32807907478755904, -0.2144818179414824, -0.1350743044322728, 0.18133286520413014, 0.041774760050892513, 0.6003978097224247, -0.16273507187198447, -0.3213160883402837, 0.5092050798108905, 0.10578779169814971, 0.11501274032688477, 0.03994126293530436, 0.3857286704924406, -0.0669774529842039, 0.2000409076802089, -0.6561449055563703, -0.23213063473475623, 0.24454626906283589, 0.10307152291946892, 0.11611465699625666, 0.1308140355508111, -0.38322207369665273, 0.08961961073543699, 0.2694412456839034, 0.16026959078765718, -0.34196065762975564, 0.03823627244681716, 0.5809543817479671, -0.32942291904778653, 0.27927620198644887, -0.017297724976411962, -0.5530702593221386, -0.25233508319523973, -0.4083975324852325, 0.5883430348994327, -0.10527251864180807, 0.35689312390032213, -0.3251009983610969, 0.020121021166983548, -0.23993279562527167, 0.4801591056465211, -0.31992571029617084, 0.0437425598203419, -0.3188344833338002, -0.19684271497108746, 0.05212960404915381, 0.14652758502955446, 0.2634817544872914},
    {-0.08862743769832578, -0.2764560696481065, -0.015619361972605886, -0.025904843123433257, 0.5570451120845937, -0.32272447623762796, 0.09455619970460458, 0.629446181980909, 0.54933961783438, 0.24996015258553908, 0.01733565753718743, -0.045235918804471066, -0.11968380912870973, 0.22723303768306355, -0.2757337437034638, 0.02378229986368441, 0.35693940459210177, -0.11070349814999804, 0.06717699687304346, 0.5205763676248191, -0.10840053446268276, 0.4608564441997167, 0.546444364548906, 0.21727539568350218, 0.3145359341679491, -0.06144526098749793, -0.10874943561788056, -0.46745955373129916, -0.3175369233697901, 0.24354107675313777, -0.5597048165383036, -0.16956124779654372, -0.09644369798995711, 0.38094667232901464, -0.3033271297725571, 0.0135332212619232, -0.14845844081893012, -0.17699420229582916, -0.31043388879511014, -0.2218892208666653, -0.1375134369771696, 0.04175028502965217, -0.15711425030304738, 0.2901679111679619, -0.2548396608289352, -0.397394324933954, 0.27490600641665974, -0.14235817141311974, 0.15478043263400004, -0.2816993783100096, 0.6160416101695531, 0.487505490120421, 0.026707405516999374, -0.1444767871507401, 0.11681754747073762, 0.040695934485084816, 0.5275918539763723, -0.05944431367674915, -0.17419810011113487, -0.1995662825540182, 0.09736306335541453, -0.060922708010688255, 0.010306923439941095, -0.19305241385270566},
    {-0.18752729423466355, -0.0324227552561869, -0.043532487439158336, 0.39435124086725526, -0.12401006891848677, -0.286068599856036, -0.13351779014364978, 0.4732913632746747, -0.08196020268233051, 0.1455313191164316, -0.03192755541904723, 0.396619021034759, 0.1727927686836412, -0.3623372341253494, 0.28442405881354366, 0.3445235518733399, 0.2954225399665568, -0.009696850215727495, -0.22113669066742786, -0.26804046869461307, -0.008362193683055524, 0.43932506757046796, 0.9656405008720029, 0.011176272469625013, -0.18420102685843315, 0.11140942612269969, 0.16945827346647113, 0.3811011333260158, -0.5221536660934643, 0.17175334688311392, -0.2767356926516442, 0.37824076282541047, 0.44306943187437436, -0.13688140534813734, -0.31243826552247633, 0.5914644637142898, 0.10320363060628654, -0.1252241310072905, -0.21799742172149178, -0.001600637774411789, -0.06036005774180344, -0.13068536687082463, -0.23321359567458363, -0.17849920457569668, -0.01763835651500297, -0.5582925784507203, 0.6481997151758263, 0.2343223103490707, 0.1908192814929851, 0.09273210428592282, -0.4543679168185695, 0.684366497609241, -0.0037548999397516197, 0.6421493457478519, 0.21599353624255888, 0.44290468861409693, 0.6517733294080053, -0.1862084891076648, -0.19490288366736647, 0.32737798745025676, 0.613457133408447, 0.01935682088255282, 0.36702644978938037, 0.24604016977229554},
    {0.19601811877046987, 0.42406479546316345, -0.033353906776254105, 0.418788547439849, -0.12099894394181498, -0.056045475534057726, -0.2370947220365064, -0.562464447436662, -0.21471582931759692, -0.08778665796582079, -0.26614254255849906, -0.28044334927497727, -0.5026830825907131, -0.05087775355267747, 0.1022228627790753, 0.38392551490259014, 0.507811580244303, 0.20437242682491139, -0.05444205341818501, -0.34561105862200986, -0.23701572133108256, -0.2885608335760263, -0.3324160348623805, 0.002393099428554427, -0.42689613065122795, 0.2960334263672567, 0.40522045532439893, 0.6064663257770635, -0.5585495925257632, 0.03009284256692678, -0.2634475631701419, 0.24773757990186027, -0.36065386279129963, -0.310165327257443, -0.19577946173553987, 0.02848281250640794, 0.46546504571630154, 0.12658735620415104, -0.0650982359928615, 0.663840187474253, 0.8454336472876812, -0.0053594286072973394, 0.09566607562336833, -0.13301616497748087, -0.16969367680686548, 0.015063569257737462, 0.5100314301237476, 0.12832088046036513, -0.10233671468218376, 0.33269249907860604, -0.2975405914210578, 0.31209617689085484, -0.28501488042206874, 0.18138033507992987, 0.22656455552108792, -0.0829684918408029, 0.6852865376384072, 0.22820607129522777, 0.06143857310809137, 0.23560332390578703, 0.25502480989721704, -0.08093073768653503, 0.008664435513617964, -0.20474779429521311},
    {-0.09884362977372094, 0.023255902682744026, -0.3259293462624018, 0.191059664019573, -0.0162612676627211, -0.2897239040181998, -0.48293592868702867, -0.01151343455305633, -0.6093846100478879, -0.05356681049330879, -0.5141218668077385, -0.5719157284114457, -0.39499606422018463, -0.5657270997343288, -0.16355968431449486, 0.24001534103153407, -0.41982238594865684, 0.6318868238373783, 0.039572713530781664, 0.08073186674685687, -0.4494372667416999, -0.13767493182554807, -0.560922814631504, -0.188154401536441, 0.3115913575109073, -0.5980263399447353, -0.2512980198892763, 0.4476397832411018, 0.15056195330835312, -0.2048469408183806, -0.5418393424612257, 0.2808006534554051, -0.5489978096851883, 0.05314250066152248, -0.6348171890122868, 0.08863386983070742, 0.08088359776492923, -0.0015451923898396433, -0.1908175240294348, 0.23225194237639366, 0.4415916387594876, -0.014392373858389762, -0.04536447065728161, -0.2946549186534088, -0.6463415375874142, 0.30704700606113533, 0.17757137654590635, 0.2500145743634161, 0.10640151100375221, -0.3521490391917023, -0.21346503689014218, -0.33362779321165914, -0.285667392902526, 0.22049563597619082, -0.2152697529419183, -0.6329541824393421, -0.6021666635967508, -0.09393311862633477, 0.4490045725577471, -0.39932532525326064, -0.542078004514239, 0.10980380885385652, -0.15703186942109565, -0.6651845547687485},
    {0.08219635950477114, 0.1879839112399206, 0.20790931089315165, 0.008569530236465221, 0.48953821562219313, 0.15021319389243337, 0.22534661746634746, 0.31377326211329937, -0.20017312499123904, -0.04352713175086468, -0.2840967591192346, -0.007709662352953927, 0.24225349945405222, -0.18956166404612812, 0.09661170016624578, 0.045439617069224794, -0.3447341103172656, 0.2890676248539793, 0.24257145736953473, 0.48865931616541164, -0.06408979102491337, -0.011791498039293673, -0.2258371534230318, 0.033749633402261295, 0.5505462137471259, -0.13135050148231175, 0.08972347578367093, 0.35560228052933607, -0.363014105537854, 0.04145847185327541, -0.22216657444801208, -0.2117422779240395, -0.4176528442007521, 0.2778747455276111, -0.3003960260049448, 0.40375346657608013, 0.18439492478293032, -0.04959403680585105, 0.23192066026574829, -0.17570302720916953, -0.059724864328497045, -0.3609981882280006, -0.050721753197612775, 0.1579857903190488, -0.1090664007653602, 0.14623987952462142, -0.5259546752275989, -0.039126548688884405, 0.524213236698125, 0.4758532703637065, -0.09523357850729834, 0.05589682992503905, 0.10600945307671077, -0.10192791989030962, 0.13669917231027795, -0.37257657726877863, -0.4393578925273989, 0.24532274853658775, -0.10408873979189688, -0.35486063797196954, 0.06077231798500646, 0.304317537225208, -0.7203274427912997, -0.5975591665644656},
    {-0.313104058620187, 0.13839190546451607, -0.15113257227539892, -0.25386546316101244, 0.08515704517345958, 0.01985112698777132, 0.013853653575984988, -0.19624470077041825, 0.24672708891556766, 0.5204172903739125, 0.19723672552731109, 0.2257201524768152, 0.38917213443199833, -0.09020607352983585, -0.19910395720721666, -0.37588287961439637, 0.28164076649637093, 0.2438479555367705, 0.695277700058876, 0.7732969248192216, 0.2221597348212949, 0.38912829054580034, 0.4818129028872954, -0.14270782203696647, 0.11362852944172058, 0.40220444248891446, 0.25603972279801174, -0.44165550520340213, -0.24197630168869713, 0.08760325840089533, 0.2616602262531981, 0.18528774645310386, 0.4938162360132205, 0.4744019915425806, 0.0003919808469705627, 0.3992361520974104, -0.0764382036161047, -0.22310611463136706, -0.11418437308217604, -0.028487850410361993, -0.5158659967089961, -0.13428891484535782, -0.4557364508081288, 0.5509280857746934, 0.33002869080100294, -0.4127024592379345, -0.18649930793070663, 0.2485419312294486, 0.25321710508352874, 0.26550206102005053, -0.36496488720181686, 0.01888220614407007, 0.6446350079662172, 0.8674420847074694, -0.5052528667524327, 0.4277103812588454, 0.20948853147857896, -0.3346423348779723, -0.24627316345129507, 0.38566738383162597, 0.24800952289460906, -0.6010447707674826, -0.13392082210765782, -0.030998399339585585},
    {-0.2290588704815122, -0.664879272140933, -0.10059036072802849, -0.3172922058255652, -0.0016569914981386514, 0.1109388284946939, -0.1393101327992318, 0.17771019576431482, 0.20636186911310184, -0.14410624069747033, -0.20882407668146405, -0.24110620441524297, -0.3874048919215581, -0.12020457857200283, 0.05123903520700197, -0.14400304121498503, -0.02904432672450373, -0.39997334274407276, 0.06834696074557857, 0.05577252354971887, 0.3482430162651089, -0.37767176860981494, -0.06927949549193342, -0.5015531687819664, -0.07522084480010878, -0.31221280180344796, -0.1621393544864334, -0.12402226134801835, -0.1832573701393617, 0.35764784682492023, 0.013153435385719192, 0.1098721445515385, 0.718139950505667, -0.043238854383800804, 0.4756376681484899, -0.03650906650972729, -0.2063842924794214, 0.3505072198783471, -0.555859766233, 0.001474531736988462, -0.26986102239581916, 0.10501156888746535, -0.33154605204848575, 0.5881066623599195, 0.1280489811734016, 0.18664765894545193, 0.24019500413173037, 0.24421722696839995, 0.05791889802989888, 0.006710131877753223, 0.05838109298753234, -0.13247269423783095, -0.09231734702894376, -0.010032876652009713, -0.024870210265153216, 0.0999076795524255, -0.2203883726578293, -0.16539463567444776, -0.38953102623590413, -0.10208154635335455, -0.3639055834702522, -0.5178049138745799, -0.04434137798004974, 0.00882916788251239},
    {-0.4417956332749971, 0.10414644905336144, -0.4731337760343988, 0.3913367109659845, -0.11177318365569082, -0.0905451312913034, -0.3103629137703399, 0.06217422155620498, 0.2013834565496544, 0.2084973203202273, 0.19870031111988504, 0.5915030146001674, -0.41972967033829794, 0.15576592067673292, -0.04473501502691403, 0.4499880739968036, 0.19928421420921527, 0.4482775290623278, -0.6394971040681195, -0.3350434484382524, 0.23398400142778056, -0.36202928279901553, -0.23159980322988058, 0.6874424456897141, 0.00938681865591752, -0.06917684044680675, -0.08550764082925073, 0.30495439022549053, 0.07504799965381648, 0.5639878862867073, 0.025436022372042642, 0.31874759394754365, 0.3120410009857701, 0.020570152167941162, 0.2653023264963923, 0.4865188345574094, 0.2047199537072085, 0.6933910904667745, 0.0048852994252702835, 0.5095080798685423, 0.08409692752878213, -0.035873858476771846, -0.08486828253261865, 0.20554737331278364, 0.22091011762751442, -0.03770897471520753, 0.37114031076288584, -0.054397051051219183, 0.021531753789572727, -0.33863919813025606, -0.16146625421436653, 0.4702698345922648, -0.35118716344551937, -0.48997731926693255, 0.09908428694932003, 0.1605494692648134, 0.3161643964400704, 0.09732446993946767, 0.20872134631865633, -0.1823293527764415, 0.2837228995913747, 0.3165234767647341, 0.25904702673800906, 0.004187517727335213},
    {-0.4267395281562498, 0.5143451511492707, -0.08854681247310146, 0.1103808855708758, 0.30691837452745285, -0.48537167573393536, -0.14443387421653073, -0.34330333234268073, 0.2078736128319314, 0.5640500286838254, 0.0905994699536855, -0.07784978785346536, -0.11838636352722055, 0.23403728160389006, 0.17977760536021875, 0.37943057345262393, -0.3816875992499484, 0.23999575656717365, 0.36642243229176796, -0.1492254803294066, -0.02160248794630364, 0.22647477611854053, -0.231647270153347, 0.09638123940309692, -0.20384167079260362, -0.06567529828573485, 0.08875257907678036, -0.3947166083142426, 0.18086036245512205, 0.19313181611946612, -0.10689302675882642, 0.49870570692381055, 0.1578744092623792, -0.27998509433921837, 0.14956606176121173, -0.004238049673369962, 0.02035630852719457, -0.4943573199591547, 0.03976038614529107, 0.566344423624242, -0.08121733267082445, 0.26894942076036543, 0.30843615230023186, -0.6233893866852165, -0.30272328098207146, 0.12429124830660629, -0.25244220210147406, 0.019479874144335947, 0.7394877778546326, -0.1890970546257774, 0.19997208443809736, -0.1160140045074387, -0.3068030385683272, 0.16201601305972577, 0.012950210909109885, 0.051482775973828915, -0.08757457707467237, -0.013703348133683676, -0.33323693294669626, -0.3424895893931264, -0.2305522959072523, 0.42376142070525225, 0.07925893833631681, -0.11492195761302652},
    {-0.16076885109231046, -0.4637350396704902, 0.32175941125593654, -0.16209167312615447, 0.2873776524170105, -0.5032276128206175, 0.34550589559544487, -0.04871800407724045, -0.1924312674717687, -0.314549429615567, 0.14969711953733847, -0.507750767260126, -0.3772573201122684, -0.04982205051155629, -0.12938206966003657, 0.09801800959219657, -0.26619326888247113, -0.2915294269830436, 0.5480596849740776, -0.11031781619856797, -0.20411318938250478, 0.3871161697444563, 0.13284414703767014, -0.4943011921355614, -0.2711193798550856, 0.07892971697846744, 0.3248791068201628, -0.15018385551739188, 0.5066290570722465, -0.11460161827713806, -0.12552453373939818, 0.35681674799408264, -0.09913302722919466, 0.17694254757068886, 0.11764452888721245, -0.0744090454523024, -0.2735557671244834, -0.5827258419005648, 0.2470063688397442, -0.12822192047303613, 0.05723892136381722, -0.12492990674300107, 0.2998830855369077, -0.44516720405127097, -0.21337845542417672, 0.8227252708019414, -0.09128128041422064, 0.1169662150251817, -0.08846788092835033, 0.15024812718183664, 0.5420472338148756, -0.14956247716919496, 0.09680470327730573, 0.019544443634765696, 0.2813961599500805, 0.07578458713867847, -0.4448120691914618, -0.2861771443104785, -0.15262405807094112, -0.3076258417372501, 0.4526399411895866, 0.2994393475108063, 0.059720528062460566, -0.21213078711283934},
    {0.263689497701331, -0.5087513673592315, 0.33443589448989974, 0.2084570449703443, -0.010356255138887495, 0.33257101724971017, 0.6513820557460198, -0.11470178903627067, -0.48412845385829223, -0.5635457163466518, 0.20855494196939164, 0.03395523383246743, 0.1994322548968985, 0.20439634513825333, -0.1676228533985743, -0.0947990724272368, 0.00721722760796772, 0.232863252343303, -0.2204162874529019, 0.2559294798256918, 0.09389542256201044, -0.6655112087818708, -0.048760713116313116, -0.14504858588431022, 0.22702265286271356, 0.3118174378368049, -0.029608145341577116, 0.6201857210256629, 0.027212609676264477, -0.017482397571373185, 0.2779089683122563, -0.5436057401798855, 0.12138741257769725, 0.15142567177658106, -0.08653866227624261, -0.23876302043044678, 0.2951761355063799, -0.10384802181983421, 0.15670841090710808, -0.1602191728564603, 0.4940382753288582, 0.05177002221835698, -0.09238402541340285, 0.0023529326094348887, 0.022320940205365, 0.19190426148114817, -0.09019488105121609, -0.2033417593037834, -0.2844238503235252, 0.07671987092863966, -0.2237172405417554, 0.19545313912453177, 0.37499489317663964, 0.11726039658162729, 0.14908273887556842, 0.02118781953572876, -0.19564109197820603, 0.14734040841024637, 0.2560802210776412, -0.16726282893101194, 0.2181448895447987, -0.42048143331340637, -0.13206240434069463, -0.013724804149662225},
    {-0.22505533278585566, -0.018104023299194395, -0.36225845414044566, 0.021209380762508376, 0.164932988483966, -0.20215015894645566, 0.007256768541125909, 0.1441763487976792, 0.1040153233701733, -0.4164010480391013, -0.007776150439061382, -0.12469736713256215, 0.23217114822565738, 0.18919898130928123, 0.2063865901424991, -0.1467953834133301, 0.10019194328672466, 0.2324639812770593, -0.017341893218165066, -0.443438477959857, -0.16876738099418476, 0.40066181665901407, -0.1570493908778655, -0.028488443671625625, -0.05072870265923281, -0.005794457427412714, -0.1057965341018833, 0.1513305150238956, -0.04192033822501934, -0.05901623924801525, 0.19939999930553817, -0.4226428456419043, -0.5579843506571408, 0.3862560044858644, -0.19837610250483775, 0.18760060448296398, 0.19370058078907304, -0.5923527334480895, -0.170244794944745, 0.0010874493442788386, 0.31580600111461393, 0.004560723920380219, -0.32644360393551153, 0.023873388158887343, -0.06760693138744887, 0.060942309924418, 0.0005886837251154222, 0.4834223290444522, 0.2876788789328046, -0.06183579030857765, -0.260555571108101, -0.364539185648557, 0.6559905656390883, 0.2566649321412458, 0.21761583731800377, -0.02987380515707866, 0.1978104546139492, 0.43172358551307244, 0.054613541207703044, 0.13822896549905989, 0.1745450391696376, -0.13008921159870526, -0.24637087750334055, -0.1703097935927589},
    {0.34116182723708965, 0.21895645772914205, -0.014257308018907096, 0.8227855502443135, 0.4032025955650918, 0.6661549202800517, -0.1961901934674374, 0.3578936437316514, 0.4378535308082628, 0.30606317356679846, 0.11652574649952652, -0.2634857064790366, 0.21381298605599425, 0.5038248007431158, 0.4005410311551838, 0.46011176399356163, -0.1674326539672846, 0.20163564691259228, 0.014251659543708642, -0.11248102546131895, 0.19888979921834296, 0.9856156289568933, 0.04694936203576629, -0.49330253556184334, -0.24652976322739698, 0.23248660188656536, 0.12160076924975105, 0.15327361088165944, 0.1424185248584742, 0.32057681883275824, -0.16624118757798242, -0.5474518671550764, 0.25721477694183215, -0.3682418539730244, -0.10316755159138731, 0.09854745718068564, -0.14115993583876707, 0.035161196659299135, 0.023490652661710153, -0.21519389032855035, -0.3445536117265934, -0.13466550605554703, -0.18707333982377494, 0.5377503842141711, -0.14867347163495417, -0.3132099006104592, 0.16921734816401893, -0.29321055503112414, -0.21978016759076469, 0.4274726114375523, -0.19494923015796703, -0.38956132980347774, -0.40555477516109406, -0.401442564418498, 0.03962419295902386, 0.3169274054510039, 0.34520099327870735, 0.23009482402204837, -0.28955714951889744, 0.2581736159722078, 0.14975819941376803, -0.2060062684545282, 0.2579915129585203, -0.05136754258533027},
    {0.04739256982108089, 0.23010313392902307, 0.6103886653134036, 0.012843405950914736, 0.12180069766599831, 0.20916300275831254, 0.5379949503804424, -0.09276301343240287, -0.1752085246116772, 0.39149491285594257, -0.6079717285264326, 0.8549040687325375, 0.6406209570872893, -0.1031765527155015, -0.022859848465123508, -0.3497550544076073, 0.8300104828157246, 0.10868279189175785, 0.12870896223288622, 0.014589961160955558, 0.08779658534398901, 0.10759861778450137, -0.43776374905122556, -0.3820734379340115, -0.36406298365397305, 0.5301014414458763, -0.4314171952982208, 0.22337089072963065, -0.7147137308984988, -0.0022304213342365735, -0.05617446266404503, -0.26695251543626064, 0.22198856838948522, -0.36759400880378024, 0.23998469165849393, -0.21468080631692177, -0.5444343546317157, -0.053283637065239094, 0.006980412182013491, 0.3839817062677024, 0.27887774546460814, -0.07327521877130197, 0.6644535484123378, 0.1690499769444552, 0.07912923775891988, -0.46595038311711534, -0.07985256790682739, -0.38560535820940245, -0.4360381215269314, 0.2752426757072522, 0.17060915858341327, 0.2378480016204142, 0.03128148139749253, 0.14327940709054304, 0.2523506282351866, -0.015292284613489845, -0.0619308915073541, -0.08190128452449333, 0.11448917798627892, -0.16240099924696202, 0.2205799888172979, 0.22540222081618555, 0.10425720401503487, 0.08601591919570195},
    {0.6445981903156663, -0.37467673676181246, -0.06254858167850696, -0.24825131856438876, 0.3243296585488617, 0.1442391429239553, 0.41631758983499423, -0.25015560293592204, -0.5057557554077824, 0.28385358797579885, 0.5077337781027279, 0.23105312096515607, -0.01283793660069802, 0.44847985365236936, 0.15835535531680445, -0.16723232921145662, -0.09129527266828796, -0.09336980770298366, 0.2352206874194633, 0.3516407208285683, 0.14363644948959375, 0.23189281528371877, -0.24856988404632469, -0.003573532044377269, 0.49038076422151056, 0.4581897320965526, -0.09311113644406764, 0.9425592270946477, 0.13447353518929794, 0.06634998255463048, -0.3051381320745315, -0.1959434892234152, 0.30860593603995407, -0.13855744688822957, 0.1734661874061223, 0.013813509782382176, -0.06027232999955444, 0.3471457398955735, 0.22602269858668064, 0.11908010316393718, -0.08015057491891833, 0.5508255865852244, 0.23994442934974175, 0.43944746807182555, 0.013744600734158055, -0.24805806510067174, 0.3835486501204347, -0.039429141492177334, -0.3986836018651252, 0.42940558632888437, 0.2103264727285676, 0.41001341313426726, 0.2981716314636712, 0.2091770154923888, -0.08635221600913193, -0.041298410501585656, -0.3993374889370054, 0.3337129774523781, -0.39996044322084173, 0.0054745726852208, 0.2561758993118558, 0.10363054694081011, 0.17552405210059407, 0.011759332258072958},
    {-0.1897344974009799, 0.1567953767455325, -0.2243679829272304, 0.1299408296682037, -0.22362892150239858, -0.30221448995104844, 0.22847021702102652, -0.688609377120444, -0.17222317158528413, -0.4571403455980267, 0.0029143141731388, -0.28192128672023586, -0.10786906583490664, 0.21735392815975343, 0.27726548664142336, 0.5191204447070806, -0.006599938925281433, -0.12979191982941515, -0.05152135034067302, -0.32754261195165224, -0.12903800237850974, -0.1570721003206833, -0.03669115326258481, 0.1583289312255586, 0.5572122835621135, -0.027152154874428965, 0.16365859528325738, -0.3568534952654211, 0.08492925291750153, -0.1220570701555394, -0.15712859250142266, -0.16801878077667412, -0.14040704254628777, 0.17496050510114128, 0.07612612387448181, 0.17172433098598572, -0.14969174154311318, -0.2756567692546432, 0.06503347490633586, 0.06652044296295227, -0.2876468149324921, 0.14625963785453225, -0.28808138338643197, 0.1034744058955874, 0.011819938107388296, 0.22785614134768223, 0.3959265543728476, 0.03000771612760026, -0.1885450515555707, 0.03793684893816804, -0.15874585980791853, -0.30315098502068805, 0.16147292472337305, -0.2020063309913321, -0.18542287734122223, 0.14455761248741683, 0.1298745640513241, 0.5806508184617304, -0.1598033130707188, 0.15712784311003752, -0.32820024747484344, 0.08132312424364539, -0.2861037995027185, 0.20145067609352943},
    {-0.464166672582407, 0.18597367177381607, 0.15942862061702076, 0.4812957831105209, 0.39947491360856663, -0.3550817249909343, 0.12311743625090213, -0.1188248367751808, 0.01887161214863052, -0.3178334897443304, 0.14213911566423212, 0.07708953831815295, -0.22190041654372258, 0.23151362263924685, 0.11834727839661802, 0.631122003263307, -0.2433828426911328, 0.3959892971014246, -0.2647024948937156, -0.3422637934467579, -0.48587675294957716, -0.3597629116091557, 0.46234562757096925, 0.6870580511938782, -0.177043292208557, -0.20868003569176152, -0.1140465442065738, -0.17795805749864288, 0.33384460422797113, -0.5907799093891166, -0.17779562891600262, -0.3794091596235519, -0.5273321839403857, 0.2982989864601305, 0.22208412990520351, 0.018171055507030975, 0.22046261941211207, -0.002979840479738083, 0.018392118726448876, 0.08552367349960499, 0.026111485284205642, -0.5138238520495405, -0.3485946254229049, -0.30113470751029353, 0.07587514916625787, -0.23317859894558063, 0.2373828028250855, 0.1895047263307493, 0.21813068345469427, 0.4523819000199399, 0.004488214263922272, 0.019765838630310537, 0.17694189737871654, -0.07937636735971244, -0.22298676597264014, 0.10750923816500954, -0.006515641931508311, -0.03246215560794822, 0.11471201159994283, -0.11266023096074382, 0.16233548785913224, 0.4445693711260082, -0.3341176701706514, -0.382029960988448},
    {-0.34084875621364, -0.2037228898456689, 0.3091239673648663, -0.11699790600702134, 0.23913513101225217, 0.20896505711247687, -0.5169338107254217, -0.1106772514901176, 0.20034390146546197, -0.12929055555354493, -0.5620585054700438, -0.08825753707571453, -0.49808576200154386, 0.2960350139638373, 0.09055933404009713, 0.2047899112641704, 0.426295355960963, -0.4035122070626132, -0.8032947244226043, -0.06793292464106569, -0.09870892580475588, -0.4106856161744389, 0.590506705295631, 0.20985412583426555, 0.08365151064937176, -0.09826045138352164, 0.15737289332618243, 0.06899479829669654, -0.43262543115669566, -0.38127633090402935, 0.08859930999559594, -0.6353549490845763, 0.3051187336486282, -0.35441001696846386, -0.4285144443715395, -0.3144421290883152, 0.26073979424079213, 0.4808883716846076, 0.30308142777628355, -0.8922592558081834, 0.21623693819400666, -0.2023638113889019, -0.27111648144129713, -0.17131691740977043, 0.037932636077030096, 0.007021032442290015, -0.02613680777632169, 0.587196677464239, -0.2678470985915532, 0.05091851602295222, -0.31314210845393003, 0.19682511489828353, 0.25124340932648853, -0.3438217139490361, -0.05180272220984167, -0.16794344780634998, 0.159409795621302, -0.06336909921699928, 0.4822700081054937, -0.0829469808303856, 0.23603172296363548, -0.1567506847395762, -0.037432576392663536, -0.45119722028787873},
    {0.0060417200199316705, -0.2039429016628744, -0.41173994399106617, -0.4275531253157885, 0.026982305301587337, 0.17938477263001798, -0.37638524011713376, 0.5125536687841951, 0.11892542608025843, 0.15491987055442547, -0.14097439146427299, 0.20441709715404305, 0.052675710044835, -0.238121170114109, 0.0003815483497000753, 0.6540643182456621, 0.8509636845225436, -0.3877443317061553, 0.4792152164831925, -0.4227935194643718, -0.005413516924370738, -0.03964655574130199, 0.566412596596329, 0.26246810367604606, -0.09248175152859561, 0.287319614557837, -0.33344661897616484, -0.1134384374205373, -0.653677151235118, 0.5056566057362248, 0.18834440155818413, -0.03873951107188302, 0.31385275907170407, -0.6447029766095549, -0.14295170891361417, 0.07416170614686421, 0.6003261498915917, 0.6040474054813194, 0.4742818383711343, -0.04928243216302905, -0.1726515320196757, 0.5648724653495396, 0.013343778725129516, -0.07746885281836682, 0.2623377940801984, -0.09457387595039268, 0.12174217281358848, 0.2603537846181964, 0.0995225149747205, -0.1297169675623185, -0.03052100286477881, 0.8247225953833756, -0.4258936113549769, 0.4358910395438562, 0.20435781423678653, 0.08204297972370121, -0.06950426473841657, -0.27816511473630945, 0.05457233286832462, 0.05080141141532831, 0.4403167311118003, 0.005313523587423847, 0.3008829473716923, 0.38860811201485285},
    {-0.10981716471609063, -0.46609492271824465, 0.10195865842980822, 0.37606695428933967, -0.20193950791535872, -0.1306966715791046, -0.10690135837182575, 0.22219724814039132, -0.039278354323936455, 0.44795599165815736, 0.5362416118060144, 0.175741459883857, 0.46796538514230757, 0.28025788060823986, -0.3257187164133535, 0.382351850018162, 0.38526727088916723, -0.0732630917210003, 0.1969508963335377, -0.23804851235474678, -0.17730789988002374, -0.5480661984862187, 0.1507817630525934, 0.010209475852854104, -0.07321029716018639, 0.07154356794641177, -0.11500656348874162, 0.452274158360342, -0.27108508509544577, 0.4814087250224211, -0.0590776234354287, 0.16664476932656072, -0.5231785256535967, 0.02975683797443605, -0.41733049767645436, -0.19463776832115784, 0.21890657330654337, 0.2660932501068361, -0.06330383269745547, 0.3871787325075477, -0.04583078769617838, -0.10985983031600433, 0.11065744717795797, -0.07543304569154498, 0.6180694481431556, 0.6233484030499097, -0.06179495821703985, -0.25114061982406094, -0.5437043645060466, -0.12748503063184055, -0.36918218372192835, 0.1961625017414961, -0.20807748955354236, -0.2844603663423212, -0.07453769326986336, -0.17653010029575855, 0.20921914685333884, -0.041079369693796296, -0.3027567684209149, -0.15529277789455334, 0.05049130377693, -0.2782779498238802, 0.25236690389135785, 0.45210642877871265},
    {-0.6912300448461599, -0.42017514285784946, 0.19133289147740112, -0.009325037122052366, -0.3442011316783007, -0.11235879694760917, -0.04921781113305581, -0.1936696062787158, -0.06153590131053343, 0.2850976930803822, -0.13350149287350885, 0.11988992340066697, -0.114390342095619, -0.04908467517767863, 0.49019709957045643, -0.5090027013786524, -0.17068798534391433, -0.40334617945288814, -0.18000580260748814, -0.23234464561642687, -0.4578612305880247, -0.10608309934699767, -0.05348322165841063, -0.10581848375795355, -0.11399539268017282, -0.4066672328319659, 0.3083174744845706, 0.2849840148326367, 0.1905210457661397, 0.0598865420831562, -0.021818159713882217, -0.05617075221209168, -0.15543130057398702, 0.07562371492626492, 0.10286325730749259, 0.44706398046635853, -0.3686219907435269, -0.17797030956462606, -0.1351265491346809, -0.7521819685273964, 0.34257360706564954, -0.14065485217263643, -0.2614673177442455, -0.06228146015036168, -0.1671979764314251, -0.01423846238155152, 0.12971917945947184, -0.07637579731461751, 0.45564052922858295, -0.475144187061654, -0.26556179473741465, -0.04052560837319666, 0.6309564456043663, -0.6358117752954655, -0.3920645967464313, 0.15046555475462847, 0.12653381174804104, 0.0382412850237098, 0.08226516168546659, -0.34033114465425873, 0.24304465574284737, -0.2907960929577555, 0.32288450765162824, 0.2193516910818315},
    {0.0009084779532366104, -0.15994500537085676, -0.15258252142142634, -0.24723235594466839, 0.20296060028820365, -0.42397361224025987, -0.052012692979811134, 0.22294452566131157, 0.2026950436306967, 0.2443608512698727, 0.0981921507208199, 0.3778421232126636, -0.4015109730042784, -0.09758883951664701, 0.3218270662024218, -0.04966594203256791, -0.07731182142680518, 0.10586408401101699, 0.2789415949991576, 0.21564303539420904, 0.22773985763896326, 0.6063988542122243, -0.24500486840892444, -0.3782026473542482, -0.04827841406558402, -0.23296789599019674, 0.10699505033435204, 0.023681407355264545, 0.3751755274639776, -0.23249028244856315, -0.1627559473468935, -0.0020078039459607917, 0.20145719404200546, 0.28400750854102846, -0.11786490995681494, 0.43798744277114005, -0.5523560862420881, -0.06304875775283425, -0.07698470946394755, -0.4371872465832977, 0.030138748054302705, -0.16207991546453251, -0.3905041396557276, 0.0990959761373981, 0.1546138166257643, -0.1613489199261347, -0.15812517221547112, -0.33593064889729646, 0.2829691291860249, 0.06008912644204851, 0.1394460540750977, 0.0856902199685013, 0.2803570593597583, -0.16659218421888686, -0.2848368147164886, 0.00836190292381698, 0.36110757875297894, 0.08668889026683917, -0.07027102311365205, -0.28685824911932956, 0.1347176303339456, 0.35788682610979683, 0.03637392386441873, 0.060683910733105216},
    {-0.5726050498386615, -0.09877690878406789, -0.07203870930008181, -0.3608296019505792, 0.15233142000261835, -0.1806305120060982, 0.20441068065635323, -0.31006104635493903, -0.08501576520014163, 0.2325810759683906, -0.1279105472923164, -0.32265756090623987, -0.41510807354232776, -0.31766019222011, -0.287067087656224, -0.3027479019065456, 0.2555536601951993, -0.6961608084605465, 0.171717535710529, -0.1551048636123499, 0.1665045174207977, 0.35434902640476745, 0.03946552724294565, -0.42438786643362264, 0.23175089342554953, 0.26805355695839916, 0.33012173228077324, -0.02335606180651975, -0.15365495535245238, -0.2433117316052089, -0.38209537832694446, -0.15929659533681437, 0.32990498254003126, -0.10625755284871662, 0.16609434705546952, -0.09957690869561689, 0.6039693590503833, -0.28851645609632903, 0.2189413616670118, -0.4218168466188782, -0.18598127247740867, 0.20700427232023996, 0.22997460778273227, 0.34524903946514435, -0.6717682867335748, 0.12481715587285964, -0.009271897063946025, -0.3111083978165013, 0.03582172683444227, -0.3777715186928553, -0.11660891267081779, -0.5104355634080551, -0.08284508019227224, -0.2226356305551017, -0.1863333092447423, -0.208178762454752, -0.41287795439765224, 0.4837805904856139, -0.4829419175175104, -0.6241208868252325, -0.4855490783801971, 0.1835986491886989, 0.11555973381169715, -0.48371412632172767},
    {0.14364238545880967, 0.04849691413349782, 0.3552310159084949, 0.2890483537189445, 0.11593863656197605, 0.006058100340229925, 0.07286170999117961, -0.5164387157129079, 0.031070653286430324, -0.04405848741687545, 0.4181951241930413, -0.11895213270170923, -0.18031688136590937, 0.36291714302892086, -0.36729855540979095, 0.28487148978416416, 0.13722091784421803, -0.06069353464183015, 0.606773030763442, -0.029325264904460455, -0.25078059053548535, 0.032718221833553676, -0.14343608500598892, -0.26925145099503506, 0.18196405488113018, -0.1845397648938751, 0.34978300349609703, -0.13638694513203725, 0.050590758501572096, 0.19922624497560512, -0.34496264279789574, -7.910765333381896e-05, -0.31854449801292495, 0.1300198563538231, 0.09179487240289161, -0.033139907920877294, 0.12252734067786929, 0.1440175811410807, 0.1090820470988321, 0.252178685040234, -0.2332132218240673, 0.36121573005500124, 0.389063709046631, -0.2349464181140479, 0.012966747584714508, 0.1202437066930743, -0.40498684215948605, -0.2660588729741043, -0.20980891897797824, 0.32049746258368605, 0.03456539890246857, 0.5041718251672299, -0.11318899338252121, 0.4426846089163177, 0.049100459931633735, 0.24445837328454426, 0.015349091025143176, 0.2470477460992783, -0.021078713137594043, 0.6759730056470166, -0.07090554221195605, -0.11600652215658386, 0.3985221447823522, -0.04535895307551686},
    {-0.07534588567979074, 0.0658469790116292, -0.10957038304950349, 0.011104965194739873, 0.0509585443604984, 0.1473787119642856, 0.2378818683605725, -0.160930796818171, 0.06498331709369129, -0.05726357062139571, 0.11829209120018132, -0.5284341697304581, -0.011761605525128296, 0.21838925220695554, -0.07778968873789913, -0.27274901794679063, 0.015771768048770472, -0.02136728095574396, -0.020323166527448987, -0.2118983624974788, -0.3094912681712777, -0.2511165048760827, 0.011072411544721517, 0.22880101683931053, -0.37595536915147465, -0.2036231138436024, -0.22735277096954506, -0.0625563524768596, -0.7381330978627458, 0.0439569218083454, -0.3244242153165044, -0.21682789965525096, -0.5160265258712079, 0.20517926939828152, -0.3784980334638935, -0.47649512713940106, 0.6279695390525492, -0.31982024064984765, -0.20314785487913128, 0.605197568780788, 0.06310733957990748, -0.24302043259340814, 0.11002185090083995, -0.20613871766340347, 0.4914439264796173, 0.17680579164814336, -0.05290001267257588, 0.07456771830021339, -0.32671834601696503, 0.07500736493253617, -0.028037420118444515, 0.32850219189131163, 0.5702031577126416, 0.3778161233980962, -0.3289593059754826, -0.19312984797894692, -0.13594948861277834, -0.14727720998964594, 0.010430380366745665, -0.2924020876920575, 0.05766426450667109, -0.28253795859593606, -0.30306333605044733, 0.07011010353375868},
    {0.03468624815689804, 0.43602098439284803, -0.5904868180441951, -0.4986807372954756, 0.1823498332797338, 0.15388890492236168, -0.016462711849400687, 0.36422988219370406, -0.2708437980602032, -0.1860269243871214, 0.14761726195610367, 0.32425074756055244, 0.004028442623453018, -0.363619337167741, 0.2298282013971832, -0.5824386990497341, 0.15189191198612853, -0.25999855305656017, 0.1870614243497713, -0.06676889546466344, -0.006821665642168279, -0.22183068471867842, -0.4641714753530237, -0.37378949189544863, 0.08565095385611131, 0.30270349444553296, -0.3327775374480649, -0.24633895501301542, 0.2327577967640808, 0.29928647967833777, 0.21062771014464743, -0.08405098967235418, -0.5878287310660562, 0.04216086186410709, -0.11709733298424253, -0.13638055451637623, -0.29971091108138964, -0.0840918136918181, 0.15799240040300375, 0.19065559017823647, -0.08840043578441142, 0.26857313580396547, 0.05405497687555887, 0.39131002241630175, -0.06005736078958096, 0.08534129380616379, 0.5691180523090857, 0.025997606019224576, 0.03145801205585088, -0.36029674696003783, 0.18514496642513995, 0.0478273825206475, 0.11658168971508212, 0.25394492091784765, 0.060632881449769, -0.6641956282131264, -0.03210038475889307, -0.13404724250305336, 0.09275746651463913, -0.3176869943010892, -0.1423414452024616, 0.6068044995273801, 0.16467887458957742, 0.33613254111465785},
    {-0.5371391986446445, -0.4528149898192276, 0.5902093066181417, -0.6560319189021998, 0.26333650500029887, -1.0167323351023947, 0.3862961641868822, -0.585830677108493, -0.9698916394774333, 0.35033454884686627, -0.7030622072902297, 0.6733034631647827, -1.0153347182862558, -0.12590427283779557, 0.39294461335700126, -0.6726300180144262, 0.18566301915164338, -0.46027359199758777, 0.37793889794805, -0.6922877637811307, 0.4700751086037302, 0.22382618338795437, -0.33560075763134123, -0.6151582065319938, -0.49704961751072707, -0.6062012032463239, -0.4489074756994644, -0.47384747070894606, 0.2581695638246378, -0.32129323826490314, -0.8549203461346936, 0.20834613066138338, -0.2729161330934401, -1.080172313238407, 0.7159063387063538, -1.129400768240889, -0.8148233217483822, -0.9132770991418386, 0.14105757098921023, -0.8981557756116739, 0.16281978448497375, -0.5035447550786075, -0.9295016221275774, -0.1750615810922013, -0.7175210540355326, -0.09630851138537286, -0.16952513598166893, -0.9535000037055815, -0.7667533318666377, 0.2729274204076122, 0.49315373417483455, 0.5919301303915464, -0.682247741436016, -0.48447225402810346, -0.3046839738562503, -0.9934069330755431, 0.4627676207357121, 0.28721931930878564, 0.30549318184231006, -0.8866698234407696, 0.4418441717236132, 0.7807616005494971, -0.6616974560430797, -0.4376127826747497},
    {-0.13199403131891943, -0.38495632119923956, 0.060620946726746366, -0.20528072591995308, -0.492110702723665, -1.0885928236752493, 0.8338395799993874, -0.7630347383399275, -1.1622452531975687, -0.49327068302166366, -0.7009816334718066, 0.7095722721622207, -1.1391908328252038, -0.2930702062694339, 0.1708478179286465, -0.5501484757400193, -0.05196696506513329, -0.03322277184627315, -0.1314735095201545, -0.8641924998221788, -0.03322707842895066, 0.028950780927319685, -0.10037233655385547, -0.6750740956537777, -0.6245073858706189, -0.9459348599175088, -0.3856350730099056, -0.4592504580772574, 0.09057881313428037, -1.0216452974317134, -1.0793467833538088, 0.013344557526872096, -0.581041171261079, -0.7330789215635177, 0.6870236679416863, -1.21617398070141, -0.9109301218191043, -0.5293684435927627, -0.17088455165520344, -0.5297592650338232, 0.6461123231279514, 0.027974190061170495, -0.6988182285696433, -0.6977749139130329, -0.7223976872660205, 0.17427285750327093, -0.3992928993926996, -0.7589171429631768, -0.23133926277639477, 0.17337030367856104, 0.20820118646272143, 0.5900089215777341, -0.8721363698431697, -0.5434320818407115, -0.5364057316155274, -0.4829078391510135, 0.028498116985582526, 0.5538256789552739, 0.02532896349494154, -1.0134391050812879, 0.7310785132823511, 0.7482246711439368, -0.3511694362803379, -0.3686155838105539},
    {-0.17737041993025282, -0.5348924025871606, 0.618015269004866, -0.5627226190532889, -0.0005506800495661936, -0.8368994721084936, 0.222331544751773, -0.6259771809981514, -0.3521046149239443, 0.26417125651913254, -0.45017951039751725, 0.4678265707354899, -1.0337474530690247, 0.060753665572133776, -0.06307865062380526, -0.3722475174510222, 0.5074821034045066, 0.21721959727694767, -0.10800275693140483, -0.7974567233434914, 0.2784603278263976, -0.07131439740558675, -0.36726089444215826, -0.44038124232818937, -0.16758886329486927, -0.7374142097619605, -0.5797035281498105, 0.3417007774118259, 0.6528412448733256, -0.4961416155170605, -0.7373106264452999, 0.20824193620951864, -0.1994681689105566, -0.5019899174459543, 0.29568853958342156, -0.41287358186409073, -0.5165512666311277, -0.25174455759934466, 0.008845911003506473, -0.41290579252190396, 0.37052597142957777, -0.011298310212194476, -0.4617394499337917, -0.23421362187044906, -0.4208488849159404, 0.3942757543888125, -0.4812923841510847, -0.46499072779568856, -0.4296720347221838, 0.008578967244062867, 0.5100463794801994, 0.38398209674148376, 0.058174962256629936, -0.08814432538413614, -0.20691784785082082, -0.7037197875838631, -0.17184064891223066, 0.2983777839923539, -0.03236286617025872, -0.049185614587845955, 0.284085061711715, 0.30592347410991, -0.5803681314345318, -0.5255022932758554},
    {-0.6216852380436273, -0.9244581666541856, 0.011448109219716127, -0.518927135649266, -0.02557408794760321, -0.784433368420802, 0.25797715262646875, 0.21136579103832695, -0.4447625419505973, 0.6490782161070023, -0.047997370955128696, 0.6502538107228852, -0.18881818194197764, 0.39707270766444513, 0.25556860011684396, -0.10174417025416264, 0.332718292392009, 0.3546517954044045, -0.11139396593145134, -0.5125431283187342, 0.38045971707215637, 0.05225448805228837, -0.10929240478899832, -0.18433362024395272, -0.36751561590720716, -0.8946742216025532, 0.018343221880079866, 0.17985378238927688, 1.08575396381985, -0.1581371467274944, -0.540161141548748, 0.10692009936214102, -0.13796264370370007, -0.6185313078426113, 0.3320342142560916, -0.4181070735251346, 0.09146026142454532, 0.03659504075637846, -0.2706273020672666, -0.3378358838929072, 0.08837746874888437, -0.6687252976223766, -0.4543562378589971, -0.08902348480933156, -0.6188511270408705, 0.5720025957028124, -0.8402704018634393, -0.445902084926393, -0.42711130099660494, -0.36742176717433045, 0.06727502909809466, 0.46456770043075574, -0.5005593075531215, -0.49452940630408626, -0.23075823311387672, -0.032068528492273776, 0.20928120352222146, -0.028799032416976702, -0.2574391494628096, -0.2562755789622863, 0.2512174325203087, 0.14590119756942502, -0.28448686269911355, -0.21425755007192465},
    {0.21761243025121546, -0.5122339052190286, 0.0029928923857900002, -0.18340775650068045, 0.1622426551356852, -0.15316488367580558, 0.43349617737964147, -0.50593613795967, -0.8896078818860321, -0.043027798007941084, 0.35838817556405284, 0.4346862440940939, -0.6933900017112359, 0.4225306161215304, 0.6321100394039596, 0.09191440449957314, 0.6099079198765277, -0.3900360702531965, 0.509831808057194, -0.0875980258173384, -0.06633491666930298, 0.3824433505909563, -0.5675392513258496, -0.4404917845006169, 0.3002477089136223, -0.2772048024401189, -0.05030873115429757, -0.27684143202476663, 0.4480003984301459, -0.3340479572363097, -0.4489146688859104, 0.15573015562322448, -0.2637982054257468, -0.7263486500547665, 0.2725386584854961, -0.12189998617249488, -0.4001185879182284, -0.05055761314607816, 0.036187925974010084, -0.12251369158094229, 0.3015116160781661, 0.08689224948411034, -0.26717153413029326, -0.09323029200631205, -0.605564037107726, 0.5341632013025568, -0.5607706389058893, -0.551505789165179, -0.043884752985757516, 0.06249306086701586, 0.11738778247120765, 0.04948910563706473, -0.0681857051001894, -0.43448367724973347, 0.03225032496105513, -0.6441659947997299, -0.30129799854894695, 0.7300916186257063, 0.2029219619775732, -0.5588218135717109, 0.37411408394407863, 0.9366989135133938, -0.2997275790344441, -0.5917591302233038},
    {-0.3240315914928134, -0.3681725579983413, 0.6790437011214479, -0.4336128842988605, -0.563115398600826, -0.9718013590798635, 0.3081321895330942, -0.6069583767469545, -0.5409102138726399, 0.3257450690893765, 0.17492622195122853, 0.8222470754336137, -0.47688798060827636, -0.509655802299578, -0.29369409550357617, -0.12260152138828766, 0.6200822041071444, -0.39639895326260016, 0.3654054773346692, -0.4252354019275412, 0.6948654287380938, 0.5786588530081271, -0.35586451249538664, -0.09187288118614603, -0.5238514373565075, 0.2512151566655958, 0.5906383456452406, -0.3317636324272404, 0.45245691375469915, -0.5593650559199783, -0.3657356008866921, -0.360348667674721, 0.10969994827154195, -0.5201410621552004, 0.34087256027813106, -0.2189650231230357, -0.6422284891883298, -0.3936970112021565, -0.32045442251484485, -0.4998518495951079, -0.24272982328146325, -0.1328085549730831, -0.3616163743816383, -0.3724371991745459, -0.5618728566850173, 0.8028263756958018, -0.09201515337172783, -0.47002949864413623, -0.1252486445611043, 0.22601426025800372, -0.34062787096108776, 0.2263821681797813, -0.3605549954744846, -0.5070061538832553, 0.46646901396945406, -0.4001092028138395, -0.0038742823481247583, 0.49838977148223573, -0.5672461526570775, -0.1895147369233645, -0.14248629981226232, 0.20139084664647164, -0.5939579479365614, -0.47435737259239735},
    {-0.2664114878109283, -0.4829300036086917, 0.06604506633581285, 0.005887662994501051, 0.1039145262841368, -0.5564413530307489, 0.23790400781252818, 0.11469554725825488, 0.34994175449170656, 0.2238259783252008, -0.6292301108731093, 0.5840278447035326, -0.0913948980209078, -0.3093262440129159, 0.35368398393677786, -0.020147996174757505, 0.32753146357964275, 0.10208484344379187, 0.7093326845693472, -0.6094063023041394, 0.4602463515729691, 0.4991626158540439, -0.621343134725196, -0.22935023644012772, -0.1130380998134238, -0.07352748624008416, -0.14095469113671835, -0.5224920863484144, 0.4968339479457165, -0.9344918317327608, -0.6147098070556528, 0.49154353031917414, -0.35065056129164696, -0.01956742480458893, 0.6670944495532649, -0.49933754125944785, 0.1843465974382598, -0.013039650149826281, -0.07307156834111588, -0.8845672020930998, 0.6771535797997592, -0.003970240331580347, 0.11186449496470921, -0.26734459058793475, -0.6620265785067895, 0.7966298269201284, -1.0971760868844669, -0.06932780623011248, 0.6230128129536626, -0.11767066394519403, 0.5773575701826638, 0.039541476711675835, -0.1394484957913504, -0.28696682186069805, -0.28413299768493816, -0.11856133778385107, -0.4660524452482112, 0.2273295948529652, -0.5039175498904875, 0.1816201682083303, -0.030079089187171337, -0.35032863808462394, -0.3901161828264521, -0.12520661120639848},
    {0.48925507532599777, -0.401301811372022, 0.4806172053061775, -0.02095127338159746, -0.5698092306331111, -0.44418037533567756, 0.26231977149481767, 0.35464364470254095, -0.647773762624817, -0.23622778201549424, 0.25071254250606195, 0.4639630167872283, -0.21578606950045157, -0.18649309032505, 0.030395880554462344, 0.21876502383507396, 0.8302391708776989, -0.19245873645172487, 0.08002301282941354, -0.03368777353403232, 0.5484504815591704, -0.33384514493523854, -0.06961078399075338, -1.0417573074770363, -0.11107955900078914, -0.16146891525907284, -0.0830659591649287, -0.9219660872990857, 0.9592322359864632, 0.15198223602899252, -0.5689525833997247, 0.2708867098241231, -0.042723889290695004, -0.5012236642840193, 0.5155855991333799, -0.18615921668900512, 0.01292960558462063, -0.18399130563443877, 0.47178659315663624, -0.5728993802674615, 0.5178275233800297, 0.5992393904055615, -0.09734994799475116, -0.3429269357232833, -0.4543165428212616, 0.4609333708573425, -0.5684961332287327, -0.6353331734282179, 0.1510130848058521, 0.49068167460170514, 0.40091051790593984, 0.5576557037445921, -0.16595214489798807, 0.0569506459304043, -0.4902258210408707, -0.1545354132413903, -0.03164562972255772, 0.37065287957855736, -0.5558460310668707, -0.3224424627830521, 0.3177945428796107, 0.458789977947782, 0.20643181711280487, 0.30731402712316574},
    {0.020789159229944135, 0.12724767333719372, 0.5365900065035171, -0.4620565255812576, -0.08148996278635169, -0.47719029922055284, 0.3977469535443986, 0.23751801316937027, -0.848157919903185, -0.3588712686815915, -0.12444025501265175, 0.1740759769021778, -0.46796576011374635, -0.5374977956263439, 0.2013710233684703, -0.07768474068899647, 0.2985060084406393, -0.751916607058336, 0.07063108395561743, -0.8451544973263226, 0.31828644401765216, 0.00723116017416742, -0.10489522466179999, -0.7673717725553674, -0.09798784660156142, -0.008794038316330199, -0.6312871825452597, -0.49084065243508423, -0.05202972403154814, -0.14534416199692046, -0.37181014043571536, 0.3276209449066445, -0.4053453038885164, -0.847424342163324, 0.26099438776620465, -0.5737800374500901, -0.2393164124598674, -0.01938865654040185, 0.15612241019025638, -0.57236071089067, 0.41122370714123746, 0.6424507558028101, 0.19696720330391299, -0.786222624667249, -0.5114596490004865, -0.04882085335708436, -0.4807193205653784, -0.6801417730221924, 0.2018390000543235, -0.40304315311793293, 0.3267737666545148, 0.6807343304881274, -0.2569478585460458, 0.17419469415839794, -0.031250711861828935, -0.34086096416414063, 0.14907445930639326, 0.7474555833538213, 0.10385358943207257, -0.5901179312369598, 0.36813561964658514, 0.32672524922684065, -0.2400698795594713, 0.25749355183719935},
    {-0.10539951538073379, -0.20054672384961086, 0.02754938044021247, 0.04967265042875384, 0.81667611751403, 0.16030290951837944, 0.06118946524232667, 0.07544294225375274, -0.3048763437812615, -0.1370998850681745, -0.541805520078065, 0.6251636207169342, -0.24963590235544508, -0.38561630323779883, -0.382133203020433, 0.18453590369295625, -0.33015750563360985, -0.2570064291168695, -0.7493873246723552, 0.26987808274866265, -0.008822344306617618, -0.5369952620054237, 0.17755703756611954, 0.11446697385136045, 0.06288393716450841, -0.3345792015462858, -0.016872751872872682, -0.3006446777945677, 0.2672757450452111, -0.2699957689054891, -0.005477561373625361, 0.14328819944927018, -0.06699097201009566, -0.0422240737700201, 0.14733613488774827, -0.885047684772797, -0.1405313872687701, 0.16448707669070967, -0.21405502892978187, -0.7227458904876727, 0.3244312492742143, 0.19820255664873462, -0.18591204086019444, -0.05663660096605319, -0.2633240481111863, -0.399952943490628, 0.35760279126672573, -0.30910511747819347, 0.24609714119343715, -0.44688026408298936, -0.05782940153477766, 0.289854092763076, -0.011502016650477268, -0.1388943735990114, -0.24810255208604695, -0.1493394342215148, 0.0014133800698125233, 0.06609594697567647, 0.12137552323009874, 0.0828198055753247, 0.39132777500269833, -0.10330479334047205, -0.3117795792440154, 0.08276815576634336},
    {-0.006351399510399655, -0.10603006373715002, 0.2812464804770976, -0.297784649720883, 0.5609417002371409, -0.4839534150417805, 0.6061910309786576, -0.23380892325123287, -0.2453671833427676, 0.4883449612679586, 0.3460095945498916, 0.06711001492726447, -0.015067523361999647, 0.2430051640868654, 0.0716366735785711, -0.24839369656557245, -0.0037589981832462575, -0.5368653605717656, -0.4425410534750132, 0.08150712708961676, 0.12854276005197796, 0.2244285059109553, 0.6006700021823997, -0.5465740693851274, 0.5988545834804976, -0.08284825807455411, -0.07914139888495324, 0.1071680663116505, 0.2842841231860631, -0.12837609098603323, -0.5011122045259583, 0.3158139912727853, 0.04096882892528484, -0.28039960004723463, 0.1346080893658764, 0.08380093341884443, -0.6103849623667879, 0.20125133573215376, 0.02872399536255434, 0.07619772106754291, 0.6456719391256517, 0.15195714973595048, -0.31614649810912165, 0.34080786643357575, -0.5399334055537205, -0.7442941969805345, 0.20463070942019124, -0.5922189902006476, 0.23659285506747874, 0.4365216760587781, -0.23206953592256133, 0.7172844499703503, 0.3642821436369671, -0.21814253601778033, -0.2615554907887462, 0.07975489740882767, 0.05926348861701046, 0.05739459192489493, -0.6908815077964265, -0.7895751485031398, 0.23601366484325417, 0.3645268389864089, -0.10869805737655865, -0.28255009249319984},
    {0.3510443827684613, -0.20938563877414876, 0.37702133251956604, 0.21125324342217772, 0.26353867870016146, -0.3317595406277856, -0.20459063029268362, 0.25282468196671176, -0.4256937072024748, -0.24225581121957138, 0.047834777204903214, 0.07609352362861127, 0.2859945307938919, -0.10034933802629094, -0.6929244178277337, -0.04014113673232925, 0.5731802821836638, -0.16659247024306406, 0.17096022209850328, 0.5386988725395784, 0.18788502782060976, 0.5197204504028582, 0.5930187325084824, -0.013881696796400647, 0.19602989022475625, 0.387142763497703, -0.5027339191512744, 0.10450936163006687, 0.10718728040010259, -0.021410470506871147, -0.17653395105896483, 0.013478747648237048, 0.384241384887127, -0.18255025256822618, -0.7205090000362117, 0.12980066396189296, -0.0960470505281482, -0.25715772513534235, 0.22689534713509854, -0.44541339352267995, 0.26266354623032023, 0.47745886966697804, -0.5577111506500321, 0.02496236683884426, 0.1297781403418875, 0.07504900614594746, 0.3364339175647747, -0.22222322849707, 0.14934850031618013, 0.26515297395101184, -0.4857376010569597, -0.18909810531771998, 0.01038536705673165, 0.22540167658392737, 0.05213710120441155, -0.007145234154632002, -0.0800888630281216, 0.3066892045081388, 0.14874531667536495, 0.002113270262138118, 0.5141812770317087, 0.5323810449495732, 0.033038766568374664, -0.19845212200180914},
    {-0.4725333222975261, -0.6771702043548767, 0.33254042123163535, 0.1517330379322465, -0.1091258172385571, -0.5294308821289869, 0.7194885547803033, 0.17310855334701306, -0.3501267674495322, -0.4910873452541977, 0.3381458189814165, 0.6598565296543099, 0.266593165978736, 0.39407049187305726, 0.010007255972605388, -0.19750776427835123, 0.21003135081941876, 0.16558679022299944, 0.35845517268609955, 0.2794087953441375, 0.17101251859430133, -0.13181492349437365, -0.08734250100215697, 0.09078363796044601, -0.5560539583622539, 0.06449607643227322, -0.30590163919112945, -0.30840897621397956, 0.5276755287556342, 0.041899382130170346, -0.4931476128550813, -0.39414342326596435, -0.5856861729393125, -0.32974664355907785, 0.5276740574795223, -0.2997411969680734, 0.21654092024982532, 0.07230555822682158, 0.013965350287625, -0.07005625736255229, 0.2832729612276546, 0.09552586840266822, -0.48784165207439717, 0.0391871178996206, -0.7340599753769954, -0.38940124585201125, -0.5122425466564702, -0.05701654604213774, 0.08395045219472537, 0.35194971012977605, -0.031448986631851056, 0.26356707270543184, -0.04116421959957346, 0.5579392650268445, -0.4560431112677226, 0.03580656538326328, 0.17598321425010985, -0.06312871464607245, 0.016645371012418232, -0.6095376033109339, 0.7050950874654449, 0.055482099415228414, 0.14201601988927284, 0.0867386678394646},
    {-0.3712295610771706, -0.2055713132622541, -0.3745459591074922, -0.3036471967517336, 0.03403779994030956, -0.5675134184314049, 0.8715236873619576, -0.05720925197023833, -0.49796530875973993, -0.8279840113963354, -0.44209730656762297, -0.5800081857455882, -0.251901832911862, -0.13111294708337745, -0.17652724651223514, -0.8681025155859268, 0.1472222462395554, -0.31623257092644386, 0.2540318252873827, -0.634577712505417, -0.1042536396856377, 0.3237084360794519, 0.6682663502773216, -0.6606813832629073, -0.3956224030042599, -0.3709139109423836, -0.18564718118043527, -0.7488874825072735, -0.2280450329512677, -0.2756777319327821, 0.21915905446356657, -0.026898283762030267, -0.4058138985991482, -0.08577678870148457, 0.6091467560513406, -0.5318442732273186, -0.48293864194629266, -0.2744252764061262, -0.2472784779940057, -0.22231589265067403, -0.21690882513856474, 0.19325968943158223, 0.0863380649493883, -0.649355390477686, 0.268402069869575, 0.6287877683059446, -0.14257526230634535, -0.9269086812491423, 0.08076959473436826, -0.12530689242750365, 0.18692983136038446, -0.24178773021384053, 0.3615473752664338, -0.3028079237776917, 0.37049155773833514, -0.06138272566679559, -1.1352387269379405, 0.43414680823165425, 0.17025041350106856, -0.15440760126716618, 0.04163803444454473, -0.3380768519293486, -0.022468257725591627, -0.16109669977151},
    {-0.29714240034721034, -0.09223430345689101, -0.31269972225505616, 0.6761584611072669, -0.24279579632217002, -0.034382582460997235, -0.03511873445615976, 0.11200440754515416, -0.15441474320259957, 0.4414336306593347, 0.4372022682720543, -0.27711639554934486, -0.09357009611252771, 0.5076953025774125, 0.1987962151674492, -0.3400302214293027, -0.3338344907582675, 0.025747377856881602, 0.3215812941595648, 0.09415043625051561, -0.05820804095352436, 0.5734729241528455, -0.029215408129286347, -0.41245307594359126, -0.307101648866679, 0.5853698536664004, -0.08018417749451252, -0.6795886338957763, -0.1629150627160584, -0.056823331325685025, -0.1674222036234393, -0.42695113289647224, -0.5698095613258939, -0.032755339355775646, 0.20805701383951145, -0.10697461575628879, 0.06014256993816046, -0.174851268909278, -0.07285281254270011, -0.374685424358542, 0.5396148982643496, 0.27375941224786143, 0.268479443068547, -0.7153187518121407, 0.4272936161217142, -0.33091707081956595, 0.1995527543850463, -0.4366505769746206, 0.2840333844661167, -0.060027256062583335, -0.057585649666683794, -0.13463599729104372, -0.08543978918523018, -0.6791514075396541, -0.11657972512144857, -0.15672504298299716, -0.12898844029111764, -0.6071353440440543, -0.374317301930467, -0.04138008857855039, 0.2831448218375909, 0.2506213242671112, 0.03696347537441478, -0.333413902244121},
    {-0.07191349203693585, 0.4083593094850642, 0.30502945915346363, 0.4731434861746455, -0.30591952657874993, -0.710277595302955, 0.04927685915553942, -0.036783258867112395, -0.4545970710297734, -0.5564756508017288, -0.06416149382630829, -0.125548779691033, -0.4711852798126839, 0.4548057909440787, -0.19226873137994677, -0.43463462919687557, 0.5543754003994011, 0.005416367435310768, -0.5568003556128654, 0.253325039560185, 0.22498281397446254, -0.2308734517797593, 0.08980890854343886, -0.40944901024991764, -0.4193027683547485, 0.5826705887993991, -0.7003171709859931, 0.25633856114900105, -0.06885218515232265, 0.015054297805017892, -0.3682179801178155, -0.486888750353213, -0.12756612266153666, -0.6636909970688865, 0.43848891549181734, -0.7280079031269959, 0.2042577560059736, 0.056171800170834264, 0.4100963570847321, 0.26079666208489855, 0.45050582769936504, 0.31852415842183257, 0.044715868802896484, -0.4267914234520346, 0.04977726631355294, 0.1118085069474582, 0.15926995531737723, -0.34705616437510717, 0.0381402337411681, 0.5232201653428619, -0.16430250966954207, 0.04813127320340286, 0.3310023633530326, 0.010591369873295921, -0.29673540628576234, 0.1040450657794837, 0.08834829631782758, 0.13087314733041375, -0.03399789196635607, -0.028982489653368013, 0.3931723711085907, -0.04428801476458309, 0.5334367379447481, 0.2999603625458872},
    {-0.3911615333879447, -0.19948304906242176, -0.4485340745483222, -0.07756071065513909, -0.3670864685955392, -0.5202868343527515, -0.26715224914056357, -0.0096439231241536, -0.7014520210356787, -0.14799137269084542, -0.3754977072764466, 0.16296400025925348, -0.7566096447682027, 0.12760909212913316, -0.13347862134183489, 0.2991056075480434, -0.24013042712253815, 0.5854554023289968, -0.4884859173306705, 0.18670251886870926, -0.3128895669073699, -0.4461258212352847, -0.2565820045165352, 0.16260035080371762, -0.42206423885647104, 0.23482756379603373, -0.5033815224307127, 0.3471246521938362, -0.4714925225466237, 0.02542721162020171, -0.3135252054998072, -0.2311429092991339, 0.14113486033332043, 0.19941365065692845, 0.47225382676147093, -0.3924581314308804, -0.16163855833746996, -0.4288347633251173, -0.010533947899857359, -0.16959234445519056, 0.1315192604571248, 0.1971546802346758, 0.2569189324605839, -0.5163490559222318, -0.039703757607982865, 0.40528844610364645, -0.45389750194260015, -0.43499999318963023, -0.4214919976227479, 0.055299981650809224, -0.210715505630719, -0.12157017755358288, 0.5689297473848328, -0.538614272384147, -0.14014747918661943, -0.15925696487247795, 0.2563423086125169, -0.5737665706399392, 0.2226740101120727, -0.17571455838792568, -0.27263064420189875, 0.5303286794016, -0.30557595423467016, 0.0036277877217453683},
    {0.047418342374347354, -0.5092558263127976, 0.06056905467348579, -0.735538046672977, -0.08131831405497165, -0.3992950125297174, -0.15796519142261703, -0.041590125593622636, 0.0497074424404083, 0.08458996187895598, -0.08490533060862024, -0.35878003166344363, -0.7969065809485782, 0.3065521981879082, 0.4717495856364694, -0.6708793975536874, -0.35400770683187305, 0.18273538541482004, 0.22225109401066043, -0.044762245952637836, -0.46897093918388405, -0.15251416608718654, -0.31937732080830344, -0.2518800673019896, -0.3246325835040919, -0.496021598810012, -0.9653047241764651, 0.06388837286281289, -0.3580380793293346, -0.28773711877223945, -0.12085509463650486, -0.1105775017928128, -0.1833742699959215, 0.1053494766774344, -0.2908522692096046, -0.4751554824463464, -0.31940449976715707, -0.07539734086261805, -0.3260823261469078, 0.17980297580290852, -0.48810015692453906, -0.13010414451934613, -0.3081994706728092, 0.01106361053258595, -0.14945616412433804, -0.3367658776748043, 0.018960119280154578, -0.05074886721228425, -0.32671374183507884, -0.38149747833849423, -0.3840032298142028, 0.016263229240814487, -0.3244620437216255, -0.6519341693291872, 0.5924435694021171, -0.2429928065148259, -0.5808321892548938, -0.5051511617609392, -0.8692559051864499, -0.08081712638987436, -0.006524495438111875, -0.29483110187005385, 0.1088214957862732, 0.11683004404682096},
    {-0.4664955015182475, -0.592327627972502, 0.048283928015396, -0.35202715646147054, 0.354642919018988, -0.5535457325645817, 0.591287818970362, -0.016855312204390935, -0.41233021225324795, -0.4695855855025022, -0.2620434644199024, 0.2227807943421709, 0.1607512941590376, 0.5377677940399166, -0.6932222657770684, -0.11543259587030012, -0.19210848260372834, 0.06958353956796363, -0.34087589693690257, 0.1587687660815307, -0.3644236263127449, -0.11780463009482119, -0.07794393679427174, -0.15005571055901992, -0.3503704565531798, 0.2797368147006356, -0.7236420571488397, -0.1224485819036633, 0.3504916954280309, 0.36925221900859695, -0.3379843590437599, -0.1115213775991752, -0.20023323505383034, 0.1713981033508522, 0.28046406957403663, -0.2768508695777713, 0.21514888303055396, 0.32075007461255123, -0.400777601961664, -0.05610841850629976, -0.18548392433549526, -0.18942463975581664, -0.23089778867705438, -0.05071460374982626, 0.11150662637082029, -0.10984434956063192, -0.0835960284572467, -0.021339188259565548, -0.47513767230360393, -0.24237744575094303, -0.06582465861211234, 0.012034793541163909, 0.39041209477898625, -0.32075850174583115, 0.1671121454408906, 0.27333010437376354, -0.3200714691963178, 0.48493290142667606, -0.6113500667914007, -0.3358639171998359, 0.07082458592548459, 0.23994118783265414, 0.17649511739109142, -0.22482124756321503},
    {-0.4895007271708816, -0.6451586789731414, -0.47488696977656797, -0.09128502705848097, -0.27361319852956606, -0.6377535560804142, -0.7163266453227172, 0.4840368839006504, -0.3361205006421863, -0.55622321408795, 0.23896384332314285, -0.025549660988792, -0.5331530814567322, -0.6998062784598523, -0.4746269617441879, -0.23481871292310735, 0.496651374570816, -0.5558718574372373, 0.10238681749239448, -0.42344121676881813, -0.4707890175345702, -0.4232851687292644, -0.18800835097220264, -0.6582361157736432, -0.7204198506789733, -0.4629733103591146, 0.33794297328959094, -0.820621072433152, -0.4269732680864078, -0.5737427443274941, -0.463859705165315, -0.23482732777201576, -0.052827985396427656, 0.12196092368932585, -0.13143712340664765, 0.2600812722096825, -0.721779997283345, -0.37451963174589414, -0.41646684980750115, -0.10271856270630689, -0.284357736338593, 0.17032750987517234, -0.6948199195447571, 0.29720938445941214, -0.6122225474883347, 0.2994268549917308, -0.15797325537198414, -0.39557131845228294, -0.2978112965025916, -0.6678433226744535, -0.7990232248511807, -0.12960717931709584, 0.0680914767155721, -0.2598144703641422, 0.32884796233982977, -0.5841780571677148, -0.3999783789294418, -0.44087288435383115, -0.19625188689231943, -0.23397915510662617, 0.1707457503476322, -0.2977110464263281, 0.2084083075798707, 0.11465193621747338},
    {-0.8446915096199592, -0.4799576683424891, -0.3453762779155982, -0.08812428947425306, -0.30910557194589044, -0.15886342997349132, -0.663617164965503, -0.0722785886022845, -0.09285328915688178, -0.11616138355039005, 0.2101457040705382, 0.12464715113079168, -0.10957094855665331, 0.30996098371311254, -0.36116029123020893, -0.015630404411799033, -0.24713357202718203, -0.09420604620044994, -0.11331536928988993, 0.4959314481822643, -0.2904195409849785, -0.6534133013754417, -0.43334750616737433, 0.4842047060025386, -0.1489675935537286, -0.49575486997137297, -0.10884462647311502, -0.13256331323806628, -0.030075888571067175, -0.2915881593300605, -0.4182085257653268, -0.592679560326407, 0.14192050495563957, 0.012766556815709346, 0.21509972271115196, 0.24410648566789775, -0.07807318264481777, -0.505411218156905, -0.37229087643656283, 0.09421557243672611, -0.14966153932973997, -0.4290169551016893, -0.5508247051445332, 0.5484899223266497, -0.6073022527022834, 0.4932242650347383, -0.46942527637746756, -0.09859826814968205, -0.360921051745575, -0.30968178240936517, -0.7673893417265317, -0.4229786635500476, 0.4455814599971365, -0.16449254528511426, 0.01285610830606582, -0.5110660386543247, -0.2709872563216866, -0.09116132371283267, 0.02415260158237268, -0.04221994690548228, 0.07778273904999788, 0.28419567992866834, -0.4716431514901621, -0.513738694912667},
    {0.22725373304449742, -0.0035381311293656943, 0.2310285265905155, -0.17441962183783621, 0.4806545439030688, -0.5758762723349948, 0.5194676821787532, 0.02312344326205228, 0.11005033760433741, -0.2678461349573455, 0.3780281949286717, 0.09611823076902465, 0.3394125114268221, 0.1627833521684656, -0.600759390446745, 0.177251453996966, 0.40822199172356394, 0.410565530844537, 0.48703375677818966, -0.3950713530857186, -0.1855295747360656, -0.056196717527946735, -0.39469431324363846, -0.45553613931965203, -0.03533601894456903, -0.5970788350010209, -0.5418558135743562, -0.05454387625103372, -0.506565345311786, -0.3489289537575472, 0.25381389002394933, 0.3823648456074083, 0.13319022060144006, 0.29539321765073273, 0.2564767780173205, -0.3885151137716758, 0.1981598159964176, 0.20598284817228252, -0.373836766694536, 0.14771215582778452, 0.6391121414416134, 0.16753740678128753, -0.11975479437528808, 0.14832134516752107, 0.6470766671076128, 0.059478601929238865, 0.5818166876330423, 0.4004979573689469, 0.04826482802137126, 0.010265991288192423, -0.018123674473045026, 0.18284715764134862, 0.38760319693282114, 0.4523356699449057, 0.9295877774635378, -0.5139809323059578, 0.07920074750554967, -0.0257757192498493, -0.06743690444134212, 0.1495065557905573, 0.5766509385505066, -0.04319156882652973, -0.27339426680395434, -0.14058413082742116},
    {-0.5257516178386781, -0.41153489076692606, -0.10531872874621634, 0.029453992142713922, 0.3537281596331047, 0.055467587815034906, -0.40464476694174323, 0.13129373791585072, -0.2610274142534028, -0.38445487378967663, -0.27874272082392004, 0.2590056632164632, -0.3113520735845091, -0.07028291265152038, -0.510797306952663, -0.006331177335310453, -0.11857761936295683, -0.0988188562862562, -0.46321867691200386, -0.02825773020266393, -0.05519365842549705, -0.13014884960433334, 0.10737094316509735, 0.44923971172925004, -0.3958980633126748, -0.08967195389318973, 0.028722785918626304, -0.4992071675936191, -0.36646408841656875, 0.017601560448698837, -0.5758180058006889, -0.03472678882426961, 0.17754826971372012, 0.1285288474565341, 0.2594384538010974, -0.373423258095736, -0.20982508834179245, -0.4015052566782123, 0.053050601657774046, 0.04656558028378034, -0.16190153207737024, 0.19734082502034775, -0.18787116608297524, -0.19770303315509663, -0.20364368967040955, -0.2267340402812709, -0.09054504718420593, -0.44138671110400585, 0.1904928533297466, 0.05730098376263192, -0.420364670541567, 0.0205307166948452, 0.06397540611194415, -0.5248265312849346, 0.3463186517029239, -0.259499523610218, -0.5676894683221039, -0.026712445336799912, -0.40773396856622407, -0.6373318209767507, 0.1938181485517353, 0.4528643199609335, -0.3008912265236444, 0.017232610322341628},
    {-0.42691424046899723, 0.001740607091955355, 0.1383394944645866, 0.25286615591406103, -0.4619101496761488, -0.10363889806723228, -0.441170892954866, -0.04032101279652291, -0.06211605923515533, -0.5335564859891613, -0.09137545734486167, 0.2589672403280612, -0.014861262017338974, -0.06053453131617907, -0.26710193364677026, -0.0900757526930576, 0.0865987370099272, -0.32747479087735865, 0.2142975820793459, -0.14869791754567738, -0.3052229726424683, 0.02524215514993624, 0.773219315169433, 0.18370364651644952, -0.42835762236803565, -0.22138570694244022, -0.17228944488671968, -0.826315354828726, -0.01342290864119123, 0.29127807324586846, -0.5743562842761362, -0.17216804044512782, -0.09267523001928571, -0.06946696022218202, 0.28158344292789333, -0.1877965675960909, 0.03340932843353586, 0.06937020061792483, -0.03641707389082377, 0.21749369755497358, 0.2878815294405099, 0.34214451505383525, 0.13074144599191506, 0.10850525327753627, -0.24393616472219828, -0.06243243904704393, 0.7519897270236425, -0.37517571795313837, 0.35050258234667175, 0.5171248231878932, -0.17333727287686085, -0.639673805894466, 0.15090378179703637, 0.38258524910797115, -0.6748147016022469, -0.023195868165866773, 0.34025501197009034, -0.7154428655563391, -0.30580500183797543, -0.03885781766730011, 0.18493038782535817, 0.1234676161156898, 0.12576162992612555, 0.4328962173730374},
    {-0.09623394640438288, 0.3233860904990029, -0.5340796852408779, 0.01991470910715224, -0.6719737287035039, -0.2293881446125471, -0.02527065973683988, 0.05485531967542417, -0.19137767476243048, -0.3831480494620707, 0.09238093445480883, 0.2810959877855105, 0.2502325369134656, -0.5206250091351562, -0.6922114586022348, -0.742132482620453, -0.19520738035316468, -0.31737395362454845, -0.1743115932633154, -0.6218574396522221, 0.11406140246494603, 0.39627174265486853, -0.27588204131314914, -0.16674184851248594, -0.008250825410685093, 0.05118142042107052, -0.09082363591305574, 0.0049340594353399535, 0.6875801308573268, -0.15797432273487225, -0.3297403701884245, 0.10701862446873588, -0.6289534146103253, -0.3850485118477176, 0.6996706236279696, -0.09821836804585043, 0.08169851919586617, 0.07000367536000932, -0.528692202469386, 0.026787933779155237, -0.18443631084025106, 0.37372754450385526, -0.27058217932254414, 0.30757312483850796, -0.45275169562252343, 0.5481454977728051, -0.18944769552814716, -0.2655894388331393, -0.08670662505255605, 0.23858140266207192, -0.2925871995059647, -0.1459168196904185, -0.16319568270627033, -0.32915409458864864, -0.3319101931130654, 0.6080157318626055, -0.5965393276485185, 0.259473768468527, -0.151879953338438, -0.6489519563896924, 0.04494869184558092, -0.3081563407844313, 0.008778247738654165, -0.5359307090430668},
    {-0.13665506129338542, 0.4775596041849327, -0.25401612545967406, -0.32777459430914047, -0.3122534627529702, -0.2764665057117151, -0.006409317378544789, -0.01247934046451022, -0.4806765937736482, -0.23349340312581296, 0.3036297831420419, 0.41684917636546265, -0.06303455509920486, 0.267544525890056, 0.16292551882301898, 0.5256525747999593, 0.017961372264038426, 0.6698558765461106, -0.4531756112620432, 0.44078894326984275, 0.14797124913665902, 0.31039996834570194, 0.4693170442968939, 0.20451255448781755, 0.030186993054938962, 0.17615584626210892, 0.3144593885611186, 0.5856358433389552, -0.011688193423261209, 0.20002058394838615, -0.17340383267362453, -0.24217958321749192, 0.29180169399684863, 0.029094530557521186, -0.18458253148049664, -0.1997320255145861, -0.07849779816037679, -0.08145830700829598, 0.1350372398891372, 0.40399871418459293, 0.36131629560257933, -0.5459549614199952, 0.3059874836930973, 0.08867935520871607, 0.023573991484463507, 0.22846069928828322, 0.4048146698135705, -0.4624456821689705, 0.10301548530691079, 0.703448498812916, -0.635400621179186, 0.22825221873841398, 0.3537475323756507, -0.1620086883667299, 0.1818981568768967, 0.26330892579779464, 0.3302007097801997, -0.25928734769600575, -0.35132052657631535, -0.16334869799510793, -0.0815563154929934, -0.07520900334277396, 0.022007452513781858, 0.0617663056565633},
    {0.11924936132698502, 0.40349315845021266, 0.3099669379237614, -0.1922019012367345, -0.5117907613473736, -0.3748134728226897, 0.3456121723491861, -0.07999800848482162, -0.21058856048168204, 0.2438213898967913, 0.019206290913642673, 0.5642552995969353, -0.2428918859114548, 0.5182545009592113, 0.5531379259296098, -0.6261573156869755, 0.3005857037147739, -0.11424043170031542, -0.3220399908577576, -0.02091483803455173, -0.16383266471894775, 0.4172545277615478, -0.5729362911910068, -0.719910201736469, -0.02927582799838561, 0.029079497067557095, -0.11785576681981962, 0.16352468017993557, 0.7389327583544337, -0.3218453344381003, -0.4460305197349259, 0.14296732112953928, -0.5370750070487529, 0.09361817781405656, 0.44396884739547937, -0.11662339406122857, -0.39380480534259954, -0.19763782081472367, 0.1289289822109935, -0.10546085835767176, 0.2987693002001337, -0.01735558617966467, -0.49877613731633835, 0.6490232331833263, 0.23457464983311224, -0.1611038693670044, -0.45659919891674444, 0.08981459420144647, -0.32000664680767854, 0.5528726983542516, -0.19167443631852743, 0.042923461381546776, -0.26548119988989266, -0.6171206495989712, -0.5163876385416897, -0.26227687459522514, -0.17283492459387173, 0.07611843967423063, -0.24336217512329095, -0.041886376023490775, 0.7237078817269302, 0.005484037226164669, -0.028251992054865276, -0.09834906551543966},
    {-0.20503759567251703, -0.23733884947557957, -0.5171735458148781, -0.20870374115640558, -0.2939033243307203, -0.12921954126953805, -0.04565146988075985, -0.12953060694607835, -0.5457725880333678, 0.18922756814411829, -0.23407329720736111, -0.08702620298222753, -0.5681920340352811, -0.4511835440586806, 0.3901270789818699, -0.3062152146369117, 0.0891184741160482, -0.28780171856997894, 0.2574259732907303, 0.08453346813866809, -0.6547057983479319, -0.17371868079567593, -0.0044831181614677215, -0.3108137831241263, 0.08037953368172651, -0.31485919352608105, 0.23520054314858896, -0.20865385389332725, -0.1481705300313263, -0.06440439817463127, -0.7476576856935514, -0.020431154668580732, 0.1611349089101356, 0.09411062735086323, 0.0647098803289742, 0.11210280285515618, -0.3772701645422473, -0.352749674920392, 0.3986598745077961, -0.41805452950011535, 0.1349348276507853, 0.07082293159513792, 0.03732633850356943, 0.298157765604986, -0.1692623867695348, -0.1375914831442356, 0.5438572561100706, -0.16913728118275959, -0.13378815451236944, -0.25545979573552047, 0.12824861940088342, -0.016339763447132342, 0.38246609967608236, -0.3370357407126252, 0.47563341252072977, -0.31190992525986805, -0.5367475182523211, -0.7575200491852975, 0.050268361036328896, -0.034778598534447654, 0.28297844590394217, 0.09146562448805336, -0.37297140140843954, 0.40086088064460357},
    {-0.08834908813702724, -0.04390448441156637, 0.390145116509598, -0.5801445665953013, -0.28579885565467145, -0.6379443967923782, 0.05789186751330265, 0.1039419520578653, -0.17094020856796266, -0.21775627955030927, 0.043736783867781896, 0.3020572489606039, -0.3645342796715853, 0.3512195661058414, -0.04951375012438129, 0.2545072257546626, -0.1871493497513449, 0.22786629169401026, -0.06065706552480852, -0.45912626275521873, -0.4095460175034033, -0.7570992346835365, -0.015597598515069613, 0.24007923366547174, -0.005300172848834554, -0.4018240163984264, -0.2547849208154853, 0.27118983272046593, -0.21086177310463602, 0.40396484677766675, 0.026734241095723504, 0.5822577712762261, -0.40470278013595046, -0.4588298289712213, -0.12272683615059916, -0.8168465396434926, -0.42454119946284524, 0.12065098834133935, 0.29051183286728427, 0.41662957463556605, 0.2086135616277043, 0.19277280206279912, 0.6496535688688, 0.20135029442710556, -0.3256517524435706, -0.4154934441903368, -0.9348424224475829, -0.4514549163728091, 0.3105470346881768, -0.0428605121506616, 0.16294052022369315, -0.13270760793928935, -0.6262924809274883, 0.11713355429830577, -0.003988795952662468, 0.19776616878215625, -0.2421881078260861, 0.045604260490679664, -0.8563038037469776, 0.08847094387656046, 0.02488507654346193, -0.3059271637503246, -0.11933817371099553, -0.1117360179662492},
    {-0.6876835739625835, 0.051488689220804164, 0.5693957778969893, 0.48287313097361256, -0.38924354531861727, -0.0774443738163074, 0.09675436094972878, -0.5185702449972117, 0.15746375150491784, -0.4841346566563397, 0.24076144040661535, -0.21569686544381758, -0.12258522399382588, 0.49229596377117024, 0.09580462839167017, -0.054183322888965664, 0.2781219819903901, 0.31223546614140374, -0.4334780980592129, 0.34118500475082125, -0.2977653301509313, -0.34299038987477687, 0.011447232717088994, -0.18342083033738718, -0.03928458746931664, -0.03589377255293383, -0.2568375255380234, 0.033559521601970156, 0.2022308353396394, -0.12783076909695915, -0.0683267889642997, 0.030798778283099237, 0.13332600108412404, -0.47341096402394617, 0.1929219898346672, -0.05763811695887268, 0.23047579732211648, -0.04956214590232647, 0.2712369819810226, -0.3625576971998652, -0.43497142878757733, -0.1802783439426825, 0.07282375550103576, 0.2610035158575419, 0.4248277724186687, 0.5286357662010925, -0.4183396915446298, -0.4702290828840411, -0.11547063291527666, 0.20512339876860455, -0.2989258296959957, -0.13309432616741126, -0.574831458523582, -1.0084287347757386, -0.5467124621875591, 0.30265417190422916, 0.6735732568775131, 0.06018314738931909, 0.2801224373861361, -0.23599011121112545, 0.47280949637083775, 0.31369541006140533, -0.4926727284321674, 0.4091225554349586}
};

static const float b1[64] = {1.070887364537003, 1.1487148317569333, 1.1607657799623974, 1.2064594373043953, 1.289218152268761, 1.1920030424393424, 1.2252690600990286, 1.146663546844193, 1.1726497957689055, 1.0231978995736284, 1.194219947471307, 1.165439157369759, 1.1914791846426755, 1.1469959251839754, 1.1306943301395096, 1.112417895433248, 1.2169975463857559, 1.1587310859936033, 1.1344308356691666, 1.1608492558465888, 0.9129124964286078, 1.1540531259217255, 1.1493488233978542, 1.1058281446674871, 1.104186642963429, 1.0808660775159067, 1.143286943505608, 1.2295833121753355, 1.1858503225240338, 1.0489427886168083, 1.0701907256344962, 1.168334138774719, 1.2603893679078952, 1.1201874316918878, 1.1627169731322016, 1.1881872188491858, 1.1044543148410697, 1.096533915788521, 1.1706124099319755, 1.2701859978602277, 1.2279811745150613, 1.083295043213066, 1.0899360188070673, 0.9602914916013269, 1.22683035235177, 1.258053385735862, 1.2388788448205217, 1.1281700777870887, 1.2033771331390208, 1.1515156562057332, 1.2234852951275506, 1.0748651665478683, 1.184935001116326, 1.1282394011179915, 1.1467992083681826, 1.0481272325578022, 1.1555714753314703, 1.1625073664706358, 1.1153731445695907, 1.1472057248591125, 1.2430762259294854, 1.2312016368482959, 1.113193660811941, 1.1428604444149468};

static const float w2[64][32] = {
    {0.5793462901130519, 1.0638548458471346, 1.0963680581327029, 0.46935757723389704, 0.6839718566801357, 0.5986501659900623, 1.0545111420128708, -0.09496779423778581, 1.0371595950372052, 1.1020623652273425, 1.0931353355288602, 1.1535348348652583, 1.1309173855244556, 0.08472221428790337, 1.138154657275712, 1.0145186062322615, 1.0033053373975953, 0.1006897166160747, 0.8335735893683527, 1.15352734489429, 0.9470812242431905, 0.8404690339256443, 1.0160414976926957, 1.1545975172284977, 1.191157751568591, 0.956843544246108, 0.9348271024551328, 0.9732729649437832, 0.7066287507898629, 0.5497218108380961, 1.0432027242558446, 1.1215830364758772},
    {0.7136991490311047, 0.9274726183010501, 1.0166363030701857, 0.027091588579001367, 1.2008015311273377, 0.5381264343901615, 1.169431277874702, -0.27496984500856203, 1.3237764025926653, 1.3506797648212796, 1.212526405788202, 1.1087525721482183, 0.9066825058209251, -0.27713208647622395, 1.1170561694465782, 0.7066106369058742, 1.038520171304785, -0.28460577558518335, 1.1859558511160877, 1.1342770095415722, 1.3232052510556986, 0.3480005664253271, 0.7689055369020098, 1.097653599679584, 1.0805126686880853, 0.5064815737227502, 1.2637240224811925, 1.0871982754264424, 0.5016095095707098, 1.113226996251525, 1.1017496239647995, 0.7770986094169832},
    {0.7648035903014112, 0.9769022624489235, 0.9294052436923637, 0.3553675417477532, 1.0201713759820281, 0.3609610440515978, 0.8935708770726519, -0.31333242819141993, 1.2021962002853346, 1.0961788777284134, 0.7615952406517721, 1.233552628723609, 1.324472834282033, 0.007072391191124385, 1.1240844896172217, 1.2198520183636221, 0.9169864475761199, 0.022483977436555426, 1.0264502542701792, 1.1692154508056347, 1.312752119320809, 0.5620096108316585, 1.3019019060384562, 0.8085872375525922, 1.0827551579671533, 0.7988325390517356, 0.8221355484737982, 0.954834396029492, 0.7000887973563716, 0.8145951910072144, 0.9225747765657615, 0.7875037871504338},
    {0.2587714789076081, 1.0183759219820572, 0.9086272702223246, 0.134528402139901, 0.9330990841051386, 0.7200667290774506, 0.8608213117758748, -0.2783791632507604, 1.0550682548141026, 1.1237750178239374, 0.7930171943036762, 1.0232149340953554, 0.9876694851007405, -0.013020458558321337, 1.000262738551137, 1.0822100265918333, 1.1946629185307156, 0.1091551298437097, 1.0972941290002236, 1.1147232189062293, 0.9778690270079389, 0.2845196569460216, 1.0897466887075449, 1.1243242347777556, 1.4158042035917673, 0.7321198872108718, 0.9559693122698197, 1.028948154257235, 0.6279580421336513, 0.7474533261461647, 0.8889943286745081, 0.7938627433715434},
    {0.24594605543511378, 0.9818787032992662, 1.3442500403011688, 0.3984395576941783, 1.3650664185809658, 0.7639383013702015, 1.1482390532301674, -0.24674208457946034, 1.3635369858518456, 1.1851030865439915, 1.1727811132808224, 0.9568186892518893, 1.0164171973671006, -0.1097471671481228, 1.2667014116438557, 0.9649619765101525, 0.9704081176009434, -0.4581925669382857, 0.9346901348233075, 1.2862310387511833, 1.2813957899592188, 0.7573318616166818, 0.9138088703883167, 1.130557010501246, 0.9113306039381301, 0.7877926586785591, 0.7988212211697752, 1.1157989250720017, 0.6093401171092133, 0.8105006962148817, 0.7934762888909528, 1.076160197886376},
    {0.6440676624454776, 1.0365480073857216, 1.2255925489555959, 0.37562275995076105, 1.437223773403808, 0.5801024587469711, 1.2736075453234514, -0.11971166632675233, 1.0935144941367243, 0.9377256737369782, 1.026730610818269, 0.812001389119546, 0.9894910582097147, -0.04583560287391247, 1.2387197557146654, 1.1040228144193178, 1.2469037949584347, -0.2821706072092639, 1.05844463741839, 1.0980140384372903, 1.152379529928525, 0.5140623581044543, 0.6779207143084957, 1.0971369896436134, 0.9065052056616114, 0.8174000933182963, 0.7200576265171054, 0.8437789555700297, 0.7927891357356424, 0.4375353405160882, 1.0474647693925974, 0.9225509755871831},
    {0.6146368403397083, 0.9363857185846668, 0.861368696191585, 0.19788444706857575, 0.9984862616279367, 0.4972081616085288, 0.8353651818293114, -0.27745577310388203, 1.023540201860231, 1.1261000811511093, 0.727679840870007, 1.0000395811824614, 0.924528516026062, -0.09654005305430141, 1.26352572270059, 1.2260058710833341, 0.8469123910175392, 0.26783737973528443, 1.20599233682295, 1.1389101682462217, 1.204902553233698, 0.6950395052846127, 0.6921667744152646, 0.9681225067522645, 1.074415373840786, 0.7722816432184189, 0.9291358822095734, 0.9979715373538204, 0.6352756149256819, 0.7611614761073952, 0.5203217345458478, 0.6978595318954414},
    {0.2701567354674804, 0.8105884940566567, 1.1252800810900097, -0.05789746685612208, 1.1710223100786838, 0.6057013949266264, 0.8141457732879996, -0.11642655821058964, 0.8465998470293644, 0.9417427866264317, 1.087703829860223, 1.2109904433228211, 0.8139730979463627, 0.1750052078552914, 1.029606277469858, 1.2226454005011356, 1.1235131360386206, -0.045595990831107464, 1.2095845524372761, 1.094216186818951, 1.121980536665644, 0.8516289928183035, 0.9640886830818025, 0.9729577634014775, 0.8784688342733585, 0.7937083507769461, 0.9340254443611633, 1.0567907669887497, 0.8247483798511928, 0.8157398214735047, 1.0114171598287185, 0.7289811390607635},
    {0.699283226269095, 0.939408666477061, 0.877754150835979, 0.5902681474031626, 1.2478561666651729, 1.0600390092859067, 0.9446138814255419, -0.30121272797601434, 1.099951071671548, 1.1290201656283376, 1.1655283073342109, 1.1843833800914603, 0.9416916400033272, 0.06266554800167276, 0.985836405237941, 1.1712191848285454, 1.0703297665445444, -0.08163739474126297, 1.2035843029931101, 1.2871383535192296, 1.4462050153301549, 0.7040959160736749, 0.8335777606196626, 0.7074728800185907, 0.9827001251330828, 0.9575814468788985, 1.063492070387046, 1.1640781278805343, 0.8950278566691963, 0.7043210059355112, 0.8269752367855171, 1.03407278533517},
    {0.4805513156232484, 1.2562727258422746, 1.1243641171744858, 0.30855333613662106, 0.8272728670078224, 0.5900922553744604, 1.014052624080928, -0.014615851900346862, 1.0376712150404799, 0.821804591836996, 1.366080763889491, 1.0414394174116182, 0.8987186695886424, 0.08237258828337701, 1.1659796695415314, 0.8767824333800323, 1.1424891279659632, 7.405686002925018e-06, 0.8953726898558866, 1.0565387309191459, 0.9959379948415561, 0.8248872938252926, 0.8750606612362662, 1.3279173809699403, 1.242093951012967, 0.8955620034621242, 1.1193615912110413, 1.3139102781493301, 0.6339550448411017, 0.8653289452244203, 1.212795718075968, 0.821008683070765},
    {0.44205113484047637, 1.0293927750258298, 0.5490527836457885, 0.3513929874412439, 1.254309371014688, 0.7823172516711239, 1.1706262992367324, -0.17683232680693498, 1.0076632302589554, 0.9735495304196158, 1.406963021904376, 1.159679124887057, 1.2490963993651258, -0.19339119735795068, 1.1979503824635218, 0.8990250752934766, 0.9854662502455023, -0.2428984566585909, 1.0846065173227097, 0.8426033154821237, 1.2245003537659969, 0.6023701786912984, 0.7194050651650161, 0.9683038902758497, 1.1742033582067157, 0.858568585931892, 0.79045447294323, 1.4850278312773584, 0.8652599549541826, 1.0594399129728602, 1.1151546419681038, 0.909716158433612},
    {0.35190049180918914, 1.2104668834722598, 1.2510250631763262, 0.5579154719294062, 1.1705184218346802, 0.9477927158842477, 1.331086773864863, -0.23485348221007202, 1.0354258267510474, 1.0618875586368333, 0.9740982208872271, 1.1787190880072298, 0.7829648292573582, -0.01646064520239156, 0.8214269091433464, 1.0666085406212862, 1.0842519959427344, -0.06579357619374845, 1.3550274326245109, 1.380217841556829, 1.2832580415937005, 0.5423864808028049, 0.9174348941454362, 1.003680896647835, 1.1438206805520388, 1.1578529762264467, 1.1210806537193205, 1.0742831463291787, 0.6130211895404399, 0.9668880529436261, 1.147908121732858, 0.5951959744026679},
    {0.34950252919210595, 1.1297052443247875, 0.9391280921424068, 0.223283311585521, 1.1938545478332863, 0.5981433090782553, 0.8348875903278686, 0.12664451104907945, 0.8354396945713598, 1.259643280359269, 1.2526977138650703, 1.2082738922183769, 0.9651188373480782, -0.16318001608741325, 1.221122358354768, 1.1782061798570138, 1.1525345915247682, -0.25514406352759517, 1.259800458555815, 0.8933555511185031, 1.2353241570836424, 0.9661831393618546, 0.9783431093773071, 0.9796427636271402, 1.072810168986243, 1.0771288672896664, 0.8321673130783445, 0.832899466415514, 0.5199436836197661, 0.9360797652931845, 0.7293828949875125, 0.7568997282962305},
    {0.08144633457138521, 1.1370625805660952, 1.1332245208773057, 0.34946948971428615, 1.1084665624589716, 0.8342061156534761, 1.1626696038518287, 0.028800443986907863, 1.0951403969923938, 1.179608421968301, 1.0198111294735257, 0.9814103343921223, 1.0763328461994575, 0.24589978216012712, 0.8992992856676522, 1.0010115040039385, 1.1324354594071961, -0.021113603576896536, 1.0060734811578789, 1.5108126018765202, 1.1963836085372932, 0.4452246947418552, 1.0718574480453213, 1.2125626264166067, 0.8824171835555424, 0.9202499696915176, 1.0847917086877352, 1.0743640951646154, 0.36866010478395805, 0.6830304729484842, 1.0517394727229328, 0.5279433578474976},
    {0.6289003268956528, 0.9725277041557383, 1.1034848908315902, 0.39836054773018925, 1.0016819793507226, 0.6240335481762281, 1.0021968771639969, 0.21377769706972577, 1.1919277419113576, 1.162784208834116, 1.197186242954304, 1.1515336511670144, 0.9268087247870782, -0.07733297996823059, 1.328373290847049, 1.1695852720086408, 1.241047505236042, 0.016626257495834733, 1.3365123905810552, 1.1944019267998287, 1.0873084649430365, 0.242923655339979, 0.7454996635152907, 0.8770011356677554, 1.086883317903469, 1.0216163113916399, 1.061234833467653, 1.4243886465397309, 0.6244452094700351, 1.0311738221853175, 1.3864921530258925, 1.0894790182220655},
    {0.5371320470906134, 1.1305620048313718, 1.0905211979673093, 0.47560757773124784, 1.1579235181878056, 0.7162149698935563, 1.2143500802490224, -0.06423157013295146, 1.36296103508867, 0.986056058899548, 1.1861612602481735, 1.1971656416158032, 0.7778728094234691, -0.011725188755919321, 1.035859217016952, 0.796754318958112, 1.0854746823210253, -0.37896443710872146, 1.1597592567821808, 0.7061934464345115, 1.1372264980706033, 0.33409972186820713, 1.0341098342974708, 1.0587896623053112, 0.9861146836174123, 0.47101468022194964, 0.8078364670611631, 1.0084236145879708, 0.7648268713350409, 0.825868202560393, 0.9102463432363836, 0.7352280979665575},
    {0.7865543304579867, 1.1156373484536617, 1.341328232911629, 0.6539994042692958, 1.2900521805772796, 0.8365350267600965, 1.3013119062697427, -0.12585070136437618, 1.187508933464314, 1.190260140598316, 1.2552202926746294, 1.2637968973125526, 1.0764284816608916, -0.1784396466363696, 0.9948225367057781, 1.0823356993364244, 1.0796692782373578, -0.20295783108476753, 1.2240671014348077, 0.9734022040606128, 1.3475339826298243, 0.8372234599031806, 1.0434468589849806, 0.8832473497410245, 0.8323879063364952, 0.7010927737413567, 1.0532143082443246, 1.0752947260474806, 0.892699340542547, 0.6420207224743447, 1.3283051860128763, 1.0047471376228267},
    {0.5250242627210034, 1.2956506047655845, 0.8932185983446319, 0.43266230075173034, 1.0710501528887166, 0.45940319524665313, 1.201395520423301, -0.06474680616643157, 0.8435655518000569, 1.043212598924246, 0.6969096093782317, 1.1173374386969674, 1.0181342894420022, -0.14218517742908038, 1.0059254624071277, 0.9266043719450099, 0.8922843249801576, -0.23141634579612894, 0.8718962379545903, 1.1660984086979553, 1.149793876982887, 0.8471580404828317, 0.825121078272532, 0.8385051656915643, 1.1951627739895156, 0.6256303158883878, 1.1356534883586569, 0.8433062210842268, 0.7583292776408372, 0.5478129758430548, 0.6761841077735652, 0.9617349580587926},
    {0.7717285239363609, 1.0541394539620856, 1.0436096017767253, 0.2386967126124213, 0.9737915736785818, 0.7015583916722129, 0.8056358737484202, -0.20617704400140568, 1.0047034585283803, 1.1988762229375192, 1.123179819746937, 1.068297058731427, 0.767492537166795, -0.19807779024721098, 1.3983256136915516, 0.8911501088602917, 0.6430912808422027, -0.142668927391647, 1.1143490959864732, 1.2280493580843603, 1.4664938952004163, 0.46932411278741626, 0.9552292117841131, 1.2602688669853086, 1.07562107988413, 0.7834806121858064, 1.0346962593640507, 0.7889918219388562, 0.5438112287569586, 0.8192805401342077, 1.1772416243181878, 0.8654101721213913},
    {0.8062306212357226, 0.9177959442256896, 0.7619734113010981, 0.3776100957624919, 0.8522927648628106, 0.838809448406033, 1.0998617672212738, -0.14765087425060464, 1.165156892119519, 1.0299203460983553, 1.0967323401421394, 1.0063771732948708, 0.9888954674486417, -0.08320867630610368, 1.0857406774998017, 1.1826669607396458, 0.684314529117818, -0.04130376214374457, 0.957283406853592, 1.1206652821978575, 1.3198143768859438, 0.6105242097459044, 0.848987432295795, 1.0109535575272164, 1.3578264800588797, 0.9432258107064019, 0.9284015508675304, 0.8898048446313231, 0.8953728938855736, 0.7637723652243869, 0.8443548314859758, 0.5711608740673212},
    {0.6010126615097836, 1.2351542064866634, 1.0170358855931383, 0.1328535557225253, 0.6916709797226094, 0.6132336928721851, 1.0280192179057484, 0.01790895341919987, 1.1087333011218192, 0.9969711833873002, 1.020613989176703, 0.8914191374358246, 1.0446167456998579, 0.16272266075946212, 0.512308929589358, 0.8890625453656851, 1.0702464206335316, -0.10913432795103621, 1.0138032405607018, 1.0700728006593327, 1.129958556868192, 0.49460108817098253, 0.8283861653030575, 1.1529231046287345, 1.1088851814603733, 0.778091390343483, 0.8408182933381079, 1.3355232881569852, 0.573304415905709, 0.821056305179278, 1.0043312285062909, 0.6749169274706365},
    {0.34586413691046297, 1.0366026493986396, 0.8615382812768059, 0.28231735021777377, 1.2093870700751268, 0.6770979325714102, 1.188540388015363, -0.008882768615976162, 1.2501525194861254, 1.082828292358597, 1.0421808891726125, 1.086146451420123, 1.212013843648412, -0.04743304731830879, 1.1313161397799671, 0.7071746734752119, 0.7234389471209162, -0.027194723748975892, 1.1464707252239292, 1.089885771543958, 0.9380017463673053, 0.4310475293819133, 1.281320396696764, 0.7946780221345776, 1.1442774529121595, 0.9387001309760028, 0.9415629885694653, 0.9851116110426283, 0.6257507992790929, 0.8786480936400881, 1.17640195831656, 0.8616816225870642},
    {0.591329775065164, 0.9885749831261539, 1.2828569580660758, 0.4541378674840252, 1.1386914652664433, 0.7146196881494429, 1.113900913975025, -0.013985630042231962, 1.27570727483394, 0.967878294145804, 1.0376668913070404, 1.1626796872227483, 1.0672101505481715, -0.2884793060232012, 0.8756770793727825, 1.024311566233962, 1.150221832454673, -0.09246769602028436, 1.0085139279246447, 1.3106746463070187, 1.1975010683657872, 0.4469300107130766, 0.6160352924468894, 1.15173152190875, 0.9397544824852275, 0.721327650150939, 1.1531654727828133, 1.2304067802813636, 0.6511334539545727, 0.8410248980152768, 1.1016338594588184, 0.8332632863451138},
    {0.4758673677081836, 0.9445048993745595, 1.38256582076825, 0.1494137021222584, 1.1973076603089396, 0.9326329042469884, 1.1589237854587877, 0.22241572192021528, 0.818149387762878, 0.9712888905709997, 0.8315733452403045, 1.1596925335511568, 0.8701124452238203, -0.21717064893850505, 1.2924781014697135, 1.208341518454819, 1.14817669669897, 0.17828736906530276, 1.1459879141981841, 1.041492361876362, 1.292738206368944, 0.629792526969305, 1.2218161104609084, 1.0285055908785647, 1.0246830715097615, 0.9967395451399683, 1.1838604457560529, 0.8019190954079742, 0.9936566004356907, 0.6903822003989668, 1.2285880778885079, 0.658140173705825},
    {0.47165354159600564, 0.9136308946718337, 1.0731971863967624, 0.40267678126593276, 1.11881946295158, 0.7722799788066567, 1.0634301171909757, -0.024487622761491114, 1.245302850233111, 1.2907164672440916, 0.9898708907802651, 1.300529363388583, 1.3408337874174137, 0.15020222269025504, 1.1526994311733962, 1.0210063032875494, 1.0561768985141877, -0.26732256208617194, 0.8976613737773638, 0.8212017067687293, 0.8786730646214447, 0.6800192731208875, 0.9593129315821712, 1.0756855533984782, 1.1275613577492034, 0.9833702112871016, 0.8916885799066308, 1.2035230317812915, 0.4992691009303272, 0.8618303371059208, 1.0350912712658993, 1.0869916380253688},
    {0.48727122291514174, 0.9453760809640738, 0.9063093642988661, 0.2702584135193244, 1.3072707055333028, 0.5709794427789908, 1.1386479533024578, -0.0963340608955777, 1.2205322802053935, 1.021875458449021, 0.821126102814459, 1.2026071630642838, 0.7986124694825971, 0.058151314890591575, 0.9511484858438615, 0.8911169048441537, 1.029846122131631, -0.24827499819322923, 0.9014771729077266, 0.8459580578177495, 1.0717457519086295, 0.7301618006272237, 0.6751419755216308, 0.9226992471815835, 1.1950680003726217, 0.6696237947491716, 1.1317491804980238, 0.8878498814561586, 0.9214520312033251, 0.7215784434632521, 1.0661546691791797, 0.6930077830439711},
    {0.4642930931040936, 1.152260988483068, 1.0298541311603606, 0.18091819020002853, 1.2011499456474384, 0.41046379911447045, 1.2707650699464628, -0.20827427282558109, 1.3091893456319854, 1.0267366360234331, 1.1744243376704466, 1.1568042149027806, 1.054364313378577, -0.10910668180051084, 1.1106270737108637, 1.3639241975005985, 0.7385115234060202, -0.016113764792896404, 0.7049604518494209, 0.982256075909659, 1.011584823822563, 0.676643820036076, 0.8971752648914564, 0.9938225949807535, 0.9385057159099005, 0.7555731103331782, 1.098654229357606, 1.1498718136160861, 0.9296494811468747, 0.6991986411383575, 0.9733384473175544, 0.7638467315860279},
    {0.018145803246941677, 1.12887158043937, 0.8074279644534132, 0.1409188745708355, 1.2063326786214794, 0.8091812642761355, 0.9320657874115643, -0.026402309095511754, 0.8882816877490586, 1.1157998872396586, 0.960547262042192, 0.999055191030898, 1.1832831582992964, -0.12792538897913322, 0.9111873701187554, 1.2020764021842814, 0.9228014728645443, 0.018834149050051322, 1.114600080434236, 1.1951444731722738, 1.0802921633479374, 0.7720334133596988, 0.7670278707986534, 1.3742448781487522, 0.8833295703909478, 0.8196771462314599, 0.9541077702146641, 1.0985646047842963, 0.908635618733262, 0.635282928357827, 0.8621773481608599, 0.798100092549702},
    {0.4837743738593995, 1.080845622864445, 1.204976691914858, 0.5110131909738829, 1.1229389912707255, 0.773550812443315, 1.0258252767883993, -0.12388127716635554, 1.0662302901568592, 1.1874829274762604, 1.1404132729618415, 1.083722643563956, 1.0739077278769118, -0.18870017134105604, 1.26788120206643, 0.9927306292642298, 0.9414096501738012, -0.36081362297182823, 0.9727771852197729, 1.022942488634212, 0.7725272563469598, 0.7401126377553773, 0.8890305244435891, 1.1165403505987246, 0.9822020253897099, 0.8369011479591711, 1.0622684699510891, 1.0073800704769018, 1.0443568686314961, 0.6001397194048784, 0.9228727322781618, 1.0786915762238116},
    {0.5074743785872193, 1.2604061974506373, 1.0408083747332841, 0.1025779747018188, 1.1846652369842576, 0.6972645044984709, 1.169077840237029, -0.07559920905912816, 1.012533144850839, 1.1151161902794324, 0.6942994000882712, 1.3350413233396174, 1.1194600027278507, -0.18283629460154455, 0.7189681527860282, 1.0494155678645989, 1.0274693130944474, 0.004013163768087895, 0.8573659363984598, 0.9315429072035825, 1.083549136904267, 0.8892552000556777, 1.1266129801160685, 1.1356131416875574, 0.6381091094158393, 0.9239539081692092, 1.099292711912605, 1.06272281435069, 0.4915563904053256, 0.7378888143204457, 1.0767176727177437, 0.862677122924127},
    {0.5912587087588627, 1.0570829333232608, 0.6724921157517423, 0.701560309141975, 1.390680723116955, 0.6438186745115533, 0.7717315092805358, -0.17660235333505933, 1.1547898739114761, 0.8560314051455787, 0.767795597812236, 1.2593466020620043, 1.0949443943230213, -0.2851482566165397, 0.91574676984708, 0.7876013730030716, 0.9260054581455619, -0.12339338051224658, 1.2417368733948757, 0.8935472716697741, 1.1297170947298019, 0.7657177768476741, 0.9251593702221582, 1.0836787917551327, 0.9306993527731429, 0.8543335658158516, 1.3648998127693317, 0.7562028081656882, 0.9146137578873826, 0.6503882313003472, 0.9697601875421683, 0.9550705934011599},
    {0.6336885026045929, 1.0908762172065025, 0.8138747739046487, 0.1439974938191831, 1.1841947947899052, 0.8843200924600928, 0.803344968826804, 0.20029615403621948, 0.79827141602414, 1.3082265723610045, 1.1590872064490998, 1.0719853459447357, 0.996817515811496, 0.12392762900923127, 1.086744281549308, 1.2789470588137453, 1.0223846369096148, -0.3497217166214844, 1.175461567768483, 1.3356883763879683, 1.2955222567553821, 0.49391013132316025, 0.7729836337306208, 0.8395952189028855, 1.073086209019688, 0.932501800002513, 1.2328226629728734, 1.0618747527423826, 0.8268626873555319, 0.6882857188792963, 0.906973685015001, 0.7953266573056349},
    {0.08868420848649929, 1.0746570508534508, 0.8113778174106046, 0.16375901547479807, 1.1056603065322954, 0.8178005500823089, 0.742808372153739, -0.1710135260753387, 1.1247207633649292, 1.236493720725203, 1.01430681768922, 1.0606259400602451, 0.9770403415187954, -0.44938258271168974, 1.1632710721914243, 1.0444845966743914, 0.9314636037039955, 0.1936209757819864, 0.9360138125879661, 1.0154707753300456, 1.3636023537355326, 0.7504430581958659, 0.7536529277601469, 1.024448325571849, 1.1979565921490456, 0.8257014725828506, 0.9457452916377735, 1.0097483079644374, 0.8160614898352456, 0.8346210505944655, 1.1437324742275634, 1.0862308554793023},
    {0.5802470855213494, 1.1008581344855992, 1.3534820834858596, 0.008143896682075437, 1.103781558872857, 0.48295293896073493, 1.1511389174475042, -0.4026098732785756, 1.1802224732731952, 1.3575300325104065, 1.0766367280119977, 0.8751690400062239, 1.1266775119389572, -0.22844167083007536, 1.0428609195495628, 1.2146183280487972, 0.8214108492833202, 0.1764573911710892, 1.3035343723878163, 0.6703113431439262, 0.8135745887733821, 0.7449199091645613, 1.1618613226233214, 1.0594755930078918, 1.028049751773297, 0.9812390494616882, 1.1722132697049008, 1.2855739742202335, 0.5820812085686147, 0.8163497592533255, 1.2269704821784533, 1.044913882025792},
    {0.9826662260738201, 0.9464114390787004, 0.9155289094949061, 0.29489538768833334, 0.6335742406384818, 0.6755624079787436, 1.1336149009787446, 0.17486597722491998, 1.0880560951676763, 1.3948346395966713, 1.2739394779060997, 1.0383043648034387, 1.0545795806922666, 0.004301536218590127, 1.2730546921227728, 0.9528033726369936, 0.8273544119114957, 0.1452488161078129, 1.3961085849299324, 1.2585746324406084, 1.1553335105697053, 0.7176182815900755, 1.1961446576236316, 1.2114496368650916, 0.9661177666011443, 0.8642666619146923, 0.9950901534989104, 1.0144916699621838, 0.528739708710387, 1.000015134638324, 1.12081751509583, 0.8924673888050608},
    {0.34797503032515353, 1.0781707281533794, 1.0115148788397177, 0.25594452573937976, 0.9140999631483712, 0.7109504114700834, 0.7084920609662213, 0.04646381080824398, 1.0362951307805435, 1.1936721770671999, 1.2657027011033992, 1.1680415527415795, 1.3684579072473944, -0.05372311674186366, 1.0244804259039904, 1.1494963857284426, 0.9390517644475693, -0.2791577236683301, 1.16902926678278, 0.8208782579317165, 1.2865312608582207, 0.7041938654294714, 0.8993370702802658, 1.3633963061303793, 1.398562415532126, 0.7390877760491124, 0.8037676824730475, 0.842914952318857, 0.91996536524751, 0.7233569374148909, 0.9764566509580502, 0.7636318052949094},
    {0.5168346928587586, 0.9835571906600268, 1.2198430234183537, 0.43583137286505425, 1.0761514144566917, 0.7558264501348222, 1.1330898418523487, -0.3330406000649374, 0.6381349656688065, 0.8613822060635464, 1.1116247515655096, 1.1510854874753853, 1.0544680711175727, -0.14119730059615374, 0.9242670396428125, 0.9664560612248747, 1.0905932011821033, 0.046409350058913126, 1.1412924978803678, 1.0841806284581212, 1.1448237788763298, 0.8354039457161071, 1.001879624078847, 1.085638863806526, 1.1965549038064465, 0.9353471991600829, 1.178398342151091, 1.2248282085964202, 0.7319582795708648, 0.7276924377376951, 1.0137783221044103, 0.5670448849489462},
    {0.707170573292255, 0.9664104601166554, 0.7660817354001994, 0.45465328645827535, 1.1450601744376878, 0.6882905505381569, 0.9719813615236481, 0.3903374122407007, 0.9968115137251715, 1.010168941323348, 1.071777443450938, 1.1934030018351356, 0.9048987988655528, -0.0885066315757576, 1.1522246460795347, 0.9605830654832743, 0.9203740886138722, 0.19283742381639443, 0.8676531632099955, 1.1997398410673064, 0.9803818724533074, 0.6741801749278958, 1.1305653714700192, 1.2361691305256632, 1.0371389676421767, 0.8716211756036506, 0.8742542281666706, 1.2124166592766632, 0.8908389532728925, 0.6138042349799878, 0.9207130513910206, 1.0138004166558912},
    {0.350470923405672, 0.7637207173639583, 0.7354601830268598, 0.22791681665347283, 0.7821156090259745, 0.6372505098151114, 1.338712839681661, -0.06074486710875606, 1.0337950217790404, 0.990643259580331, 1.1021753557966096, 1.1865425798430513, 1.0466517781535731, -0.1241788988146002, 1.019140647963035, 1.021534006994103, 1.0843532956726127, -0.3302287304137832, 1.0438967548999865, 1.1737573715557947, 1.1174878668507395, 0.7054585880040227, 1.2196073379148364, 1.0524155427607857, 1.140088007223157, 0.7042906271440599, 0.9729508624691007, 1.1543559647901813, 0.7460151342935032, 0.8643165530167762, 1.0091049541456854, 0.7964075632664425},
    {0.49151716104782095, 1.0828932859436267, 1.2500510419088269, 0.4343902182396134, 1.2364352443924085, 0.7431340022011527, 1.1965622494631651, -0.3040247445380044, 1.026551941914671, 1.3236262923546607, 0.9684583365961177, 1.0505804181444323, 1.1816518811018983, 0.11400828102832629, 1.209494531173565, 1.068518787048425, 0.7970332816211003, 0.025361594641643177, 0.8416555881693819, 1.0393924569942299, 1.329836293463578, 0.8081020068617376, 0.8739670254467803, 0.9031930564869617, 1.2080420478089318, 0.5747088989350065, 1.1214817577543696, 1.1765648518044765, 0.7361240371118684, 0.7272802827194705, 0.9211340806521274, 0.8722525184836928},
    {0.29099024483424174, 0.8329623185820594, 0.8478600832874073, 0.2836334974611285, 1.2474100132632175, 0.8249517860741394, 1.0361517641730242, -0.1524257216346815, 1.0452099476233117, 1.045657249742619, 1.0439593920326238, 0.8675351934147506, 0.7985566543719388, -0.5283660622018271, 1.0298759786285014, 0.9691140888885124, 0.9356248499092997, -0.2835560522408119, 0.7948837886413442, 1.151662366879164, 1.180928933346938, 0.641356965462689, 1.0643009795084661, 0.9767690611786792, 1.0021060924222425, 1.0646039382891075, 1.0284976638566259, 1.0023926092839701, 0.6353607076911026, 0.8685473016100418, 1.1805919689642148, 0.6365058766005517},
    {0.4413678073955393, 0.883013509199307, 1.0710956313943696, 0.19694851496055266, 0.7721914704464613, 0.7764848981469848, 1.1641161109136162, 0.07805878030430108, 1.1454971868283434, 1.2222071537337202, 1.2174902335518303, 1.0971167386159026, 0.643586957117616, 0.13567570378928107, 0.7501117644654716, 1.005790936166035, 1.323416395801207, -0.18173291994989885, 1.2274107249345787, 1.0802252356197684, 1.1628437406971353, 0.3244367798870766, 0.838341808298805, 1.1819776303202922, 1.066142735239857, 0.6756876874589359, 1.664454969743525, 1.0544016134817031, 0.9950484776986633, 0.4738297606420852, 1.05067292638985, 0.5090847571770432},
    {0.6933086804789138, 1.0837512578175181, 0.9991815543837085, 0.18324942246064294, 0.951320240138401, 0.6986134473487822, 1.0590002389126627, -0.07176056052935784, 0.9161714330237258, 1.0099287793845326, 0.961477554647926, 0.897277529518801, 0.8703152128246269, 0.07654131473590521, 1.1534091468259964, 0.9586201243186745, 1.0726862341980021, -0.2560978887577044, 1.1582495411390448, 0.845728145524408, 1.1243245684020768, 0.4406841864988754, 0.9551125881288367, 0.9940979516865782, 1.0650987522816644, 1.230239667912205, 0.9037657914205823, 1.2541522546168395, 0.8341109160845703, 0.9379820166348943, 0.8033086484660069, 0.8054017630652458},
    {0.40532288874840333, 0.9514737608591988, 0.9196331970440312, 0.3691852039369739, 1.122926994297572, 0.8501211725097199, 0.9895072070913503, -0.07820420346930372, 0.8129021567831308, 0.8123616958857781, 0.8988880816975389, 0.7627096039069617, 1.1229916705072354, -0.3036214106812291, 1.0966921813602648, 1.205148709485884, 1.2769341879982892, 0.012726461668327289, 0.5757849728745216, 1.0475792178271939, 0.7147664858837844, 0.6922533988836216, 0.7785019813063663, 1.059033378447494, 1.541290801895199, 1.0503421313233303, 1.0888804280575175, 0.8860800471833192, 0.7670040137852049, 1.043186624875824, 0.8409903753522739, 0.7210845862362831},
    {0.4091775413988287, 1.273541914232668, 0.9620148340749621, 0.19966657344878852, 1.3772714097270053, 0.5660759839181099, 1.359846715091631, -0.18867989854785266, 1.060676521761698, 1.241190705776086, 1.3003497470019483, 1.1404919194381988, 0.8842376839738739, -0.1779608470726567, 0.9136825981764016, 1.0704173806026633, 1.0037228059259884, 0.10624222389009665, 1.1196827808485175, 0.9931986957238463, 1.0948661156216464, 0.7766909318866438, 0.8132183644147695, 1.072078865883102, 1.0831359772963358, 0.6042542671850788, 0.9317519348916649, 0.7582300343334915, 0.7769942717407551, 0.6926049785584077, 0.898132650392925, 0.9159587631664331},
    {0.7267016675164528, 1.1524760758422468, 1.034004965759476, 0.3392863795541257, 1.188572674836175, 1.0060006246424966, 1.0039819393726557, -0.06257483188719556, 1.1788494987580236, 1.0892310434528931, 0.9045381100355585, 0.8244499296751472, 0.9823018741778298, -0.30846286087955777, 1.8547497625588203, 0.9412462840760606, 1.0948493044995917, -0.10171987128923957, 0.9071304884224072, 1.270222104129692, 1.1780380805025443, 0.6717842969704491, 0.9079702887903434, 1.176639008733367, 1.2887886862200424, 0.6725478641693445, 1.0723619445420394, 1.031643854826651, 0.3729922215443149, 0.64162843997557, 1.1267009741949747, 0.8393221123795802},
    {0.4987488290546294, 0.62397571592854, 0.8472245525119594, 0.3742288673272684, 0.9553325405406007, 0.5975228256442813, 1.2184295961472544, 0.2194084120707795, 0.8769510155876539, 1.1343064052522078, 0.8434349759324039, 0.8506773430988673, 1.272607621318949, 0.037262783234061535, 1.252715445843009, 1.2651228851321137, 0.98593888467317, -0.008132335557816653, 1.1291803908477163, 1.2689935890559143, 1.0735185290650038, 0.32614705415974954, 0.8313229625123322, 1.1802419450233965, 1.0396560526579124, 0.9857515854345842, 0.8996284451493157, 1.0579490892337784, 0.7857549766956635, 1.044073532980855, 0.9793237496406992, 0.7774511475969692},
    {0.8585879677227104, 1.2852939771684526, 0.8087319209471742, 0.14897126212688847, 0.9562693890930154, 0.6850798638339021, 0.9462164889611707, 0.24504910920458858, 1.228021039145007, 1.0606768091464347, 1.0145650313227639, 1.1983846069597028, 0.7914836421937924, 0.009308040049463437, 1.3539469334728662, 1.0746474915594952, 1.1447988218074725, -0.22319602873642466, 1.0123659748827232, 1.352849168529047, 0.8294466322495335, 0.5832484708589318, 0.7142251623138088, 1.0051381185742556, 0.8937050020160394, 0.6388627109709987, 0.6985352266269432, 1.2675206768281, 0.7872509535721872, 0.7104955014691593, 0.8798768295250464, 0.8657745248068777},
    {0.5420868886421141, 1.1729279514079674, 0.8057469511525412, 0.5961367485313879, 1.354246952771182, 0.8337293952230401, 1.0061050488918721, -0.1545981299270451, 0.9787345432161282, 1.4037565735267246, 1.1381046671079904, 0.840519914811116, 0.9882841651178431, -0.14140123220730752, 1.1877857837523365, 1.0098853840377888, 0.9163966255798905, 0.11733716916075958, 0.7003549532459095, 0.757956892401217, 1.0676362081421324, 0.5576819371944256, 1.0352604909429677, 1.028921512636302, 1.0431151614076986, 0.4846282543999526, 1.0595269501449935, 1.1661654771766006, 0.9867521070939052, 0.7782874137211806, 0.6109732401527906, 0.8357007914338366},
    {0.5987718697780139, 1.2374823904358232, 1.0016193498532577, 0.38657613418749626, 1.1596898673973521, 0.542891097356961, 1.0779325905648152, -0.015642996950628495, 1.0512654965933799, 0.9835070858968019, 1.0267369667767507, 1.2046709867399872, 0.7477291749534609, -0.2215407732344886, 1.3727783920309622, 1.0524389940172971, 1.113157261791073, -0.22418307443177754, 1.0949276310433114, 1.0681906508069192, 0.7975849050975032, 0.6819575422792654, 0.7386153314799674, 0.850177363043953, 1.1116272212845455, 0.7205188184212746, 1.004349348945945, 1.419044584703187, 1.021473904462699, 0.7726720125298218, 1.0436891537983646, 0.795564727038435},
    {0.23072301562180736, 0.9664667435287757, 0.7504483102101239, 0.07836335033238677, 0.843306629883585, 0.7603703120516243, 1.075537273663656, -0.39501604997141526, 0.7798659559481145, 1.0910789281829105, 0.7260056043995352, 1.204502908881483, 0.71211441479527, -0.14120941186948163, 1.224194739321495, 1.1175357807395554, 0.75861845263376, -0.22405856086225137, 1.0321345350009066, 1.0722808787848295, 1.3102087320001778, 0.33761887747920744, 0.8314305849303032, 0.9306665853748353, 1.1872291107585973, 0.9835356059892241, 0.9467905852941069, 1.2953195203951409, 0.6367134467915841, 1.1240802856326373, 1.0134570531620373, 0.9193475625258839},
    {0.5537587233986323, 1.1105029312867638, 0.7873352810235927, 0.20470376103878793, 1.1119419946085591, 0.8499480865852274, 0.7953490895282117, -0.3258974056648158, 1.0713358013971577, 1.0265394782214619, 1.0365041696210362, 1.038518261789132, 1.3203079840588103, -0.060325051862227565, 1.2477755982959506, 1.043375936143917, 1.1101075706753554, -0.3236066716793899, 0.7832799479782543, 0.8557400500646244, 0.9259172048940679, 0.8781956571720347, 1.1682408418947485, 1.3869978523968605, 0.9674808928370563, 0.8145561581520304, 1.23220490745647, 1.2898435543597515, 0.7733444815203304, 0.9304050332327073, 1.0647158697726478, 1.0218134944791901},
    {0.3825604740914192, 0.9483763606730594, 0.8172973406844107, 0.6227217578588198, 1.4269500787424814, 0.517032158384984, 1.0495644545340224, -0.1648428039515567, 1.083024577435191, 1.2652622708581884, 0.7825990578214119, 0.9092931694355346, 0.8021248950643695, 0.5181460809468246, 0.8652850202489946, 0.9236927326308891, 0.7559874254766505, -0.1122887854083736, 0.9319810876563702, 1.1942012165604234, 1.2835693287074939, 0.983035703797548, 1.0652538795140103, 1.07851932834204, 1.1834567252194972, 0.390931402946246, 1.2021265100878409, 1.2818874611156477, 0.6087948808821091, 0.9559491843664011, 1.0928802885301148, 0.1954063809783007},
    {0.3434888999265105, 0.9833568493557296, 0.8602365132613131, 0.31992745013779256, 0.8903908770400613, 1.031287931042256, 1.22350929111658, -0.02176698971932105, 1.0127128068018132, 1.0215560529798984, 0.7517889472145426, 1.0066224300208293, 0.9485545387624232, -0.1907750026928767, 1.0879348591201516, 0.88207006144107, 1.0260893762483663, 0.16935002838912916, 0.9871924042533887, 1.024695592329131, 1.1387824229122332, 0.8979898490033354, 0.7104865347254379, 0.8426610961492648, 1.0425718415247685, 0.9854203011351168, 1.1275320585864577, 1.0424694462013988, 0.7446224733193497, 0.8633417861472341, 1.0274216663531481, 0.6412888578995708},
    {0.4601938457598509, 1.1361479903524294, 1.051831871652555, 0.5737855113583411, 1.1123716762514644, 0.9803712599040055, 1.1761957539755719, 0.16149453705600228, 0.9218013367754226, 1.052179600687207, 1.2871186635052536, 1.1343739200378087, 0.6857538045821904, 0.09761762708946714, 0.9621996755510985, 0.7478999543426468, 1.2259250143060714, 0.02433866203080889, 1.0538258507993243, 1.166122390759993, 1.2931154385133132, 0.719906410628508, 1.0110049656387963, 1.1676590507306617, 1.2478880352258355, 0.8390102031210862, 1.253655463995548, 1.1256070854836429, 0.7803434310707339, 0.6996868681479899, 0.931622919727791, 0.6316997295602363},
    {0.2676014669383498, 0.8979250375533163, 0.6765794036100418, 0.07542380904684512, 1.015796158928978, 1.202381384205384, 1.0272443883965343, -0.13113462570204387, 0.6694608048052306, 1.268210534730691, 0.9979124823730946, 1.0722290300612527, 0.8413281477438661, 0.02075214836521679, 0.7457027604747133, 1.0539544887818166, 1.3123956216807366, 0.1207230962834824, 0.8271224312224305, 1.0636252462926306, 0.7353074130740213, 0.36325466158140723, 0.8651501183322864, 1.0902257324008688, 0.8878043204730877, 1.1414872394098468, 1.0000582138127982, 1.1366292929506894, 0.5030389972484588, 0.9135873300602831, 0.8811847567821982, 0.7737979042946006},
    {0.4031871345027279, 1.1465765904228387, 1.3043382401979182, 0.39848949873116235, 0.981167736626933, 0.9478767636200797, 1.0776493311765256, -0.26440319941963597, 0.8355114018864197, 1.0999906012796077, 1.1783771438588895, 1.2778614172177825, 1.0741421778096303, 0.18382386233565265, 1.0659657240698615, 1.1730509023910278, 1.0980374230020638, -0.043149632682332593, 1.4543740691354954, 1.1570287735598477, 1.0737958997126986, 0.5032869941677142, 1.1061426888611197, 0.9041718367479283, 0.7050345048389464, 0.9872702179266833, 1.1990540703160528, 0.8723166422935982, 0.5463045374449, 0.45875682000656726, 1.066267095377947, 0.9027721711509112},
    {0.5391235135575362, 1.0553914523880423, 0.8146690549825083, 0.3944657359558325, 0.9004513435724187, 1.1240479009007602, 1.1684490125569371, 0.02487378511583951, 0.9755313572949255, 1.0819225106558543, 1.058993482200605, 1.1937133968835547, 0.818007180406481, 0.037126135387191554, 1.1402763178349558, 1.0430714076368128, 1.1617744770670277, -0.19339753713605845, 1.0634930911361014, 1.2233015039052104, 1.025550474364732, 0.47909066895534314, 1.0222834568277146, 1.1925254050218423, 0.9923903230611283, 0.891480424236308, 1.0617134888235642, 1.0196731263416938, 0.6484127155199622, 1.1547837052645995, 1.1258567236463508, 0.6125822478476876},
    {0.423748614123778, 1.0767954570545513, 1.1459354236062975, 0.29568167643579674, 0.7325874412128155, 1.182842761511015, 1.1500694700975267, 0.07543599117422542, 0.9810926134053515, 1.1614694926643157, 0.9491321313183196, 1.1374749588476942, 0.922158266059631, -0.12711758570464265, 0.8540476896811294, 1.0035891327576352, 0.8320276758149869, -0.14506919653903302, 1.1756174121792677, 1.0034215797456734, 0.9809792310871126, 0.8663304570244986, 1.0893697845446022, 1.32874561501685, 0.9795045928828258, 0.49573596737536185, 0.9714077355531793, 1.134924320378169, 0.8747107987233498, 0.6487535254623784, 1.0031133989936247, 0.8603566264326977},
    {0.5640698461262155, 1.1911704302983062, 1.0437565551517616, 0.18384016799632413, 0.815540402600312, 0.7319446521449763, 0.986212894541148, 0.05352435152555085, 1.0507117381766262, 1.165672948956962, 1.0825293054862084, 0.7261714627430121, 0.7854098075051273, -0.0966142835948759, 1.265074262948089, 1.046510145709481, 0.9418928087914059, 0.1084441397655831, 1.1920678173099026, 1.1803948484474525, 0.7704160788422282, 0.7837526345450454, 1.1381625690551067, 1.2355530317584433, 1.1993245547032414, 0.6807585140491063, 1.0357877227605177, 1.066924734033412, 0.8326896006680032, 0.9053835267764456, 0.7262866199558125, 0.7756341802841745},
    {0.5150533888560386, 0.9897846356319094, 1.1958023373408555, 0.4224933806805155, 1.066342677299474, 0.6494963212005105, 1.2246829334074656, -0.14008001479340693, 1.0657418846266768, 1.2277744530528203, 1.3107087914236384, 0.6857708122816895, 1.1279777048508943, -0.056286298362290044, 1.0569598855828626, 1.4097230001098622, 0.92227105990316, -0.1900200951264977, 1.0947126215340022, 1.1948765301808102, 0.875321043413813, 0.6682777319811076, 0.9460139883648109, 1.035305062192761, 1.2581886670516385, 0.809197850573126, 1.0797375699494909, 0.8947115096996674, 0.8507697862688299, 0.799974562793745, 0.7868087012462164, 1.1307259893370267},
    {0.6455633056838184, 0.7645205338312653, 0.9292519402872903, 0.27549523620810595, 1.032806577390818, 0.9937850572734234, 1.21003922881988, -0.3170010412951636, 0.6614046670341107, 1.440114169785156, 0.7234851927118963, 0.8432580445592693, 0.7322502723793362, 0.07509181364218552, 1.0670207101981775, 1.271956486062395, 1.2234750857451708, 0.2310580983329194, 1.2300259501599011, 1.2304312163403284, 1.0724702579094694, 0.5425448393070291, 0.5545389460833539, 1.0397174545976198, 1.088846857035937, 1.0660269218867, 0.9184456577719813, 1.0789677663437225, 0.6625843380628422, 1.0035003697733265, 1.0920281825934484, 1.0731902010037015},
    {0.40651816729425505, 1.2302384653841476, 0.9126671217657104, 0.30670395616221646, 0.9884627617931029, 0.8510409420074122, 0.9556774545426497, 0.1947108036892097, 0.9652631478965353, 1.5131107201053873, 1.190336086063568, 0.9684543603952933, 0.9707821814698062, 0.006769381294948378, 0.8842535567098327, 1.059775319450589, 1.2277448379082514, 0.24999035707026615, 1.2403396069502, 0.791183097478933, 1.0629731144939019, 0.3477369992935633, 0.8741801744056494, 0.820641390235909, 0.9524569874045583, 1.0928573444230378, 1.1107271897217388, 0.9324066888210956, 1.1239333285492394, 0.7164774139086854, 0.7288670779163018, 0.479765018672459},
    {0.4362441191992924, 0.9481884202338043, 0.8929787785431076, 0.07566021680497009, 1.271751463493098, 0.6936963623187417, 0.9835661325271051, 0.15928757775348354, 0.7770278208694062, 0.8411919897189097, 0.8612787271661784, 0.7981508544676355, 1.0838350920426791, 0.0140438412638343, 0.9659322083802269, 1.3200812281519463, 1.033178126436058, -0.12354207507524244, 0.7142968085981508, 1.2436743965291503, 1.4164873823300888, 0.6295810939403599, 1.1786493484712697, 0.9449396056841277, 0.8986590200372833, 0.8245881398220497, 1.0495172142882192, 1.187362267307703, 0.9124875038400133, 0.6790874316679868, 0.7585850559022951, 0.6064459628484333}
};

static const float b2[32] = {0.4987634830707196, 0.9815257335015194, 0.8947277646086493, 0.37582715880589684, 1.036378904700618, 0.7727445483494225, 0.9907450318869909, -0.07971582705341064, 0.9520337028746033, 1.0374442757909474, 0.9454772956486002, 0.9491417501218287, 0.9290337337033736, -0.1112959054747477, 0.9913988324190308, 1.0230368615132217, 0.949367068409327, -0.09866387529165963, 0.9629084663114202, 1.0460301805643875, 1.0265993439769105, 0.6353910317284667, 0.8919777100747066, 0.9748419068079213, 1.0395266308965565, 0.8197039900248013, 0.9402113998356227, 1.010918443590877, 0.7518048002068518, 0.8024952018788885, 0.9008687184655292, 0.8249733825386651};

static const float w3[32][16] = {
    {0.851027034814548, 0.4709202657650037, 0.18322661500533066, 0.055411778429624754, -0.302778150696413, 0.8792896692502228, 0.21225679060714442, -0.110717215639341, -0.27299705984505485, 0.505618675579103, 0.2743345294403544, 0.9783091233262144, 1.3111662773158863, -0.18028120956435487, 0.08999291935396943, 0.78950393282119},
    {1.0899863239942396, 0.6805355682510699, 1.2694342453364569, 0.13143584397690652, -0.22393639546525448, 0.9605643796933944, -0.45707885409398513, 0.17314220046945125, 0.2921987801977783, 1.4210943991335203, 0.33360411111872307, 1.1996673498793735, 1.448974923166335, -0.20541464260118067, 0.5078826411010738, 1.1937726043056578},
    {0.9613138479705718, 1.2725502013366636, 1.0235258238003075, 0.009018682258988303, 0.17226183141681142, 1.5076094219585765, -0.37091352622132484, 0.24307457748300673, 0.22836674678122418, 1.2813053282855706, 0.19965613633184429, 1.274542788811939, 1.5408479900922774, 0.5259691852779855, -0.14626050369946333, 1.3844324787822633},
    {0.4951203506868641, 0.3374405483099165, 0.7937519921595692, 0.16155214139447116, 0.055141294922657694, 0.490941436199782, 0.47832225945941365, -0.06675687828602853, 0.18797721744146473, 0.6052007869515731, -0.35838910901155374, 0.4443688195045694, 0.41230648474477966, -0.1779338776976776, -0.4397919096963629, 0.07088772307065269},
    {1.2836476051441006, 1.4744686434048098, 1.3222987991162354, -0.06959803548061774, -0.027923623197897898, 1.4572015137542513, -0.43014090172522296, -0.13278003122093054, -0.12411292101579634, 1.5709346572773584, 0.0028458759739348484, 1.0695316592300046, 0.8980299195989594, -0.2938540531352718, -0.2783320017149108, 0.6783879778461556},
    {0.5341468585480222, 1.07534137535679, 1.0643127917203898, -0.1361731495084751, 0.012882716816242597, 1.1916561223825761, -0.00460325902038399, -0.17354976273684636, -0.12605915217509558, 1.1653964214801729, 0.19512173446864509, 0.9128782027597002, 0.9903788367838449, -0.18108852562153768, -0.019139783999710645, 0.7612270424998557},
    {1.0170026679541107, 1.1480967129200457, 1.3323086402261095, -0.1217058871320999, -0.5066445897929589, 0.8062813665850581, -0.07650272047591773, 0.07342995809567868, -0.20102591506806589, 0.8764482923523065, 0.049758314402960115, 1.3347477659423095, 1.1776604595839326, -0.2787543995153034, 0.19681827521732503, 1.0675391471122324},
    {-0.4192352132470623, 0.377040631295435, -0.6540091374049701, -0.021920278057527064, -0.11946721776065858, 0.06432926268527, 0.2678434742962674, 0.20080042452412683, -0.11889602656103222, -0.013160890822060529, -0.3289517480108716, -0.2816469849128262, 0.28332794073146056, 0.012340799285945484, -0.20102698889200452, -0.27123069399685834},
    {0.906766377651078, 1.2280233161486573, 1.1319652053101812, -0.0231177914950463, -0.1054508171325709, 1.0369656220553518, -0.07750271535500101, 0.29015335606966297, 0.10438654709668177, 0.8754093926915136, 0.11623368582572462, 1.246798181016854, 1.588336006835926, -0.12086990378328316, -0.07988495054231172, 1.1375229723550884},
    {1.2011900837030114, 1.2160056987579342, 1.2922603506950447, -0.018560110504523046, -0.2702412107717174, 1.1107929718811045, -0.4790747389051153, -0.15062102883398878, 0.06097727530692725, 1.430461630277493, -0.008338602819162134, 1.3296756901432594, 1.5709385605550668, -0.341374451837187, 0.04662665836076266, 0.8584098690933717},
    {0.8819144898652248, 1.0556724516809566, 1.6167506903007758, 0.010877905073122111, 0.08986905269982426, 0.9170870955360043, 0.266794971197014, -0.6109327745024564, -0.08244449175513296, 1.0037529150177964, 0.16263607026213137, 1.2479980331975533, 1.0991689430855107, 0.330164853473077, -0.5254967722135141, 0.9058370885422309},
    {1.2176834278261248, 1.5170925317703594, 1.4674771423329174, -0.049545422085771555, -0.2925258142249803, 0.9222099363866875, 0.26012931944497814, -0.4041712146008485, -0.1267353343065438, 0.929610568211202, 0.29462464474233385, 0.8095798751084474, 0.951520570999724, 0.32296757992510255, -0.30332541249439293, 1.3870817098690649},
    {0.6264495349665576, 1.2020950039490177, 1.3062148750351934, 0.2560782849840499, -0.1460316969627709, 1.0794654286659549, -0.35780223780604087, -0.3835657214349293, -0.23587380753197554, 1.330947987503468, -0.12824296620119985, 0.5053190416960719, 1.3155215606884587, -0.5589970247971727, -0.19668046238119344, 1.1580934614142284},
    {-0.1871561398416753, -0.21387610300681317, 0.06675925230219626, 0.23281995239726366, 0.3606148970999519, 0.3655082665868787, -0.23515083045127838, -0.10281017526251121, 0.1556990427178102, 0.07357030188935038, -0.17914169183374634, -0.11036764628163499, -0.08536399896322021, 0.27008757773183056, -0.25401778497517064, -0.16245528422770072},
    {1.278638628184926, 1.665098043834579, 1.4244728984598163, 0.05586176517334966, 0.0996649990027389, 0.7716548624915658, -0.29378337779549873, 0.11218207229059056, -0.036051270403515925, 1.5355001574316165, -0.03099819398409496, 1.0871249477284461, 0.9766308318572899, -0.2926292914863092, -0.08125973618928994, 0.9545529289178417},
    {1.3311255154385184, 1.6375283275178905, 1.3061073055956622, 0.22271167888219695, 0.01794128436723165, 0.9016588093152907, 0.29226858336089784, 0.018214051832071258, -0.34856919580108153, 0.9175530706486225, -0.25827094957231816, 0.8523485079025045, 1.1970995381118303, -0.18403708083310405, 0.15647744050959564, 0.9900363002359852},
    {1.4504231914176124, 1.1005682874353269, 1.0726126533788451, -0.0018599369922796694, 0.075440722630813, 1.074836255193519, 0.24582879688553702, 0.1177523298017852, 0.0734786895461396, 1.1111284121037188, -0.21706854603955886, 1.4659736152717189, 1.2535993030024393, 0.25166288387325464, -0.3891468987747223, 0.8240577041803129},
    {-0.4021875931622483, 0.1843214503525963, 0.12995715047313108, -0.2649895283664368, -0.027863267021234168, 0.2719662667323785, 0.38852686944077597, -0.12118674581297964, 0.11427430157048785, 0.10375680894554834, 0.04926651917719316, -0.34862916068484107, -0.18078162396356862, 0.44794459912072365, -0.39264476953104605, 0.08234430021731504},
    {1.3815909405476174, 1.0361365620616403, 1.2060093391999769, 0.3744252009865812, 0.3683973154386216, 0.6346655834107151, -0.333249667745622, 0.36464066563743713, -0.15782604147985654, 0.9306939281612338, -0.08553814038568244, 0.782939724808523, 1.6767465533108745, 0.01500694296829486, 0.16241166108430757, 1.1956310690785241},
    {0.9583504734830212, 0.6647167491622835, 1.736344797370846, -0.41384767624097707, -0.034815427403490626, 0.8758853983733228, 0.02086703877684631, -0.049063532484815875, -0.08619744318271748, 1.4071338129164384, 0.1714592657365581, 1.3015222555420651, 1.0650004518015166, 0.21074681152249744, -0.04298018675063977, 1.3892620712956072},
    {1.2395874935218594, 1.13452664621261, 1.2358898481944258, -0.2737105002791732, 0.0340323359364833, 1.1602356304475687, -0.10178662758828684, -0.21159491332720007, -0.16596888336931145, 1.2844652701629102, -0.2445134297001393, 1.0746923006064293, 1.157554232080191, -0.10497495561078499, -0.07629817905236863, 1.3720383642174308},
    {0.46025248969656185, 0.6983117997824044, 0.734703828392094, 0.0651050984617709, -0.07659418903301386, 0.6339102251595096, 0.036471184264891626, 0.24834517433634914, -0.08479685169852093, 1.297260599789561, -0.16094364136396788, 0.6013142981490085, 1.0765841369729565, -0.108564593636852, -0.09411267470044458, 0.9192599099095313},
    {1.2665591564833136, 1.1227685872766777, 1.2775356456006342, 0.34939917668453563, 0.3514403360626549, 0.9508719664613413, -0.3476261237931512, -0.2947598881910717, -0.009992753458765971, 1.5137937592819688, 0.060495911135985576, 1.2415690853159498, 0.8285337300444896, 0.43986603179925915, -0.10766561281525563, 1.5227925067241384},
    {1.280272003091885, 0.9235419676465615, 1.224624455737396, -0.5383817107086024, 0.19459991811194294, 1.4917227204026804, -0.0011218101960104327, 0.016817544216482655, 0.08907317278118995, 1.2447988212444256, -0.12941472739737037, 1.1429541852626766, 1.2718537662575087, -0.2258512024153409, -0.19870184800101234, 1.477045888681187},
    {1.2468195829216762, 1.0524378920823978, 1.0284252841287573, 0.03466264639089085, -0.13490785551079545, 1.392545769433171, -0.17373128313026903, -0.378105248210376, -0.12796167152669916, 1.174652519128347, -0.48019222100148323, 0.8450716685915894, 1.0721213882576548, -0.06787502741485947, -0.17854818798132793, 1.381978677363061},
    {0.8976846145720025, 0.7247349014083289, 0.657073255997777, 0.2400767351868957, 0.026593302381429984, 1.1336588938279164, -0.3201601056492007, 0.15604212607144313, 0.3207710058052541, 1.1794319874124928, -0.32511386495775957, 1.262533957776178, 1.6198996458988435, -0.03626176124767925, 0.012082111903276115, 0.8974043410185177},
    {1.0443072257040125, 1.2684917829950155, 1.2950247499313212, -0.13668731606808374, 0.3819808554988819, 1.2097355984889822, 0.23189748917012276, -0.36504509939815016, -0.08034189474916537, 0.9280903092831054, -0.1595195181314627, 0.8552886011293038, 1.06566754762816, 0.15453713916954037, 0.041999643707668274, 1.0643664655809084},
    {1.4176790153856818, 1.1810347912673067, 1.074323194368711, -0.006652166395155265, -0.3182440462436845, 1.1357850336591242, -0.5031042619235876, -0.19214465901131872, -0.16820725441224177, 0.9025178767190224, 0.2506895085467822, 1.0599191515416988, 1.0144627524219318, 0.10206818902196635, -0.25187609167429886, 0.9594465567653582},
    {1.3599812667811015, 0.6937451993313979, 0.48587944127977334, 0.31564919119779233, -0.254360959275457, 1.1045303708434762, 0.57756924585332, 0.0764508650465062, 0.13363405768234252, 0.9954760496593832, 0.3869461081803178, 1.0525192336162659, 0.7960137079058432, -0.08305503958613361, 0.1360371384098544, 0.9439817986873617},
    {0.8645435682539703, 1.3233365990434915, 1.1286674764026612, -0.07505564193294717, 0.3349593460314389, 0.9764434047157591, 0.2691426503783206, 0.03320518570270108, 0.12082453999967543, 0.9227708733891554, -0.0002617918466268786, 1.2090385571037336, 0.8458261386636302, 0.3168202426403074, 0.08407507370915238, 0.7696832849253611},
    {1.0066204019049334, 1.0398268819387422, 1.1087857694258239, -0.12544411862803495, -0.0035604578689906585, 1.4329056650032808, -0.0740013289246136, -0.20097036105515603, 0.5598480308701406, 0.9629071409944094, -0.41176563209521505, 1.0904262726060012, 1.2477830328804596, 0.025473463173160817, -0.009500152799323671, 1.2307317478400834},
    {0.8065185027725915, 0.6861155205944206, 0.8520056039384024, -0.14272184705988836, 0.16094774588480723, 1.2513927314748678, 0.20412326017531562, -0.05254205786309517, -0.18202033536919343, 1.2325370990142253, -0.3206655479436622, 1.125916467396649, 1.4345207702799874, 0.12932286587125247, 0.2224651273673642, 0.9689050081584921}
};

static const float b3[16] = {0.7227328142519343, 0.7119355792337385, 0.7315733045328903, -0.03537679071235728, -0.03610017763813173, 0.7844611838831556, -0.026898600903659343, -0.037333768982558, -0.03893905471547279, 0.7758737505829388, -0.04281944815185439, 0.654018423468523, 0.7476110805850109, -0.022866060462364387, -0.049301185988253705, 0.6337380712530238};

static const float w4[16][12] = {
    {-0.968772558375214, -0.9846482634132678, -0.6708268823135163, -1.7574167401083751, -0.3677201882852987, -1.285031967351065, -1.3781133726623356, -1.7410107820904102, -1.250123642103606, -1.659643516769167, -0.8585484212042356, -1.4272539390727068},
    {-0.8507159869763211, -1.3294626314187294, -0.9122419108684541, -0.737908192712232, -1.012480713376829, -0.9927502139860749, -1.1502646322856576, -0.7414614999634335, -0.9719648277166115, -0.3381014679449095, -0.6886066918756037, -1.0190379455780953},
    {-1.0241807836861891, -0.44762218414208316, -1.4410734329149728, -0.8435755969816805, -1.1675610880206828, -1.8623113152661361, -0.9624155460513516, -1.1738252118796062, -0.8132727303605175, -1.0057724291314223, -1.1867305558701697, -0.5951057180610647},
    {0.5050418275713969, -0.6007290497980668, -0.18611206938393626, 0.127296877567867, 0.3747616883374511, 0.017614136489689024, -0.1675311292015703, 0.2200692638317118, -0.3728967623914377, -0.16089340281410364, -0.07250015795391893, -0.36851417242475704},
    {-0.8503356731053113, 0.2143969316377375, 0.3752384962822752, 0.04656474749677443, 0.9677680554325159, 0.05319573608036737, 0.1343831201982252, -0.3608407394741651, -0.18053905969139916, 0.08012035428933958, 0.33195130590801664, 0.2735415049579739},
    {-0.9241769289550231, -0.8141511535094204, -0.8041702385703889, -0.9608676223343788, -0.886318098338869, -1.2706552351836187, -0.9015791658723387, -0.9275259403165138, -0.9155211041307536, -0.57796004885905, -0.37360845222199945, -0.5351023616578372},
    {-0.7052528926899901, -0.05332398673259556, 0.12666516486173846, 0.45238237576547563, 0.4469528205020205, 0.03230116508642451, -0.09912624306439963, -0.13411997592012082, 0.1816851136629878, -0.1185084978260251, 0.1092212716627487, 0.26914973912080253},
    {0.6086166919601629, 0.022235451040867032, -0.4961748351960916, -0.4109763529230524, 0.22477039193199874, 0.2184649072045304, 0.09150805651608668, -0.0034776601049899304, -0.2310934217404967, -0.3398551454595232, 0.1867914090608412, 0.0136840264737992},
    {0.200402658635695, 0.1818830711978279, 0.6120387670137353, -0.0006714483252967411, 0.26786487949472415, 0.006929168427183294, -0.4098163601670743, 0.03221521776848476, -0.10361567277137619, 0.38361817111087615, -0.0910239741250965, -0.20329687170819397},
    {-1.1838237194016872, -1.3409586165423089, -1.0456590008232804, -1.0045162254370126, -0.8222244453771935, -0.5056278547534728, -0.6806805020115028, -0.6931190112965255, -1.51743854097199, -1.3820442436532125, -0.9547182656778803, -0.7690604116685367},
    {-0.1569724197700435, -0.11822665075542924, 0.046007817071886226, -0.0034654921020845666, -0.35966760573046586, -0.08073319791772428, 0.05898172749430925, 0.3482992335987002, 0.25465453596955584, -0.08198756486313506, 0.37618094228397825, 0.41331442524844203},
    {-1.1901684640203856, -1.3471004956978156, -1.0270896504460272, -1.1542708438611369, -0.9064088409031869, -0.20805934809101173, -0.5857534321860358, -0.5390199307626281, -0.738466233168572, -0.7807929795664396, -0.5923426446007344, -1.0149032580303208},
    {-0.9284557432955527, -0.8629171498620715, -1.028861107181113, -0.7163021658758499, -0.900513958554844, -0.777751387800956, -1.0373710906199956, -0.6986292652161357, -0.712421745527812, -0.6487769520206357, -1.9152516152643633, -1.5511666485713114},
    {0.18931635030332164, -0.710520244675769, 0.6914576704936155, -0.17355819948848378, 0.20509509452993138, 0.02749429831820561, -0.4332914407118105, 0.03439895459098375, 0.06810376561933083, 0.1546793606803604, -0.2698819311010522, -0.138016045692878},
    {-0.060162214378510874, 0.1762756941563159, -0.006144695986274966, -0.22849571377791458, -0.3060995231924551, 0.33096471180322834, 0.2845763611492657, 0.4198397811596126, 0.1811760595068147, 0.04236218588705869, -0.17326666556950054, -0.5127653769132701},
    {-0.5422196117681429, -0.5463343252002383, -0.6072509708616008, -0.48592709694086733, -1.5433347487464233, -0.6795686478927877, -0.9217253733043953, -1.0446213672291582, -0.6726265920994056, -1.2498221822971327, -0.8918493590818751, -0.7091173226377403}
};

static const float b4[12] = {-0.30570717921392526, -0.3319014137211059, -0.3659823972136845, -0.3025436833402823, -0.2713730656811574, -0.436394720416539, -0.3662575687388487, -0.3806448232459205, -0.34268088869415886, -0.3403467081897557, -0.46773897893965466, -0.37414975003170164};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
