#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.7694914817350531, 0.02682968409217255, -0.0008137413645845012, 0.00880471501685831, -0.14749911528498263, -0.6879079331883574, -0.49728539823025447, -0.86031203441721, -0.14441592147083876, -0.043980245725671344, 0.043759115935199655, 0.2821501277510617, -0.6897070722780076, -0.3832814064445854, 0.10481020481546745, -0.8632977565882949, -0.13180719606544752, -0.4141226247922496, 0.1521097351302298, -0.23153560043830643, -0.6141915305614984, -0.10450249813766767, -0.7111109269579456, 0.3448250855566112, 0.12996310306322217, -0.5966217277764975, -0.6904027900704766, -0.6046252381642764, -0.0887034776834394, -0.26610087854638603, -0.8419791319371508, 0.23964919477003538, 0.12428238111159272, -0.5419797423409073, 0.17998136462103947, 0.22404867174777415, -0.7210844915090506, -0.07328970671222507, -0.24035762270147817, -0.5689205753011796, -0.4509834601699307, -0.1596096778568451, -0.6103599948388149, -0.6630303347942015, -0.02932213634824324, -0.8241015630227115, -0.38415202955115785, 0.11387061613956971, 0.1907945992254319, -0.6209229964100597, 0.1445204382661624, -0.413908459389536, -0.8504589554737728, 0.09356248153862962, -0.7509779475584694, 0.15514199285096614, -0.9025187232611984, -0.053160131298955894, -0.22724633129318642, -0.11519899751674521, -0.7161180371420994, -0.6553111663899814, -0.5883005128356371, -0.29802268343792987},
    {-0.4119319628299028, -0.0661461197852005, -0.4198278433021057, -0.31113822637332805, 0.026149928437036785, -0.056804520643584926, 0.4712129316817554, 0.15600479525016867, 0.09212148316832602, 0.11928356785801834, -0.3801146975669026, 0.11882747252892661, -0.2450948419301046, -0.16509809239479406, -0.013102053912676591, 0.27404067684471284, -0.19618212963977336, 0.4732781007721547, -0.4773735031832607, 0.450256126243474, -0.33065923859238916, -0.889470324294007, 0.6219375597795241, -0.3844716429596948, -0.6548841156519389, 0.15742147097819228, 0.17235707682556534, 0.2568338482970201, 0.11424005776936375, -0.2856879082401205, 0.1646657524284778, -0.4608896235603948, -0.6897846400343483, 0.4702517105398955, -0.4162722180641195, -0.5064003824392536, -0.024273120065607324, 0.22161743305267487, -0.8006601560897064, 0.061529167745327344, 0.24182343993950467, -0.4960295259760319, -0.413429370695732, -0.687838451667388, -0.44179889648298876, 0.3255480927387765, -0.1386265590316587, -0.40518347560101553, -0.034444349748542484, 0.3240243868240663, -0.27572167149916765, 0.25619909451295486, 0.4300117794905313, -0.013336304264605858, -0.14213360983032305, -0.17587261281188066, 0.4243395475683685, -0.5128917132296403, 0.32870363291324267, 0.3485429959893929, -0.2411429014936788, 0.06647521702883463, -0.3127272809323256, 0.04520101087880356},
    {0.2378169437472325, -0.5876499134051126, -0.6618615768852856, -0.15538077640548711, -0.6240807162311914, -0.4516930094369488, 0.5862957069953955, 0.06172330559047375, -0.29248950658555406, -0.5680833188462849, -0.08706313109830366, -0.2154439602284307, -0.20888608070086323, -0.6231959826454487, -0.46724150046933316, -0.2501003728660648, -0.17092408281231844, -0.23651730415360095, -0.36216748066102455, -0.428796888412138, 0.3290295812338356, 0.0963046001242955, -0.03149152712559695, -0.27917320690833014, -0.4420383683345721, 0.22629559708013328, -0.25716825248911407, -0.22083175751738165, -0.659138837312507, -0.6233937208861164, -0.09245477237506051, -0.22388146931185957, -0.37492981544987564, -0.13360140621515026, -0.7789379389048126, 0.08158332318045511, 0.022638846795623106, -0.49489889715796054, -0.008892365719412997, 0.2656407034516401, -0.15935023230553189, -0.11386673439341459, -0.00640701374233274, 0.1167051493956986, -0.5115863758887131, -0.3272416392503066, -0.13413475046936987, -0.702026904201056, 0.17621905824723347, -0.14483416113060213, -0.7887743072072962, -0.6359109198854644, 0.3755621971356694, -0.2418511351764974, 0.2451011326980949, -0.11219395239307514, 0.018851113876537377, -0.13949226522656205, -0.32118813118736067, -0.3874427701734592, 0.19638815666684845, 0.10523072889524596, -0.22096635768257328, 0.2088861123238244},
    {0.8694502679073176, -0.5494669716571495, -0.7303140946762612, -0.34249816057169125, -0.4353668299916726, -0.4531495901150311, 0.13935484357232222, 0.19185204628699654, -0.26012012172406135, -0.6290987002985023, -0.17588634893013003, -0.6198689033659012, -0.15012363245935487, -0.34649161507754667, -0.3578815759401721, -0.07293984536134669, -0.26067070526119496, -0.6683255520470617, -0.5195220227971781, -0.5519468516982524, 0.4619051000319265, 0.3094414889707185, -0.13881612535615093, -0.5923612916081769, 0.06950502582072715, -0.15946664565691582, -0.6855999032578876, -0.13524418810552502, -0.44574021039418654, -0.5278784158617287, 0.2407988309066631, 0.2089892112940202, -0.20226162263101957, -0.375072764296464, -0.5048102189283569, 0.4417382210817123, -0.3701968953194054, -0.35832891411576706, 0.45706891768026753, 0.1932282941827554, -0.2413488037207627, -0.16795200453437092, 0.6287064410414597, 0.7363995727779391, 0.015835120478500594, -0.21928442607691087, 0.06323073222456763, -0.6279506349477507, -0.05180782798224739, -0.30812440058607865, -0.6472095139354186, -0.7449329090280036, -0.31867215894925444, -0.6866814620492525, 0.46511679065248857, -0.4316350700740416, -0.21155264556254308, 0.618476760150528, -0.5988334598213041, -0.6511211023945201, 0.33938445873948603, 0.19955139780347236, 0.041388347829754764, -0.3276521093776624},
    {0.8652770017773733, -0.24997840082175857, 0.027030529513094887, 0.30905688399600795, -0.2712108705972184, 0.2751034568697004, 0.6330433153926237, 0.653304815369439, -0.28952258369769573, -0.5904928018721233, 0.38339377025144794, -0.1932535438615213, 0.20237163441599276, -0.0025547341477013307, -0.05482245728966925, 0.7000766311460547, 0.6664114417036097, 0.20734940604486798, 0.15062654252443258, -0.3459143963332521, 0.7983954010089247, 0.6097484310358815, 0.45537692000207775, -0.24523601802639056, -0.18587569508767973, 0.3315551972614672, 0.06821721282298547, 0.4473726937814514, 0.027053893372854822, 0.0037050792755042973, 0.5150689949717686, 0.46419761313124297, -0.19397780772258047, -0.16316817229724948, -0.37789892897840127, 0.20931576681730663, 0.4153125104469093, -0.7077182539167245, 0.5446277128825981, 0.5112406547867963, -0.3673216327546823, 0.1935586206752285, 0.46987939958566993, 0.7354278940851265, -0.20135856110371825, 0.169074277317269, 0.6531870552025085, -0.473384302130629, 0.49621988643790876, 0.7778932223250223, -0.20996333159003713, -0.1882382870260518, 0.466924641465738, -0.43585314256349417, 0.6892555555907531, -0.34893898124565315, 0.7071700880185016, 0.2476863607717244, -0.36127399298193785, -0.08836490081499739, 0.7209975308002124, 0.6004813535447144, 0.7279751537303268, 0.09693337325882496},
    {0.8843835935002375, -0.2311782535371405, -0.3661547502534465, -0.33812141537125817, -0.07549011894108366, 0.26521388141048696, 0.5100080379335997, 0.8663259335581001, 0.23212028920740174, -0.5334979883638058, 0.10787757365796313, -0.31352708950946523, -0.09058222304963366, 0.6845565057865131, -0.607692757742551, 0.7275652425196054, 0.6334808545961805, -0.124137403998383, -0.2542280339525809, -0.6391838381903985, 0.9854754052098994, 0.6233586599741479, 0.8687902863642107, -0.30692521479239815, -0.2692206833101683, 0.31350106458498284, 0.42349958348567524, 0.8525857682558173, -0.4752454950122845, 0.12007937783469083, 0.6384103147862437, 0.4520487409612208, -0.32026015374762296, 0.23098662645717877, -0.27732724804526726, 0.4173501686228041, 0.7476289399226601, -0.6548265704621757, 0.8115875578710933, 0.8916642418259179, 0.24546319008770479, 0.18699412030643864, 0.4520779298890508, 0.9222372112738376, 0.039691949393595376, 0.6808693426841211, 0.4758829284547807, -0.14827975808471813, -0.0389931133310579, 0.7683894659713888, -0.482038093344246, 0.05491765577883058, 0.7255218610506294, -0.3330735391196958, 0.9013975265462957, -0.3947114192729228, 0.9597959575743082, 0.5873063912063212, -0.13199356229110334, -0.22808818088519567, 0.818373537017318, 0.762857949490277, 0.8643337442095592, 0.24140204053028996},
    {0.7354907881722458, -0.3299712814956603, -0.29287553207253514, -0.19907588276231528, 0.15181139553854633, 0.1240606236974989, 0.3588668239814538, 0.8349866200710747, -0.06364999383332907, -0.19487949482328792, 0.29669477327617766, -0.40322918181785905, 0.2027800578215493, 0.5569986433691847, -0.4943578929494765, 0.8849623328180102, 0.5547728777407521, -0.23015582334616624, -0.20462868794154687, -0.47101056217080006, 0.8090855335921215, 0.5479717709175621, 0.7801728454743353, -0.5414336535056407, -0.4160682677126588, 0.019087832941585763, 0.21522539114768946, 0.8493246827561666, -0.40698431775780736, 0.15211865223410695, 0.9083441867779073, 0.2642418601961043, -0.4275998354916306, 0.07108123353976184, -0.4007462364545341, 0.07197338912492848, 0.714104568977218, -0.7389863299586508, 0.7782726628476416, 0.8650942776370243, 0.18965750367680687, 0.22729181560950765, 0.4524699838848646, 0.8749730163413286, 0.3832443206673584, 0.41356434088352445, 0.6663305883371389, -0.2232912426924076, -0.04463933447166097, 0.735808579007115, -0.6414510331063419, -0.11050658322258342, 0.49877590614844897, -0.4028073655613691, 0.8796936730378642, -0.35552985546858984, 0.6670827024839805, 0.4063096715656501, -0.05119893098465524, 0.0834687846908812, 0.7405385535944448, 0.7741362545879508, 0.8790846317972327, 0.05330069855219362},
    {0.08701140647397808, -0.32970091135818286, -0.639162741766361, 0.12001707212843353, -0.09203945381048009, 0.213298523973457, 0.4620399756204233, 0.5109352939236173, -0.5254737840006286, -0.12209003123869801, -0.2678181252089218, -0.48660397830684354, -0.5229355231211195, 0.006816440358196385, -0.2894246717060121, 0.35744607856636934, 0.510613435566404, 0.04554323304874339, -0.6444294506392236, -0.0013529040021273374, 0.10961941519918064, -0.2880220471763397, 0.3521169442886851, -0.42655061760633906, -0.6726646207523201, 0.35981873238983053, 0.14257272217229897, 0.3657332216137587, -0.4740362321384891, -0.2896082028784181, 0.582320134693705, -0.009780264030928748, -0.49673477065387156, -0.12615561204717704, -0.695489136916896, -0.2786356538029401, 0.22806528299265705, -0.47274967016595565, 0.01424203731339503, 0.2864987979760515, -0.3750357145453227, -0.26906292774758045, -0.5085489641719649, -0.0778316782908968, -0.00640464424096957, 0.30028553350733994, 0.3209611255130783, -0.46626745087879035, -0.28105333187934356, 0.629257272280402, -0.35739080948393565, -0.4223481929649769, -0.0023069592453983804, -0.2729536634994387, 0.5235837230971615, -0.5779802267941836, 0.4089019439452339, -0.6521411557342751, -0.5238409382470257, -0.27956947428377515, 0.4652072903297347, 0.36056794346138166, 0.054712154496821964, -0.14996449705758144},
    {0.20525432654416997, -0.214689075790171, -0.24146009447414768, 0.16507533376687583, -0.4063815190490595, 0.6063481020725546, 0.8420986025245627, 0.501414410234353, 0.09546371970313715, -0.633459190006538, 0.09732086881539151, -0.008290246613310685, -0.1658126201970992, -0.04787596098698779, -0.45940256508838767, 0.09998453874922064, 0.17746332263690312, 0.2892902483838159, -0.08602375406353646, -0.1534320688194562, 0.36536105994930546, -0.2581478278112694, 0.20019989844357802, -0.1675195275177271, -0.16977771636844521, 0.27480383801951697, -0.28060533966626316, 0.4322731196734855, -0.032523539249804154, 0.030114689891545136, 0.6725283971437919, 0.2387439403748968, -0.38063031384994106, 0.4582730909356676, -0.1853161201557783, 0.2240496512167793, 0.6250486068654434, -0.26630626474906643, 0.0006374189779904586, 0.7081468925778395, -0.10457106998152013, -0.028027664476967296, -0.40641302815489894, 0.34804041825203463, -0.13644514119032816, 0.4876887601270588, 0.2052615209729901, 0.17180496929582365, -0.2599840924725414, 0.3317282386546946, -0.5780707939965085, -0.26456416920683307, 0.37665078986120254, -0.049448586939439085, 0.6896276229961642, -0.4494423382520456, 0.6246356371634338, -0.3350413847389385, -0.25912883491977917, 0.056186236332663994, 0.34568809469184686, 0.40140026317172567, 0.05759874476995352, 0.3069424344554626},
    {-0.33754764974224644, -0.016626194654875453, 0.4108011229603407, -0.4256424440616289, 0.4276988613255468, 0.39217398788744773, 0.36256807453544954, 0.22627557409420135, -0.19628525534134827, 0.5850125716452377, -0.3023516419769338, 0.08560456045621238, -0.08050684610810865, 0.6564937905341168, -0.13794320108045796, 0.6719897347662145, 0.26628720600910705, 0.5127545469841852, 0.17508076793342328, 0.6824517025304558, 0.3387140761776696, -0.09469376594299608, 0.04865975777464411, -0.23597869209467476, 0.32286187198740124, 0.1662321695117937, 0.5430483211880623, 0.2670223930145034, 0.5525246664985326, 0.6286949631243565, 0.4338126886161154, -0.03452302630758226, -0.2839474357589208, 0.35221675218208987, -0.07614184592176798, 0.05457417097726797, 0.543455642107966, 0.6284411355970412, -0.22742225690517806, 0.5022042424515469, 0.20889289911237158, -0.37254277365856164, -0.5663785823870915, -0.08026266337785493, -0.04306971287945253, 0.15512676630581015, 0.06573150498356543, 0.4863921539858423, -0.1413236259626073, 0.1970511181775765, 0.5286844992316467, 0.47133052231658523, 0.11408887198484698, 0.3511336386649189, 0.09606458448076616, 0.11795571481826085, 0.19371451869813142, -0.16882951282161546, 0.07027240246768046, 0.450321133126488, -0.21549157945400874, -0.31760681342016384, 0.1684101204384248, -0.5479700247722519},
    {0.17814928943643954, -0.2782064235152512, 0.01947197655619535, -0.6172050411530536, -0.06565345205458747, 0.4417557049389792, 0.24293089848548566, 0.5823838401097583, 0.09572072940200164, 0.4685250561097315, 0.11141943745403858, -0.32728235600812516, -0.0015388807222227819, 0.7533973329668532, -0.3311499734145279, 0.27818483015720813, 0.6223828389380874, 0.003642104751274887, 0.11927830944573524, 0.580162028232583, 0.356959755473848, 0.5275990490628674, 0.5748455644093204, -0.5058430657805616, 0.016888074419305153, -0.11865090940821243, 0.6601070022735017, 0.4418273577649355, 0.22349135463020398, 0.22029646917727658, 0.27148064034422, -0.5094601251726365, -0.02753345531318422, -0.25188768907634007, -0.1386631765458401, 0.07090840988424807, 0.06737576115217021, 0.1427913390191452, 0.46226585153863076, 0.43275374096216024, 0.25796694017173516, -0.32393613768667584, 0.14767684196095704, -0.06313477978340792, -0.1981506236427253, 0.41834904603466166, 0.1638250276891512, 0.0897910893921076, -0.23805222087536593, 0.14759327783443313, -0.01460604295532156, 0.30660956134231115, 0.65181287919177, -0.014330959862029941, 0.31499901056969626, 0.16800253227751824, 0.607388873320287, -0.15774931912613754, -0.011592080210228473, -0.15286742224091449, 0.09254040144451503, 0.24016702318531563, 0.5618603491388251, -0.6391533927491629},
    {-0.27017434563751475, 0.005991843371048234, -0.07373546557553563, -0.043879924642510414, -0.20229412431171132, 0.07212792159503707, -0.0997479755551679, -0.635092787779992, -0.26334783496842246, 0.18323091148213608, -0.13166929680631762, 0.060459514220044135, 0.5438185304931539, -0.5506961339999801, -0.128193931001229, 0.008993876299184165, -0.261218383673158, -0.16956133031576445, -0.4217179870524498, -0.029044017536617336, -0.5609785983097263, -0.264529639569448, -0.38302595964728064, -0.04844330591351027, 0.42359495087486976, 0.15204230716140493, -0.6412235993864058, -0.4634129469377989, 0.010456264159039821, -0.014125005941104394, -0.3320352302327884, 0.22915245549300253, 0.08486049631363864, 0.34394687764443105, -0.013716979382308623, 0.07732007792603811, -0.2593564566448784, 0.1768892387034528, -0.552746253112823, -0.010628448701422372, -0.1357361937295985, -0.4492585656476124, 0.28851162674342484, 0.1130674125197201, 0.15926644029364925, -0.14802555581543195, -0.5372205753008422, 0.14056265582111696, -0.009509442679452182, -0.5216610283342032, 0.183019710594784, 0.2390927842448441, 0.14037299647095633, 0.22805571390760712, -0.4459609962019117, -0.1649139928636146, -0.4107865011824353, 0.43018265183038873, -0.259426626517705, -0.08919118603149188, -0.3607427004106952, -0.28201923473425716, -0.2920503885287725, -0.10851546584516218},
    {-0.4516906459343167, 0.5401710059212437, 0.3249091469998752, -0.22944080567942085, 0.4558398985839186, 0.35752417524701174, -0.05029281429611395, 0.27974812565659307, 0.4928276481461767, 0.5509932780836936, 0.03032011745356008, 0.3834801469873663, -0.07174187345393161, 0.2488232451309948, 0.19260475711235275, -0.26699853011986974, 0.2382029576894796, 0.453415364066303, 0.16075581181909362, 0.42486401924162576, -0.17105597472760936, -0.5075619011921332, 0.6319735097036361, 0.26056735067581693, -0.6553874744799221, 0.5757690728447106, 0.6196163043639823, 0.3090984588296416, -0.4356008215714819, 0.12857791499588272, 0.5946384396590749, -0.32699713870241537, -0.2672628202706077, 0.6083984896181699, 0.18784889859341136, -0.3708758185736249, 0.743171231998989, 0.06302166030771511, -0.6407123140200094, 0.05538462469605366, 0.6852499729665377, 0.1673847300275955, -0.15592276182121237, -0.12116624216393829, -0.12620488755178258, 0.5733201277196928, 0.031829362599004575, 0.14108266259525376, 0.14015967156834142, 0.509751428443826, -0.4130626654685541, 0.6733764114123199, 0.5969220323709915, 0.5968128863663931, 0.05125374826323174, 0.5640924785889697, 0.4624877147066108, -0.47382447016722545, 0.5535618308864718, 0.48227410215342037, 0.2508940529305328, 0.3356327628741739, 0.14438379897323406, 0.25158536643916835},
    {0.5126704327451134, -0.5342959189635638, -0.5828251758888067, -0.6169528427124658, -0.6595184271996936, 0.05894826296739423, -0.6114558379761895, -0.5367886092907084, -0.014904781185097651, 0.016764465857429852, -0.1599910894235267, -0.478736453169963, -0.004836266651050208, 0.0747139524836528, -0.6863054017162928, 0.30988315769430075, -0.6511081256597312, -0.6363863308160833, -0.5504656026734596, -0.3947082665769389, 0.09280433526672446, 0.2079337647607652, 0.23428952858495372, -0.5741851786354933, 0.5888744210355606, -0.5380738825545228, -0.4105960159024964, 0.34296350750192084, 0.2715304801907962, -0.3619062598379471, 0.4963680823548981, 0.06341559611660755, -0.016931614367975596, 0.3069268497016024, -0.4537527210221242, -0.3646394767415042, -0.38195825939670286, -0.23827153878277635, 0.27570107457209453, 0.5927782825541253, 0.04474710421760075, -0.39483522882040334, 0.6684648912051806, 0.5355608092056631, -0.17976049265262806, 0.34807470637727556, -0.4965617555498886, -0.32523132648720643, -0.6505574634748797, -0.285688766705878, -0.2586864188238111, 0.06715491045191309, -0.03751953653508793, -0.3085319344685334, 0.5576989555897361, -0.8148271522814576, 0.5971572779011973, 0.4224396365089337, -0.5916621120096274, -0.6506093021015197, 0.1317055336637628, 0.5435177636863061, 0.049237761338925094, 0.0487933825142028},
    {0.8865662755540111, 0.053411076515723944, -0.35706076141306775, -0.0005089548378857463, -0.700739515436798, 0.379703353236482, -0.4538493312255513, -0.28315521374214275, 0.24401350309850364, -0.4944321100251108, 0.3265198034513449, -0.6117700561751916, -0.3600825667965465, -0.0471903007764646, -0.8063198376432926, -0.4727111990069585, -0.4775101631053692, -0.6259175544223516, -0.07938365326827179, -0.7319569002529526, -0.13998002957910213, 0.6609084042666561, -0.24814886886229212, -0.5787224743892996, 0.5737611770094408, -0.7720258213098634, -0.6492601111664351, 0.14279344912324105, -0.012514874434539497, -0.24914077326357278, 0.33863171153462257, 0.5731498902775832, 0.04369789590832558, -0.028313711878445398, 0.3057278804004103, 0.2583668874053324, -0.2864562730441487, -0.36111994008151516, 0.5918582151661548, 0.456899412526805, 0.021811927897109885, 0.04523989835514843, 0.8103148356558441, 0.9789143015290629, 0.25717799074592645, 0.5247677644417134, -0.18846145432362543, 0.38638258298157857, -0.6604862570536012, -0.6091408319815868, -0.5309165115488337, 0.07540001688567094, -0.3847542107853464, -0.5513069537872552, 0.5838889007641119, -0.5482670873728744, 0.31957679727497884, 0.848977583217351, -0.5560413113060527, -0.7019252556992908, -0.12449141572019749, 0.6116480321110697, 0.19346365165211565, 0.5269203591418592},
    {0.003173231592152428, 0.31098843968764694, -0.20738763707499527, -0.04361049218840977, -0.06722084966488226, 0.4033595544839362, -0.5378580109263751, -0.5697126655929526, 0.4555456900723442, -0.0804002582819233, 0.2891049838015404, 0.29086889239796426, -0.0063938282846561535, -0.018308436261073875, -0.586482303194287, -0.3225772082861682, -0.5470518273381721, -0.03414262398433301, 0.1455695634771977, -0.4920305229282301, -0.7347290296691653, -0.365247042191451, 0.2238655147012046, -0.33733402817350566, 0.348683325177664, -0.24007508940047198, 0.19760844886863688, -0.16141491781652584, -0.009574648389067103, 0.17242108328265926, 0.490312311208497, 0.43019412386748135, 0.010508078862392902, 0.5853036586795779, 0.6355487590588673, -0.1518162487140654, 0.4353845256256944, 0.11943541401160818, -0.44518428490368617, 0.4223516942280155, 0.6637904944871342, 0.4951410419281677, 0.42273412465992866, 0.45915062875297075, 0.13591240392933754, 0.7747579713876622, -0.2632200549199266, 0.6651490207616431, -0.4933668146100087, -0.4911794670996128, -0.06158243857995372, 0.6876551933477815, 0.34996495549882545, 0.26123480517081993, 0.5169940690162365, 0.1806315213192206, 0.6318856238058497, -0.016958316937781697, 0.4364057233781945, -0.1570218514458054, -0.019883552760611524, 0.5711987763011999, -0.49898246897446713, 0.513654743689659},
    {0.8451363570930367, -0.5127599421713994, -0.5291607757763218, -0.1950789465632674, -0.4700833853450133, 0.5086119771614147, -0.4404596345481053, -0.022338480490764416, -0.18908621769806425, -0.23845074122360768, -0.11744073849983812, -0.49316915141465506, 0.20526548007371398, 0.3210942334414892, -0.7217112074342588, 0.6086695254308052, -0.609945449612098, -0.46808658774291034, -0.5659026984990072, -0.49025808185562264, 0.5680521121488231, 0.686083514750196, 0.32033036372977636, -0.8560185704546082, 0.8493450914524714, -0.6771458036732211, -0.3346992991377412, 0.35237825598467065, 0.027655300750878305, -0.07337827738085492, 0.6500169318574949, 0.12494163631921876, 0.19330141251249047, 0.1664573394070027, 0.08171563603435422, 0.17478380564860097, -0.23429899132877532, 0.14357661785812245, 0.704829636829055, 0.6994737418543636, 0.07393324930574754, -0.38294244599052607, 0.6234436880122786, 0.8514495882512123, 0.5567151627703932, 0.7125759614212404, -0.17733550339536738, 0.08672583622961558, -0.4752091099436918, -0.013953554469177901, -0.313263457943297, -0.04506238053933615, 0.30593711587460376, -0.5026326297260678, 0.43676534493620317, -0.7762881232453575, 0.48200183945627106, 0.5476805927823744, -0.6508026994744159, -0.2963451543175373, 0.2876787422441623, 0.6606663306787373, 0.5960284089912766, -0.03728867358394195},
    {0.8580228290852491, -0.06619411848406552, 0.1286183203875047, -0.10236291418641769, -0.07428398052563076, 0.4829317526183509, -0.2445395462096473, -0.12290002933912769, 0.5290146339420146, -0.1278436178480431, 0.21044358245102374, -0.5110416567446516, 0.3848461739148101, 0.25971775996210417, -0.6540028817538578, 0.5302739205200007, -0.4024308052799207, -0.2959196028914775, -0.11038187588163965, -0.4768787358278106, 0.3794133435151972, 0.7413373450851043, 0.31481471620313756, -0.7030307501505305, 0.6514850359373678, -0.27202080541255325, 0.2484898733465737, 0.12362523988660343, 0.018705862390907255, 0.005046377568021465, 0.5806927326939922, 0.15407761816122725, 0.04117680759204076, 0.41754793307704413, 0.4696411118114841, 0.21234511778513201, -0.10844632209022495, 0.1469104222915436, 0.617442589182554, 0.4133605915477007, 0.24260957879542538, -0.0870226876915614, 0.7693836591062263, 0.6828789681692096, 0.5311661800149868, 0.4080914897130492, -0.041369753942896534, 0.4979877180829443, -0.17426801670698316, 0.06882861549503981, 0.1367285752358157, 0.6423245566613055, 0.27777419382005236, 0.13579292778215893, 0.40830085721778736, -0.5282102885819248, 0.2930606552273154, 0.7639847408834193, -0.04518957163579877, -0.2246106340841886, 0.29410960790867363, 0.6568461293769975, 0.4783777279941348, 0.44898650372847365},
    {0.3643907949548651, -0.09986804355085817, -0.5025263223408574, 0.21643908502029743, -0.47373029621933815, -0.2660803745006696, 0.047720884645624385, -0.1957245756428918, -0.28830461040366107, 0.21646407938828777, -0.24604888200571812, -0.20991906287012985, 0.10151770054686936, -0.2796573051833167, 0.13919694289520998, -0.1405594754021352, -0.661023890643676, -0.5508286401626653, -0.3269121673884936, -0.27981230723601336, -0.07281914367762936, -0.09953687939900875, 0.17811692358536763, -0.15840744017133015, 0.15213216821388523, -0.058010311522963286, -0.5674326047536329, 0.24055453145309927, -0.39437579046543175, -0.4148110836077825, 0.37755650468319724, -0.24151159828324192, 0.3604219097307299, 0.3548999906501876, 0.07272782574075702, -0.06411210116196438, 0.15360288156400528, 0.17350854457936662, -0.12625762256967138, -0.12708198874908933, -0.07979164816303355, -0.3911331803468815, 0.5007993744983893, 0.5339743425279834, 0.19659054076086227, 0.4623038900068653, -0.2725414426606492, 0.3702388724769169, 0.19244567533250564, -0.045599911935795316, -0.4638436818445672, 0.33264846831214007, -0.33126364368595035, -0.012669202993713097, 0.1847847342682826, -0.3034959656082169, -0.08604562584214931, 0.3128399370927247, -0.01808276639917385, 0.22499338176695574, 0.2780456880231767, 0.6707035346828439, -0.30371772655291424, 0.5215289092034106},
    {-0.23112399971495118, -0.18921804963329936, -0.5363458510024325, -0.6349499616539698, -0.32854562828083006, -0.3873819707393022, -0.2678155899502155, -0.49761742001081716, -0.4470373993769565, 0.20594478140146574, -0.4367940388256253, -0.10404456789331205, -0.4916288863039289, -0.24770518246359485, -0.23548496680983025, 0.19243498448509827, -0.01995007339851805, -0.3105610880138343, -0.5494583552200526, 0.10379702027305657, 0.017796246683219306, -0.09314429717822585, -0.1233699821626451, -0.5922514015477164, 0.08045245037494966, -0.38920763037153067, 0.07564835384139669, -0.24310022981284934, -0.15330485712597883, -0.0339509459343512, -0.541254347872842, -0.6292544808861159, -0.09062848341618758, -0.37044266278307436, -0.4882250163700536, -0.19376443595305315, -0.10725681788030943, 0.25105981148465656, 0.46335272593688076, 0.14023145642373297, -0.38246787087825285, -0.6004739354845562, 0.1531311109162941, -0.10232067408759458, 0.38926439824294445, 0.16241368728745448, -0.32282715519615035, -0.3789611040361901, -0.2300324733513572, 0.035198663039018536, -0.045485874454814744, -0.4101743370516483, -0.028006594093335942, -0.45547364264015494, -0.3156858602355034, -0.16199603675372756, -0.046881209349716665, -0.2438801427280522, -0.2493571686361345, -0.20132820072626653, -0.43140957432918464, 0.16642749763589548, -0.2604908695495862, -0.35826733386359655},
    {0.41306522044660854, -0.31025795580219845, -0.34530329484753003, 0.22100331167351106, -0.3956277083166023, -0.33729093862629045, -0.32753612978345054, -0.6164088290339602, -0.44527362156481526, 0.11163864251717083, -0.33042812106087444, -0.201644887827651, 0.2364571454617311, -0.6242892188000074, 0.15676414330564709, -0.4058049173679131, -0.5258630824883003, -0.19592375503696194, 0.04300806783196422, -0.28799852233775375, 0.020962649381777814, 0.5477654168987156, -0.328900310315136, -0.4860755707936968, 0.4599073875133689, -0.6425153976349768, -0.5139787545957236, -0.11190857565075853, 0.08624193568684374, -0.6584479469050567, -0.34551246679960995, -0.06063157490352682, 0.5552928822060722, -0.4169971201722534, -0.16959123288799183, 0.07244963991293335, -0.682994046778759, -0.07483892224047631, 0.6593728208499876, -0.08767327710836897, 0.02077615461960187, 0.08998382171859923, 0.7125053055073463, 0.551600025468673, 0.21963199163626684, 0.1361489140008516, -0.04973129230112103, -0.035311789703386054, -0.3998617979850925, -0.047379275846863494, -0.07951859697350598, -0.16743409990965377, -0.5801137777404665, -0.529533424257646, -0.2825180854152009, -0.31494044539684424, -0.14224851110714837, 0.6229179859961806, -0.2063453457546475, -0.664421990841473, 0.059596297611410345, 0.11108748343635189, -0.21609810096140913, -0.03913547627246551},
    {0.7132206085282065, -0.3348841970717605, -0.5330249036354962, -0.03423735037665786, -0.21610782954015895, 0.2912274826646728, -0.5030960501238084, -0.3933108461216229, -0.3754709980856254, 0.38715516493555546, -0.5063757942227515, -0.3014513151480653, -0.2789245321812891, -0.08462735891254149, -0.4109319121308043, 0.316172929437929, -0.253792940497678, -0.4800351259226536, -0.30458518880848356, -0.3692205908343535, 0.016259373684216177, 0.35702260159056914, -0.09844663313770048, -0.7484925346715183, 0.6187182288720587, -0.8059638085976891, 0.059247248008403794, -0.1932613960290735, 0.6525296897504014, -0.2690298826446236, -0.3554236873891134, -0.19314119048785863, 0.46407578347007694, -0.34419284842805387, -0.06385331950086119, -0.4283763657067248, -0.5708610711588591, 0.45104714122191253, 0.6469479793665558, -0.2626023370548057, -0.4796461796997847, -0.19197513522135004, 0.34703291375731943, 0.5424167488426982, 0.29952183625208995, 0.4805802674036171, -0.2765467926504549, -0.3881757979917657, -0.4724987817671873, 0.17440130559032763, 0.4070044782592223, -0.34548216398178083, -0.37964022910391126, -0.332575366289061, 0.038075084389765784, -0.43610774596940755, 0.04366718092188433, 0.6950622121114504, -0.6871081671917247, -0.7499324349479531, 0.03550187601498081, 0.08573139842480884, 0.14976676484626922, -0.5206056152108756},
    {0.3465731468504491, -0.4209823552743451, -0.7409709910077571, -0.289057833335408, -0.31994028975540345, -0.1500650424256364, -0.7957941688584939, -0.6234006804805687, -0.28901038368143106, 0.26070925397258576, -0.3471114058894405, -0.45614870787516987, 0.18501636191985515, -0.3913663216006609, 0.15388292436900947, -0.11647489449530618, -0.8251799017095995, -0.4398690787522917, -0.004936265299121777, -0.30555713560101305, -0.30256343926498186, 0.035158899181802, -0.288629735336592, -0.5444020108726851, -0.024236563901264194, -0.5957426295802467, -0.41609234635396114, -0.6897041464699504, -0.12461584361868044, -0.5936070901934029, -0.6605939649142104, -0.6469176205788598, 0.4794149119301234, -0.3279714803278734, -0.20185409172579136, -0.5886019413735374, -0.4382082349699926, -0.07452517404202116, 0.1735828273058308, -0.4478020877681005, -0.3783142964134728, -0.33285047389667005, 0.42609663035598894, -0.1764592295241724, 0.20191357698062004, -0.04337527385104397, -0.23682283861237383, -0.4562705478118574, -0.1299461216654406, -0.6228526167570684, 0.06349028996497928, -0.11879923071353317, -0.6106793288774289, -0.6352706362964166, -0.6369750162532877, -0.558633088279956, -0.4188447176400923, 0.39587951703271634, -0.6246846886217303, -0.4237354044547098, 0.06868285911697085, 0.2732070133896776, -0.0801694337575575, -0.02577451330750424},
    {0.041999627537001434, -0.3022618996727726, -0.6243683098893439, -0.0910352863647417, -0.255780803436312, -0.5162951990572492, -0.36433417384357153, 0.07422931591255956, -0.6516696443203099, 0.3898665466500703, -0.6963106217459684, -0.5314465660473181, 0.18051926629571333, -0.3144921991649827, 0.7313941147381127, 0.5215726442221904, -0.05737996947570575, -0.333943728944397, -0.0977710342131126, 0.40008444627553313, 0.11071965162637862, -0.23847639996377432, -0.07618740302208227, -0.29352118802763594, 0.0655199080062945, -0.2958662233342587, 0.18464726525282682, -0.21932417901727022, 0.7237525610823834, -0.09582193722980036, -0.41717768658416016, -0.29136916207029967, 0.39924702143544943, -0.7416939441523464, -0.44223306083472, -0.5912957666435866, -0.33195601046647727, 0.7507238429228033, 0.24260828126486933, -0.6679627280097196, -0.6552098968740818, -0.4411191041180278, -0.2578899245303089, -0.380013471135181, 0.3350971836261167, -0.48695587166860116, 0.01758436513439023, -0.5836699698251955, 0.1367150444341566, 0.2805992201522629, 0.5332586102333322, -0.5387384461627658, -0.6490975187557495, -0.2113987420315381, -0.6066598206248672, -0.2557691701822774, -0.43505075921149455, -0.1991810551249769, -0.34240785045811656, -0.3721411112733061, 0.22274539735038404, 0.005618327256384428, 0.021663619708193145, -0.6973924231934436},
    {0.225427771420526, -0.3271050374459251, -0.29697075947857715, -0.43084591921022064, -0.36569215729139914, -0.14967603511101038, -0.48763396507241447, 0.004531394551169822, -0.4694811485491463, 0.4011760155809363, -0.3700154833454389, -0.5559813636311313, 0.3625311163762726, -0.49710263649229436, 0.33276427494350225, 0.4941331276566715, -0.12698619066219513, -0.559831677182543, -0.07484620307721333, 0.13914571897306754, 0.5901957526571316, 0.42189318406490034, -0.3619229293643812, -0.17276531574633747, 0.5536875103279133, -0.4220313997023964, -0.11570311579744438, -0.08708815074109698, 0.6958413880554822, 0.14996143459366365, -0.42416142183142885, -0.2824849498229104, 0.4115248105454848, -0.6604007187991143, -0.5119565345457713, 0.08207089419460249, -0.6152341882810425, 0.5633155262961453, 0.629591424413336, -0.2649013990437239, -0.4780688652086299, -0.5557294660812985, 0.45013848702895387, 0.2911687089225323, 0.42803071328733483, -0.15879849204522892, 0.16444277173093708, -0.3280926181759615, 0.25968378003378606, -0.14855828336064134, 0.47683103997100273, -0.5666323792309164, -0.18591898347902372, -0.4395507407443288, -0.34291681589398026, -0.4752835683934286, 0.022398569766615004, 0.7206592892236737, -0.6546050798750652, -0.35302694160722065, 0.027935489564261843, -0.18633049727624593, 0.5583369882795521, -0.5953777781433718},
    {-0.2711960777487843, -0.5013137782243122, 0.07781237885902577, 0.18222209064335718, -0.11347742287876826, -0.5746544861144335, -0.26504440609319196, 0.21446769089360704, -0.46054724094065574, 0.6515681724071679, -0.35656428676445723, -0.15573146714814928, 0.37602561429686787, -0.5683239384336937, 0.786953738285566, 0.3203216969109976, -0.19806055629220615, -0.28318387563408104, -0.26223141586850657, 0.7392951108116792, 0.38026107620837996, -0.18177994162136296, -0.6755454141320272, 0.20674028665054192, 0.5909588269259021, -0.3210711784755775, -0.3978668300615481, -0.39425846186199925, 0.47820178417055914, -0.17957888762969615, -0.7304782366423671, -0.1220721135699772, 0.6428470677848492, -0.5810811268744376, -0.11568467890006612, 0.43077988253748634, -0.585978861533637, 0.41236112943252373, 0.4676664185959563, -0.31599248207140407, -0.3666863437531723, -0.5692766553471109, -0.05507116115125099, -0.44376123864840844, 0.4767297021240596, -0.4730436738220936, 0.12933463991212973, -0.20690979142222077, 0.06487473947371263, 0.05374154043793025, 0.5966651679349784, -0.3465213028020881, -0.7304145403259216, -0.5151605316621705, -0.6943598313925313, 0.050726948975559794, -0.6365783875100797, -0.08815307924012537, -0.35069087941467947, -0.11457181734490729, 0.14625589555232013, -0.4434830538749268, 0.1308090938251255, -0.7266107950350925},
    {-0.0003293510869759991, -0.2458344157957624, 0.2755586268834694, 0.062000818514907255, -0.08473418407965003, -0.4242201271344261, -0.6670468006697406, 0.035598983191978135, -0.5063304345190546, 0.6802566674524702, -0.547539684606111, -0.5132972890618979, 0.586666086549732, -0.057317420376903266, 0.13131821463711962, 0.31089035828362216, -0.4379192412724458, -0.3584682699190304, -0.2908669646560503, 0.5637398091346604, 0.10991396009773959, 0.007180593620657676, -0.7863582413774731, 0.1874225160954307, 0.8228933997670933, -0.6785371453721212, -0.3105481686101983, -0.4903914308609601, 0.7900425264054414, 0.22861243720477695, -0.7430809995089157, -0.3329944598910958, 0.8351354267476884, -0.7188475577308733, 0.2314620583805104, 0.08852846220743336, -0.3065147240622448, 0.8717245555723127, 0.1989644677322418, -0.4642394106755261, -0.4953260565285795, -0.4004386998809949, 0.37354125295052276, -0.1539591454230617, 0.5169655517502226, -0.4463582874296056, 0.019827942462209373, 0.07787568318271584, -0.37536035314918476, -0.4023701924569094, 0.9019893064462066, -0.20832686581576335, -0.7601685667578724, -0.13189823128919662, -0.43028800146264845, -0.020854391629917503, -0.6637196926127731, 0.2707894266716116, -0.615915557547954, -0.4473600320360897, -0.018882341090067246, -0.4455740685413697, -0.16010820590622798, -0.5941495402378131},
    {-0.23686975317110265, 0.10658667623650926, -0.042019693727794676, 0.06583473807560507, 0.304214845859489, -0.5283939753392367, 0.2263357968512203, 0.49560549700504697, -0.5785258773171211, 0.5543631347590846, 0.10213193301149152, 0.025136055443574865, 0.23685072399181875, -0.4327724950973738, 0.6969914904542996, 0.15984845797540306, -0.1180547578601119, 0.17391852640156252, 0.0732402877895893, 0.35770094366531346, 0.4472622025249725, 0.4302419004588834, -0.27158270889988395, 0.5991344474596869, -0.29086841980775174, -0.11620055287208336, -0.19941216674700746, 0.10713837618237372, 0.31338167512362336, 0.27043025006847426, -0.42599736006611794, -0.482715508529141, 0.3521289509546941, -0.28912326398059063, -0.5359340501120283, 0.09407901367277739, -0.22183714271863428, 0.04631053887480606, 0.012752161231846755, -0.4866741463763712, -0.18763603267293255, 0.09407920958699606, 0.18149051214574805, -0.5471242529119854, 0.007387704548673106, -0.5136777737953789, 0.026740722440103882, -0.6777575936758798, 0.0804333204165816, 0.48757024572180635, 0.24859236430176948, -0.4918760266670742, -0.03605027562795779, -0.15123259597735528, -0.4423089414815997, -0.12077663873375533, 0.16561696967007586, -0.36066208606985184, -0.187773202392782, -0.044769509277367316, 0.4422632157580474, 0.11750915650386792, 0.5187235628050283, -0.0766033342878961},
    {0.4521586303311223, -0.489633879842672, -0.5944713024420345, -0.31838586260849683, -0.3156684698439795, -0.23685403145352704, -0.4459895594225334, 0.21159050873401727, -0.6920047828617097, 0.029896994549777352, -0.5561059823937217, -0.635630996181546, 0.24489003659018657, -0.265895483928736, -0.1085872097453773, 0.6381997447943487, -0.4496500926589974, -0.6404142370531852, -0.4357762828128793, -0.034126663456538274, 0.7252448469529789, 0.6228717550641001, -0.609730432785997, -0.6789837464473342, 0.8135163246759107, -0.4051765151535899, -0.5260477126260003, -0.13768245304458196, 0.5821606506373086, -0.1579329869600374, -0.3940079442058497, -0.4189634994400265, 0.46596369880812394, -0.7612601750400159, -0.14478601106759598, 0.1966031973193077, -0.7017946843329925, 0.16669857849779215, 0.8456165343747986, -0.23854344713798223, -0.6772184352007279, -0.5153037482270277, 0.40002655306680124, 0.050206504687986035, 0.7049666976783432, -0.5047421472179439, 0.10527209675137805, -0.10239413394650891, -0.4301255833726302, 0.10566207492379795, 0.22296647194513536, -0.5624473809411251, -0.12271282700808168, -0.4936459277275345, -0.46283002772349185, -0.6543416039462319, -0.1632939018651825, 0.6175996360692655, -0.8436376465204456, -0.3514551143488709, 0.4769449888783286, 0.04135542011722867, 0.2662285732282853, -0.7654273148699596},
    {0.3156855760679756, 0.05884787359230093, -0.12570668530242401, 0.25267532665270165, -0.4058634940746938, 0.21563772697706493, -0.014279079901564802, 0.4670313247573016, -0.5661405023758522, 0.17849789494397927, 0.039399616243784845, -0.7084612379195968, 0.5946213084620566, 0.15472447071605586, -0.22766797512029424, 0.733773671873829, -0.31012628632457745, -0.35142593616813106, 0.0007732157205826963, 0.1937028757355376, 0.2961244044180584, 0.6080835722156571, -0.10106929791603168, -0.2327944027936657, 0.7698035324965115, -0.6420877858988984, -0.3434398735944135, -0.12220946780940226, 0.28401477658802726, 0.21532805983511677, -0.1358060835262627, 0.15616439149085676, 0.4357534100020718, 0.030772030199735508, -0.2091191930364772, -0.21886592759234108, -0.08319346791997757, 0.5282776867453638, 0.5291084449507133, -0.15284295044716778, -0.6113848997481673, -0.4848171820230281, 0.5130489628219947, 0.2428244023893084, -0.06679429026661352, 0.26636803834142797, 0.1945946643098046, -0.29247152740116994, -0.20198692003944627, -0.31051648266048876, 0.11440128850268226, -0.03453120577111258, 0.12492617665889812, -0.23870246900577374, 0.1279934261657061, -0.557347858533884, 0.28613190606329086, 0.5704648870810257, -0.5651313093408991, -0.36574883634899236, 0.4542127855867722, 0.11912752236340557, 0.21668120054310255, -0.09731297474756594},
    {-0.8176073940825983, -0.36554927924072744, -0.1304134944773306, -0.6817007479070203, -0.35963664638091436, -0.16235508758059405, -0.7629050522695587, -0.7077779102190502, -0.8153931418238307, 0.040098631263517634, -0.4433075812390476, -0.38938014252509, -0.8732792326220078, 0.1327642010795519, -0.3317159645090286, -0.4508565336565784, 0.2199788760332208, -0.6752252664474406, -0.3391296509430108, -0.057417654433520884, -0.4875531683089674, 0.21141765766605491, -0.791401404824075, -0.22287194053855539, 0.11931707844600152, -0.5395542216498815, -0.4347956173118266, -0.8877659465530459, 0.15839860001701425, 0.20634267198802175, -0.661273275780567, -0.21843033210174076, 0.19906168704808802, -0.7831584959762248, -0.0375514919384786, 0.2717995854718459, -0.7335368566671964, -0.019631431686796114, 0.31471901395539714, -0.4915226927551848, -0.6713318863628055, -0.11029883287863623, -0.5268412824883456, -0.40541756333040135, 0.3791273945730989, -0.7062678648039876, -0.585547208047071, -0.19466546857912972, 0.10911144720934733, -0.6623505726192668, 0.1179708620297921, -0.6004811785113907, -0.7844577672002407, -0.5460384857527257, -0.7784385040503595, -0.11057360985574025, -0.41261183666742246, -0.1890020181613146, -0.6254912023472791, -0.03953709957868191, -0.5582333400384729, -0.8774484459894863, 0.19787481721623693, -0.6804358510106023},
    {-0.34903445115095016, -0.18742073526985714, 0.17145863169220293, -0.372973545679568, -0.6870414215110541, 0.04171405337188682, -0.37772743103425743, -0.80586434531856, -0.6075703156657813, 0.20450133993755362, -0.4667659177382974, -0.394451749294499, -0.6735432592835285, -0.16289458456633835, -0.21176440618865713, -0.6613221824203988, 0.17399960019105154, -0.36093384921294003, -0.3443369716548995, 0.17914034200041667, -0.7428781150543555, -0.13146948294794714, -0.6866436908136296, -0.1146461478479368, 0.4098037909631107, -0.4889098170149616, -0.28339917241386514, -0.6724025051704324, -0.21031831270928242, -0.23913672519323945, -0.5555238378497839, 0.05824777693330213, 0.37149361841812895, -0.42332193332803636, -0.30769669285985934, 0.2273715764827871, -0.4020481205166202, 0.10923902844417156, -0.20510039045542366, -0.2969922113896986, -0.7576625524085423, -0.3373639931517774, -0.3567757050290852, -0.5228935836825488, 0.15031756247656308, -0.5657870940771111, -0.6668076695582316, 0.10671506511828602, -0.20362327357873045, -0.5812384426746224, 0.1552720688062108, -0.5782205511276282, -0.5357767480296316, -0.5231851538496928, -0.3487555948311071, -0.0988413106641839, -0.8033543131536364, -0.21744435777442897, -0.6407388035336988, -0.30236707430889315, -0.6561127682304261, -0.7916484331620093, -0.03572108587418336, -0.7322633823732999},
    {-0.7362383608763897, -0.03087384772848767, 0.06478016797284665, -0.21171193734091368, -0.07698134188618495, -0.4598136052175661, -0.5917863099437433, -0.40336427373287087, -0.37061465607383026, 0.17506660240858438, -0.4934718390953254, 0.2200572297682226, -0.4077419255719558, -0.006998604093514324, -0.21691112129425527, -0.3555359647649423, 0.49034343461734053, -0.40745852036617547, -0.00600300320318956, 0.3769523905374426, -0.542850417625752, -0.2494847459073971, -0.6854319535711986, 0.4083435369556774, -0.07939654633579933, -0.1446536190340168, -0.16137073381205533, -0.4409485342317186, -0.18749339689096342, 0.5758094363421626, -0.574692067593093, 0.2622334432787139, -0.073396432405184, -0.4567608572066698, 0.17130593755479986, 0.39961376070100235, -0.42032304257345454, 0.14330351826527865, -0.22118278567789165, -0.20562930559811152, -0.05318591857805468, -0.3759030408039416, -0.31762007284112187, -0.5000797449696345, 0.3560940762183539, -0.6024086848397502, -0.5767378439327199, 0.1256016397364732, 0.24662574486253142, -0.4763779138990841, 0.08118995841083186, -0.35008924250526724, -0.4307238771938992, -0.24950099626443745, -0.454587754037011, 0.5744831202990196, -0.4680187069761564, -0.3944027628468286, -0.04326889953235852, 0.03231208444499537, -0.3712326983098998, -0.5804907958323797, 0.15329384583011932, -0.3703762566185023},
    {-0.19780565513317086, -0.34961699372241134, 0.584962724569637, -0.1094579700719329, -0.16991691704291548, -0.351072061359162, -0.22072383875845056, -0.6521474100095808, -0.557601917158675, 0.23798177242679117, -0.33928083388788793, 0.49681709276041613, -0.6211534365555218, 0.07599154579561589, -0.23783256940085593, -0.1908128363946925, 0.08716958453684523, -0.06591933453519264, 0.1777596628274844, 0.28645048538427736, -0.39925442809888834, 0.04196842291470564, -0.5685309183836214, 0.5132342620794733, 0.14473857952099117, -0.1244889873857161, -0.21918614592943989, -0.6940708440427962, -0.5518954651701594, 0.5214372278671633, -0.4422573894667567, -0.08252015910074526, 0.006039522579510457, -0.6667387597289149, 0.1556246763030613, 0.5142546666294356, -0.37325825740279867, 0.3893863469070168, 0.14481641577479798, 0.11643880287324777, -0.4925925117235229, -0.1843321019153829, -0.31598145019538115, -0.13254428567179855, 0.5190863997603674, -0.6724735551558081, -0.4069589036833005, 0.09357185971509624, 0.3532616850498531, -0.32863689631336496, 0.4777368318499111, -0.5016300161614087, -0.6849429489341231, -0.0056044504586770846, -0.38788537281421404, 0.06726692759435565, -0.5971132091846446, -0.24658550044336314, -0.26013745085588763, 0.08765338972400688, -0.5400840825442211, -0.7430669975941683, -0.22825362432150006, -0.511407353409367},
    {-0.22709888321578275, -0.0003104385176201045, 0.4685087083974402, -0.5580336747882206, 0.07646920835376747, -0.5443150510831346, -0.14437881286546547, 0.13640652862190256, -0.6690213381608116, 0.30899265310478413, -0.46939008318058983, 0.39624736507877917, 0.36975724026960355, -0.01700899848229283, 0.014448505304289946, 0.26564780959644313, 0.06129600601891443, -0.27474598630163793, 0.06067200141402812, 0.4737247171395847, -0.023221411389607073, 0.06988713024867467, -0.3693949467774623, 0.6140942471285307, 0.2056125021495425, 0.3077485583751595, -0.1536114609585611, -0.4770584614412699, 0.4146642271802303, 0.2646525584730188, -0.7295364423358075, 0.2581312697826141, 0.2671149235296151, -0.6603952261659518, 0.4992079717488776, 0.6005165478537153, 0.21072216873641247, 0.2563162319728787, 6.792122179914012e-05, -0.24662933932585515, 0.09020493775141047, -0.02914267747810229, -0.04276573594887535, -0.422587464205114, 0.37059757269646065, -0.5903705241780852, -0.10108729162206823, 0.31497114635175033, 0.5540013853167653, -0.2766968054808013, 0.6946385455880644, -0.1912663336108149, -0.298252281698402, -0.032483994074132896, -0.31100190303881503, 0.5005305121590082, 0.15222946168264617, 0.11849214787627932, -0.5703765288150948, -0.3012693157115824, -0.32090769491104704, -0.7443867318220184, -0.05247990215100572, -0.17179960873441116},
    {-0.20739859689377152, -0.21895964146800184, 0.4379357020170269, -0.645260461724623, 0.5322566004939203, 0.019529451959105777, -0.16869876174459647, 0.12937412207283458, -0.3558377796386236, 0.10181841763870736, -0.3724602687493059, 0.40024100333206, 0.10586329608653365, -0.0468856776848866, 0.2576284391728808, 0.3452578818658878, 0.601698173610375, 0.08025192947917378, -0.14496669479281252, 0.6264414399395746, -0.21017124200382245, 0.13335541553709154, -0.6106464988728362, 0.01677883337842268, 0.5145329950553296, 0.07767582886385306, 0.10587842650134978, -0.36694036485466447, -0.2878731395588562, 0.5401981050349125, -0.3916777907287295, 0.4882943613341859, 0.4002855847247742, -0.5100732771793176, 0.4390757411920144, 0.46585912860895284, 0.19013256112526308, 0.32341037482182805, 0.15643259254253636, 0.06837475939325417, 0.11387410930018646, 0.03252409234099949, -0.012067185893146643, -0.08554803226669672, 0.19895110682969175, -0.47152377912483123, 0.4806915414560878, 0.36796028423761457, 0.4062308428815855, -0.42872547212784223, 0.26186147705920576, -0.5355208304758224, -0.3754245129894312, 0.28242395455310304, -0.47580000414891205, 0.5532803137912923, -0.6474655579244489, -0.024438448640358497, -0.022860642313079625, -0.3948206139411731, -0.3834277197164018, -0.6674782945613102, 0.1908366365913999, -0.43984829179550894},
    {-0.24619456282417657, -0.38387393914018564, 0.12132637178260573, -0.056586909394365434, 0.2700587548491701, -0.5579152532219654, -0.3533211189947141, 0.14782183992222386, -0.4742693391305318, -0.05938018555074287, -0.030341239278623606, 0.273515255732095, 0.23844753021332868, -0.07373885687861242, -0.33673757739001275, -0.24846763657528667, 0.032930524205248286, -0.322505791660186, 0.027526030091276178, 0.38849934651627416, -0.3683888008779107, -0.13997767307469022, -0.48503969754146403, 0.20781502573490604, 0.4574563921989387, 0.2673810083459612, -0.11097403535585168, -0.46405780177593886, -0.6401429493589177, 0.4206026154024219, 0.03607409170971095, 0.3612559723726207, 0.588168562782926, -0.3865207227464419, 0.29955175587425314, -0.08037915055656933, -0.014898948930999079, -0.18935182383391622, 0.1184560187464563, -0.29017028671095574, -0.4429265028441778, -0.38201340905228764, -0.018783943674928704, -0.05559549032241441, 0.5792117009260943, -0.5638863251026608, -0.27429442727633563, 0.5722174225637713, 0.10752539446070344, -0.07751450370133538, -0.29593612926850615, -0.10223087897696095, -0.3705738938207667, 0.06179481101303268, -0.49711862080540514, 0.44172360599321464, -0.2598757398100218, 0.3816653897085736, -0.4154559816291344, 0.5328867371393717, 0.2778590322771208, -0.25666294996629585, -0.2781692950687816, -0.46349901973888935},
    {0.015681909202478153, 0.03866849988002633, 0.1958678559386047, -0.21909012404091718, -0.12008263114090967, -0.2969307444939765, -0.5548775307020826, 0.22609931695403399, 0.046392370687217924, 0.09229855174662399, 0.3355586799505654, -0.0688757654229082, -0.16466257764546863, 0.5252758661913992, -0.6250118243843675, 0.44875160157733235, -0.19264058364422965, -0.33195383677297163, -0.09752270306567146, 0.014497483119092738, 0.17556864990979698, 0.3117410798620275, -0.22935275809689595, -0.05468536094929707, 0.14931906152196342, -0.011486691564760305, -0.1951252231642689, -0.08802180154161651, -0.346786513058709, 0.2846231498732577, -0.16741451523809237, -0.12031171748739906, 0.3065685144010427, -0.3090836780549443, 0.5932153014463422, 0.14922311330402835, 0.14678900857539956, 0.2773937915622145, 0.5261795571166562, 0.15304299185170772, -0.4535922389976858, -0.05878799777791174, -0.2854549058981893, 0.06942391759685307, 0.11414389444073124, -0.03153776735920038, -0.021367947392925978, 0.3546221414023314, -0.2125932166181125, -0.3579183854979327, 0.5028402727562802, 0.15956978852251658, 0.1785374423167798, 0.2312350986830919, -0.30953313878130095, 0.2757947735683775, 0.18514807241747233, 0.5856644538845236, -0.5164884451644547, -0.209040267352237, 0.22177001883450304, 0.24987377587174897, 0.5613713684268039, -0.47947614066540595},
    {-0.08574868584334701, -0.6405298391840168, -0.30293464068885684, -0.5367673503720822, -0.14721197753667933, -0.3648977369398381, 0.03143519514226049, 0.1418294441186424, -0.5209549050478612, -0.2378089909352443, -0.1838155714287388, 0.02589097768900474, 0.2337207340514021, 0.1629438331211159, -0.6536040904667446, -0.3233772587479785, -0.24239071519519814, -0.4424447452093578, -0.5120169707944374, -0.003793727806226182, -0.33170027573226013, -0.1944936966179437, -0.675020464506952, -0.20265502374265973, 0.43285374976550806, -0.16938637145633456, -0.2032275364745101, -0.1949886819186346, -0.16518226646279544, 0.36647843424759324, -0.46876482441327955, 0.5424321170320495, -0.23725867969743325, -0.015554276726848277, 0.14286180263923617, 0.45644803476447066, -0.49966788149056557, -0.031222338602385, 0.4233249769901884, -0.06518484128155168, -0.589532497134922, -0.29184887622289213, -0.1177498117269328, -0.028899669818079655, 0.18774882974676482, -0.311981078536702, -0.521067951568629, -0.26921228134467906, -0.396152754892208, -0.6373854413559633, -0.4952197352633372, -0.3604510376329677, -0.015123403688313407, 0.08707621753583716, -0.5263021355239826, 0.42683792909812224, -0.12695571607200506, 0.07900956946481709, -0.3880117886377507, -0.17724547323186257, -0.5107529902538496, -0.2928922947813655, 0.34859713710291984, -0.5122202763455542},
    {-0.5416209223994053, -0.3932554752769297, -0.3333549059201701, -0.1454231933971096, -0.36030872374605555, 0.29396615885173877, 0.15759622266511708, -0.1408647837390767, -0.44841919291087706, -0.2933882944522735, -0.11508128895383626, -0.14498632089578223, 0.3902743647514257, -0.07304695823059139, -0.060715289139766905, -0.14512139077139163, 0.11397733469480766, 0.021397959337635285, -0.27269696040764557, 0.3744831763873063, 0.20888447230925763, -0.20951587479136455, -0.12169474744908398, -0.12789856563441204, -0.27999389613473613, -0.03087054020629924, -0.6342563067120017, 0.47882410118596475, -0.4769502785963625, 0.06560107651411448, 0.08785672784943503, 0.4146792055580196, 0.11593111963378216, -0.5149468268496348, -0.19205064193699287, 0.27358658236194056, 0.28926711604715666, 0.4487203724808178, -0.34143245548082424, -0.22166850433927143, -0.4057813240149829, -0.500068048412048, -0.02466170380716567, -0.2462285700290706, -0.16785982885499287, -0.13434110949852562, 0.1434652355308892, 0.4358930954316253, 0.171924613841665, 0.35350517363651124, -0.3182218676704493, -0.02053792015073258, 0.07641426574804651, -0.16895778672076806, -0.08396664503368625, -0.29008792148805496, 0.047816766944418734, -0.4592043274605509, -0.5979107007969562, -0.3578072247711686, 0.33640839643575937, -0.11025427832791668, 0.08942970112997904, -0.3935877259258139},
    {-0.4218477033090677, -0.03019394160171081, 0.4056160681970889, -0.35394645576212486, -0.42954958003602334, 0.25017210186530764, -0.3778036520795383, -0.4153360155565459, 0.11418842421516931, -0.011150363896922928, -0.07278225160681699, -0.0926131405891828, 0.2579687652031522, 0.13062305709355504, 0.26093995579264767, -0.17702549351893893, -0.28380321835191574, -0.2258613515412648, -0.04114100474257642, -0.11868430294834409, -0.33641359121885495, 0.1563391632740619, -0.554636463444286, 0.4559424135159747, 0.39926136645567334, 0.11471326565725343, -0.22481748455248, -0.6738916299190586, -0.3576361575505209, 0.4995813372545774, -0.30101241290600245, 0.5910952092278084, -0.10490674749213817, 0.07234479641844353, 0.19094607799608543, 0.4343205262849915, -0.4499623632572019, 0.4824977475458268, -0.061422274349482595, -0.20055218087867072, 0.37475008970789137, 0.10044805911459223, -0.15198479717745597, -0.01955440329218809, -0.09298451360272499, -0.5472277603888532, -0.384287813872639, 0.029808672218700608, 0.5091649869190794, -0.4413637115476965, 0.37145129910828323, 0.20366552011005581, -0.16615558863791735, 0.2752906907792438, -0.14838117694372338, 0.6037698751094618, -0.11197417805860135, -0.07673749103321835, 0.20739151063868164, 0.18086747354487623, 0.05100359200814183, -0.5758076868262983, -0.33527865990450756, 0.25565530937613534},
    {-0.22576653128664265, 0.27851413826204763, -0.08849660113148632, -0.59848083904024, 0.19929612445630054, -0.1196400876072271, 0.12203599227244107, -0.13330840266970084, -0.2064889257648021, 0.40648770402462353, -0.485017622236599, 0.08670683947835797, -0.2431407999141225, 0.27740517720422525, 0.09408353139230621, 0.2966346602861876, -0.20285663326687164, -0.18885559874354207, 0.2965348359363171, 0.34499297490616426, 0.1768267481576371, 0.10469526758057382, 0.0016846581045884452, 0.5844392772214704, -0.05870593305863476, 0.3793381593830426, -0.09304226564905926, -0.07537715651153344, -0.025148876992589417, 0.25313359089487647, -0.48765571771729693, 0.21812958117239772, 0.4718338137194808, -0.04933074205214401, 0.05487005701774347, -0.19097732247418, 0.1258392900793436, 0.36925445643526794, -0.27365010319633204, -0.045400313030524025, -0.42755977199739487, 0.3508302263431677, 0.06962851043132055, -0.2620058832819906, 0.3178423298667651, -0.41245826024519855, 0.43560100165685073, 0.24662095711212997, 0.49616237650423156, -0.17250294749607198, -0.16646094228519845, 0.029236806210674857, 0.26873601503722955, 0.27912582915589684, -0.5076980040824888, 0.09383640460609814, -0.14397230119958268, -0.3127086583870882, -0.3627000301231572, -0.47022493452476194, -0.001941489453859395, 0.18112025634880302, 0.05202176617475144, -0.25744653526486594},
    {0.5191133346733734, -0.3153229471973039, -0.19731612458792597, 0.3049389945979724, 0.054754912960020906, 0.21972305561002275, -0.0979853562759442, -0.25948085058160725, 0.22360130861781102, -0.355136485001848, -0.41367004464219137, -0.24072809851585905, -0.1325388735890876, -0.2802148911890576, 0.22620007062515457, 0.5599771304893287, -0.18058502757131145, -0.3323116662093044, -0.26873477248965455, -0.22483298449627837, 0.13104286392357722, -0.07670320968506525, -0.05664171410246798, -0.23685828783294932, 0.30605197410671, -0.25798349094179324, 0.019166692988977826, -0.16667745980181425, -0.409177700514012, -0.17799839345233043, 0.009982773543224119, -0.051152289131980215, 0.008959845926017703, -0.3985941404874166, 0.12445405568115785, -0.03360680488529087, -0.10291422192368538, 0.12529774300667024, 0.14185205717824473, -0.10514054577071487, -0.3093878321922129, -0.3829721414544361, 0.025328263894274977, -0.17543025565383216, 0.028646407665636107, 0.2650221108703464, -0.23672585262296247, -0.1452401424877529, 0.007238519373890229, 0.08937584726010359, 0.2390255939250265, -0.2579347022472315, -0.10364142238432632, -0.517302016473997, 0.5087840104190303, -0.3556967300451379, -0.0292632442996571, 0.11691048580663777, -0.5053611803839974, -0.4616084641442972, -0.26063204227895775, 0.023132612490883393, -0.09959327907618763, 0.2215389861074688},
    {0.26501640426718837, 0.08296382058227252, -0.3664979631823998, 0.09285504084406009, 0.33042388048672194, 0.15684652177300673, -0.21483831968718528, 0.3896278070290125, -0.11664444095219942, -0.18222982306599878, -0.2112965938034189, -0.14404435440112712, 0.27460537890482306, 0.04505743806282139, 0.25498124369542047, -0.29294357801538456, -0.24509142787174537, 0.10628735141239386, 0.21959744960982286, -0.369656372716769, -0.009680700116667853, -0.3224832242061959, -0.3946018441110843, 0.42208656553107926, -0.2700718517247688, 0.07719207184135592, 0.09661827959172145, -0.5189720170799642, -0.42369937982032, -0.12426056522657887, -0.07465566793503886, 0.362572918111089, -0.025804987630764283, -0.09841993968253068, -0.23348202412905222, -0.2812144638578219, 0.14422823384178138, 0.4573155830441354, -0.30013690775896373, -0.4832445899717828, 0.13533508710944495, -0.20409143118589942, 0.3333059190996439, 0.27583546151777166, -0.1441877291892324, 0.41256476973831185, -0.44197482039051506, 0.6088488845231759, 0.5864116807194037, 0.0330013302712806, 0.35038747135504533, -0.1660058365563728, 0.1287630307580613, -0.08202134439049759, -0.14754150430270999, -0.007968946012876283, -0.3438787543891779, 0.024481752396543287, 0.1950740757640588, 0.0355140854756764, 0.13446539736963353, -0.0004660831034107033, 0.3132649259389814, 0.49637118557863136},
    {-0.27310543073423493, -0.562884502194073, -0.16674321057603686, 0.06663863277425705, 0.3549966477251895, -0.29394047403480444, 0.007299054033993276, 0.3416388959220174, -0.27064690883317677, -0.12022304034747801, -0.38317799324527846, 0.5095859371169192, 0.04492910347138901, 0.06942167074648367, 0.39541598783029536, 0.3073992166497951, -0.4494950271593909, -0.277154112694033, -0.02223095437573366, -0.14049900175760532, -0.23596171437254113, -0.27289071816277627, -0.2958885964098241, 0.0688950745703729, -0.3027902621179376, 0.17104518769404847, -0.41750235153142007, -0.1878786218663465, -0.0882277969821798, 0.12809221195976445, 0.04622276781019808, -0.029518752463911144, -0.3394507252298047, -0.048582011514298536, -0.4857124207363912, -0.3387605737949319, 0.058972651234385165, -0.06388488334282749, 0.20835269568894188, 0.3784879617873386, -0.44819905286689876, -0.020015676829017264, -0.34086477656996456, -0.10069771790486541, -0.04454319671002634, -0.3682650204490281, -0.1700276693570423, 0.23390650854095135, 0.21931601035398415, 0.6556489379038885, -0.1325256098341534, -0.3503205219855002, 0.020809070987915478, -0.3575451126457442, 0.23417501755560663, 0.4506037805980241, -0.04907752670599559, 0.32979414496711834, 0.31059311117153504, -0.008658791423216152, 0.004579402104970689, 0.22988156259220352, -0.024222416622743936, 0.3389362767266042},
    {0.1069408882431085, -0.363058076105384, -0.13417989588145515, -0.47683158703274187, -0.47059581040260035, -0.42602496202389717, 0.20746081248331893, 0.11188109564963494, -0.7018279658787664, -0.061360297828423824, 0.057856528795954085, -0.5848379334200211, -0.3944094138317137, -0.5097711977591599, -0.06137712752330185, 0.28985345939096846, 0.2040999976061372, -0.6361527078832933, -0.15248611454530522, -0.19648033450406494, 0.25873184687741163, 0.3072226401515162, 0.28253511550359867, -0.33439537759674587, 0.32684504549840226, -0.406108761642981, -0.39977420210622266, 0.3588853775920465, 0.11918313352111316, -0.27276464878499074, 0.05777136228884358, 0.10787949614856371, -0.2608084275303101, -0.40024708472471304, -0.1826360632910165, -0.3477516126215468, -0.3385020850126896, 0.5632850199577089, -0.12470807123724136, 0.261777630420349, -0.49454118348682163, -0.7621745282031467, 0.22756055226902694, -0.10585229060183039, 0.12330579484815189, 0.18508592404104393, -0.18581382881469924, 0.03946371174445965, 0.4230491349718553, 0.006353979617468603, 0.10276811429686077, -0.5836005381333937, 0.2667460289463624, -0.7373246406393692, -0.25457283828540705, 0.2516261221597921, -0.11386662386656739, -0.3677477556555637, -0.284445963424386, 0.18002319710764966, 0.21790580301824625, -0.11474568206880686, -0.03383256067366294, -0.08669719764424237},
    {-0.05629235739706621, -0.555709479011803, -0.027620325703882315, -0.6279114021145098, -0.36206789774463927, 0.06234644179734067, -0.16433944032081607, 0.29204289981019377, -0.11173764180042726, -0.2108806612033016, 0.22786990964435266, 0.2751717845774045, -0.21905724102904758, -0.3049078918884336, -0.29901550457121434, 0.0965324089214892, 0.012268568907951718, -0.09198821597368537, -0.1301303210884222, -0.13739472379177317, 0.17132108815212146, -0.10738560290807843, 0.312308233551514, -0.18253532130175107, -0.28695364963495473, -0.16332640180367358, -0.7201673068313957, 0.14273649731617058, -0.002573967925592744, -0.5756410208658068, -0.08118888532387676, -0.1410956419834755, -0.2654285100255998, 0.07070139520275578, -0.628827166585411, -0.3229360750789949, -0.41831420133316716, -0.11227997052166618, -0.18817321068112683, -0.12267331021218157, 0.15978632386104064, -0.500555232676284, 0.06859224681665384, 0.058044304179429275, -0.23048403257634992, -0.3727299040730708, -0.3199857002910452, -0.3375649113778258, 0.07337110936067172, -0.27803201475889444, 0.03246229722133642, -0.6774315835887741, -0.5440358630117976, -0.10625297153120611, -0.25805038867948427, -0.2065890101190366, -0.07547788477831252, -0.16476986843152452, -0.5421762022101929, 0.41330159806834665, -0.032795023379380735, -0.1373535084045521, -0.47183545705937413, 0.10169390818646941},
    {-0.344006172008484, 0.45017797339738735, -0.05430590851372277, -0.22071901910910827, -0.1696800585953109, 0.019380376325492516, 0.19723295850147535, 0.30428775771481986, 0.24030452536075123, -0.43031519165500254, 0.07279453896606079, 0.002393577629215508, -0.17283825865565305, -0.5766027421028749, 0.21145761492427415, -0.0941117466473923, -0.15351380564115602, 0.04989490437771751, 0.023083030876949164, -0.1707500752764931, 0.36141827783833547, -0.3948146529625793, -0.019376104643285003, -0.17806812214155252, -0.3275250289448649, 0.4410836681479599, -0.01712054258016728, 0.37162895803612805, -0.2853388339525749, 0.2474629766379515, -0.2351547755971423, 0.09788996114778901, -0.33661296245744915, -0.3799004723595341, 0.2594856921890095, 0.07296446754092349, 0.25907653541552444, -0.4306877329585086, -0.45786433337435184, -0.3325667300593494, 0.37212141614875965, -0.04758250339749925, 0.530975929771559, -0.3728874798338414, 0.06234075425953171, -0.4216330037400884, -0.10357582742357448, -0.3512172234077263, 0.48617090972141436, -0.32204469652707296, -0.3843005196379367, -0.4503118260528081, 0.041551645379730134, -0.14007640670946458, -0.06284918113837959, 0.3277680881886098, -0.44524279350461815, -0.13772149649724544, -0.3253311275051814, -0.008078008221366872, -0.3577411156333121, -0.11714736188964771, -0.3289844332630812, -0.20466196436027842},
    {-0.47035859832497917, 0.11411623400824726, -0.41106645867748576, -0.3800460096735407, -0.5549011189794766, -0.591293574368159, 0.3625018042914228, -0.1058872466099127, -0.20204783233003268, 0.09937972235999938, -0.5178849929664913, 0.3439501438277397, -0.016043870847559625, 0.012563799144515634, -0.5240414241110957, -0.21738358835074184, -0.049170206936963, 0.03584745154435439, -0.29143074973079863, -0.006523500304279079, -0.08922621848436728, -0.13248225310420197, 0.19614676185502503, -0.1746049712077594, -0.038276933972934295, 0.5729492071565915, -0.5965609728681883, -0.31290161996245586, -0.07388071043352125, -0.15254849744921845, 0.17106512325330694, -0.4218916144811192, -0.49423638736341946, 0.35715017237254837, -0.261027573568845, -0.42341502893027466, 0.30522970477563666, 0.0796686299721044, -0.04635880005420087, -0.05248585619683705, -0.10120245657289076, -0.6448710805407593, -0.3022301220517518, -0.0824866790415049, -0.549258034251363, -0.12052886855058584, -0.4269942020492824, 0.004535618019334007, 0.3231204653381197, -0.3525378138090391, 0.02581412139665318, 0.1570866209622437, -0.12920400979827296, 0.1578759026153243, -0.41418267962713484, -0.04066838196601141, 0.152340440634335, 0.2515220401410417, 0.21368944749403845, -0.1849446183783913, -0.3402374362761807, -0.4791691470792733, -0.20551457661153794, 0.23278277853588114},
    {-0.4614395249987315, -0.5141919946380537, -0.06744950507170103, -0.5521556595225111, -0.3689629752992746, -0.10237875619276962, -0.31588986837228356, 0.04452109329261563, -0.10264148747964749, 0.23566253950212018, -0.21453816942236129, 0.32887555615338376, -0.4353098881444187, -0.07873404346397947, -0.20839201329639023, -0.09873786209570169, -0.5573127267677458, 0.24295819276726577, -0.5032232418470551, -0.014196096152126941, -0.030451467276583686, -0.1586531310690677, -0.15315923499789086, 0.30234547572046194, -0.34650891290233976, 0.2337363725928888, -0.2592416304412692, 0.11668057216017481, -0.3193172259486426, -0.5358116530499856, -0.011111627613706572, 0.12801181848892892, -0.04003008500661398, 0.3267831442777195, -0.1443155532083832, 0.4249842202434357, -0.5105480744727131, -0.2287408817930721, -0.26239631978395245, -0.4342473748182638, 0.12580925901807968, -0.4973388420507303, -0.021492036949060822, -0.35837554013763745, -0.34358958327099076, 0.01703578972407136, 0.08168116016792769, -0.3632556516841163, 0.44062002834870717, 0.15864121345766521, -0.4219481461889192, 0.08190529795666289, -0.20359566102617155, 0.29999876343411963, -0.3782436901246223, 0.2642984465986256, -0.4622027293277189, -0.2956111702132346, -0.01559451184075924, -0.03591177298455913, -0.2630344792855796, -0.4034457827107466, -0.4430432875407333, -0.12276758013591337},
    {0.25301765916259816, -0.4589898526285287, -0.5213927698655236, -0.0967855456199884, -0.43652152622930174, 0.25977626248959906, 0.3889478704079383, -0.42362983182801767, -0.136408907058904, 0.11544378100762613, -0.42417984311461787, -0.0573093507869808, 0.3958307259162919, -0.012056180993072416, 0.5205677003982505, -0.3657556253863489, -0.44571280106467914, 0.08047060270216888, -0.27246960239400714, 0.03672661261631191, 0.3383987929498358, -0.08977526891206683, 0.0013247451012826765, 0.34991921973258133, -0.15585372030526257, 0.3816286747118922, 0.39428950868609075, -0.01644916333928364, -0.1999540881524003, -0.5467055158909138, -0.3138190689779972, -0.17794824213184934, -0.4073545199576276, -0.12543985819704026, -0.023605948471619027, 0.0898308719312202, 0.06301500776361973, -0.5940797397307577, -0.47120440993555357, 0.5226304365202074, 0.6000621472335974, -0.3975842022956309, -0.12496126997244983, 0.15041124536842856, 0.4311629578460867, 0.33262347893072286, -0.3322937797754886, -0.4281909211617589, -0.0268689107792211, 0.1817047252256457, -0.40405598678027377, -0.4605811989449589, 0.07398181581338775, -0.32831009631608626, -0.19439865433346198, 0.29640383114103985, -0.25609019774849673, 0.30157491486310894, 0.14900262481045906, 0.3889460068023484, -0.33304226293360134, 0.07657830241268503, 0.160624320175355, 0.03021243366172734},
    {-0.14503833552995182, 0.42527275114281976, 0.19038786225281865, -0.5474438896196463, 0.3448557767506875, 0.4408057352079241, 0.06227426270388701, 0.398100303774797, -0.3630874672649712, -0.5170310599637139, -0.23739545408899496, -0.1046985294075363, 0.2029192149807463, -0.44452984272714674, 0.10336641427892786, 0.0939663219174245, 0.06856869724931526, -0.21309748123550454, -0.5397401336695149, -0.08564903748759946, 0.054180758803816155, -0.1929014461203722, 0.07936775195938428, 0.24441983332162406, -0.10878557006151895, 0.15240720715405684, 0.02344311109788637, 0.296733075343211, 0.14304744998548552, 0.06002916037670749, -0.3271857520999289, -0.10600474683014047, 0.06672837328909477, -0.05934881493657582, 0.017028569781627655, 0.56044784847022, 0.4148356960214087, -0.12542602469603983, -0.5359153547673752, -0.22567957020226792, -0.024099634437032568, -0.4881195352164745, 0.0476692520524041, 0.04587839860336977, 0.3798303521868874, -0.04708592971487141, 0.25520887459212616, 0.35202876943906036, -0.40635053096125384, 0.10323693547652893, -0.3556711414634745, 0.1011118286345202, 0.4130303972117236, -0.31525317531902547, 0.26020064645362556, -0.15973120398645754, -0.42638629680155565, -0.3811595368507583, -0.0044108545591111875, 0.4727956614563586, -0.37054246296755483, 0.2964190536819347, -0.4315950443537469, 0.2967777074890924},
    {-0.0655857003709987, -0.21777386463040813, 0.4886851099033638, -0.458029228820973, -0.20305594131242827, -0.05440499029871597, -0.137691235158801, -0.3060997462486885, 0.28320126502701953, -0.10202945299464904, -0.40203457515471275, 0.35760004969618814, -0.3749017363252659, -0.09018036269591419, -0.13498167680773435, 0.19423999510086892, 0.04550116445954321, 0.20263861426199706, 0.43648518574017703, 0.3711466963215185, 0.42027139918666806, 0.20056660405661195, -0.17583662643654224, -0.04121334615130854, 0.44301298380964504, -0.29799874223393524, 0.15392052153201408, 0.12273958743362332, -0.1785875149673748, -0.1082772600710006, -0.16226435566503652, -0.2511306555727404, 0.27500593900420706, -0.22201719188822086, -0.04085802049931456, 0.019542460306809114, -0.08437837243602231, 0.34400776050241544, -0.24359918410928846, 0.47796910497424483, -0.421846372860206, -0.01184214989329669, 0.24761390072995645, 0.046410490198624976, -0.26686425781086437, -0.0593323798815907, -0.02029039052072847, 0.22537630909035808, 0.21054666993662816, -0.10313548417125089, -0.14016295926884265, -0.4585562987606358, 0.4616446173664586, 0.22273211723745742, 0.18872714479546518, 0.13261135321563136, 0.3719084571567024, 0.5177515594840223, -0.35101888375740553, -0.2848287615748956, -0.35175974904883106, 0.1367168669725481, -0.19196374986281003, 0.15823833819268962},
    {-0.24530043209718308, -0.32404902250459966, 0.421455274436599, -0.484120098906967, -0.13753637589745915, 0.12211086401252629, -0.3952363280605923, -0.29793998305587693, -0.3550892086932611, 0.13347242213360047, -0.2095432435197199, -0.2723646408314834, 0.3756240319315299, -0.12214012092479817, -0.36411587730279327, 0.3072687301226196, 0.06969882390393536, 0.29788541105661004, -0.23171230483417812, 0.3072384689259092, -0.14577476764483932, 0.010907538821860567, -0.25856047087708245, -0.44051730755074325, 0.2676415890393537, -0.08098664121032123, 0.2910524143930506, -0.22503297479410253, 0.3995974019529832, 0.06068588779841534, -0.05289272468412911, 0.3285262752962917, 0.11399545937116295, 0.19767781267812756, 0.11494663207440531, -0.017816963906013096, 0.23214086430146877, -0.11441365432198916, 0.16574611313941212, 0.18791116500052674, -0.36598284981922563, -0.33658014116086143, -0.2237178965691679, 0.09607487102130179, 0.021707432798526844, 0.28595484754846384, -0.409566015034441, 0.25791076981481426, -0.3101729457534483, -0.38672313428566973, -0.28366584555796637, 0.18231862791257133, -0.14238747711966834, -0.4418352460212381, -0.24491960735005544, 0.15419915771258744, 0.026512492284036352, 0.48341164319543956, -0.30034853068627193, -0.08228385519227184, -0.15875418608818026, -0.20471166977045346, -0.08476016536457659, 0.2533910630094651},
    {0.2968706149411362, -0.08684831886489339, 0.18346680940363674, -0.26826811325862004, -0.6223511323201786, 0.04363791285891791, -0.39242486381410197, -0.5368631205004895, 0.05092186054027661, 0.1423326160395403, 0.12394356340106694, -0.5090801695608281, -0.011513883863792809, 0.02793456681836102, -0.24145923462854466, -0.26578899474549106, -0.5875687290911503, -0.36193950865601365, -0.3749025517357922, 0.08248207581539557, -0.23397765410775775, 0.05142497592596647, -0.4316986751860992, -0.5436535835991655, 0.4618898948757435, -0.2762662489301047, -0.593759018384285, 0.22580987383580872, 0.37393574424165954, -0.5166746891088041, -0.10642805691203312, 0.44149047488300286, -0.026376565846206058, -0.11218493310735404, 0.2013820757993336, -0.01595038108142509, 0.02130902366396953, -0.2593730949803432, -0.06894134869292155, 0.04747200564778098, -0.3733942153991637, -0.023615126180711543, 0.42179636398991704, 0.4716312082279241, 0.10970478361301735, -0.25743806776779776, -0.27285159331704795, -0.3878633802519962, -0.56729614330038, -0.2489674892165502, -0.25762264648485705, -0.19510798505538743, 0.3650883838305721, -0.4443451193577519, -0.27079648564129505, -0.36115856161815496, 0.39388185968361533, -0.10054576714051876, 0.04381117342601025, 0.08736728273871196, -0.25292295783702057, 0.09181601007079533, -0.2704874822568927, 0.45343379634320446},
    {-0.20846668032676036, -0.5449143251452593, -0.1446877214725778, -0.4765738702898031, -0.10455468361326871, -0.06033563389065339, 0.1643694026099123, 0.6497028236532193, 0.04538431772899737, -0.23324445868573854, -0.16777155286531686, -0.045429547507780485, -0.05612928514777583, 0.30727351607280085, 0.11497878978507092, 0.627376868994922, 0.14435843084873448, 0.05104636148674228, 0.23474653533124848, 0.14985277821176765, 0.1534365224990739, -0.29695391214285505, -0.20555514319056248, -0.032722109731197324, 0.1365167018274231, 0.4992888919019093, -0.21539706892472532, 0.4215943495455114, 0.4910840065807955, 0.26265058167870975, 0.23935075719226967, -0.24986764799124905, -0.32103637163213466, 0.11576113848466976, -0.05177501783447691, 0.28451875317370323, 0.46942757728293677, -0.11691809345844198, 0.20629680366731368, 0.3662821469616436, -0.45689690366873714, -0.2524740827203646, 0.2955357657197746, 0.006656483898043549, -0.25050199364700826, 0.3694610317619547, -0.38776113336491863, 0.19162517137443774, 0.15548849271487042, -0.19785376970769122, 0.21754870885191258, -0.3901001389374016, 0.47664915029502425, 0.14424804423104215, 0.13829216284129855, -0.5951458611496167, 0.06614729456910388, -0.28879968808580964, -0.5110255827152183, 0.11535026186024458, -0.27132749428056097, 0.08350947948856292, -0.07902879675103648, -0.2636038733065855},
    {-0.24423679312754665, -0.31189472551963454, -0.442726774689039, -0.06796723740554737, -0.27735615871750646, 0.5374384133199397, 0.037902466161361156, -0.14269462314906756, 0.019848048461571226, -0.2974017245212593, -0.06891018487951044, -0.13626340198742545, 0.0909596722632863, -0.3183653362575335, 0.008911065819322444, 0.4364647933523949, -0.444551470260466, -0.28666104801903286, 0.12343172149819807, -0.06873268051175188, -0.308142330086033, -0.5290719510631103, -0.03621348801039826, 0.14637806672749684, 0.6813949335677766, -0.374041823525713, -0.2541217598225252, 0.06284774941655137, -0.1129756809980614, 0.4621497986390898, 0.4251221427646251, 0.25097004867331935, -0.0520587571905603, -0.16744514494112867, 0.24264808642945557, -0.05592582051880524, -0.10470262851993908, 0.26294308355740614, 0.14561708229005305, -0.09700886466478512, -0.17951024539114696, -0.5167331765358222, -0.17807394733171303, 0.1329467915880318, 0.4731403378749066, -0.5356867415726461, -0.356533435405212, 0.47146119260435254, -0.13092323214376306, -0.5584094024193911, 0.24158951347992405, -0.24628794983963664, 0.2241505592373531, -0.36952839786672714, -0.0851978205002355, -0.4490061094620033, -0.31295742231347073, -0.0735114718236416, -0.1506221375597424, 0.2933471224862016, 0.02064758320467479, -0.22447916832944564, 0.17819098624206203, -0.05754614066716262},
    {-0.14979050332982866, -0.3206967526032894, 0.3503060279089336, -0.4505093857429755, -0.04953742185889603, -0.30527341122061036, -0.04460545551653559, 0.17109066030106415, -0.29125898302677017, 0.1112052881626097, 0.4307986301002928, -0.6458819436693771, 0.394276964459406, -0.18972854676295714, -0.32221686699643687, -0.25138444761273493, 0.2940459202466028, 0.18890301011245603, -0.366081204422844, 0.24749332304413035, 0.3484791065211394, 0.13980441669037083, -0.23923581419649137, -0.4367028049648303, 0.23041000564487726, -0.4268772040181362, -0.029639344987999708, -0.0811457094512695, 0.399399921151817, 0.19957327417894455, -0.29382249990005094, 0.28187984258873955, 0.11254286546881519, -0.018536309090507665, -0.21734714222400353, 0.2764170259638061, -0.037153381833904854, 0.002852669619664136, 0.2997613157898975, 0.35262756208724266, 0.1959698008611799, 0.21488541930408755, -0.09657980794043133, 0.19651713664956033, 0.5996159632768847, -0.27179795516902777, -0.20524961680440212, -0.5290385451492925, -0.23320820055612748, -0.18738300375505546, 0.15728659949384624, 0.14492680081633325, -0.32776952754338384, 0.22037194872522084, 0.054394565975841386, -0.04119612801632982, 0.38141224997708767, 0.22490080704098436, -0.2814851662402826, 0.4134378249443657, -0.18957926331477024, 0.14721392746731024, -0.10093121819065523, 0.09112770747111942},
    {0.370385274860098, -0.23859381477886968, -0.20806035635622702, -0.10961056405370163, -0.2832871228950332, 0.37352630358991207, 0.4072718723600818, 0.30049119327108464, -0.0012124009889616161, -0.3568435802044024, -0.17633654414236755, 0.2251641335854878, -0.34677454005862685, -0.5130093155556378, 0.06674263356162169, 0.3379787950399031, -0.02490452892688404, 0.24477993752762914, 0.04386669194171607, 0.16821738316252957, 0.3525441072541784, -0.023961377361596498, -0.1475773168078384, -0.18136519663225645, 0.6003436431917066, -0.6295602817574779, 0.05482656298976675, -0.0035958341326918462, 0.43368468936409277, 0.0725680590896631, -0.0812651858584244, 0.609820134637302, -0.2067519348448162, -0.3203123565141832, -0.41747516620730485, 0.37006626382263713, 0.14244955755252398, 0.4520194910464328, -0.057836468679033685, -0.17272338109111218, -0.25788877922057224, -0.5288956752160493, -0.258110861702007, -0.16741466276118208, 0.48085611304111464, -0.23493244141836347, 0.27281241913524235, 0.024048446612668504, 0.16841765727742933, -0.5504752809215877, 0.306357311018076, -0.589578345706646, 0.12371263953690692, -0.1852413529893304, 0.14398010719208476, 0.013946659247091939, -0.19621901088095087, 0.3117279479469032, -0.12869644784655218, -0.0977793329199309, 0.13739814211449242, 0.3559589928060719, -0.26160225375121393, 0.22674522242927778},
    {0.046319166328479836, 0.12787864690714448, -0.6258825357256865, -0.3741062457972684, -0.618662517625311, 0.14251805446343838, 0.21291069377081592, 0.1824848501625107, -0.12459776615596792, -0.2548918121194685, -0.5256412535703907, -0.11320814753512212, 0.1322239012453362, -0.4813713507971861, -0.5605921920265943, -0.04683016744594636, -0.13019765295813937, -0.46127474789597284, -0.39230556915296816, 0.1414122695724808, 0.25078088049945235, -0.36200393800398384, -0.0769897310092979, -0.4511872015125513, 0.40471263454232065, 0.35817313664673683, -0.08503658368984414, -0.19437863527836227, 0.45305148296429065, -0.2936574172373038, 0.4243218146626889, -0.11198600727913947, -0.28269084395629407, 0.0701299834432874, -0.5860525206946658, 0.0067414011721438055, -0.09608165404695057, -0.034326442846730545, 0.013346300243587683, 0.06406275290842836, 0.11188448071107114, -0.6849059272766521, -0.08157537574095304, 0.3997238521156608, 0.566125245800944, -0.07222181784001193, -0.4705353996880022, -0.19459459580275076, -0.0813453054421808, -0.30075085434677157, 0.20008751400893982, -0.10281964649641055, -0.2301861898950912, -0.364146186703065, 0.40993962580387217, 0.21300012378924044, 0.07174584921071209, 0.6254668047685572, -0.23065674854323517, -0.48990372164567414, 0.16039457423759973, 0.19986316916191932, -0.19984415792252408, -0.44836857646204203},
    {0.16508439237174302, -0.2840175036449363, 0.17844841712574128, 0.4473598677507252, -0.34876606796601856, -0.1404622840061424, 0.18776979825560558, 0.003117349267064771, 0.3438218473336696, 0.1211042370393128, -0.10696865985745817, 0.3692684627462794, -0.05056723698664635, -0.16135365088359016, 0.19767847606989397, 0.1570145225985134, -0.0720506644819826, 0.103127642526154, -0.30490298851630254, 0.12231813959871284, 0.24000772557658462, -0.028794645197015845, 0.16608823565472222, -0.15243880417477587, -0.2709050261449805, -0.3186932338337276, -0.27147534828227904, 0.0544838180041007, -0.18477726903238717, -0.04419782171252728, 0.34605848929666255, 0.17998591759741164, -0.1238049771569935, 0.008031942535470678, -0.3060011190318031, 0.2582236299180418, 0.3002970081892982, -0.3999316067662475, -0.25607014326322064, 0.04540985920341575, 0.2780767627843008, 0.0896923795686812, 0.13486330048219156, 0.1716751192810396, -0.11175573918501966, -0.01374052080816531, 0.1718851423170683, 0.12691878030266002, -0.012295436249675423, 0.05127200061582994, 0.27544045460970285, 0.47817640445276527, 0.2504809091841845, 0.43614549472111674, 0.429751910064615, -0.08801896881256242, 0.04796278072384453, -0.3244333527636174, 0.21499491298577908, -0.2672225447016367, 0.05416115247099886, 0.3895150677243638, -0.02906321421105201, -0.13621167647761856},
    {0.1633830081682314, -0.38054532662966445, 0.4181745548757615, -0.28284156389908055, -0.18137948170378687, -0.41717346128342864, -0.4370629640212755, 0.06829144358310635, -0.22948955783713756, 0.19532877133897386, -0.44885210640240697, 0.5435387930266596, 0.09209983896935338, 0.06235898323380856, 0.1771493274363883, -0.1295090662987717, -0.3846226313085429, -0.3815014669107246, -0.3246646513959147, -0.2785176785029428, -0.034457799167502294, -0.06932515579027258, -0.31647925487810696, 0.26500889793134774, 0.16528144113229365, -0.1407449167666475, 0.4159904193343112, -0.30449729498739436, 0.21895466225914065, 0.23872273338707906, -0.3336432827975251, -0.03225084282262657, -0.055627587178480195, 0.1557072646539894, 0.5059375711320016, 0.10718924886673768, 0.30911613711533986, -0.022627059082844306, -0.3704912236845569, -0.1527407038759315, 0.34552636127228037, -0.056475028098955826, 0.4132096122719111, 0.15767781172917894, 0.31558621565193157, 0.39149296919590154, 0.08464865297275179, 0.1465959558663954, 0.16146792138419422, -0.3159722421790019, 0.2175716836698551, 0.17785948042298003, 0.04754413671197509, 0.537758970453169, 0.0026620943780081155, 0.045506456623530485, -0.3183519152564375, 0.33717077437530085, 0.50168687959923, 0.3011226698122482, -0.08713831793601119, -0.23419156147035916, -0.0542362908475428, 0.26372948541366403},
    {-0.21577190550938474, -0.040104635504027576, -0.33231939527282256, 0.13034369350317765, 0.0860210728790086, 0.26259284965210156, 0.4454639515007781, 0.1825430086233489, 0.20316107766742988, 0.13680171333710728, -0.21597845019222528, 0.1785119973275906, -0.025071590710618635, 0.11318589289051025, -0.013962955938087445, 0.29971060128990046, 0.19657597851185848, 0.29452538968112085, 0.007047107752359727, 0.11042587475222665, 0.10649953685922937, -0.22604349959137143, 0.08643112860648626, 0.34973768678733314, -0.18342333310822886, 0.17148196055484255, 0.04336800004044899, -0.0834364199267871, 0.3937309472638192, -0.0628094159483637, -0.23572315525539125, -0.3572595148840267, 0.20684327502111924, -0.1388430684846809, 0.20804760221599194, 0.22878146298943994, 0.4256177014640664, 0.0930015348805534, 0.29129861737865764, -0.35400726422515494, -0.17958479454464915, 0.3990036893741052, 0.2751734925393154, -0.05022781903628973, 0.042897147814240734, 0.10427537201617364, -0.21107093456151177, 0.3503536188703992, -0.14155475523787459, 0.23955962076085016, -0.04726107823129836, -0.1481718739016848, -0.1221275708891431, 0.23352219414952916, -0.15308682503618426, -0.13679469882202908, 0.04799207446019006, 0.04952881788397802, 0.21325965956892096, 0.2080246888699256, 0.03727260107523356, 0.39407101810407424, 0.39854567624672804, 0.07954303670488486},
    {-0.3425515380877194, -0.15320883131958057, 0.012909790283416248, -0.027102054976705068, 0.0029104458755886136, 0.4685925884752066, 0.4742448819988304, 0.010149383916327526, -0.0017882814550065269, -0.11258334079169259, -0.2817276247177551, -0.30010339563911825, -0.24331367326440545, 0.3296491718540241, -0.31326547585163494, -0.029312051280153496, 0.5132534393295402, 0.08913521113647115, 0.2716196973164497, 0.4104901025617114, -0.06551741659734525, -0.08057390054962432, -0.234874704420081, 0.21644919518377925, 0.4478910891380078, 0.38049584850892215, 0.10702402360963918, 0.15448877852623372, 0.19353247379024294, 0.2343831188273523, 0.4089074796765608, 0.00013636117385809761, 0.3538338027216135, 0.02029775091268436, 0.3273894822324091, -0.2022569009308231, 0.2440355943850207, -0.16394704628317108, 0.33794577722266317, -0.005023082521480575, -0.2980373492896095, 0.24079743310464888, -0.17555669652101077, 0.15979474430920554, 0.2838147061963593, 0.04631194157722002, -0.2780070379034907, -0.24506811129449074, 0.23349903765871305, 0.2306508137789291, -0.39642165514177835, 0.09373083915983749, -0.2857473188160344, -0.25802657644911536, -0.10144315950521017, -0.22651715676169545, -0.2844473378879425, -0.043353663316396014, -0.09654289772450245, -0.10879968252322242, 0.10731684896378518, 0.028995172890926013, 0.13914709961410116, -0.19453658318585987},
    {-0.3586067036359347, -0.055257695199145675, -0.05216519415641905, -0.027490622603092502, -0.11913830212561351, -0.04100532714604371, -0.016299105190867552, 0.10388244005875764, -0.24594860713266098, 0.0932570869415388, 0.4055760256810395, 0.1975026674717888, -0.5534799177032806, -0.2894786805381353, -0.2751412568347922, -0.4542199505104165, -0.11351753873423438, -0.12197925139094012, -0.21699156875542244, -0.1833772210938513, -0.04887061790280996, 0.055464546920776805, -0.20932675219749533, 0.28829321473405695, -0.04595343235871759, 0.13868243301932628, -0.01631426489870099, 0.010083335616582421, 0.3564888485438029, -0.42137798520720565, -0.044990233822669076, -0.01083505309793827, -0.13624355804002908, -0.2811572151193188, -0.42088267073499164, -0.4521099318102981, -0.5430094310253138, 0.3089124534125059, 0.22489584689555955, -0.20706819967486687, -0.4590680947419782, -0.2658447680324241, -0.2084494424306543, -0.22250960761652452, 0.10303599203892189, -0.4794156964092648, -0.46894590694840593, -0.3481704495199785, 0.22159159566096845, 0.15038216032992005, -0.19494364233428876, -0.18309548611728793, 0.22859639573867221, -0.3229160590025042, 0.1304281335473336, -0.11081158433519321, 0.3279581995744936, 0.14685448940350038, -0.1262441267150096, -0.3134049684628228, 0.12950559982393337, 0.03896378405629965, -0.4430904275787331, 0.18167170973195107},
    {0.2926693400481692, 0.4680257093735319, -0.24692638005470766, -0.11124516530363206, 0.3759419799591644, -0.02767512855992121, 0.25331559831508477, -0.07655557322685766, -0.3898474270749151, 0.3703049810400034, 0.10835162637657833, -0.11464360463346962, -0.44006078108998403, -0.1434492348998773, -0.0038021940399734517, -0.13612788646469248, 0.3884509273875682, -0.2132961794887238, -0.27682331421730044, 0.18848634839853012, -0.23933875748564662, 0.24450666633367354, -0.22339582022145474, 0.2766783254527962, -0.17671147208699728, 0.14161323441530524, 0.3394428909002084, 0.19534114525575672, -0.12026142721013945, -0.23089983303266454, -0.004351029884728986, 0.19770847352775953, -0.2720438608867942, -0.07203264312170667, -0.3512327650015599, -0.010918015865411426, -0.4946126152945827, 0.12467228880130361, 0.2650384214424621, 0.42229300626425237, -0.34362043771183604, 0.23589565974598853, -0.0873007662484648, -0.4278067201619565, -0.33968796519550365, -0.12356158216207017, 0.0552221700036998, -0.38376815328416924, 0.3599091209203, -0.17646604190353235, 0.36817358453428195, -0.3324645835037988, 0.041585890684636154, -0.39432460000068553, 0.02248322353479832, -0.13664801258470385, 0.41198571917005294, -0.24212725778384164, 0.00855512376707796, -0.0029062787881604427, -0.39633402437522564, -0.1934403917718735, -0.31677360581360264, -0.20259044989407052},
    {0.1555710877652138, 0.5985316477225296, 0.36512344811281766, 0.29101721559404586, 0.17963480841052654, -0.20598449044447326, -0.4062227325040795, -0.3488033839527219, -0.15885670481006314, 0.41946458703137784, -0.008709372109769015, -0.24800966371011524, 0.21260208593413263, -0.02130547886227473, -0.26597872883503915, 0.15288669639996796, 0.44940392433173776, 0.007750059947689762, 0.053223833388830515, -0.08124216594517289, 0.21644743697176214, -0.061913105513232876, 0.16509259871863272, 0.24857959668315016, -0.021058816735921068, 0.1188637442262692, 0.050453942971208275, 0.28843402533629486, -0.3840866803045557, 0.20996383891399917, 0.040264482847806836, -0.09437297762162888, 0.13763674454237237, 0.14593103758959533, 0.0836094248529295, -0.2241402859539536, -0.26866245759183277, -0.019702254077991668, -0.09324872086623091, 0.11830522493681948, 0.25007699108669074, -0.17443083630761702, 0.0004985302848244711, -0.1565493872055409, -0.19617404695301344, 0.12442930742850063, 0.4521133154896538, -0.35205879525339684, -0.19556576114076452, 0.29013096968641455, -0.012912919238258392, -0.18597531354028038, 0.19075960882803683, -0.3383095859994629, 0.10676813944620138, 0.20166433256053276, -0.14815740455605406, -0.5011624249822075, -0.2741926610906138, -0.012701470323880502, -0.327702703765075, 0.20376687962711543, -0.11777140479821437, -0.0321882115454776},
    {-0.3578457690037982, 0.40325519311323416, -0.04244954731476041, 0.46272868160860525, 0.22557815175017787, -0.163996925899912, -0.16018452364801342, -0.20702994573979427, 0.391464599789051, -0.0006053671119955885, 0.01479872749537986, -0.44078554149500143, 0.39555129581870224, -0.06462558745030753, 0.10908577679935287, -0.16955521941065918, -0.04453457214762412, 0.08120807454442673, 0.3193224912793153, 0.2368672998286816, -0.2607947815127224, -0.3345696976169079, 0.25016874748232243, 0.21546112199590187, 0.22989057909654165, 0.014054398728474136, 0.02555138536528453, -0.1475938285745359, -0.3557645222707457, 0.18105984388482707, -0.2237207029221459, 0.08928121682629223, -0.34690109122422536, 0.1599489678166343, 0.1755549501037066, -0.1247799296912887, -0.38526760865540716, 0.09655284686096827, -0.15386274994549443, -0.2884162371828713, 0.037012591286728805, 0.06625124217018143, -0.336884900607658, 0.11500597291739313, -0.5199116750798525, -0.37255930181520297, 0.3451691947248205, -0.30132066636298244, 0.015503433449033214, 0.38674002349053255, -0.06313286311260857, -0.015528887429735875, -0.24791770698322543, -0.3509404406837452, -0.1950762951765441, -0.31433141845214363, -0.11703656977021909, -0.455709905455841, -0.335759244242178, 0.42074464085400987, -0.06685424316520461, -0.30706812978739334, -0.1680443151294184, -0.16697320270759602},
    {0.238051994885485, 0.14162672298628046, -0.05124548099712867, -0.05417186319550279, 0.5903642216121974, -0.018360174249647025, 0.2967137844512484, -0.03817354667808351, 0.5035477147851675, -0.16253573728680995, 0.5376722449206239, -0.21248125486657385, 0.07955295099795948, 0.4452877034602173, -0.15486780162798494, -0.37918898648457167, 0.4248714898135124, 0.2174336569584504, 0.5495305622974813, 0.3175403737724707, 0.2941715928377606, 0.22616819228835813, 0.2603584146074874, 0.10004545568492698, -0.07047589565759176, 0.07094308854395591, -0.20765308084826417, -0.1982605957986328, -0.16382632687588014, -0.04454066165006293, 0.20856422519288312, 0.28974458067799974, 0.03885375045822555, -0.21482391851878088, -0.004821491880758249, 0.27261171899121117, -0.43118901045478225, -0.008957363403198228, 0.20706899311765703, 0.008237660693890496, -0.13156535903704686, 0.5581010659454232, 0.011784359444374322, 0.004366042516872009, -0.11917021507365726, -0.4164234791928935, -0.16545663287138354, 0.05158847661378076, 0.2391619358348937, 0.44890474829341415, -0.3609076050123602, 0.24464967217499997, -0.031167410746243143, -0.3218007450855047, -0.28652263783243265, -0.10334818209890363, 0.08686127252045646, 0.12669395571806574, -0.3348640407658643, -0.0499063953981055, 0.2908762099286715, -0.2877117315964863, -0.11709112733453625, 0.019571511100868067},
    {0.12127475421778189, -0.4002804407043859, -0.18448619409656136, -0.4699541176763723, 0.43366992722982445, 0.4308768150130096, -0.10488171010019028, 0.08762335437060653, 0.3115306679948152, 0.06345578423151688, 0.14720615676775098, -0.16534353103690808, 0.22884909877110965, 0.3981856406288325, 0.2617194375536946, -0.264727893519178, -0.07130076362564387, 0.4863308174313137, 0.1794419393795783, 0.40553164936175484, -0.06550887167329461, -0.1051094584674595, 0.05765268559081235, -0.008365138602347303, -0.5218407836105665, -0.096572952734424, 0.12187677509454099, -0.09223258829935317, 0.23270669554311563, 0.28911286888158766, -0.0729441285509202, 0.33533623913174426, 0.23321975204238596, -0.36714615562619163, 0.07808639900940559, 0.118792580647346, 0.15467510692910924, -0.07489515822694941, -0.06311109989096651, -0.18091249883089644, 0.15980074656131013, 0.17574221428117476, -0.2907897444443498, 0.2018302294235789, 0.2738088552912935, 0.06251192358172074, 0.2458347305829456, -0.05062173736539691, -0.1905094865851912, 0.3554089185299219, -0.07478696746552183, 0.16077437250649448, -0.3686273338949929, -0.19881481552647573, -0.29489081588183463, 0.012063758033089834, 0.09425123867043386, 0.04944652740957929, 0.22769983827303103, -0.3389373897852563, 0.24872077824265468, -0.05719189287478665, -0.029222726226471422, -0.18796862227829025},
    {-0.21759655483238052, -0.30810256339455794, 0.08842351338861301, 0.13651772270748258, 0.27573458514565535, 0.3677804333489373, 0.2781411242979994, -0.2705045673814276, -0.0010515291389671716, 0.07177515324963572, 0.2149683309143328, -0.4243387481334571, 0.1961275143084929, 0.3513947417819333, -0.3760436007668187, -0.2444738509752226, -0.1609579910315607, 0.22279648131405463, -0.43264406429998775, 0.40273792723752794, -0.2640605232450457, 0.262087095739673, 0.20365304014672944, -0.10766893897107553, -0.09498580442625615, -0.372504447113437, -0.0004871878927885413, -0.21545148216532067, 0.056225632486487584, 0.4639955519281955, -0.43442974735047835, 0.008831953447576656, -0.24048517208134085, -0.2830284355097602, -0.2962292515014073, 0.15405858761838256, -0.3748488024031379, 0.17905780056690843, -0.0784877341344397, 0.12829786325242876, -0.23031845442729054, -0.028682513882082355, -0.15073447858652642, -0.38797448628129527, -0.13080573434939322, 0.4055845592974344, -0.14635595211746386, 0.15826600878137043, 0.25153539284060267, 0.1060191249743277, -0.3340603706033697, -0.28687894152624066, -0.23716265796557492, -0.1789503555881173, -0.1249335379160051, -0.10365897961260136, -0.28420574532404125, 0.06853068620438695, 0.3659619875408769, 0.14549893154401128, -0.038888701351829945, -0.1114263283228785, -0.0024790597465733167, -0.3863638516154666},
    {-0.13753021931725418, -0.13209244057367966, -0.09989907548409116, 0.28637188628613813, -0.09987001137742887, -0.289589767550351, -0.08809417168998131, 0.20511474857212136, 0.25360286454289843, 0.030644835148602056, -0.01522517235123739, -0.34838713184350717, -0.34115815469598887, -0.30424928878709423, -0.3972985886217984, -0.006703404144482735, -0.03403492541402157, -0.00548521228960478, 0.33764004820103366, -0.03166908819838674, -0.3720924149993471, 0.132754466289242, -0.12117811883664448, -0.03848639835879443, -0.07093123519414336, 0.42192100279781125, -0.18628515142709595, -0.09527987029480713, -0.32897851551615703, 0.0859420183632754, -0.1254820436693234, -0.12113585377132856, -0.03767421898399306, -0.2088199796771285, -0.2348466427492698, -0.07448595338792097, 0.18212760832085625, -0.09595156413056924, -0.10310223635548739, 0.3016909371220871, -0.169948934295549, -0.18974132472856992, 0.05108010419674446, -0.3225519512046623, 0.21484094243367638, 0.11729321251414211, -0.044965350609976, -0.07938399939776054, -0.15461366894407422, 0.24330350127735792, -0.12752715904771014, 0.18810632506530023, 0.3400033527728997, 0.0713248014905379, 0.1372432566044241, 0.4248852233648115, -0.09214937124807687, 0.12086863002242995, -0.009157437489202617, -0.08072425413132968, 0.09508312730684042, -0.3440383433420482, -0.2821327207249993, 0.07629158596362426},
    {0.41185590592346166, 0.216962483520775, -0.060327763748086315, 0.09048102477692833, -0.40969018905299304, -0.07428585159354928, -0.3856745363104814, 0.02201884064219841, -0.26096233313928546, -0.36736736095338407, 0.2173730216947236, 0.4298223843212213, -0.15533216052936533, -0.18230394748675582, 0.304498285752189, 0.0320622392534714, -0.294813545549595, -0.06540685775390506, 0.4451271529552332, -0.3474411760603826, 0.39193981185506394, -0.04005033626182482, -0.12155125040096894, -0.21055685078840475, -0.04218516047405875, 0.206477528309476, 0.16819961385365934, 0.007960595465480488, 0.3300023138455806, -0.2101098062635273, -0.1809681347094228, 0.22273053668639928, -0.22116775985009848, -0.1628391586411105, 0.22473351022996502, 0.003179531810888646, 0.20258590418626915, 0.09160267439793375, -0.26019997134518047, -0.15907429227658423, 0.06282734876566998, 0.15931552606361285, -0.00021865945029051774, -0.09602545423099697, 0.2183788756385478, -0.11344772573430807, -0.31585617198583105, 0.12648647763351373, -0.3230273800023307, 0.04220358660071807, 0.15765175339696139, 0.002026419640746519, 0.4333710215662787, 0.060524419712282486, 0.13062709209945733, 0.29466270165038316, 0.17589784393872154, 0.08287350686878661, -0.24601612664563444, 0.08166511158930632, 0.007924057412718998, -0.13589478216648088, -0.1949884381966381, 0.11750671899016228},
    {-0.043037967287235676, 0.42781921313520477, 0.16347672428515586, -0.16440747795411484, 0.07506186114917161, -0.1033712680198464, -0.07255158016739988, 0.0536432326846833, -0.3414867167735113, 0.03864783266713335, -0.4003396610134003, -0.2508940018487928, 0.2794524026556178, 0.11355023497357325, 0.21057540196050284, -0.049280149534459014, 0.20952474332729257, 0.3779121148392563, 0.38072552747661065, 0.11582219380230938, 0.18761537718959395, 0.266598569594122, -0.2674913077707825, 0.16484772620061333, 0.4101297158594493, -0.043542146681364434, 0.19423001955007593, -0.12161987729581356, 0.08642471122539831, -0.43557440022597027, -0.3269462514847445, 0.22887010597639296, 0.2910968018410632, 0.3169950144423118, 0.34048521117226466, -0.0827725422208861, 0.19106872595801588, 0.31321590931307663, -0.40839476050408613, -0.42927185488639463, -0.47043171288104063, -0.328222780952826, 0.1349768041226191, -0.23926712090417768, -0.00806147439833774, -0.3702629864199746, 0.17193241212601895, -0.09599662642443015, -0.24565733445450277, 0.0618570167402903, -0.1328704225498958, 0.35062959883728817, 0.3833299792721417, -0.054662500618002194, 0.14967142133181868, 0.2931986555540612, 0.35936240686753823, -0.1343049878180085, -0.12799261506612888, 0.4755389536665159, 0.25441967188160186, 0.3455973186434499, 0.032123470802730536, -0.18754062733622115},
    {-0.2569465727059537, 0.4035296067544326, 0.30892742384383065, 0.2607768819705516, 0.16153134654070195, 0.07992151855756988, 0.32929012059062174, -0.15050437612689488, -0.25607547867525876, 0.30334248842101286, -0.03302016044040362, -0.20858119779760959, 0.3341590255184683, -0.11918814532879596, 0.3827669163463616, -0.3442131852101133, -0.462323225741775, -0.28552130441184076, -0.3178134756301779, -0.445792075713548, 0.30121667082353965, 0.26590388764085005, -0.031227873105470125, -0.3116181558163135, -0.08845135415624948, 0.20447757477277487, 0.2223677402089732, 0.11029500343300533, -0.11980578711926583, -0.5011561893501179, 0.09582661402647033, -0.4151103519624232, -0.05104783852938812, 0.14859062452600275, -0.11934476816685582, -0.11892974809833565, -0.22595156744513387, -0.4312313814322529, -0.13202727842447004, 0.03244193845129002, -0.38708221935313464, -0.017943456724777585, -0.17067567845865725, 0.32791956176337766, -0.41366151566161685, 0.13855500849458163, 0.2568457374858887, -0.3194735980593572, -0.009995809882219982, 0.13348510714370937, 0.39157663922899416, 0.014782479474723685, -0.07289405580882563, 0.1483895866550383, 0.14242189892361992, -0.01056422555340129, 0.027013940570074817, -0.23738190889441083, -0.11430713048408903, 0.4618642151369457, 0.05910508712344212, 0.2692377667904456, -0.37967741490226936, 0.10780237085037848},
    {-0.22485223326088805, 0.24373057063527886, 0.5025500262970507, 0.5015005780489448, 0.22778252050975256, 0.33684783645750926, -0.2964754609509784, 0.26359101865327195, -0.10191894652057612, 0.20166043123963784, 0.2244562463522657, 0.6606644776242576, -0.3248641414253283, 0.24300288319078198, 0.32430864585020136, 0.1381083155172161, -0.487392911193272, -0.14068756259250398, -0.14302975156997874, -0.4095292780577085, 0.10855028497630778, -0.12995018460180638, -0.2789758224853452, 0.17734875307993622, -0.30193572226631665, 0.31884915102380385, 0.36996877883660867, 0.01745621186951628, -0.04631981124331781, -0.19561670715311666, -0.1650614326730492, -0.40876407367830375, 0.09862025548446442, 0.3625815946824725, -0.15148284578371093, -0.21752854278394754, 0.18231141919721938, 0.22785250731145723, -0.21997460471537666, -0.2949906089155743, 0.488449026904677, 0.49350803516788583, 0.33726500797992265, -0.022274571945984357, -0.47395816482477915, 0.37982544426360076, 0.10347680241245534, -0.2226699971913174, 0.4111547355287957, 0.223969950975209, 0.1856522685710628, -0.2869935270715346, 0.05520630741834571, 0.06200282257749344, 0.20163332967803807, 0.0583237015045526, -0.15050083749569462, 0.030993364583774823, 0.2194362462731744, -0.1792437927472941, -0.14831549948113515, -0.23363941439581026, -0.16452484576344448, 0.223741493106718},
    {0.1909517560538729, -0.13206815877764308, -0.24672139131812024, 0.11343300997325365, -0.1869849816551596, -0.1826322679612048, -0.06761398828749975, 0.33368920646437494, 0.29468804170508855, -0.2768226862122641, 0.09424950240564697, -0.14693615964494214, -0.3027107873702126, -0.19376728126973777, -0.06568688605363164, 0.3675687594933369, 0.26192931800290786, -0.10295655260777711, 0.22864406425772907, -0.016793121140206504, 0.46635483105864034, 0.26232094631948816, -0.2843311239675081, -0.12289095270052683, -0.18078684595074296, 0.11936945148420704, -0.28179801320139475, -0.17923955510390965, 0.1547643961417831, -0.23730592070100626, 0.11517204744561962, -0.4359159467235508, 0.24277201132397905, -0.3052218813307642, -0.17444221570180007, -0.22406257984938713, 0.2235846674515077, 0.10776917857651362, -0.16900684126765725, -0.06992226813231069, 0.03289651673488908, 0.12908189471986056, 0.3481874645249071, 0.24324152226205373, 0.12063014936695331, -0.10361800808460596, -0.23256980702777139, 0.20849494523379694, -0.14886644455080947, 0.34794794516612354, -0.1806393333316028, -0.14454233615222511, -0.15818927730700408, 0.05960071400526525, 0.1298204008365849, -0.369898731950288, 0.15520552195876494, 0.025231581117299017, -0.19403511462573192, 0.15528107881282238, 0.07427987469298176, 0.10538492722196892, -0.03066225536873039, -0.16027541846320545},
    {-0.20019466790761356, -0.32804796824935595, -0.039798794776574754, -0.06740366890294702, -0.10328946362854097, 0.21096387959110532, -0.1257673907299093, -0.032367622525233224, -0.16574014026870343, -0.32032178332102684, 0.08190275541291098, 0.09831754297351963, -0.04070497940429038, -0.5205669473844325, 0.2580578699231802, -0.05858208717540375, 0.00019866051292374671, -0.2978198780645536, -0.2963565512917862, -0.1905976696721948, -0.06363199754702636, 0.05039213436692503, -0.08243081520293434, -0.2481482004944803, 0.3285143108529857, 0.14857158829809625, -0.33223706631663036, 0.05688615017529157, -0.06210196133685894, 0.18752061750535332, 0.2664192011062786, -0.10711905907150072, -0.38746106088162674, -0.35212466078116766, -0.28172484619974936, 0.2121371766779536, -0.04299902228527065, 0.07579846734118227, 0.17760939845316745, -0.28917657065578434, -0.09175399517722742, -0.19483544078208329, 0.08938364827299655, -0.006398744933542321, 0.433622683316029, 0.13445780647850325, -0.4393808944947192, 0.4495950697518796, -0.013490040178666547, -0.3660695068527458, -0.03580719227432672, 0.14963840040677348, -0.005776187405427228, -0.22605870389068347, -0.22628881883232432, -0.026626228552562824, -0.07816945950695994, 0.4622744148015967, -0.42999536565346785, -0.266424554274929, 0.08998702459454039, 0.24567855783157191, 0.1893667804526346, -0.24673692151846086},
    {0.24892785971344142, -0.059692996659061, 0.22326407161170564, -0.32957967668050886, -0.012492888076936182, 0.45804533160503386, -0.2281900238394571, -0.24060311625858746, -0.18356265214585285, -0.03755239583420845, 0.3448892647524318, 0.017388819500926692, 0.48275578973900835, -0.21974086030360235, 0.09248142271152537, -0.10760443930879379, -0.4172272268041635, 0.3082206416002958, -0.023436766853843754, 0.12013328345339877, -0.12543498774446094, -0.12184472913308314, -0.24506113424578851, 0.2845688672987306, 0.1267883968601213, 0.24615790494983095, -0.3316425712750808, -0.02946500293437428, -0.4150768779496518, -0.02688688544828397, 0.13115213388300687, 0.4253646835945184, 0.02725720908747039, -0.16254875584702166, 0.4364323584592939, 0.3696529164134045, 0.055567715085217934, 0.2965663226631852, 0.3708474731277191, -0.42410120441682875, 0.20427780043326965, -0.31970478223406557, 0.179001650248112, -0.20278477436491485, -0.24990533638047116, -0.38242408928398935, 0.11306711971845805, 0.1750402904301422, -0.05606721625598885, -0.08738832566622212, -0.2999426883371491, -0.030480676637324764, -0.22571010817533205, -0.21170646239473878, -0.12122013813126295, -0.14681632838668346, 0.12304865029970734, 0.49662302221576093, -0.09099213225312724, -0.04026741176084675, -0.14451390291735977, 0.20429132947357723, -0.0929998928102659, -0.347837775601894},
    {-0.16205743990428959, -0.09070893856934653, 0.3084656851351894, 0.12334520147923612, -0.1474236889469831, 0.4192237884152059, 0.11544312915050954, -0.4803696504016987, -0.17498724300788013, 0.25529454702104076, -0.25339789888666653, -0.4359867488297199, 0.45379026055090166, 0.1764279886423408, -0.19784652360940255, 0.015533393628249152, 0.2229507184045108, -0.20162727893983395, 0.37507786075484423, 0.04993472302627489, -0.28109194670534815, -0.4235378695427986, 0.21136182232237122, -0.044851134063660106, 0.2433571221449719, 0.27222128350033375, -0.1325608873024812, -0.07753106386123983, -0.20584492367882118, -0.35159689533467975, -0.26155323978262035, -0.0166026403440719, 0.2578623434638222, -0.22197436475819707, 0.013830010429324687, 0.14734395071961123, 0.3876720446013101, 0.14886922308356773, -0.3073160360436313, -0.3855613362914378, 0.1267064964096198, 0.38270051502595875, -0.06854575847910127, 0.023726485510796164, -0.21217386890512877, -0.3251587049042089, -0.10651963858023969, 0.22247665025815105, -0.08104170947945634, -0.4267640899507841, 0.008420653914326568, 0.13451393966433986, 0.11036651670978935, -0.15867122000751357, -0.41301405154647003, 0.07690006427987979, 0.08563995563389001, 0.025126852905912732, -0.2218627637394629, 0.0891187304472248, -0.41769986022295064, -0.2368658637364918, -0.054691880866124996, 0.12459900545787754},
    {-0.37024005793942794, -0.14937598854036283, -0.28340588603348654, -0.2963957919143001, 0.03398058949556055, 0.2201843142088926, 0.010451587157483615, -0.4175928176532427, 0.15092278343123922, 0.09419217181214191, -0.3334229489331796, -0.3350176259448479, -0.2446959817271092, 0.11961742583306885, 0.029742091809457426, -0.30444950892755135, 0.2700555520514324, 0.008992208518980367, 0.12166684230612602, -0.15490505747888572, -0.19569319593471385, -0.06983226391311044, 0.02977832430296219, -0.06470340519704668, -0.1579095412029507, 0.09913216128189084, -0.06307453389117201, -0.41001135618955864, 0.28035993713644897, 0.13026071026245714, -0.28606314375381287, -0.4679935892005198, 0.4174219922901692, 0.17542621078251797, 0.2760362016478859, -0.15643637086349632, 0.28524154885927805, -0.019470447887654767, -0.15309741318075965, 0.11901597532244909, 0.1335723640909438, 0.21119627810913583, -0.3421946275432747, -0.17048514349010202, -0.1098283125725701, 0.0446743920707799, 0.02167159019879264, -0.2885727797468382, -0.10938415897028064, -0.14381554146473682, 0.34713115499867875, 0.2917928549001416, -0.2090035085959097, -0.3370840203474967, -0.2683173843837829, -0.03178170744618462, -0.3660485472943866, -0.02440939804077165, 0.11575255352226675, 0.20144001382127666, -0.4507469642185148, -0.17100108346834453, -0.20300212628473213, -0.28098620791655404},
    {-0.3793910922802779, -0.28379535639008946, 0.03758812789230583, -0.2951630103189293, 0.3113988947921637, -0.18476784099534535, 0.2876862825122546, -0.4086631839637216, -0.1924356914453468, 0.1285088089452968, -0.32951385838542285, -0.06788701827127747, -0.587300392381534, 0.08122389611385701, -0.023884035683671312, -0.20967658539900141, 0.5166832551699279, 0.01891071370386066, -0.40680885034322567, -0.0852771010559377, -0.3756040520012163, -0.15007056580120795, -0.06898329760735948, -0.11814450815882908, -0.40901700527849244, 0.0372707862654551, -0.04882647408353188, -0.44936620286016216, -0.26195598299447104, -0.3177014896175196, -0.15938751546514407, 0.38453965708713667, -0.2302618471487542, 0.31029492935674097, -0.10717149916612002, 0.05108473779267519, 0.2805259387139707, 0.04139825057012421, -0.1341859317534221, 0.12170539925774532, -0.05483911494890477, 0.3864014535287713, -0.01020031647700737, 0.20677091751642335, -0.004229199665587852, 0.2970110935892399, 0.43393333879444485, -0.4941457257926562, 0.06623801114470619, 0.3265357952867927, -0.24079730492705811, 0.3223745390617766, 0.14908066152697766, -0.05850771863534619, -0.0018529981042809877, 0.11230291380530887, 0.28941355564289195, -0.48109624161590747, 0.029075398381740017, 0.12863548544116182, -0.005116653365721015, 0.1260723434707179, 0.3638630967654558, 0.0422079250138174},
    {0.2955884313122436, -0.40658810484152974, -0.04602408283855112, 0.2276478301313163, -0.3430727730533902, -0.05367181835609623, 0.14706243375434813, 0.26155096619542606, -0.15988103239199294, 0.366400448976309, 0.37124557308839673, -0.07720541780106545, -0.35748568680019494, 0.04953637923625191, -0.21602205766599486, -0.01740250066079846, 0.3020178308602018, -0.10096309376866497, 0.302150108365069, -0.030808690080738114, -0.22802174946290732, 0.07227903831642929, 0.22395278391892562, 0.1868550715607619, -0.1509271664505859, -0.3964761569550194, -0.0777402008752741, 0.22745100226185672, 0.35279481667891377, -0.34147194268743486, 0.23067605563992438, 0.3713737935636296, -0.20898874675333637, 0.33846224965209976, -0.22314487041938597, 0.14212547305895246, -0.40447198494583336, 0.3273072557675303, -0.27177370702842213, 0.3125399715306677, -0.08763900105402428, -0.42358077896910384, -0.3154226311910516, 0.059818359547774126, -0.38739679532411997, 0.16766038283597964, 0.11076736205349677, 0.060880654013602396, 0.34390919597006364, -0.12572977369477006, 0.15380551672175424, -0.11613918061052732, 0.11471816573916455, -0.3817498615235101, 0.10039155134886574, -0.14786707141882932, -0.0658332185531588, 0.30387091029288593, -0.19942601080019198, -0.3030898735267487, 0.06963778436871969, 0.08264174088383869, 0.28323672057926513, 0.19038896074466188},
    {-0.03318997845023187, -0.23466802534844644, 0.21914150047576145, -0.03668485779515131, -0.22878032232210807, 0.02025563131967481, -0.28824510508403745, 0.10050940768931069, 0.04806970843186353, -0.20605798551113846, -0.29391662725883144, -0.3302715237167008, 0.03705183191726459, -0.11897503378623737, 0.03976929955199151, 0.032614767752654136, 0.09454060583965308, -0.03079782667005055, -0.11898817368316689, -0.07246201032937316, -0.21986460446370432, -0.3280405119823336, 0.20246600980685267, -0.20907062590300104, 0.11634926437928611, -0.14549078952085853, 0.08190578005994092, 0.3466704838635614, 0.2018604735991463, 0.07486192206618357, 0.47981837125787563, -0.05282266423474989, 0.1960120245576134, 0.3326141223913285, -0.09313688548791503, 0.05661114332759115, -0.37805284363601366, -0.22869234383291254, 0.09580583534513466, 0.37152837983545356, -0.16575443036332013, 0.007346553798854869, 0.1414985894404935, -0.21654251281090173, 0.08399064258420727, -0.2611812501569157, -0.1468846690719715, 0.15438866748641375, 0.017358183476353515, -0.43823469459228304, -0.30361467935029224, -0.16961003947201975, 0.09606107377185231, -0.3002863574585699, -0.20980062773790162, 0.2634391694701457, -0.39369827485518666, 0.2000000348897136, -0.3249854021890456, 0.37268062583055395, 0.2907789873508343, 0.08819702349997426, 0.24305826436968997, 0.23525802622591185},
    {0.04563075061430167, -0.5375671572936099, 0.06298123411610476, 0.0650868333968527, -0.31609617651778954, -0.3603010011904673, -0.27959169071468987, -0.08207464622233712, 0.06173412489245578, -0.4000300854220396, -0.223118530052559, -0.0994857358328743, -0.15855521481396187, 0.4157667113872761, -0.432537143774525, 0.34547812700367025, -0.1266795049567192, 0.09250261259717353, -0.4813474056916333, -0.0787844087627896, -0.22411528700797853, 0.2504902994133299, -0.1338982428173733, -0.1770349069091933, 0.10667439163252895, 0.16666941673902252, -0.11521937962796512, -0.05406248864640925, -0.08492268688528222, -0.2982948390074099, -0.21996256941234774, 0.19542103242159692, 0.14846169353555358, 0.23245597421068862, 0.05690396669474798, -0.060282870158549474, -0.08064491721438027, -0.0255930305190828, 0.2910772966593625, 0.14194378411546063, 0.16481586296013065, -0.2264724461271547, 0.2530666020507876, -0.03098752226618357, 0.35799288826864734, -0.057529882586887876, -0.30474942138633454, 0.029030700224971114, -0.4955329871234494, -0.0722313858128093, 0.04306681082373532, -0.048667170803021326, 0.23458580781730676, -0.18472357791588612, 0.07886845274937102, -0.10809947456970904, 0.24181326263996017, -0.23378330401951802, 0.017820619292020175, -0.12692460654077206, -0.2935158511281656, 0.22658832080044514, 0.2786237631630015, -0.06980116834321999},
    {0.11971069643364778, 0.004711360837210484, -0.046268696751107966, 0.14692809962773554, 0.17007625899145093, 0.20065644453851295, -0.11661179849939252, 0.16150215432545206, -0.04463081926425198, 0.46687301476584786, 0.2055418045610773, -0.10914945403148832, 0.30938930011387583, 0.49666553900736776, -0.24333294200064887, -0.18257552446096786, -0.28073594599925317, 0.2963181092287806, -0.17636809215763669, 0.21529093774204128, -0.20009413066806098, 0.3314442670758744, 0.07221793355413844, 0.5228818788990965, -0.23129819882732214, 0.015764684767737278, -0.475796380886027, 0.29175977738562686, 0.2503696657193981, 0.3652661435328016, -0.31040581049024163, -0.1825029616513494, 0.025205963617340798, -0.29637482621996275, -0.0005084032695038624, 0.3758367869009187, -0.39565951308465513, 0.3162202250482656, 0.2913307747032867, -0.026955058739857145, 0.0749655465912921, 0.019848407017076686, -0.2435470890396245, -0.1362317464691397, -0.08942125444336191, -0.2540588896269495, -0.07245858847149465, 0.3166077457255362, -0.1128054618858286, -0.20724034242488593, -0.028749823662788186, 0.34302819228224063, 0.2554214051244968, -0.07457583273160719, 0.12200845367449795, -0.25314351487761416, -0.1523342723173637, -0.3883485301678779, -0.012707202630454047, -0.010563452584024335, 0.34698742267555294, -0.28081960384631144, -0.4192789542326632, 0.21163369822321118},
    {-0.167734843735077, 0.3767471288854668, 0.1583237086160252, -0.47983458053228595, -0.2538601204756391, -0.43150738884626366, -0.24716138435870516, -0.33744769615650333, 0.030843697121444864, 0.3107554810175267, -0.3544012663376339, 0.36158993382173715, -0.25764669888214875, -0.385748815009873, -0.02474605927306845, -0.2452237015245215, -0.020016160654848382, 0.009721238522148184, 0.298078466950586, 0.036084317409284854, -0.36004641936880016, -0.001999065037013911, -0.3461695721449328, 0.07079705420955973, -0.2232053187125834, -0.23358181932493816, 0.1912689893838859, -0.007821137399818167, -0.1919023548454457, 0.2055324925765087, -0.011668708611802305, 0.21574354646545188, 0.35404941639839227, 0.25390702073794474, -0.12026892082834241, -0.1809468194891613, -0.10136867862658507, 0.11385187669832886, 0.2100797883164571, -0.2758079752088747, -0.3527157510399924, -0.07270500737364095, -0.4644773382430075, 0.10258504079003165, -0.25369850569650326, 0.12351838671942421, 0.12701217246614885, -0.29805393951456244, -0.4818592152999176, -0.028002577380830982, 0.08936596228924577, 0.22715467184469337, -0.2665953832864208, -0.2507561715503472, -0.3043469748392655, 0.32490688199954904, -0.035479326047806355, -0.34384440412183465, -0.4070050132194471, -0.33945957959102574, 0.08724173166083259, 0.0191033852327492, -0.4085364877385414, 0.2756587291787145},
    {-0.16947059029626685, -0.2060517364957837, 0.22831900946209369, 0.09386345120909395, -0.1137600571993183, -0.2978123855974466, -0.23269742158386986, 0.1415859542425841, 0.08833768135158815, 0.09840242848394296, 0.4150392346702164, -0.14479010512347829, 0.4071076950085217, 0.36062181940944477, 0.21622574195101418, 0.39723494613845406, -0.26169601097696604, 0.16961859762325013, 0.2027361033087213, -0.09881406558990315, 0.19645006227308914, 0.24611321778515066, 0.2020327254240403, -0.32319375686353363, -0.08375425090613325, 0.24023949395964808, 0.45720812074038286, 0.15200481835874843, 0.29144498755602966, 0.14475984701847247, 0.1875493988955082, -0.2822214662144953, -0.07904556029813911, 0.4414076901422184, 0.3645822320809659, -0.1528069011332468, 0.3893666887907674, 0.2670847386868112, 0.22704711771940725, 0.45722318127762973, 0.00030152485915876725, 0.30326979762068734, -0.219042868237325, 0.159415885074112, 0.4090990216911999, 0.4533121697554538, -0.08420799644548699, 0.048872329081565705, -0.07131853145552004, 0.2081214537156816, -0.19895994804803183, -0.1286015685985323, 0.25220629776809167, -0.25593927418244167, -0.26066115793197975, 0.09016297174974881, 0.11256362591330175, 0.22061497517147205, 0.37013946680936355, 0.13319590955773505, -0.2003637462101476, 0.05516469001109401, 0.45229983673071517, 0.37141238096353885},
    {-0.20335597695122135, -0.12296705753876516, -0.34841602365746915, -0.08003589070647862, -0.2853565578719871, 0.3739867953363439, -0.24447679611294307, 0.11359107496393131, -0.1892354188346238, -0.4107264141251771, 0.14181958560211233, -0.08655781376924507, -0.04975486619569941, 0.44001697816023305, -0.2928497436029802, -0.3893280176689604, 0.0029074306612677727, -0.24139899615772067, -0.13101837543970807, -0.15641523499147797, 0.2749518857733991, 0.1070052187652059, 0.22904163474796466, -0.3642032453620448, 0.20201876219005843, -0.2629842807624056, 0.4409329154528329, -0.06907902346799526, 0.2790182293496889, 0.12736117352411558, 0.16450145016494208, 0.3192860256514353, -0.2638725305484202, -0.2457633448970264, 0.011751522626478935, 0.25915615362984146, 0.17937100434889267, -0.18171320494057502, -0.21622426497517763, -0.23753774827794114, -0.14422420365176203, -0.2015481419239757, -0.2962496257483246, -0.38580407556991747, -0.05830734777306601, 0.3301208211270745, 0.14252809367457675, -0.2695639112382547, 0.2758457770733352, -0.1947740583405597, -0.02093820069786893, -0.17985116025269687, -0.36182232605345555, 0.18175850974483349, -0.3249371078449677, 0.07703830110910312, 0.20915422451682547, -0.04963096845565163, 0.05389013450222859, 0.16490909504355913, -0.014898317689087346, -0.18151876583147278, 0.34310787361157186, 0.24103150872350637},
    {0.10781298783693527, -0.035220290092743724, -0.3751546225055735, -0.14865943762575337, 0.2763482381441505, 0.1925346097721861, -0.06653832289845911, 0.04258190885336513, -0.28270014568167373, -0.39878049045030756, -0.30672685753895573, -0.2715307343627575, 0.48147860588691954, -0.14727978008148193, -0.14350864397979002, -0.44618501638768626, -0.2101718343372284, -0.13650691899757156, -0.2123910293083805, 0.0711404542212087, -0.34856094014336564, -0.05512281805726937, -0.24224236178953107, 0.009619557797027929, -0.21475575746339126, 0.292311385183661, -0.305437302088422, 0.30918013561887003, -0.43360279616350866, -0.38904383378420143, 0.15755183524741684, 0.3359206814935362, 0.2420910941387549, -0.10431570208928151, 0.22293099424154433, -0.23904824364423397, -0.13744092596970844, 0.1402128604833936, -0.24034699003909013, -0.1583004499154679, 0.015229749345292304, 0.034165313814714396, 0.2646625790141067, 0.05535641519074089, 0.30255969737086547, -0.14510191612682857, 0.11922784024907904, 0.3895353305809769, -0.06004734153333008, 0.2825571129684206, -0.37428724542050806, 0.35485764809157666, -0.10047303370096725, -0.06949619394142201, -0.17472673378308964, -0.2943322815025309, 0.004862683419715012, 0.32159613731289255, 0.01132119947438333, 0.07932793395809473, -0.10354588237829887, -0.276011037530758, -0.1156851570241869, 0.28660886398650226},
    {-0.5947698244124959, -0.35918903490758664, 0.22732082955695798, -0.6789460146434365, -0.17702815939134423, 0.059827911028337906, -0.3639577761001815, -0.1228461347716675, -0.8187489897514348, 0.2790903676765316, -0.44692524832721603, -0.3549326380693489, -0.7129792822266819, -0.005620585915546097, -0.17806473658865482, 0.010533124421488663, 0.24104120829472298, -0.5482829556832725, -0.3981828716701487, 0.135430192503336, -0.4664698843686184, 0.19346573168891237, -0.6327946465729388, -0.27851489290438436, 0.60286546445752, -0.5702629398473925, -0.23856658821224258, -0.8037931427361098, 0.40352176410501556, 0.33321863840422344, -0.8427222873122642, 0.11762360005928238, 0.1446456338476049, -0.5188532300756544, 0.22718216306732827, 0.18962411118640826, -0.6908603837791701, 0.28731725582497786, 0.3674499882878087, -0.2679731396175588, -0.8018346335707126, -0.3553676982414382, 0.011236891372356386, -0.3660907190653046, 0.48562159095650487, -0.7211927660701332, -0.38632004189749714, 0.19632826334332631, -0.05983095714986463, -0.5637140855236052, 0.28339621314901425, -0.5266809955880861, -0.5396867931379802, -0.5451323239780262, -0.550095024051938, 0.04692568388224733, -0.2528987721464546, -0.3886929734154232, -0.8566236612117514, 0.057919187126875306, -0.5735520131025135, -0.5335438695625003, 0.1585000988916027, -0.8483876746059139},
    {-0.5436199572346463, -0.17082285482136073, 0.08357617230673403, -0.6672651357118384, -0.4053505748135303, 0.17066302285199822, -0.3700936449858811, -0.36046077857174025, -0.7547401396479135, 0.2982948011737638, -0.7754298935159794, -0.5956567288714295, -0.22588523248540932, -0.06137431489401584, -0.3051112329240946, -0.3899378641096463, 0.17227269956701283, -0.3172618096286593, -0.4614124695353244, 0.31443911755247234, -0.5441086220049289, -0.05037522887887811, -0.6751087981046826, -0.4304601141052738, 0.776185182829081, -0.5786804754110674, -0.6559861945873832, -0.7921011860492605, 0.03172614563528165, -0.09820942062229326, -0.5818680404763729, -0.07328870262876439, 0.36350199142050915, -0.6228978522756634, -0.1421130712078493, 0.6141416681689286, -0.618889833225712, 0.28597598086558756, -0.005166617728719765, -0.2641520292330257, -0.8460479209494427, -0.47474456664095205, -0.2431265656254448, -0.6336684468300934, 0.6101822619546086, -0.5404130392832366, -0.6216684493215134, 0.35861945881056273, -0.31037502494480257, -0.48416769649863656, 0.38840312664434357, -0.39148498645751373, -0.7247867985050493, -0.5801152166248118, -0.6695224095570577, -0.10491877635420035, -0.6028594361075874, -0.4033834506517518, -0.5625131129315587, -0.12715382635149053, -0.6340590972823928, -0.596813238482373, 0.08476654301245522, -0.6624389104383226},
    {-0.3692664368055889, 0.3362813766876382, 0.33053923762028864, -0.16946961743200886, 0.05023087572908168, -0.168109280960242, -0.48930406156217554, -0.4866936127708783, -0.6184592647522692, 0.14046682228355023, -0.13510173911019968, 0.1899182988121397, -0.2934757487564189, 0.32682794518428837, -0.10744138922822281, -0.3584957214344651, 0.4058911658406063, -0.5737461889843857, 0.058057269964359066, 0.25597223645171535, -0.6963808646750296, -0.24997732253522412, -0.5942931614229999, -0.0034365162848183717, 0.4301904573278487, 0.06356645188643945, 0.0060446513738544585, -0.41255440649037217, 0.26509977783858424, 0.5182070983215878, -0.4009598368543841, 0.44076580856410713, 0.12111463854224389, -0.6222812615552443, 0.4284527464786912, 0.35442211016004666, -0.0630388229742926, 0.14784164278623807, -0.36524602123626854, -0.07594570789484953, 0.025061412127751717, -0.30523875848580034, -0.37776646943199044, -0.35072971451075863, -0.057320799788368355, -0.36861760301539515, -0.09121744808957578, 0.11137339861356915, 0.4237386287222478, -0.2675204282138729, 0.44646185701036945, -0.1582723100487929, -0.6611117144754382, -0.3830592233592041, -0.6045719039060439, 0.3509960321116046, -0.5705543699575666, -0.4177779720791319, -0.3164635465772485, -0.0647655460940948, -0.42419651487516896, -0.561234989045807, 0.1694088597626124, -0.6575064314158595},
    {-0.051035249530639586, -0.05294400777370756, 0.5687805374393698, -0.1560127496547639, 0.2474950512718366, 0.031073982875290264, -0.45849960671188345, -0.46549584396355953, -0.10590247843433184, 0.016986818135853073, -0.4863350841628167, 0.49929416613329625, -0.48697004654085707, 0.041505451569907315, 0.0514871840203009, -0.1769038907004718, 0.0314737003733067, -0.18638917985405543, 0.29166618269377276, 0.026357909384859435, -0.1534671577437847, 0.190363894627107, -0.6633104976326056, 0.5565611529796052, 0.07795999827077543, 0.37833394331568826, 0.19438398605982354, -0.660900965716949, -0.45337263135212247, 0.29725502020931077, -0.6011083541189428, 0.34832177899176797, 0.3095092075158364, -0.4817256204216387, 0.1891990139508144, 0.5245115211467292, 0.19517357459386192, 0.12641975413728526, 0.15092178987608393, 0.3057656876595181, -0.462396368237469, -0.3711895768715834, -0.355654532991416, -0.16399938830351388, 0.5812058436864066, -0.514459407955089, -0.4317716405190677, 0.12120809009640934, 0.16792999524127186, -0.006651460799632975, 0.33551847452118627, -0.2162868269288376, -0.4789929914330026, -0.03386749129277781, -0.2686921288333363, 0.36387460892159634, -0.6693072392409664, 0.0005350013210283998, 0.19412054491858816, 0.2294415392031378, -0.25770040075753375, -0.6573127016274699, 0.22668224199416495, -0.448666909878454},
    {-0.4746413291348396, -0.25390104964463306, 0.35763077382702957, -0.63955324805962, 0.2972855760669121, -0.6363185679503561, -0.09100490748856004, -0.2046178383827986, -0.25696150301974047, 0.2857247691662154, -0.5045392024290337, 0.2524802446077645, 0.2164336556144189, -0.19470035744559022, -0.25824462632817125, 0.2721139817547627, -0.2823815491842463, -0.03158756418265816, 0.052463340850351946, 0.12435414351251085, -0.02187024741983237, -0.15344891507108024, -0.5114082133270192, 0.19692731088844656, 0.2260995243194756, 0.12368896850410332, -0.07106625075165214, -0.6442719263656397, 0.20698601985141266, 0.40825286663167276, -0.6952288096781762, -0.14595926113284075, 0.36984717761365304, -0.47064062067585116, 0.31974448156998214, 0.4414481410509978, -0.10404483560621311, -0.1080982669987124, 0.016761513550459354, -0.03149324799736487, -0.0666344213281015, -0.3308416087647204, 0.1701211616727822, -0.04090569686923197, 0.4894431897381723, -0.6100219692209825, 0.058049260103315195, 0.055752349814759676, 0.3104141815846522, -0.5570106064330315, 0.6566246429907541, -0.49941117574207483, 0.027151522735252308, 0.13602882714614595, -0.42659035037853793, 0.19913699928415718, 0.12229857794725556, -0.23646763448965555, -0.5899962536485314, -0.38958146502346985, -0.12064343995921445, -0.6028591873083673, -0.06634130824732432, -0.4458847780292529},
    {0.014831367300462785, -0.44860957456118256, 0.5162633942937739, -0.7214177525552924, 0.49056599914491256, -0.09713967115331225, -0.06675868133775133, 0.01795893655885068, -0.611398825634983, 0.32178097177989834, -0.5417724453639018, 0.3555224062614325, -0.47202121702019517, 0.37308439682094924, -0.3921847643807983, 0.3948855082875796, 0.36661252374202924, -0.010021658433022286, 0.12547639366299132, 0.495245553914207, -0.022019431657583327, -0.07576497019776074, -0.40574365816812474, -0.1793395657911998, 0.613688247267535, -0.4207231450122955, 0.22229060484277374, -0.38126762031379025, -0.10500700384847751, 0.4143857614791699, -0.3807919590588995, 0.3905497292092918, 0.29619458245152047, 0.017668956791689557, 0.3172295909679908, 0.12707681395334985, 0.115486230826134, 0.04707168401574112, 0.1650947619111999, 0.3175215856462328, -0.0055775893359691535, -0.27483677705780546, 0.11769876206558555, -0.07376468973598553, 0.3985111299560397, -0.5791132813066797, 0.3160869898269309, 0.39630469851011135, -0.09833134431243978, -0.3264090893307187, 0.3811247919818537, -0.35321652602687204, -0.3101643353851868, 0.10797420016541696, -0.07598219801034521, 0.3442712717760119, -0.3869019970072179, -0.44303431529866905, 0.06960185465117114, -0.5578795800413727, -0.5695966075579013, -0.6200317689007244, -0.3227129209486354, -0.37214840073882444},
    {0.013020658655821485, -0.15041568314271708, 0.13295835444547321, -0.034332658117938356, 0.14977230977024947, -0.42297728959267045, 0.037613143617477265, 0.2458201292847378, -0.3822872252101171, 0.212146073030972, -0.008321024658015694, -0.09804545286283366, 0.35213081666454477, 0.008363153105431684, -0.30421857145759573, 0.2115123863619322, 0.21638347959118243, -0.49431892896034135, -0.13737672679238627, 0.12486839834428701, -0.30142465507173066, 0.2504416723516919, -0.10696493563658847, 0.19510485884901418, 0.18355688192676684, -0.2156494667263077, -0.27682676983875726, 0.0370720053204506, -0.5541798505053261, 0.41356465827082933, 0.32744591332701684, 0.23438860764940175, 0.5492539858691825, -0.11926211184610595, 0.3313012699805637, -0.06617186431703116, 0.2885813783963981, -0.06989707224030889, 0.3347662271142699, -0.3053084537700302, -0.20671486749361295, -0.5767460466788181, 0.3452929030194059, 0.353083132578586, 0.609174625443827, -0.10421094939627895, -0.17003872097865586, 0.5266302112387449, 0.011283015554827473, -0.26278899881632095, -0.038939739599670044, 0.10405487342093506, -0.5231996801569031, -0.07793831649290912, -0.13413698989933592, 0.4424730573107548, -0.3248940301344815, 0.1699193572310924, -0.4201607143765806, 0.38902405905243786, 0.3158009525145292, -0.3637129378377291, 0.02399403847265474, -0.1727779238994253},
    {0.16374798555824396, 0.021020838857147194, 0.032623643478808514, -0.013032426489907814, -0.5340824345901466, -0.448612332996212, -0.5257402734600817, 0.2263056649557224, 0.1648042880964236, -0.11079877207412936, -0.12787738512982988, -0.4014334047202661, -0.09085942629650966, 0.3303879421074359, -0.6013698497625494, 0.5373322839913225, 0.14987942721114936, -0.48379986420146376, -0.31721128682588096, -0.17664937886009696, 0.017845990243736565, 0.11681648279629334, -0.22729212924950876, -0.242874556280414, 0.1319463284599625, -0.05094383231914586, -0.48667954931963103, 0.033147875653424655, -0.43085501146082367, 0.3160287267015968, -0.007277948179493927, -0.3322334544689574, 0.40833372500160436, -0.45426305122798016, 0.3600034339910992, 0.2128922966487086, 0.08312975317807461, 0.04023824861161059, 0.5432489656063947, 0.24188035266791896, -0.4347517172780198, -0.2558271658016844, -0.2046056764096281, -0.020551941372187375, 0.11816890971722242, 0.16497295877889792, -0.12484870788502272, 0.48815165989607406, 0.15680848577179002, -0.26756479060043664, 0.5128654464790106, 0.12803871757284652, 0.25488488153195676, -0.016533927866434775, -0.16300476598281824, -0.03052977484511678, 0.09328467740295726, 0.5222337972383658, -0.5092771502758753, -0.32119836831597354, 0.10200612611383886, 0.01736773735595688, 0.4638580542371412, -0.5504827659173892},
    {0.13830658398604836, -0.5179752281487938, -0.3592592024568758, -0.6863263919032352, -0.5701304747533924, -0.2039305361845021, -0.23959462094463352, 0.08768870525495764, -0.4652742371484515, 0.033407846387954764, -0.00037025763117226525, -0.2197404920493385, 0.3432299495071311, 0.18656363646395593, -0.7070224479856446, -0.43164501238043557, -0.27171277441047004, -0.3750078735492256, -0.19191881130874267, -0.11194946930810198, -0.30299224775244454, -0.24866199210566475, -0.5342449724812881, -0.4763752318647824, 0.42771172131566454, -0.46622910236595333, -0.47102955681710756, -0.2437787371698159, -0.29174341213326976, 0.2923055609422616, -0.22280060545340735, 0.35113232029063546, -0.24714142245097762, -0.34896590506332076, 0.15952885032050534, 0.5295969088868654, -0.3919172236179593, 0.24798426120329684, 0.4003782668576609, 0.2775837086102919, -0.42801837576124663, -0.056583150123865, 0.25883563435361856, -0.1246238820276611, 0.16050723338948866, -0.04433822345759937, -0.5792662804046746, -0.20695547224659663, -0.3017973533980125, -0.4802869735050581, -0.5029399568577047, -0.5596750846303425, 0.18408324061504694, -0.061052983252377846, -0.10218517574991356, 0.20582661140883352, -0.015374639624467917, -0.17821485522536648, -0.4224715580918437, -0.1380618231701596, -0.3891792089279368, -0.22174124868327327, 0.4097478955329439, -0.17453524325946998},
    {-0.5141642783888543, -0.07441667009211995, -0.0675637924759154, 0.09898567776423797, -0.5031577662017696, 0.3674651846619275, 0.4427830255145976, 0.3116906866179019, -0.23471960377965578, -0.1442140300294286, -0.04509112286349647, 0.16491875500396522, 0.3303797694598696, 0.20348004440624484, -0.2606678044178156, -0.37139004410570925, 0.37312486401516515, -0.2523699524719132, -0.4237094752343081, 0.36361597872466445, 0.1159421982136848, 0.18598615084741615, 0.240780745214574, -0.3034424303291216, -0.03927666307378012, 0.004813317344739361, -0.579286052522889, 0.4533215073883212, -0.48080637505224605, 0.13987952927590822, -0.016353376061418182, 0.5725297755758851, 0.20423513698110374, -0.4391590017558594, -0.2703374014658191, 0.4459933617797112, 0.41292139546592754, 0.22029380226523274, -0.3424533532853057, -0.12023689883791708, -0.5143590477296752, -0.487345127654465, -0.039831996739615565, 0.10761227409173889, 0.36656967737365853, 0.2650380539363928, -0.1358472988117182, 0.4925450062121553, 0.06502337323272465, 0.3099127164832295, -0.05332287533295923, -0.10868137600395289, -0.20031358123552637, -0.43667518712367775, -0.06817489414585594, -0.2997623395056052, -0.11538946981335498, -0.3226946666871766, -0.6272713939399003, 0.15082881208657212, 0.06392963294630694, -0.3266619051062942, -0.1216207661538976, -0.27069689492967686},
    {-0.4916781477867829, -0.32347220641848246, 0.5240172052952125, -0.3894768315027412, -0.2451844453144797, -0.17479178197418685, -0.2821921184375028, -0.07243004239607971, -0.34613094535328154, -0.2692979627755324, 0.08629125953729212, -0.05605244554831378, 0.08360323293361818, -0.06310235966056688, 0.2899065045282946, -0.28711725438604085, 0.1567439568133498, -0.4145691920015218, -0.17347018608351136, 0.039266074396507276, 0.14218443552475182, 0.391943954888115, -0.5497064050880108, 0.12414553816145892, 0.45847145703827846, 0.2562960140733599, 0.03755823738259638, -0.6298545359759017, -0.0961582940710328, 0.4727679648308081, -0.2944052055590141, 0.4558932925813934, 0.19085668168368441, -0.42149805749178726, 0.40533075581253947, 0.45059898354001743, -0.29362832485430074, 0.5474114650726747, 0.016479452982583926, 0.023961356669310232, 0.2583828650937602, -0.1551669617686187, 0.12826388182429233, -0.31603373701057536, 0.2735512916557752, -0.5019147088150923, -0.2376619668428329, 0.37232155166241676, 0.5512334322161538, -0.025375308448557104, 0.49094444115361535, -0.03990219150385935, -0.22025440855423636, 0.37488811673706357, -0.349300724932141, 0.514060401355183, 0.19396605296418723, -0.15345576068536404, -0.06293432266225166, 0.40785507097199825, 0.013452636639314789, -0.4354513869663637, -0.35000620499296164, 0.0925086632138111},
    {0.1712535634033086, 0.37150051910495496, 0.4081061380400888, -0.39412677608260976, 0.5041660465980764, -0.09301594775272887, 0.2513348404525689, 0.23382838656317706, -0.4352044421895496, 0.19962089046545065, -0.561678341373232, -0.05616772691801745, -0.16624810766666678, 0.13717133642484594, 0.026420328748262865, 0.15739469262251427, -0.07912779299775109, 0.23866999223415053, 0.12729151833678767, 0.5528397032227714, 0.20234401751885164, 0.3598485684542366, -0.3521041001525471, 0.4986830427539951, 0.2480953021387186, 0.29742498191344796, 0.09724405628340704, -0.1619840163658654, -0.0010370692576623394, 0.0354302071014582, -0.5085073805071474, 0.1791040859287555, 0.5775962765138575, -0.3529099669026639, 0.28215646496417507, -0.37599034066358117, 0.3975706233500474, 0.17721658694817857, 0.24550434650860906, 0.10620219146077392, -0.3317909137090549, 0.43363965123250675, 0.03482823490437907, -0.2348875050537055, 0.19501012555435393, -0.17626177533509169, 0.47523430294835156, 0.24649840152615804, 0.3392880008159917, -0.23539502023623235, -0.005940700137248074, 0.09734188295134213, 0.0009190037543732109, 0.05470942629851824, -0.26620201587204834, 0.3052706559370626, -0.13406535285200483, -0.14105737394610413, -0.28745229472247924, -0.3489034402956653, -0.014970992899077258, 0.16058089466784523, 0.1367418765631729, 0.031812959489320246},
    {0.44445214629686924, -0.023747221954077146, -0.18645623891821003, -0.24496989726570534, 0.19823183886168982, -0.015807298819030077, 0.2924965204376997, -0.23359438927388218, 0.07325423533864238, -0.4582250105751552, -0.43334235567000623, -0.15948503144131135, 0.1571529209587978, -0.17775180235591068, -0.07111368118713633, 0.5020984304965593, -0.17492491466724444, -0.2726602181126313, -0.12916532808934456, 0.10941656733312893, 0.05196613733511138, 0.3362428853179978, -0.3558096085056065, 0.12324054616223966, 0.3838901332029035, -0.12964102808844938, 0.0748181534459234, 0.17223142613104686, -0.39772687353921515, 0.11622964547817184, 0.2301025313853072, 0.09349534845061852, 0.17116151097562488, -0.29418316247862514, 0.4088288747980298, 0.34697894338837565, -0.1693274455604056, 0.23186201127513828, -0.004272060014738764, -0.12043206152612333, -0.0675145587407876, -0.5212406221768483, 0.00038250238898404805, -0.3617884259281839, 0.20922141881371414, 0.18861456655465342, -0.37981007154861096, 0.3407263726559972, -0.10318549770779527, -0.18006097388944786, 0.5087742823564991, 0.05104979934136352, 0.30185192582620957, -0.34381627202158016, 0.24306512093939694, 0.046199954712552, 0.18142389962913383, -0.012484434275353144, -0.5237793176027036, -0.4727393946367686, -0.27884119272852625, -0.3933689964769112, 0.08339365987721122, 0.12563659701641267},
    {-0.1721329787240015, -0.09759891143998489, -0.41026996833617607, 0.04794988938948028, -0.1021575000546563, 0.2751495772669355, 0.15765414905287303, 0.35060925776605634, -0.18509352824575723, -0.29115920227318737, -0.03278308118744483, 0.011413017151769567, 0.3805952469946604, -0.20779233704563974, -0.249495616089552, -0.35918642745373386, 0.05247609986569434, 0.1617363296399411, 0.06122481467652335, -0.4791913415024517, -0.42313273887241093, -0.45211700616279193, -0.460594546898762, 0.4444398239404876, -0.3616322267858957, 0.24841985877773468, 0.04938281244621761, -0.389138019680079, -0.3298088633748695, -0.21542941428279141, 0.021772452236953427, 0.510253948516218, -0.35588456572593563, -0.21284532449248017, -0.12340843666619937, -0.14329099683293, 0.2730903919575942, 0.11476695234988359, -0.2873535157624751, -0.5158240035428194, -0.38808139554368093, -0.36810387719715165, -0.114235702091118, -0.2674711117917667, -0.15649989518898358, 0.28067019591464093, -0.6097007008854842, 0.40318562772759486, 0.5655727735991121, -0.01810296351987265, 0.20640937882524663, -0.23244996826456732, -0.18815258934614362, -0.31465278933057006, 0.1346272853720289, -0.07355450611702459, -0.3291212239905364, -0.24927537697618946, 0.14743026228415787, -0.08856334378288995, -0.31035485050321343, -0.4225078713426449, 0.32337848978892736, 0.4771009742847211},
    {-0.09438612928189667, -0.5772977123303432, -0.22673434981779733, 0.1978997533787924, 0.005999189091044875, -0.4061565386004083, -0.47739546863181853, 0.24774495028491358, 0.046535669732766655, 0.3267072369168756, -0.1686547811752577, 0.5078714392145018, 0.17483827791920248, 0.09671815889590273, -0.22306922016190645, 0.4354477512194231, -0.6122261806413052, -0.4622550418573212, -0.1457240779400311, -0.2422130800817172, -0.16993963942422655, -0.538098793923566, -0.23681267479420057, -0.03182258853570775, -0.4285839484243572, -0.06508182986848775, -0.2999011091233023, -0.33593930544541584, 0.12639067212630595, 0.3583653594988244, 0.16667825964429533, -0.1488892343998028, -0.28048553260441694, -0.029373713569228074, -0.5717806601138862, -0.44346781805999896, -0.11552519321351697, -0.31776287669276604, -0.2160609536916391, 0.2296585053542219, -0.4549780838256424, -0.2560406280761321, -0.11901350205327396, -0.2677008479328242, 0.14309684583836582, -0.5295475324729929, -0.15106596059056684, -0.023835111963092584, 0.1268980516964075, 0.4575641653739084, -0.0021935215002284046, -0.4461259294565744, 0.29924076410508654, 0.0360975600802748, -0.018005799853234118, 0.46372753708625264, -0.18591409599472397, 0.17278658923292237, 0.10596304864465053, 0.24269233720941932, -0.07120742171333724, -0.28573501366079584, -0.17042269920186823, 0.011052059500851103},
    {0.3352590972688837, -0.2243735948964268, 0.05043525729960095, -0.25956461584999174, -0.23508516730393433, -0.3331942085797964, 0.18068387334270283, 0.009768968241485263, -0.605659490131431, -0.27302719356229715, -0.17561007644917223, -0.40274537998456716, -0.5003166538012049, -0.2029907548994758, -0.318491127086905, 0.005344778780456066, 0.26408030020787604, -0.5476111867783295, -0.4888829906073676, -0.13722656006169026, 0.21543289715639657, 0.2414417635058348, 0.3722312163638527, -0.12055987404858712, 0.30802750943059864, -0.6513073892337665, -0.10725510604820944, 0.2880318730182379, 0.3975042660112938, 0.19705305396041603, 0.1460641530912979, 0.24667350147568934, -0.49034907781438686, 0.015500037732817192, -0.251209604687306, -0.09461647839592127, 0.09184291277564789, 0.5918275024932584, -0.2535932454285134, 0.1849946863802253, -0.4901545567038371, -0.6042567694712986, 0.034158571613549175, -0.20070103040664183, 0.33369615406641534, 0.26936561171467954, -0.27181517966154944, 0.2943566843542304, 0.14540379966196257, 0.009611872677947922, 0.369983788346356, -0.5073711325524818, 0.22364719205648906, -0.6574824657561144, -0.22662434925036815, 0.2850273807123222, 0.05509106508532604, -0.28688407616427264, -0.32276893487736524, 0.10747361838132252, -0.00152097755955523, -0.40071672707774086, -0.19019146228892136, 0.19403754450551522},
    {0.00017978889250454527, -0.48842835221187847, 0.3231268814031998, -0.6914073178446724, -0.5847868689241209, -0.23031792508148438, -0.06393026395418501, 0.3335576309788212, -0.35365517738986874, 0.37487060446131815, -0.004626683627437974, 0.22970592608144857, 0.03814594337313057, 0.2506795082647672, -0.5504063993360941, 0.05234294941255376, -0.06827279496466403, 0.20131587905355397, -0.14548286836432678, 0.023289031155326788, -0.2774450604108374, -0.10710020896183639, 0.2764414263918917, -0.37174830626330796, -0.1993233135906443, -0.29877314916832726, -0.686767770026845, 0.18387921546003905, 0.5154169612529459, -0.21043075626898647, 0.018022338010166575, -0.2911501558386094, -0.146684629660653, -0.12946786058849014, -0.41818302092542414, -0.44194920252646847, -0.41833415422383385, 0.05498047262554361, 0.09904385106638704, 0.0964766831501415, 0.08883222678747968, -0.4267497691420114, -0.32077247631770317, -0.16503381481115417, -0.012387408224024381, 0.008370239730814763, -0.2518644125454082, -0.517144202155359, 0.03775167853949508, -0.3996664534681379, 0.23560111862494568, -0.6433322850672774, -0.5601969634988184, 0.015270246574511905, -0.1478950771903589, -0.05470422269586373, -0.37353200080104465, -0.517320076728574, -0.4814868936710034, 0.41851901984250206, 0.00029766962837123663, -0.41297388029297727, -0.17196389704757498, -0.01793006678642983},
    {-0.5592540380998711, 0.40677755462105564, 0.20185199517335342, -0.3911135863544431, -0.04079667515804587, -0.09834371256125422, 0.3934086087638856, 0.26663179478441523, 0.1838780175559505, -0.29525816363409596, -0.0030313446825702846, 0.17330814407186718, -0.1085134951480375, -0.3625790906927525, -0.05161302581731854, 0.0947308418366869, -0.216369363683616, -0.23239861002689502, -0.058608972126220876, -0.20042199736254923, 0.03893262515402723, -0.49365924505652137, -0.06279396788565221, -0.20730704187723673, 0.23685222872045208, -0.0029052308728291466, -0.1122391959239973, 0.27314623440741226, -0.25547902130642913, 0.28092513531978525, -0.3732668354450446, 0.10276508120565818, -0.22772039224572646, -0.0718047426073508, 0.47814779713727784, 0.12198612918939816, -0.1251258720038151, -0.2565168503217849, -0.1122803565642548, -0.35088114292570166, 0.13285034808854077, -0.14425032814358535, 0.4430833731016274, -0.3706124308322957, 0.05993677283111392, -0.4805851288700218, 0.11548866649333332, 0.1787730840837612, 0.3932020956303392, -0.23644180625384129, -0.28283003564091275, -0.26500551004762596, -0.06359024855472538, -0.194107807472291, -0.25125836672041485, 0.2430989264512463, -0.5422045847615369, 0.23410243385674503, -0.12135619854515503, -0.2682848395673491, -0.18765580620413516, -0.4037696369237377, 0.1686175290119456, -0.29910214672350066},
    {-0.22508550105293304, 0.21529844911937995, -0.3571253021447424, -0.33945267017521435, -0.4390160630963198, -0.3699548513490369, 0.3406526491518978, 0.1289269791100076, -0.5626341867254944, -0.02215606237307535, -0.4489062279967148, 0.11632401717720606, 0.17192488805183648, 0.01939682427066752, -0.3680732210880421, -0.17996307552892146, 0.22937121376735373, -0.04270423338927383, -0.3074871082597456, 0.2634776827848709, -0.4067431714852304, -0.24000017610863758, -0.15445986606715725, 0.07808735509798485, -0.0497425734114635, 0.336553753837701, -0.5447017245947773, -0.3145560522005598, -0.14583040610373832, 0.15073461235690538, 0.12738167263681552, -0.5368729572354305, -0.22752100169349687, 0.16738418628520513, -0.16317283036006874, -0.46244303111507407, 0.11060717864062772, 0.11261506749424156, -0.2128602907123961, 0.1364466961517336, -0.15803116728086733, -0.6795994136727822, -0.1635208872768385, -0.4178263609833591, -0.2775757606496386, 0.019890837056977466, -0.5254314791145388, -0.020440126110485523, -0.09031548218926785, -0.2841854561852708, 0.35759376229247847, 0.17170224828320044, 0.10971640864334128, -0.05093862466986421, -0.5105606203559444, 0.14311951350993282, -0.020923215522933237, 0.25774730980182936, -0.15364930233660007, -0.35472777380845444, -0.4961222958157368, -0.544635463228261, -0.1345913960278868, 0.19535816359075783},
    {-0.4749309239168956, -0.5747380877557791, 0.17081967433614412, -0.45132566561379395, -0.44309349997829595, 0.026144446078527655, -0.11228730564497785, 0.30250126928916654, -0.3188582808070646, 0.32315336506588466, -0.6312447583957257, 0.20432609184337247, -0.32436016292744396, 0.19797544509914475, -0.06949322139265986, -0.31603197669815136, -0.1903109186141908, -0.1351838013172862, -0.6592955531650072, 0.28189385746261414, 0.024343956422623006, -0.1721957866156183, -0.32303364150957253, -0.030853779839392807, -0.21837140322408133, 0.043452690304217056, -0.36798805727623646, 0.1537463641175954, -0.1469434315363748, -0.4785553376654335, -0.08541598372011029, 0.23911383555095558, 0.1190847852557897, 0.19815236903760425, -0.05695334138220792, 0.26333932049667896, -0.4435475431256356, 0.21719776500450044, 0.0011350458524241104, -0.3952830074975566, 0.2645924478777945, -0.574469410194193, 0.08303527089181563, -0.35933392910236345, -0.4065756603091744, -0.4134894054532584, 0.10577639153592759, -0.24734782889758417, 0.33629284473257554, 0.07474777316042208, 0.1707628329655548, 0.005369631763950251, -0.4343271763386385, -0.07625086095180192, -0.5071977038466905, 0.43745932932194437, -0.2372250482570151, -0.5404783130261718, -0.34362247057752665, 0.05468077743373221, -0.014034424117995915, -0.5944417938026617, 0.08209533002151245, -0.4633853190453876},
    {0.20816727427561957, -0.3239182604959776, -0.22405760800223207, -0.10047527112956305, -0.38766544200683695, -0.24036163044863237, 0.36217694294431513, -0.013517201786415824, -0.31684202398582995, -0.03610230823906831, -0.38521093424056985, -0.16366846205734129, 0.5037087825149685, -0.004395660717629857, 0.6271619450060627, 0.11887042731693052, 0.0029620660682404157, 0.23429477635270304, -0.2203162565793829, 0.43103610153859, 0.12353295474889747, 0.16098184172445626, 0.07068610863520398, 0.40516536800984854, -0.14924495417878444, 0.504366753884913, 0.3611733065292868, 0.03626528413876849, -0.08568572639477028, -0.3475142943449232, -0.3341563379774002, -0.2225317146250359, -0.4026447328587533, -0.32942775597952423, 0.15351218030805508, 0.4279696201435259, -0.0038409902446146526, -0.5100169583788426, -0.08348675070926251, 0.388425900098932, 0.34713126593191274, -0.31969957834069984, -0.10565210255320989, 0.061157270701213885, 0.5363072338937637, 0.12410208953880794, -0.03301715168862388, -0.37344012818470584, -0.27650951135703605, -0.08047319723009881, 0.21734853343079785, 0.04560984683175764, 0.1597831592738844, -0.277304194378032, -0.25903473254224213, 0.4765865733591192, -0.20906349407253638, 0.2883760856494708, 0.4075546494414815, 0.42999805733542873, -0.4689243952568915, -0.23703501229180107, 0.02315535168322094, -0.0362357328554724},
    {-0.19258087535302504, 0.4812873125274766, 0.20250776152907263, -0.18382550709746032, 0.3111744857378404, 0.6274712116555908, 0.41022875451721363, 0.3814567185951687, -0.055684757724677306, -0.384457805183281, -0.0786216959628108, 0.05043453975496519, 0.2833569065080968, -0.1655563174243227, 0.4796105111455635, 0.25446031294022187, 0.056847677966258336, 0.30063400227612663, -0.06965970314192044, 0.40946657192544983, 0.3369302079690598, 0.26830784771130123, -0.2555165498450466, 0.3078827546935424, -0.07707498388129348, 0.17886838326386845, 0.09446192905459522, 0.3895128853809287, -0.14604563779844262, 0.3082655631931844, -0.2425263416494365, -0.24937552715899008, -0.20652971862499486, -0.33866754226879475, -0.34832977720247393, 0.4282937089535983, 0.42935476905476977, 0.08445282736165005, -0.3723877427418138, -0.261827471989184, 0.11975118332064504, -0.002295350413940391, 0.02466963995406602, 0.010944773946543421, 0.18158546480499188, -0.18297925977637433, 0.10242779279684427, 0.3705130644217278, -0.17730185550198352, 0.1497470174227426, -0.06026186251873991, 0.3631876122664983, 0.458215667258349, 0.012442821561190014, 0.004897339848365443, 0.1121868818416195, -0.46256947013062905, -0.3625147284143645, 0.04566143417552029, 0.5390834582398779, -0.16519235424241563, 0.2656533064680547, -0.19814042087709507, 0.4030096550835684},
    {-0.3964683684486991, -0.283675835320307, 0.5196368232488814, -0.24223155812464886, -0.310189327347471, -0.05964713040535131, -0.27893726303984206, -0.46570198163640814, 0.17235731073945357, 0.36307770202901885, -0.38093085848480174, -0.08159140867771858, -0.16078986964509798, 0.33072549139535623, -0.05637901160778351, 0.12948103182862725, 0.44192732448560884, 0.24603093996636968, 0.26232501197556524, 0.5000078876145179, 0.3326015561567319, 0.32333159213953483, -0.02241789293818645, 0.14474499874869914, 0.19966288760179574, -0.3958237269566008, -0.09823222660855124, -0.148913179224262, -0.03559010839486135, 0.20814191060875734, -0.3398253168937882, -0.46962958308387615, 0.06367076095991289, -0.21294531822665672, 0.3392046502675736, -0.2788357493137032, 0.04651317005861719, 0.31072762496475337, -0.2756944584929208, 0.12048211785026372, -0.4335421686835031, -0.3102257853304508, -0.22626970052576834, -0.14671487747684242, -0.16886814921917792, 0.13769969408540836, 0.07428344167656994, 0.34789301770388814, 0.4914974428043681, 0.02824991335273961, 0.42454588204436794, -0.3903176402616676, 0.19929687662225362, 0.14136207011238638, 0.33593232995748623, 0.19600328189635363, 0.2144623263237887, 0.4880486179245143, -0.3483362772420853, 0.03995444479459304, -0.09224896317760298, -0.31168972821829, -0.0024280540654113966, 0.4378926861224188},
    {-0.1114713114166038, -0.36666466687542476, 0.3797760991445923, -0.008027890735803208, 0.07229181339911958, 0.1289225729721807, 0.15956432264007345, 0.03772303282232517, -0.48504874574604123, 0.1773707969158315, -0.21844734054114065, -0.5122626641091625, -0.05626251676091512, -0.0936604244806273, 0.06109895373851818, 0.12178209312811426, -0.10632341697509928, 0.4235048296067506, -0.25363317155696175, 0.00044425821784970974, -0.3226592608962662, 0.16633445493971186, -0.44747281904816266, -0.42248070196357834, 0.2020875026629028, 0.2612988122051413, 0.3751138688261298, -0.2864460223307198, 0.17109797752392736, -0.36384213515450503, -0.28011627003312617, 0.4230948509851661, -0.4110134064916501, 0.034464009575570526, -0.11641218261783962, 0.008013669944458922, 0.25451842367777616, -0.11103856449130864, -0.1558755317536236, 0.044853081051158754, -0.17822426578806902, -0.14054617750098197, -0.3481487040937572, -0.392107276494431, 0.02255219886899386, -0.012141366359466289, -0.08879774689753385, 0.10243113904608475, -0.32969850438378456, 0.19333291757183022, -0.4778456875787028, -0.12501148011466767, 0.023271985854665802, -0.3991396806876126, -0.37000740424085526, -0.015004618264234805, -0.22921434324683634, 0.203236225628994, -0.39686588828843594, 0.23178000374268193, 0.2379622891188261, 0.12946747017862334, -0.12019184671575901, -0.11225457062647638},
    {0.04663644634670205, 0.28254514940939146, -0.0285821099192022, 0.11835129409368823, -0.4092437200740101, -0.07712248083447557, -0.028411153702210933, -0.43400021632691416, -0.0031545522059615687, 0.12695914225777158, -0.2679229183256884, -0.45843109934641346, -0.07318518600473638, -0.1767788274727194, -0.13406422944173862, 0.13043659046675632, -0.5896118341209602, -0.06352757601086745, -0.16010504109865709, 0.11350942815875942, -0.09855947354770635, 0.29910144525517507, -0.5894557825190639, -0.4912632457472227, 0.39694317723691624, -0.12384999608604697, -0.35350188984647996, -0.06976487635781804, 0.153874036245472, -0.47403253707104176, -0.032425143184249106, 0.6101976488484839, 0.10347075694410938, -0.04002403319194179, 0.22123146754525283, 0.25639065716945375, 0.08729203523869178, -0.1541602277882064, 0.09629753352407358, 0.28311273260974223, -0.19919721804584742, -0.10347336154112385, 0.001716750789694381, -0.01638774132205215, 0.25085473395340846, -0.029534644078364283, -0.3917105382124298, -0.4135241296254815, -0.18702311095563165, -0.049285117385605204, 0.11981977522278296, 0.22684840827898242, 0.37143420696935253, -0.32319783386826495, -0.4833885058227434, -0.35782831599341863, 0.3557485063850058, -0.3848386601087818, -0.3353657448990255, 0.2977460521102855, 0.08567432373135292, 0.2879769489754785, 0.1870792920935312, 0.46603588554687986},
    {-0.38171364849044465, -0.20689317787273645, 0.1626698304741698, -0.30330186511109025, 0.33564807785865475, -0.14410711522818798, 0.21001287245549985, 0.4570472000557016, -0.1381743019874327, -0.25318233294596937, -0.35780522032296236, 0.13709531121200427, -0.1606364654921115, 0.517373452196204, 0.2727074135797485, 0.5581767684848058, 0.3885456625395603, -0.01651789524170442, 0.0885270413415518, 0.35485298849236185, 0.025806441665447113, 0.06739358268928827, -0.02959609766122419, -0.36891196532873904, 0.20270209606378098, 0.221444506926981, 0.13489389251654654, 0.02909284491863507, 0.38091469496113756, 0.42546053150791113, 0.05548592719356854, -0.08550073131514291, -0.3301635552120089, 0.006051412726900831, -0.21457448269171994, 0.40578768751381966, 0.364922077173213, 0.018850699257122776, 0.24424810171425723, 0.3705169440026096, -0.14116637697174686, -0.004021804258241368, -0.08305865931944831, -0.09299168339257705, -0.43428768301547227, 0.3089628316695123, -0.22338550217797631, -0.21027285646567737, 0.12637117928985003, 0.26947784821253634, 0.22008939844722147, -0.34216203655849, 0.3499105629213257, -0.11848609347797098, -0.10603563895195547, -0.5916315062015662, 0.25306050189281304, -0.3397037167827771, -0.3876148030068605, -0.4050533855609948, -0.15013034038389214, -0.01064698239354532, -0.2589518753740405, 0.10509711287392344},
    {-0.15544839866035565, -0.2549196894004926, -0.4512226665941043, -0.16388730932502935, 0.21970459630308586, 0.5583572004942059, 0.09532828002309003, -0.41661035656852013, 0.17573147406283743, -0.10897103205779739, 0.23999941878437056, -0.16768840626024192, -0.20808504134397157, -0.17155956584348112, -0.18328158937918781, 0.33786424686926175, -0.24265226290145492, -0.49018805559368994, -0.2585272310927113, 0.17236207963557545, -0.4875303161462588, -0.48352659771244877, -0.011865707998029993, 0.2504093931477426, 0.5683549647020085, -0.1642420116584162, 0.12071245101060028, -0.007943498278373177, 0.2844887911047374, 0.5327921764513953, 0.405590491116481, 0.39843629171042916, 0.2110540404845922, -0.20803958883054036, 0.274714003729304, 0.0480825564099338, -0.4999783293826184, 0.2384959050913218, -0.06741185331473352, 0.300160270257683, -0.07461927358029881, -0.21759178019321895, -0.3155352062768296, -0.18919801003652928, 0.5462621270964908, -0.566989357444117, -0.4713758866247282, 0.4023641062534854, -0.5229274948548482, -0.5019437509002713, 0.0019446391899548097, -0.1894226376109715, -0.038505374486641326, 0.09884884446372104, 0.023788493443456016, -0.19586576222202334, -0.3789820678300132, -0.293610101205256, -0.3917880142039458, -0.12117707936661777, -0.393246803213878, -0.17482076975511943, -0.09979572749467698, 0.02088186315939279},
    {-0.5622919643447737, -0.4865737889660368, 0.34055804963700775, 0.05093119032012212, -0.15782236254955104, -0.5468886132050212, -0.25719857899402615, -0.13227071564416742, -0.3275785452114197, -0.16378173603289842, 0.10492220089508542, -0.5526859565497194, 0.5490617905254135, -0.5599524355201408, -0.0886658361052385, -0.16314432336194812, 0.3332149123113098, 0.0749956033736816, -0.41497531114139674, -0.08379995464479066, 0.23992444591758882, -0.17653737007514583, -0.2815340224925244, -0.11299394867815322, 0.2414710939748385, -0.2406083943086325, -0.39372737855025075, -0.37117553788798713, 0.012834247769020164, 0.3470316525080489, -0.1389479790943187, 0.375598942790265, -0.10433719585555892, 0.02690973392568698, -0.324504038370751, 0.24071048044656784, 0.138381749683679, -0.2516297370284562, -0.16384228490575156, -0.16551734942034252, -0.17478583421196967, -0.12944100876418924, -0.16860031206196724, -0.3107395714521387, 0.31044442398970085, -0.3872570712903878, -0.45981474585076, -0.4069344109356444, -0.4264777589422847, -0.1625187957860649, -0.14263392048970738, -0.2520925793067269, -0.3529839203970782, -0.10520743192135916, -0.4890874606960147, -0.21303830592023998, 0.331718613388371, 0.15179471890018714, -0.48734170881366773, 0.5225867388212638, -0.08020902883062488, -0.3267982479115059, 0.0738941077349601, 0.008420174633790248},
    {0.1410828888574988, 0.08527093288215919, -0.3430033443710301, 0.008037825564890376, 0.1501285159791533, 0.27895625675295677, 0.22627244214990255, 0.2844534805875987, -0.2681698860650814, -0.3424144079525293, 0.12777001246972036, 0.4171500820922523, -0.4121714900448581, -0.37723055318189275, 0.284184965750959, 0.28453671242972894, -0.41823528586008274, 0.31639812127517153, 0.013629325905830495, -0.3393346611350438, 0.38661502319181645, -0.2771981605618761, -0.08088608080260551, -0.09196203176343043, 0.29872071843176107, -0.546982206003747, 0.30811843711359005, 0.19274347329296068, 0.21337491871764463, 0.27019947948254747, 0.06286783750083957, 0.4406155709411996, -0.17767114618578403, -0.49789861609300057, -0.28541160698917384, 0.4257436946963214, -0.2526938495300908, 0.39439394352795815, -0.11070473178548514, -0.355515737105909, -0.38693677072052013, -0.09121525698085418, -0.20262401394893823, -0.14112302419854791, -0.06099682080572145, -0.4080485133238036, 0.2679419634873722, -0.20342699680841228, -0.1765484855172812, -0.2587179388234648, -0.053060888370897105, -0.4810549471447721, 0.3308469082259891, 0.23583040506271832, -0.21992750875636283, 0.21095366212618655, 0.23042635650723653, -0.08694031690907444, -0.022344074155304393, 0.08194049636044996, -0.26843235967517487, 0.2747374292160911, -0.29851329865426257, -0.10936548895601868},
    {0.16370958302247895, 0.23095209255324042, -0.6248774439201983, -0.28082180763537684, -0.3013366752479833, -0.28802678874961507, 0.19032899872069647, 0.013734488549110635, -0.15896969331197852, -0.5212530598441938, -0.4544900112938855, 0.15237907332657033, -0.5025640253774186, -0.22967719089080452, -0.43502739703264415, 0.27842381597734855, 0.07804338646572186, -0.2868167878247146, -0.1072373388239074, 0.21896786407126884, 0.005091722676115303, -0.5552761507594934, -0.21432893947671253, -0.2576631109865223, 0.33275999983232735, 0.34981158388590744, -0.21227345143932755, 0.08418387304404987, 0.3603661416755484, -0.09560200374673772, 0.2209347568142944, -0.3288837225643794, -0.30492378439065515, -0.0498965415359565, -0.3091007896803373, -0.15397933969298713, -0.10895513011016601, 0.22780166978616936, -0.27418237182652433, -0.03139299608368996, -0.15546500117162912, -0.5091847703505777, -0.10961137375556763, 0.11386493980000013, 0.1334700480943334, -0.42168838378765855, -0.30154646780784294, 0.17294782763412392, -0.3886049253806414, -0.2868082320127487, 0.43752374996871696, -0.11566926244714244, 0.170020322710553, -0.3747959394417168, 0.11766280518390751, 0.19774433952869186, -0.06062987440700292, 0.44967206827002615, 0.03902580980135446, -0.0190803452720754, -0.010775620648529775, 0.23511616832058316, -0.14679395531141434, -0.3903881474372547}
};

static const float b1[64] = {0.9236900650170922, 0.8288472274485056, 0.822449808413375, 0.8760202499874699, 0.8817774548805198, 0.8791543262760564, 0.85506709185494, 0.9170313002714353, 0.8431725512264325, 0.8335752790735383, 0.8470865566537406, 0.8268525840771653, 0.8792962958037844, 0.839335997437547, 0.9165847367377429, 0.8969091430723077, 0.8762309633426669, 0.7901372851449827, 0.7171847130181498, 0.8152129296870184, 0.9027479389141169, 0.7796646393503639, 0.8456869231166654, 0.886129294695732, 0.9656335044986786, 0.8710347320299264, 0.8697763528642303, 0.9054298934871222, 0.9225023833706789, 0.8827756992398165, 0.8738401838273206, 0.9051253380442298, 0.8130785009133392, 0.8496762105616127, 0.8338198064273203, 0.7728385101260025, 0.8929588822743972, 0.9174614758346531, 0.8600402489684801, 0.8503588667325322, 0.8440547553825569, 0.9025605091034341, 0.9143467588798581, 0.8758492443819889, 0.9154563115321049, 0.8674108731236618, 0.7479808375117681, 0.841107415308829, 0.856248596364197, 0.897612655949475, 0.928478576887131, 0.8288061985934376, 0.8946433253172543, 0.7665037528227385, 0.8474455258642066, 0.8599324537485028, 0.892054330600146, 0.9384001085224014, 0.8686139678674898, 0.8607909174331138, 0.7477141583160479, 0.9422740071960158, 0.8411314424367684, 0.875779314698261};

static const float w2[64][32] = {
    {1.049200878003426, 1.0575345681372372, 0.749340246954119, 0.9469042370520567, 0.9122409279885799, 0.49288784661505897, 1.0523001128580576, 0.5432663945059919, 0.28508682828573273, 0.39910532355226847, 0.8790368478413891, 0.6916413415452661, 0.8083152226056185, 0.8330746625281742, 0.9931257156299367, 1.0568683338164857, -0.07110396357639732, 0.9102009897363508, 0.9785692208902858, -0.1648720362131113, 0.6972569209681502, 0.7556192239249415, 0.6478919030223619, 0.6634968016466884, 0.49042636152598057, -0.05861835390578408, 0.6249076446761407, 0.7653647767088356, 0.7261845099870844, 1.0497726848988607, 1.0052319608121216, 0.7121231626870215},
    {0.5983556834927539, 0.7766480739959519, 0.7095314707141775, 0.8571035025605007, 0.9709395906370798, 0.5625493338980573, 0.960061662958169, 0.8764189639686737, 0.2891058464078219, 0.36920438052757276, 0.5408897016617112, 0.49707777786272395, 0.8265879003452586, 0.78451350030976, 0.7279169637007604, 0.9053396055314399, 0.000745895986725114, 0.6317014031113243, 0.65060555582343, 0.07098404084170212, 0.5351191181076306, 0.7852092934034842, 0.6390066815107808, 0.9447131900415316, 0.7625999322270561, -0.27803792750140394, 0.6472392919404106, 0.8938356437935708, 0.9949528595559459, 0.6905947574389867, 0.6391720921402438, 0.9342395530843944},
    {0.6413453659058375, 0.8117521129740716, 0.9776397800950906, 0.6641092674183847, 0.7976477615264592, 0.4137488078756821, 0.5785006541440683, 0.7037250823253298, 0.3623573097984235, 0.3204712355045902, 0.7803710974873213, 0.8932817236974008, 0.988482788821273, 0.6780700647853052, 0.6550478669329507, 0.9748285803454747, -0.10150716769779479, 0.8514390178413794, 0.8464305603049689, -0.14459697172486685, 0.7409522596130569, 0.5814411176217432, 0.48866692805783885, 0.760824322113594, 0.668139774542137, 0.03728375387989204, 0.6306293071370375, 0.4916491103673491, 0.8734418763518894, 0.6692589861700305, 0.785079176220807, 0.9482244387677473},
    {0.8348131033528161, 1.0167202086297837, 0.7306409521962421, 0.6816080594022856, 0.9506336911293601, 0.5559723132761342, 0.8008831539078222, 0.49257971572682785, 0.530956453704781, 0.4370201946172506, 0.9075839759359763, 0.7584206342420015, 0.5908141928958467, 0.9946341981434894, 0.8301280843592689, 0.6903353171004581, -0.006251713272026518, 0.6705352469707025, 0.9626890748104313, -0.09098908852931036, 0.8159123385893039, 0.7498847816374918, 0.6158959879964069, 0.9300767364276403, 0.7668073663998801, -0.111682621852861, 0.821361292398204, 0.8412273075700318, 0.6206699423317237, 0.9586209749557466, 0.6740574246544736, 0.8904207194449246},
    {0.9080826554842257, 0.6878054325127283, 0.847314361306596, 0.5972760386892011, 0.7401761629908825, 0.38069025071296336, 0.6980116090390635, 0.4320454796140396, 0.18828627384428281, 0.4605195323408505, 0.5284874021493109, 0.7404549430725089, 0.7784057549148014, 1.0203345296736475, 0.6296243904696179, 0.8809658228170134, 0.15020307013275397, 0.891100372127271, 1.004764908968602, -0.0033901884570788645, 0.9226703290641385, 0.9177493074980398, 0.2762916814213655, 0.7426051456599052, 0.33142844554008066, -0.20832908642515718, 0.764752137885092, 0.6121598196114442, 0.818535216193563, 0.8591287538170562, 0.7737939240929855, 0.8807885581094665},
    {0.6736543990543241, 0.8109625394058714, 0.9024878735957462, 0.6904976425920588, 0.6985174072912582, 0.22985171607252497, 0.6121984593407961, 0.5435601974258489, 0.6707573578844732, 0.35413801947699536, 0.8104677127645771, 0.6949127203909031, 0.9259834235142705, 1.0406323307695113, 0.5299430036568102, 0.9896641985179124, -0.039901868269845445, 1.0112466731057415, 0.803124207759232, -0.25190215125351806, 0.8281104156310676, 1.0216804275278561, 0.5506879672935918, 0.7486255763342688, 0.6206402635924759, -0.19716164332700525, 0.710786831439829, 0.8799173605309487, 0.755507188159636, 0.8225962591932258, 0.7375046001261686, 0.825912784912504},
    {0.8393826473371288, 0.9085031420346229, 1.0344952957599367, 0.6506794311198979, 0.8762936936402475, 0.6051540364865062, 0.6352841146157903, 0.535331610803571, 0.4861673297068725, 0.5518765282709254, 0.8921248744661476, 0.6730616091414126, 0.8785353753910564, 0.6005310062258793, 0.7051857534968041, 0.915489528410631, -0.12668189318100959, 0.8149447601331922, 1.0231074585966038, -0.10470074999637466, 0.6306491118981046, 0.8572517434107277, 0.6174030365323819, 0.5739152814101267, 0.5071633106159174, -0.0071083658328089236, 0.8290159829228128, 0.8999381461916985, 0.5996032602854952, 0.8347816333271818, 0.8808822961135719, 0.6391743421630093},
    {0.8301649578520924, 0.949951649100018, 0.6713963988980027, 0.8806809721923795, 0.6239185356886976, 0.49747048276782035, 0.7744289732968643, 0.7738252836666335, 0.6471685142958881, 0.2518196310998614, 0.8699016044429586, 0.6679712545882563, 0.6563217341090684, 0.771974992009228, 0.5328102899809851, 0.6714858600557525, -0.26931576090965714, 0.8515343086400344, 0.6612071000386437, -0.1634033320593577, 0.8384578928150189, 0.7661703204733316, 0.25276319115560736, 0.710777778454989, 0.42816263523704906, -0.279127739906649, 0.8825714694679031, 0.463278051654361, 1.0260720664379093, 0.6584379793941698, 0.8077049696387657, 1.0692961234606404},
    {0.6199285316804612, 0.761561519737048, 0.7610217643346275, 0.6528383701758326, 0.9654009904556765, 0.37718124146311477, 0.951719079539213, 0.6272079116968187, 0.41722239618068513, 0.3347245700049085, 0.7696589849971797, 0.6511180908927643, 0.6142447619978713, 0.9180655448121, 0.8053566240112832, 0.7335794726690535, -0.0012947696348696667, 0.9597761941654194, 0.8982721676735265, -0.24997201584843906, 0.968211503829102, 0.6838450356915525, 0.6720600737309491, 0.7327616850555584, 0.40463296837434864, -0.2068165268331202, 0.975121887222594, 0.5722531191148769, 0.9698563530634893, 0.6297864661740268, 0.9771806448719411, 0.75562716430826},
    {0.9529444561949064, 0.8561546979981934, 0.5621350945143838, 0.9557881827753907, 0.8847864000127019, 0.4031373529591497, 1.052261529582354, 0.6242286654066748, 0.7918269499002137, 0.29128821536255456, 0.5763772830202891, 0.7303386468135983, 0.5441452316795319, 0.7159071031207502, 0.8618554309316586, 0.5807788621298199, -0.06846448956942806, 0.803780413214524, 0.7467506255737326, -0.16987373437335512, 0.5761735615524866, 0.6033612085361151, 0.570783973527343, 0.7557314673214931, 0.4338204133121827, 0.05922327484725685, 0.8523801160875684, 0.9505846891946552, 0.6875966314047165, 0.96709360884972, 0.5360057983573747, 0.6609493016627918},
    {0.7614100527794035, 0.6701400307630707, 0.7019995662734642, 0.5914104083403532, 0.6923380514822348, 0.6324740856016443, 0.8658578298493362, 0.9128275847031104, 0.39416584138717137, 0.3807838509007305, 0.7339788081551045, 0.8474584847901465, 0.7318454629842545, 0.7689432590127757, 0.75670983516484, 0.5491938224480694, -0.013448136200592823, 0.8156899032749091, 0.9600956238947626, -0.12173901859220408, 0.7343245475100122, 0.9791938499158827, 0.5279051275689904, 0.8703256419964577, 0.355068279014469, 0.04800345652798399, 0.7667591426102325, 0.9361282776406061, 0.7642205455918849, 1.0408335281136347, 0.9616410943425936, 0.8677323660036492},
    {0.9442938785061751, 1.0153278148021507, 0.9593686424106902, 0.8334631389257424, 0.8581559458940228, 0.28517404289804166, 0.9905076445129334, 0.798061517275653, 0.35503457015065687, 0.4459982893695675, 0.6283245307305264, 0.5792033939143335, 0.900009099233899, 0.7955876160574905, 0.7806616489198401, 0.7550702281832314, 0.10623329697970779, 0.8550021349814727, 0.6859306727562852, -0.0377783815003874, 0.9100160945111865, 1.055390055172603, 0.6279067628477899, 0.5801063809455159, 0.34711977900229246, 0.1168477648609333, 0.9366933439654668, 0.9206434772819763, 1.0068572857078733, 0.8085164337651278, 0.7936724431105935, 0.6793700594709223},
    {0.8175053073478644, 0.8390749700197778, 0.6217533614306734, 0.9945335476945344, 0.9036069497039834, 0.326955477829335, 0.8620830895634946, 0.6697709424536, 0.4543389038651231, 0.5457586679719635, 0.6657091969889557, 0.6813891350219133, 1.0279036154118455, 0.7003645944262535, 0.626705495158264, 0.9119834543794713, -0.19042250631763064, 1.0025825797025982, 1.0710151516295965, -0.21518173138466495, 0.710696042329959, 1.0820326532021074, 0.751491889603388, 0.7344500689358087, 0.4428192360831649, -0.01093010103250542, 0.9828905303337048, 0.6626163606238392, 0.8409969481677206, 0.9856246560989866, 0.6408956051076133, 0.9180135429657394},
    {0.856773914186421, 0.9219804643950774, 0.6239454842360392, 0.7165270794017979, 0.5379368075203874, 0.2278919129504378, 0.6741005597140581, 0.5144558659023537, 0.25217409796523876, 0.6052331632590219, 0.5828151749478957, 0.9507176170490628, 0.5243552439934966, 0.8491724712512765, 0.45714144019234, 0.840309362042162, -0.25884518837904674, 0.6077825873101335, 0.8328624268883038, 0.020117727286664302, 0.8977976028021651, 0.5947764122775325, 0.3664176479524872, 0.5207980755140896, 0.547775680179317, 0.09762877716084718, 0.6137478459942698, 0.6113044426174455, 0.889228466181134, 0.7363525749843093, 0.659857396860284, 0.7944844083160634},
    {1.0306010487703894, 0.9529040805313486, 0.7726952215309505, 0.9043335006000353, 0.6106580699822837, 0.6769653513904893, 0.8978720119338846, 0.4759260981209169, 0.6990905663054879, 0.2501704417218225, 0.9970959678548726, 0.6749777182170549, 0.7309782583198221, 1.000242974581741, 0.6232250369339262, 0.9152028967149453, -0.21137801665201975, 0.5849986714865452, 0.7774684733409757, -0.23042012946308377, 0.9887687986347982, 0.9249458067178739, 0.33163414946144437, 0.811712474942798, 0.45762317652727813, 0.09459462741060602, 0.9413684694594203, 0.7799916369771398, 0.9229591175635468, 0.6728035035092402, 0.8352220161047013, 0.9780800525803995},
    {1.0192415512422277, 0.6266958579583496, 0.957776341387327, 0.7492727075696981, 0.9432243218653896, 0.5898977070747167, 0.735173651691618, 0.9041744282166212, 0.35797608994332847, 0.36014691209554167, 0.5893154407648664, 0.8143625155281302, 0.6906066341906711, 1.070085936358554, 0.7614034109075414, 0.8877827916072817, 0.10658889472166924, 0.8576855857808278, 0.7117943927688198, 0.10172973440443601, 0.8810543829224704, 0.67499804948385, 0.4477687648479697, 0.99869889319487, 0.3901113041055995, -0.09163064965233238, 0.6017341670489306, 0.5980632382875526, 0.6751174050780991, 1.0813801272057524, 1.0296946406431826, 0.6595897885427541},
    {0.8998615505108586, 0.5613903471785975, 0.8115454171163329, 0.658561972593059, 0.8023880416881574, 0.24272042299262422, 0.8254900778659523, 0.5450589672550168, 0.4602067710532036, 0.39084288656733285, 0.8967903496337607, 0.7078482797480006, 0.8739869226809422, 0.7227116338246201, 0.8075769729964751, 0.8557472326305272, -0.12348939104871778, 0.5630783386731193, 0.9105877935422809, 0.03919449188962556, 0.9269943643657351, 0.9285866563409401, 0.5943807094612218, 0.9064008399868971, 0.749453172956065, -0.03298047575183978, 0.8331863439811833, 0.6444223094167842, 0.923806220770231, 0.658733118592315, 0.5209194185910997, 0.9011783762599389},
    {0.5440609189385281, 0.5670861660903384, 0.6891978857725698, 0.6845072580382684, 0.5615760307773237, 0.5754377994391123, 0.6318188249423767, 0.8289348571976781, 0.4840624023499456, 0.2928348659374636, 0.6692493037562588, 0.831189270140773, 0.8734237658912921, 0.7215869765143825, 0.8070695488014914, 0.760296219995687, -0.11711281890059196, 0.9310513887848618, 0.6181365746795446, -0.1633997070009362, 0.7290045166157638, 0.8753326307071423, 0.27088588384848167, 0.6462278748590692, 0.7411124475672737, -0.08890611646285349, 0.8889991482944389, 0.9130868549554638, 0.8384781274668922, 0.6445323075998395, 0.7606711198912928, 0.9265701697419829},
    {0.8288792127724807, 0.6271881374681997, 0.5730638325167297, 0.7108414993402773, 0.9359050365784614, 0.3407335329141944, 0.813780497856172, 0.8214411858913305, 0.44802086630460947, 0.37996069292839335, 0.810072874205698, 0.8415149854605054, 0.7691381053924492, 0.5939026276588341, 0.9308468901393492, 0.6753702249919128, 0.06199081991313222, 0.663760558443812, 0.7995171718653451, 0.07491483532321623, 0.6586187900498999, 0.5975128802595545, 0.673459167190645, 0.49656284273606865, 0.4955367914045136, -0.22258883646925678, 0.7641791593302573, 0.7689897700675657, 0.9557971507627095, 0.8704686772907017, 0.8685667112849715, 0.7353433766526685},
    {0.571212638646793, 1.0029543736492614, 0.6504065534586508, 0.9522494849087103, 0.5766427007678927, 0.6506337484236646, 0.638254940700553, 0.8914099498103273, 0.5757048967176448, 0.2704495215417762, 0.8092752565791683, 0.5570370094765634, 0.5882140761768767, 0.7838804536883579, 0.4975300125094975, 0.8804518869869357, -0.16614939041151217, 0.9464837260613009, 0.7698684380151558, -0.1136424815634433, 0.7414705518504872, 1.0001934143431488, 0.7386968930762332, 0.49774963304150377, 0.7479016960809737, 0.024956934748537312, 0.6750661793788476, 0.8874055606955116, 0.7440669911758401, 0.7170055454414289, 0.5069171365339604, 0.6379656567731111},
    {0.8596117773471467, 0.8224680046131645, 0.713170148973648, 0.6365196908558184, 0.6342176544590398, 0.3174906186802877, 0.689969478135484, 0.6075268753972375, 0.4238330666614894, 0.5820749529584544, 0.8407816865281212, 0.5088287939507422, 0.8319562206634945, 1.0750258252053209, 0.931557062938622, 0.9853453662579638, 0.11904268856129414, 0.8480671185945453, 0.8386916002202971, -0.05029527731045929, 0.6111107536686368, 0.6413581223263175, 0.42583916193337923, 0.9541488825165314, 0.47618237797468754, -0.18730404564137143, 0.7422124379407572, 0.887610856365809, 1.0739588653365808, 0.7092932266131886, 0.6518335009379407, 0.7249873758158751},
    {0.9206311024290693, 0.6482360891603827, 0.7228090353558343, 0.9162639114918237, 0.9878384936875879, 0.7190338059987021, 0.7740648722717041, 0.8520687875408471, 0.5458150820456993, 0.3341315114195866, 0.7329518610134038, 0.6798280633285215, 0.6290302491446276, 0.7884425757367464, 0.7372337692883812, 0.7225172759336356, 0.15182414035079764, 0.5820051169800912, 0.8750122413877278, -0.17608773832089708, 0.5956724914711693, 0.7537980297256397, 0.6017040493025039, 0.7346610849831116, 0.39897193891804983, -0.21039624488452713, 0.9614800017629987, 0.8055968165925361, 0.8985111304675839, 0.8651996355241448, 0.7125405782557556, 0.6910247678878814},
    {0.984746305356338, 0.9526814560890947, 0.6755512000647785, 0.9956393946289737, 0.7432405096590768, 0.4779969428728806, 1.026562380586248, 0.5650215148335216, 0.624985022937517, 0.3784810253829459, 0.7735075379848585, 0.8325635825337092, 0.7951643864505477, 0.8697178114097536, 0.6608985156107363, 0.5566407735045846, -0.16072473110184007, 0.9535496137188587, 0.9252741115342272, -0.25803360300801503, 0.8777221134079681, 0.6392378485351949, 0.7378524081631537, 0.62640715072845, 0.5771911678924455, -0.018046470162578637, 0.6155483429575306, 0.642126974898769, 0.989525356755072, 0.8262476258934549, 0.536823880447592, 0.7510517916085928},
    {0.9283925336665377, 0.6616457484312963, 0.5517094633367803, 0.6025825606615527, 0.5894788450008319, 0.5931176846899273, 0.8654149907526649, 0.8458229436233499, 0.31746974666200933, 0.18488509044209883, 0.5180003225625638, 0.798086379404682, 0.6092551045913146, 1.0006713116257886, 0.7982565167947617, 0.9256350692765937, 0.18175145104862805, 0.8114816508368863, 0.6425879121089262, -0.11895035418376487, 0.5941521451237137, 0.8863335604823639, 0.6075360108732966, 0.5044477867046099, 0.4028637779125104, -0.30972080680103653, 0.7081000575994152, 0.47240562267941155, 0.916560257940712, 0.7810275300389188, 0.8520524629718117, 0.631919514185407},
    {0.7005589614738018, 0.8123399356001846, 0.6490722038799139, 1.1097754886610043, 0.852422709002509, 0.7623621269400455, 0.7969731994903719, 0.7069079739291669, 0.8173494851128572, 0.7502867437394367, 0.8387454505915268, 0.5449058032389321, 0.7319742622172153, 0.8184715767600614, 0.8454285488137414, 1.062234003866248, -0.22175433146407222, 0.6504069692823743, 0.800359163961895, -0.16060460599736556, 0.6258861827002227, 0.9768353549303321, 0.7576441112982713, 0.7799325752653375, 0.6779478369052955, 0.003801904204519629, 1.032787203312656, 0.6732008961395586, 0.8239584839223044, 0.9538812082942907, 0.6669487159578473, 0.850688253713561},
    {0.7294102029847123, 0.9090769673550637, 0.9354970797995195, 0.6820096263077771, 0.9295291679344018, 0.20635667196342009, 0.9558323481203613, 0.8075633453024127, 0.24476963492259596, 0.4731490963652192, 1.0188723053490836, 0.6969360187260444, 0.8608332528182803, 0.8067914768716434, 0.7042068961983974, 1.0061431092985547, 0.10232525322596601, 0.9787090295421093, 0.7714116445478052, 0.054376139014793066, 0.9829917554371891, 0.8690819710160579, 0.6310916497342621, 0.6003019429889569, 0.5707837002247638, -0.17191922332347584, 0.9527196482328087, 0.6307079935308796, 0.7227130205078733, 1.0641609454657486, 0.6086815802970369, 1.0119247843494894},
    {0.8341503523147432, 0.6130389029541311, 0.9467472103503403, 0.673825690274004, 0.863857676607959, 0.32334207853590213, 1.0271643504784236, 0.5510040519783287, 0.3786526652464851, 0.6011739022753556, 0.700476954102619, 0.9034253398220733, 0.6067563314856892, 0.9825802561280801, 0.5204855366579758, 0.9160069196811762, -0.1857513531516143, 0.8010052000810286, 0.9978782605262337, -0.19994920348399106, 0.6903463409558767, 0.9720098882095084, 0.6758468030292609, 0.653676137491648, 0.5302075485835659, 0.11841188307580956, 0.7422977036869793, 0.6200135970954189, 0.7313723793003081, 0.9031129682634804, 0.7923768901579114, 0.896064166750326},
    {0.8628509925075913, 0.6538540370307295, 0.5937941066599611, 0.6411558563837836, 0.5149521681746378, 0.41188738496305527, 0.9513012272707484, 0.6262478403466771, 0.23126205327691424, 0.6002736187300001, 0.7061464134056203, 0.7211342842779451, 0.6902484639076445, 0.8958697684492369, 0.8290767606519964, 1.0227175589118307, -0.2786785032067031, 0.7627430944092832, 0.6125521497660025, 0.15580145512202534, 0.9330923341467231, 0.6047983049620873, 0.38941381001605724, 0.870417559229271, 0.5836987665479362, -0.11884093194128359, 0.9336969744545157, 0.8001252357282612, 0.8562893583405313, 0.6060386866411427, 0.7854112624405785, 0.6538734479901145},
    {0.7142531974357811, 0.870417197153089, 0.9390367826587088, 0.8285831208991005, 0.9889496690772858, 0.3284727433555682, 1.0803038587400144, 0.9556629758735828, 0.7563120680187886, 0.23935076535234812, 1.0311976110931897, 0.7804756060390886, 0.9175099958361727, 0.7617025777978588, 0.6006444468980124, 0.6230226912596897, -0.06573149263370366, 0.8576350935172804, 0.9125856625438249, 0.0033440689907796957, 0.6393621183035989, 1.0681293774205252, 0.5170433869227284, 0.8636214510692862, 0.34926950888053976, -0.04909163469259353, 0.6807406492407463, 0.5727822082832904, 0.7873861582838153, 1.014234580002567, 0.9083643997885695, 1.0504144458019287},
    {1.0233180986159338, 0.6283134726351027, 0.7918274352863657, 0.7706459673818803, 0.8707624259877055, 0.27202465898468264, 1.0271727026094495, 0.840355709703752, 0.3072658576381761, 0.6700292677325471, 0.5154049857655415, 0.5726613930455178, 0.8838571496203149, 0.6099465653527578, 0.5187337853052292, 0.7853155215860649, -0.15970023369322112, 0.6269156215449668, 0.9295294919915804, -0.14373747202962717, 0.6896161094726178, 0.8316050521732138, 0.5154972516287182, 0.7415925597035232, 0.404420824744978, -0.07019405391575968, 0.5639035872964768, 0.883432650935995, 0.7861301628658237, 0.8458504384696047, 0.9205587608932596, 0.6804476874210774},
    {1.010283084062197, 0.9754208135318181, 0.8418737771286036, 0.5740567977970422, 0.6770722571362193, 0.5746533126045009, 0.9772704748071823, 0.7870696224328383, 0.4265683697190203, 0.2625850902589572, 0.7445630215815469, 0.6724819161316479, 0.5443431688637161, 0.760647459798758, 0.9496344584538196, 0.6615767796396144, 0.11665996167395437, 0.8286271747001647, 0.9945575172594012, -0.05252184636950348, 0.7094184447411889, 0.8389207173514689, 0.5242804767482427, 0.6495087745769428, 0.48989675744507155, 0.04713168144004038, 0.7373386670092008, 0.744818020483703, 0.6607736807095446, 0.9611679406761966, 0.9247017871856602, 0.7242091436088334},
    {0.9831845501850947, 0.5903406369398599, 1.0088625577910995, 1.017241965696076, 0.9084696756034273, 0.39790957197913307, 0.6376686635881056, 0.5209158284842538, 0.1932601419549483, 0.5325597558972125, 0.8003653345027778, 0.6163147432531985, 0.7997418233493141, 1.0091180024492112, 0.5417235646706051, 0.903424697311888, -0.10734542375568763, 0.646326576873809, 0.8022209688212903, 0.027594638060784566, 0.830368154366873, 0.893284894333588, 0.45026458456255514, 0.6892640000249518, 0.5789843873788006, -0.2060556778167785, 1.019645541375374, 0.5387903473730307, 1.006435318841659, 0.8906136318519581, 0.9365497972663388, 0.7881188218372647},
    {0.765977026827313, 0.7698597946605713, 0.6000091956491999, 0.678576982631213, 0.8440391379559383, 0.2822581667002054, 0.9300504827002117, 0.5944391251171534, 0.7652343240634081, 0.5912535504672185, 0.8581097220879784, 0.5742992414295228, 0.7012343426316022, 0.8871916528763892, 0.7986014092000636, 0.6824184167332763, 0.12338413167702722, 0.661951750958348, 0.664010042787133, -0.24680331097169927, 0.9332493199677119, 0.8633175859370092, 0.44275925722499215, 0.9052837825833394, 0.4334225669095995, -0.23319269826476952, 0.7820986163361828, 1.00195662698001, 0.7823751018121533, 0.6743675658295097, 0.6838448181388553, 0.8785213953065973},
    {0.6314876182877092, 0.7942614377098033, 0.9187772160439099, 0.856304028450494, 0.9031138249856827, 0.3747627857417375, 0.6239943495418865, 0.7512975743682488, 0.26565421554090146, 0.5150962518669576, 0.660304020623714, 0.8893598658860468, 1.024280242984393, 0.8010135597721467, 0.9263339496879247, 0.8627930748757972, -0.20616102615596416, 0.7206270622063534, 0.9401010557652802, -0.19857486826371892, 0.9836664729459786, 0.6336391503736516, 0.5659600215274454, 0.5651914357572185, 0.4426950965895677, 0.10798099894723483, 1.0303641190469128, 0.8611825437911852, 0.6007634882846152, 0.9721668758364777, 0.5907289174568187, 0.6078583697499589},
    {0.5891547909555449, 0.5465933672082482, 0.7100236438966208, 0.6018806875449547, 0.9283192062329996, 0.3397480219983623, 0.5990271715983674, 0.7673003079583788, 0.5722457278582316, 0.43716259182238015, 0.6546387204793346, 0.781397213468702, 0.5340214158423583, 0.6941754934384045, 0.6041364799536381, 1.0155059838026768, -0.11344229147220797, 0.5378432746602293, 0.7461312352627112, -0.15898044200201278, 0.8364131291161477, 0.6915492127230406, 0.7437611563971553, 0.6727971920925248, 0.5488886269926317, -0.23575837705274508, 0.8071522546440929, 0.5167756210569698, 0.8242243009453875, 0.5666788945619339, 0.7908568620238908, 1.0227178128096839},
    {0.6548842347230069, 0.7605626991422344, 0.6225888869039877, 1.0077129510930565, 0.9671729110758549, 0.6024623122979755, 0.728321620771855, 0.7188288830161312, 0.5625608406206694, 0.5503672649498071, 0.6877549164342288, 0.9916722448988253, 1.0179758482952181, 0.7798369428127302, 0.7921538173934382, 0.748857245355316, 0.08821236861446795, 0.9646257075738208, 0.9316505676821176, 0.17197249801540435, 0.7994906482149096, 0.6316463848231018, 0.5905038392951087, 0.7615298226375196, 0.49489291048042394, -0.2867979985369896, 0.8280113831952116, 0.8376034463216537, 0.7368954223715596, 0.6232766229929757, 0.9548130296743634, 0.8719301557908697},
    {0.9813972393915712, 0.8051207371041273, 0.9265538866991386, 0.5277716186044847, 0.8861640329701874, 0.35023096460145325, 0.8948181385523263, 0.5688784634582813, 0.15589475559472132, 0.5692440798548939, 0.9514309130113502, 0.6565228473719347, 0.8266231351269574, 1.0028117873537385, 0.6066857240267555, 0.9437266305958998, -0.1880886234675318, 0.9283316406317499, 0.664967735212401, -0.21908551016865294, 0.9305882017861902, 1.0145951830843913, 0.4838320940964031, 0.6747832973564323, 0.5602849604755971, 0.09245158965379831, 0.8039401460584573, 0.49016550054794855, 0.8708745216385754, 0.6830546411559115, 0.9220378919177543, 0.6073037600059027},
    {0.5964702387718668, 0.6244923292723904, 0.7620036072713614, 0.8867149286975444, 0.9915110042215312, 0.4024617308581838, 1.0705019069275357, 0.7328157704724411, 0.8032688151446107, 0.37075869426389974, 0.8809538740499611, 0.5342592733128153, 0.7828367891044692, 0.6077541820089208, 0.660105652509533, 1.009027277230182, 0.030151680456031477, 0.9345597928197273, 0.5895749965111211, 0.026484185598574534, 0.5980582838883567, 0.8929271896899947, 0.39722354610632493, 1.019536731638034, 0.6176502855910426, 0.06486265637803346, 0.6668897087241152, 0.8969178436349525, 0.9503047451902983, 0.6196291493294576, 0.6854660986842703, 0.9326303805309878},
    {0.8463350561784405, 0.8405330815567463, 0.8219572010514371, 0.9856142417935344, 0.7648922384521807, 0.631713940234021, 0.6398018050173083, 0.7358717716834404, 0.3460967979091974, 0.5815945420607724, 0.6252121448949144, 0.6254852377822362, 0.6847176588232264, 1.0097319630940405, 0.5918979159791118, 0.7656405421082513, -0.18155098899686117, 0.6216327456247066, 0.8891227856512445, -0.185495807966388, 1.0227727252435916, 0.91556233372145, 0.48395201784686825, 1.0527959002588043, 0.473439662324488, -0.26239537152308995, 0.8129858253223337, 0.9488827806856918, 0.6862717267929664, 0.8435975519244474, 0.9601747841032646, 1.0353442005555622},
    {0.6430292088942096, 0.7815206237444982, 1.0151026465965662, 0.8723869145994181, 0.8779400782881652, 0.7052699115914942, 0.7858318289630163, 0.7102124296293258, 0.3217518407698154, 0.5747815002275328, 0.6973122448017922, 0.5607426109453785, 0.8014208496033007, 0.9716986599133369, 0.8223003453554654, 0.6820561188619217, -0.12404972931052163, 0.9729559500013567, 1.0282532323869158, 0.00030402698482565483, 0.7948775632479553, 0.6660722342992884, 0.6457982717387524, 0.9536503099766372, 0.6676540684404789, -0.28357132710649985, 0.9509279989901281, 0.715550137810596, 0.5837130481840757, 1.0253076094814424, 0.776881149214963, 0.7924219744165213},
    {0.7124498105103974, 1.0259642557935087, 0.5505484868385083, 0.8086411637952143, 0.9454597394765579, 0.20019930142982617, 0.654132537924545, 0.5019468617719942, 0.44470509637001965, 0.14631929864477358, 0.9861791360818442, 0.6679765764583707, 0.9225649717704549, 0.8159564839506801, 0.809860078035755, 0.8538971071186741, 0.013931766553138079, 0.596607031598043, 0.7270710414152438, 0.21361440778829865, 0.8882243815261515, 0.7005517363244584, 0.2588872572761057, 0.48569494410547204, 0.3066053688043409, 0.0452435199090661, 0.8627588299505644, 0.9406143813194486, 0.7882199806374305, 0.713269658133204, 0.6330545630858491, 0.6621238816864983},
    {1.0038864892039197, 0.6558420601133197, 0.7826311222562985, 0.5990934453213519, 0.8479048269336654, 0.3916094303477404, 1.0215079100066202, 0.766991875042628, 0.2770007104839442, 0.27800007217642386, 0.5799111214112578, 0.952143895212531, 0.5892686979141433, 0.5766128222250329, 0.6956126881679038, 0.6709101262250745, -0.09717002050174639, 0.9157606292904884, 0.9308036005808642, 0.02404761187631339, 0.8782384332033699, 1.0013110415203956, 0.5190853138553144, 0.8112366684355511, 0.5271989147163627, -0.07213896624617079, 0.676389350370407, 0.6144334478830115, 0.807913606515492, 0.8449435592789916, 0.7474223089609444, 1.0388607811695967},
    {0.7649191000017291, 0.6392270040506887, 0.6399703595127344, 1.039397208311933, 1.0423857998484405, 0.5387574572049211, 1.023703397735186, 0.8729929123115204, 0.8669336281072523, 0.2608710698933748, 0.7451165272868009, 0.9080130755972237, 0.8092013156492469, 1.1127752392607504, 0.7925794830451566, 0.8808427967016138, -0.05398769255398083, 0.7355091028515099, 1.1042336267851873, -0.04204192090100632, 0.977797711794245, 0.8062927276027892, 0.547123417303718, 0.7209610469685497, 0.3596136631131242, -0.23343174233000516, 0.6405951164323428, 0.8858983779331898, 0.9980250715789267, 0.7302042419860654, 0.720442047057201, 0.8259816359518656},
    {0.9086048210576149, 0.706257181702774, 0.7360660292429181, 0.7302140792866009, 0.8130802353914408, 0.5211239873962491, 0.6859923374012915, 0.7758277919651284, 0.5535529281971472, 0.34449035790016164, 0.881998777315125, 0.8028953533141854, 0.704261054579828, 0.7890156190072882, 0.8882927649084275, 0.6343720497583596, -0.0781708254807544, 0.5959432386723563, 0.7456770922818984, 0.02336154620317334, 0.9745350364064508, 1.0015359942343995, 0.7554359641987828, 0.6283532773023295, 0.511057685443741, -0.056575324741224606, 1.0770653816635993, 0.9307363378636879, 1.0457416258107022, 0.977614922415379, 0.5707013259911342, 0.8308751893669074},
    {0.7146013113188076, 0.8601887139652181, 0.946964130057068, 0.9122844694623091, 0.7902613099613441, 0.4846785541516569, 0.9944661777352548, 0.8421225736293592, 0.5498432743007693, 0.38106002370463476, 0.5991713848324484, 0.8223420214336532, 0.5955247270810006, 0.8890715221032995, 0.6240682597101053, 0.9327316364882836, 0.0373476921968881, 0.6560918927351337, 0.6194224247610671, -0.0856434966442032, 1.0202264928048568, 1.0887463364947692, 0.6997314544654635, 0.8936615139802585, 0.7279195169435274, -0.17207278580869712, 1.107260861553887, 1.0113493545027654, 0.7558860606469974, 0.8602343371038232, 0.9073312246161104, 0.7271155139645521},
    {0.7403481923679445, 0.7450337470112828, 0.8337080780602772, 0.7836342040680568, 0.8350433952347627, 0.6900889594226248, 0.6454349214157751, 0.7205908351099425, 0.47737926425159444, 0.19566626682136992, 0.9143227589607262, 0.5437345513877818, 0.8040628876053802, 0.9097107224863692, 0.9595476621254642, 0.9853711019295955, -0.15591670540127714, 0.775709403643189, 0.9179013573301837, 0.012786137647376699, 0.6610258987246246, 1.0439779337443216, 0.3461646438888488, 0.9136343266355101, 0.2663351093995411, 0.014367023528327924, 0.8244045054227306, 0.8762925868301844, 0.8747372939202985, 0.7075405678800887, 0.6140379700193566, 0.7788923725493567},
    {0.6073421285618762, 0.9549773948321505, 0.8297790728148559, 0.7982895158082094, 0.7547688420626193, 0.23184811576393174, 0.5879181593509034, 0.6764095083832572, 0.5562361946382888, 0.23955073161469356, 0.863363643836104, 0.8147609216417465, 0.9627791331239325, 1.0129693960894552, 0.8342982939168427, 0.8677946218666365, -0.029116697398792333, 0.9669232954515824, 0.9639827679215712, 0.04170312146306204, 0.6464373015577372, 0.7277293027210314, 0.3536526065410702, 0.6585628843056496, 0.70968003808674, 0.1624455291402834, 0.6390274365007433, 0.7590363856108431, 0.5910220721678598, 0.6825254839776991, 0.9819192284776276, 0.7200345361605918},
    {0.7832206612646977, 0.8546590477040159, 0.6628807298769142, 0.9762427383839872, 0.7489564512307673, 0.19768538148281525, 0.9553922315121294, 0.5419893958392208, 0.4750165177595463, 0.6047638048215576, 0.7141785740867578, 0.7328847725808489, 0.9726373374070861, 0.5603768301812296, 0.5212001033124852, 0.7254421496959497, -0.014474316117014269, 0.8666268115131548, 0.8080236915382759, -0.23326374601972813, 0.9818655398091736, 0.6744756698237129, 0.4302770200570973, 0.8282886055225429, 0.4269904211733711, -0.04362427623165679, 0.5982877069377246, 0.8036995279398417, 0.7859132270629752, 0.7798902935551313, 0.8171106987385591, 0.8636217274463098},
    {0.8899810959435348, 0.9938008768835743, 0.8170911332563193, 0.6388075188423687, 0.8414070155987099, 0.5355045100161732, 1.068528941140523, 0.8912657988455078, 0.4461820035566147, 0.5137685031759214, 0.7694210138276915, 0.7203403486966565, 0.9392725670761061, 0.9017876755503337, 0.9896673051698729, 0.7322392758447975, -0.14713961205832943, 0.8752221775693676, 0.8474851867181468, 0.07698811400676217, 0.8782534605195141, 0.6489619519066173, 0.6565361059635638, 0.7289791306385709, 0.42111702771025095, -0.2114843932484782, 0.8550870122018133, 0.913056297058528, 0.6421186365398698, 0.767587584977342, 0.9547414898902358, 0.7838753932647803},
    {0.8733478368603687, 0.85903390214276, 0.5792690490255661, 1.033866264457305, 0.7280378529799018, 0.473605026942493, 1.0519622964806694, 0.6067541278305967, 0.48389758966333063, 0.15084225302149692, 0.8909785822069681, 0.5197361108691627, 0.8339759388072999, 0.5965650948876479, 0.7237072440953461, 0.958685897869558, 0.03987164324899444, 0.5626489966276168, 0.8268629990645691, 0.02523285252165764, 0.7440588645894967, 0.7252617093546286, 0.3768933159731164, 0.8427792117049665, 0.7412341933215295, -0.11413919844096364, 0.8298393864270962, 0.8189021255416324, 0.7125275110590086, 0.8581215652032742, 0.5461096482059103, 0.6431156929148069},
    {0.6882556959045506, 0.9914640216180138, 0.6897224278232849, 1.0422329820773246, 0.7791392490263027, 0.4847535074284333, 0.8927316263790904, 0.8258980052737858, 0.460433137259245, 0.5011362394724539, 0.9480868649942414, 0.5782788956959093, 0.8963606546246036, 0.9310200596825265, 0.6326904620321834, 0.9654359886978705, -0.03549084698420755, 0.6846248833514862, 0.6184248707643621, -0.10743528656899413, 0.9371883604524837, 0.7815726337367532, 0.3540606292509388, 0.8655600876597092, 0.500130010845601, -0.2983301546230863, 0.7954964753850854, 0.6963470606017949, 1.0313028852288795, 0.6751982684893961, 0.9824866967828444, 1.0722230198545193},
    {0.6967572586361954, 0.568193050152384, 0.6337657552338003, 0.6209198420380262, 0.7155518379052236, 0.2385890818288057, 0.9544278747744774, 0.5249222011932778, 0.668125377187875, 0.5105209260652667, 0.5229068677549458, 0.7785389248236388, 1.0085086317918666, 0.8136630001434362, 0.7047351609953869, 0.562920945806546, 0.06639226645897721, 0.7060128660206721, 0.5639927134564006, 0.08244289472307549, 0.8405623821043557, 0.6692250563675127, 0.5374880845393677, 0.7603470377263322, 0.421856453904683, 0.08378014903334997, 0.7436434075705713, 0.5961012887905881, 0.9386050855233785, 0.9582807895004045, 0.5673486224339218, 1.0599552554398077},
    {0.8005829031158902, 0.6669320585135793, 0.6777857046895103, 0.5961125640843695, 0.6238794427035146, 0.3896869630326017, 0.6582934275583515, 0.6217681405777508, 0.44213114083063404, 0.34259839637729145, 0.7823145083479389, 0.7876979731289028, 0.8022781844103574, 0.8034624160729941, 0.9637333078351782, 0.8622994939683694, -0.00032384210058321403, 0.9659672293611713, 0.7405095266612842, 0.042437742914622496, 0.6829065460025975, 0.9475870236984193, 0.3161123195087215, 0.7009046141752558, 0.299179999380185, -0.2347111811038472, 0.9422062202435755, 0.7429104260249273, 0.5643401654315221, 0.902904642074602, 0.7606424690885865, 0.7151308150756852},
    {0.8697741721396838, 0.562417951832876, 0.6468076824202339, 0.6324914512029994, 0.7853412191842227, 0.3965822778818898, 0.617953312849923, 0.5578766658757477, 0.49707396776432783, 0.28203892825050525, 0.9651936001992865, 0.9610503846209316, 0.9494252595009716, 0.7193477499907422, 0.861240325800837, 0.66107111340674, -0.15759845093178063, 0.9515907123865207, 0.6738475949817451, 0.18953236526098302, 0.8150869471790168, 0.8528885596524697, 0.7404038090379396, 0.7636997552469792, 0.4756575250832425, -0.011857010605741111, 0.901877142113425, 0.7088202576494286, 0.678297179269562, 0.5819033098361728, 0.9060493267379299, 0.8192868673040914},
    {1.0035060456784552, 1.0116259961044742, 0.5618759947168939, 0.7952026139957001, 0.9872116624570427, 0.6558869961682068, 1.00667452876848, 0.5159506748747683, 0.2315476219330435, 0.4611261073853211, 0.6412596793566658, 0.7010273478145777, 0.9833292257162826, 0.7692751388400266, 0.9210024575709902, 0.6718419143287455, -0.062876473967903, 0.9042899034430244, 0.9135197982256023, 0.12773025993066367, 0.8250458007631529, 0.6032706981782032, 0.5020786337540033, 0.876341362179157, 0.35905839321995076, 0.06332377237392216, 0.6826097938376644, 0.6695881028640076, 0.7198578298961709, 0.8846242416034998, 1.0026647962303283, 0.6096864681408923},
    {0.7859269678963247, 0.6315916107576687, 0.5686571438922624, 0.8644007546923445, 0.7991081305051076, 0.22361238202097708, 0.8071610290844954, 0.7518150300427562, 0.6820427194113139, 0.1838356612551035, 0.9544304061217824, 0.9176054400320784, 0.88796871983286, 0.6399602013542719, 0.8185265137373826, 0.7993393415238224, -0.020125586078198903, 1.0269059783547043, 0.5678626412445236, -0.1223950593412855, 0.8603582434211405, 0.9071702947935103, 0.541850526865745, 0.6277208076948099, 0.726043430215551, 0.09852807181299506, 0.9167866235008034, 0.9011351402760968, 0.9135145223721639, 0.6581155734090091, 0.640752030647769, 0.9972039095837436},
    {0.9364515227135586, 0.6631900521132825, 0.7016683581702462, 0.6209518020724024, 0.862484370852909, 0.33538671857703717, 0.7830181202823954, 0.615631981973052, 0.33131867490855915, 0.5923883364608712, 0.8347369048088518, 0.827853480005531, 0.9774536916853469, 0.817204355120115, 0.9112415542685957, 1.019501058289538, -0.2092639482526856, 1.0140054705331738, 0.7605231327456046, -0.0775315622844625, 0.7079229409135592, 1.0019288406965847, 0.6973754715228768, 0.8287596734680922, 0.3562212622726256, -0.14475082382220678, 0.611758020976029, 0.652712986572969, 0.866166655615265, 1.0030321550652819, 1.0008467434999844, 0.9390153682644173},
    {1.03384045392769, 0.8773937895378994, 0.6763728390066088, 0.6605997103693887, 0.7887015288692969, 0.3129856192891522, 0.8878210927806842, 0.5823935266136389, 0.5118215154601843, 0.4938895790598912, 0.720621501542119, 0.5427552905910549, 0.700355137102436, 0.7890806965780626, 0.9590158156163063, 0.9389719492008115, -0.07920307040413695, 0.8367058007344949, 0.6575632938504694, -0.022353419220219453, 0.8219452692054559, 1.0680721825463788, 0.6373286060535426, 0.8780536971172853, 0.7419819816880029, -0.06867963875821441, 1.008906483949373, 0.6945135854613823, 0.7270224867118308, 1.093870406812235, 0.5883701141835462, 1.0476544050348182},
    {1.027923352501938, 0.9033875585619332, 0.8952883641838861, 0.7180002951630388, 0.6398204036373708, 0.6439457868029235, 0.6128965585304087, 0.8036637767127081, 0.29882488633173504, 0.5141717833892807, 0.9022547359602804, 0.6101133599464618, 0.8731517124511265, 0.6988856655915672, 0.8768965382158375, 0.7816219356277397, -0.007865979326601238, 0.7912388064973945, 0.7252895219387014, -0.043183846400116646, 0.8853609052370924, 1.0011979572086567, 0.45975742205747716, 0.7434698086870695, 0.5136447688637094, -0.05265507700628576, 0.7386948219329648, 0.44709081137326995, 0.9572727337397077, 1.0181448151428287, 0.906227938628512, 0.9003945532997122},
    {0.773089636135918, 0.6071820807118296, 0.6170751299164292, 0.5600375250460918, 0.9299179313850692, 0.2773461587227097, 1.0589115296374632, 0.8676233736751334, 0.30421887861663305, 0.4786593705924432, 0.6190402868103372, 0.8834240334507704, 0.9972319760589481, 0.6201499018348615, 0.6131848173188754, 0.6870719198320502, -0.21471016357805497, 0.7479917225890679, 0.5988292691737167, 0.09205604268390505, 0.9360153188322851, 1.0518373677529458, 0.30383389221106044, 0.4922693146066765, 0.4067444656332485, 0.10254966169916313, 0.8341119309112502, 0.859374516541672, 0.6000745941682962, 0.7071603804338048, 0.5410867134667467, 0.9591942202960009},
    {0.6968957278026114, 0.7977105216034348, 1.011822080293035, 0.9943943525917792, 0.8985581815696078, 0.6389423692946727, 0.729260199573922, 0.7426155920388448, 0.417227975923997, 0.47902595917927593, 0.5801516085856537, 0.5715927936914439, 0.6463706957723764, 0.6602272422277223, 0.8052819426506201, 0.6416965232497422, 0.13336753840803897, 0.7169830804991426, 0.8409500514399683, 0.005250297045878807, 0.9904108523347825, 0.6301425937111607, 0.640693551401394, 0.8301708557542768, 0.5200737191019519, -0.057095999416649744, 1.0637798146730357, 0.6386326273649411, 0.9487172993252335, 0.5963570654416321, 0.9980727733057431, 0.627881208431083},
    {0.6935082464420071, 0.6140500545357365, 0.7135546400230379, 0.971369922862436, 0.7203147829478285, 0.27577927965149557, 0.7527963383723049, 0.6300527709495608, 0.41948904417515387, 0.3001069910734021, 0.7064379039738966, 0.5686542708084065, 0.5780088126515079, 0.8570674327597283, 0.5530435411542591, 0.9354918318576435, -0.2273721703902232, 0.8364084801380095, 0.7467438243061942, 0.04189329448927161, 0.7472105361212792, 1.0336621903281427, 0.60059391743905, 0.6454965665324317, 0.7159387557273497, -0.2486688611718067, 0.8019434837327554, 0.6290289701302556, 0.5717031143206955, 0.8528812399561965, 0.8561562744919949, 0.8020124170873837},
    {0.9616155513930629, 1.0022826487646022, 0.9762416270832418, 0.721318195159111, 0.8636673199486582, 0.47790298265827275, 0.7464106872274058, 0.8043190160615784, 0.6709928036466318, 0.3653072776250036, 0.8446840431151101, 0.7309562226805288, 0.5510515221204402, 0.5877320048211179, 0.6764249746902586, 0.6381838153932731, -0.05493308147588372, 0.7243496453482091, 0.7808066464312946, -0.2426882597458949, 0.5976713449293712, 0.8435297901311878, 0.31876036581840184, 0.9942084103533131, 0.7216052129368273, 0.13466329493501225, 0.6436701579417965, 0.717768689535703, 0.8974301405230812, 0.79621837384855, 0.6328194657697218, 1.0644825436493208},
    {0.8323107512527278, 0.699235161949875, 0.9901900074318689, 0.6161938021133222, 0.9885042446669694, 0.6176202302995173, 0.8026719141938006, 0.8476404671353708, 0.45682405983501323, 0.17685858352521794, 0.8581697423282705, 0.828213615124245, 0.6900935855926914, 0.9981122516617056, 0.557620214398914, 0.8760511086815976, -0.0008668180893426381, 0.6259665217606228, 0.7465624594773267, -0.2614823998527131, 0.6340844790890824, 1.0366822828779516, 0.28221238781771346, 0.8043543378970592, 0.42526577309025465, -0.0894503971170391, 0.6904855832313942, 0.8666108884709829, 0.5500412086580702, 0.7674608566805703, 0.7170445257771526, 0.5847296503217565}
};

static const float b2[32] = {0.76203283565791, 0.7729742511712628, 0.7545591741292041, 0.8089246217569677, 0.7295909435782632, 0.47961715165738944, 0.8066845521942493, 0.679109221083708, 0.5682936702183906, 0.4456995611396589, 0.7792227313578312, 0.7333940450327163, 0.7772789371398372, 0.786351502808608, 0.7396065656077063, 0.7462650783072184, -0.0422117551213212, 0.7594979461408036, 0.8287632072851441, -0.0495654421121967, 0.7220275891431859, 0.7796624515139786, 0.52913673927435, 0.7181836373369946, 0.5657726728448995, -0.08867791274020759, 0.7867562077212432, 0.6820457168233325, 0.7869287695718923, 0.7611757614952429, 0.7568393794747414, 0.7936016509340571};

static const float w3[32][16] = {
    {0.9815849066763113, 0.7566664899446099, 0.7319015353892896, 0.7994220142152018, -0.3530497922486863, 0.5683870986696875, 1.0055466518931329, 0.2040386143389875, 1.062672653243837, 0.9072990253979862, 1.0252333022437548, -0.13159473284174078, 0.7290388332661467, 1.1130794633444951, -0.0815060039005071, 0.8964527678561842},
    {0.5327082700032278, 0.7707552510349851, 1.0888899094779323, 0.9165508303092924, 0.14580313332821077, 1.1015537509756, 1.0223449025661229, -0.2960190975453741, 0.712103928987163, 1.1920282108298226, 1.0754819055457607, 0.09639600710625149, 0.5432850758164343, 1.084753520268494, -0.29202978178120725, 0.7818373179456932},
    {1.0376203984591923, 0.6727493968455429, 1.1050946379931117, 0.6255157637580904, 0.2019415402872093, 1.0581375878338903, 1.0730214611406999, 0.005963111597281134, 0.9616800467478427, 1.078282588215873, 0.8012002958486488, 0.09677888623253011, 0.9704970933410026, 0.5913936327649049, 0.17569871573549226, 0.6508542467544165},
    {0.6052651423362898, 0.9933571484338404, 0.9234037460318949, 1.075935271398025, -0.37543404630802063, 0.8607155048257407, 0.5656333959788751, -0.09095355470329243, 1.1644117000316445, 1.155007547048208, 0.970812944866359, 0.09609724955368872, 1.132842559356658, 0.5490479198647452, -0.018266071922710934, 0.6308833847429427},
    {0.6569283834846603, 0.9993092650382981, 0.6034633733247143, 0.6514746238594606, 0.11220775891170068, 1.1630094841233154, 0.5481362610471171, -0.32508279671347273, 0.9749979599009306, 1.1838933246371972, 0.7139251445916002, 0.22915249247417388, 0.5920068184778142, 0.8631843596232738, -0.19652071859204442, 0.8263621020145108},
    {0.4077596683884188, 0.7069107934111767, 0.6388873456203285, 0.8221751600228112, 0.24606710597069553, 0.7870866360207377, 0.44812264122277917, -0.15932934083136366, 0.6370897432925335, 0.36428834567969376, 0.8404168593429971, -0.15548204459150192, 0.4478855297313308, 0.5021333878699047, 0.18400150394782844, 0.5766110924655611},
    {0.8904434433665445, 0.8200397919366793, 0.5094743423359641, 1.2012991993533977, -0.3576163075313092, 0.8563944223134595, 0.8501278547511061, 0.20167859778591093, 0.8264830948290613, 1.1865372283045625, 1.0649235242229604, -0.06856880224162426, 1.1649191752542571, 0.5843377964814038, -0.29332148805726477, 0.7401321717746},
    {0.927554332343719, 0.6625224382827668, 1.0767679522195845, 0.5505188112974629, 0.26031479204008695, 0.516788768130951, 0.5988331085140128, -0.2586871396163421, 0.837457307969529, 0.6861696359872341, 0.9920165131398464, 0.03386835055386097, 0.9823754071160877, 0.8658129040319845, -0.3323917283772592, 1.0674335128099672},
    {0.33783376362989426, 0.6530061440572804, 0.6302907278736267, 0.7810917588576144, -0.04705052692414654, 0.6724737105693135, 0.4281885831850758, -0.3140154355625878, 1.1568594633284084, 0.5929933623391753, 0.47460279935703015, -0.04644492773748589, 1.158229591100192, 0.8936721765792042, -0.035457535866734065, 0.1842735251595027},
    {0.4413269865042946, 0.8168055841184373, 0.7666727401063582, 0.9162852932345581, 0.057834948201740344, 0.22095899199136332, 0.4117778770876807, -0.11776505092615121, 0.30102643414869323, 0.316634964527277, 0.5192821754839386, -0.015761772652023155, 0.39805082736953223, 0.9105288000360074, -0.2245001960492787, 0.7325152619995327},
    {0.7113740040959269, 0.8232757498689126, 0.8035557317570909, 1.14414886407796, -0.03989351983321501, 0.8654791538269294, 0.7745672396889491, 0.2166341533804291, 0.6707445516312518, 0.9718597952605429, 0.9965741017744342, -0.2850180243978819, 1.1519771684687714, 0.6820506740676793, 0.2315747273728232, 0.6395834362663769},
    {0.4803187386986495, 0.8101712995487366, 0.9953771734885539, 0.8086206738136124, 0.23122976607742854, 0.953507764421059, 0.93819641503511, -0.2599544557256179, 0.9921230061864005, 1.0787274589228797, 0.68071492004715, -0.2542104221844994, 0.6404677625050185, 0.5081736743180567, 0.24518183738468194, 0.8603138497923338},
    {1.1468275976830218, 1.04695931164017, 0.7767721667669479, 0.7693067725488741, 0.12034210692711388, 0.6434966617337741, 0.7008822581258771, -0.19248819539693104, 0.6404314832975148, 1.1351924973222558, 1.1165177051244364, -0.1721318085799242, 0.9910870816422772, 1.0093085144117613, 0.06158686166274072, 1.1340910815984278},
    {0.9165413113417584, 0.5997777662535825, 0.9836602683211063, 1.1843363294622944, -0.16258221765236988, 1.1551092798276645, 0.9829442982525657, -0.17215914979042313, 0.9244474214441338, 1.0081278154149975, 0.8935116792831811, 0.19685862833706352, 1.0847539060578744, 0.676253645665409, 0.2779733585330162, 1.0051699011241375},
    {0.9070881479988524, 0.4416149913120957, 1.1345953999749556, 0.5776311624352529, -0.04352726461007431, 0.5487139397162306, 1.0454988447437426, -0.21548230373416058, 0.8609047714914958, 0.54006408596284, 1.0106612599789537, -0.38465799160304687, 0.6504572491289385, 1.2209337988882885, 0.29348578736774056, 1.0214655199584823},
    {0.7647193986593577, 0.5131120989730849, 0.8207758268092149, 0.814940608609766, -0.047414084169120956, 1.1860852691236627, 1.183589060400934, -0.21923977835416042, 0.960231586277729, 1.139604175976483, 1.0098860436779842, -0.3259996785411829, 0.6974397243645057, 0.9805359424608006, -0.05330407400627409, 1.0566454775927503},
    {0.07093480783095409, -0.07136979550683654, 0.12330538951767107, 0.16455153319982227, 0.10798322570592485, -0.17846736504661678, -0.01929780647532919, 0.11237726844537331, -0.21687729427871924, 0.2653285496530708, -0.1513367513913851, 0.28878979458589865, -0.20695013129394813, -0.08639488185122486, -0.08710379652833179, 0.21121562722082204},
    {0.8775096374359856, 0.7529184255170491, 1.016287658768801, 1.2277551740695338, -0.26742226626978416, 0.9401308477932209, 1.1042537447419674, 0.07439669696532258, 0.5033347704418859, 1.026001956413888, 0.5332452551082436, 0.17570830848244387, 1.1329379652668201, 1.0509331118239522, -0.03108803273897803, 0.5223631236159892},
    {0.727405700843943, 0.5026767087914814, 0.8229431149700632, 0.6120000872329985, 0.16493196975786986, 1.0192432395978235, 0.6356922969234347, -0.09416358671483088, 1.0055148542089822, 0.7505008037847978, 1.0330675494758734, -0.13814802348899557, 0.7738685707176064, 0.9681126092335591, -0.34020887099393343, 0.9947699202636144},
    {0.18403596753450008, -0.25641941637922994, -0.10912545277820687, -0.04047488316280791, 0.11879118039006382, -0.04888146117333243, -0.10963269829725893, -0.14782646416343412, -0.0746738760454899, -0.2839927204386884, -0.041083171657272224, -0.14422121468555338, 0.16028113966434857, -0.16140441492364813, -0.2610534864380479, 0.0393145461856935},
    {0.6293029339970648, 1.077014620220708, 0.9485256347637995, 1.0804036834809048, 0.17334790817768445, 0.9533921502627317, 1.1966246234882962, -0.3365107317033288, 0.6159228956397896, 0.8284840149628795, 0.9626098354623331, 0.20236125167119737, 0.9707608574633049, 0.7391338558491933, -0.11856681413547537, 0.9927989739175128},
    {1.077096816326706, 0.8093559452636837, 0.655890544874375, 0.9627269642762736, -0.22828721550183928, 1.1061775282737105, 0.8472832998816365, -0.03085713511048694, 1.1454151026007435, 0.866991987014272, 1.0625500008857272, 0.1419360753029107, 0.7711550378068899, 0.8759562263805211, 0.18969916093001765, 0.490015125790082},
    {0.6435456169118734, 0.7631174440381068, 0.6266478489099305, 0.519899452529548, 0.2529969258576056, 0.8989460638548701, 0.5060742380906462, 0.020462075823098946, 0.5569280508358544, 0.9613105225706658, 0.8282988010727094, 0.3266350829002117, 0.4221690588623633, 0.5262756718380772, -0.29682916575470236, 0.5776104956525089},
    {0.901570940361607, 0.9916935079673009, 1.1572451576175464, 1.170011907030054, 0.2814445282024431, 0.724644977247612, 0.8810014819198007, 0.19993965173320746, 1.0569345961156995, 0.6492567223308218, 1.0525092959078857, 0.09107406620815789, 0.7251097487791551, 0.8781230498171645, 0.1458659516869168, 0.7325483074389674},
    {0.6666026795868202, 0.4227090183435239, 0.9567683748012794, 1.012702282408342, -0.05264749778377015, 0.6336359401709258, 0.6119469361484212, 0.09356013140886543, 0.7491505050854786, 0.3269462826033116, 0.8867014520636154, -0.018628909182449957, 0.8060924921801671, 0.45858701514974726, 0.26222728477038254, 0.5789197965015193},
    {-0.1536768736015108, -0.24756012656747903, -0.21569310581140008, 0.15203849262800267, -0.015321083428291004, -0.19739316593321662, 0.20128760289418315, 0.041394954029396594, -0.18587919209982326, 0.0010895174579650042, -0.04735399494362346, 0.21334382262960586, -0.12398193784250326, 0.07356382495073732, 0.27595909549496467, 0.08791106272383682},
    {0.9909612698613428, 0.8565909518885273, 0.6674629121228729, 0.7997864888001868, -0.18675670987809828, 1.2074099543886518, 1.1109424097085538, 0.2922290696231957, 0.9609393396372022, 0.8665893718185343, 0.9657281917862174, -0.26497858840983957, 0.6504682282477721, 1.168943178657692, 0.16378041473563396, 0.9544625169371954},
    {0.7518829110510016, 0.987015525399715, 0.8788032814581259, 0.7817578175273988, 0.13788623270244701, 1.1779797290738148, 0.5432062025646531, -0.053778529750776516, 0.9229705221498511, 0.78198763985265, 0.8054728825990397, 0.18996833226272675, 0.6119028037719153, 1.138797376288733, 0.16070699844987454, 0.7613091382158623},
    {0.5480525977290687, 0.7821825026211697, 0.6715173862730212, 0.9245805533499459, -0.1943816741546902, 0.7943755184293845, 1.1344516353030434, -0.20613071183127749, 1.110300791342352, 0.7428813741995312, 1.0947855088171206, 0.2800090083253598, 1.057283771528101, 0.6845075069027277, -0.05302741067398195, 0.4687071135470007},
    {0.679081032032452, 0.8418578628550831, 0.8121326484455824, 1.1242951773327174, -0.20377440636816485, 1.0912485045343845, 0.5038249252768386, 0.19865141607950393, 1.1530094610573625, 1.0965502537014498, 1.1594197640947814, -0.3026814311191886, 0.702066250738987, 1.1982809165495252, -0.3627891001982181, 0.9700482525776559},
    {0.7948203565773916, 0.6291920449311632, 0.47546260368279913, 1.1585616503559184, 0.1298455401466666, 1.112077876179272, 0.7706006894670312, 0.12408117165147668, 0.6412265256246409, 0.8153870219119291, 1.0743980942074092, 0.09908604767500553, 0.5040382176113273, 0.9239956898926436, 0.01376236859936209, 0.8238029677119507},
    {0.9040019315787963, 0.8199296263067694, 0.8214217563552575, 0.9541494723242641, -0.08744028764077146, 0.9134957005872206, 0.7970111712833591, -0.3337564316964814, 1.1184900695305782, 1.0489055292953846, 1.0336186973405184, -0.037991303962698064, 0.5834496900237308, 0.9862300747473929, 0.06303065049821298, 1.050732557531423}
};

static const float b3[16] = {0.6012406701699173, 0.5173364714448647, 0.5826243713741367, 0.65680441305116, -0.034969517661915604, 0.5732640856799004, 0.5762393500607738, -0.06275669183335832, 0.5527176999466481, 0.5564408163629209, 0.5870633579544903, -0.045723815446760505, 0.6054063327575673, 0.6019016981808383, -0.02936797891798031, 0.6019835928238777};

static const float w4[16][12] = {
    {-0.5411234603918157, -1.122493787076525, -1.0761493974290466, -0.2859510073954283, -0.598744237052239, -1.0912429520043994, -0.6616734227006597, -0.5645350108392859, -1.0788679620955213, -0.4538758342476887, -1.0023747336564042, -0.49543131365117427},
    {-0.6854409535747327, -0.18325163626328272, -0.9164230477620637, -0.6593813494127814, -0.7945309079166468, -0.2689934622801513, -0.5539461473587745, -0.7952600923706017, -0.5100578929345926, -0.8410819745447294, -1.029609975537518, -0.5833429612742164},
    {-0.4311773791977049, -0.2653888073507024, -0.469218672373686, -0.6393413380440123, -1.1482467358509854, -0.9310164764879171, -0.3347398281716485, -0.5487576231565785, -0.3502335540567845, -0.9246907718366152, -0.8582171829973083, -0.7085956327064673},
    {-0.6616774443230954, -0.7300473305220131, -0.38268115181543894, -1.0232912866111057, -0.49606860763821353, -0.8337623381211556, -1.0511928253960585, -0.8450836130704539, -0.43000958099748093, -1.0955807661564956, -0.7799897567793398, -0.8035510993280899},
    {-0.33183826372955155, 0.4146791220995161, -0.1548364748110651, -0.3189631950778807, 0.41525260292556326, 0.33783827613462203, 0.3185737949130724, 0.16965371896637957, 0.24067196790003798, 0.25420001785772134, -0.42405977138021816, 0.2573716604563638},
    {-0.6011676859348545, -0.9180598823049713, -0.8711024041690055, -0.8418963950348218, -0.5957671775820031, -0.7119209568650949, -0.45440566131772825, -0.6701646315322671, -0.45431283209960815, -1.0173148305031348, -1.0421471182771955, -0.5948675564672353},
    {-0.8517236229363241, -1.0744211423931391, -0.8546518898201034, -0.8626612880264132, -0.5915196092213916, -0.7136458318537611, -0.2946968475309557, -0.8522874755385947, -1.196448070113311, -0.5923599681444801, -0.23286950416531588, -1.0865253022106094},
    {-0.27364058649508227, 0.31923892369258355, 0.1550739011825737, 0.18680778540576626, 0.05453291599500005, 0.05674195011411137, 0.23592095367904858, -0.02510607019596383, -0.1884517216297612, 0.04424822197443459, 0.18463823275080712, -0.14686701129759486},
    {-0.9236905623743132, -0.7836979376832038, -0.32758138710156204, -1.1060479949155817, -0.6906010991919554, -1.0031699380753558, -1.1997821676243812, -0.8457046914805927, -0.5520124786188819, -0.22289748591563738, -0.3280618600985497, -1.1988944876251135},
    {-0.7137762082762901, -0.44939475196197715, -0.9059378433551316, -0.3932050357015337, -0.9439844641415561, -0.2437167351682102, -0.9572878480986757, -1.1599369532887414, -0.5022320647388826, -0.6281516392255924, -1.01872617843357, -0.7614998314045561},
    {-0.831925820192702, -0.7395983395488468, -0.5701308422777043, -0.2845064208337577, -0.8301002674386445, -0.6172382139873203, -0.5362626121676862, -0.5241080071938108, -1.1844478778179917, -0.5912668210247729, -0.8094231261468913, -0.705042773616731},
    {-0.3965988397945393, -0.06574405889787713, -0.48147489064054305, -0.0716248682524529, 0.11740307075385432, 0.36424996217493943, -0.4943725011760367, 0.23289174110740454, 0.1753314073998407, 0.41581168480547037, 0.3625752223468203, 0.09769324381483206},
    {-0.5423678123614261, -0.8918238045384559, -1.1016043296902591, -1.0416344968151028, -0.3390549325555724, -1.1710241015603031, -1.1839237790450414, -0.4503450427800299, -0.5468710354964024, -1.0664490410460687, -0.5711866816971541, -0.5093996692252167},
    {-0.9703875046943706, -0.8811960145395287, -0.962280405399807, -0.5941753169618749, -1.029390851594774, -0.2516788275654678, -0.8919213702568705, -1.1553346100314459, -0.7582210442346534, -0.3107785310757529, -0.6637477355739644, -0.6198507294871202},
    {-0.09404063707540306, -0.3579272945888475, -0.102976634003674, 0.11979609362656791, -0.08102743233310503, 0.009047541200308942, -0.5213551495785769, -0.460282018988601, 0.33336634773568086, -0.06588576848325778, 0.2568274983445729, 0.3973871981395069},
    {-0.8967916766568881, -0.7646939035851973, -0.3826207284908199, -1.002250947541176, -0.618538346007004, -0.9728238060257052, -0.5305691163098524, -0.24729733844828206, -1.12824869591097, -0.9881481780705319, -0.3927084666249008, -0.5567316576080998}
};

static const float b4[12] = {-0.22011483919537667, -0.2959302082473837, -0.23532126295578132, -0.18963545249220873, -0.27122145957294236, -0.1572832727305997, -0.2998468074918165, -0.22681548432070883, -0.2562568916700066, -0.25241192997757383, -0.20534166541310725, -0.34031368049255317};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
