#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.28096294036748687, -0.337523151057389, -0.25110744357517667, 0.5985900940000913, -0.17473961454748238, 0.46360778574022027, 0.3239216329895756, -0.3183704245686012, -0.1359443237758455, 0.23236163552337985, -0.3530448262170621, 0.5695698876544683, 0.5720311549275167, 0.23158206343153104, -0.16158606796788505, -0.0005362735463069162, 0.049606939973513585, -0.21963148340984395, -0.18296203053511523, -0.13308872413903375, 0.026955535803871705, -0.426405991108794, 0.8048730747468568, -0.40844157243438906, 0.41719370493911195, -0.2630086399172813, -0.4466758069404686, 0.44565480804576824, 0.666084046765746, -0.5256538172662758, 0.3831706530579899, -0.007193862336966059, 0.06120638802203884, -0.18428552905596107, 0.5105021592144204, -0.04199382622579947, 0.6062211077433539, 0.542088418465542, -0.590806929174791, 0.6646046533675753, 0.10504461026971937, -0.47083982423203324, -0.3323264308703397, -0.00027113270733427356, -0.3969129179973132, 0.31425319281748126, -0.3126870747774327, -0.08283502269454836, 0.5187169856297007, -0.6071170845468116, -0.06745883274875838, -0.03887621477246319, -0.2307349802498581, -0.43888389740534367, -0.24800522045247067, 0.08623260743600926, -0.266475230959569, -0.47443535472261156, -0.5073175599489934, 0.30339983100803863, 0.8699075992646524, -0.41567052588375786, -0.31155061223837927, -0.16773583182774707},
    {-0.48877716369153146, -0.5505711452244448, -0.33145778095177214, 0.514692803425204, -0.4514130709821811, 0.4321556366308033, 0.3859348788147324, -0.3144699752110349, -0.4057188982921304, 0.589077537292793, -0.3379762154886413, 0.6918214276161183, 0.6534200233664162, 0.25667746509551626, -0.15065798586999954, -0.12465325888791162, 0.17221209539476148, -0.3471125776355244, -0.10639578741915917, -0.16755739488596855, -0.31300226769896555, -0.546089507334733, 0.3054337222097988, -0.1762683915302154, -0.0765350600754646, -0.14676323498074703, -0.6460354647335314, 0.43818272430803884, 0.4006012688718672, -0.2905025424787851, 0.2752352082337419, -0.49360694680372924, 0.01412532620106098, -0.0815200764319447, 0.5038016519117606, -0.3724750685607856, 0.8623749449637278, 0.6050714136090548, -0.4540328713230935, 0.5732700946941189, 0.13645285064207713, -0.5160272189286395, -0.8002787817786376, 0.1260036967923127, -0.44497228676383144, 0.3096079432533388, -0.08274816035915647, -0.33459360643750335, 0.5099054218101245, -0.6328942700795946, -0.22368000420162742, -0.1870383093202233, -0.1119021834024194, -0.3511074617954579, -0.6200598941333992, -0.5631006621979086, -0.615186579958036, -0.3364691842454415, -0.3885535461958245, 0.4418564771269157, 0.4498033190828522, -0.6785148816985745, -0.5378305601356639, -0.4933916168045456},
    {-0.34408098759502476, -0.4675326661199132, -0.46244986456235065, 0.5593119191050319, -0.17442854332284802, 0.7636946428943941, 0.29454915871937376, -0.43944127760004775, -0.3219356986094941, 0.682936888887774, -0.5810726878338632, 0.6422344900641764, 0.6984123381307435, 0.2818280795894387, -0.23007895337527895, 0.11004101981746056, 0.25648242515337977, 0.031905229398486626, -0.2500526574036426, -0.3572418928853402, -0.40433820187652214, -0.44468479598012534, 0.6174781409628516, -0.23795003043867763, 0.135676889539498, -0.2410972305592752, -0.5401287031221381, 0.7832181295039105, 0.7929994295443223, -0.31422126713906245, 0.14781824005306737, -0.24236746686782135, -0.14625210082429704, -0.29169244023836777, 0.4213123817208629, -0.2329578616301591, 0.6554209670842269, 0.5761593174077434, -0.31711803128577654, 0.46224930178512613, 0.3401124252715486, -0.6628514153858475, -0.35549259275430545, -0.1286408686424813, -0.09807879246251808, 0.29452092916420874, -0.2800084837594813, -0.21353661932015364, 0.32279047597411475, -0.45743419837538235, -0.08648022523030201, -0.3009678849475272, -0.177666551515833, -0.32107392937157947, -0.4183325890650246, -0.4926539855311327, -0.11655410362047411, -0.33334974798545636, -0.3824932338160989, 0.19879927305599368, 0.633493793620623, -0.3523854188156788, -0.40945843291706685, -0.14180562262985122},
    {-0.4683323742281589, -0.3930580888122618, -0.3453130893250723, 0.5346392218973041, -0.2381473657315337, 0.29497103300701244, 0.19085847533893424, -0.6757051800697279, -0.23708921907744823, 0.38534229813607, -0.5980503493018203, 0.7652916181081127, 0.6977187095682996, -0.41959536920668766, -0.4957165956467723, -0.6023032347322284, 0.10907210996723266, -0.3203635818257309, -0.23072029802034405, -0.4839578458451662, -0.4509774844298971, -0.5707473499327242, 0.4414079800637429, -0.6055541527283849, 0.034631894429427657, -0.6288788715777179, -0.6435139261927618, 0.7115677667599177, 0.5236696442372839, -0.6416146969067728, -0.2689940871974606, -0.5158460292561312, -0.6326918535226767, -0.4410576768206926, 0.03563676588783694, -0.035714628455433065, 0.5323958535849657, 0.6143350939282789, -0.21489344641219563, 0.41312283976356307, -0.38193165987855976, -0.7920105437592473, -0.574453465751127, -0.3435321118860659, -0.6674156251026162, 0.24176016674142908, -0.37995648281047373, -0.5608133183018535, -0.2615828250835219, -0.5853962198423728, -0.4585436130564975, -0.4367741123676886, -0.5340108859582025, -0.5866576400883737, -0.686939310579538, -0.6836599064863216, -0.29010030066685116, -0.5871108354394583, -0.49081108005630825, 0.10067974855892599, 0.5154883918728806, -0.22231421348885086, -0.4912276753839723, -0.2834021915794686},
    {-0.6948068276969656, -0.7021182734038354, -0.6293216017622367, 0.6477350479972849, -0.2994719465791157, 0.3867615652225102, -0.14563696194102607, -0.6314136634662025, -0.27845090525027344, 0.591025389127281, -0.4951648491934824, 0.5027935519704211, 0.700546687030095, -0.5002719262649014, -0.47492843777457666, -0.750751443082018, -0.22902911080937352, -0.7556303540797037, -0.4078174156402473, -0.4971819903597929, -0.5995486576931981, -0.5906554922623449, 0.27879971771046985, -0.5136434147950503, -0.38369458657223166, -0.6406807661193235, -0.5712103967341617, 0.336158052389755, 0.40848063616521785, -0.718818150372389, -0.38086418355539986, -0.35217747396554794, -0.5071951346157858, -0.9669115050706989, -0.2029648479354679, -0.3016939208353029, 0.32669700967293164, 0.5169346718355808, -0.4742531507186429, 0.15273359863830357, -0.30825703400226245, -0.930043828800754, -0.5286016879779467, -0.3343212554177542, -0.6859392158342763, 0.25946180129140384, -0.3454605290888986, -0.2339697334568174, -0.10339242976636862, -0.35766013658753076, -0.5440089615458649, -0.4514252875688401, -0.5808256217303079, -0.7779869980828882, -0.545405585854743, -0.7496975527849513, -0.5066693818303909, -0.47161006746730694, -0.7425394857963239, -0.13698573312112838, 0.46925596764414695, -0.18424346339307543, -0.7307214041057992, -0.3393468871117989},
    {-0.7081032566679448, -0.5134174874412413, -0.25463805008203944, 0.2428771589709447, -0.5345803905223402, 0.39708895518812953, 0.11576941576079594, -0.39881345681281843, -0.15714723667974995, 0.6316762363333935, -0.41715485291631077, 0.09867330037115496, 0.20622220419138543, -0.5448997077890183, -0.4645744817687777, -0.7099522003945756, 0.031091831721488026, -0.3924834999977379, -0.7004905761611507, -0.49874652188100727, -0.4968840577133128, -0.4514625917577331, 0.1757971034748789, -0.5822524718488559, -0.28497590152637825, -0.6219973418920165, -0.9186737870711692, 0.24469952755459062, 0.5215420788480162, -0.4124417272370746, -0.3705464395840706, -0.49375428738868127, -0.5535864427079343, -0.636633711072257, -0.25435911348339424, -0.42161139967343103, 0.2555094022080372, 0.4252810379047893, -0.5984811977899265, 0.16567518665508535, -0.6749842673989133, -0.7595991809676039, -0.7048595650378735, -0.45976828099431005, -0.42751845446349934, 0.287759593826109, -0.43561742664763603, -0.06446564967173074, -0.15398732488948574, -0.7599028943093769, -0.5878706290201122, -0.6353200056873314, -0.4319723032553297, -0.6863710566448931, -0.4577370228595424, -0.5245365705396151, -0.7508642272558634, -0.5240810760595399, -0.6594598181254788, -0.19403513415007445, 0.3970426306883739, -0.36392652839771794, -0.6456079550768947, -0.5177464388338248},
    {-0.7017199819408636, -0.7626213421992509, -0.18778651743919483, 0.2597867226791592, -0.5702872907908593, 0.260706980838353, 0.2128944983334089, -0.5294848796116428, -0.5899694097796975, 0.5243279767514336, -0.5090570952635296, 0.2789105823016372, 0.1464399842086835, -0.5422263536068659, -0.6087370126992405, -0.4480195266286622, 0.06558523953594358, -0.37296398482598125, -0.5007383913303459, -0.5504689629576109, -0.6701991337301415, -0.5313791965003734, 0.5128994855642168, -0.6460820289678512, -0.21056838061734623, -0.3456438397582706, -0.6337945991420795, 0.3820839712090323, 0.33501293852885333, -0.5304424019741747, -0.3158811123564207, -0.5918515986412967, -0.33696347616984496, -0.5617530422983236, -0.33858068479051184, -0.23466918731079386, 0.508064568545946, 0.4527848606644013, -0.5945242785905323, 0.05516914586041841, -0.34665809566502603, -0.4163399746844933, -0.5684939735021834, -0.15307428862399414, -0.5647332684323838, 0.6133447029753933, -0.46047455793934217, -0.056237020510338784, -0.1650970259666944, -0.3640556444357746, -0.3057165185316906, -0.37507149789154154, -0.4303681794858396, -0.6098373869244422, -0.3697700075137561, -0.838841596256261, -0.6431742447252707, -0.554420464503869, -0.7474735596820138, -0.3151451313505546, 0.4321326600140266, -0.38076710983800355, -0.38757113217628403, -0.6381875317307966},
    {-0.5324039671416844, -0.8874675207804652, -0.5303966052905491, 0.24015239249571818, -0.44675570194472, 0.26193282800709516, 0.20518524057138088, -0.44649910367407314, -0.2932365338813616, 0.5034907808723159, -0.6040651025544093, 0.43372833739090594, 0.40268293191914695, -0.2727172067302285, -0.450421714941139, -0.6025537325482488, -0.13177630013724173, -0.6783441024632689, -0.5231846061704741, -0.37684646801594884, -0.3946116898005381, -0.6103704220583023, 0.2888576167207377, -0.5111401288159167, -0.5448886239430066, -0.6307636185859126, -0.7482069089870927, 0.0791314761736148, 0.6759894096861737, -0.693524784924037, -0.5872389338475249, -0.5081796875259222, -0.36695602601555066, -0.5515541503673308, -0.19003540941230843, -0.1693638976459795, 0.7753313414164373, 0.10180579052892928, -0.6278799415696661, 0.08721969625088957, -0.3926947350746933, -0.5770073527086966, -0.32942004047863105, -0.6727833475976599, -0.376134526091335, 0.5271943000699588, -0.5203234890244088, -0.24890124567698133, -0.08205808110271935, -0.5479955133960561, -0.5242909794051902, -0.3857315557412722, -0.5792387849039662, -0.7292709724434306, -0.4629645897414717, -0.6151919811424508, -0.429247538684396, -0.5424420439982561, -0.6156566997662429, -0.2058836045761696, 0.18533938462149113, -0.5830914714129198, -0.5467151847914309, -0.3695301006368212},
    {-0.6266972986504091, -0.581722934679495, -0.6557066316576965, 0.3687962324353981, -0.5480549481652132, 0.15707849292973872, -0.11923929900112504, -0.7432434993957369, -0.417986607730513, 0.5541903338431043, -0.6911205558205537, 0.16097360316035425, 0.5013576528617781, -0.27981886092118585, -0.5171690918104004, -0.4909253689462507, -0.06314204068672655, -0.5399931795600015, -0.5265519692670423, -0.5095740811573813, -0.5042095172626269, -0.6242991119784286, 0.41698331230211505, -0.6522088392873949, -0.12004215681454819, -0.6488541274437128, -0.594602132388374, 0.07545237041174171, 0.4514457240685935, -0.6233286624965889, -0.4698608422768206, -0.5293564050156458, -0.7074846272220794, -0.4288868030110818, -0.10847698619283498, -0.4257705468765941, 0.4678507064660357, 0.6271394805516793, -0.5731493465926659, 0.09260480952171807, -0.5932465780002655, -0.3581885269458966, -0.5509064542444495, -0.6268288664884285, -0.5588434368507509, -0.22161430917934183, -0.5668689987725567, -0.38171090655163553, -0.18819228706324032, -0.4246030326034426, -0.47888316729709346, -0.5834187586229128, -0.5083416084222719, -0.5244709609639577, -0.5564450249151136, -0.6528442835389681, -0.29976078103886067, -0.5047911358549061, -0.589740029384361, -0.13311033913286124, 0.4989314949957594, -0.6463303327822724, -0.6183540165686737, -0.5297517850658386},
    {-0.40456526720178904, -0.6073183541530504, -0.5429911528064167, 0.3011297940111668, -0.4559321444421194, 0.5769493984382618, -0.07023776660842893, -0.5115688333005883, -0.48458581425325226, 0.6104951215569066, -0.5939594054859109, 0.6320272615228658, 0.5976885046044045, -0.5457390660855584, -0.45483103075048964, -0.27262049339252076, 0.2336547398996004, -0.312298817017236, -0.3173592489212562, -0.3421152835323698, -0.41368988728618605, -0.6265553902366167, 0.6012391916261475, -0.7799380233566989, -0.3042014056299005, -0.5439308282229107, -0.7219301938549839, 0.46998956571502803, 0.5348384281829384, -0.8927048491925828, -0.5460909649279644, -0.36271233324485125, -0.48846534412234227, -0.5638331223571723, 0.2517302870651376, -0.396916172834216, 0.527576507943695, 0.6148087202774434, -0.5124176221295923, 0.21200394128893668, -0.24505067762705687, -0.555222769513132, -0.6302669650920399, -0.2889858835615502, -0.7577213179842754, -0.01886636475834018, -0.422532776369824, -0.3307006836871445, -0.052328455531405894, -0.5213215892142464, -0.5188728170886039, -0.546955494054411, -0.29187274271114794, -0.6067440396109182, -0.49052412050913563, -0.5294617251978179, -0.5159558841983986, -0.4562709511097982, -0.6902814991298477, -0.07176338479776562, 0.37746832275016096, -0.34978737306933755, -0.6625061858900015, -0.5294211648886752},
    {-0.6575871131604951, -0.532993433619417, -0.46991462589242744, 0.41923431137810147, -0.34989209947090927, 0.28791151827958955, 0.043353475477594, -0.5797093762281592, -0.7090739352589998, 0.2659355474083131, -0.6425376064559003, 0.41070378132367985, 0.2716692649712909, -0.3754636796969631, -0.34666836419094155, -0.18572430613370278, 0.08046341673434601, -0.4300460968364585, -0.5592740480216711, -0.3429524313559655, -0.6181488182589899, -0.6630708674599394, 0.2443384356671224, -0.6943618221854536, -0.20774482402739394, -0.6075724929259322, -0.685070440978528, 0.10713779971161708, 0.5262355970525583, -0.6790779054782707, -0.4113569352371907, -0.4608331433025259, -0.43502713341733756, -0.543496538251192, 0.2855167846503385, -0.3351166962587314, 0.3195170554947566, 0.6035254714355844, -0.6707772746519916, 0.021949392613784154, -0.1467169655080424, -0.6712283296327322, -0.5566946586310043, 0.03212649718646464, -0.47429789402558603, 0.3141601789885287, -0.6167237347495687, -0.6415915283329029, -0.03639202072094358, -0.5993894163419824, -0.5447318151881525, -0.3090921179612115, -0.5573880462919876, -0.8666485895639371, -0.7091309564818374, -0.5734837620601574, -0.23685694948330327, -0.5731435388320293, -0.621127552837898, 0.06813580648808498, 0.31350527467361955, -0.2712698374133035, -0.48673789624882957, -0.37930982892915716},
    {-0.3572071182474156, -0.4386926773746292, -0.44380601841504136, 0.4506748858517549, -0.3365383304241094, 0.23635483929683945, -0.059162251629543694, -0.42078187733908384, -0.4307025336519441, 0.4183898546692145, -0.40334845298012256, 0.41806091877261004, 0.4158129512210249, -0.3309450151472965, -0.5420099309392185, -0.5331655581663224, -0.10820078009372522, -0.4684147816273453, -0.4975281730222747, -0.3941184989819415, -0.5190282610639395, -0.3102076849843391, 0.2466714574206846, -0.49947634241269523, -0.17443168550718022, -0.43117114599137035, -0.3810023437326544, 0.16931615846113524, 0.28445194631620413, -0.6888771279291985, -0.6001760976380576, -0.7432027670033716, -0.42075346126739555, -0.2912289842097034, -0.16756319666998934, -0.11151686492381258, 0.047000167308756974, 0.20837011993029025, -0.3377075977139496, 0.17633133028186632, -0.26810073410889723, -0.7659029817143405, -0.6949021066139622, -0.06006345670233459, -0.7091307956068192, -0.19870752005692932, -0.4590864773727594, -0.47773858636254357, -0.027577491898204957, -0.5310523894128911, -0.5548799500254913, -0.5794196010223573, -0.5128087589982163, -0.4551745253928275, -0.5052725564801617, -0.4469796988961551, -0.4036915349887231, -0.5895786214832346, -0.5160829465592102, 0.16316933469752878, 0.15576508642519926, -0.38883855383238775, -0.7184539947205809, -0.4311383331122874},
    {-0.5250883028336029, -0.4736995443002028, -0.34932528437130766, 0.33812934459968547, -0.4071424440198095, 0.14798043559310378, -0.06796590501821766, -0.46702297973937884, -0.4425947149007138, 0.44810025752708516, -0.7774132490540981, 0.2123612772874149, 0.6447238728043602, -0.41064945788277857, -0.4775742275596978, -0.32270157303609237, 0.04058438962909707, -0.6944338060230622, -0.6321570668903798, -0.2569540011918469, -0.34458845531931576, -0.5025712297788583, 0.11217421067783681, -0.49686214601964057, -0.2165719077842944, -0.4582578529401168, -0.42858089728623944, 0.32109411901323676, 0.40646557850010784, -0.6473314237535869, -0.1535894766200157, -0.699626146417496, -0.5590796874408891, -0.4915593901079642, 0.2681467485058415, -0.22183726781105606, 0.2688807937349474, 0.4416969905847424, -0.36345415950030063, 0.09626531074550425, -0.3538974782629592, -0.41576246543547235, -0.30246470038527207, -0.15080405541085531, -0.49444205318286255, -0.15984835614031898, -0.42518766190105917, -0.42367974483510945, -0.29173265699827056, -0.5237558335259738, -0.2369464997930189, -0.4933088134302697, -0.3222198045005072, -0.3003802355637997, -0.2512020637918495, -0.3576102478122637, -0.1622558541116364, -0.5339352158330641, -0.4544421537145435, 0.17844981068878943, 0.24414128830988294, -0.268631066935261, -0.4969924834170789, -0.39734038100844826},
    {-0.581088167778239, -0.6340279697480894, -0.30555996968382104, 0.3038509912535426, -0.4698981808864795, 0.6245070275089606, -0.057209675376396193, -0.3605082958724789, -0.6553717979010543, 0.44589516590803685, -0.590898150973709, 0.39651173165862236, 0.334345390823183, -0.37041018229346145, -0.3302197201061527, -0.2823132650405932, 0.3307402055460404, -0.4074443768038217, -0.4299821549765342, -0.3725010952091977, -0.5444314624768922, -0.28038713450486463, 0.5253155954898806, -0.5170772333070989, -0.07231423523222923, -0.2257119878964934, -0.4489965636174277, 0.5701958966692413, 0.4696693833739692, -0.5681500236558229, -0.4505454915950805, -0.668816014840562, -0.620023511486122, -0.5522661940583106, -0.10344623400407792, -0.20859429295100781, 0.12618020379908076, 0.6910393488817226, -0.4832334351741576, 0.29478642830728213, -0.4247652411974921, -0.5902926119822245, -0.4960729266331893, -0.10796680598629549, -0.6043659720008908, -0.14222187391966631, -0.3933902547257491, -0.13728469945425445, -0.31254706835890417, -0.5487876858279515, -0.30971846980061113, -0.5925429166546192, -0.5391080768510182, -0.4996425957291062, -0.3526370837840035, -0.3131146361356579, -0.3797489313334849, -0.5798020405717993, -0.6445733994803772, 0.07690443219862574, 0.001293265667772423, -0.5005512415924741, -0.44150589537288965, -0.545918077739877},
    {-0.4318785942353792, -0.3854999161715914, -0.49332553834376, 0.5403713636367087, -0.5001278819544013, 0.46085912750174163, -0.08684044821307264, -0.6713476905901581, -0.32753777331871353, 0.5085447229685387, -0.33523164090489904, 0.6076367062986521, 0.4460082395065687, -0.4711468646795219, -0.11566167468865875, -0.4357930317191094, 0.015017062683908742, -0.32159143684597186, -0.4409654395269327, -0.32944182162224134, -0.30584274733815714, -0.48673992848057174, 0.25990230988723256, -0.5447129401875774, 0.007607069840402089, -0.5672906889652723, -0.6682840746362472, 0.622357437319935, 0.39035396085788704, -0.47524003749846366, -0.16399689103599152, -0.20803877214490613, -0.48342467730551963, -0.5349649329158283, 0.5631577581451881, -0.37720706397102355, 0.2912515188963373, 0.6734734513878846, -0.5874432486838131, 0.22688924561111984, 0.0746213285079, -0.3564274510492614, -0.524172370745041, 0.18743501074858562, -0.4213944365092882, 0.07847577153733601, -0.4862404026753719, -0.5049732270544306, -0.05111104689387422, -0.5704928492290475, -0.35499245807719304, -0.4311411658031942, -0.48731439519570463, -0.49077092077993195, -0.5670326038380545, -0.6779467780239817, -0.37481997461287875, -0.5468503553172029, -0.30858252429733285, 0.19665454677137653, 0.5257589892090123, -0.42932031964370293, -0.48513656776713576, -0.5155458255316369},
    {-0.5234439265819247, -0.8759719163171504, -0.47391995184833147, 0.5155711805923459, -0.4105379700167851, 0.3595741134101895, -0.006082111255560986, -0.3957064210737047, -0.10504872174386237, 0.6954061356991976, -0.48447344322013025, 0.6768991847616731, 0.5456567854780205, -0.5732850317026648, -0.5600162879418943, -0.6996454699224989, 0.0866173313184789, -0.37298678584307515, -0.37038787876139156, -0.17734943630391417, -0.47360052613253956, -0.6785136504734047, 0.3840884285806094, -0.4179564833739601, -0.16204188272024525, -0.4770089698489566, -0.6194421298856073, 0.3677731782601314, 0.5869201478852349, -0.5923901099257808, -0.31473488067659544, -0.5505723321677205, -0.6079685277592232, -0.5652914447839523, 0.23338364012923765, -0.5070676484931923, 0.6181496504739614, 0.783636621268985, -0.40832232763684995, 0.4527392281838958, -0.4783968379811237, -0.40011739218045556, -0.6673533970797803, -0.061685196598253576, -0.180308964813831, 0.290477301277834, -0.47340614063015274, -0.275053778054969, -0.05969446687753296, -0.2735047301725631, -0.4897055581316767, -0.3125670470180623, -0.5792584651394785, -0.7264493996545953, -0.6346039461938454, -0.49289318058240605, -0.43759507733284686, -0.39606162135003564, -0.566412983393214, 0.12657115561640758, 0.30931376624916307, -0.4871005918615497, -0.4824803811755118, -0.6691653354493641},
    {-0.38208954337740797, -0.6837062688682118, -0.47606135467362054, 0.6744435221543591, -0.47060722803077276, 0.40472277162700254, -0.046222816836712595, -0.42662907827621815, -0.28583587934898025, 0.701495026402188, -0.5249901259277909, 0.7256605551250126, 0.6131489262898134, -0.3138220113765131, -0.3897858113591279, -0.047476291581668224, 0.1463949510902706, -0.2341682505345179, -0.39887926359362086, -0.35149803896207404, -0.6314532789132794, -0.6904215525104184, 0.41354065418873026, -0.6523577846924893, -0.050005074646395704, -0.6245013522595549, -0.6525155598723462, 0.8328781236778984, 0.7174575855133105, -0.4824801608964437, -0.33297622886218586, -0.7820005314940215, -0.6692112540059982, -0.4414762689745693, 0.18151868314012987, -0.38030512537137356, 0.48092114925666557, 0.7120492988716457, -0.3930694764370838, 0.3872475846309239, -0.22947094430316006, -0.5651666090621909, -0.32268988542891824, -0.04779190840460098, -0.24948879392527662, 0.10930296368123807, -0.6180131890490034, -0.44692867560004124, 0.01834082068344383, -0.6329974340503199, -0.4778977188716149, -0.37497999184559205, -0.5868462974751749, -0.252656277822943, -0.2568147503783291, -0.6979944738856824, -0.5077639819230119, -0.40140263471132903, -0.5506586460436351, 0.500520401319409, 0.4351156773264373, -0.4950316285876819, -0.619178856710571, -0.25284585161117407},
    {-0.17254902064920644, -0.2674976654039183, -0.2944050031434287, 0.5548762973223, -0.3321332534573674, 0.7669953356506841, 0.022999688780200544, -0.5264275749970768, -0.3587410898412483, 0.7273639208554663, -0.6171215513987061, 0.8514037336967436, 0.5609950169525426, -0.5857588706685383, -0.4176702717006064, -0.3519460427647365, 0.48058925398717145, -0.3569473003940765, -0.45842883436729087, -0.16710910844313262, -0.20477834130948727, -0.4202043639521888, 0.6830871164377131, -0.19376707133452267, 0.3350674174271512, -0.4035840382631568, -0.14069322778630897, 0.9065201123539336, 0.629954849625113, -0.40594067147062796, 0.03707825227148083, -0.5758588526783597, -0.4471503934933023, -0.4531550145378399, 0.4905052197568453, 0.032523186942394595, 0.5605939656641657, 0.8109601512727428, -0.7638937265828549, 0.5156390624457954, 0.10733916905871686, -0.4264136103732704, -0.45170472453082744, 0.07666514638134304, -0.3595365343989908, 0.22464506784332716, -0.5256945006606084, 0.05634767972484654, 0.11643040222716172, -0.3062715407578479, -0.24973200313647365, -0.3538338268750613, -0.47174472851633864, -0.11662123958326172, -0.41218972097753176, -0.2889793618994289, -0.29970259437717084, -0.4534492165839201, -0.5314813924216982, 0.30816970106736197, 0.34636543585345503, -0.41858235689191836, -0.37614188191132913, -0.30918876940939927},
    {-0.4175790871171355, -0.35223634202101545, -0.34430428850059003, 0.7308751596045702, -0.014607439983608195, 0.5370784177733757, 0.13466505602758527, -0.13784293589996732, -0.43610382240292234, 0.6120034035428162, -0.524344613175078, 0.6773360537371206, 0.7011812993505525, -0.13702156852330602, -0.36373940092661444, -0.17771561557001284, 0.2708195285388467, -0.16751873206254775, -0.22792347425896337, -0.6221960780180239, -0.4252545776839978, -0.24098247517761728, 0.5502861632003736, -0.2910845975920705, 0.28485926439134784, -0.3563908438294282, -0.5122307866982604, 0.6069939122288753, 0.565751140860011, -0.4612274145343393, -0.4476308764531562, -0.5516614292257278, -0.5588589021040044, -0.7173315661751144, 0.2798604484620369, 0.03562670702636479, 0.3162766955771561, 0.5763522145078463, -0.3921250054850436, 0.5040289947430215, 0.20537893660019826, -0.3303362362303644, -0.4946107248507826, -0.05874182617208593, -0.5544736315231368, 0.31225731582817456, -0.3212257925008216, -0.04303699047929298, 0.03967617614826598, -0.2001298824122952, -0.3083555998670683, -0.4063647722454553, -0.5611201578786233, -0.24188336811173586, -0.16806713305537105, -0.2962534355045174, -0.46220127384827087, -0.24175337061164207, -0.35593455166769544, 0.2598043383874819, 0.4727932241850595, -0.620976043566545, -0.2949875729688563, -0.11838619733995961},
    {-0.37549031878439937, -0.7641205447773195, -0.21447285490310428, 0.6540123942078214, -0.42968171589201043, 0.5077381037104999, -0.045516180113909475, -0.4523786297803059, -0.4132186582668991, 0.6850269937197822, -0.6914497844491626, 0.5584436374095573, 0.6698095070483522, -0.23064863833037577, -0.5485488359542593, -0.3652993536301008, 0.41921821341870474, -0.26544082125126844, -0.44352059460721466, -0.5812327741415519, -0.5443885077357443, -0.6313033817710874, 0.7073425664923153, -0.5632267100523465, 0.06844321577380563, -0.279269007082084, -0.3971269917860183, 0.44709363119457113, 0.7153952426468847, -0.5466689101452844, -0.44308699610319763, -0.5353969446806084, -0.639096260020536, -0.3882012956247361, 0.4055491974610863, -0.2099104046437289, 0.4689105281133133, 0.6404481041575432, -0.6040046306402909, 0.44512600153470266, -0.19402944909036168, -0.7098801775462537, -0.43433713028803467, -0.09465118579751639, -0.3878504679735824, 0.2836676683091042, -0.33711203837636855, -0.18629510321888668, -0.005356396378961089, -0.4172605323915901, -0.34284931043484806, -0.3852633782395188, -0.5381504891010457, -0.47816511366269193, -0.4284655361735029, -0.5664037717318056, -0.36256770328185767, -0.3644911622531785, -0.7094847686714937, 0.22273436908858532, 0.7852816774719364, -0.4742126725782729, -0.5542720997861156, -0.3866136141937353},
    {-0.6073949112698027, -0.6095713826523257, -0.2455466975595694, 0.45397931605473224, -0.184804011467754, 0.4939080883351873, 0.02304921630149003, -0.41617152326592577, -0.48991319937146616, 0.5690677997268058, -0.47531514849572515, 0.8320994116518857, 0.3604183832177892, -0.4459136321754861, -0.5463804435521201, -0.3614248106138598, 0.42930873907340084, -0.5333827279640369, -0.44392552748118264, -0.37280125361423994, -0.43264022385451834, -0.5790748031098824, 0.5266207765300152, -0.4550412102435116, -0.22469238458741114, -0.5201319965255655, -0.4387624165613573, 0.5539101130257681, 0.5364535274935334, -0.4509497629378415, -0.09049216592639184, -0.6679210937464278, -0.30137104951487415, -0.24446887527327346, 0.2186387012469191, -0.3696032439116442, 0.5167144107778849, 0.6398813857559819, -0.26533033167326414, 0.3593706370448249, -0.22301899673575473, -0.6044549578174692, -0.26268377779540253, -0.21135624864839306, -0.5830299128897266, 0.3184307569405735, -0.4353285546043542, -0.5009658772794682, 0.1590949371289442, -0.36182253953438515, -0.6022111043735745, -0.32106098167993075, -0.2324191841639304, -0.36816534303059245, -0.5906105697805939, -0.4363941741940066, -0.3015899883247379, -0.33732403886165346, -0.3848547405693392, 0.13668806338740988, 0.5705041426186457, -0.380351016231567, -0.38203395929513195, -0.3745824538410602},
    {-0.3445430716394735, -0.5080179741058077, -0.4952846418009661, 0.8221888999653597, -0.30554974101127264, 0.40308630277284113, 0.10287168046021472, -0.28111793080711733, -0.38465215158726507, 0.6621381452444927, -0.33226580733967903, 0.7855466899761121, 0.451363750222273, -0.2400714048589566, -0.2938251195513224, -0.17280731361285256, 0.2530667223249082, -0.5184823108655129, -0.5237037046375451, -0.4568254899495925, -0.437165202500445, -0.43431874661527087, 0.5658283605276231, -0.4381894872637069, 0.1607321778129339, -0.7115162467725905, -0.44390509174197834, 0.8055799082284305, 0.6527543134699703, -0.5746307543450031, -0.23285362006817242, -0.4042872325678486, -0.2455775086108597, -0.39031500819069836, 0.28192094689509156, -0.3371565372115887, 0.7620229520825431, 0.7580774732949402, -0.46409674555226754, 0.5673732997266756, 0.02129605075464374, -0.6330396977999867, -0.5689329607518827, 0.08239077761501899, -0.11844963430494818, 0.23758303921422402, -0.5497975553990561, -0.25149382596975006, 0.2679169001421189, -0.5513019331435316, -0.4213227849286922, -0.276310748867145, -0.4500732296038453, -0.13025573427638337, -0.7030920572762313, -0.44887332515461575, -0.43142834613597203, -0.4761258899917182, -0.6684125068706547, 0.5951057828026183, 0.47610332888013757, -0.6438657220291235, -0.47926741636052744, -0.2925003726300095},
    {-0.41164616516420244, -0.40930458222377325, -0.25641759989672896, 0.6513957417241785, -0.3263895732557387, 0.755005832139347, 0.12744379567488962, -0.35969233259576866, -0.2750253861232116, 0.6602847025870249, -0.4358482277805375, 0.6339732337795969, 0.8415797301513738, -0.19904127355194984, -0.21048414589839246, -0.23042846638322625, 0.1890230246031812, -0.3573152916856756, -0.3381451236885912, -0.13386883814569625, -0.15755518296419974, -0.10309229160932688, 0.6630476315891357, -0.3823395559298155, 0.43303272051157327, -0.2853939140695108, -0.37253454825191396, 0.6735122077375921, 0.5758366884309696, -0.458298561640006, 0.08210615787943797, -0.27555124988961927, -0.27439646307425275, -0.40344858061042965, 0.36677147781312053, 0.032031064396709115, 0.5095525820468682, 0.7742621226826687, -0.7517993183421238, 0.6889234513043159, 0.11112618419257048, -0.5370838889765194, -0.5266512266631925, 0.018946377648500604, -0.27492943898981004, 0.28780244702248936, -0.11744407608657452, -0.2299734533203463, 0.4900477281702189, -0.42266292486021073, -0.12920895453897882, -0.04876035784690275, -0.1802834101960096, -0.23001369377861214, -0.28732807429281665, -0.1385175769323349, -0.3109087941038871, -0.29320602888796177, -0.4461466637057346, 0.48934813540716243, 0.6140308789431553, -0.3887320255671191, -0.0907204589604126, -0.09193987419031356},
    {-0.6623927845226188, -0.5284197375418447, -0.45681493473465284, 0.5914761453251229, -0.22560542736883313, 0.6402905375161759, -0.025207429818335063, -0.3118362430440809, -0.5561966243505, 0.9378760220053375, -0.3404796667092818, 0.7257367871213861, 0.5373208930973932, -0.3549418482328784, -0.6174694603364775, -0.3362419657235808, 0.2496837958922929, -0.34148659639536044, -0.3102095482673175, -0.2875774483395455, -0.3746562104865095, -0.2570279666250261, 0.39894097644251025, -0.1653779728476277, 0.17738307231899292, -0.4520520566328685, -0.23023600989791357, 0.5840858074122618, 0.7661286000544243, -0.7215898421084077, -0.14755295393547077, -0.20191632822890845, -0.39166045704058694, -0.18838913943010352, 0.3628387228522815, -0.30626400117438973, 0.6040186157049294, 0.5363832210527684, -0.7801193671999979, 0.42531217149878264, -0.05123376377706413, -0.6548537669353719, -0.5606056549537808, 0.1576801527207018, -0.4548305936179758, 0.3836020979549778, -0.5987685428499365, -0.4286565672870054, 0.06539544246929152, -0.40983088642604865, -0.24515811441562013, -0.39391341692866133, -0.24074338143458335, -0.4561437057789475, -0.28551303849759424, -0.4205119667135386, -0.3777998438260802, -0.38950166192359736, -0.6407533239531206, 0.36995166159524767, 0.5190602796477147, -0.4897726320442595, -0.5424471888564716, -0.1728394589854251},
    {-0.4299960436935025, -0.5235948572813245, -0.2843674795053479, 0.7968263024270191, -0.3626132113023026, 0.6654157949270801, 0.05368816333175912, -0.30197852851340173, -0.49463082105347506, 0.8090185564187067, -0.6161059513185434, 0.6800659035181595, 0.5405734803137701, -0.22842907687699782, -0.47706500164289734, -0.15826022820296218, 0.10982232624247326, -0.42161438970542653, -0.44415283975950387, -0.4919479243511267, -0.43459305628037936, -0.45934488721826505, 0.5087621300326358, -0.34118151004456637, 0.04569234615437121, -0.4414275231090081, -0.4507409980922796, 0.7671443395763148, 0.6807755225466315, -0.6621511829797486, -0.06720834289270683, -0.3647264233050694, -0.39846288346074904, -0.49946736868962893, 0.4756734029455759, -0.2199981041856619, 0.7906930719245193, 0.8174784665638625, -0.784894350014017, 0.5906545719325627, -0.24294462845193365, -0.6719254957927345, -0.49967857169950985, -0.1290100731096692, -0.17826064516342913, 0.2369082316044784, -0.23705649931703385, -0.3809504739801999, 0.1494239927803896, -0.5362435452567814, -0.8336831162437054, -0.058372191192083644, -0.5437579529643609, -0.3797478237601044, -0.6007166986740266, -0.3258108125004315, -0.07093115533664694, -0.6075517225433671, -0.6855158067347294, 0.32524182194412876, 0.4550819007341598, -0.5489825709034589, -0.6084390383441747, -0.2750564510114951},
    {-0.4159894058064979, -0.5052721641303004, -0.3177574105845949, 0.6864645711277727, -0.20624646183639211, 0.601029747354045, 0.11100572870288725, -0.18611948051692853, -0.381018755168366, 0.7335657424113557, -0.48246849902513683, 0.6974598166151669, 0.5162762898731442, -0.4300509530577264, -0.3438062602268231, -0.4410525966651306, 0.15205235844917175, -0.2065511858256593, -0.6342459090861859, -0.3158602418547244, -0.37110019117592324, -0.37882189550976286, 0.6487449461388843, -0.5774245052955088, 0.06059908175448997, -0.3116022923328421, -0.42969810619516124, 0.7065417709490669, 0.5489444743395473, -0.3263366192649423, -0.039444290326171215, -0.4917107945985776, -0.4909362296552348, -0.6759461972715904, 0.3637716719942778, -0.0708958971014484, 0.5208167946530224, 0.5566457427008229, -0.6688866477126607, 0.54080842330746, -0.1834443517756449, -0.36436269122090575, -0.3238329663975973, 0.09045468727681462, -0.49511954399728303, 0.2577778223022268, -0.23178909189090316, -0.2819110844584685, 0.09656964757321755, -0.4032785496029778, -0.3661840158291844, -0.1939662116523766, -0.3823081791457084, -0.39482392943798034, -0.48952072832572596, -0.39394521006632566, -0.4928804865891614, -0.38858548372762347, -0.5793191323887273, 0.1678322514225943, 0.6084462422917297, -0.5857692572047131, -0.47740974760448757, -0.3598606400362002},
    {-0.47930706669843853, -0.5288022115605838, -0.29396294052602967, 0.6952438214250134, -0.4627494816721154, 0.6102687833383292, 0.0420955359120765, -0.4076820225972653, -0.2526053251824471, 0.6219544082480741, -0.25142756629861385, 0.6584445698394384, 0.6694777994630491, -0.44850233054511124, -0.09669690781534353, -0.5035205172530474, 0.12156125814640607, -0.4309933625334582, -0.34490750395727776, 0.009964297285467355, -0.3351261214526846, -0.34329167158958634, 0.6439450718109759, -0.3601155707252674, -0.023668909485833552, -0.3657153201082694, -0.24238352344028885, 0.3473949982697883, 0.49890263635351023, -0.6157847615380595, -0.17975205012533593, -0.4382022597797355, -0.5484199303666338, -0.42248810121391783, 0.49985164920487596, -0.14726181413119283, 0.7208509382141051, 0.7409564569516364, -0.5264468094550021, 0.7152185756883844, -0.031746626100917295, -0.4948871811152054, -0.47011451777648355, -0.21072888558100022, -0.39514659816832975, 0.3002842087166207, -0.3496077812038917, -0.289733026923945, 0.11414314483388963, -0.4429828726860619, -0.49282590720025776, -0.44451698783893295, -0.2563655577184567, -0.6198303592341995, -0.23112412509456534, -0.5007916420016848, -0.2080544105973101, -0.6699737543388212, -0.49300446474043363, 0.2897021208881487, 0.6004114875633956, -0.37941913621040646, -0.18881001319771817, -0.3976598126751714},
    {-0.6394809949957176, -0.7701140640932665, -0.28663323486888526, 0.47867949011060446, -0.30945550441731917, 0.35322081765549684, 0.17695533169542027, -0.44593580042893677, -0.33298744308883776, 0.5603226760150811, -0.31781322574599874, 0.8418094983194067, 1.0998375097903137, 0.01506572450089669, -0.46352538296548207, -0.33032842467307777, 0.22309214063777813, -0.31646246927368, -0.2886432702375064, -0.4267195155297621, 0.022748378823426594, -0.6303233777701942, 0.32542676032426204, -0.42344120003911445, 0.07583656701402396, -0.4198835186404355, -0.6006991841658108, 0.7845344639536855, 0.5452305624959892, -0.43091835410596646, 0.0014758877585105907, -0.49806382608605293, -0.4397068350526316, -0.2795999206162858, 0.20152773177145078, -0.3883700470374836, 0.5187864073153907, 0.5492750800194697, -0.2969265741050117, 0.6333554560094394, 0.021282924459613304, -0.31506351218792283, -0.6152692154117452, 0.2898941029885187, -0.23751415087342337, 0.45545240192010433, -0.16160970144009223, -0.14508421675932345, -0.03685806814909025, -0.6586541895250674, -0.15833980260951858, -0.36573960724669097, -0.27190298863077794, -0.7288713071030317, -0.5652501040972311, -0.38122095128832956, -0.28319720680616856, -0.639153500043618, -0.5855699756023945, 0.17613675028640363, 0.39660068258773445, -0.3102164345658408, -0.5105845203062289, -0.4175110355352607},
    {-0.5472498685547165, -0.5823983935176545, -0.41862213773396756, 0.4328864131710128, -0.21789031365638073, 0.5234695169306968, -0.0885687475967891, -0.5428438259202871, -0.4682218338245826, 0.5614660011819111, -0.4063918080408602, 0.7009776167948294, 0.8588993148450299, -0.007422859382523773, -0.5643759608480629, -0.26431032735027754, 0.2530626957520254, -0.2520437452657098, -0.5774808500382564, -0.49707523669898734, -0.40205303949713184, -0.4638890234832427, 0.5932398493571923, -0.2850039391468774, 0.1088337675001291, -0.28282837492226665, -0.5123220378251462, 0.5253233974838786, 0.6809555161815842, -0.6425336766957245, -0.22644389248628014, -0.329771347040122, -0.4772534277042457, -0.45838355294585825, 0.34756124542910655, -0.2851497058969707, 0.7006310373690252, 0.5541955078303841, -0.450394921630936, 0.4112569478753529, 0.019695723118558054, -0.5405291273393601, -0.3647912827133195, 0.2455244589646388, -0.18560853602123437, 0.3742262471634067, -0.47700416208131974, -0.37433881151461806, 0.08059458740978659, -0.3190588620622265, -0.522459692353318, -0.569458908358932, -0.15668599785499965, -0.4327763890021109, -0.2923416622045239, -0.04191137344113539, -0.2018894617065919, -0.359762586189807, -0.40484520174519495, 0.22398977314465832, 0.5119872536685733, -0.3117852827478277, -0.5328209099842526, -0.47877512057487126},
    {-0.3739228098489279, -0.7702296596602736, -0.3098669675517507, 0.7391119061184565, -0.19823892726465028, 0.37678630659550016, -0.06710861702422821, -0.38119728860673263, -0.4886296838748021, 0.82780752827372, -0.577932998064896, 0.642670994706412, 0.5173803347553443, -0.01530027439644838, -0.2619229494341704, -0.23555406585973374, 0.24675459287847445, -0.25887040736936917, -0.3869653427077839, -0.33086328571511137, -0.33588408883895715, -0.5191849355802918, 0.5310258300620514, -0.6365980537691185, 0.125556120266341, -0.7099807629524568, -0.34562332375317645, 0.5166032356569789, 0.7251424062144287, -0.507582428023057, 0.000942851450606526, -0.498174169125033, -0.5203407611831745, -0.4676822240958422, 0.3305079459807102, -0.30304415727122797, 0.35574715291812586, 0.8007488671514311, -0.4735330864334924, 0.7600875191427532, -0.1427458437208703, -0.5200051022630939, -0.25313511131719274, 0.09193318407090366, -0.3323562722284504, -0.10348810475190917, -0.3704991393420147, -0.4330328476159258, -0.0216541330180714, -0.7166231733351621, -0.22573042493889328, -0.363146783261772, -0.30876412283245247, -0.30234318175533503, -0.46577965922056486, -0.40609944450006913, -0.43976870238377735, -0.41122977866666716, -0.4765188522440799, 0.242804896439732, 0.4241644018251546, -0.3360975945705727, -0.41830585613885213, -0.2540110887655773},
    {0.3545960375774381, 0.2987917050416971, 0.26094449519746116, -0.08807353466957814, 0.002002546420139579, -0.23604861611868289, 0.5273932889411377, 0.40980864285413027, -0.15356959587906632, -0.23226614252095926, 0.051860228560277895, -0.12719306335542302, -0.3635404309779116, 0.0054845592452110875, 0.549356648225596, 0.0038721276982784736, 0.043906847317283185, 0.18038081979867918, 0.4300641675911494, -0.1833641840536086, -0.1552527275115926, 0.3783565644276235, -0.009592746831349317, 0.5199802115796812, -0.14772252156769766, 0.22010192951549157, 0.28955572607511176, -0.4100002196921809, -0.09692261880497974, 0.35373796929139373, -0.2129896884371466, 0.02361615531227601, 0.16717122635754994, 0.3864772595486354, -0.25226395701692145, 0.3048678546524481, -0.36299478543663216, -0.08087107608886294, 0.3391221406520172, -0.02510930782131784, 0.2363421704948078, 0.4359119921439314, 0.15991575630883526, 0.036339829148888385, 0.329192620447181, 0.4811077510217072, 0.22836307519633084, 0.27569132727568413, -0.29192003868720945, 0.3298469989609576, -0.14984009574654572, -0.15867232666928707, 0.24182296166516418, 0.3595641326391466, -0.13025484334930454, 0.09385157334165083, 0.14863960951445723, 0.2811203367447396, 0.3226198242901573, -0.0401307152259465, -0.02167780486542537, -0.0958721968969649, 0.28802255564660706, 0.3260939787687371},
    {-0.26427467556292067, -0.3140041600363336, -0.10652384327655612, 0.5617348126813679, -0.25697676496330124, 0.3045134168730114, 0.24885926812138204, -0.3146087413961994, -0.03994615082527375, 0.3625615331034836, -0.029435862495228247, 0.34984205521719963, 0.28523880676782554, 0.03359882234250711, -0.3804729052263645, -0.10333272249245791, 0.14633114714956327, -0.020845991743084935, -0.06639006213515392, -0.3854092164600158, -0.14114184368596788, -0.12881770073431337, 0.07404210399953878, -0.27547043977781305, 0.050040995374274144, -0.37031412347562165, -0.27800135786838975, 0.3068079468262793, 0.26286401934945797, -0.437231982412493, 0.5270894835252369, -0.4928921177383473, -0.11338091954652073, -0.21742544240821077, 0.24724587184548213, -0.06622556009271338, 0.4219491853527109, 0.5731762008358864, -0.16392012608595616, 0.30854151813710223, -0.07819047985102068, -0.048321590369454784, -0.43020756073918376, -0.011235115549929295, -0.03650072661026975, 0.2948894716615099, -0.23668257793469133, -0.04585309026859836, 0.07607985514252974, -0.5139634149976844, 0.00700112055738442, -0.10820471740103982, -0.18031051564593614, -0.3014924559887365, -0.322220239163505, -0.3477208748292131, -0.26209443510059266, -0.057572281865243706, -0.14214268675553984, 0.3340469967454631, 0.5540362126811108, -0.3310290028786474, -0.10797959619267122, -0.27274945148042995},
    {-0.07659449277483707, 0.22606502459033137, -0.10235837421889231, -0.4819572386059915, -0.44787712345172076, -0.008810390894475887, -0.08276751950529454, -0.30966225091693533, 0.0036613216906429833, -0.05437456354872205, -0.05752952800496529, -0.37343899731752395, -0.2669531214714569, -0.621648723348257, -0.8082797905308042, -0.30103689453056326, -0.10745289624785459, -0.24759391073522335, -0.43832058458583956, -0.6937948105474387, 0.0006647031542169744, -0.48541028049936574, 0.09211496068437512, -0.30609356265891285, -0.15901509965153976, -0.25013477203875406, -0.05028665776302443, -0.5655588272869335, -0.20083639247126728, 0.008435099890064038, -0.47632353888128437, -0.05115351021377929, -0.49613647430942354, -0.4208447130713372, -0.3878209190867011, 0.09697796628194781, -0.3005007551050486, -0.2579649698765331, -0.002469982402575411, -0.4383101419780222, -0.3563313307082562, -0.03206075364479071, 0.10100305702722538, -0.5565703181537693, -0.5028185735192375, -0.018499884008695133, 0.09062785793113536, 0.48612404834465467, -0.2060930303976701, 0.48034851305988774, -0.1624619893009535, -0.3290629908526727, -0.12555281373819932, -0.32342911082577, -0.09895317789146113, -0.3018062454243903, 0.2599590834795847, -0.3572001420777782, -0.3003596923869635, -0.5980615625716735, 0.06255193207588491, -0.022968154784920765, -0.3733350056412346, -0.2802142612659563},
    {-0.3439671683695833, -0.04389105084787786, -0.10592423623088311, -0.33020571406567806, -0.20267919871587675, -0.12953882886987075, -0.31814185475549905, -0.35497497251219023, -0.2986843610978027, -0.27211124065181025, 0.038384305105385284, -0.49780460654271796, -0.3298947466796149, -0.385742321570109, -0.444733659072766, -0.46174065897474825, -0.5950907095964533, -0.5658462673788393, -0.5757998771136316, -0.5167363107083296, -0.3897286931878301, -0.4994900305218723, -0.5183505797580688, -0.5407460871953489, 0.06201730140275239, -0.4827477537634451, -0.29126933094873836, -0.603578840896969, -0.07670918917704465, -0.39958477823603183, -0.47034960769776235, -0.6016366479690665, -0.49015016347586615, -0.3197261900597913, -0.5434196706003411, 0.322279008665161, -0.19691522664892414, -0.21670275849429793, -0.22992876929880357, -0.3855307031261759, -0.30820025709081184, -0.39690183231988563, -0.35537069887178013, -0.4477285788784702, -0.34795369076082583, -0.20351563698217184, -0.46470309065811705, -0.05908857987009035, -0.26346451468600246, 0.09387971304888539, -0.2657746792943092, -0.18200897210444647, -0.355043519228652, -0.25262361663589616, -0.3087767155346695, -0.4288747706884499, -0.3091009045275168, -0.805135834773789, -0.38672901063742937, -0.26576569215196405, -0.31810709254395625, -0.18816342512682996, -0.534062451445759, -0.3288893006273854},
    {-0.5801935712300248, -0.48925813271170143, -0.21875523751660647, 0.32793245201102733, -0.49433583213385834, 0.21934454699275843, -0.11998569421744464, -0.3466382382057923, -0.37529693430538164, -0.008786896811680128, -0.30202581321666855, -0.19780324239627026, 0.010074009470203382, -0.5502839446576202, -0.6187317471582827, -0.49842483092785456, -0.6363724343236805, -0.3276176712581995, -0.47434745695569946, -0.5226174286532324, -0.25695751182256515, -0.6657606427671938, 0.05340666599083759, -0.46241137892610673, -0.2991768502472978, -0.48606630921794425, -0.561291055609481, -0.28724916680364887, -0.1670892141357049, -0.38751618682782996, -0.3301262925611574, -0.15417344161481975, -0.615249546528678, -0.550181275785977, -0.14916098689005405, 0.13445960059735704, -0.026981321719803344, 0.04167386570191858, -0.21938522503900673, -0.5358567355552266, -0.332046018632602, -0.37248969897675194, -0.3542903836589145, -0.27266830067236086, -0.47417040505987995, 0.04881105051187871, -0.4497559405028051, 0.08483024273804557, 0.13476361866493983, -0.12277764546912186, -0.23157205773907524, -0.4446325090993048, -0.2502338414232132, -0.2427759291082956, -0.458147133572276, -0.6421871238701237, 0.0622119691501037, -0.5281442489047664, -0.2670333911813291, -0.18490682887133594, 0.16583010771401355, -0.08923887225851108, -0.5744407863544131, -0.3198873916235246},
    {-0.585710879052874, -0.30855448319683976, 0.11086791385080488, -0.16631394477591394, -0.6282806702587298, -0.011146456667782207, -0.04520342948576537, -0.3874260609425296, -0.14689663242206707, 0.13446900444789808, -0.09047664467071223, -0.5500879424251364, -0.033834508091671274, -0.29462711080046056, -0.5938901445351269, -0.39647363196443736, -0.4055861176005606, -0.4115427854808376, -0.622733659163497, -0.4200308655589202, -0.35777005518645116, -0.4735767670709991, 0.10920545494856536, -0.40803258296308825, 0.300323712402013, -0.689438363865143, -0.5673932880600433, -0.44001246417834283, -0.031133542504547692, -0.03964833733442482, -0.43239902114582546, -0.2918745935598964, -0.66692216003748, -0.4560242114564707, -0.0285481249851566, -0.009694346644394655, -0.1480763006608266, -0.26753704573559733, -0.6030490121714074, -0.5553104026483121, -0.38878974833158764, -0.2895448003699959, -0.3143883566507126, -0.7287057930435541, -0.1701763412953396, -0.11233651388705622, -0.41694106332099157, 0.13755137343597268, -0.49074914488491767, -0.283842577395324, -0.25285363897940194, -0.6103297922053166, -0.5243049683739485, -0.4079934283611361, -0.42003263447279443, -0.6959217453001566, -0.13712276580318603, -0.4731917291283122, -0.399982467448404, -0.1445032453344443, 0.13578596414824004, -0.0021746453891417403, -0.4572171098290811, -0.09446373667190332},
    {-0.49961961037121594, -0.09950014281636883, -0.10982909405111718, -0.04847166412500193, -0.4038322901545437, -0.09096109723713355, 0.2326942373701235, -0.4895634110286262, -0.37874535838500306, -0.04104644132658679, -0.18238772024843936, -0.2871251844511557, 0.2005871948475143, -0.41937197094270795, -0.5720950142569904, -0.35387530735613826, -0.06527202234263206, -0.26750191142205054, -0.22751803152821043, -0.4188949621723556, -0.40179051856244646, -0.38837464086691836, 0.3654973560273558, -0.5640729059172539, -0.23292650788392455, -0.5012871289799012, -0.6487379003907756, -0.28599881732271754, -0.2806068253903744, -0.3809910548825845, -0.4247805750806691, -0.11213935696884858, -0.40132042402096757, -0.7694418128527978, -0.30258221864418805, 0.27382831271741165, -0.1854703415348267, -0.09055814063207258, -0.3007572045832278, -0.3768458638674456, -0.34362229208016304, -0.40089664662529034, -0.523876322086058, -0.38102003433169207, -0.12357648926897978, 0.448134748384962, -0.31116920728932973, -0.027937460641709558, -0.2979433327260148, -0.10784333698686258, -0.38362623818574504, -0.6060479068014448, -0.29941528958213726, -0.5715443663353845, -0.6367382791943237, -0.6646393437807749, -0.17035083764707024, -0.2802903326504768, -0.4301928914312756, 0.16407563423848595, 0.009665634364588647, -0.03690232874250975, -0.4715941191894018, -0.2892170084865974},
    {-0.4581699755450236, -0.395536498794786, -0.2162104311839249, 0.1846098565044186, -0.44114280213133933, 0.02374781727128678, 0.09633737119643898, -0.21622283682196727, -0.3104311288664845, 0.09858091785721906, -0.42574196805882725, -0.05495214404250251, 0.039319917707573294, -0.09380776096332584, -0.5685054030778702, -0.13687293561475694, 0.08613660879967834, -0.6095912915050462, -0.49088302473353745, -0.5400075205004463, -0.39363313980599846, -0.6408150721026034, 0.10021322533427895, -0.49983955819805426, -0.15358696371035993, -0.3292521207320783, -0.41304836869268247, -0.33689984758732483, -0.06211248354190795, -0.4844125081177636, -0.12871688072722512, -0.37124802246487515, -0.2822785006642565, -0.7033224695684153, -0.41118219436998255, 0.25120726234511503, -0.24520290409837653, 0.02212427540039645, -0.4143168352323724, -0.22310379817441434, -0.31237193759744436, -0.5414382500017968, -0.2279375670699442, -0.4003179192452779, -0.4600651236564261, -0.21123347106721901, -0.22067410136279472, 0.11879702030452116, -0.34199792350604297, -0.30329142362146483, -0.22519714972801816, -0.1534014868302407, -0.2795292824859822, -0.30343488274163943, -0.6410020954667304, -0.2882637877478952, 0.011708611802400695, -0.47531961433132225, -0.6253659578391165, -0.05441609603421817, -0.13236711341757207, -0.18588377104658432, -0.5245893574315318, -0.1604790934140984},
    {-0.5622371519987202, -0.2888045077247946, -0.18238398592534313, 0.06979685002727645, -0.382165189389104, -0.12467046303936384, 0.2424947526193052, -0.2841464874904277, -0.005580202726511378, 0.06215968199255396, -0.1295409896016639, -0.21821460722654534, -0.010213148824631299, -0.28558307999121624, -0.41054973726095073, -0.6223068178553931, -0.22998905994237995, -0.34677722069228867, -0.5950160242579186, -0.4176779377372355, -0.3111376620300536, -0.5549564476386882, 0.22820266416378626, -0.42250063027546386, 0.0928979450815179, -0.36991481114268904, -0.4228467528862805, -0.2447398051109784, -0.014830502532522877, -0.6055817213462718, -0.23716293736930505, -0.34770099798867105, -0.3257447015691818, -0.4113114099961966, -0.46516397414312927, 0.13030291373512323, -0.17053649554500952, -0.09729499514670721, -0.44895687847795435, -0.4463455621468487, -0.4409219832958935, -0.27821896649174854, -0.34291382527587655, -0.3994581558406794, -0.26859620544450863, -0.08281103437550315, -0.0038352028583538795, -0.11865767361249674, -0.3177220356528777, -0.4507953162219437, 0.12335209317942641, -0.712743910740213, -0.4937093695817938, -0.3186551927193849, -0.579781820091049, -0.43124469942743904, -0.22968362430881975, -0.6693680036712856, -0.7528232629437486, 0.0778074562624524, -0.12586898864516502, -0.12012707728655389, -0.30005446086284976, -0.6598461927755309},
    {-0.2761307151632607, -0.6349351386026802, -0.17490841163603377, 0.05754645633395062, -0.6663048353918843, 0.24087247284064164, -0.04556239802953135, -0.5129514710545636, -0.2299470263983956, 0.060416928763941, -0.4590609105898547, -0.3979642175354968, -0.2482416584708325, -0.5887322737994413, -0.39522912489726014, -0.3683954188041587, -0.266207502304004, -0.019996649950144905, -0.34697855852922826, -0.5174128647163132, -0.38482642337881473, -0.5916305599037964, 0.046407208436210226, -0.5968432435923599, -0.3421513051700137, -0.35361932713784916, -0.08318367408731975, -0.3603278418578079, 0.2698332593440334, -0.5390662390476386, -0.3936209209120319, -0.4606971463942695, -0.6941742409286353, -0.352413105893161, -0.3561937080632533, 0.29131753444221037, -0.05268504598704413, -0.008557391923629065, -0.33540749545033405, -0.14223154067100768, -0.48086657079534767, -0.3756080792314135, -0.5272265298056082, -0.7447964498213807, -0.5584206055517584, 0.21333611887497517, -0.40676970685674324, -0.3766374130181445, -0.19731158090202247, -0.29773940059742804, -0.06808944861794258, -0.4309646250098, -0.6496428858390967, -0.6509002238432005, -0.471258431099413, -0.5758536556407827, -0.1410675598757558, -0.5561122731740417, -0.591534028437355, -0.2872831490452567, 0.1278410128685829, -0.16228942793210333, -0.578490639485517, -0.3341452558466003},
    {-0.318167396882931, -0.1419634372804641, -0.233646707099509, -0.06060685896027009, -0.4124430153769356, -0.15656441990756498, 0.04615022064845662, -0.2369787394346101, -0.28508944129607766, -0.13636772125368307, -0.39059087619451116, -0.3044761029386527, -0.0669141446985557, -0.443285992911074, 0.0668836483528336, -0.5057197704489409, -0.4141380444072642, -0.4086585623240376, -0.7215804244888574, -0.6522730139274855, -0.31261334903370713, -0.22411630967744128, -0.035553337299069905, -0.37345805711618907, -0.21179550754404547, -0.43484116741314854, -0.6972270871653897, -0.3697067299292874, -0.26571943405189163, -0.5732579884280388, -0.2930235173516203, -0.4632371699262128, -0.5604407980108785, -0.4646644329683721, -0.19644005921248664, 0.28278548566713974, -0.387148781230064, -0.07391838106156676, -0.6269348303699805, -0.7344621932194463, -0.46698679277632293, -0.4260647990275891, -0.5387734683526482, -0.5682904563869847, -0.30953332095087893, 0.22415199276019868, -0.04917059741555405, -0.14388373721557976, -0.6577202554482106, -0.04525011622334729, -0.19423544924759503, -0.7689467430627325, -0.42907954569781487, -0.6508075671065494, -0.8618503776734151, -0.27390098673671187, -0.01606267722238468, -0.3881023153688398, -0.33187266636726703, -0.1521008045832716, -0.17065954647406856, 0.10138050378393403, -0.2922291141848874, -0.4968731501594101},
    {-0.3256025976529461, -0.06727443935764936, -0.1505053037128754, -0.22804496244987293, -0.5544824710211769, -0.17132217194976537, 0.11461233020825909, -0.5851840291333057, -0.07108612302102883, -0.0608033707003516, -0.25336364119934435, -0.41935619756712167, -0.06466374527108358, -0.5352048853805319, -0.26411912583632735, -0.4564356730342085, -0.29796075748180884, -0.10742957754307088, -0.5791554003162179, -0.49577825279681936, -0.6071092567873945, -0.5839003917060731, 0.19382073734581506, -0.30757985296689666, 0.1829695170205754, -0.46154015967841816, -0.44229072161905864, -0.4730778645232386, -0.09256685277423875, -0.3382161535758392, -0.5200523169558143, -0.40069170228188583, -0.5453853990208519, -0.5866515369607437, -0.154962077009692, 0.16119518634593533, -0.17802045564055727, -0.08842808042961345, -0.7828481442486388, -0.26189568334280294, -0.6161644679660473, -0.3369162799879352, -0.7423006519060842, -0.8239957535456701, -0.575874038237651, 0.3473807504512542, -0.22833436847085983, -0.06222618132854162, -0.3975822159206422, -0.2831542529383084, -0.18521651624645394, -0.688291666307313, -0.4913557661455269, -0.6862487931297354, -0.4800908357353328, -0.5157883879581391, -0.1748657473012307, -0.6712244847572342, -0.48619975315200104, -0.196769812541483, 0.03159545583177487, -0.23589555410585158, -0.5178093265483357, -0.42103491036354196},
    {-0.5880122547348755, -0.2736002175438779, 0.07154013263723381, -0.1382936873291234, -0.6091204422410406, -0.06147798161655573, 0.3678099115114501, -0.16083567444843253, -0.5227027910352077, -0.15799444468369986, -0.39513885482659433, -0.32317161469989447, -0.10362117547061031, -0.26158062300049156, -0.36376207656192494, -0.49883628234342964, -0.5731626953230201, -0.2382757820227458, -0.4597688835813484, -0.4191519022436431, -0.2064413253063861, -0.7969807604414303, 0.2317938120246835, -0.4299168862281713, 0.10691903870479615, -0.3864248556963334, -0.5392464334212842, -0.6385178644937818, -0.2225619591808159, -0.48954008848225156, -0.438635463395409, -0.4020627442579156, -0.8025922060669882, -0.5444479233099766, -0.2190929076470497, -0.03408869922021302, -0.2627533743702407, 0.059793802213592435, -0.8019786146425291, -0.5461976024658279, -0.4472372672599805, -0.3141455768945304, -0.6984275707261121, -0.44684282148896465, -0.5664383680147229, -0.23679100356757365, -0.4310554845829618, -0.08489688323852464, -0.19957735962112524, -0.39148075218623174, -0.23576218219279288, -0.5903059766376253, -0.5422318426442921, -0.41444705692508, -0.3884276869046042, -0.6092944266400484, -0.34068686628255207, -0.41219533946539166, -0.4164598234456816, -0.2627311062947302, -0.08571213260516294, -0.19177786209033418, -0.40762926646669995, -0.47524134347360447},
    {-0.4987028041759676, -0.4588627173001228, -0.14145084957992776, -0.1801516809401823, -0.5115660685781048, -0.11220119313366393, -0.08243863606141019, -0.32025507603239606, -0.40627869791993265, 0.1621994771785121, -0.39051385345560463, -0.44619968284113104, -0.20646260020208237, -0.35600804595997065, -0.2940846600584756, -0.5386712400512553, -0.19462058043375513, -0.023807141149503715, -0.4032314769232693, -0.4985929898175686, -0.15282596200396106, -0.5506696493229232, 0.16135539710056024, -0.323393103810839, -0.07706466381042432, -0.5121681912858413, -0.6024769700666479, -0.6583497709275444, -0.2639856025278205, -0.3545138895286288, -0.19516469931533245, -0.31722675285492896, -0.5073952255017485, -0.5456360792966205, -0.3939646183202398, 0.3266334359882712, -0.18977482160509027, -0.09932737825121535, -0.5303427434119432, -0.3525886744330943, -0.6939737683248608, -0.19178889971472313, -0.5774085324240881, -0.8992940507644693, -0.5632762290147459, -0.04237723894096094, -0.24512187938461466, 0.051551827081947124, -0.2973403311544341, -0.3903218733106676, -0.24395469442228768, -0.39315601918057475, -0.5612841216422402, -0.3519130907263191, -0.398403418022777, -0.42132601589587515, -0.34443273098646465, -0.39563201951835253, -0.4733977493612003, -0.44713065893235987, 0.12952408208122163, -0.2929076137279915, -0.4631361577215923, -0.39233724602169223},
    {-0.27804903003131703, -0.7129738885734255, -0.032795354237170476, -0.2610466016717227, -0.31091441521843594, 0.04657747442205866, 0.0527718152171694, -0.3790258916612169, -0.515329625432258, 0.15038518807878024, -0.22249120735194894, -0.26001211987981376, -0.3711022704398044, -0.15470436114900563, -0.4585577273749537, -0.6995290490346731, -0.17384439894812745, -0.23572969677064537, -0.3926823609939948, -0.4931973982267106, -0.1466136284058606, -0.5529050066669446, 0.0771192591655009, -0.4401284710122385, -0.10873696369095472, -0.5415098083607424, -0.34961670681435525, -0.3683076435972666, 0.14121955604262715, -0.3797789398944571, -0.5981371204101759, -0.3359459204952992, -0.7670494207327787, -0.48522107963691774, -0.40374445929730934, 0.3642086442260317, -0.25577716360938657, -0.0437467995372888, -0.28014249583241724, -0.2712724517381532, -0.1053312617578884, -0.5149940865400023, -0.28100587085137496, -0.4116117515775472, -0.48650941490874294, 0.20406683972337458, -0.16203463805679613, 0.19766382954762243, -0.2648235278939914, -0.19605744401109582, -0.051981275604328574, -0.4766951083113645, -0.42689717992266435, -0.7537583741876567, -0.7609019807613686, -0.43529320278919253, -0.31556084355216185, -0.5826041141854114, -0.47376873520352714, -0.13602534082826442, 0.04833986708594896, -0.05945508896998662, -0.39731283040817805, -0.32624160330866275},
    {-0.24655726358771432, -0.5744910569196462, -0.06397124234783848, -0.4053932697965578, -0.6396316804744004, -0.015864562556175677, 0.396539763192224, -0.29779643231257974, -0.27623436022162634, 0.023097960356037905, -0.4536395114202265, -0.29615691896877133, -0.2813866045046858, -0.6245212471844026, -0.36401693004840385, -0.45755018395368136, -0.15902062205356915, -0.42142595394325033, -0.353718287635994, -0.49598895306837004, -0.35339514502232816, -0.472657740779577, 0.2116459540256831, -0.5994428685893186, -0.15446279798415669, -0.5355992392513925, -0.41743554935339444, -0.5126061560267022, 0.000406353636642005, -0.5044931791644734, -0.5253031298405269, -0.3929206214055988, -0.5763383236513688, -0.3656312612697861, -0.08821818997379206, 0.3736788123401527, -0.1822255998353663, -0.24258308206600662, -0.6776287294072613, -0.2092156799430725, -0.4969018450452475, -0.29688194914432553, -0.4229599750391203, -0.4712787295612954, -0.318379451825887, -0.003676118017912071, 0.0237246952803887, 0.36991186333347686, -0.3029792471451735, -0.21185042078972383, 0.13861323727326763, -0.5130640082598911, -0.17231153657717513, -0.5668926851976941, -0.41528863112324743, -0.7883906441950633, -0.07681835744198273, -0.4622231861469405, -0.5593734692240032, -0.3016989681811643, -0.1447912178701483, -0.20526464791646704, -0.4127688026309968, -0.23103067776744943},
    {-0.3127768005828531, -0.2990160725601029, -0.18595292492738955, 0.07833754152260278, -0.42863118808106165, 0.0007310178856050911, 0.21083249117783534, -0.321732256626558, -0.34845705911313596, -0.19904404031738637, -0.26996376044437637, -0.36445614126882747, 0.029612938141575534, -0.49091480138453825, -0.1472916778684647, -0.5939240724792962, -0.18298030107317184, -0.27282779290768144, -0.44332561048413077, -0.4650263407452208, -0.12449060703393221, -0.3245483227017747, 0.01274932212964941, -0.5193054435169495, 0.29281171400057326, -0.5479698885010865, -0.3985297068116248, -0.2792834387785725, 0.36904965759478636, -0.3013000626016873, -0.3090563435815381, -0.27205894816568965, -0.3661826119575179, -0.7471382180664067, -0.5451135009476196, 0.005747646110001279, -0.3565289520603286, -0.2502160365408216, -0.511238601128784, -0.2711333322494202, -0.4998370329353337, -0.33817628292522617, -0.49994133434260496, -0.3751523510996283, -0.30504700913769145, -0.048568150119780114, -0.5575792116420221, -0.12158561851914466, -0.43419180404437147, -0.22195029344203396, -0.25502877117042017, -0.41506322752829317, -0.45321628266615643, -0.3223636071774567, -0.6614673571727933, -0.4871547934587255, -0.3684625627412746, -0.5031703456865951, -0.2949217586109889, 0.0509594684386438, -0.13505132986246093, -0.22608696745222676, -0.4382042240217209, -0.3779751467430457},
    {-0.2400172481937655, -0.19608981711933057, -0.04166403266805758, 0.13510044517391917, -0.3242097085035596, 0.05988970774308858, 0.20366203894834253, -0.48748533891883045, -0.12416835938245548, 0.1075994167273015, -0.12292579578540982, 0.09082836470543874, -0.06545834645943477, -0.3336887291110369, -0.6038984842872283, -0.22260851657197497, -0.016107430824232993, -0.43106440128796064, -0.44762036491847673, -0.5682815785617052, -0.07275780277745457, -0.273481238277944, -0.06110486820358375, -0.26704806052584584, 0.2805561445044959, -0.148913366471442, -0.11918588559059666, 0.11100599724034196, 0.22776560383988945, -0.51616028660509, -0.014389515075591362, -0.1602523889073078, -0.17688969073082986, -0.09398317286158317, -0.007430454956200503, 0.14710634214346002, -0.038312777077739564, -0.13905215275043625, -0.16760435464283255, -0.18697175628073762, -0.34530446579298235, -0.42965631437273233, -0.35222207709015774, -0.22870124294587688, -0.5005762337124001, 0.16350327050404978, -0.2736344074137849, -0.022008922598131943, -0.44307396773281416, -0.14924472753589663, -0.19177973949790392, -0.5823765612920975, -0.5224864670132133, -0.0845996562363601, -0.22155813740146163, -0.4499190175060302, -0.031838457598367294, -0.3358257600630027, -0.3127418953074082, 0.0005467438734982638, 0.16694287342238395, -0.09360841725116444, -0.3723523437921767, -0.07190322208020422},
    {-0.2836970185901451, -0.23386201718814242, -0.024602420734643516, -0.1034033120914822, -0.5049243642567184, -0.05412281037609599, -0.10679356898649375, -0.30191691849458485, -0.2647669850262577, -0.0334200987990405, -0.3825439057216745, -0.40669806661703506, -0.17297694144738693, -0.5197929872432699, -0.41039789822522954, -0.4866393436004171, -0.31426382846910067, -0.27392801433973946, -0.3690079213125083, -0.1666589649099563, -0.25122836379438956, -0.5164335190661979, 0.07472241643117383, -0.5920675888234243, 0.1235495117552763, -0.4855162305103814, 0.023400722639515738, -0.3478059406026971, -0.15164757806370488, -0.2665718739789683, -0.5203985550116423, -0.37732560363494805, -0.56529784343886, -0.44275230589203735, -0.4094685126269864, 0.42933065784309754, -0.24746236769749233, -0.1908301874066561, -0.29815107919142425, -0.6493751824922238, -0.5200947324285801, -0.45365396595175156, -0.25656497205747997, -0.41760305038100715, -0.2916351078874887, -0.02924564245610058, -0.08022609471723008, 0.20498775315958367, -0.38006179011510033, -0.24587666427745067, -0.37484648689386096, -0.6545526624373867, -0.5068591477394556, -0.5853580125570718, -0.4665911637538008, -0.5212208753642046, -0.08873534725686896, -0.5315710022653738, -0.2462300191015854, -0.2533570502539966, -0.09248292889816727, 0.23175641586286821, -0.25424909681183766, -0.21692777590025025},
    {-0.3365062265399122, -0.40266825349557295, -0.361538450245729, 0.20026509294649297, -0.5446969526620451, 0.08823347817288264, 0.19591565203100816, -0.28266299354158, -0.22872469797454775, -0.11674055798758277, -0.3849292774626654, -0.48960432796827874, -0.12620888643974626, -0.3515030182024485, -0.22231143955499427, -0.4872838414326792, -0.455567882653628, -0.632532018273551, -0.4917006452655011, -0.6187636805791046, -0.5053213001770277, -0.373796723501637, 0.006574728314684084, -0.5970121017437512, -0.14562731764935566, -0.41040989061709593, -0.4933902404233742, -0.49945624371095454, 0.14346281953755485, -0.46776639644694007, -0.6421001744734175, -0.29828315736207106, -0.7037371541112818, -0.3453503340925474, -0.3634520812890248, 0.23519296224429215, -0.35711110845272603, -0.12991203251059044, -0.42582943985444954, -0.526402314896376, -0.3417313698561761, -0.38643292015113045, -0.5145887448007157, -0.5340653248388265, -0.5128273638284002, 0.16725609849936687, -0.563844396379663, 0.05411801178068515, -0.34250199664599196, -0.24993454696710232, -0.2711046518687255, -0.7382790013094814, -0.42774750056936545, -0.4802974289474023, -0.6195829159785707, -0.4441950064800681, -0.16617681327933156, -0.4518589511609832, -0.33170642885260093, -0.10826089681873573, -0.1204562553319821, -0.10964065409343864, -0.4639397748863609, -0.3483649918306423},
    {-0.4921205575926258, -0.4007677643282375, -0.4213644427756008, -0.058637689926458375, -0.2720160883892914, -0.22244537143363277, 0.04675948047963933, -0.3636919165430947, -0.5969703036742025, -0.18098984646966276, -0.33760093914129213, -0.38686593252468165, -0.396194071135735, -0.6495454227083168, -0.45075210704614793, -0.605777735054951, -0.577565893859395, -0.368567831347611, -0.6566479546072665, -0.459492430312825, -0.4524907248720876, -0.6229882185492288, -0.01563550031633217, -0.4005285764007107, -0.029654015571391173, -0.5110037468989254, -0.36038260175487347, -0.21892441679009556, -0.02757857568927141, -0.6070834876365487, -0.4371761839795649, -0.24050303637650267, -0.3614490226293938, -0.3154136088764365, -0.23778572610881016, 0.3085404420640698, -0.5721839899211381, -0.20653719948897556, -0.5292233330957756, -0.5176694679667686, -0.25478988382226975, -0.3855598270622028, -0.5668393449437059, -0.4341276709557499, -0.646229300753782, -0.08013495867938322, -0.4068917210818483, -0.07979996571356048, -0.37715926433272445, -0.4386487456902951, -0.19625034753431522, -0.5212377435117332, -0.6726422402851122, -0.666849813982095, -0.6307520149872078, -0.43526494573700747, -0.25734515881258624, -0.7041225618769307, -0.5611437980538669, -0.6614890889719348, 0.052496325679528624, -0.3564578135395205, -0.4938005549338476, -0.42353163199342525},
    {-0.4991278630467945, -0.5621913492588185, -0.1921744670327955, 0.0989416138086577, -0.611901826428139, 0.3134754966389952, 0.13171949123520055, -0.4501413384250778, 0.02632170460518976, 0.24051160142401015, -0.40228426367870285, 0.20708763577878642, -0.17893922413562088, -0.37308787348106653, -0.3479256702894021, -0.4781282232250666, -0.5725411924348455, -0.18006169341162093, -0.4726468080350939, -0.618094531969476, -0.24378183173314896, -0.37136052855401686, 0.30549871618790864, -0.3739672500161545, 0.15074182539136335, -0.5327789002954669, -0.3703273522457991, 0.007525747695780184, 0.12826307517373498, -0.4744803026947822, -0.5494425104665754, -0.30405271665054856, -0.3002882934208358, -0.3000294292089512, -0.16649920136819926, 0.4561824102440344, 0.11446331093751662, 0.12952296372958588, -0.4279997230997445, -0.11778590831606212, -0.5878470497381258, -0.44885416454168797, -0.6620649568646658, -0.46618676378180124, -0.7163141754471607, 0.4638320038514392, -0.3152456890334905, -0.003408006386868241, -0.334869029072167, 0.05233849763916212, -0.3937989996579284, -0.31478741194779425, -0.4405254745403992, -0.4061949648036258, -0.5283160960639042, -0.623476623686511, -0.12488414326214056, -0.4514256877984571, -0.25566074335154243, -0.17187425015893562, 0.017891480488181052, -0.08193277273903053, -0.6320772607181019, -0.3714070198951873},
    {-0.37420052631589806, -0.29755862222113794, 0.3710302278461363, 0.06705201097969342, -0.3553452573524442, 0.16328129247251863, 0.5613204139018655, -0.11233940304668627, 0.24880372420668856, -0.12201543468848584, -0.10407143526279986, -0.3745635932315507, -0.1357507223528298, -0.5530364055289356, -0.46093626436000096, -0.5967167393865109, -0.5322430002720653, -0.40879211899772355, -0.7599840783725175, -0.4096715181585842, -0.36300935442632515, -0.3996302954906045, 0.47561381550237336, -0.31230880426099683, -0.13728691863021933, -0.5607477787572526, -0.334089217159355, -0.35174207219913073, 0.04649835778961723, -0.24359581514300332, -0.41172392592044676, 0.14067239332034673, -0.18631986956821045, -0.3205624453544724, -0.23835868779824473, 0.3466466385715629, -0.07298440297849496, -0.21482106965135928, -0.20837534196095828, 0.23126624932199263, -0.4836512691102085, -0.45402093246793573, 0.035382684411592064, -0.5770803852010644, -0.19949719169401373, 0.4251698918706584, -0.12245467830192375, 0.5428953177311342, -0.5296167048207332, 0.1950584772591852, -0.1793452971715912, -0.41428369495439404, -0.36529407204095243, -0.11158858012300321, -0.11989253458292984, -0.6733218517165316, -0.2435326127734416, -0.5305343209855407, -0.20755911071613345, -0.22432239929471004, 0.4451852562180024, 0.10409892813514517, -0.21566805678314646, -0.164979840409688},
    {-0.5677355364205491, -0.4444831975011494, -0.09797986544820345, -0.2974315719826607, -0.7366938471541286, -0.20670144428933457, 0.30169515599498226, -0.22113746515261673, -0.17228163835467042, 0.08637198315601782, -0.276360188885927, -0.35885372360189105, -0.4029112628130303, -0.5515032950183654, -0.6332935305086419, -0.30203293824270727, -0.44051632362007803, -0.3611912054706335, -0.43776661703767683, -0.6338962412509995, -0.38116151393720465, -0.23958843958174977, 0.2561383290069941, -0.3414916697148165, -0.16772865776619345, -0.4310801904013241, -0.6069944911499712, -0.3542050181248084, -0.01943488256491983, -0.5421742844440338, -0.5162433956361056, -0.2895530853343741, -0.49496910566423535, -0.2907576105722399, -0.49022934987056566, 0.4969902386243786, -0.5042975669756236, -0.0796557782744021, -0.47526058464314463, -0.12942401845898494, -0.4722683410212798, -0.36038349029803396, -0.25028237541882525, -0.2479530618025216, -0.5268973402189299, 0.3700555353007952, -0.27721766339528425, 0.2467866488826227, -0.34638559215105313, 0.02226021329064358, -0.07223779286379721, -0.5259801859768701, -0.7793606745347003, -0.40224635055137115, -0.28148022902344244, -0.5434830290273716, -0.13676140622137548, -0.29280294896100334, -0.3612135849487984, -0.5196367107757922, 0.30531719959119363, 0.025661400597526127, -0.34543196648826174, -0.3275191584982787},
    {-0.37749752568538275, -0.27611777569710355, -0.17653883365129933, -0.007294506860262713, -0.7096342826999352, 0.012020544777590327, 0.4549770983237888, -0.5050329859856215, -0.38386430743561456, 0.1061632192643631, -0.29954706939705106, -0.273706944245884, -0.4163915657703368, -0.5675489360851854, -0.24851521962511955, -0.5825937441263056, -0.472607227590293, -0.2868081020374749, -0.693086870346565, -0.5053861706169802, -0.44045761245200965, -0.30113473791037876, 0.15704268611706135, -0.28020576386733953, -0.052073292454401836, -0.6741669353531514, -0.5791721615295963, -0.5339741580390436, -0.04053544239930403, -0.2669960436504597, -0.47486352273083193, -0.2551348010907394, -0.528711104054242, -0.43936893146334177, -0.4581937426826504, 0.17514180145175326, -0.39670409579628924, 0.008675929063496752, -0.776553097968604, -0.12590742528744478, -0.5009813552350464, -0.30072612430558865, -0.37089343343412073, -0.451574144964877, -0.2834163518342852, 0.24561599373394744, -0.5784106517543643, 0.2594819945151657, -0.6963790925463546, -0.4087022647207054, -0.3394585022503907, -0.4912802553469868, -0.466980882599796, -0.26482696209941925, -0.5327958290175728, -0.42566425050247275, -0.07630345799110115, -0.4387625497671666, -0.5418627822799458, -0.2959966322691517, -0.017958410438203586, 0.0736620758105566, -0.16605788565747906, -0.4696691414631423},
    {-0.3481808042236881, -0.05042229337472528, 0.11332585974437685, -0.03831694372537616, -0.5086980357348265, 0.07441146833881643, 0.3083815602131339, -0.015186576489879589, -0.36392319960677727, -0.2836771764524978, -0.12612910125159582, -0.5743922507629069, -0.48626963109060195, -0.6451732000116713, -0.6076310851083676, -0.6996501238999691, -0.7652397762077342, -0.4029384367926624, -0.32633407228297384, -0.4872967020804977, -0.23681195121652873, -0.3654338073698037, 0.1572912001854383, -0.3947825610451831, 0.04066414436988752, -0.4570263495992346, -0.1987140943585593, -0.3182760130859893, -0.11461946873744985, -0.10728283067835186, -0.4381979611598579, -0.3246263401719399, -0.3513982498007016, -0.41356251720040343, -0.5260190046310844, 0.49962832869683577, -0.4955298637656219, -0.31218670234769885, -0.21339619265559354, -0.46545586666447486, -0.8280491778647373, -0.16782831662973757, -0.05819658555444534, -0.7018533212794195, -0.2730710693501684, 0.16012204066457547, -0.12069475216296169, 0.5132575189024261, -0.5880581225857243, 0.04831792328097417, -0.20896299210167296, -0.40079193504266714, -0.4249296253695292, -0.4133136401195765, -0.48047725921819207, -0.6273501531774984, 0.06811106541175796, -0.42264348721801387, -0.30216074285011335, -0.6912195879685417, 0.317602758013256, 0.16367204941170663, -0.21109431762525013, -0.36359949120157287},
    {-0.3674330027721392, -0.0556227866380678, -0.1160771323695173, 0.10876912446258809, -0.3085422221084906, 0.3256444624329401, 0.1773834615984712, -0.49008896558841886, -0.39942185641560796, -0.04239179875110003, -0.32274343218535273, -0.19099877971186652, -0.40712669737524587, -0.6827207280890931, -0.26258288292998333, -0.3748622099433584, -0.29545680858060464, -0.49202631366208743, -0.38054743547460007, -0.4119103960665604, -0.11098432691597514, -0.5157158389668273, 0.24714917933109404, -0.3810965621225973, 0.008367598444987159, -0.41936331173989405, -0.5102052463786052, -0.23136166370884353, -0.044765407321318465, -0.3673346773504629, -0.4894552165047703, -0.12031740336591175, -0.5633273255838801, -0.20675566149071326, -0.18404752093803917, 0.5227156911603321, -0.13058517966267624, 0.09629991716107503, -0.23949312496438058, -0.36485813348945, -0.6208627415647919, -0.4061575600469831, -0.2585093710346108, -0.4389998829811348, -0.3811538537411457, 0.35220259973185947, -0.025056537410343842, 0.5098310623633575, -0.27863951396952685, 0.34616198185832425, -0.2095021668782474, -0.6188664112563312, -0.27917585994976, -0.6236906232381274, -0.565316521875461, -0.25838390465436795, 0.2509048521060331, -0.27266538774660676, -0.08640566097694224, -0.1254001804301334, 0.45522926849338335, 0.1259409684504211, -0.1902772647980689, -0.1332599514534353},
    {-0.4498212205854684, -0.43864455020177745, -0.10440000415260693, -0.10046777835779647, -0.598595774148993, 0.1286607243289177, 0.3060437438655462, -0.32518215846492177, -0.43589358768054504, 0.14628845669409363, -0.2419804914281697, -0.3190863509694084, -0.25908800157111156, -0.2967784403748472, -0.21286123121262143, -0.4770991833170151, -0.6470359755664442, -0.43113548348778985, -0.07485319791634011, -0.7792164129982779, -0.23496058081819693, -0.42231330784686427, 0.28743807212565065, -0.4346941123999591, -0.0862551465581022, -0.254834727657389, -0.48119330944471533, -0.2641808594543958, 0.17960926893515072, -0.4385870900374201, -0.4245150498513491, -0.22980112492230395, -0.22158450610786345, -0.33149138819770235, -0.3351182006192876, 0.3993786355466552, -0.28532749737703755, 0.0834614355751321, -0.5583777852969597, -0.2469814993944775, -0.5385467916326157, -0.27726887341327566, -0.46254764485941374, -0.3498990849977719, -0.08655859339956425, 0.5999905715012772, -0.09420650006078517, 0.3074477685215585, -0.3562228086109615, 0.1645808652335963, -0.21495514003243876, -0.451350495032479, -0.5495592354317408, -0.8310511182732827, -0.6537716652713501, -0.4502845660885841, -0.1021676601118149, -0.23992341777149298, -0.27539074612909525, -0.2492238801032482, -0.08095024881233144, 0.08079717079900393, -0.406138299815039, -0.3548942601894816},
    {-0.4927261485802484, -0.1666618795011437, 0.18475961070065255, 0.05064213027850063, -0.5995502848386499, 0.1833790656316875, 0.5667301852679415, -0.23911886658071577, -0.1938114083828847, -0.016764354630854256, -0.0372765478328366, -0.8717982851496303, -0.21583832755380253, -0.38305543750033844, -0.5531793739960876, -0.42858891319488573, -0.45243211112697923, -0.4415148663647685, -0.5568307092485328, -0.7448608558383429, -0.3663029011228862, -0.45117022995635225, 0.09031580328651383, -0.4751733630776569, -0.05291463805785397, -0.5488666896379663, -0.4221049690834476, -0.5590732354411523, -0.0674902829792978, 0.09128372626365995, -0.4532711933793067, -0.05713736582134206, -0.30778674986256277, -0.1642006981200279, -0.3268826519905064, 0.2679581011999004, -0.25388298342258525, -0.05813125965124929, -0.2677065922781556, -0.24274706897184317, -0.49999861607694407, -0.04710427258318878, -0.12021769333476917, -0.4508220027734063, -0.47694850393137894, 0.49568898735137534, 0.13271401958605833, 0.28695735272341283, -0.42592684053391394, 0.31543459915195193, -0.19905199567623963, -0.4408865732446361, -0.594531779056281, -0.5042273021285725, -0.08946152028552169, -0.7217032381862052, -0.2069438790732922, -0.520648768888726, -0.24550576820705464, -0.3873417942150651, 0.2448098471325896, 0.3561850637804487, -0.32077319159939016, -0.17099735328516463},
    {-0.43234117566754143, -0.3265784212094798, -0.2758294662893059, -0.13080262303060095, -0.5896962103671988, 0.16869191301053005, 0.32898248633437216, -0.4474433295295892, -0.138312111094304, 0.2554161186788219, -0.22632962780899663, -0.5277047340452227, -0.43384985557401534, -0.5217676548479409, -0.4483026630176119, -0.08822471098502298, -0.5099859038150293, -0.49085537766424503, -0.23084727606584501, -0.6915912446864013, -0.29870179427472354, -0.39673370219864257, 0.5210479620880449, -0.5443550722230033, -0.10405687224201404, -0.40388191594372785, -0.29488784971134313, -0.4433235795487251, 0.12072376849492086, -0.3593306403980538, -0.6223223849153585, -0.24452231726345827, -0.3129537505680868, -0.165624127728818, -0.011879186665868567, 0.23363045957005504, -0.3051737068309452, 0.09489848464246342, -0.7292210893259463, -0.3637983627681154, -0.453292945691305, -0.04483982501985199, -0.1722296991445917, -0.4951432813839155, -0.34179071475908535, 0.5032163000524783, -0.09131703425860814, 0.4673631456338563, -0.48772081468565104, -0.0363376905795619, -0.23148213939302648, -0.36709937668083537, -0.5131839189467746, -0.25561121220911537, -0.4946427980867049, -0.48394974593493506, -0.009681798635679941, -0.4343491917967498, -0.2487819645243197, -0.3544269927664943, 0.14841781968229958, 0.004514037813879109, -0.44633330740154126, -0.21273977542629344},
    {-0.0295699262829439, 0.1389940894012855, 0.4842937470805804, 0.18705499890719307, -0.2768517720070244, -0.40429122640422593, 0.5184125542179379, -0.02612871884831028, 0.2650507110883993, -0.26413921719843464, 0.19864695135470017, -0.3331317821968682, -0.08513261638357261, 0.024991943858156423, -0.01659635365375993, 0.26441420960701467, 0.10858777287047296, -0.6296907192506984, 0.04627261167127912, 0.3796341989982837, -0.18219156092904323, -0.14261932359780832, 0.06600254155019608, 0.0881850992730759, -0.5107184368079353, 0.6095225430950362, 0.15763572990599864, -0.16385238004802238, -0.05363298242438623, 0.047522169388841705, 0.17214662851406906, 0.1946512072735123, 0.05237656338424257, -0.18813213100906465, 0.5964502935804116, 0.23373298679019422, 0.26889079496723817, 0.028782614536629576, 0.030965432817599177, -0.28551596873592194, -0.23951983472632038, -0.01793763250009235, -0.1949433811849275, 0.09405217481918088, 0.06122774540100551, -0.4493635688146648, 0.11409042388842715, -0.2855962490141233, -0.08840074469457478, -0.19124289889561172, -0.2513794391782674, -0.20950290161315624, -0.12876797766038472, 0.02139364393462997, -0.11128423505587413, -0.0452965952461125, -0.870855571609033, 0.3322495165498672, 0.09576683119673696, 0.08834922845490513, 0.29270093370386324, 0.2978579505435559, 0.087881217537598, 0.16650853531390158},
    {0.11503887504205762, 0.02200935693387343, 0.36173675545304146, 0.21527969697925067, -0.2528546905375359, -0.44943757837320464, 0.17050735477147688, -0.5050133738654653, 0.2820624479878945, -0.2811050308653683, 0.17598516085393814, -0.07022236848602868, 0.034316152296221855, 0.7500126604051306, -0.0370121956353849, 0.20187066446775287, 0.02588594332159686, -0.25473025976970476, 0.017143195047995805, -0.12985412904174523, -0.5226182826320104, 0.08276618510354958, -0.045154335216520014, 0.4700122209293252, -0.5821642373392188, 0.13591852011797917, 0.107266521240175, -0.02532061201581766, 0.43856053517032884, -0.05434560315485247, 0.2947676652690175, 0.32598859959415755, 0.33407593937040364, 0.3462485207539264, 0.3575930524857421, 0.3390335683151278, 0.49408197580433416, 0.413012279825647, 0.1886712468528222, -0.2747048363299638, 0.21464225266487436, -0.0695428246369868, -0.2508523612195965, 0.41345056341320413, -0.2707542475073043, -0.5380156063226208, 0.48958886441896016, 0.45519282682492745, -0.2880123540604749, -0.4629476016351865, -0.3051728053073425, -0.07232595700037701, -0.4920933666408882, -0.2192494511934752, 0.3158782595668856, 0.3300910860748763, -0.4449039554556429, 0.14889173195848152, 0.2709669065265608, 0.37588590665539123, 0.37631308836541794, 0.14836068299015617, 0.2577258780217564, 0.03311024359221779},
    {0.08260461848029814, 0.26857086751740955, 0.42495059136377694, -0.12837189656709155, -0.3921599805532887, -0.463738229978601, 0.38811102658077906, -0.31000602042945746, 0.3491511218605516, -0.08076118975787809, 0.3074434250476884, -0.25697812454105423, -0.4632642925442519, 0.22829370759279394, 0.07987691619454257, -0.2298465558194376, -0.39880745750851876, -0.5805446088108658, 0.1625356364252765, -0.38366395149382765, -0.4678025310127868, -0.35804503777957136, 0.2026310316347602, 0.2741681620200683, -0.44660279909173306, 0.31897744547291573, 0.1451555084278834, -0.49872713228290916, 0.6829889929444989, 0.18726391108355034, 0.415332411185922, 0.3574137418877018, 0.14081977499673914, 0.2918826471619351, 0.1574684870762758, 0.29869832059238505, 0.4422508686858999, 0.16214851761972143, 0.24458681337884616, -0.13748167772623732, 0.10215977608828407, -0.1928652596483336, 0.14448643519544524, 0.24791864584410322, -0.5101223173207848, -0.12900385363283237, 0.19900040312465683, 0.2388207808051329, -0.3695031792389685, -0.18834359685793423, -0.3942060969874337, -0.24413152314937953, -0.6797773140425338, 0.07832180800116145, 0.48775442678411285, -0.20580543544150476, -0.34786163914628443, 0.45073290673076416, 0.400870615140187, 0.3938483493511562, 0.4063101835620313, 0.1376461755222111, 0.3577175139100882, 0.32909930036763896},
    {-0.2916867206452484, 0.26753606929740087, 0.5093930531490205, -0.008138635040749813, -0.3744218952996122, -0.638272778668931, 0.16475280009008283, -0.5411640311885252, 0.3742604821862887, -0.4444129800402811, 0.5613957471274873, 0.12754084315497916, -0.2732268395891473, 0.2213967917702149, -0.053062296386602516, 0.2632421316475181, -0.27305779485957565, -0.49399198909937686, 0.34120563112185964, -0.28945559338357263, -0.46797985142035525, 0.028386740199429442, 0.26661909443147336, 0.48421808299944874, -0.3044799695805182, 0.42161259782019556, 0.15753062457008538, -0.4607558816531348, 0.38967353933741705, 0.25354309794983476, 0.35816407769489056, 0.34984890991320255, 0.29159155534666625, 0.16727332494753933, 0.37587433987007085, 0.013731535331880396, 0.3158019371463903, 0.09182374242895898, -0.1468322637636408, -0.22616935839476388, 0.053851610175752636, 0.24848129555285411, 0.08027396149892768, 0.4190037531493483, -0.5740435811773184, 0.07129142054302241, 0.1394957252804105, 0.059674456688778146, -0.47006239245372045, -0.033019351160785505, -0.2428864469745682, -0.3050267429736711, -0.4084129711294995, 0.20988733981930977, 0.32349602546045725, -0.475237125527102, -0.738077378051387, 0.3911084655130521, 0.11531773962510798, 0.5291040205714215, 0.3099779618555657, 0.5232348398734218, 0.3513767446021221, 0.13324409206501153},
    {-0.21763596035269128, 0.24881465963802654, 0.07485083173021824, -0.20218185799878136, -0.6118210158115167, -0.3836423853179352, -0.0530213418684504, -0.40400601256580304, 0.24272605339459077, -0.10628285283195558, 0.3902816185434124, 0.07732708312666618, 0.09324516248292943, 0.5065443226562372, 0.23280095063884101, -0.08099497265596158, -0.4434017579528852, -0.3504458295382082, -0.09192563168757432, -0.14802676683947866, -0.24695636297783036, 0.2570580163123654, 0.32959559155366314, 0.3911638374166508, -0.39015161772345597, 0.10780301932326655, 0.1788679823073286, -0.29459497718434874, 0.388182362688971, 0.30195626890711297, 0.326534765112108, 0.24660746691945568, 0.5295708713771176, 0.1013754614718652, 0.5615297924427423, 0.09625903311390094, 0.3194152421976526, 0.1956490936485491, 0.268750873411899, 0.024490630555590965, -0.19224984267631015, -0.09476933422890331, 0.23800987133983115, 0.5621980281625829, -0.20988708828603575, 0.429049469802198, 0.2716099084543662, 0.08364383719863097, -0.25207225660877874, -0.24423282502676863, -0.4371197981743209, -0.42609198910807095, -0.31348180991925717, 0.08630649541965202, -0.16592565058308362, -0.4938991904491823, -0.1165987994845106, 0.2824943504612795, 0.3817951443398227, 0.5016839435922876, 0.7200656911957819, 0.4299236804733848, 0.264446151959794, 0.22804105618695675},
    {-0.31485175806046684, 0.19003494484829217, 0.17631194473922732, 0.0220820076967383, -0.5837570168099054, -0.3488759909625518, 0.15585250178921103, -0.5837678654291255, 0.30331649881034545, -0.17087253502589872, 0.5773348361739307, -0.10063348392609914, -0.20857255555271606, 0.32445173631675284, 0.28586484656124006, 0.05233883138222334, -0.5046460625030044, -0.47444250922888714, 0.3219878091312853, -0.10093623812302144, -0.4920763275049007, -0.2850944356822779, 0.2756435996744346, 0.2604913738224368, -0.47710576324279114, 0.3340620916132524, 0.09341012964592982, -0.6397150139865159, 0.4897256212088314, 0.4252297685335742, 0.16918528462642868, 0.03710578561310105, 0.3350689400425433, 0.0010458096546121889, 0.391875129346215, 0.05481352952913027, 0.19007978121248081, 0.2755806503221576, 0.05414364972751523, -0.5216682074090464, 0.2531243656345449, -0.09279620417225394, -0.032063368625864626, 0.15120573172186202, -0.26604833674862044, 0.2038125469434518, 0.2273441631092321, 0.2765244417165507, -0.7129397822775589, -0.5490988395969143, -0.42465857937877893, -0.31507497635935444, -0.35924549388973737, 0.1861786916194228, 0.06324158141212907, 0.08886943423442911, -0.26345774501188196, -0.0037132232655542542, 0.6553767021005251, 0.5527482852302917, 0.4656321577527067, 0.34714383627000667, 0.2352383688126664, 0.47948046143200934},
    {-0.09893358551947902, 0.4293173887836248, 0.043807644618744764, -0.03340165699067598, -0.46393194839107876, -0.6600923192235099, 0.09523863121249661, -0.574695483407053, 0.8065943458391504, -0.09958044773293499, 0.3205202916692838, -0.09644730338274936, 0.06970057436766357, 0.24784915034914287, 0.024867927016504993, -0.28066095100027305, -0.30808925551688143, -0.6091916020579645, 0.2067468928976509, -0.07489683601706737, -0.3156990568448335, -0.13038403506866805, 0.445103830238237, 0.4019459326342502, -0.7360045106623694, 0.46690018809507405, 0.4161877281656247, -0.25581681860966293, 0.49217245001431836, 0.107716672258943, 0.540552159011861, -0.02472881453977698, 0.09959094279206518, 0.28958002491051243, 0.2148594514011641, 0.2195826678244649, 0.009761411317035276, 0.19156955655916869, 0.15472868972625037, -0.5388147188739444, 0.17352433317745994, 0.14580626707816738, -0.2779918307343021, 0.29067046367041344, -0.18647129787267155, 0.43660855329492393, 0.5078775061449838, 0.11611322282967303, -0.24170583331471993, -0.6859740259255256, -0.33205248201357257, -0.28557234351217514, -0.2918910668695824, 0.19963035387801098, 0.006330034809287066, -0.03599256270391937, -0.21372499633089329, 0.11491941121338124, 0.16435986102955813, 0.4070346973100575, 0.18601983769078936, 0.5102530749609542, 0.13678662538980355, 0.14394422084806377},
    {-0.04186481550131675, 0.2816759771105132, 0.10837406076835626, 0.020902433355003913, -0.2381127552794074, -0.724889929481594, 0.42883357971915204, -0.47736450040113193, 0.2897284399230471, -0.08216933407126925, 0.2518342872887497, -0.1609822404725137, -0.1951395523780329, 0.392802840278164, 0.25446497507540283, 0.2681859425284789, -0.26035070122096793, -0.5949439675877558, 0.31383574691533733, -0.5640763345747386, -0.4206469629502254, -0.17734784928045888, 0.30189398738641626, 0.34698592595091876, -0.648978071067356, 0.33265111732230607, 0.35438971496373484, -0.11200356414343023, 0.2770106464419839, 0.3319127862422406, 0.3644056269005636, 0.23122225467932792, 0.23752189707921392, 0.38755616070275106, 0.3422793195410161, 0.02436161839403777, 0.47363865705853286, 0.1705674284979967, 0.007853297065848487, -0.2324014951596782, 0.03979573333076928, 0.06724581137221619, -0.40476585592702424, 0.6787393133472042, -0.7243230053317843, 0.08063667540176048, 0.46933208295679224, 0.14231312862675494, 0.01807867975334385, -0.6014587352958759, -0.4784953881416268, -0.4088751451761983, -0.4323549163136493, 0.35960111696313796, 0.3686524991343455, -0.2588300435713118, -0.1620349849543143, 0.21135435391555346, 0.3131195061846181, 0.4213065641002718, 0.3103196351816037, 0.07794176638817495, 0.348939492548597, 0.2714344418892842},
    {0.08101614637315359, 0.3334184055929711, 0.3664261314763019, -0.027334976478825164, -0.411224776771415, -0.517150735596691, 0.6374006345224938, -0.5067101644403489, 0.2524529316932438, 0.008719676148438478, 0.36918948147493047, -0.006858908702910956, 0.017012078370795148, 0.1531266952026683, 0.5115070307656723, 0.09074393028025327, -0.2923296507231942, -0.43676332456098954, 0.0798947238600844, -0.14630777403011877, -0.3843057820015634, -0.195677065687744, 0.11206655548229268, 0.2722504848580677, -0.4503164326222874, 0.42053314777712064, 0.34556502034873404, -0.4881259325420699, 0.23224104833065534, 0.33172274569951027, 0.30410485742326715, 0.4304265870125645, 0.392208598186658, 0.2858922513412135, 0.3473984950425776, 0.09397461876937789, 0.6805191831982835, 0.06745946742385152, 0.3613610329609548, -0.5067212799005618, -0.08696687724344357, 0.019599077737015257, -0.28003300266138775, 0.4361132013768012, -0.5155350027726114, -0.2591706145903338, 0.2837480992338276, 0.17854694239868682, -0.050402921934561154, -0.5434488319723563, -0.5644832405471509, -0.3872414749671527, -0.6421400810905575, 0.17444258273494068, 0.4688170663290438, -0.3381986914905732, -0.21985707799089674, 0.032677098620984786, 0.5676550487533604, 0.38537153027011256, 0.4495798591151903, 0.49391757845268686, 0.5043296572364622, 0.46267021428697125},
    {0.14868008298929322, 0.34125139407971994, 0.17632719583026782, 0.04499544821832007, -0.48280495987853417, -0.39044166384129253, 0.13228676307623594, -0.42831394707220843, 0.37391390513612055, -0.06365999958363804, 0.3094080766960628, -0.1911287937516558, -0.12473465429933502, 0.34805656349081404, 0.05794129735744534, -0.11571641830409249, -0.16993545232477142, -0.5034871725438191, 0.3817602551855978, -0.014676400152800933, -0.3277169480386359, -0.3427524961473027, 0.218392714251458, 0.2785931297548111, -0.4237723530689442, 0.4211865246422496, 0.6365713316860537, -0.38901119385775523, 0.2984097006482117, 0.2516692495507349, 0.3801141917440254, 0.270729273542453, 0.40113620929033356, -0.023696296432265552, 0.3151148939179558, 0.14048732225080363, 0.4648135168511879, 0.08920906920596984, -0.07952081253928892, -0.45060979246191396, -0.0929619360397986, 0.37094344351374003, -0.42324400927918054, 0.3806397490254592, -0.20973825613529382, -0.12569407114438957, 0.21145933743190484, 0.4349789926866456, -0.5207587757191312, -0.3013564692730786, -0.40519068701807565, -0.29320187892763494, -0.4689412642772781, 0.27098020129860684, 0.28864439115033896, -0.0407042368030487, -0.20014963890300552, 0.08436356931858383, 0.4428805965821449, 0.5745249362518545, 0.40389558383061186, 0.49206660041050554, 0.08799041677081508, 0.17438793016015497},
    {0.24135719740580147, 0.690879102976028, 0.49849669024555454, 0.21490674481798341, -0.33090939098600325, -0.4688779460193759, 0.3918941346477101, -0.19492979084349743, 0.4670030551547911, -0.4643899622660143, 0.4289438116436607, -0.07274305423338344, -0.12460706056793877, 0.3121812755428904, 0.3880664342267455, -0.15581761425734098, 0.0655203821645255, -0.3274273950627906, 0.09478622707392342, 0.05132324668744352, -0.49294290947091207, -0.16454956535761286, -0.017638065952224714, 0.4029321122388097, -0.5725751061092963, 0.382264365407251, 0.07369949756302975, -0.18834346293312096, 0.27272993562764214, 0.2927595916254459, 0.3910213924751936, 0.25232814832607275, 0.4149879020337423, 0.14935464841280055, 0.3689893510510505, 0.15771157920807868, 0.4371749485670368, 0.2014004122293987, 0.11305728619179242, -0.4245212012403364, -0.2694033977313922, 0.3535201339175849, -0.30667822252032656, 0.335420416166673, -0.5347582591808404, -0.30042443943771013, 0.394409973126973, 0.3655578569269683, -0.24429609054321733, -0.2888026470780884, -0.4461477444461632, -0.4794786198834595, -0.5178379791542543, 0.24863236826851712, 0.4035547484366897, 0.24873133115647017, -0.39315214827535744, 0.2490294843707037, 0.33136887029136963, 0.30355296362000384, 0.36850325545971346, 0.40009434987079223, 0.26266035480768213, 0.19916271746069036},
    {-0.03282605959484316, 0.35756723704829024, 0.3595094164159226, -0.11531893596205631, -0.5116037003096466, -0.6004920402657306, 0.39062447717952636, -0.6902667209714193, 0.823368729216908, -0.42010507634005606, 0.48113816669765097, 0.14776453159539554, 0.20799997510290277, 0.3505237411160596, 0.06123313160528305, 0.3075812559886356, -0.20123684991994922, -0.4569822533885498, 0.2585592778135377, 0.006863021121623305, -0.5567867495776384, -0.09767150869289791, 0.2757791812993903, 0.4937248856345713, -0.8273618575325272, 0.21959167378655903, 0.44185463306174527, -0.24351526234693202, 0.380427002438486, 0.4836148693807613, 0.7296053978001314, 0.04170321249806339, 0.5031283472283566, 0.28214285750647, 0.528538759366727, 0.0151549224851971, 0.6068545371512228, 0.3035645986296007, 0.28793127651991557, -0.9022593502165709, -0.13394122576961218, 0.12011374434499074, -0.01986271907038764, 0.19907640314167754, -0.7655088630569988, 0.07693133228836434, 0.3762290212737579, 0.1593031771889411, -0.38841220582590197, -0.26049217464072333, -0.4279706000228485, -0.1919862554454449, -0.4684021238141615, 0.5282818628543975, 0.14173653008812917, -0.16081475054924058, -0.8666864461582681, 0.24318860860239208, 0.3696189232480356, 0.2067468822432629, 0.34443423660251005, 0.44926432614887396, 0.155702565999612, 0.4133856269951067},
    {-0.13878162309803624, 0.44662619284090893, 0.13798288549575483, 0.018541564583751047, -0.3798159070388535, -0.5051874726038453, 0.49955209814530277, -0.3449556904786836, 0.6236677589327484, -0.3574446082525479, 0.570621817043447, -0.25880977307657116, 0.1611343794392534, 0.478192863872243, -0.19926106006016273, 0.36212990101042014, -0.22122994463703896, -0.43109082136576227, 0.02996303559231754, -0.6129355002156452, -0.6313755775433284, -0.35341250321182516, 0.2411143141011347, 0.419274277358284, -0.5207313516884966, 0.2362107119559588, 0.4607910795930497, -0.46045235142712176, 0.6307886496688021, 0.11135256643237416, 0.38333153948194415, 0.053598749861141756, 0.4987113127802649, 0.41834996619842346, 0.5264579475416418, 0.3165339803063211, 0.5052130754104959, 0.3428417017143448, 0.4636051765348509, -0.45510689034628876, -0.3490139151103476, -0.025376521441687658, -0.4121336855412464, 0.23651312448240513, -0.6443884992007656, 0.02851563762789407, 0.2229960545221867, 0.05170789364455157, -0.16015100319809158, -0.3945254415830332, -0.5581214249418285, -0.039145849601697355, -0.5793380317694691, 0.453150289731322, 0.423594290828053, -0.42332597924985427, -0.5075275662042485, 0.39289318485064384, 0.1626121320419722, 0.5684503662180719, 0.7556704256355055, 0.22554827544112224, 0.5978812894658302, 0.3864250154826939},
    {0.18288709762399846, 0.2925334284550348, 0.3760601709841661, 0.2176220547302336, -0.18321843247485256, -0.510005315038312, 0.47122378777065504, -0.3538077647955007, 0.646694429002332, -0.4155300541477986, 0.13009581306127027, -0.020510028090654737, -0.21923989003212688, 0.4984914702487696, -0.06667821869283051, 0.21600645567443472, -0.13362024943354417, -0.6533390437476194, 0.2469214374218111, -0.4045107393460746, -0.31993193011851845, 0.0016093282478700489, 0.14564392450135985, 0.2691337160253755, -0.44506098114309833, 0.39093496769421177, 0.2948893392743229, -0.048224953847108454, 0.2582974192099286, 0.26654299343032983, 0.6405476868278989, 0.19117903271541964, 0.18768649762644254, 0.025986537066144125, 0.3633870156839624, 0.2788867500474806, 0.36161364805286617, 0.04084276424443701, 0.20469597960078711, -0.4271572077288846, -0.12882423540821497, -0.14744775771289417, -0.13788752169351615, 0.5962370678854851, -0.31310473084664087, 0.15092511748880091, 0.4135809950536541, 0.1943420093691774, -0.32474730422205883, -0.49225893762197404, -0.5950916138065656, -0.21437798985177778, -0.31819833958024546, 0.44546416108762227, 0.3002177026212099, -0.41987201824783005, -0.6654205178767886, 0.30178484851875675, 0.44276377792455174, 0.561853012253553, 0.3123662548197223, 0.13487087349176458, 0.48353941232861297, 0.31705111164417044},
    {0.13459782210148005, 0.5538414017323233, 0.4417232164649475, 0.29421171104303445, -0.39043279368592904, -0.4797981991120215, 0.18086635475052978, -0.3762671880189996, 0.6733539773305423, -0.3807079453663267, 0.20774290433944959, -0.2620292692321747, -0.45606254953732756, 0.17075643400100737, 0.0876838351761921, -0.3474734236841995, -0.494742768742844, -0.6273913885883872, 0.25044043667296423, -0.40465960450593735, -0.40590016562147324, -0.04628672966457949, -0.23782279809912268, 0.24745351815109576, -0.7309043452405201, 0.22753317210149596, 0.5478027838417951, -0.21321949095645876, 0.1558526049767408, 0.357882341869755, 0.5194383016199315, 0.08560935335519478, 0.363295824730994, 0.2925963876976675, 0.4331606949051193, 0.30028462362891495, 0.33401562298465726, 0.0625763643723533, 0.2646773570358078, -0.27203785711608125, -0.3875968487637529, -0.22395472870372984, -0.09139799235448845, 0.1832137113634692, -0.41242809961250987, 0.02263981663809093, 0.7091633421152653, 0.15725792955118736, -0.4317823797013699, -0.5124725434396559, -0.8178264777603619, -0.3394582617011378, -0.4632200908329524, 0.313107600624473, 0.16579339045800257, -0.49722802217276396, -0.35035769585873877, 0.2647557544963506, 0.375448809862955, 0.46756278878199564, 0.49764058380133264, 0.37570670625410896, 0.5512414716331353, 0.5106493051632465},
    {0.4099263268013075, 0.25051251158209514, 0.6208997462788337, 0.2421841093530624, -0.39793777572024575, -0.7504581974865155, 0.15169074427766854, -0.5423329534860586, 0.4217458280938815, -0.2644014004334043, 0.22705532223379432, 0.0010770391345727435, -0.028052638849675574, 0.36274976528838043, 0.02067750224213226, -0.04864081281276522, -0.39816068967451274, -0.624528757734651, 0.26052694949126903, -0.27930970796792687, -0.6884844348585727, -0.4751422516103305, -0.27229921622013165, 0.19697164705673517, -0.6274127689116688, 0.3924528279955555, 0.18106626630230954, -0.42369480902643636, 0.07157965056576153, 0.3866745097037736, 0.4456085889278656, 0.2604217250749951, 0.4096456844206417, 0.2050984905055969, 0.42613703628874033, 0.2508808423779653, 0.5915676147422837, 0.08896393182391066, 0.27018063848904006, -0.390922000150096, -0.2201175901356869, -0.23751952269711665, -0.12183649936072619, 0.2361636356408072, -0.32116695121138406, -0.031040134494263703, 0.31470087398302443, 0.44459003298701133, -0.3898863054607585, -0.5888955419844444, -0.5533665516878202, 0.03074775000383088, -0.5674449696034456, 0.2530934601844532, 0.16444106341978432, -0.4507979813953949, -0.4060848451039944, 0.4060018708855785, 0.1257971172514084, 0.4454615710055359, 0.7420069957170464, 0.40269571355232747, 0.3246067789486317, 0.4455416633413334},
    {0.07168113232806486, 0.36059695063151953, 0.6142249745420912, 0.2462552800232002, -0.46919937578063164, -0.3315968244198532, 0.26913009953424055, -0.5046161782291319, 0.32094104629444486, -0.16651743124725663, 0.07248149776911186, -0.15600017319369613, 0.1711636787315704, 0.495847645535226, 0.0977289815458449, 0.11596742399320219, -0.3849076394131342, -0.5433675967311695, 0.1417281408331463, -0.16486191502681352, -0.48113387612220604, -0.23206223763553938, -0.1664514997426777, 0.5939246024847796, -0.42321360807167857, 0.48634151351077337, -0.0897958189463436, 0.02194605840547887, 0.6013536695433538, 0.5523969484154644, 0.06079065179016631, 0.11439368472338031, 0.2503374656139122, 0.6529237397616486, 0.5995943095810521, 0.25544040740010737, 0.6413112939453138, 0.194979879159675, 0.42624008705361877, -0.5140767834884029, -0.175295730871335, 0.24557499961250132, -0.19676634986039868, 0.4324029500956582, -0.4043811925175826, 0.23592392548802385, 0.5916945416457802, 0.1999027477246563, -0.16423497445824004, -0.13160536537833267, -0.4816877532067884, 0.028254075450967864, -0.5262123682266642, 0.3382669049791543, 0.3751374846715049, -0.11063444830711462, -0.48870350928482037, 0.32949991783718063, 0.30722556410303403, 0.22570341088342108, 0.5568180087514706, 0.6176673178353508, 0.4141978963490652, 0.6160191689536291},
    {0.2715059651608405, 0.2065735511559712, 0.7938297430469827, -0.10569553227157945, -0.24913599829136182, -0.3625891524768246, 0.4861150423452662, -0.43462008880902747, 0.5291927144676883, -0.2488690040664718, 0.2375142362042473, -0.2247704402498714, 0.03105771685900138, 0.6439203680260208, 0.10363257943688071, 0.2129441456391021, -0.34610312512191643, -0.5391473968856537, -0.013018782828034708, -0.21602924081425234, -0.3972418228027084, 0.12383593224793629, 0.0208807540920329, 0.6229048296387757, -0.49226961768788063, 0.38909348050725817, 0.5894509781961921, -0.14856169348107967, 0.6173143111539539, 0.14438057664664156, 0.3003150954385545, 0.25060241470156325, 0.4732668265999117, 0.6540942311696426, 0.45638281660368885, 0.04100353964371367, 0.46128753750873236, 0.3092494484069335, 0.07342262744257279, -0.3068767582671493, 0.03000065980181375, 0.2687200838418671, -0.2274317822936512, 0.29073277120023217, -0.31139159333052585, 0.07182015771839932, 0.04057842267913983, 0.3887702172093796, 0.01684407308961006, -0.37193859044492955, -0.5543187108615379, -0.20716905398565302, -0.49235724126936853, 0.26374668869865425, 0.3830462792297039, -0.21253992756305592, -0.7285758931899292, 0.09346050408465134, 0.3730901370156439, 0.32221136021058316, 0.6294504641885841, 0.37864505075287974, 0.4204007075123732, 0.32822153190174747},
    {0.06022057521112198, 0.4970516571237849, 0.6658579085660786, -0.04873506688445434, -0.39493485237132375, -0.5868628803553019, 0.3671108035313833, -0.685295763431101, 0.6281234736598879, -0.22533393851469835, 0.5786535411152979, 0.1788414710731489, -0.05805787293869234, 0.3878887542756663, -0.05263224624981778, -0.24941455794356202, -0.36091043960960084, -0.5867494488999728, -0.04866610750952233, 0.0022185283061605, -0.28974372067293513, -0.11943915327512804, 0.07493325696759576, 0.0952666467743654, -0.4386597091292747, 0.2793456854587251, 0.3349064994088227, -0.07347597391374827, 0.5387736734007889, 0.27676176190690477, 0.7033630466111378, 0.1912905142121047, 0.3972618279196897, 0.373810948451535, 0.31571455138541044, 0.20765117235847133, 0.18404769974187465, 0.04458269425512334, 0.485896178752158, -0.2338866661581919, -0.09696673054064622, 0.11816055441844016, -0.08808274092033308, 0.17376867025860898, -0.24198656245527805, 0.10338041536549507, 0.3118461904962685, 0.4005138778476595, -0.0146604476455121, -0.5490273692473191, -0.6045344709752104, -0.22862419711548362, -0.5704950996219733, 0.35959984849247, 0.41471466592348966, -0.38384202081509017, -0.09253505147820752, 0.2780685306932057, 0.35425460803126557, 0.1260203163946558, 0.43129506741194606, 0.3142621561443345, 0.2800815397682389, 0.5978463139062146},
    {-0.015760384956111564, 0.7798187931975551, 0.6598424524852593, 0.18733296418647713, -0.48519400923549155, -0.6769836201013508, 0.16996376270643646, -0.6154688495771675, 0.3329116348868169, -0.34039923277093065, 0.2580624879577043, 0.12809887796510339, -0.20032016809265074, 0.3371347022204306, 0.4890106591585219, 0.37186179678166, -0.36189551278399695, -0.6896102495170309, 0.2451964621604727, -0.018820802852693927, -0.3054197851025553, 0.051437489463271084, -0.054856310949544004, 0.28299772577487964, -0.33623257484319913, 0.2670723045579505, 0.20121784730346845, -0.5191051330801698, 0.6393944767993041, 0.31362646571228814, 0.25389502796793645, 0.45285987391082066, 0.13519205264546952, 0.34378256985660116, 0.34404602941229634, 0.26490349635458343, 0.18752247472113218, 0.06820364324532782, 0.3316340161738212, -0.32289420295681015, -0.24167996545780496, 0.08926757892467664, -0.26049663653061306, 0.4100179927279307, -0.538939875639908, 0.17440052242637447, 0.35860734220226875, 0.19592563556208642, -0.06613783472786124, -0.4123016394924837, -0.5112465083192681, -0.48128007871047546, -0.2882919592054687, 0.4835639449090111, 0.44981293091780566, -0.16341174642470555, -0.24343986042451984, 0.37535522630923035, 0.37042418618396594, 0.7024116207088232, 0.39531935437080223, 0.7832098691188325, 0.6019818755367385, 0.4716453615954778},
    {-0.26869795954429726, 0.5167364987898289, 0.5484511080662211, 0.1408780233803184, -0.5375620972994932, -0.5355555891173612, 0.22156192329523733, -0.7522012005535691, 0.23442581376140711, -0.153817724580485, 0.25257915472172954, 0.002259548824055196, -0.10684892245491313, 0.30899220026036656, -0.19537389068530958, 0.3151686071772507, -0.21520364175767784, -0.394779019888927, 0.29417624157177963, -0.12710657150123103, -0.3390592227218264, -0.03603499780016473, 0.1937772046963288, 0.5674817706067613, -0.24957569823035622, 0.43626633919287416, 0.32817658326283033, -0.2171752435461133, 0.36017235733025615, 0.48387659158209484, 0.5438198846787649, 0.34534121839273324, 0.032383376050950714, 0.42937088439595766, 0.44838583844014496, -0.01253224246379339, 0.7093920040293787, 0.3997432820127587, 0.26476016037148214, -0.35354037237752733, -0.13238939879031714, 0.29469936587578627, -0.32927494176399447, 0.31939503052186874, -0.59329776079084, 0.22879507241866567, 0.19864179142859598, 0.2972253623571726, 0.07091035005937558, -0.48503459632718326, -0.5683691999459011, -0.4744235375717718, -0.4887974916810271, 0.2192562394495338, 0.6297274665094568, -0.14660040451078252, -0.5501551723558161, -0.16436069957931315, 0.5389551354275934, 0.4133475383990821, 0.4258298931810221, 0.5885210633999272, 0.17111537001245697, 0.32834487365917797},
    {0.06166514881961317, 0.4575960237277286, 0.6553595701145147, 0.4245433418306315, -0.12229180211062306, -0.4952382388028551, 0.5281419059389293, -0.2980273235024037, 0.37947512995602545, -0.3257033157406815, 0.37440267114849884, 0.039669541872931306, 0.07258848094290846, 0.4345439044561832, 0.44169082637420726, 0.1269044094119234, -0.015230578254267052, -0.7307115055110269, 0.5140007155569217, -0.04073796840869733, -0.6206334966865779, -0.22033698501274462, 0.18642201449149642, 0.40903482252996476, -0.35738404100760823, 0.3951437763009538, 0.32926522960647864, -0.0891194067426984, 0.5151545554744548, 0.6012916860737342, 0.30610495708990576, 0.591298222452664, 0.25807858836789394, 0.17557277750726394, 0.5466695922309942, 0.20415953039459842, 0.46009963106311214, 0.4515987535267042, 0.13025643818393973, -0.3272434740763765, -0.1467389999668787, 0.5659856068292807, -0.13049638847536946, 0.22520200429535597, -0.4889630469987919, -0.011456935208271377, 0.5692129049812307, 0.44620874818734907, -0.001628572864451866, -0.42989497560741585, -0.8756047707602153, -0.25085480816212313, -0.9038625168974722, 0.10210437436827766, -0.01348868662095946, -0.28975229146699777, -0.46364320328142383, 0.3594338454691443, 0.4560459851285674, 0.5597042836650453, 0.3469744979576548, 0.2982493952403459, 0.3802622235257185, 0.6892070049662328},
    {0.3033566533728481, 0.5497754955266684, 0.5654447290938461, 0.5891315145009519, -0.5653232799163195, -0.7849378843070972, 0.6907957354246196, -0.7550972496248872, 0.5694736587014623, -0.17432845588903842, 0.22704565727341366, -0.07881592489716051, -0.13416466926385825, 0.3711422898658648, 0.2422087570475274, 0.2999556793126126, -0.29414518530161265, -0.4890397977175597, 0.2748437889007176, 0.1028694460732815, -0.4355398857829262, -0.08182627088295066, 0.10008272485278652, 0.7118113582044968, -0.6468041528816098, 0.26254027843654787, 0.2631207918329609, -0.4000873815626062, 0.5029943564217199, 0.1557449589342161, 0.4445196015316648, 0.4476325976528844, 0.4453422468202247, 0.34348843431619336, 0.5713249331533495, 0.27930493872230044, 0.6010998915970638, 0.113754484872509, 0.2002434531577446, -0.3801019768239612, -0.37037817368944514, 0.23764904589115887, -0.4747119686008594, 0.7015048676536885, -0.2861742604785027, -0.10484554629166198, 0.1998577915419198, 0.11826299712472553, -0.15134988480435302, -0.30876671492351654, -0.6189918498893517, -0.4444470003641807, -0.28927763723717514, 0.27685067488638704, 0.2900533826407119, -0.08979041116545045, -0.539175388329367, 0.6161183802145492, 0.4539854549556259, 0.29402936319799494, 0.7220595612348147, 0.29310559381426393, 0.37475051595008396, 0.3089152689222953},
    {0.14206923965693197, 0.4860425369849437, 0.06591930737071089, 0.5049936402499952, -0.4679679480798712, -0.4230463386271103, 0.28855994954207287, -0.4535734628352243, 0.6551432484406842, -0.19250359342350426, 0.19873842068319444, -0.07360836567452678, 0.0026668892391950444, 0.547925081619159, -0.019190650247440294, 0.32160467385201247, -0.3210603123963463, -0.7515395511174993, 0.326129882896462, -0.34264790871762185, -0.40359167259648465, -0.03741000158840502, 0.28543948404216346, 0.3502778647863517, -0.5842930362461608, 0.41923435842284823, 0.3828998243058042, -0.08736519896538132, 0.7172687771873736, 0.4548904819828825, 0.4654675709562328, 0.5269123781477524, 0.2568244074572784, 0.5283429402983076, 0.7005613609854275, 0.17401242582160426, 0.2775547536635083, 0.1692928322009777, -0.09825468898666455, -0.3290166442403159, -0.1564882906432754, 0.25032621523446524, -0.5491356435055998, 0.6484431969951551, -0.4075839190669679, 0.017058744605735057, 0.4040622484687485, 0.5597480220100531, -0.37538429210521207, -0.464587088234394, -0.4607468146462409, -0.47571905627367506, -0.5008800883682385, 0.3187149810116075, 0.3563262809302298, -0.11658058638102246, -0.5641074396823117, 0.2795792727480633, 0.2107899154324533, 0.40018698725082985, 0.28012013674309666, 0.4664477705275785, 0.46181704389026357, 0.5702477138571916},
    {-0.1478723452044102, 0.49565186988944454, 0.539157512073913, 0.3158637689211361, -0.557437159614409, -0.3742888791873998, 0.5352829448384346, -0.705628086511592, 0.4687484781765344, -0.4246338029412161, 0.29333634322752417, -0.1470228421187805, 0.19451484378481346, 0.42542338949884534, -0.099533389445927, 0.472950286089413, -0.35840972330862864, -0.46338807083865974, 0.38299494173825205, -0.3318026713354433, -0.471027121210068, -0.022159235338357196, 0.46898867053400917, 0.4054990229823373, -0.49118204439088015, 0.5212628047843895, 0.26206178247268425, -0.06999171794079626, 0.37522191486088724, 0.2839347397147858, 0.6304806343505989, 0.14387649151795934, 0.3028522989933594, 0.20927271731040803, 0.4440446043650495, 0.11617632658846118, 0.4895333059677492, 0.3605016602176398, 0.0698094687756664, -0.23710279463840567, -0.23479022476647338, 0.029504066774626952, -0.40420580821163976, 0.47237008610340714, -0.2260296925598141, 0.05780284305789152, 0.5405001719153576, 0.5015312902986865, -0.3749856569198348, -0.7605661566303847, -0.7419072292781541, -0.3464460971472405, -0.5405498151319386, 0.27446020851750874, 0.4235526631984715, -0.05133756952422561, -0.4611280377959968, 0.3077053258733111, 0.6157838186950418, 0.8578236043323014, 0.4716886259802987, 0.5316299303205897, 0.43259794216686626, 0.4199838792367379},
    {-0.08078726267122195, 0.4915877551958255, 0.3966889611404128, -0.012432808203690854, -0.7794981767160981, -0.8746412272675707, 0.47468849892581433, -0.6581851292451966, 0.5067442504494024, -0.5166356889393137, 0.38320384594314555, 0.09477977198652174, -0.06805481246532535, 0.48644696898487455, 0.23616014870946284, 0.47124605176704676, -0.4651325787944441, -0.5766813628845788, 0.3810117424651423, -0.42968411247750676, -0.9101922331578894, -0.23088845515589307, 0.24146084454927708, 0.35536203737572525, -0.6144947842701374, 0.518744389075017, 0.2912101640024678, -0.31051521051969977, 0.5181698037956769, 0.2836944679510706, 0.3211813111535641, 0.33518892466597383, 0.4257694887134809, 0.28312187456324334, 0.5117456746553193, 0.20393768610388158, 0.5357579682991612, 0.20035498465549562, 0.16693762596786543, -0.3535470295285832, -0.07429036386359379, 0.057112835479223724, -0.2555780367774234, 0.5340570829151887, -0.5147705143354693, 0.12457149333750955, 0.15268422603730056, -0.07640641532487791, -0.3320820703017239, -0.2064309130974541, -0.5221752115741363, -0.5433753506218315, -0.6129717606183893, 0.41216520065867446, 0.27203621915118936, -0.3278917835424347, -0.5551818048896987, 0.16595382933568217, 0.5905597580766869, 0.4755983480473021, 0.4116021010746173, 0.4745005700457827, 0.5126963136593901, 0.50727410236191},
    {-0.07740897857978067, 0.8375565896919714, 0.4907773310111271, -0.14067746159030056, -0.4507001197635385, -0.41805158489579625, 0.586564666367724, -0.36087795608242107, 0.3326769588243474, -0.3601980567763431, 0.35962584772115885, -0.3263375979325664, 0.1766267120772765, 0.5351467006101864, 0.09490877377612636, 0.47127741523749994, -0.1742178261516113, -0.4246901350337426, 0.22596210138949324, -0.2444655693452464, -0.687127171794789, -0.15991322596491236, -0.07148799812156274, 0.3283389211849068, -0.5073091221907609, 0.21582245323518226, 0.3924584099260132, -0.41096226707234673, 0.42409401514736467, 0.5128766027450754, 0.11040261658497628, 0.47148978722526597, 0.37361460630849264, 0.5286772807621982, 0.6878784627972857, 0.35481684393442786, 0.5929448824748579, 0.37444643027690466, 0.17809047082519627, -0.37919387163400886, -0.4758293459530014, 0.34503943506299223, -0.1432123497458434, 0.30970146853118546, -0.43672747224764064, 0.17537821441104273, 0.4280515348408091, 0.17219375561990016, -0.39768994451396306, -0.36951543518840385, -0.4550491264815994, -0.015274250778211845, -0.5161162991399721, 0.43433237781796696, 0.35995127068542376, -0.29518976224817745, -0.5690357897934102, 0.3398694698874013, 0.6653374964164794, 0.5442598886684182, 0.73708439325337, 0.32376196571148136, 0.5624051246334796, 0.5034047112259137},
    {-0.04357984512322297, 0.5091293815482619, 0.3089927308857436, 0.2028359155793813, -0.26348755902469706, -0.48608501363323714, 0.5616200663366111, -0.24482396586121943, 0.6622763790558969, -0.15332875685034703, 0.4918097365713943, 0.003205474871366892, 0.026455592272896785, 0.20914071519063315, 0.21522853672029313, 0.25619967636648067, -0.28563984692747607, -0.4573215964675593, 0.39478744688220646, -0.25510954927399043, -0.5872484621793025, -0.3250835338772183, 0.099024965988169, 0.3245673349656541, -0.45884589078654703, 0.3218158114241976, 0.30593316393877135, -0.22732836093210648, 0.47767072139177646, 0.4926358732324758, 0.29147493687513437, 0.20157401365928418, 0.45196659812122464, 0.4217666799161563, 0.5552934991354656, 0.26441519891795773, 0.3870023624289031, 0.004070510324140731, 0.22108792323202478, -0.5058696299254958, -0.06482350043502638, 0.2433088619522069, -0.5660507341077143, 0.43042653469301073, -0.48615878391886963, -0.18180523560357414, 0.38414729343268517, 0.49836085094044824, -0.18504948419099826, -0.5205749160972669, -0.5630201836606771, -0.29103644868687956, -0.3848256254507434, 0.49350035375307183, 0.2785890678664822, -0.021295612062061434, -0.7052599037286706, 0.25880603900514854, 0.5690851907230972, 0.4132005460370727, 0.6956726235650186, 0.21238027872565346, 0.40294125126405317, 0.2618596922799893},
    {0.060140875008264774, 0.13656487969059172, 0.3939823788573406, 0.35598732221466056, -0.5052951268482835, -0.7062228554705862, 0.3937664573884624, -0.35311301276079216, 0.3352804207123804, -0.2841738166845295, 0.37076582789908213, -0.23836856450706578, 0.08968625971329476, 0.24573254817908496, 0.29861133794705136, 0.3024025896565921, -0.17305585839328522, -0.9126349615869381, 0.09447732712289574, -0.18676095360680586, -0.4690612560079121, -0.03688485016158329, -0.010409296494853705, 0.6296642064813126, -0.5912654010932814, 0.5815368528905719, 0.1867587621316372, -0.3088644754074729, 0.2733707157233644, 0.5578208281902215, 0.3151077558332034, 0.34015312316606844, 0.4765236001018069, 0.6356675136966043, 0.5779789847514537, 0.26922558326954255, 0.5624508126308655, 0.1745244113529267, 0.13133073872503048, -0.41439752223960097, -0.5771142991434607, 0.41955439252848625, -0.6659773701115834, 0.8376557581908021, -0.6440369713051594, 0.30482102282719403, 0.31254407868445755, 0.3154818878739654, -0.4301545420450306, -0.20578913995245765, -0.711446051289741, -0.5214602528888177, -0.28540814816249666, 0.6041835898614506, 0.12455894223784499, -0.3555217906107872, -0.585439705131147, 0.5428507407133771, 0.5336909267899438, 0.6870580700477482, 0.5853794542882244, 0.35574545367732313, 0.29851541771516293, -0.04018018270824343},
    {0.16529422004897587, 0.45684691301681296, 0.5664444394662791, 0.25745608024942196, -0.7056371824999202, -0.5120952320881722, 0.4709779683132475, -0.1672395802483104, 0.6862624971958946, -0.2913430776712077, 0.32231822877369726, -0.18158306141846464, -0.26713237760815095, 0.4044479182096654, 0.11009851832902647, 0.45546630310353287, -0.3519685901759915, -0.48927727363756707, 0.16498867018889998, -0.012481298127418022, -0.42793777938942007, -0.13726125406968837, -0.08857691606775975, 0.37447585669210715, -0.5784148304361773, 0.16951329396925927, 0.27324017176049037, -0.3134769012519304, 0.0904213133463121, 0.37546330981848147, 0.33111873345293874, 0.38401769573185424, 0.47932475787711837, 0.5294481849875526, 0.23832861203699707, 0.2616677262880049, 0.3202213778489536, 0.35635651796622814, 0.17845669277491555, -0.6191083120080281, -0.3469426777209333, 0.31990504956054, -0.23569186620634563, 0.4804067056179168, -0.37383419702403187, 0.0071793179021057574, 0.35926226300486735, 0.13697759342493826, -0.5530380817222699, -0.2677906785467367, -0.551497596914925, -0.28109890297488704, -0.5493102767758314, 0.1004430941349357, 0.43480623560383136, -0.25380447215406954, -0.6553396362254614, 0.34560464538601476, 0.39405142364846296, 0.536229598660039, 0.34389600526619374, 0.41007202739065807, 0.18052694547972306, 0.3643996926707175},
    {0.3765684896815846, 0.009978292519750418, 0.2573391814385073, -0.32444254841069803, -0.19640495794072094, -0.40804172737940814, 0.18744032064996496, 0.36925716778835493, -0.21220245252581849, -0.40254157014695513, 0.0018262657291317503, -0.2579263519296359, -0.6445789487639091, -0.2573151756979327, -0.1278249446990326, -0.19528003790083354, -0.1822325662742383, 0.20772778852098608, 0.12546643826257978, -0.47698929085821734, -0.0430625152278991, 0.26536188966623686, -0.3858935004065847, 0.059696531355937665, -0.3622647342653788, -0.3612055644442941, 0.0915070011656107, -0.22992183677802902, -0.6117840999319977, 0.19360138640167, -0.4669057116445836, 0.18697118256754175, -0.12882133888009362, 0.07839530871745068, -0.3586286828283376, 0.3854298107687496, -0.13452944647191847, -0.18820733356271555, 0.1359455773098618, -0.009501113265661401, -0.23160152610438378, -0.033967895134448124, 0.18420709973032745, -0.3221364881451557, -0.08939443547996996, 0.2919292854896871, 0.29398980600330216, 0.21880576364988655, -0.5922224408615644, 0.7400728644868094, -0.11434366847615011, 0.03467102335997194, 0.14076060577213517, 0.251374370369136, -0.10210475614711302, -0.22261533450875373, 0.18151747184004785, -0.025126740641302023, 0.3767854165028332, -0.301187139707608, -0.4063907216653007, 0.044682964250234165, 0.15351614990389462, 0.10362235894025777},
    {0.02559077689421768, 0.30308907654387884, 0.1327737283355609, 0.08407602613999565, -0.2616988943023406, 0.512211119644214, 0.20480695489270856, -0.16760143598707333, -0.013755471878553832, 0.33083869352599077, 0.43439698908677243, 0.18599186018038041, 0.25836978422181034, -0.1514112181703931, -0.1148854563940768, -0.147129347355255, 0.17923909280536726, 0.0516468173361275, -0.23034389395222385, -0.16064522068626053, 0.19656978229362532, 0.19656978938509628, 0.6165353442269202, 0.12932847703760644, 0.06505885117421718, 0.12971791539450198, 0.17463215305177165, -0.033665075665180594, 0.18208133706347682, 0.20963010146034314, 0.0868520491591719, 0.2015559928590072, 0.0821809339614779, -0.41233370079333376, 0.19206661145990844, 0.20133912926283948, 0.012403905864740737, -0.042784828985541146, 0.3350617425267901, -0.020842372705873864, -0.11628957417496677, 0.13272049831223023, 0.5503398496328267, 0.0024248106138216176, 0.17606839229365714, 0.3505271868858835, 0.3423668951899502, 0.3410492510409035, 0.27069444662567765, 0.25485071718279834, 0.2032004479350716, 0.038161833645186986, -0.013170562533771602, -0.12019948274406571, 0.3441696099712654, 0.14019836284781861, 0.03869614238733916, 0.21255645312924493, -0.012025423765878023, 0.007156108415663553, 0.5286837395500282, 0.09688386720074746, -0.011505429326822714, 0.39228455368914517},
    {-0.4713090011632356, 0.28677330549913566, -0.21391015709226277, -0.3975409054267097, -0.44718495140743403, 0.15853714276419226, -0.018073792471469025, -0.168312457356773, -0.26630577032537667, -0.09424926198012128, 0.12936403225339463, -0.48234257139629655, -0.3968882222541099, -0.4842258366137912, -0.18882097871925627, -0.34119949847379505, 0.027315255617450795, -0.28575598135574165, -0.2733752278301033, -0.5246998402481493, 0.11906093422556972, -0.1954103782554409, -0.26128783322762933, -0.38498574380990214, -0.31186528504091304, -0.4471566494121903, -0.1702516142531043, -0.6362859590547676, -0.40464257240754004, -0.19597682341927125, -0.3925567757257872, -0.2598172217131262, -0.5391952405061282, -0.245764105543216, -0.34479614794331465, 0.36581727596225644, -0.26346045689452186, -0.3515867006676336, 0.06772896996212369, -0.4632299254892889, -0.2818040429898368, -0.13693504532675282, 0.05178881161572865, -0.37342910973414417, -0.29163717150586965, 0.1578439027362027, -0.0449984647968978, 0.43829222432158715, -0.15398578583571934, 0.23724894721662265, 0.16786212207056073, -0.5054119478031794, -0.002535588508173951, -0.5982885211874022, -0.30718979347816294, -0.28969807362912037, 0.37629856457319766, -0.13034433249324515, -0.18097565352727057, -0.2694912427441512, -0.29714590153937936, 0.20228936222069943, -0.3704293760793793, 0.3184991205387151},
    {-0.30772994568617135, -0.025879850417130618, -0.2788696205979948, -0.37400504825018954, -0.389494313575424, -0.3570936518400699, -0.49949820261834, -0.35427472107788827, -0.18914235719237488, -0.29605596840316073, -0.22885727278113244, -0.45421194741292303, -0.46498791794299454, -0.39737764825059935, -0.6223671278413354, -0.40347512465418, -0.6506655425396812, -0.36632935687302565, -0.43055487091227346, -0.3561698866059789, -0.325976177584357, -0.23054542448458326, -0.5789915182001315, -0.32150891939015924, 0.11627795673273274, -0.2525493354174621, -0.2822295736440845, -0.4387993574206383, 0.040697773438693054, -0.20779889160213028, -0.47774330829925116, -0.17873180382252724, -0.3482846056830293, -0.23031892487896588, -0.0555621002581953, 0.22811953720889708, -0.16446210725615285, -0.4001939164654284, -0.24421769585311476, -0.3722870727180923, -0.220513726157373, -0.2486810559746726, -0.06166044668515709, -0.2839774634929485, -0.29496267821541866, 0.3350345517979966, -0.06789612893450475, 0.30931142482633783, 0.015663844702792033, 0.07547487606077238, -0.09335420341270143, -0.22848252592450063, -0.1885727536774141, -0.3165775199761518, -0.3870712120964576, -0.4937559404008615, 0.1197327228856278, -0.3955678208609278, -0.09846929399428327, -0.22177946159802478, 0.046059273451639945, -0.09678974376496034, -0.4689802877784663, 0.07630046193745625},
    {-0.45631448255835444, -0.45677098328628135, -0.6108012517717253, 0.029304388170622114, -0.31795515722144585, -0.2842869931153921, -0.21126901767853234, -0.36943121702153053, -0.18396781812364446, -0.056220466743266126, -0.1757278621894664, -0.5393262517884805, -0.19701493057746083, -0.4633704155867798, -0.4227922839153194, -0.49238249619343544, -0.6086165306273407, -0.4265253636228187, -0.3932058777471258, -0.3086385515559916, -0.016129679028759083, -0.1830766265681046, -0.17879531709793928, -0.289380005276671, 0.045054592498851714, -0.5141524453405387, -0.47807089981886697, -0.24716851529718753, -0.08977574564029672, -0.25416625540175186, -0.39350219365946953, -0.5615982893622207, -0.43653803315779044, -0.47736207463681096, -0.2541463116874799, 0.391881227536443, 0.28675761375653713, -0.18545392468296976, -0.2828942747638922, -0.6431272937331951, -0.6195219412399501, -0.4471488223902716, -0.22561231179598798, -0.4093067343890133, -0.2045467814593225, 0.20579223088735898, -0.41170552399448734, 0.3238999741024736, -0.04568795741456487, -0.015783210396191783, -0.22058413508463312, -0.2722857563393972, -0.10438244896713224, -0.20343514743873836, -0.49370559324085467, -0.4863242662435366, -0.006656417346416203, 0.047644290879919594, -0.26114510931144824, -0.16300775004716106, 0.23425897184037672, -0.12740675326726342, -0.6031521983959454, -0.16156477097014837},
    {-0.572851976146997, -0.2381485237912589, 0.16878724054019004, -0.1920261566466, -0.4550871869645929, 0.06677121527463037, 0.13685029380741306, -0.3929087372048613, -0.01650358192199206, 0.4086816651628915, 0.15850392346150663, -0.4187805706935343, 0.02524307008904309, -0.29846280865245717, -0.2141022081555381, -0.31778723968367495, -0.3338771395130725, -0.03050362981436682, -0.6371571993114805, -0.2552306770705563, -0.35810327795818675, -0.6424133439102856, 0.2475429668207419, -0.5194391764810687, 0.13731668692894627, -0.38076705537917444, -0.30174996830665257, -0.3464297225028714, 0.08934793849791732, -0.19135528259958998, -0.39126989832490267, -0.22304446512517107, -0.3512003407926624, -0.6139032655437856, -0.39630990247750203, 0.3721193655573041, -0.25232927473629735, 0.00871635306392724, -0.31381863549587324, -0.34093350443727044, -0.6136773157607509, -0.14239584836811509, -0.35376429944002286, -0.5149356131442445, -0.28533616697916847, 0.3220374325823622, -0.3405981479424243, 0.16345194153938963, -0.36755094764800755, 0.028046209979151176, 0.12251366942948663, -0.19536253927924288, -0.025268383774415485, -0.5349610858971883, -0.2621512932977257, -0.31418994433814873, -0.20957634452271032, -0.298993145010368, 0.16667207885792806, -0.010586930789328227, 0.4871204131102122, 0.0656250661534618, -0.4245274868330139, -0.33035631192340587},
    {-0.33324705630629525, 0.08897236211212249, -0.09000477068275699, -0.08819049489725467, -0.5058912312072518, -0.02229569458898039, 0.5512409248375241, -0.8621616993556793, -0.2461746295387822, 0.17526711014400645, -0.14492524649162472, -0.5863329369232071, -0.05991235417374384, -0.4051786715219318, -0.4019489648692345, -0.3094586266211146, -0.14631006587697312, -0.4066727708405485, -0.028392359354223882, -0.13680011775453313, -0.22479017355639155, -0.6532311945046789, 0.22316829505530755, -0.7092677084997359, -0.2705554310154369, -0.4033334510700833, -0.5218350992189661, -0.46471887797562633, -0.3292748223588147, -0.2292658616907293, -0.5636832670019915, -0.43901923130327297, -0.4324112367722222, -0.4942655065949564, -0.36110990622055456, 0.27630886619998263, -0.2802236942817406, -0.22999929599926464, -0.27647381655415243, -0.35929079577932505, -0.17541430673848454, -0.18512889250956488, -0.16193290438818042, -0.5534930732205535, -0.14926658324391442, 0.1596622311733722, -0.26305690093048506, 0.16706907563973694, -0.4800824746729472, -0.19995183541028833, -0.1421146198140177, -0.46102038297981823, -0.17347447004193559, -0.16667951062564354, -0.483549645641123, -0.32304210916747633, 0.20721101286194196, -0.2562064196458711, -0.32160022708814506, -0.18467923008287135, 0.024432649762226574, 0.056177417831848375, -0.25273637146494676, -0.079925500748061},
    {-0.35077170908906247, -0.2307810199984898, -0.08025346893613823, 0.264325105801821, -0.39403328858314485, 0.15447898402256208, 0.29481091845252483, -0.36668519609782185, -0.1628957764451735, -0.019168442384095943, -0.3640800213509281, -0.08094425404017472, 0.14156619708539048, -0.24389016447235834, -0.43221448026700243, -0.09512087818460528, -0.1358193357498448, -0.6538261811146083, -0.3890067157664969, -0.23847290210869523, -0.11630377974064306, -0.3766176861631089, 0.027098018005344466, -0.4780457975480351, -0.22999879107621263, -0.12989130752699685, 0.18788393018026364, -0.244171747478198, 0.28914302406283476, -0.15367618195951052, -0.03572450879294371, -0.17766443805009924, -0.2588585619292815, -0.5320442576204779, -0.3965945194370275, 0.3946287186316251, -0.422439584923372, -0.015441269603365611, -0.20335656181742706, -0.36862586793339963, -0.32923326317208457, -0.3034029867641959, -0.26277077850275676, -0.34939029438337943, -0.626168039965355, 0.009905046006690583, -0.158647725016572, 0.21352797023177728, -0.17411167990476054, 0.00587813175072093, -0.30395857261221954, -0.4735659600936192, -0.6419272339130561, -0.06453166113638134, -0.3446458858452206, -0.5384932844548895, 0.20824238374344706, -0.5573344450756991, -0.23546257998123143, 0.037284595969323424, -0.3192037854539599, 0.1322230141294099, -0.44851013915142834, -0.23321495035644724},
    {-0.2184432601123619, -0.3858595793775889, 0.24312080676516537, -0.038504457493812344, -0.4117138997353636, -0.15671808618535613, 0.25723868320217513, -0.2984933677225042, -0.01599265719069067, -0.19772568471134602, -0.39660230579933836, -0.015148161923285131, -0.21649488505192213, -0.18358395622191023, -0.36597637858394755, -0.1961188394618953, -0.092322348212273, -0.23602973107289718, -0.622366614118352, -0.36490469111846463, -0.01602118159789664, -0.34033239787317066, -0.09131974048339155, -0.2791904272434549, 0.07258274062445752, -0.21740701413609922, -0.15716382731845135, -0.49888251957397367, 0.12578189973975273, -0.34833177929677817, -0.06879137025537274, -0.4571760982914112, -0.3803368068408138, -0.282796019951258, -0.5346086134638144, 0.3105053069354035, -0.1418816966424553, -0.23912987810002995, -0.04738320628993689, -0.40941245594683845, -0.3870099946466713, -0.447692601705249, -0.09972861886537894, -0.36644929596809955, -0.4091502446978217, -0.030886805681024934, -0.20296788342266964, 0.21506407598288826, -0.11500033039785246, -0.25281311547626734, -0.034519071742704036, -0.16444174642222154, -0.23250761839068848, -0.6312437683861432, -0.47983379447846813, -0.4273227871617119, 0.1954908727724915, -0.5155333590377202, -0.5012820684295407, 0.025596994996906264, -0.17200448276719715, -0.008547782698527497, -0.16062023870629386, -0.20773990388036012},
    {-0.1743231389967124, -0.19131507026484515, -0.13005344002986002, -0.02443923228074433, -0.3643752317830443, 0.03675807130224097, 0.35107839727673423, -0.12301995646336172, -0.2752282035865265, -0.0086392946842503, -0.35587407600028287, -0.3733893353326393, -0.05844924916617589, -0.3986299844148902, -0.2320794621764142, -0.08205198641192922, -0.38230802316063994, -0.28425199758953074, -0.4582169374539113, -0.6559636024287296, -0.36936443298731564, -0.4591494060256012, 0.007254781064616307, -0.27739793962979215, -0.366921106671431, -0.2912825814198814, -0.3765328538121852, -0.40972423549510545, 0.2567865246827289, -0.18833306933507507, -0.37029749245898685, -0.2096432796605709, -0.2575877524296597, -0.3505864790472652, -0.16177147781221188, 0.33303231686937534, -0.21764788257355233, 0.025547100763719188, -0.4619497150245531, 0.030251297508381576, -0.5280035566531059, -0.5870754077403294, -0.20870556473172533, -0.5155502319699785, -0.24910831964826735, 0.2710848260515749, 0.07511120212880068, 0.24616150387831587, -0.21395725124447362, 0.10791449237805595, -0.227040639226397, -0.5382458393736188, -0.3741259347577806, -0.7495708592279821, -0.2220306786423941, -0.41666424157595205, -0.03307201640510016, -0.3352062329693946, -0.28584617746729185, -0.39691851338814843, 0.2668033424275986, 0.05739267455976553, -0.19718807860036705, -0.22819347993119596},
    {-0.05933849895714739, -0.11338780469461295, -0.16744598010596967, 0.1346282319662106, -0.41045141729795076, -0.03702235371414681, 0.12823126021585307, -0.1772424074615278, -0.3939553291895319, -0.2686867682908519, -0.23612124144593766, -0.623934612404037, -0.34571819915530144, -0.10768355787749279, 0.048345238801911786, -0.10997817199604144, 0.1623659667876371, -0.10704767981559056, -0.39915683621508563, -0.5043902150130826, -0.26807220951041283, -0.38895440327226194, 0.050321317416811735, -0.29216485266153835, -0.4040551947734628, -0.541813746180289, -0.009259003798798215, -0.6591605952626851, -0.22819053115449467, 0.23143645763450646, -0.42908884567385724, -0.3631838638475383, -0.47718427846502703, -0.04173791277693221, -0.24344161380294838, 0.19621018993502579, -0.2577487429252178, 0.0211722999818642, -0.0012690266150995721, -0.34524939701416546, -0.44675963662204105, 0.1042179744840165, -0.13428495003567956, -0.19091351224690023, -0.547215756372554, 0.7781246318730762, -0.08688985082193193, 0.08287175571222984, -0.46659537859936184, 0.14217639972190516, -0.2514511117479709, -0.4075662478203241, -0.2218715741257151, -0.2949635344150005, -0.1899900967930486, -0.39110536253595185, -0.18656364944679424, -0.14941511279193406, -0.3219028858377674, -0.3533684855856011, 0.05589033224109766, 0.45686153785001477, -0.34193053219632946, -0.2979772650311573},
    {-0.2281970900495317, -0.27487848203535387, -0.25056217244366547, -0.1286015917091345, -0.48573250949984526, 0.0215056942086462, 0.23311232112734515, -0.18007204245833602, -0.3389686186675985, -0.012917668925447197, -0.42623497228703505, -0.30145282117328515, -0.20947409009985912, -0.3868363022333044, -0.31315082351087864, -0.4334597353334944, -0.6031000353432072, -0.1456440477274522, -0.4087134564513954, -0.42273991072935857, -0.17799265654082563, -0.4125804686689473, 0.4357873347745471, -0.4497197749891672, -0.007103478261112048, -0.6355568470686429, -0.18654931428813967, 0.050156205977737144, -0.1821012926540761, -0.0011113293410074873, -0.3350228533220959, -0.4566544445404043, -0.2588411290490337, -0.3280379460959587, -0.22839461790576085, 0.5214627000836739, -0.2035893770658006, -0.20738561097258937, -0.5537384781080084, -0.07583070263975435, -0.550310230302514, -0.4372118474998676, -0.20964337186590923, -0.37273200715689786, -0.6951322555553294, 0.32064100271337814, -0.09921772968481274, 0.08096088249312706, -0.4520669706215634, -0.22297641628351197, -0.40781662920218265, -0.5828402855103713, -0.5319103703600794, -0.5163675353772346, -0.29456650318793226, -0.31324327178189976, -0.0636444946391575, -0.5742590498288553, -0.2634626188244351, -0.47293618608894245, 0.060099437489784954, 0.14620532051444715, -0.23224576890231102, -0.3915425908253191},
    {-0.38530940536813346, -0.6405729196308934, 0.03101789827532952, -0.14036613932741576, -0.402273144656792, 0.021873106604626297, 0.2314118280090918, -0.03191358407295651, -0.4890169561658066, 0.012719969444302764, -0.2773012125906639, -0.3964929369475662, -0.5753645968685083, -0.4943764779622155, -0.4959512646969641, -0.4654418997417394, -0.2541462279863194, -0.5248085146101892, -0.3365035077769839, -0.31693890581034306, -0.3248477604152527, -0.33354299007337473, 0.07879965931242902, -0.004061349662556085, -0.1350905317522471, -0.17757494630079862, -0.17830236982947562, -0.22343298198273928, -0.17055240315324938, -0.2071899449085212, -0.2751793453039423, -0.28296620463691136, -0.725138168790582, -0.8760718510636611, -0.20377683714564843, 0.2316661508939956, -0.07973416184153469, 0.12754604000878486, -0.6768253086899386, -0.2310947361983008, -0.20244074449939792, -0.401837085858407, -0.44686805647713945, -0.41867610521965726, -0.3346463340587575, 0.0731205475993485, -0.2503833366134294, 0.08450688407182029, -0.22652338490077786, 0.0003794181331951531, -0.33849430545913384, -0.41179253452686077, -0.4711689909769993, -0.39081330029890243, -0.11504422391746232, -0.2871653513770684, -0.12418413905769864, -0.4913380262815758, -0.36513238264021675, -0.13694197946508585, 0.0623283676842069, -0.12296525865849983, -0.4110951853562321, -0.20890849792943383},
    {-0.40833273941005643, -0.47455027496617186, 0.17595014389917393, -0.4583656188758484, -0.6145684746937619, 0.18712202915909515, 0.350447632761892, -0.13415997113184835, 0.06915829117921206, -0.11941189118193042, -0.05030864522020935, -0.3488509083097778, -0.3046494450663702, -0.4573714525620319, -0.036594152099331735, -0.3380545671318737, 0.004088917331659161, 0.06826603354242025, -0.2970812986814594, -0.24496565272644763, -0.17729864574486992, -0.6694764762892804, 0.08183366610396767, -0.47889206550598473, -0.1796289332171503, -0.5059680478457269, -0.30881083308140067, -0.4776705151826506, -0.09911253498352778, -0.2599479529515991, -0.6465295032364605, -0.38315511989653384, -0.6148658372756335, -0.3946919441188035, -0.4482143990206567, 0.1216117424034506, -0.315837884612911, -0.30251799482218483, -0.2897998702622644, -0.5422422292975698, -0.05311232187480002, -0.18679305751313552, -0.33167315998928354, -0.4499183311572389, -0.4560220808948113, -0.03653058791229468, -0.23658488538611988, -0.03565440179735498, -0.02949705769102409, -0.04349536637353917, -0.48799280996555255, -0.5327227370653355, -0.18769870470117542, -0.3386912613299444, -0.4334080075601466, -0.33141176795078414, -0.07103598914330563, -0.26019071682396344, -0.14471849471947662, -0.443362405607139, 0.1353861119549504, -0.035539649550454765, -0.4691489878068156, -0.4061959548045195},
    {-0.3144363331897995, -0.23571201398607886, 0.22827595504681467, -0.19847382808711822, -0.4215307143341437, -0.08016161195463256, 0.10520809556862376, -0.18839915527850143, -0.0464215289730144, 0.0712237596054627, -0.08538688701010369, -0.2778295692863487, -0.40260921808958433, -0.6067010837573147, -0.21568551525758387, -0.37469574404777695, -0.35886872804707404, -0.29663375143878407, -0.32757218674547045, -0.5390291826228898, 0.0018565782534351264, -0.5663528097537994, 0.10315082213739189, -0.3566803593956883, -0.03888431342316461, -0.6661639757716824, -0.23662341537340434, -0.33099739109628423, -0.013715294410726312, -0.2304047677098732, -0.5173042721204568, -0.2772158815628555, -0.5096952381710232, -0.3754810187184877, -0.4489107555847192, 0.4753416041029768, -0.33910775650543346, -0.12328128530257856, -0.18652519908616855, -0.4954296130870184, -0.34448347152204756, -0.3588989573870388, -0.0071720255298007045, -0.5531581411614535, -0.28102196802475277, 0.41720647369740854, -0.07562577893197986, 0.03148489134945244, -0.22482223440586113, 0.1824376952210025, -0.22823363066183563, -0.40330167601996003, -0.2542993031219849, -0.3603599536020649, -0.418153186508884, -0.5336067239368776, -0.07198938889156181, -0.591191189158471, -0.23709097906589444, -0.22453430548699804, -0.2817876787776396, -0.006214753466938135, -0.10440556125202899, 0.006244627290157377},
    {-0.3592425355862052, -0.4103558874626206, 0.20413323193014626, -0.28696005222493803, -0.46439212838444915, -0.18121739116692026, 0.3132585598381935, -0.40450440140665805, 0.03394154904561722, 0.014894607939073348, -0.17035437317285143, -0.39898556030502114, -0.4485145981926025, -0.08497352132626067, -0.32432712894433285, -0.2935649642359401, -0.7996146098047525, -0.2784668330676166, -0.3731421300390862, -0.5170560971566323, -0.07955436068971493, -0.33965570387532734, 0.18147511401698163, -0.1330838659951405, -0.15604807680249755, -0.4629632726130635, -0.5410962672873272, -0.7061119422662839, -0.1981602250347491, -0.05688801330282076, -0.38375549970723444, -0.15679866798000666, -0.4110917677425144, -0.342887094812673, -0.34633069883842393, 0.30436445549847096, -0.16085311361373744, -0.35129240288384067, -0.31725428767251795, -0.42484860255265716, -0.5554687990429235, -0.5016280061246614, -0.06977795010700376, -0.5340707914140189, -0.4158204822142596, 0.2593086683944247, 0.22992950584888971, 0.09860876573376795, -0.38673222445089955, 0.20253364132488616, -0.10538103873070614, -0.16209258723852701, -0.3427316614520507, -0.2303868360759818, -0.3460034652369246, -0.519475672702956, -0.20082641826640316, -0.3872836986656736, -0.3691627852727849, -0.1654058758099756, -0.003399695955137949, 0.0650014917402572, -0.3332184299693464, 0.06837669818820986},
    {-0.2847378414673667, -0.5119206760366238, -0.26587219566487, -0.20559836104906595, -0.5155680786540651, -0.2393459506282356, -0.04420536440259674, -0.3731177112706487, -0.1448448254138248, -0.46952519385306407, -0.32601009255018715, -0.41674483823839753, -0.21265257953007424, -0.4895900668470434, -0.5186727484850151, -0.5569565996829176, -0.3461723150320577, -0.5760148083790629, -0.6600854751904401, -0.5043180202639521, -0.18702135793820285, -0.21484588417903416, 0.047821373036486536, -0.7092866433360171, 0.007341437461663684, -0.6174187969951658, 0.03958046601171277, -0.43138096479997945, -0.07109199164926425, -0.35134929212615185, -0.47697332195648545, -0.13657144143973354, -0.5528277316042374, -0.69442471012442, -0.4673446698571725, 0.575019987356292, -0.2516523637052707, -0.41844420173064667, -0.29507912581081075, -0.4767757190832985, -0.629092984105825, -0.30494303892864294, -0.3070579502357197, -0.43862260682682763, -0.45734425927123934, 0.05978445837601412, -0.31687638662415313, -0.0686101498769232, -0.3980838256585212, 0.19958895086214973, -0.3876185983676103, -0.46702371822259464, -0.28759274777276617, -0.3341062011316, -0.3732951931177958, -0.5728251602743647, -0.07434022260276478, -0.5971680336469619, -0.6257056886578237, -0.6267116224643297, -0.07829984290500945, -0.022838115986428608, -0.4544466261295446, -0.6094543640479625},
    {-0.436083222637323, -0.5706879750626485, -0.08396513051410551, -0.26635438025264685, -0.47057139895481037, -0.1144713957797305, 0.2768409906861881, 0.1031282611893579, -0.08626420824519694, -0.4448970879766247, -0.4237801891662949, -0.6135590676981336, -0.40626780769766246, -0.33614359740450483, -0.5385730395795122, -0.7549554672116255, -0.4895237006231752, -0.5338889249587015, -0.5936501735878115, -0.5267155520904475, 0.06383907249760828, -0.3515761174759433, 0.24809758384329486, -0.467571882931966, 0.09975933547239083, -0.3482380715709512, -0.5117097386211761, -0.3947729155033734, 0.1315511965436151, -0.1298908344267229, -0.2907570057862796, -0.2160689752068656, -0.3942141423848267, -0.2772890806494367, -0.2508060501001842, 0.26504726333618706, -0.19588990062357492, -0.6840365436092589, -0.6297931579209339, -0.40160131096168916, -0.79669742298605, -0.30743597175436865, -0.03559865194078088, -0.29259217677054733, -0.3919152795449847, 0.2656446135410361, 0.23755777450704066, 0.3889434475776354, -0.29643360080446324, 0.11289456773336662, 0.08802170136634109, -0.48742892951768385, -0.39323598152435735, -0.3001630274618645, -0.35163944619556653, -0.3088273626522322, -0.2999792217835224, -0.3162110156704216, -0.5611286222556561, -0.22754361183496963, -0.19821268289071448, 0.07919230829717147, -0.4183194776714725, -0.13428543779679888},
    {-0.2617441646354519, 0.14979215179114017, 0.13684269028758025, -0.2801292557178224, -0.5354945226312855, 0.02824980967140784, 0.34736010369499715, -0.0330439062709535, -0.3038054758606635, 0.12738694027299155, -0.17728678853196025, -0.5081765432279876, -0.4479692999536207, -0.3552723234699485, -0.3380423425147307, -0.5570944549458076, -0.38829929929428436, -0.38611051010735864, -0.3059925618401967, -0.2600620767815775, -0.07250051099241793, -0.42730406618256106, 0.01463501685993771, -0.25045790298361537, 0.0018076505205902268, -0.21389194384282206, -0.31126624086260274, -0.3671534720617944, -0.17869635858596614, -0.055655236719678626, -0.29617138291018896, -0.181723592689485, -0.4903081068671757, -0.42057125280002, -0.18098357097804027, 0.4378868085898533, -0.6484542839674303, -0.6302498753109829, -0.493234496921471, -0.3421533946360884, -0.5082819081763655, -0.04870700809480782, -0.05293765856649695, -0.4438334675358798, -0.2531362458644925, 0.3002106249427263, 0.09238955816512771, 0.23351426932333838, -0.6263526097416223, 0.10784137141820704, 0.13622804534120903, -0.4566007945954938, -0.2503815139477661, -0.03151904310865348, -0.22484079274107077, -0.20936882265432244, -0.23265560574481167, -0.17110417830469332, -0.06562087259229363, -0.13624528450212398, -0.14194206344482607, 0.3186128144882215, 0.11282138452454045, 0.04484505690295923},
    {-0.5984635096046921, -0.21377057417378756, 0.05510587964668166, -0.2310639391600259, -0.6271406091339231, 0.009903631114124253, 0.1915207703291215, -0.21423767509561775, -0.3051367611643665, -0.08932591276559622, -0.25629683099404693, -0.4209364395992711, -0.5989676782882702, -0.4109115151355621, -0.12758964349331717, -0.48492446453837035, -0.6883404837210225, -0.3529472928923767, -0.4114186514095573, -0.46908859449425017, -0.35165430758037, -0.4885456055106812, -0.08586764734580364, -0.5195286669530664, -0.00760134440397205, -0.28789667110551875, -0.4893305555324245, -0.597962414551072, -0.2064766632310717, 0.06420397202887215, -0.16336239349619855, -0.3811599202070561, -0.47776725270322196, -0.7717205225630351, -0.17687378744679738, 0.20904356056065637, -0.42221055757316717, -0.23921046751563824, -0.4755689528000486, -0.34442440062597607, -0.43979532525473763, -0.2953243851460174, -0.2538609018928093, -0.5176550158403554, -0.5657670326168805, 0.45663242225872597, -0.21089931643393806, 0.29281359130169804, -0.5218929579961332, -0.17121210557879338, -0.4731954985979088, -0.4239109632035721, -0.6012631141595346, -0.388623042888351, -0.362718066882492, -0.6852735890144092, -0.0944589934574057, -0.17033115996947742, -0.3636287385355764, -0.2172034025973225, -0.07925254984822383, 0.14463399086138343, -0.30606398708412136, -0.42646174845334706},
    {-0.26959615946097465, -0.46889516951802995, -0.1205691088305691, -0.37857481832477424, -0.7973977838227629, -0.10588991226236, 0.149783385213793, -0.31958233762849747, -0.3720297614027, -0.12867818836837372, -0.4539255539089504, -0.327121168362113, -0.3328854181963921, -0.39351126487524124, -0.342034758371397, -0.34097673765813247, -0.4123331208802659, -0.2750065527392841, -0.4808491258161522, -0.563282371366012, -0.34638009267944564, -0.4081435728479075, -0.030952947712794544, -0.4492532239514166, -0.10754674001075785, -0.2905148982707332, -0.38587809336846673, -0.4507663980922996, -0.15989487925830675, -0.2774385572709972, -0.42884314737505536, -0.29587045283898006, -0.5397400800238626, -0.3941625984671229, -0.31240283252445783, 0.2701744909981927, -0.6470166080664537, -0.398212271562627, -0.10105675293432889, -0.38233184829728606, -0.2786139975882531, -0.10026336914149463, -0.19481527060140605, -0.4856604500636113, -0.5776080157125932, 0.18127154610422258, -0.08217902354913677, 0.042869665860446195, -0.639943213787168, -0.08915928869467803, 0.036760443441921635, -0.6754645009491426, -0.40658322712693123, -0.4548448022402466, -0.017046009845633692, -0.3884860568493657, -0.22564766051762908, -0.6174460001395333, -0.3255960696000778, -0.23381267319369353, -0.022637950134306778, 0.0777543308503407, -0.3022394929356596, -0.4116675167697688},
    {-0.3435989143031579, -0.17345685459365345, 0.020209749504432026, -0.5135544396345817, -0.6033653005189534, 0.22285056816614676, 0.10929126101324015, -0.07374890647640778, -0.054389615206744624, -0.3323898895031396, -0.2975587575917198, -0.7287133015468161, -0.6266836202481318, -0.7182494416190394, -0.29993635231967836, -0.8116683573032312, -0.6272553006867442, -0.24561485959589394, -0.602311621256994, -0.48298398729902625, -0.2676924026659594, -0.5999828169636027, 0.2439223015605194, -0.49673069206745285, -0.05619431981210645, -0.5740591250555379, -0.5523308170699892, -0.47211103255537645, 0.1160584437227402, -0.3197951597490708, -0.6358894001677972, 0.08052451099773936, -0.7386603995056198, -0.21411997415757572, -0.5889807446492538, 0.5260295436610647, -0.18174647135759467, -0.38755433500197245, -0.27671348310076116, -0.35016648724736, -0.648079543158856, -0.19722074588813043, -0.11342295531576875, -0.39419474508729413, -0.42838577917263676, 0.5973006244650733, -0.2037455551899535, 0.6512801706325818, -0.5670365977892152, 0.36687241103531887, -0.19229086094016362, -0.382285503457156, -0.3972333875725401, -0.4462505304042134, -0.0467749591954917, -0.3664716055249122, 0.020568449423254684, -0.376530491429984, -0.26600382226637603, -0.3713565190251701, 0.10993902915604838, 0.19547023993521212, -0.17090069137087838, -0.1808681658554329},
    {-0.15592015474525853, 0.020257089710563655, 0.3001783633241111, -0.22863695672781278, -0.46071880871443155, -0.2747191325887026, 0.4482493810110574, 0.41015934929881465, 0.20855471041540477, -0.5023666039175577, -0.15809687441090206, -0.5620542255994789, -0.6168593232116223, -0.35587780417281717, -0.20999705294298818, -0.8009414810204482, -0.43391584864798327, -0.32645128751685604, -0.6648994760019119, -0.3329967872163832, -0.17989344577340347, -0.384392169544267, 0.36576284976225215, -0.11554187299653822, -0.13483373032997142, -0.5031999600642557, -0.04741362024139149, -0.5263497332498904, -0.23136487487678187, 0.1506300772845661, -0.638399556493997, -0.014464062196217759, -0.5100995021013495, -0.40957079797259893, -0.47104600939803504, 0.2703529235913566, -0.6299097130071742, -0.664411869706655, -0.11887879538206853, 0.0753436685917551, -0.7205240152900023, 0.22610718563864668, 0.19908275925954813, -0.47177378231342043, -0.365385380785487, 0.35394258017072183, 0.007060961637978564, 0.27258573971030214, -0.4468932477547764, 0.6785054409967346, -0.18046321851286232, -0.4541331810412622, -0.6383922400253765, -0.2135674217543866, -0.024638655542124892, -0.31589059110695633, 0.12805805805042855, -0.1559352866102833, 0.04193015317184024, -0.3256432069358404, 0.29906440550296554, 0.39656690380569837, -0.22908019366715196, 0.15653796010848953},
    {-0.3169251468921542, -0.16638276883434774, 0.2599761287579278, -0.47756584091382803, -0.6030638520852225, -0.23131823689678177, 0.480868459881349, 0.22000453777245593, 0.12452870555478568, -0.32711512324601255, -0.16901521231566377, -0.6956443237418182, -0.5353625472486971, -0.4792494092672675, -0.2330954876011784, -0.4417758850852593, -0.5049874252981109, -0.46622581116292294, -0.495331733049839, -0.4524317743409319, 0.06201430154055613, -0.3620953192979434, 0.21951858137709002, -0.4306954993354975, -0.045358203479989714, -0.3965505462583299, -0.025656469334776194, -0.6110273665383624, -0.34229568036019026, 0.13215463019314608, -0.4990913862581413, -0.21658360910237642, -0.3927151220967467, -0.8432967315523213, -0.2996550790346436, 0.310299319143772, -0.3329104841296373, -0.39470142620195287, -0.21222673799821268, -0.3461271004561277, -0.4968350060528568, -0.2931062768068974, -0.2350855476831687, -0.7675814326591215, -0.17233367611534015, 0.6375673133810704, 0.13492647886739959, 0.5410917135499345, -0.35581515992961393, 0.47680706940277906, -0.13944523026207867, -0.6543396342604141, -0.37175352835080955, -0.3779173026932741, -0.27105792515512067, -0.4169916867981419, -0.01741861239914469, -0.20371612926572674, -0.12007680484388182, -0.2639078257697567, -0.01307003092417615, 0.056281627475929456, -0.01191869881071859, -0.17430837669894492},
    {-0.4361897580851216, -0.5415684890161028, 0.19098119744017517, -0.1988950702684039, -0.40789183299553267, -0.4091539809538145, -0.19628715098836397, -0.15034139138760624, -0.12263530315297494, -0.3323543531485768, -0.14784500670484957, -0.5217288876797878, -0.6189058915478949, -0.3650277374705921, -0.2319014408344118, -0.5637223162598315, -0.3938711150183587, -0.1768139519462135, -0.3749100271798431, -0.8125772180820018, 0.09621488453636388, -0.594599903323865, 0.3924162271475188, -0.6597241681778092, -0.10876381359536744, -0.20812456320483413, -0.2998445212854724, -0.6705202336864932, -0.21614893898602847, -0.16812369098362998, -0.46972781083016096, -0.4424970975770111, -0.6362730873704966, -0.2796100877355102, -0.42545862003739393, 0.49641742104328646, -0.5536194920879524, -0.4633760561508758, -0.5216075815318888, -0.30222068215604625, -0.5155816130823467, -0.1330586457374504, -0.25955267148903344, -0.48711859442817745, -0.3616467081850764, 0.556450693323479, -0.21208701455609383, 0.4056790547559891, -0.5561490249671762, 0.18068929508440124, 0.03684507688598135, -0.46227826636549674, -0.5242253979330253, -0.658033519652599, -0.4282552639381299, -0.45592728961711254, 0.09055057361528734, -0.493173278763971, -0.29523097509813817, -0.2810713873503679, -0.07236344563648653, 0.2932022867888966, -0.20871389467414322, -0.2485102103463181},
    {-0.22995371893208905, -0.14692318532251233, 0.20680099898342966, -0.4198656252232574, -0.5795546460745624, -0.2744058554021078, 0.3828524107639935, -0.12105797073593935, -0.11848514639234159, -0.46953875047798005, 0.004672549581006165, -0.628371625785917, -0.6721439499025915, -0.4652343825146933, -0.4534098260470367, -0.5988513189596186, -0.7772966780572197, -0.06935850449680026, -0.4191544866011975, -0.5012428769223128, -0.09276156581672906, -0.1831531975584117, 0.22486375531124272, -0.24985005716335124, -0.21283650663271195, -0.42850002788364233, -0.13894589401880858, -0.4991533073806125, -0.3353782835808497, -0.138658567250761, -0.5130688910029222, 0.12766484747305892, -0.5139743711253132, -0.22367775248026556, -0.6900756698803628, 0.6219775109478085, -0.587187021123196, -0.2701254002629201, -0.32108411414569515, -0.3689839963813568, -0.5745018357711257, -0.098429986501439, 0.20774974710310218, -0.5220995064315881, -0.36047545231648426, 0.3532447770306772, -0.024171832751732118, 0.6549340041681032, -0.537953092890076, 0.32140505015965076, -0.050009546949658264, -0.1581382323111073, -0.25228191479315165, -0.28862271589682603, -0.21695344172028025, -0.5629431411002485, 0.37603210741193815, -0.20114215248494297, -0.0014110454171367512, -0.5203401093009575, -0.22297404213648447, 0.07298059031632288, -0.1096875612369577, -0.15233912178816278},
    {-0.08403170611228812, -0.15395128564956295, 0.32485563061851097, -0.5692986591149471, -0.5815206909647416, -0.20178507442070384, 0.2971169272007888, 0.1270737594365445, -0.17309263712045322, -0.595096263867575, -0.242997993233986, -0.7002676971149758, -0.3009901800584655, -0.4129717661009456, -0.22184690952821748, -0.3685125074506263, -0.5793616883548524, -0.025893917470319983, -0.40056701206205686, -0.5775451723436608, -0.1794906421475468, -0.5678506129337344, 0.3066280242089863, -0.23601781013105447, -0.03596532655298024, -0.3892521289801355, -0.3892895242092076, -0.6257149326921514, -0.26546362676624835, 0.31241412117943335, -0.5293321244897263, -0.13869817640219143, -0.4249749877515223, -0.3210354451566017, -0.31604150860337443, 0.5960511577915341, -0.39704348219059366, -0.46166351346763224, -0.047436931579968894, 0.0559000124541594, -0.3532467364182818, 0.028960579271974207, 0.04084705473565595, -0.6271965875791414, -0.5770652530088707, 0.527257975525477, 0.21198857158067147, 0.6060918326869744, -0.52898199150602, 0.5884704929907741, 0.1742010703529069, -0.667236596402921, -0.23113995696794684, -0.3923064916482222, -0.10523316068674962, -0.6225122141819759, 0.28888045057943595, -0.10602073295513922, 0.16929698314148534, -0.2719400244423434, 0.0034664399525380055, 0.022891753489618152, 0.002061621626758701, -0.044651767847562286},
    {-0.3055228035789764, -0.04034825376911278, 0.25763879099627146, -0.5154612564622139, -0.6935246131427447, -0.17200305750596326, 0.2911114110501082, 0.12026067629434352, -0.14029855518200232, -0.45552936737152966, -0.1476719168742669, -0.5892996960228432, -0.6211291717972598, -0.6429821365701868, -0.4397787804700519, -0.4786613768264375, -0.5512518100095758, -0.47203939342399254, -0.3094601333272696, -0.6935409193515583, -0.1085957892894375, -0.5808330210725202, 0.042336899489222625, -0.37271670780235827, -0.20357841328959675, -0.33806771644168654, -0.13482806187662383, -0.5647080633579042, -0.030129172020783728, 0.11263908300209027, -0.4962898335559052, -0.21198711340930945, -0.502074747158773, -0.5033382764710801, -0.5534912790764853, 0.40022862447229707, -0.45319360405743553, -0.31720449270604034, -0.17162835623128686, -0.15982314097669179, -0.42350280616719493, 0.1769166230750755, -0.08030460917921209, -0.5947113232877084, -0.29327604922220024, 0.28407038316630595, 0.24741333258316336, 0.634578354728061, -0.5602804975963109, 0.5165425873404299, 0.035205669309000494, -0.5437604351234446, -0.15653001392857938, -0.33700302936874804, -0.36919206516587566, -0.5817179570870392, -0.03960484621899208, -0.19614903714799165, -0.18136039377003302, -0.21846754107541502, 0.07495046110193242, 0.3326663923251922, -0.07589149477915448, -0.0802707029377562},
    {-0.18114216643736092, -0.20394070385904617, 0.3035303749538103, -0.3896835646692692, -0.4379929810497484, 0.10871520195660461, 0.25567138672696377, 0.04251522940443215, 0.11694543047015284, -0.4056926250709859, -0.04765195543996971, -0.6357750180670266, -0.305872603551122, -0.21561298769040357, -0.32033192595644167, -0.7060250913857394, -0.8143057631427998, -0.4256378114714927, -0.3986618850068662, -0.43638796778778666, -0.11799178201992452, -0.3309166840321357, 0.33642386714402056, -0.36520513550299677, -0.15953235272617594, -0.46150164823217815, -0.22964925526804517, -0.874782968376427, -0.5548831875799433, 0.07260399620607895, -0.41850075625071986, 0.23219516776453222, -0.47246206524425494, -0.5243401323636716, -0.42765796158808955, 0.21994318786874875, -0.5730540343688526, -0.5341182373137725, -0.28638249708556024, -0.20353960305564803, -0.5067232804420169, -0.0803914317095938, -0.09040349078548404, -0.473694731070145, -0.41351903726141664, 0.5987183214005403, 0.2149017643987188, 0.682951523011742, -0.4603557579508227, 0.7980883509109064, 7.019247576839104e-05, -0.477535648730489, -0.49898310644996063, -0.2776585890566325, -0.2198911026084996, -0.7730497623352233, -0.12834890028191803, -0.35894156367136965, 0.10668788516624285, -0.17107666020338158, 0.05854066296368922, 0.10435033007718594, 0.01695105403933572, 0.41004557424870636},
    {-0.04622657815343087, -0.3116522812948545, 0.06895600729307536, -0.46107178570827584, -0.43407441635584826, -0.10918117542984444, 0.34850321733407064, 0.031843271977522895, 0.03564202076546315, -0.5509541375791058, -0.037395801315327964, -0.6066021335436829, -0.6634406202735816, -0.2423580664663839, -0.20868718711939463, -0.363307506733026, -0.6464201295576733, -0.3178845751193899, -0.40174776992704053, -0.5844731492419785, -0.18845829142864245, -0.642176213325016, 0.18068998796327035, -0.2345214958731147, -0.4413432956237958, -0.18718947308678124, -0.4718559571191015, -0.2665348126698255, -0.40077087017369284, -0.005176227548605851, -0.5472655708729974, 0.10138195511654503, -0.4013007900209066, -0.5052898417038044, -0.5611287708468603, 0.6583113799373961, -0.41929783591304143, -0.5932272226685825, -0.09037293338095025, -0.11585674515021245, -0.5166816744586856, 0.10802046304354437, 0.28211826646637106, -0.5794152998632139, -0.15432698177328066, 0.5219688644153136, -0.0762908855825574, 0.6072196401665005, -0.5016961989477621, 0.5390242417965542, 0.07048815974787731, -0.6812638976435894, -0.5241285754254785, -0.22264335477701258, -0.027966676806428156, -0.728259552776645, 0.10906780436769015, 0.014523108316444412, 0.24507700879196784, -0.18475403272470287, -0.07254734265667427, 0.1484361501203011, 0.13141022775472627, 0.03963305421642955}
};

static const float b1[64] = {0.5885429689458274, 0.6618146022811557, 0.5889447898291656, 0.6351834774550154, 0.675020060493341, 0.6647505061870942, 0.5348915351745472, 0.6724036335542697, 0.6357564898643585, 0.6422502753322844, 0.5829713054439501, 0.6643457080345884, 0.6314271548001104, 0.634997316195254, 0.5675517326418166, 0.648066276546967, 0.6964107592761484, 0.6805946061374823, 0.6194683205337056, 0.6593909096992564, 0.6385907101924899, 0.6403324857392889, 0.6310959067739027, 0.6469882909952848, 0.66694868144167, 0.6341249240619432, 0.6412158550103867, 0.687292716317244, 0.7039176198002465, 0.6804513812593156, 0.6025650387600052, 0.5481206480489923, 0.6702359400495976, 0.6783074773575231, 0.6585913711936116, 0.46655750294284487, 0.6985689923887104, 0.6529326622232324, 0.6550975188502345, 0.6855283564920283, 0.645960962983675, 0.6436203746353615, 0.6756020438185965, 0.6758524770232333, 0.6556108760039459, 0.6730785549802637, 0.48503649414560945, 0.5600679867733975, 0.5929025293463286, 0.6971111754524699, 0.6346174020187079, 0.6490525141160747, 0.6673334234648302, 0.6638104048394634, 0.664341009841135, 0.6713923109992981, 0.624776130105307, 0.638004577279327, 0.6539204131076191, 0.5023701067378172, 0.6442823497748987, 0.5240149299053265, 0.6158674124752918, 0.5188457457801449};

static const float w2[64][32] = {
    {-0.011877253132965027, 0.44082545149484836, 0.41156245795543844, 0.5472410532472657, 0.6501748186276478, 0.20000276719445445, 0.5599312430675517, 0.7076783566890769, 0.597242135953601, 0.6889781482899994, 0.4626207600024276, 0.076655036851004, 0.37611243800464705, 0.5387069749773621, 0.29480893250789975, 0.04250218830106348, 0.5856526661222712, 0.4156517039890195, 0.5984518855137824, -0.08910385499477899, 0.5351066211305379, 0.39387023422770534, 0.35185008086473907, 0.2580918233016043, 0.8774261668305783, 0.11195418871660584, 0.5826608512169837, 0.4484687105683675, 0.8305345618677534, 0.6289247216570637, 0.21492691869276093, 0.48536352107144065},
    {-0.09210324279184394, 0.6774345778051136, 0.1462042691583019, 0.7367481374821889, 0.5474185189908136, 0.2314116043344492, 0.41834762131659736, 0.7665761944763833, 0.8151369226421589, 0.30469099336162625, 0.8482623723263177, -0.23893610142412286, 0.4587936812283097, 0.8916468516036227, 0.4776585842754178, -0.19161920918867087, 0.4085878132070793, 0.7273248308892589, 0.5662643215705181, 0.01004293357206469, 0.8440777022658258, 0.7435414748196687, 0.5972583831346683, 0.7071608175519332, 0.4865375560214184, -0.47289463486963734, 0.4861072468626238, 0.7826471207274157, 0.8134319716824251, 0.294946884465539, 0.12920103831964916, 0.34129395462442036},
    {-0.174863301016412, 0.43764828314971915, 0.38201179220937725, 0.5317895308660574, 0.6688906886068323, 0.6216111209384986, 0.25702985059906447, 0.274099610023212, 0.7155375576941476, 0.5538022863074182, 0.4353742591142304, 0.03168654015052479, 0.44358649184489923, 0.6101482419405203, 0.504684116771669, -0.4100434504937829, 0.36850108483406074, 0.4235681182741496, 1.0557610856092003, -0.0001874622443742199, 0.40492839519967966, 0.721193485905605, 0.6620782297824213, 0.800880373669604, 0.8618974535655358, -0.13189806166773257, 0.710997924279299, 0.8256539896276376, 0.2930597455080601, 0.3623620977516437, -0.07408442691896377, 0.7225906862096462},
    {-0.0031823770830745773, 0.5871000038252485, 0.19093047804742141, 0.5132542315257638, 0.6039122156295951, 0.5345517598201449, 0.6170035273611442, 0.5486958760282902, 0.686514002720458, 0.47124956003734536, 0.5406965266062309, -0.2508851241069965, 0.2907442308014106, 0.3913066984533573, 0.6426932616701263, -0.09185383798324906, 0.7288703618030952, 0.7443412832467242, 0.672563913587112, 0.035127657277501084, 0.5329218509273677, 0.3251633812491981, 0.6587822484972032, 0.5730488429082802, 0.8811924772786152, 0.008190846455345924, 0.8048506035963343, 0.5945416721194342, 0.7874411428282374, 0.4718327758391436, -0.035499562441211066, 0.4345439238791825},
    {0.08376461970083972, 0.7873263071656526, 0.3171699344896538, 0.5030147535125041, 0.6105564294450222, 0.33294930255863486, 0.7779322681297114, 0.7874351134245036, 0.8827608102489558, 0.48339733258770123, 0.8128790068030173, -0.07888873196383447, 0.18115667409064, 0.7633524124725631, 0.5832389418995448, -0.08669534659725987, 0.7479835573396826, 0.5160020315508587, 0.5383937421571227, 0.07203077781455126, 0.5028952591173156, 0.1989870311409941, 0.6078763066041271, 0.5849658227220066, 0.7599554113232094, 0.0907901720624915, 0.6883786758137779, 0.6674965786809413, 0.8173675840108353, 0.8813605850973729, -0.30871694701356145, 0.629663296761258},
    {-0.3161289595534013, 0.595943609445845, 0.13295445778843443, 0.6680694636560797, 0.3823553439572425, 0.4844855132922549, 0.581649520004537, 0.5244723177740961, 0.6152516064609007, 0.8226493982086707, 0.4134964472036872, -0.0062975211947621694, 0.7014632892974723, 0.7124497189722339, 0.6988678289201298, 0.04789000631063748, 0.5511481445036259, 0.4351502347139702, 0.7455334075591928, -0.18949009762508479, 0.6673121890356836, 0.6137694919656194, 0.5649522504273697, 0.8862100013039742, 0.8694463022053852, 0.09286471157329203, 0.6750933997493029, 0.18540010300763896, 0.5468579395235517, 0.7429158479638959, 0.16104752426444954, 0.6597670023518569},
    {0.1398906653498307, 0.681635244020945, 0.48273612597972965, 0.8491611069772972, 0.5548012989685579, 0.4593382209890848, 0.38642488632819444, 0.5487198440253421, 0.46705187903781453, 0.5406221587846021, 0.6795249709426487, 0.15820641701748078, 0.8040042637759582, 0.5617314919774387, 0.5980470901886701, -0.2754286123610459, 0.7811070579970537, 0.6220786464154155, 0.4896497654197123, -0.14776630209149155, 0.6442811208472584, 0.5794230093246904, 0.500759455869162, 0.7012680475082813, 0.31268709744520107, 0.18335365235163137, 0.43156712976329525, 0.7878995645436562, 0.9281906872461929, 0.7116582064569558, -0.08854820246656944, 0.4873253181012516},
    {0.018373456075169534, 0.7378843555426252, 0.01670429730430588, 0.4366225813887762, 0.6766197486863627, 0.725058432581568, 0.7575834150443208, 0.7207539569463789, 1.0038225964320178, 0.778291127358932, 0.8118775560786565, -0.35447898872764755, 0.5836450965717188, 0.709582044218526, 0.8463359514749917, -0.05004472582418163, 0.30073516513688675, 0.38621341925733116, 0.7067411507923801, 0.11103124019502664, 0.6852141583480257, 0.8733710063767066, 0.2988143403391097, 0.6738350690919429, 0.5703566439904869, -0.010946079958837262, 0.7222769232608677, 0.3979587947926956, 0.9046688131495819, 0.7236575624000714, 0.021427863319612408, 0.49501099290054035},
    {-0.3269225107810727, 0.49012766043292755, 0.49176184238429277, 0.6051617841048699, 0.7219015894098778, 0.39242541261360486, 0.45957485961936057, 0.46821596173739993, 0.5769651467341705, 0.7199528722211714, 0.7098925042668908, -0.3342073417797819, 0.3574041310074934, 0.4432474134571711, 0.5645665814594231, 0.17523876978038397, 0.5118780471305091, 0.25861008310975336, 0.45350218242055085, -0.01173000130050499, 0.5424295353972061, 0.5885073019165331, 0.9455498249032763, 0.6684939205768032, 0.6498244995552286, -0.2861369812873719, 0.6407876007705215, 0.33658796130182056, 0.5106435585072722, 0.7510500953872776, -0.020541077570925957, 0.8872074200967192},
    {0.07740188733778622, 0.37549431272122774, 0.12581159761259006, 0.4100019143962869, 0.5423197009216526, 0.8149882767968668, 0.6916507191779918, 0.7601619719145912, 0.4900079717420659, 0.6067189997165848, 0.7771635996216955, -0.05697956119022529, 0.4501512105969963, 0.49031062835911016, 0.7195606437075347, -0.011265214278877889, 0.4157977745140565, 0.4248780664361193, 0.7852882003367926, -0.2779326806927266, 0.4147044760677161, 0.6057097838549999, 0.6530293166925694, 0.6475941512928622, 0.3255196801887168, 0.18831912539838402, 1.0122966560303397, 0.6869476775789685, 0.4611504210484553, 0.4487249634320743, -0.1427287000882358, 0.656500536332474},
    {0.3486028535443781, 0.4767425360265258, 0.25086453200871345, 0.5753308846324042, 0.7075624402108898, 0.5182616773541094, 0.7499939462332279, 0.684187580092921, 0.6815972856733796, 0.3837959812588027, 0.6816112487024352, -0.036242535136082756, 0.38456562122191185, 0.6390657634395244, 0.661914075198, -0.18776017989195343, 0.6537766914518663, 0.26847319920526586, 0.3640474142216006, -0.3013698483783462, 0.4212289731129084, 0.21011400575235017, 0.43058118843302656, 0.5230706636836028, 1.0148770973436114, 0.2650152080214656, 0.4609904948842991, 0.47726101567694496, 0.3922750467911087, 0.19152333970416532, 0.22941007880769407, 0.2969623596737185},
    {0.13751941369004422, 0.473774618552126, 0.3010241954319774, 0.6877016110435835, 0.6468645085190061, 0.716800224323575, 1.0350791865128575, 0.5442592795832314, 0.6397697012952663, 0.5245998792878356, 0.577662352445022, -0.10513209564514733, 0.737571092834555, 0.5676618687283681, 0.8798669590084008, -0.27108361311911305, 0.47201671930481215, 0.7253236926763674, 0.3151547535531948, 0.09652032019597472, 0.6666000266479758, 0.4852286426820804, 0.33566352619896084, 0.8316466868781169, 0.7544202763893247, 0.15005997915657857, 1.0463207862460135, 0.4576698594374051, 0.5320016500866058, 0.8401115450154615, -0.35967958969476815, 0.6832598927234922},
    {0.24095472461908307, 0.346142840370053, 0.046910146000923206, 0.16850936411600104, 0.5900944113224164, 0.33147596220896414, 0.764299315224906, 0.47787617347026035, 0.7451158791956715, 0.9115405255924233, 0.5074150352488435, 0.22621545434742338, 0.7635367913857843, 0.6697744754988115, 0.5368949602272719, 0.12997967806775354, 0.5429685990578405, 0.35472718474354864, 0.5367283694691573, 0.0012568524866044368, 0.577615303264634, 0.40795026742468155, 0.7067144138638255, 0.8116412449449362, 0.6942265574133958, 0.05427306727103689, 0.872533758801193, 0.9266247276573445, 0.2223432647874637, 0.8368258225950803, 0.07029264610545383, 0.4298063679538241},
    {-0.4006519089081008, 0.5605032228538518, 0.3061118227157934, 0.6666794000797255, 0.8052736617918286, 0.48621511875760176, 0.7087346281050099, 0.7244629688801629, 0.5673634837583791, 0.4875359333909432, 0.45087572908911316, -0.21580825347555246, 0.6672713423319511, 0.6565199340643453, 0.4782683380418529, 0.07815625720550806, 0.5539685475671499, 0.39784288743169477, 0.5635662071505353, 0.09460489585184649, 0.6580857440101229, 0.22724030527727318, 0.14644096161073547, 0.5848998270375124, 0.5708317761747326, 0.14256801503489835, 0.5386259276880703, 0.4591361104280291, 0.5774456269006346, 0.5267570361437591, -0.07258026393383703, 0.3569845365782007},
    {0.06387103871991268, 0.3611425020449744, 0.20781670550583609, 0.49525742223861197, 0.7013297615765883, 0.8058451931508125, 0.40443742772757985, 0.39357991620240473, 0.5038970065025223, 0.4913571256266669, 0.7143013813253339, -0.0290853354713394, 0.43010662908718555, 0.46078538985011874, 0.5940692355772262, -0.23249701273595091, 0.6097602947452213, 0.5622642690214202, 0.4432229428454306, -0.06710411339872628, 0.43409475658971336, 0.2545502449775278, 0.598350293551966, 0.4615038952607263, 0.54474624411952, -0.30935032742170837, 0.5331595730953517, 0.9161250148943257, 0.5858311194372814, 0.49068456377386127, -0.027100369993868733, 0.6846199566581914},
    {-0.16498420837866576, 0.4431799381587987, 0.3016597562597449, 0.33931598535180735, 0.6658634844843154, 0.5342841619870552, 0.8842782817505345, 0.7008594025415009, 1.058255081360292, 0.503625087647353, 0.5049195497424617, -0.09979565554849927, 0.5003544482036192, 0.6151823338172411, 0.569047638913812, 0.05005103915273134, 0.6425831449964713, 0.7416919383063105, 0.6592669309873511, 0.11725575330436944, 0.8530912464365649, 0.13133203445962385, 0.8505476204772827, 0.7140026450758848, 0.717140867485789, 0.03909737310326837, 0.1381557780384924, 1.07708177822789, 0.5336322623161128, 0.5139107305860331, -0.1716921829733221, 0.8038005722846117},
    {0.07761226264455288, 0.5382161516547072, 0.3159861527283734, 0.6822737972351736, 0.6361842579373668, 0.7634946964984072, 0.7102456630888191, 0.6124920322431658, 0.4903787608665082, 0.28316330156105113, 0.8559770022455623, -0.041107057994599266, 0.6142849817886353, 0.7438506199778472, 0.42907095441115306, 0.023437754616941604, 0.3991167482738139, 0.5944183965163115, 0.5795245157160012, -0.09202610410537286, 0.4426615048003256, 0.550365587525679, 0.5141752108605363, 0.7000431594852661, 0.6803761452185392, 0.10914681159154624, 0.6513050861956684, 0.6800819483200847, 0.7096148448969631, 0.6143634276778945, -0.20076619711191523, 0.7156303058881228},
    {-0.0649693279030357, 0.6525474936860308, 0.01339096630048751, 0.5551519827708723, 0.6231695366196862, 0.26882955189596036, 0.6498090357097108, 0.4244820192297786, 0.383744369337364, 0.6494288907877039, 0.7250190953112202, -0.02457160111573381, 0.5525587386428357, 0.5654332319234634, 0.4156710511178605, -0.1335216821713018, 0.7082198817109591, 0.3592283621555758, 0.7442377198456765, 0.07012044181802314, 0.4596592238348553, 0.4807084345967125, 0.47142279426494343, 0.520014636579908, 0.5794474853808688, -0.036674585533646054, 0.8273419847046907, 0.553796290151389, 0.800724501292869, 0.9064240131841186, -0.13156038014024626, 0.6768607144644779},
    {0.029744275014390444, 0.6068711378922936, 0.35034160876946113, 0.30501496923165317, 0.6091030526132789, 0.8412867052570153, 0.6531058059989244, 0.7359529220730792, 0.6050143070505885, 0.4525423807686528, 0.36586585262107757, -0.11581624475387722, 0.5664914026334352, 0.6401820958677465, 0.43954127523778297, -0.2566256753427831, 0.4718639245454895, 0.6764122751460035, 0.6512745916132229, 0.18277075843943727, 0.5881432703831229, 0.9246696196502227, 0.4261024683493902, 0.739951913866436, 0.5547291932696866, 0.2529758117016185, 0.6562814565035789, 1.234967622664222, 0.5153856886920704, 0.7244964138886058, -0.19016294461995542, 0.7439243398583899},
    {-0.15471319951316473, 0.43281431532999953, 0.34150102747110445, 1.031945630178897, 0.5824293536737506, 0.47851023718573527, 0.39137799950330016, 0.8231693289530937, 0.5530906281785276, 0.44215676735550163, 0.7367407413877637, -0.0937860179089493, 0.6645602144451714, 0.9442890908645005, 0.5522262379342575, -0.09329674379910882, 0.43764044748642145, 0.5528976727084856, 0.4591952867205546, 0.13906011525908624, 0.6878305235476978, 0.41307770425432133, 0.4226762083204555, 0.7318704694206841, 0.7083267728751026, 0.034760609400669475, 0.5159343726990088, 0.8318763378450434, 0.8688277443770697, 0.293170791623405, 0.4021306704317642, 0.8041883335031581},
    {-0.06248223611045495, 0.37144074325210863, 0.41148609612577675, 0.48265996209308193, 0.7542947082322424, 0.5722072052128576, 0.21715347430207102, 0.21144198180792237, 0.7559938544095671, 0.6150815153063636, 0.46511636590548366, 0.042779377630978895, 0.3651845983309949, 0.5898620780809885, 0.7925195698440246, 0.09386379544285425, 0.6219643895618555, 0.7005503330353922, 0.5053205536091312, -0.3202049249164908, 0.8058683194097208, 0.25249045750845817, 0.5182383379297311, 0.7554807767640339, 0.6801759653153805, -0.1573920186713088, 0.5272928634170546, 0.8998101949855722, 0.8645925987834238, 0.5782892942459313, -0.35459981321298856, 0.7039871868337866},
    {0.1270683407268518, 0.4826120693842197, 0.28513910977536927, 0.8790306506581848, 0.6653038227751601, 0.6511102860559422, 0.6970520773129293, 0.523181069782907, 0.5184880464508391, 0.7882468172643435, 0.49109616265038203, -0.057072433880497, 0.6274474694090971, 0.8539436788466426, 0.38659100488362913, 0.21044077228487792, 0.6149686959899693, 0.6186108301827588, 0.43824925518410074, -0.38321818953250314, 0.7636656507234174, 0.23852169712952598, 0.6293102862011273, 0.6500831292608642, 0.7970077276654836, 0.03689127035557487, 0.566493754662802, 0.932540615369037, 0.7079611448828372, 0.6155377211251122, 0.007698775881675299, 0.5883203023925458},
    {-0.3204163071882892, 0.5624322815678415, 0.16129869376828346, 0.6185908589469064, 0.4063895795867949, 0.513028242864411, 0.6508306563267542, 0.5765102498184429, 0.714307788136759, 0.3791769437837051, 0.8095476091388846, -0.12866051541035345, 0.7466971433082655, 0.55632079775267, 0.5271321916995134, -0.1096723834745133, 0.6317405503379352, 0.5778737236493227, 0.42237004407399764, -0.26217617430520135, 0.5897572740574664, 0.4504887273296165, 0.6910618640212807, 0.543150326657686, 0.7696316015641022, -0.11578159921467823, 0.572256246781823, 0.48562855888168194, 0.5223388109426408, 0.6496185952550694, 0.03342094105844385, 0.42930087425467794},
    {0.14391474716223004, 0.4756695048633048, 0.2996667617578166, 0.5799171625899476, 0.6821930117521569, 0.5149696096114722, 0.9442018768108411, 0.575735870512185, 0.383989643347409, 0.5700040266923365, 0.5266069103360728, 0.00037093793007841853, 0.3784311334147902, 0.7090360717300929, 0.5590492613753841, -0.18718506679569563, 0.4254203372611646, 0.34802345101871734, 0.699393573832574, -0.1555621232498603, 0.3352854554313086, 0.3725274742416981, 0.6163791819166108, 0.5521077897694983, 0.7064224507480951, 0.03426314158190284, 0.5831976340365531, 0.5562324292282224, 0.5386565762417967, 0.614854828854435, -0.036749996211809834, 0.5567237439694418},
    {0.09607008755292261, 0.44721399373875126, 0.07486603292747276, 0.29322793462428015, 0.7410780671818107, 0.5632886918560172, 0.7411003191533101, 0.609099967271932, 0.7077248567796262, 0.5230028214112752, 0.5388308505850369, 0.12174837774025617, 0.44825221279046906, 0.6738279846242454, 0.3997617222970314, 0.07427988043966638, 0.6345651420407532, 0.9420597257780542, 0.4693719795600627, 0.10577743237884514, 0.5609900266810078, 0.671801640553463, 0.6760147853123628, 0.6087799422539827, 0.41400795374313015, 0.08561238892619419, 0.7995853534845989, 0.7509460510380747, 0.9710458321918016, 0.6208592381231145, -0.007476035379885037, 0.7152744886477815},
    {0.050858060741446706, 0.6496580847695109, 0.11697496166761592, 0.5916075336866888, 0.7541027304252362, 0.37387348663520587, 0.7378818072146401, 0.6672500617202061, 0.4666669795937752, 0.6983433298655006, 0.54902206618813, 0.15220043812425843, 0.5658826738459238, 0.7708516707764669, 0.6661287999996406, -0.04284519500067712, 0.42297118050479093, 0.3865358170035818, 0.5577865729413543, 0.0073061485489813805, 0.6190632022149536, 0.5213446392629221, 0.6097946807711325, 0.5693376071870528, 0.3460515883856304, -0.2702277690446022, 0.5722013967341173, 0.43763249483699673, 0.7911022232348869, 0.6845702162722919, -0.2552379031291053, 0.6648827945202915},
    {0.15565063386849817, 0.9763041586991008, 0.20263181043669573, 0.4277090894198799, 0.5486385989482474, 0.49501071128573776, 0.679753302614903, 0.5705439237664478, 0.5982186035140001, 0.37587315643007313, 0.6620375422187159, 0.08801809887733479, 0.5584227135397978, 0.5098273966714841, 0.5470380832303178, -0.22618049889808825, 0.5877667618349384, 0.30156919694461654, 0.7851035509544942, 0.00024742419800246023, 0.18581207028929106, 0.3877925731711791, 0.8008453253091734, 0.7958265014286362, 0.6851857128329369, -0.1890685804362186, 0.36475822373079186, 0.6640887318099183, 0.6060795285696299, 0.43587711152266667, -0.1462509962420898, 0.8253694660639165},
    {-0.23629559604289355, 0.4966179171735144, -0.1089370358398596, 0.7769548129057324, 0.5635507537821892, 0.5894536993017326, 0.7671833997364454, 1.0396291377607239, 0.5717118614168202, 0.4936068410014347, 0.9388648870356163, -0.01654299157118928, 0.30418129842554675, 0.7025367562260072, 0.6837702334056078, -0.11137444664333747, 0.5692551755802137, 0.535010132498829, 0.8583452324631731, -0.20858726260961166, 0.846271580805354, 0.7582857696361416, 0.6458822730819749, 0.5391081925702692, 0.8245833954802627, 0.4487603462575609, 0.5636401910741304, 0.4716446075320014, 0.8506710399683026, 0.7246769176483894, -0.07850267259293642, 0.6959592507575654},
    {-0.018260729924682036, 0.4159713334617684, 0.20573462226644068, 0.6220580408242907, 0.847330513233617, 0.6182281657133616, 0.753538223512179, 0.7993134786725944, 0.5891254293754701, 0.5350847787950667, 0.7324694793601231, -0.0537676891695129, 0.9211084101998179, 0.5913209968353123, 0.5180308210802868, 0.0674125476561057, 0.5220637693987853, 0.43529179937022205, 0.3212679632676553, -0.47222657911930366, 0.690786254638986, 0.4539341595928297, 0.4787922702637653, 0.9677967534371412, 0.9149350639074171, 0.07001519687473269, 0.7217031473344699, 0.26625564520421136, 0.8282849121423266, 0.7948418165378321, 0.1432076331653369, 0.5469951672223867},
    {-0.022848473315928344, 0.524003848820065, 0.21045208306152402, 0.5002829177365923, 0.7355168271420746, 0.7890534270049604, 0.6434422397463448, 0.48654936484471456, 0.3924748856689801, 0.4364773623316697, 0.5928847008890128, 0.08160969831995178, 0.15459204858271877, 0.7906562780009656, 0.40252204610307457, -0.09501746727551096, 0.5571363907483153, 0.4669521845727058, 0.4588969133095402, -0.15133912773793776, 0.5720522659342356, 0.49872001085650414, 0.2264183644253808, 0.4136918329645565, 0.6052801468918868, -0.03112970456039498, 0.3599594731661491, 0.698608474438218, 1.1226769776644494, 0.2904350878848048, -0.14461013034936643, 0.6530273553700451},
    {0.2007536773681771, 0.49887526818589284, 0.08007098193502922, 0.6284542385628351, 0.7962147929974872, 0.9411866867506526, 0.6813976811652059, 0.3894607887368998, 0.5467385105247158, 0.3617124178698413, 0.31915123345887575, 0.3637765566232345, 0.5137441831076989, 0.4915196612407578, 0.7733602280197387, -0.1399070600097988, 1.0880556360543814, 0.7186718118593892, 0.5250310500073614, -0.07904592621889028, 0.4765018038949338, 0.34872967448273723, 0.15722013454404968, 0.49987996712655003, 0.6062607269695941, -0.01674639017290009, 0.23190990697538594, 0.6838713988737511, 0.9571324913083222, 0.7171184685784079, 0.044182861835015894, 0.564301139880601},
    {0.11466783343367573, 0.45958087508414447, 0.35717178190029547, 0.46598712834542605, 0.04348345884206973, 0.4154700695671668, 0.4654105044186213, 0.548071294091818, 0.7419079455609501, 0.4889630698231406, 0.6923568965164246, 0.07776421014022762, 0.5309636593458551, 0.5561744585212469, 0.4506418160314971, 0.3258744260854046, 0.5596793960326145, 0.4359255353711209, 0.7192582215315925, -0.24495571578716857, 0.7680873961568189, 0.46572118154458647, 0.5481586838194484, 0.6017577147091935, 0.36938325753355605, 0.3898691506782256, 0.6010554873630654, 0.6017773968299868, 0.5185584071492966, 0.5178090629555497, -0.09655399214171966, 0.6076211797461367},
    {-0.23241079128525768, 0.5865398270001656, 0.1748954766426989, 0.13549406967007133, 0.4421879846293968, 0.6183559068796232, 0.6103001643935846, 0.5988304496831006, 0.9888089641926503, 0.49026352181282973, 0.6728945663397755, -0.22304312766867967, 0.6169179912959857, 0.7907352895423969, 0.7112144155339264, -0.12875444412095471, 0.8653345239103685, 0.3699611743372663, 0.8094691019776173, -0.10283041661535383, 0.33004375875132036, 0.3549546923553626, 0.571498742633646, 0.786259761871872, 0.6362929171527855, -0.10925082932155626, 0.4311012690732949, 0.38877650083461557, 0.7543767391997236, 0.628392197741054, 0.05345675231612432, 0.5416813457227854},
    {-0.0840801250016463, 0.3053330660324247, 0.11096790996076272, 0.6806530949549717, 0.4991962327983915, 0.4116568336854275, 0.9999624241147387, 0.2722614854386132, 0.7457310936702691, 0.743211994524182, 0.34941681841719113, 0.014648342219852065, 0.2608106817898531, 0.6176713360986618, 0.612589160154166, 0.01746158520839974, 0.47056737792969416, 0.6257488923265861, 0.5334213578577472, -0.13990773757214042, 0.5629551289192811, 0.3655832179122506, 0.48080846685676476, 0.3920380797218932, 0.6257268818949939, 0.04550266086579445, 0.5248518275468386, 0.5037779182787901, 0.38799264134303, 0.7111206387305788, -0.1605613815693699, 0.5671892748051384},
    {-0.024962299484864833, 0.3224827442227959, 0.34837477031200276, 0.8047254231168474, 0.7840424929161542, 0.629066386522609, 0.7621913503157108, 0.7672508488497802, 0.7307110174007391, 0.6278623476989117, 0.5582787996608185, -0.23753187561451994, 0.6089325104523936, 0.5818724647733406, 0.48851104605069995, 0.08135024213997102, 0.8441977753360792, 0.7980977086020653, 0.480571856391019, 0.12768739611272611, 0.7063766284182277, 0.1629109394711315, 0.5061188576771826, 0.39930489771143546, 0.8156438077638702, -0.019731556731876702, 0.873105795189766, 0.7214826595775877, 0.592325646229726, 0.48796242306966364, -0.2442008195216649, 0.15751520565330926},
    {-0.11542818186646218, 0.9398210268055432, 0.38464558536097176, 0.8023387273345073, 0.748834854898091, 0.4405171072319133, 0.3986888199648523, 0.6186039226903994, 0.5032768812654372, 0.4119560939944145, 0.43047407793675685, 0.0054927941615227445, 0.6670705503326291, 0.6037292090265682, 0.5617604811700141, 0.10247619213319989, 0.5358028887143554, 0.5051775892236111, 0.20302380156336716, 0.13653001500578632, 0.5611400012413285, 0.44228939890860913, 0.26498945106613303, 0.5580015536205593, 0.6421833122739777, -0.06333016407956372, 0.7052380206150586, 0.5422020683168749, 0.7591740629168654, 0.4025574354222342, -0.32126895828573904, 0.7398935783098455},
    {-0.18900855841610395, 0.45082375016476806, 0.406291180401131, 0.5754862102146554, 0.8679079091056591, 0.47323970090922224, 0.9394510323603131, 0.3281350170609427, 0.7539369360500919, 0.5900503302133577, 0.8073381870921154, -0.13323300917474595, 0.5598393815223953, 0.49125424308233495, 0.6220992293057984, -0.07873017725487857, 0.34708864103222664, 0.3874030566325449, 0.5187553974697977, 0.17878055255092046, 0.48096517156337326, 0.4571022983567758, 0.7362304464150898, 0.9029116462193602, 0.5401741772463869, -0.06478042433487041, 0.5786869159700382, 0.4170536470218781, 0.7762712708171979, 0.4807066772753736, 0.07213674739773278, 0.4229917030322829},
    {-0.150748251953991, 0.4511837065120915, 0.033737085926460665, 0.5648369083088438, 0.53840976820654, 0.615212663533072, 0.7886607648946284, 0.5982110631219365, 0.7173958381323416, 0.9273744739237223, 0.4933893385153888, -0.2759420281865611, 0.5071837727412826, 0.38949715401929, 0.732237724715194, -0.25337829886770125, 0.3667061694489142, 1.0826790598680025, 0.7851061704458627, -0.1666309637221137, 0.3335655843592007, 0.46543530993002447, 0.6602715077299469, 0.7863654317214439, 0.5576714319462319, 0.05568937380064211, 0.419775295562627, 0.8560252486468138, 0.4524035715970829, 0.764259779354766, -0.27840248871139556, 0.19893295171038136},
    {-0.20760420758348055, 0.533547302462592, 0.13439785613364852, 0.43002866472957796, 0.6444539111321176, 0.6230532692128553, 0.8563574336309587, 0.7209684282243566, 0.4807638000795436, 0.2432468205427211, 0.47814491136475473, -0.2156260658757804, 0.6110046572719635, 0.5481304801286474, 0.5744254975769606, -0.008220854871372857, 0.3855824143983675, 0.501671485122048, 0.5378119465614369, -0.21530857376138646, 0.588566816678755, 0.20068513639121358, 0.7694537580491762, 0.5135324806372639, 0.5839583431405992, 0.20955431314013379, 0.522074533674951, 0.453875591767082, 0.48043787184587694, 0.4383774813025355, 0.017891358914320477, 0.6902924708015017},
    {0.057020191657227874, 0.6422579874071622, 0.4744301494820663, 0.48895870898130306, 0.2875151795947522, 0.7392029066497684, 0.6756064845639622, 0.8854514576748896, 0.8544385174777638, 0.3783939639527416, 0.5029391624100352, 0.08504167541786375, 0.26475585542841107, 0.596394587205955, 0.5705649768270031, -0.03495294831329698, 0.5066241395932606, 0.6098538061335393, 0.7932533102743057, 0.23293818888031834, 0.5443256044461672, 0.5201072907125951, 0.6667127327444955, 1.077060960493384, 0.6089813664043526, -0.1565301233980246, 0.6858513756411126, 0.3969652756739548, 0.5837403259879447, 0.5443685245443797, 0.18871028183196975, 0.5512628923109681},
    {0.01996367421915054, 0.8407424027058379, 0.15901125045871284, 0.2861406822318258, 0.34379527012804934, 0.23675150449597063, 0.4854716302171526, 0.970834633241692, 0.8027352869094618, 0.42275948409714487, 0.464308675611506, -0.2645363786984097, 0.7417708806088824, 0.5950485594321924, 0.5663055676742215, 0.20587792957437304, 0.6263189090635223, 0.423832825491527, 0.47226786970006535, -0.11376110770607528, 0.8912152367537579, 0.4536450615571029, 0.7956117332511828, 0.6375288706291521, 1.061075043983203, 0.04071467155983848, 0.43317132850788365, 0.5266511468938833, 0.4255179405640802, 0.41730537538018186, 0.05017607092020114, 0.9136471929351166},
    {-0.05452702356686981, 0.5469720274126507, 0.1967107541125672, 0.43665145448192255, 0.5851856391761011, 0.6650632465547647, 0.6817750008629752, 0.44756296496087417, 0.5606111554194737, 0.6056406728968687, 0.5991347650560158, -0.24109914858903053, 0.1751127438396722, 0.6428547149646712, 0.7648992292432385, 0.3965506481698888, 0.40705655331152196, 0.4639624778988077, 0.7098397071150921, -0.07214108749219324, 0.7568896148602396, 0.3182502662945356, 0.5758320660541251, 0.9474646402393144, 0.9295020887466708, 0.013706910955362082, 0.4549475725574886, 0.6518658852912356, 0.5332874946163678, 0.5285646835086457, -0.15122145893419323, 0.5522130348516145},
    {0.15279204118015877, 0.2182482787026468, -0.05452286057404085, 0.41687584474964007, 0.5199932299541687, 0.4583273809251495, 0.499239056383609, 0.8373995303411627, 0.69437768526502, 0.26196599878220106, 0.5247591634580088, -0.18443984011720796, 0.5431155910281541, 0.5403644057466275, 0.31682110086638626, 0.14234740375734484, 0.6681579040448987, 0.487640320846271, 0.7671069273661902, -0.1705654572105923, 0.4299878622395148, 0.5998193831613936, 0.5327423003742946, 0.6312213589482765, 0.956964211668483, 0.07922033927525492, 0.5604497237655297, 0.6638345762969275, 0.5470860234081704, 0.8339251511863374, 0.13116197057599538, 0.4046741884560935},
    {0.06618399474881077, 0.5389629656062556, 0.3309943786314394, 0.438847319250583, 1.0143466233588532, 0.5865661828919618, 0.7968119398230646, 0.5682766874086712, 0.7132979448169349, 0.7666532330453709, 0.7027853244738708, -0.19686530889648943, 0.7286460675564855, 0.8881237572893568, 0.3843871409848274, 0.034648949726657004, 0.7498266446948993, 0.39693690568981327, 0.5344543923853714, -0.3502080303909623, 0.4633536393316942, 0.4807251852119249, 0.7226409713482455, 0.420166992548592, 0.6122430942177872, -0.2767729141871263, 0.7255412222356223, 0.6925994777400792, 0.4188401819830025, 0.7463596646341214, -0.303212716249584, 0.1848520017733789},
    {-0.019085982757831195, 0.37128814571017055, 0.3162898593473543, 0.5187386806750064, 0.6530498227295827, 0.6988169145092066, 0.8176584261938059, 0.7024884956620858, 0.3920096655787013, 0.6745203677240974, 0.5873600278267512, -0.2107106872807907, 0.30017265317662567, 0.5346916528245292, 0.38478913403118087, -0.013857722933532414, 0.8012319843473481, 0.7653597167575665, 0.7095314096692943, 0.06183139850277197, 0.8454796812207216, 0.4635540703772525, 0.5400631019232569, 0.923527914160149, 0.5613592314492537, -0.0681116632960896, 0.6774380328272377, 0.7857057571937002, 0.3215281899567036, 1.0039278540568028, -0.3072053196963208, 0.42110805824207326},
    {-0.25164489275864577, 0.617884303371492, 0.20107054719288922, 0.45926344581288414, 0.3089800952681586, 0.5212641692468629, 0.5701356795414297, 0.5023193303587499, 0.6424384793739054, 0.4509183625320999, 0.606331449826298, -0.497720364918441, 0.6032309230314927, 0.6229902936185757, 0.44209741338606556, -0.0768483822120293, 0.680958575276053, 0.5897853454491211, 0.9568896505625402, -0.42438884246029257, 0.8879477667697162, 0.5738114571345357, 0.5624238741588454, 0.7050426402220373, 0.4847699532629322, -0.4962510071387886, 0.299249747293017, 0.573172690920039, 0.5251099830435553, 0.9800862994946987, -0.16406784071124988, 0.6070285977361773},
    {0.1264249512921441, 0.6236335448347123, 0.25351099184564596, 0.5238200119011861, 0.6873584430751366, 0.7998032129785155, 0.39987561483639456, 0.5957087866624243, 0.8190546491630124, 0.654723967275558, 0.6490877678707998, 0.27851344912531406, 0.5624676459214207, 0.6089194696339886, 0.3714745852806467, -0.06260485464977883, 0.7417777838645105, 0.3339140058309613, 0.6015158127974118, -0.011116819259060565, 0.44031342892969905, 0.5692763690062927, 0.5878379701898343, 0.07917000094636936, 0.5082450185817996, -0.11253590247351516, 0.7913751459560048, 0.5785759822806629, 0.7846921343951097, 0.47793168586780105, 0.30344223539275944, 0.5129383728671755},
    {0.2282735864303049, 0.6195244827902314, 0.07714096417727224, 0.5462910973097235, 0.5067706034689383, 0.5574389788510641, 0.26582719174809344, 0.5343193909699611, 0.6297072969727382, 0.5939350418952987, 0.7260239336766898, 0.0927642653208938, 0.578045209751072, 0.6087089802744952, 0.5107506365104848, -0.10409990291257645, 0.8428405211530587, 0.6918277596303956, 0.7834952019196189, 0.24361703990532427, 0.4260240178401857, 0.4860440250059163, 0.6069739208761642, 0.8179052681116065, 0.7767123038501142, -0.014040858537899863, 0.8259081575214553, 0.4090719296520327, 0.6918434057524244, 0.424754323558716, 0.04990140546877699, 0.29168100846616607},
    {0.1688876885568464, 0.7277458515692151, 0.3497293975462508, 0.49275933735228805, 0.5517091350636951, 0.6767414643010815, 0.7596270414508174, 0.3449981024669948, 0.9026255729645335, 0.443490585050226, 0.7365491228337985, -0.0398909507703539, 0.5673547272710223, 0.3229863253751874, 0.38516956967387284, 0.004789224482876011, 0.7129425432391409, 0.8402527710215503, 0.8248532145588693, 0.24561360035972607, 0.8350183511667111, 0.0390382025099501, 0.4310920514590205, 0.4529738599416053, 0.49855071211764224, -0.31803517560227185, 0.39838884171885747, 0.4225143922350916, 0.5335241025364879, 0.8468928113792853, -0.06637716354899931, 0.7819803065891718},
    {-0.292160290212271, 0.22308553702011544, 0.07510182856787476, 0.39230392701950517, 0.30903852957936906, 0.7098146085011301, 0.8099944237602729, 0.7477657554233197, 0.5543239703875309, 0.4614603995866568, 0.8828841148234923, -0.09891900580162417, 0.44654678267184955, 0.7556936067416736, 0.7679861750657223, -0.28237728003713475, 0.5836089669905042, 0.6010103924114053, 0.6929435806678563, -0.037669817187905665, 0.7661834396144528, 0.32562983623445985, 0.6052512571294903, 0.6259707932860534, 0.7921772222278423, -0.10688989462627728, 0.3555848502968939, 0.49413946678970433, 0.6824828875203027, 0.5047393491923156, -0.07302330731604997, 0.8432018219287674},
    {0.12567416509263202, 0.29855193023049814, 0.7258829557907126, 0.6330651776250392, 0.7508742983848294, 0.4542804348374695, 0.599893499350851, 0.7158304261089196, 0.42923689042184004, 0.6261260262556028, 0.550275849840555, 0.02943793440075217, 0.5413479637908344, 0.5628913479168107, 0.09558914342735404, -0.24894433837177368, 0.33057201024992033, 0.8167026289507647, 0.5793096649543813, -0.06005904911736007, 0.7233541843728942, 0.5093300384221302, 0.22902860019310375, 0.6187753572746905, 0.7182704557833662, -0.1524195259312403, 0.7389488754864175, 0.6717799709491054, 0.6830527966490003, 0.6138358592957224, -0.3246108927520075, 0.7594761761600727},
    {-0.2423529812198605, 0.5412553925663431, 0.19651833492898385, 0.6189216788437416, 0.8015289614857029, 0.30002087301164626, 0.9214101256388677, 0.629032909145291, 0.2462990175460822, 0.8734429322499738, 0.712946352809371, 0.2106836231288237, 0.5263382476137255, 0.4364421057906912, 0.4820552042601245, -0.6330204652199972, 0.05330442316808456, 0.6726083409309422, 0.39579280233887043, -0.1390767874056255, 0.7003488109786495, 0.5660641730226759, 0.7243735360468482, 0.573908908947625, 0.35550585573909643, -0.0900628977344689, 0.568436881790096, 0.6595046616574352, 0.7486207210600695, 0.5895438964907186, -0.04966882874933152, 0.8545611842075733},
    {0.06318325954914587, 0.5582878400349734, 0.0014042557789012346, 0.47013817292707605, 0.661136483027217, 0.7160588165315709, 0.650709971812415, 0.5776842623744504, 0.6841992817219844, 0.5240604874719463, 0.31994715098713333, -0.012400969881943015, 0.5833143149723068, 0.8731472294815289, 0.6047289308686187, -0.005572207201711308, 0.2512335869219545, 0.645528113910408, 0.3601192555622976, -0.3025114027557685, 0.6575957856526884, 0.3265145165307676, 0.6785041911081505, 0.4991333028662261, 0.6999392541932071, -0.062213777612960715, 0.5609741555252437, 0.863772727543515, 0.5524990146911879, 0.603729519585806, 0.1280477565215722, 0.7378857891854809},
    {-0.22256619330327782, 0.5651470741154555, 0.4506874746632407, 0.5337594277410589, 0.628366068519068, 0.6778856475586722, 0.6875496388027477, 0.5636183365761791, 0.6438570183567063, 0.7186082304695399, 0.7218407565049118, -0.18877630185069635, 0.5704787558677074, 0.4367860807654253, 0.7349111931497998, 0.3726118401258148, 0.7095212327836591, 0.42006355263657585, 0.2253777510880571, 0.05288978194470025, 0.3857575505172316, 0.3074233110530822, 0.4534260699928048, 0.7606028430294137, 0.5011941242310185, -0.02946920914779564, 0.6234443541284399, 0.38015517994757614, 0.6028961884656047, 0.7384134560878471, -0.2520682534841421, 0.7056201157589049},
    {0.13217213516648552, 0.010986098037863018, 0.3766486994660751, 0.6379194159949628, 0.5398777697302304, 0.5518340544875753, 0.5680251184659632, 0.5036078128490369, 0.6649763763263363, 0.5050537007084858, 0.7287421303151403, -0.060154587120317876, 0.30981961401412006, 0.4120975225926381, 0.21617307617481316, -0.05761747308549213, 0.5021559627490246, 0.3262770476462173, 0.5520896800600684, -0.23587818932124693, 0.7060619843016035, 0.6296358663480168, 0.4607007316329928, 0.7516875490078678, 0.5887296966625599, -0.17585219033269056, 0.7387902162242251, 0.48804336497780015, 0.45362694005286447, 0.5250024770150323, -0.02951575986186718, 0.6366829359279492},
    {-0.2317293728096822, 0.7344798726641548, -0.01639372972158344, 0.5995715231858394, 0.5379389702316618, 0.4164098188709618, 0.5313691955239398, 0.42558843881964703, 1.053504405955367, 0.592525502161142, 0.28491297271043786, 0.06742694740107708, 0.4648506432025951, 0.7976704828035734, 0.6410298564616971, 0.22741071966617224, 0.2858251575215261, 0.6491893770540975, 0.5246973565904532, -0.16616924066708044, 0.4640199779560852, 0.307811346015882, 0.6414756970133885, 0.6316861850886092, 0.550159753091652, 0.1058570535818813, 0.7842978144600834, 0.6379981387354935, 0.5344565333995869, 0.515118152441796, -0.030312741320703326, 0.6638042414989799},
    {-0.16320664701272333, 0.27859280472987935, 0.6447875991937202, 0.689779966958631, 0.5495865263161244, 0.6311463625098097, 0.5592599381752417, 0.7824757030051029, 0.9337242136478582, 0.4271869955204748, 0.7461810643077214, 0.0022794945354553523, 0.4633073288333211, 0.6934033244851382, 0.4903178928683229, -0.025965695072371876, 0.5088036380624098, 0.6058678606178884, 0.3001470904559821, 0.13299589013589647, 0.27187723699576793, 0.8293055889107814, 0.5589352549314879, 0.2248680718915535, 0.8849935805446755, 0.003776495079592708, 0.7551000581451378, 0.6696112361089074, 0.45215167571491405, 0.8545866029989488, 0.06368172472035204, 0.9024229321253134},
    {-0.09195499528262871, 0.596416601228839, 0.13289724878578793, 0.44352147789548957, 0.9111937172522507, 0.3995162067175602, 0.5668693128903642, 0.5986652742954289, 0.25102631599521175, 0.5736083269148511, 0.5346384870172952, 0.24584334555668397, 0.4914595860102458, 0.8307081120546707, 0.5647195014932608, -0.45845490546937273, 0.2691982263094393, 0.6672778100449234, 0.41619789953565955, -0.3240097251899568, 0.5795435521013688, 0.31312190560576075, 0.5292792539148419, 0.8772798355240089, 0.5718944270210694, 0.028838161008406468, 0.5239257440312935, 0.43403488224649694, 0.6366654534472408, 0.4963931879180746, -0.014261679527618644, 0.5766366624546799},
    {-0.13965718870790483, 0.4977340467887217, 0.2853442040984339, 0.5902434929968642, 0.22779790251555398, 0.4480638255738621, 0.6726869223086015, 0.5174632958176434, 0.5815910174651134, 0.5274103700469466, 0.894774518740514, 0.1448582459798237, 0.8255704627847983, 0.7425461612203863, 0.49599328429318523, -0.30549926279959844, 0.46635885216563944, 0.6161216906133549, 0.5892818161290645, -0.3155752808672043, 0.6370436589294424, 0.2572403201074937, 0.7844887635590345, 0.5716365769814785, 0.5824743403309542, -0.1372141853765276, 0.7797443665659055, 0.985690652798919, 0.7479803680546635, 0.28678166144776535, -0.10736018784693262, 0.8429773534971589},
    {0.057424147304159776, 0.2527579720728865, 0.37811156966768616, 0.5664982057366854, 0.8956999888140077, 0.5974304268342167, 0.555012920639126, 0.5852431622102523, 0.7117987838017711, 0.5985085596528348, 0.44900366190056024, 0.07087862448387278, 0.7195292723075127, 0.49297890482258616, 0.607942940988604, 0.07873942944450628, 0.3387673934731724, 0.6499088204848736, 0.18288139109963816, 0.26155486913341885, 0.7676384958464935, 0.330187125402906, 0.3437449523482316, 0.5507158573990272, 0.6774295476793277, -0.08365928476185575, 0.43709193563841436, 0.6757194197583647, 0.49453076035920596, 0.4023553438191877, 0.12792862176010958, 0.5691052532834256},
    {-0.1672651142054723, 0.5049886670666259, 0.46801871185853267, 0.40721954876739025, 0.8367459689205343, 0.7694319857541508, 0.5277371032265145, 0.6201181640652863, 0.42331426921609167, 0.20838766172698533, 0.9321727640555046, 0.05513189850043963, 0.5821937927665778, 0.6583430926028425, 0.5637747635773187, 0.2692061838326546, 0.42350982101032447, 0.6038973475965936, 0.8925464538006653, 0.10245671787067788, 0.45314738431283713, 0.524345096650012, 0.42453933033824975, 0.4794042179930718, 0.8882439677979326, 0.08659530145771241, 0.6736817162786228, 0.6310490479816638, 0.6438052560790157, 0.6024353367841733, -0.054921099745117524, 0.4547228381965762},
    {-0.020575947809660284, 0.6099357175303602, 0.4421416382785009, 0.44451726949083536, 0.5319718563405554, 0.3088856972474864, 0.6550789760770407, 0.27882353065160975, 0.43191860576698893, 0.7835478658022399, 0.5847256688244388, -0.07675609487785563, 0.6484773259128, 0.614814619778756, 0.315851588355693, 0.14727254598712047, 0.4420681707353972, 0.6222448063944861, 0.5621289753251354, 0.3002707846540854, 0.5077555666577886, 0.1639894055364271, 0.6375745876549486, 0.49071582127739316, 0.5361655824085774, -0.3317496375244544, 0.3786764419526214, 0.29945909251729314, 0.6594475830101715, 0.6062764510995813, -0.08007196352995305, 0.4819730155514172},
    {0.0267155230827479, 0.5838172903860464, 0.40617207568322355, 0.497231126846474, 0.5506204761521283, 1.0046988692716166, 0.24125335128644795, 0.19182608941042126, 0.8763178662413844, 0.898649461847281, 0.698757712764459, -0.024045942353844413, 0.4007603886923474, 0.6058964593717877, 0.4623199281669116, 0.25708172290857784, 0.6358767368715875, 0.5967016810596455, 0.7602373619527224, 0.11366973831153687, 0.6102958743471111, 0.5722928660649784, 0.5743618771812853, 0.8557876487721727, 0.6897082168500606, -0.11579278444793627, 0.23983139811747264, 0.5258838889822177, 0.5650975762053481, 0.6679513976772716, 0.14267546433266556, 0.4183462485089136},
    {0.06571559620834261, 0.5452394690805588, 0.19498073587724352, 0.5151530137465467, 0.6576373856094535, 0.49777926948296897, -0.026428866179147064, 0.7635911315220699, 0.669989096694044, 0.7404263590623282, 0.4202414154381788, -0.12409336435054553, 0.5452567999928141, 0.47383504066170085, 0.7399549737879789, -0.19675200365455534, 0.6305442081543983, 0.3975013087047056, 0.7124060552768374, -0.31323755302475353, 0.6881035832594272, 0.646553134478516, 0.8995079213955717, 0.6112678388526817, 0.6088977035184968, 0.07106395594873754, 0.6055161584569235, 0.4571592729073766, 0.8799836804703056, 0.5685500429862118, -0.16771044462650683, 0.47833674723048375}
};

static const float b2[32] = {-0.03314308390088454, 0.4861183102422848, 0.2524325837039642, 0.5826766484509972, 0.6208867533815978, 0.5405162660814239, 0.5777298686494154, 0.6132138845256409, 0.5697412003382488, 0.526473680532979, 0.5886091290612401, -0.0467974384397129, 0.5375127357707844, 0.5806679453467087, 0.5523016228987089, -0.029527319829364358, 0.5847829511827486, 0.5390948209559241, 0.5922519084525601, -0.0717977705248036, 0.5442543905265493, 0.48110390919979684, 0.5090314737036391, 0.57108621431806, 0.5949193568690999, -0.035954246778949796, 0.5978744429399596, 0.6238274924493243, 0.5996695466558684, 0.6101775103088081, -0.07544933249740345, 0.5776919709632298};

static const float w3[32][16] = {
    {0.0927847222443805, 0.21767923251702714, 0.41387666022145597, 0.0474312549878048, 0.24167916051534905, -0.31806658106229097, 0.27681166544134833, -0.005262221834439686, -0.22282533018336176, -0.08306732501963603, 0.15349227827272544, -0.1646895197860938, 0.13264236388392647, -0.4859815669381989, 0.18509305421710603, 0.10704272878235761},
    {0.5376334194615774, 0.528250025768071, 0.28550336551048255, 0.6607209068405383, 0.17405618295209363, 0.4134870468340546, 0.507962428717155, -0.40371727083294856, 0.766891854830095, -0.0482569101005321, 0.7220400264680734, -0.3467522376180841, -0.4029429568423741, 0.0720493569036357, -0.1116924888067091, 0.6310883730421589},
    {0.4304815266072696, -0.09525182011752592, 0.011308697808219666, 0.7127655020157463, -0.48345251002394496, 0.02150593676406669, 0.2772947947893437, 0.1263900741966722, 0.25914881843106785, -0.11917835439468992, 0.6448243055172802, -0.11639248826458241, -0.013885411724984182, 0.8135471447876286, 0.15055428940541093, 0.06223499307360916},
    {0.7127158566325611, 0.14123807140410363, 0.17451875320225993, 0.6850453330472395, 0.1869228125161258, 0.5381878355279721, 0.558060748715939, -0.0451220520350098, 0.9789903633653418, -0.29614525460584995, 0.34022045061347916, 0.09378793682310965, -0.3152987319030322, 0.7693938123359763, -0.09403745580387124, 0.6203098533967562},
    {0.8803938358839305, 0.2861026026822774, -0.02401832315133811, 0.5893710910118279, -0.14893648811753135, 0.893353014436565, 1.0492732191099277, -0.16598694536543496, 0.9932600287660277, 0.032490233644831716, 0.6375052876600098, -0.07240144721750072, 0.0767913761334571, 0.4908121123840711, -0.24282309971967841, 0.5235827152164005},
    {0.8915776868797952, 0.37944604186174896, 0.11926853089895958, 0.39395637896439445, 0.3129989587607145, 0.5535388831871393, 0.3908838351509944, -0.0959045188023543, 0.5159557181130433, -0.22730218457441054, 0.904187927632183, 0.286835178279756, 0.3536961437084016, 0.6096431247243577, -0.07096981887226612, 0.7091469903373719},
    {0.41798175292097633, 0.21312893582246148, -0.14057435505440466, 0.9285794029566795, 0.031293715732620776, 0.689473151586283, 0.7251369948642868, -0.28413683995670236, 0.895579956657199, 0.056980296462712174, 0.24330636014949192, -0.5045999519856557, -0.06862006860579553, 0.6259351675569772, -0.010819421836162935, 0.9543289918824306},
    {0.5568390677651279, 0.38971248105296036, -0.4864191183422167, 0.33087262801326744, -0.5690241242323865, 1.0919767597154897, 0.8006250559246072, -0.3011038283607033, 0.7261964815054298, 0.04026280511183341, 1.1399638814864506, -0.15984657058055252, -0.1252095231896762, 0.6206107671509691, -0.12231290852990925, 0.47129317797256426},
    {0.9196019418565621, 0.8892032689530726, -0.21716690227762328, 0.8758762504342908, -0.25798316633306206, 0.7388351425235687, 0.632997272023945, -0.24149732295049314, 0.6597645393177194, -0.28951958287197294, 0.8696228123343193, 0.03363075791051806, -0.19969675238158488, 0.912025185090796, -0.24971353147951714, 0.5065422862139631},
    {0.446618217234834, 1.1346226316734715, 0.42791347970682453, 1.0028544867832205, 0.30220715770204437, 0.8073659859893889, 0.6645588835352123, 0.1765449418516952, 0.9786799789548319, 0.19570086869275366, 1.04971223651846, 0.014802905957302031, -0.20968777970055505, 0.5660290456908711, -0.44747886429472855, 0.624601479096816},
    {0.8860395256068181, 0.5063128944288638, -0.3883926319254406, 0.49131086558265824, -0.02722454441485645, 1.2674848281884339, 0.6782303541623441, -0.052112899861156595, 1.0766603237040244, -0.19017610429680723, 0.9141322408748448, -0.17009680935153548, -0.11772010780498618, 0.7197545463788654, -0.4221424711158924, 0.5066920017181329},
    {-0.09876097785923214, -0.026722140689068585, 0.15256191591242407, 0.15182725121165658, -0.05139272185246332, 0.03129296595668015, 0.18578550109117703, -0.14446723881067466, 0.16331729763526248, 0.19800412826699373, 0.25663905377806956, 0.06205782658223782, 0.3613627467542034, -0.30544155176886584, -0.18998596942085377, -0.11660923509429585},
    {0.5579678571552268, 0.5811435850795292, -0.18542722254655536, 0.4249950770823626, -0.0037026949455873192, 0.6818450841340676, 0.3910269369890582, -0.07939973650173404, 0.7236165517719657, -0.10943905051511844, 1.112618648294366, 0.062164626853208046, -0.31273837539313415, 0.6177590958524467, -0.05552740524772683, 0.5586085889922918},
    {0.5343506635318971, 0.33094948207955055, -0.3097852137427452, 0.6134574917896352, -0.4300487492747666, 0.3040843792323107, 0.07533392968532376, -0.036234188272130555, 0.7853165814673986, 0.08459535939058066, 0.34881316143099794, -0.14695974306835885, -0.013448420334504696, 0.2562444468936114, 0.0966271936238651, 0.914846730115751},
    {0.5981219307346073, 0.5740615072299851, 0.05489063156400644, 0.47527025392570654, 0.20123197800726872, 0.49982192039675133, 0.6766549502052578, 0.35976573014801655, 0.6856487660922996, -0.5055356883303271, 0.8231158224269011, 0.042188490634867036, -0.444103682717361, 0.29689797495565573, -0.029264060970260533, 0.642651396875722},
    {0.3945323714905984, -0.0904466271447022, -0.31481650349415524, 0.1168970345289826, 0.03732368803898814, -0.041424645048650545, 0.10305121165323286, -0.190699579849423, -0.33046171523590845, 0.1495074392093237, -0.3804759648981757, 0.2378836900255006, -0.041758703794369474, 0.28635189767400715, -0.3773796704061572, -0.19390045991273197},
    {0.551937721731947, 0.6202146792480011, 0.049574474112024584, 0.629583790776141, -0.3877522556189643, 0.7616562260445802, 0.5229814835270493, 0.22703892146036295, 0.49882900760110244, 0.003280583443262892, 0.5242414166615764, 0.16188949618889156, 0.031011226743276735, 0.2023474930050071, 0.49714476889798775, 0.782083351123535},
    {0.7558082567229276, 0.7696041891135694, 0.1519544737915067, 0.61052513583996, -0.0294523560022418, 0.6378926371470748, 0.6277885925554086, -0.05766512861596519, 0.8173337481221548, -0.25897898430052996, 0.5917927844675159, -0.09969972751685927, 0.5073551772165741, 0.3513164070308691, -0.7977321585091108, 0.7146652868733347},
    {0.8844934627477257, 0.7082495856314731, -0.09852590445280301, 0.5958536755112577, -0.1399710494366392, 0.7188627121826244, 0.3760199844003318, 0.026288581203555563, 0.6440311848771721, 0.27972897412427394, 0.39554806833853884, 0.04686362931549747, 0.20646751568843655, 0.32331550170475, 0.08549171492650985, 0.7396937647767724},
    {-0.15867740931577554, 0.21332470893111377, -0.4106398855364868, -0.22014312023127633, 0.21523419312634984, 0.03883387825279446, -0.11990419647716925, 0.2539818347326033, 0.1689620601785469, -0.06426064751029219, 0.5301530312685516, -0.21325308198617307, 0.2550272028077957, 0.20836078091832783, -0.34360159418813846, -0.10700120439571303},
    {0.5149662026038361, 0.5286436297368674, -0.024871421813499384, 1.067606905858816, -0.2528741786914166, 0.49873136840625587, 0.6014416209652022, 0.4576566088252681, 0.3230089016945913, -0.7216499885314829, 0.7708503034899002, -0.13689896788184464, 0.03520049498724695, 0.3781418877561715, -0.22253638185757904, 0.7181819855562976},
    {0.8265744174493943, 0.809984950705201, 0.04376375905804354, 0.2439892666597162, -0.15607491099888682, 0.9791876786535985, 0.5888583294269751, -0.023270067837279893, 0.29808198121363233, -0.19283040167268412, 0.7764640983941317, 0.3293295773992536, -0.3281618373361635, 0.21161938922206058, -0.026267012651147507, 0.38276505779222947},
    {0.658199985810261, 1.0131115796155425, 0.2988607219240951, 0.21895722703659068, 0.3570920349188885, 0.7767496473440342, 0.3399336792103745, -0.3213898057985166, 0.7560749576459872, -0.2245219243052471, 0.52255916571293, -0.0032074163287750504, 0.2842092725543003, 0.4556611618398738, 0.0559001461101511, 0.7646066167273724},
    {1.2036146912372327, 0.4580819312965107, 0.16260906918353746, 0.7451105435684955, 0.033786266971436364, 0.98979910232751, 0.6385100258145777, 0.20307093861990425, 0.4521695634224983, 0.2690428376936893, 0.8447205636893653, -0.2981187270349597, 0.3306050990272709, 0.6116188592509089, -0.41900363070391744, 0.8532758347165307},
    {1.0413534839907779, 0.7539890264869238, -0.12010740683173644, 0.48370569696142784, -0.0281328366797115, 0.19413034243349245, 0.7925191306479044, 0.11164795498760928, 0.6338246019907144, -0.2107817157217786, 0.702993862763607, -0.020870451097634843, -0.5071616467857113, 0.8187200029633738, 0.060224361258535385, 0.7035021847907972},
    {-0.3152798599150438, 0.1966530617365363, -0.26174707148304077, 0.09623691454596589, 0.3515960979034983, 0.3917216250401004, 0.23666656175289108, -0.033411841550729474, 0.17119235675706676, -0.03633678767401277, 0.035368688912435664, -0.32725949987357206, 0.0676826219075309, 0.04940207093154886, 0.42054131535425326, -0.02476117958043591},
    {0.40868256983902096, 0.7709539831532521, -0.22821548845506348, 0.51374876895349, -0.15626828757377473, 0.49772441160251585, -0.09777377017689792, -0.2839801162409239, 0.8217460194633229, 0.1696781450716409, 0.5666578114825768, 0.1437939287932907, -0.01948767331655151, 0.19984320638517727, -0.1546704179811293, 1.0200452831010538},
    {0.6069448533310317, 0.2937249665591037, 0.04609140494399772, 0.6873554077087174, 0.130346723137103, 0.6827601297786736, 0.43038842399905525, -0.20584194387261234, 0.9082770136806317, 0.11013595106208408, 0.9004586326966079, 0.09082176402340475, -0.4210007301882246, 0.5655451518240172, 0.1738941840692562, 0.4810883698491698},
    {1.0599100640926464, 0.4275446834599647, 0.20884363129396016, 0.7517379484879336, 0.08114873197921223, 0.45918805192743395, 0.6057563776776917, -0.11299653265668884, 0.7285722997417656, 0.019972894234415936, 0.77145331709922, -0.15136084358409554, 0.06388235714623365, 0.7337633025794703, -0.11727548431240485, 0.5988492123036383},
    {0.8889465981463207, 0.6488385854543658, -0.10099882189539482, 0.5743487080365179, -0.10459221003239379, 0.7735511173280439, 0.42446473220197406, -0.0956510930660932, 0.7404560004902133, -0.2978980607733097, 0.714488771509267, -0.16702426836396483, 0.38955176112933354, 0.6808471202029546, -0.04556660643457196, 0.8718570743732162},
    {0.23510841637030488, -0.018441677079052986, 0.005332795205622815, -0.006109874495069363, -0.07307109567231293, -0.1411757096851145, -0.14686916337992081, 0.09935268194168276, -0.07222468763805442, -0.03284071298099939, -0.1641041934421136, -0.28527402012003666, 0.1076570934987412, -0.16658919555129634, -0.07608797570193075, -0.2999831550934106},
    {0.755345311241535, 0.5273534882673083, 0.3335150608042009, 0.943342992563921, -0.10462793590024021, 0.7126101087350225, 0.18379121442010213, -0.05477512096122275, 0.6514042736534782, -0.028304142590976526, 1.0553611896338053, -0.3332063880525099, 0.07257349649569116, 0.45356691540927035, 0.15295817346504378, 0.6289893641045251}
};

static const float b3[16] = {0.4324573536458208, 0.30981351951950803, -0.016892052506659875, 0.4893060201868769, -0.030290197977734537, 0.4635859754141532, 0.39365623877015293, -0.03899286606275076, 0.43301372770432073, -0.04874402089653097, 0.4528918161520148, -0.03246849555610032, -0.031863305418783426, 0.3612205484674899, 0.017797974332969133, 0.3979054343763459};

static const float w4[16][12] = {
    {-0.8469155306420312, -0.5253809001580843, -0.5211572148924418, -0.36126867668502816, -0.7370386262730232, -0.684720116912026, -0.9450487067909651, -0.8142293674314032, -0.2979833728230415, -1.030275091456293, -1.0588530994039371, -0.14287399607706294},
    {-0.8575851458883973, -0.3411406720424871, -0.23419341582072176, -0.22167464327294514, -0.8248679297644319, -0.6494055554714857, -0.11603141892355737, -0.5251110997155938, -0.34999013142990426, 0.16826079052320014, -0.30017174046383455, -0.6531060689724673},
    {0.11698123879532646, -0.20442229770317905, 0.09242738443509195, 0.16690344132203425, -0.19703447864416745, 0.9801007809638465, 0.5087533435163338, -0.1773553396083571, -0.5277987134394383, -0.4001638128397945, -0.2366205577100285, 0.25608720295325604},
    {-0.17520583944543863, -1.155416473719013, -0.8232263954952623, -0.4486244720995403, -0.2942414945003839, -0.5042786733322812, -1.159703277121333, -0.8203757761400452, -0.7374511599086784, -1.107462022681725, -0.7354379617784563, -0.364250807409581},
    {0.2301548110053681, 0.4129720895231729, -0.1987949806678458, -0.3868340317692255, 0.2638421171187165, 0.48258845070110024, -0.15218740874542833, -0.2739371812212125, -0.16306534944852372, 0.6289313209794066, 0.1927893949451144, -0.035433810889905444},
    {-0.5215484028030226, -0.8325522264805947, -0.293764028049329, -0.8350658076774874, -0.9718877952712144, -0.5203309661578459, -0.617089132810323, -0.19436309042890462, -0.5193102232485423, -1.231101298430329, -0.48183915852978443, -0.6421954646523974},
    {-0.6645651489632374, 0.11811059265801603, -0.22738631000080722, -0.545644326465489, -0.3820603423618797, -0.7301841352578562, -0.34183385670211947, -0.39968869723668654, -0.5927560590187066, -0.21425218569434928, -0.6599351520484905, -1.0870201724153092},
    {-0.45340088431504405, 0.11061219745401629, 0.187534637461471, -0.02594073520123149, 0.30581527514879453, -0.07338696966362665, -0.13200272047370848, -0.32277537508601845, 0.779701446864788, 0.7644660277367481, -0.3531654131925825, 0.2402285593583012},
    {-1.043823615139592, -0.5914726897393796, -0.7752133399750898, -1.0335492929924694, -0.3586232403359724, -0.7935122364545362, -0.7098977706202763, -0.2554167514383013, -0.5017026140614715, -0.14429647695310668, -0.6462023426464166, -0.7005746767682904},
    {-0.4821157417354293, 0.2734423476176806, -0.06811550843608467, -0.2989942790709017, -0.34003894024469705, 0.8303930059268945, -0.8194181471772803, -0.15421990278727163, 0.07483721938393224, -0.6308922248208599, 0.06719954408435391, -0.00908346186766469},
    {-0.4261511806511792, -0.509757953934432, -0.63274319231624, -0.543522924315699, -0.23747237284399222, -0.56816666177872, -0.4048277392523057, -0.6106383047096692, -0.7025396414295384, -0.32090860949437605, -0.2566408503912556, -0.8496588922765663},
    {-0.2652622500493255, 0.09129860514676576, -0.1453324048448049, -0.15312948247158387, 0.12519282136294677, 0.014177343792153714, 0.2206142219713098, 0.4427502149348104, 0.5237500538413579, 0.10130071674976213, -0.3654984827777153, -0.20974763061881826},
    {0.6006474246740201, 0.11141962777232108, -0.5460568344112342, -0.27287423626288637, 0.377063022292822, -0.049787106324280295, -0.11651318807215588, -0.4527468388018747, 0.7285108219805465, -0.21176391132515038, 0.021299144241526145, 0.34728854420883976},
    {-0.25429824644661486, -0.751808731748696, -0.6314775311845946, -0.6570546729857224, -0.628681018837249, 0.23769178059598675, -0.8887824992735267, -1.0837593543041237, -0.9369746069120178, -0.5591523244237442, -0.40730191790722414, -0.6606769915621857},
    {-0.24731392664221877, -0.1537097167247978, -0.5002995013470128, -0.13883232796401732, 0.08171513972834565, 0.0007339497298210864, 0.16696107082449788, -0.09060766308025398, 0.048574482905441904, 0.17275889427754343, -0.31342530169976834, -0.19625800165319934},
    {-0.34205506444211414, -0.6104640075935472, -1.0728416642075878, -0.5509059617790781, -0.873656306087107, -0.9557286690041664, -0.04368983005811417, -0.7528057152833595, -0.7556666627943249, -0.670715040069856, -0.6655691629585291, -0.3126205114106278}
};

static const float b4[12] = {-0.16668714717510952, -0.24259011205208067, -0.18710617669066323, -0.09575644740536322, -0.23376012475418137, -0.23016788206397937, -0.15910871893321352, -0.3175191473227689, -0.23085632275060577, -0.31010552769656363, -0.16089792918696233, -0.1507827509237402};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
