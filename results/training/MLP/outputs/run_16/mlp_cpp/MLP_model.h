#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-2.531146521422685, -3.4600334042715484, -3.5657270424502525, 2.042526817886142, 0.290970788359359, -3.6368433237386157, -4.352818906669065, -4.2932577844900885, -3.6183860938174917, -4.355684114466131, 1.8284825594263152, -3.3035180004441878, 1.6580682799000332, -3.3598538997710126, 0.05893822963169317, -3.6319966718036305, -4.009880235528085, -3.361376495673114, -3.310548169101849, -4.147003931241216, 1.768370540099191, -4.177417073222523, -4.576073984005849, 3.093587280606977, -3.422701876074961, 2.518551881178543, -4.095858681922093, -3.1440252165740654, -3.2922382049113605, -4.303873568695435, -4.281571038112198, -3.14312677919389},
    {1.160504978251891, 2.8404611565358264, 3.5315711580589064, 1.5714616868639446, -0.3944459670639956, 1.1771032382329987, 1.05663841497228, 2.5518497016244375, -0.7720551228255537, 2.750198307107909, 2.73073525477539, 2.5975215286628015, -0.3481573301335667, 1.768537150339946, -0.8779460306410152, 1.7412921210173318, 2.9015732842226, 1.2567466682107646, 1.023111188896915, 1.7927660264122909, 0.07788334657911468, 1.4705474664057103, 2.9139839161497068, -3.1939710497203877, 1.6795138526075046, 0.11490338957285583, 0.15929662261080954, 0.9816391873321826, 1.0880715700315111, 2.4942225934632387, 1.6537323568249478, 1.165896844212515},
    {0.5849704327597461, -1.3092582445655594, 0.08939893223009256, -2.089323460790858, 0.5029385240746195, 3.874594534176152, 2.389319216522017, 2.5896059312911848, 5.038247943636288, 1.591784798053708, -0.43446316565525045, 2.5454668115431196, 1.1673611982641274, 3.4216743892041985, 3.079235093060728, 3.39894335747368, 3.079226046960317, 4.487609216525687, 4.0787470294936226, 3.8407467583759574, 1.6077182082713932, 3.5742847500876707, 4.463295620416023, 2.7909454464435033, 4.692751711581137, -0.48060248470406314, 3.514879037838396, 0.013133293223600882, 4.372969234251651, 3.2822505346340356, 4.664358926641145, 4.806963347471724},
    {-1.0910455287399325, -4.1496736486021994, -4.095543479583603, -0.3159164315113546, 0.5329812358346605, 1.4909252457361775, 0.5629477394885166, -0.8662430711127177, 5.96207062473174, -1.567956875070792, -2.874949355118162, -0.9046594341775303, 2.770712109656498, 1.3606542053499175, 3.0852143005330395, 0.7698758964470647, -0.9803635157428331, 2.962523463362976, 2.3708597272205076, 1.98275954162171, -0.8374838879379422, 1.0440864403561818, 1.7685157148943553, 4.840438917377963, 2.4472670961203695, 0.5447378297603093, 5.065603682933626, -2.3023333216461417, 2.107782500617785, 2.27629019421444, 4.464120391202865, 5.553912953789862},
    {1.5196205858513951, -1.0501317182034346, -1.9331641212986759, -4.796442204798517, 0.49769101139220534, 3.219871208122495, 2.964041724063862, 2.7642915681077427, 3.4715492789370517, 1.5051216597837334, -4.423766353152054, 1.2154530937697052, -0.2425283793772379, 3.1665791619032384, 1.7184252360062728, 2.9879014730564575, 1.7809545864168552, 4.932224602038803, 3.9352648172914324, 3.5661633859424215, 0.377150485456073, 3.7431240002738417, 3.221402510319618, 1.0902841141497057, 3.7695571742037584, -2.445865217829542, 2.598856319183187, 1.058737601620861, 3.900781903175859, 2.3865265382498997, 3.721310848162624, 0.5128305452830514},
    {3.7112407369202467, 3.289065035003154, 1.5239107088022463, -2.7411920905342897, 5.463432913789086, 5.305928556294223, 5.875458230086828, 4.810661796404029, 5.717999949800984, 4.334367133612971, -2.513493912732698, 3.4377853121406146, -0.9952543178336398, 4.833587700662548, 5.335723416836525, 5.268940945370005, 4.35750804558337, 6.073512108020518, 5.515867805627499, 6.053382644707658, 2.055989539406965, 5.355829222325897, 6.095095026840541, 1.6421090488335104, 5.419674539576852, -2.8070037403327324, 5.173796885930871, 3.351539854979329, 5.340497391456657, 6.73112664250241, 6.720443669526307, 3.4203000518202624},
    {2.880103336191753, 1.798592692734783, 0.22467400308521848, -2.445686383761969, 5.276157721292244, 4.809788797509041, 5.681537652454629, 3.912738022175848, 6.199878492878209, 3.5692806170000853, -3.149518765145968, 2.6590162686837466, -0.10798363210166427, 4.407575333047399, 5.62052412956887, 4.824419892433394, 3.28621431949914, 5.843015120303812, 4.769853113105431, 5.713760375875865, 0.7693994015952995, 4.824536011303927, 5.663571394273101, 3.427108406442795, 5.300384878652178, -2.293885282659068, 5.60735887797515, 2.417074238048075, 5.000921205603986, 6.553076527840582, 6.715858663181279, 5.230885547639324},
    {1.4464354432649242, 0.4491837224586196, -0.04154682359724647, -2.136703531391149, 1.0611573181757614, 1.7291189921849706, 2.620220913273301, 2.6445619220007286, 1.9989853008170277, 2.025973412879199, -1.3126983413224704, 1.2628634881780576, 0.1665326517038084, 1.8580663927599246, 2.372840723114569, 2.054259938644214, 2.456769832415773, 3.576742013367212, 2.613209739621137, 2.662902476131611, 0.06460307713207604, 2.011940189735854, 2.179707289188479, 0.5218477017959068, 2.6808331439433757, -0.5960387107821566, 0.33707245956001186, 0.3407214896322865, 3.2306675704397256, 2.121902447991418, 2.9420260250575954, 1.3694182378024446},
    {2.7573343784377755, 0.7514397924845683, 1.0510307161780583, -0.7476812468993965, 2.404480138356989, 3.8349960924415054, 3.3776127512512186, 2.3604566506575533, 3.87825632128539, 2.469526291909337, -0.827727509048457, 2.597301263530959, 0.6705668582940517, 3.677228791888941, 2.7857533052540835, 2.982995692275442, 2.707720806776226, 4.3673349440188405, 3.5399656471825334, 3.583250225008981, 1.886647878890466, 3.8137638181592814, 4.644145462667801, 1.0268529345559307, 4.4304015998543225, -2.0249386672086915, 1.3120706371709245, 1.8479675018478237, 4.360493016167113, 3.8704044352422846, 4.164482518680337, 3.0326429694765764},
    {-0.5390021104942125, 2.029098490875868, 3.048414746979179, 1.6908803719325836, 1.1468397502970322, -0.7447018722925497, -0.02921746880362896, 1.1084061057996573, -2.5331961257215863, 2.2731949245401664, 3.2896989493937636, 1.0195286864859077, 0.9791271335322026, -1.0734030896080946, -2.934467417080721, -0.33258041645427944, 1.239256580143797, -1.2496614499582883, -1.443756588193423, -0.5654673814455975, -2.2784445798059973, 0.1450541192024152, -0.25911419962127946, -2.676434361832808, -1.5428132964345607, 1.8370182984032106, -0.934136462077861, 0.6310848586204316, -1.8139563506966987, -0.005220254338742939, -1.258964819970006, -0.4708828780941646},
    {-1.258070329914148, 1.09142527174817, 0.2039110118269157, -0.2091502104756832, 1.6465195211048627, -0.8617063409516037, 1.225067459734752, -0.3405779934129237, -0.04275797640597674, 0.7184123132287172, -0.33734338625720045, -1.111007873423553, -0.44565790963220975, -1.5381414950521937, -0.7665067047950183, 0.7577920759904121, 0.8684024325470845, -1.1529628252589676, -1.0744899338095808, -0.5396861586107632, -2.387095607125532, 0.3355944744076795, 0.5942424127490642, 0.0013684934703205745, -1.9542142005500103, -0.2099187235913633, 1.1246515420038763, 0.14863580732794593, -1.4084611480275473, 1.031886598721453, -0.34246311076679814, 0.8551706521436666},
    {-1.5698129655716437, -1.8578098500334534, 0.9588402216575421, 3.621592519848285, -0.9039875727327599, -1.3301494875881077, -1.6238302931627515, -2.55380622152286, 1.8536748987509273, -2.5087333112798547, 1.3689797884949761, -0.10731366160727926, 1.9576391246980422, -1.7024439302283338, -0.7594988332299751, -2.0410998241776266, -1.4766138209127715, -1.3745190026323262, -1.47181742668662, -1.60543704163946, -1.00224080108107, -1.927214739377202, -0.4106769773257015, 1.0911888897264366, -0.8901907844530528, 2.364997129809141, 0.650102771416426, -2.140544695042251, -1.5279831005900477, 0.07084516274270444, 1.0480597919455292, 2.9908684192602455},
    {3.427811548185401, 5.114001907414225, 4.605819780058156, 0.8583637442690347, 1.302653797808085, 3.0590377839252154, 3.27409815148416, 3.4044868450153465, -1.1824073828289987, 4.2547446762088255, 4.244212589428255, 3.619033577279429, -3.3164280780352526, 2.8106020593378926, 0.7845832705344905, 3.279757847944572, 3.7845101622868214, 1.6616323629147098, 2.37575665967192, 3.035465082410202, 2.699724574890951, 3.1350874456161413, 3.324450683511529, -3.5065498230582226, 2.2122039672900233, -1.5174179335557696, -0.8647153461283706, 4.14248059360627, 3.2037914962383156, 2.088667297438614, -0.07853222922267301, -0.7954216656556773},
    {-0.5891763745716628, -0.9074200103734248, -1.8479733032210985, 2.9425214938810575, 2.7889614573313644, -0.06863311306710938, 0.582364749135411, -2.6382606260916597, 4.492240074610748, -1.9783115384618388, -2.040146209827592, -1.9428294917350752, -0.5067278503534083, -0.9030551066901668, 1.3660447846050319, -0.9756622420760829, -2.0104467983649896, -1.9037202999344713, -0.29165473860604, -1.887947173713196, -2.3227799693272666, -0.3354791106733049, 1.1655649118919342, 1.5955036394522681, -1.301455718727973, -0.2681152034628274, 3.6632867168727916, -0.8679843081852717, -1.1342087518618527, 3.090962039062657, 1.6692693896916724, 5.036086555486198},
    {1.6387431287661538, 0.04350086127094525, -3.495152574468013, 1.3048423421378887, 2.0829303657334455, 1.1624403580241651, 2.5788312435955487, -3.1355390435623547, 3.9101773866911804, -3.253918646902503, -2.9016121275702806, -2.8604677697687446, -1.962871486941769, 0.3204768312849311, 4.269875656471107, -0.47013741436123546, -3.1024237908215064, -0.4816695593428147, 0.8363589795261501, -1.057362928916983, -1.0851385718768158, -0.1539967918805068, 0.48253338237053484, 1.6084715860137464, 0.36299171023194354, -2.730224657577253, 2.752148913999494, 0.3670443279365404, 0.559690470486125, 3.3954337138991924, 1.2049284155806756, 3.454036845005927},
    {4.181743979596883, 4.049568120743917, 2.309371773966503, 1.2377762969984276, 1.282646462397703, 2.7116252301529005, 3.569916391896569, 0.3160349284640146, 0.18412769018600725, 0.8116355832446032, 1.0108543355385176, 1.3088098113151398, -3.7723245076659992, 1.9935290835435462, 3.06367055001533, 1.2281278031638512, 0.7446201413147306, 0.033025420670851104, 1.830227723883322, 0.14076148163866714, 2.037447249541592, 2.252729829942754, 2.12648125452189, -3.787011773453749, 1.314553820006893, -3.437896468284724, -0.6779569218507004, 4.2508725288820495, 2.5155612792120055, 3.158662541015907, -0.5711666457086148, 0.47217403175973455},
    {0.7318103143706326, 0.6881921574977475, -1.600728727183518, 3.715225359783219, 4.110856783876473, 0.9367420135601471, 2.9601888623706585, -1.6236327321382384, 5.880891711657848, -0.8287231937421571, -1.9614467059345886, -1.4959015231399533, 1.007028993077743, 1.1615711764592516, 4.255160454299566, 0.779550215910079, -1.5518215496714254, 0.7285817996354964, 0.7917586032864714, 0.4519983494453735, -2.69631248813377, 0.49532860814737506, 2.1465324501083276, 3.5712359701891163, 1.1262646407419286, -0.6273415975485966, 5.907706515983005, -0.17675031955518658, 0.2332697784366743, 4.682467270939839, 4.4565609130970705, 5.678453746411918},
    {1.05527907179474, 1.5421531943297901, 0.3677737364414748, 1.9544523692466018, 3.668819135128552, 1.6312092171506634, 2.5553956617436886, -0.7049294746234347, 4.010218564281943, 0.13277433781911122, -2.1160611789255848, 0.1789961283136884, 0.004178130949811703, 1.2418450074570413, 3.2963421661273435, 1.5303259313283981, -1.152208953762826, 0.24271262393341844, 1.1021473873874765, 0.9947398123988678, -1.848782381980778, 1.0027103420756363, 2.771367068581416, 0.31477895757359514, 1.0262828257038876, -1.8501766583680583, 4.1208688473963395, 1.1173401752600363, 0.3263597370709175, 3.8467199971350023, 3.1386592509293747, 3.603376655721353},
    {-0.779686577065072, -0.39461638050745057, -0.9863352131653219, 2.5429161416235546, 0.3487040611367151, -0.16873099509083392, 0.429097812744721, -1.4325584648794345, 4.122678301222363, -1.6869881737481864, -2.017841770289205, -0.9048400420720571, -0.513212032313596, 1.1616603921949429, 3.6987259220708215, 0.09321799986543204, -2.678376391268983, 0.7723707316307742, 0.95105283803012, 0.6295343365298656, -1.7582686516617394, -1.0842931491527579, -0.0022196347572975665, 1.8384698611635995, 1.6661146871878745, -1.444998539701363, 2.791248873896766, -1.0452697189358835, 1.4312985127966782, 1.4868136807776224, 2.5414119121973338, 2.63477455127956},
    {-2.2332810993206578, -1.6477326914807913, -2.0797335256138756, 3.6923696581931305, 0.5736773786105732, -2.472529503240222, -1.9492718773226645, -2.0668619546806535, 2.6279709666982822, -1.508483382055416, -0.08951295019054019, -2.423246279754348, 3.058861367589085, -1.732873498496498, 0.2508520049507877, -1.060441982428804, -1.9516417008587699, -2.5108163614158823, -2.4664122770939176, -1.6992643235182623, -3.1186634938811704, -1.875690941330021, -1.1936477379889685, 4.181072732944031, -1.954099146124799, 3.185709641476691, 3.6008690610057728, -1.815993230111665, -3.011723056415301, 0.8542234124013947, 1.5120747696186907, 3.752144969813553},
    {-1.6542359833661175, -1.5873611626787212, -3.298875550777154, 2.1738148447155097, -1.8236673291041798, -2.0550679072160185, -1.7026380435828528, -2.382286124126425, 3.329494129390029, -2.6073634781830695, -1.6418595718758782, -2.8665120001935493, 1.7329026605547824, -1.821923921756775, 1.2814227259583315, -1.4933670719383965, -3.17466369039167, -1.8156340139347047, -1.4117756338686498, -1.7852005923398822, -2.6759945097271873, -2.5570306965609886, -2.269647952735665, 3.641392096324532, -1.9473012045331468, 1.214166184544045, 3.9948331648651276, -2.1295361713895624, -2.1171829346098088, 0.32279389220379057, 1.2267698975738437, 3.3355771731095447},
    {-3.052778078545641, -2.664967462164937, -4.49135931125887, 1.574324327537811, -0.761932330924711, -3.805123041608063, -2.981561303378458, -4.088850397373457, 0.5431250083390383, -3.716511286212172, -3.4406326460293877, -4.771721783092991, 0.44745609978237005, -4.304244136755585, -2.018012174164634, -4.198158637146036, -4.6780436480759935, -4.637258196666066, -3.66627602501744, -4.492740561454514, -4.616497576272574, -3.898046387821813, -3.713562045964924, 1.73604921339658, -4.63475697297618, 1.0739493158434976, 1.6397535135297399, -3.0395910270931976, -4.742253066514814, -1.752721804814337, -2.457023074433398, 1.8923771411503139},
    {-1.9088186696150495, -2.026900668507262, -3.4184989554719536, 3.1817591939627685, -2.6729277579848203, -2.683501274282887, -2.830271790331043, -3.221926746938025, 1.68861450635105, -2.7153599212375914, -0.37706251053124695, -3.5366408261955655, 1.851761637355068, -2.2841092057413386, -1.0597143057713536, -2.213359217751549, -3.6159728259353914, -3.565776751409278, -2.748434422536211, -2.892201506336584, -3.4826786522897755, -3.505477366273822, -2.9147640318008268, 2.373136052448267, -2.6724324092955185, 2.506684307114179, 2.973972147448824, -2.5224540178019295, -3.2444795637477353, -1.0767319211168782, -1.050671989265713, 3.709730149062374},
    {-3.9484327653513684, -2.83971594945414, -2.728295985375541, 1.5584714022624224, -3.6978855754069766, -4.282137603745184, -3.872226198306726, -3.0472370936620186, -1.8404718019083202, -2.1053717554999056, -0.7459125246457987, -3.3921313187737923, 3.860045937335321, -3.8521740391920574, -3.882165298382555, -3.5031887432079327, -3.5784456633256068, -4.018601463920658, -4.004622819368642, -3.37031342744261, -4.8778704477216985, -4.644403557708712, -4.358691414231897, 1.5842738432839558, -4.293585460581857, 4.136966484821746, 0.6787027827190587, -3.765124357217672, -4.824923792709741, -3.7012880128760006, -2.8072494519556117, 0.19438304476446117},
    {-4.085641347250797, -3.7977525214127144, -3.7500173631015254, 3.321727627845662, 0.02635135754158095, -3.0973012683170222, -3.2468435266028717, -2.962818085739051, 2.5511549320487514, -3.0757085606363455, -0.9402680512568575, -3.1861070928055732, 5.2617897522766155, -3.110445119317316, -1.617573818066358, -2.9973328667998778, -3.041996373298383, -2.548644816108142, -2.541892153500109, -3.17270103155661, -3.557320695040367, -3.1029440150812446, -2.842985143255374, 5.703979251966207, -2.9776155163676785, 5.418825510524336, 4.121661572369112, -3.9452641652687226, -3.4810978471196, -1.5131857530267518, 0.36599853415674577, 4.270125786374282},
    {-4.51577128582753, -4.4458963463946, -3.115715953869863, 3.6033747582105327, -2.0598574800721297, -3.932964815024702, -4.409640975613152, -2.629599902781383, -0.14889091158990286, -2.5690799334034584, 0.9215825115467848, -3.034334422062592, 5.830363812906239, -3.2471419007760876, -2.64365880913237, -3.3474008422542427, -3.1050015050501987, -3.5889903138911614, -3.85474627221364, -2.7614460714814806, -3.3805034126750444, -3.697254109966481, -4.24628328659922, 5.459857534870551, -3.5683199157609393, 5.744044354700541, 1.5231906400644197, -4.191473050194702, -4.055241112273285, -3.9338536206687476, -1.6681799169694953, 2.2370737036649877},
    {-4.133461380211731, -4.024312586875539, -3.547147498557518, 2.7244039562047444, -3.4865372209515204, -5.711270367389442, -4.7454642244879945, -4.927364197062856, -2.5994542861858156, -4.12457282474244, -0.6873633213972496, -4.7691816602197, 3.5560708457366776, -5.166346530961461, -4.838998584065867, -5.133810538961707, -4.778211754271336, -5.660540490349395, -5.290838517456072, -5.211465824386618, -4.6259640567796305, -5.3535573286523155, -5.788320109262703, 3.152409594740898, -5.879198083467115, 4.449255285601135, -0.4736748107985669, -4.56576570683933, -5.948926175937158, -5.024240220652698, -4.0243726437259015, 0.05841206438022778},
    {-2.867255023853535, -1.9687361465871231, -2.2965602642141847, 0.8055651988588719, -1.8941741286627884, -2.334293478345274, -1.4695542706579419, -1.205324584501747, -0.03166070360156735, -1.1072819834961745, -1.2539246720189263, -1.2981010965423336, 2.876345282749876, -1.9117793722450271, -1.8713132668760235, -0.8738128998983496, -1.6119299584169395, -1.3981296458826469, -2.2381460841576626, -1.1232672635307306, -2.6874449767768946, -2.0514095959215743, -2.2370541996941204, 3.671730383343626, -1.1492384434408156, 3.7377301319431, 1.8121769647789279, -2.1333855091450036, -2.02408151760022, -2.4161175960858636, -0.7569006629480161, 1.124645519533358},
    {-4.815149999251286, -4.38056354526507, -4.519781690318982, 1.6869799823206209, -1.0473959368846053, -3.782854485163724, -3.421343251863747, -4.5737674458913125, 1.7274932713367166, -4.019744736240538, -2.990306530645743, -4.101863222055759, 3.7689444210033405, -3.6259471216074526, -1.9350877441631307, -3.8781319145769766, -4.253974896194598, -3.6752626373310315, -3.929459212075043, -3.6031208985575347, -5.334692999205686, -4.0862766782091295, -3.247608692853606, 4.869855120713027, -3.520233054046376, 3.241909595702192, 3.510247041128029, -5.054514035687559, -4.513194463327443, -1.1708868435408537, -0.021227229245161044, 3.5577866753758856},
    {-2.7707500155457105, -3.475328017697735, -3.9090256378063524, -0.11721818162343475, -0.830815488572917, -2.9782116952103936, -1.411527488599567, -3.1536018733368696, 1.3354653167572585, -4.0356386545817164, -3.3549558382944076, -3.533652280272543, 0.40234302392303833, -2.6116946989654064, -1.7953969000804397, -2.5241813205843813, -3.952701379816157, -2.7605073366403667, -2.614381016920768, -2.442347189797071, -4.035132750008996, -2.617893751360089, -2.571751597235821, 1.9511344828323545, -2.240984394882176, 1.3027312901467163, 0.8176508499390929, -3.2780337792787386, -2.2007044112233403, -1.2706368954241696, -0.9700655032761132, 1.9264626605173414},
    {-6.240944379172005, -5.515341418494301, -6.182889244924335, 1.991682676971553, 1.5228191242203848, -6.135578760943008, -6.070431337472754, -6.312124974425412, -2.957079456092566, -6.386668967544687, 1.154478044493236, -6.508714938453981, 1.4091366689393483, -5.751696225747642, 0.8461474337420827, -5.762309820560976, -6.0316560316458, -5.753993982130902, -6.233376428107428, -5.892416757844938, -0.30018881622602195, -6.095435700231121, -6.075849661774779, 2.850748948184414, -6.111709642235969, 2.582693277559358, -4.1646730763221305, -6.254738961117917, -5.579660481828568, -5.599354779315886, -4.970495966190433, -4.267731127666709},
    {-4.662185181365809, -5.2916472952994225, -4.705017992461982, 3.9311893753929708, 2.3518273936381906, -4.568340325514904, -4.408215415512076, -5.148092092349954, 0.7068159982590754, -5.082429711821517, 2.460900248922967, -4.9417103282695365, 3.8245908985925308, -4.307147733566634, 0.6321939135869884, -5.025269655994016, -3.665487308114485, -4.336075616637316, -4.646265810128009, -4.70465221422157, 0.2728524536465035, -4.384565603892068, -4.13572685490055, 4.844440920969478, -4.183013387094398, 3.888498365024805, -1.3765441942564602, -5.215823242888375, -3.283159380767208, -3.2609844648324766, -3.4947812994189746, 0.8896136228492368},
    {-1.9098272699394905, -0.9503495184443641, -2.7801729774092796, 2.309640281074563, 2.0789793706853557, -3.4646672732339416, -2.9958697089061306, -3.120159104283778, -1.7563757877800574, -3.418580948115325, 2.485183436686773, -3.6552267597011934, 1.6895578835371938, -2.3999549102794444, 1.3244087036132477, -2.797470375460143, -1.9098342014105119, -1.583667295960455, -3.790158668866745, -2.6898659791875743, 1.338460710196821, -2.4277588393196923, -2.9181120710804143, 3.1224584395860306, -2.410546130568608, 3.598572258354433, -3.5248321649742573, -3.051949773518322, -1.2107743434128717, -3.3021616215414347, -2.965881456556735, -2.401109097809256},
    {-1.407030227429691, -2.9068574450567666, -2.577426565985555, 2.143863214642427, 1.922357701825302, -3.3293562480778287, -3.0401113823625256, -3.4995764529099347, -2.041188944100153, -3.922163613432446, 1.9792051505021933, -3.162578209934002, 1.632920684289898, -2.768203254141609, 0.9196523475399692, -3.8071856516926306, -2.578085314830455, -2.809135550689472, -3.3060856147639055, -3.0586842552552147, 1.7518743682822797, -3.1496123577355584, -3.4670346549884594, 2.0941948118378297, -2.468601753721461, 3.2203916679084257, -3.401142100646875, -3.010782036652597, -1.122964740954823, -3.7528901374456436, -3.099143635605586, -2.08744523784478},
    {-0.8216672706699639, -1.2297035265604381, -2.1788385199473908, 2.307268648917511, 2.3205026436352, -2.5907433913671047, -1.6990821860472372, -1.7792460786142696, -0.46067664066150826, -2.6596638439724183, 1.5537302230607302, -0.81346496638141, 2.5672497473465063, -2.1287476888890757, 0.33611670401841415, -1.844362758954615, -0.40714404215328065, -0.6581185315275585, -2.089530178691075, -1.7340245937281955, 0.4907600652817326, -1.8662273152152815, -2.5437826020555536, 3.2823366870958117, -2.0923672637468687, 3.523707119576455, -0.6888814245129322, -1.9746865396884306, -1.6863975642378835, -2.3441391288116735, -0.5690348949947075, -0.7501618969880599},
    {-3.407482568547866, -2.3942005985626422, 0.5008429873170573, 1.629153936319402, 2.3261962212238414, -2.101849953098176, -2.7664389145381785, -2.091121421582737, -1.613538664857319, -0.6458997296190929, 2.667044631999832, -1.9158331783522802, 3.459097641077399, -2.828033641910958, -0.5040257402353594, -2.8090426718044186, 0.3751352931295534, -1.2969774289386211, -2.675436883091088, -1.426670218516987, -0.10829025739705728, -1.889428963161793, -1.5444439111016044, 1.32753742470472, -1.8391816972225221, 2.8707809170865306, -0.7431229500956309, -3.0250008942600446, -2.519865996877733, -1.5012843821955228, -0.548954924571614, -0.1929199574323157},
    {-0.08175743543259927, -1.2677826227216564, -0.13162639015200656, 2.2540073688039395, 2.638508074742437, -2.4332128639424693, -1.5406227663529528, -1.2671020653985692, -1.126228210494795, -2.5131779804118057, 1.7120348144017021, -0.8195753508519762, 1.1115671578731097, -0.23233542759606185, 0.5958534310622453, -1.9068512065766905, -0.9280346308002113, -1.3489046978024708, -2.4796978741335103, -1.6679405220414285, -0.5007182263064117, -1.754380721791517, -1.424127582972152, 1.5423259766820088, -1.021332980227985, 3.339155139912959, -1.1466319770297837, -1.7796036406236768, 0.20282482253714096, -1.8202967117086728, -0.8215198778920061, -0.3009483502295022},
    {-0.8469226007395034, -2.749821368254795, -2.5091811233258667, -0.2601431708459061, 1.230255456462298, -1.9615906326578063, -0.7632876547284405, -1.796924169665307, -1.3024506942278873, -3.167191636167873, -1.1835274879277604, -2.5621549434831166, 0.5794615973088976, -1.8223578515964571, -1.1714418261171202, -2.350096885957562, -2.9743542098852753, -1.4372152506094393, -2.0582013140589006, -2.4451155988865145, -1.0303919576172074, -0.9465751439026248, -2.028919439170116, -0.30931002644866956, -1.9806360470807627, 0.6268145383976466, -1.6555323816678582, -1.3434009545213206, -0.6140851138910778, -2.63991740336045, -2.180665450476064, -0.45012373377464554},
    {-1.6643155930426348, -0.8473407047230058, -1.5853978060935312, 1.2550626050153206, 1.6929155010460517, -1.0987509182998758, -0.2878306598487758, -2.216348390563268, 0.5918384436283546, -1.5857474202032846, 1.0657025126155422, -1.785790525966484, 2.0562183037288926, -1.1198054498206724, 0.6434523030325444, -1.3431356768176586, -2.0322004843828587, -0.44100455339800215, -2.042595255691454, -1.2114952888587716, 1.7799594467625113, -0.4856378942373622, -1.1777223070255802, 2.536071858459365, -1.0918945440398642, 1.9940028489662183, -0.23108376477808804, -1.0456098741985045, -0.6766778060607946, -1.1333542685155658, -0.11749246471147361, 1.4892844227408208},
    {-0.9336707685432286, -0.05162978514537696, -0.2429153735391186, -1.8609755533149868, 1.176571738785979, -0.06284638864043686, 0.2726279705310345, -0.8016998159427211, 0.9513781377222829, -1.4952082594225613, 0.3823850472430155, -0.7246028365029108, 0.22105352239638096, -1.8279872844928058, 0.47925093707884925, -1.280011784183341, -0.5953119323566917, 0.04340740892053343, -0.9385169292707709, -0.12282219092424117, -0.2928774669161414, 0.004409231233838563, 0.036868399222099904, 1.883049131844517, 0.006403804732798397, 0.5815554909549466, -1.2042824312027274, 0.6419848650580647, 0.6954306101724086, -0.9068693952905762, -0.5586721067793636, 1.165386221671575},
    {1.0989703573539698, -1.0677960718949933, 0.5069863937975562, 2.1503386300226053, 0.6307758005275204, -1.6876198132176452, -0.056556054372997544, -1.0525951639140079, -0.06853871682490012, -0.8223267690925038, 2.472239689060873, 0.004755405437309138, 1.67535643622457, -1.1957533181946791, -1.4754276449210073, -0.39117557453555424, 0.8093740205487293, -0.8280382792775536, -0.29009310952099354, -0.5329003308345964, -0.19054388678339426, -0.17252038030405556, -0.6931084453815884, 0.6686840826621431, -1.0863364413589707, 2.383272206426835, -1.028126909159274, -1.0237861540686783, -1.3153743102061817, -0.33774542889024595, -0.44446120572396514, -0.5869578379206504},
    {0.18833800072832246, 1.234889673239278, 0.44008652912238316, 1.8689471993696407, 0.5905906321653446, -1.8735261082751182, -1.3370305521627317, -1.3695338249478721, -1.6472045091722427, -1.0857100997588411, 2.66427795043842, -1.0308838885538822, 1.5123888130122167, -2.769461329086797, 0.06558289166065873, -2.074774129095012, -1.3238502011896733, -1.7480639028449425, -1.3181347757560138, -1.5169535730037356, -2.8802575826572423, -1.0190447124574522, -2.1191003037360736, 0.25772357305849336, -0.9366733350593064, 1.6915247676017757, -0.17249928165339143, -1.4506387161992373, -0.4816646709604267, -0.3886765345370011, -0.2872938362672552, 0.6875657160437203},
    {-1.7945774957087783, -1.6710520830927391, -2.46245784333989, 1.0862850497410774, 0.906043147888091, -1.4944814414377277, -0.05421854387314784, -1.7257379934842954, 1.127659066144387, -1.7734017353634293, -1.3363335376656642, -1.911606043699667, 2.3804948460775113, -0.7855080915566702, -0.25039299559602635, -0.9580528701929282, -0.8800093023102217, -0.6542379069397058, -1.276971279901575, -0.8971324815094769, -0.6465964615591614, -0.6926785401437102, -0.2000476022915135, 1.5560212529822144, -0.4931620496811568, 1.2639347899662505, -0.42677869736049867, -0.9851706229990919, -0.16658660909551135, -0.5618044129600247, -0.24800841173351368, 1.2201094558579344},
    {1.2020622320413534, 1.148516109195577, -0.6745730707373404, 0.8457252336300684, -0.8842248905535153, -0.5026941980043371, 0.3146788899855349, -1.2329163881486045, -1.0680394675859548, -0.30449025000912233, 1.1639879547159375, -0.09867577159145345, 1.2190710342050093, -0.4340086594963269, -1.253365115260087, -1.3201477964783763, -1.1837862919483289, -0.6141605528550115, 0.17579822266049402, -1.6257008480404354, 1.270731799242724, 1.3989521175928379, -0.9442971750063416, 0.5280380917541182, -1.4523634714610396, -0.06268721452872487, -0.5044280668761013, 1.1017176779550117, 0.2588774559523977, -1.657611925784436, -2.541513364266043, -1.0289440035421156},
    {0.6896867873192831, 1.13996004992774, -0.8928549523989213, 0.3389418091590748, -0.06867659036477189, 0.2573262462579958, -0.9996568904022366, 0.9920417552480908, 1.952360564141219, 1.2414702003284137, 1.487336755331232, 0.16199666023697262, 1.8125169628053848, 0.48329431766768566, 0.26839220221570387, 0.895777686230064, 0.7023048677314018, 1.1368861038010256, -0.08248118640464876, 1.4768681736525933, -0.29770953760355084, 0.10135036736518999, 0.1703255447648357, 0.948397524425909, 0.40166928078676684, 1.1890612619337002, 0.5277505553265397, 1.0631497823158385, 0.9568961740350304, 1.1849666089004667, 1.0809080755693645, -0.2995969725920503},
    {-0.7241394721022919, -2.6367235570665546, -1.9577593111882807, 1.9105178166068992, 0.5471990260081404, -1.8410657905856047, -0.8356220860907639, -2.3370465931292763, 0.8680867149636238, -1.8527456894971808, -0.17267107944009674, -1.317694594674223, 1.6065785603938596, -1.583118301709702, 0.9906446991612436, -1.680300386845037, -3.0368223457053314, -1.298948139660724, -1.8415872281524557, -1.8749154012344749, -1.0510395879119248, -1.2428966651233195, -0.6845601592523424, 1.7672415999251063, -1.3560999140075616, 2.0421605921023565, 0.4510452365770188, -1.9977287042252532, -0.663555574141934, -0.47772223029816824, 0.568978933805578, 1.2035083600948455},
    {1.329414802329648, -1.8685372386139845, -0.9362288174035347, 1.7112876020072467, -0.5042015400087427, -0.3910308799828153, -1.154964472700471, -0.56340316386323, 0.2807078430758621, -0.9145319874447256, -0.12096075025999946, 0.3500703482860532, 1.4449440149405126, -0.09627825375782102, -1.1778853097359117, -1.0495932920110125, -0.359499700423517, 0.008727627275656525, 0.5485698481463213, -0.7098710425800921, 2.1563114564706845, -0.5149416529393073, 0.01860469575449171, -0.03218688269830494, -1.2216538606537397, 1.7761994633095697, -0.028397763227108675, -1.1560855700889794, -0.16645023839802006, 0.3841604161502849, 0.5581282631904778, 1.2516558810448157},
    {-1.0136835245608173, -1.0648798390264207, -0.808680543592516, 0.19494928292124872, 0.7997687967658972, 0.04588257418127552, -0.9373574837290101, -0.5097425750904027, -0.45570947671175077, -0.5544638803310113, 0.6243707599155015, 0.6051805003297264, 0.9364379744248554, -1.176774772269108, 0.8037840669919618, -0.6720336992876634, 0.14768094696065365, 0.5734246271933066, 0.027376752133567633, 0.2242334320096082, 0.011034662245836175, -1.216604159338163, 0.19649830972680057, 0.20430505300578156, 0.8319288093481637, 0.2969671926247128, -0.02590755061346621, -0.7053527759859652, -0.012785524747894975, 0.5671050103374214, -0.31724898962297865, 1.395539000916921},
    {2.900891957526964, 0.4729525415494529, 0.08621221429000035, -0.9772583813459848, 0.21409369657111813, -0.18923965548805563, -0.10469121140910684, 1.3238802715261748, -1.1924104523963506, -0.15432545467568562, 2.0781318187401965, 0.9340499520594191, 0.27912150634403476, 0.28584158411046323, -0.6885253151626483, -0.4029563377238898, 1.7243134802735736, 1.278957313045191, 0.9088153755645384, 1.1410601325212608, 3.1317904044643807, 1.3176858079338103, 0.07548805872048191, -0.1697185771006955, -0.2373881240081477, 1.0641562973504959, -1.1355479643497095, 1.074466741152471, 1.9142189915589003, -0.3898306525444414, -0.2652415183061637, -0.10230727624225573},
    {-0.9665986460238918, 0.14280852876658243, 2.225617260850033, -0.47613725337976454, -1.4838458205704828, 0.6062387142840271, -0.08541028366964559, 1.241859691511067, -0.36030642470891183, 1.8689233415651256, 2.4534700348762466, 0.45966419766831434, 0.7862052190202764, -0.4561938708681403, 0.44438561819716726, 0.8484085404681533, 0.9336250904963534, 1.2482890280560093, 0.6608292789040744, 1.144230608222176, 1.3634200036802937, 0.23035718453047554, 0.9046822430688315, -0.5683450833397071, 1.3374381512899396, 0.6203758785234583, 1.199259991675696, 0.4171518209991668, 0.0591281628270645, 0.352365121884808, -0.6532344611204272, 0.8814178412883076},
    {-1.0148896649771022, 0.20409853436772998, 0.7304316480216604, 0.06747454926578342, -0.7219098315168796, 1.1128285993872213, -0.5385862260272072, 1.2854354537848454, 1.3527475503470647, 0.9295246881106529, 2.136622392404027, 1.670368103864439, 0.20341357662682696, 0.1695670701843014, 0.7662389687830508, 1.366566800662699, 1.7070383226874692, 1.1183896552851935, 0.9168315798581439, 2.0205326293815706, 2.61791226513147, 0.740431479499446, 1.8701275585481767, 0.5473944380711105, 2.0224972763105393, 1.3652006492115702, 1.738119825117029, 0.5245170066974882, 1.4747601624340054, 0.8540500989631752, 1.6956839139195448, 1.4543678263740178},
    {-1.926958603896856, -0.25794842679802726, 1.4953663157893065, 1.0621063081169009, 0.8912143090201817, 0.1878748855560923, 1.026272265457529, 1.2672065224554065, 0.32743750149626716, 0.8412140629601653, 1.4961258954119798, -0.08178519755883332, 0.5276922883193232, -0.6342207231503291, 0.4884601180063415, 0.16130957623278472, 1.3893204164099917, 0.9321145489838732, 0.6110305766782649, 0.1393793586110098, -0.3759455009891173, 0.9757007182299198, 1.380268455076045, -0.11953370040159658, 0.6937207189733754, -1.1595953447423353, 1.3536688928998857, -0.6063389626620684, 0.061286999909185055, 0.7485034998230026, -0.013952311493851519, 0.3251952579195301},
    {0.7859768200202786, -1.0437478350400982, -0.9094323707244707, 2.779407538075814, 1.500746244156968, -0.3084965447361285, -1.0566027542179173, 0.16410247815865617, -0.15956242103213644, -0.388478190727949, 0.48387074931500046, -0.4111348452916447, 2.1894506333182617, 1.2962732040697564, 0.6756744725732873, -0.8648398330847679, 0.956128411902295, -0.3628870923378706, -0.045104490991465254, -0.9397330795044628, 0.8672490309166346, 0.40348003536423926, 0.5246372209384971, 0.9827962029241345, -0.9329671207709835, 1.1018904566967491, 0.23694149684978613, -0.11620865805733692, -0.32224632899721367, 1.0550354829900943, 0.26601553983351184, 0.9557018312529074},
    {0.014955878604817332, 1.1747660571833884, 0.7344172020247716, 2.7325244902975756, 1.6022455251966559, -0.28054494637367045, -0.20564944510100291, -0.6698587984686522, -0.406316589778149, 0.09669154315753296, 2.145540694500734, 0.2661535713175732, 1.9954033463417007, 0.15575862536853521, -1.2528706980251367, -0.6260947864772425, 0.6796521363677479, -0.2652338893656622, -0.6660883186724862, -0.23265050546294583, -0.10548047629291846, -0.853243874107971, -0.675597991344925, 0.7972399738496325, 0.1873807948159206, 1.0709506506088828, 0.2359018832048595, -0.5641235524801298, -0.6387305528017996, 1.7036780279173136, -0.42000398752655094, 1.6907877052841565},
    {-0.7140799950844745, -0.13690134804456014, -0.9398262079369694, 0.15705720377287108, 1.2010086754599076, 0.8417073024801458, 0.2542832840726224, -0.6204221701807722, 0.36674613961701746, -1.1617570874950047, -1.7681239772075363, -0.40682090141842997, -2.1308034908447495, 0.28661931463608303, 0.03566608768055296, -0.507816942887047, -0.9213749922454593, -0.809418833213792, 0.6441324071162541, -0.238661160328571, -1.9045131551101904, 0.4322976214831278, -0.3823539540235523, 0.7537385321959281, -0.07339450177436883, -1.6426551017813578, 0.7793397170727638, -1.0103269130193053, -0.10546595028433955, 0.6667812051868146, 0.5530928290518929, 0.6158620427884327},
    {0.33149144131446867, -0.1598672683264928, 1.4850679842915007, -1.824894907197006, 1.000357693182411, -0.25235523316210634, -0.3704907585497096, 0.39775281215899366, 0.04210897140580879, 0.32874102912551256, -0.7804621952039307, -0.2899158028990325, 2.663449721118371, -1.3029023300788194, -0.7050852286996082, -1.3014036198500807, -0.4154809161542714, 1.0471373422787518, -0.4835244188532476, -0.24716662046106297, -0.46770684049132794, 0.2115314296077296, 0.598878316708386, 0.8700973300979021, 0.3212002971356964, 2.119811439416853, 1.017920410363217, 0.3135080160046848, 0.4635202166587061, 0.4169474104794382, 0.7861187341230252, 2.2779105902755346},
    {-1.1987164517924132, -0.09552893199454837, -1.112689902139373, 3.7559033315969543, 2.062548738934242, -0.613213524073604, -1.378632113369111, -1.4535231088221332, 0.5559725014167344, -0.7254706549357606, 1.6111784393289148, 0.030367583936718873, 2.3587475755637004, -1.2506549994944285, 0.7293704933910262, -1.6548444714051531, -0.9224021757735522, -1.2631130058975129, -0.6200460883910105, -0.9663241026931236, -0.9259929529021694, -1.30756248264929, -1.1611408986174085, 1.108473097510397, -1.4558903010968374, 1.7872770867035088, 1.426513450327761, -1.14019756585866, -0.5032026897038232, 1.088225996568667, -0.8325623935555291, 1.8225071992029567},
    {-0.32090148739286106, -0.6337062243076665, -0.37264743215472823, 2.7949182426225345, -1.7794305663441088, -0.3285564153509324, 0.46095346341679205, -1.5462620724805296, 0.5290256729372886, -1.7355781841806268, 0.3855519389459371, -0.36127251035825103, 2.055303680192674, -0.6657070896309967, -1.0748036132164263, 0.14889513618660632, -0.7288617277052435, -1.2968502955525074, -1.0152800487047697, -1.2822612483940168, 0.20290443759689383, -1.1599825466869829, -0.24140177508817257, 1.6072268577354876, -0.48928741038965157, 2.1313403270471913, 1.6542558855923202, -0.2394052672779797, -0.7048637464286116, 0.44052500865938155, 1.0691817908579166, 1.7750136497124922},
    {-1.0847942972728621, -1.5875158894704176, -1.5470159912750092, 3.2288213635929184, 1.9540764985608199, 0.18610023655184116, 0.21199586724601444, -0.5695663846449336, 2.3617469564899367, 0.5780826737589739, 1.1019317191150961, 0.15187873786320966, 3.1577343755398495, 0.613524573253498, 0.791654418944407, 0.5183480174861239, -0.18601492103638503, 0.7163864807290331, -0.6598942595742374, 0.2810961761726318, -0.0024747603174806706, -1.4187372666399134, 0.6539138678361628, 3.081138832621384, 0.29267703676026263, 2.682517124995449, 1.978200341546226, -1.4834412037671147, -0.8055116425388026, 2.131051469226926, 2.2728971485847222, 2.8028003754149524},
    {0.3344078439796487, -1.320742164262937, -1.9062541298567768, 1.3254710069865407, 0.987410330953448, -0.9804877977567303, 0.759859746054502, -0.9640743162344301, 0.13011075230271626, -1.275281002731157, 1.088756921123769, -1.198052979821143, 2.2865694035360047, -0.8763952190603251, 1.9769147122583823, -2.0556472333319222, -0.7802366646156493, -0.20613568965698095, 0.3327630735236369, -1.239069376255534, -0.31965621152072843, -0.5598613284120506, -0.08609754358264793, 1.6550069287061446, 0.10894852627794277, 1.3943298353810953, 1.3849643251292536, -2.1688266417166977, -1.0745283624432265, 1.42948780017985, 0.3831285840482218, 2.2908904349218124},
    {0.7125502477896897, -0.335157039411714, 1.1329062443042919, -1.1194805948494186, -0.3052216654342883, 0.3127472610113521, 1.2683867030943337, 1.477973980122565, 0.7622167139309363, 0.2773530329725966, -1.2024330246471537, 0.35011035007157965, -1.4113615379300264, 0.9915975905956875, -0.21059594655528485, 1.0247380232824408, 0.597440485068697, 1.4759903678398365, 0.5505646947201907, 0.9245539587107044, -1.539608153192085, 0.01058733568412747, 0.6217824791406591, -1.2313735293664054, 0.34909099058789506, -1.055390001692721, 0.684310055901423, 0.8191772095885291, 0.2946154934771717, 0.8234700434248075, 0.4015745643290786, -0.5167690754198256},
    {1.2039132073642878, 0.9364086470717421, -0.3138245160793739, -0.6004053202671893, 0.3716484497134519, 1.5750090421739344, -0.04214194477806151, 0.4647448835902029, -1.1059903712926435, -0.3083650300622185, 1.02601315370163, 1.2775195796470122, -0.9649255568091936, 0.852300744361953, -0.3999877211486821, 0.9008581005080413, 1.8836767127859384, 1.0936616478954955, 1.0434914157229864, 0.6118444568434808, 2.0423095754582983, 0.6487853958615103, 0.38449445048396386, 0.5864426325904258, -0.08388681573066391, -0.797160648163855, 0.2939516136365479, -1.2639592635438044, 1.3594538680556956, -0.4227362174440891, -0.6117804334358546, -0.42504959953145677},
    {-0.6919205007537964, 0.49924150765228453, -0.8981200831705302, 0.28691205286637017, -0.3811771847495746, 0.07075484080693972, -0.32848174480828063, -0.6020263586380814, -0.6207851192225011, -0.4547773068515936, 1.3951134734740556, 0.6595116571153367, -0.5937579737526535, 0.6240089181530653, -0.5454082621969076, 0.14199407647775322, 0.6170962711031884, 0.01557628703518038, 0.2732053788673842, 0.31162329243249753, 0.22351631507722222, -0.2953428056496625, -0.5178860801287445, 0.09075357114666076, -0.745646696177248, 0.7873928427957797, 0.04616597036658442, -1.4140910933073816, 0.532653239536868, -0.0497561576655122, -0.27646940147268656, 0.6203010776251303},
    {-1.8279056998005399, -1.190293779607732, -1.148855500604906, 0.837872323177883, -0.32841072739777916, -1.0133533479353027, -0.26998750163864593, -1.4079171401301034, -0.23780345079283713, 0.07766395652178756, -0.0645609120520153, -0.9245887382690774, 0.6884916898023771, -0.9854076515058617, -0.5461191446861622, -0.7823536333220359, -1.3325956052514525, -0.9519407825367212, -0.571015187330175, -0.6083999065244095, -1.1328336413640794, -1.115955701215367, -1.4337187065133483, 0.8339394764881725, -0.37809411243612173, 1.3150800350625256, 0.5975830614985824, -0.5828491903047444, -0.6471974752383282, -0.074922580190272, 0.3319279659680955, 1.0814985043225713},
    {-0.8133371446919818, -0.08270071126184501, -0.7161019242425455, -0.2050762328131835, -0.2120766440594903, -1.064239619097625, -0.690350880535714, -0.5191975138806098, -0.592396227139666, -0.37314135974009394, 0.24567890297923872, -0.5537527049436259, 0.3065879527561274, -1.1990282998626138, -0.8330797163679872, -1.2081964223945698, -0.6972918292897724, -1.4665872138774187, -0.062245988863007466, -1.0774098253873208, -0.5779189632171174, -0.4479015477694184, -0.5013817520048182, -0.15862993078848606, -0.0599684873854249, 0.2729266543632112, -0.7199895457408074, 0.2976069593733893, -1.6466612836733985, 0.16213026096900582, -0.0566644493768324, -0.42679459066040365},
    {-0.6740360550351329, 0.41303787200479775, 0.4171007825122698, -0.026651069791956184, 0.2762179994783307, -0.8446261204375222, -0.44260620298416203, 0.6189507971834841, 0.1056495571246344, 0.47459787043028795, -0.6543560751508406, -0.7163655800272397, 1.0131532440971278, -0.3762025199446586, -0.07239051757590642, -0.09768877313224106, -0.6235699428098415, -0.8317857612799344, -0.38068258506989516, -0.5019870369415849, -0.33571038841847406, 1.6499922981097321, 0.16773255900472106, -0.17125260023497713, 0.7884413947016946, 0.6281152568930928, -0.24280905490997584, 0.2563924659887791, -0.5991165578813137, 0.05668800126574988, -0.29688312922698423, -0.05478857559808311},
    {-0.42585407326632324, -0.03620861650846006, 0.7276954997116731, 1.4410915128978699, -0.6126314527153227, -0.3990783930993466, 0.24089182602356193, 0.39554967342245667, 0.9276255365660965, 0.1793671372935608, -1.131002396916817, -0.7647891337045495, 1.6448916150332489, -0.17141390866715026, 0.5315537919266917, -0.15310254818204022, -0.7742446693918036, -0.026147864914098387, -0.0027926680491217816, -0.591311065919083, -0.5966243692084168, 1.6060072055557588, 0.16299618178798964, 0.16955460838662492, 1.06603687446232, 1.081230971566416, -0.4993342537925623, 0.6217756407024735, 0.18464530733567522, -0.5240243795835214, -0.9150334107691334, 0.7680459984823351},
    {-0.7146225959962973, -1.2953924847235536, 0.5900244066499966, 0.47837074606518293, -0.4603269078667859, 0.15139308177393337, -0.8914396819909371, -0.6346369384776955, 0.34714186538055886, -0.41552782318247256, -1.6783998707014582, -0.6982198201373717, 0.4757183238959787, -0.2882084421831247, -0.19087577248007934, 0.023403264001654177, -0.2757935815810142, -0.4294607797342415, -1.228615934754878, 1.2025922690752209, -0.8590793923600435, -0.4234938806388331, 0.43618068538982946, 0.8956392604171215, 0.1095377966210856, -1.4860071404800406, -1.3206117789504033, 0.6566462120312144, -0.32411798841943573, -0.774419778262089, -1.0832234794826767, -0.6778673580643024},
    {-1.1825894815872287, -0.9092925676215952, -0.9331308081825805, 0.48333541540547875, -0.019694874971439215, -0.31620667975266464, -0.9488657000935014, 0.16299940200151986, 1.2126521609459513, 0.5012434729944747, -1.3347246374672148, -0.6259379627320565, 0.7726666391036621, -0.579388183289435, 0.32953556381178567, 0.11311150705915898, -1.0094654210006655, -0.25502456633161985, -1.3034666878263417, 0.6218244447790781, -0.14268750501715596, 0.03948409749163915, 0.3239829320979302, 1.3465091478157805, 0.8507794759138672, -0.15865440506654443, 0.07150335583531396, 0.9584909651503923, -0.2004043234525093, 0.21185353579434496, 0.5376545321367123, -0.6960497002657842},
    {-0.3850757004606816, 0.2673257317619832, -1.388576599915846, -0.411339743333104, -0.46754161854711046, -0.005463060415645266, -0.22618938273654757, 0.22674667913522503, -1.3420515834705644, 0.04363536947553221, -0.20951491306011052, -0.15565519018506596, -0.2038461058143928, -1.0238079922546606, -0.8976344410556406, -1.2144008169734855, -0.7177097157633135, -0.7551622185911859, 0.19608573973591095, -1.1686891230288436, 1.5569421128874044, -0.7799188528842763, -0.25597966641467007, 0.04435671810333882, -0.5955957608714808, 0.409978408291292, 0.39786938968817087, 0.8847735055008102, -0.3729325606742078, -0.7118158932795481, 0.43732033296362177, -0.5284527506579725},
    {-0.6739435509752495, 1.56107196259217, 0.8849477328821216, 0.6305432291546079, 0.5832228040421925, -0.3776283814904379, 1.1879098695630013, -0.05342921324625725, -1.0849942369035674, -0.08488098545108926, 0.48870300280951473, 1.122350923417784, -1.0354884349478988, -0.6995084441937697, 0.619080021298086, 0.0030319809608438356, 0.7714393271006489, -0.4115326455985882, 0.273509553978521, 0.25190641207324327, 0.7419143690969136, -0.6672974776550621, -0.3611854934412432, 0.49103003405905715, -0.01507330983773958, 0.2384736106492747, -0.2982290914768376, -0.10569138509144958, 1.632093432075178, -0.6807865724261403, 0.019492389242110376, -0.7489872129488644},
    {-0.6563983254393877, 0.8778831028476924, 0.45391359237146534, 1.0225718948260683, 0.6733345805411249, -0.48514741491478236, 0.7628695686064199, -0.27207090289834884, 0.13348344659064335, 1.582977617125081, -0.15069204120970237, 1.2578871197858759, 0.9087893617078323, 0.25971958730675065, 0.5333909730990961, 0.031137478865230408, 1.379905781099784, 0.8624169492487828, 0.5553417225873176, 0.12310534252410259, 0.9501747336190984, -0.019308345839062338, 0.04791838527202361, 0.0786738994369163, 0.47648574954384554, 1.1393313248630312, 0.1332449547059091, -0.9580131859747681, -0.24697027913307243, 0.3236870991704146, 0.47160946599848386, 0.7290646402135318},
    {1.0780726505006502, -0.3091100030956946, -0.247961511489265, -1.4956568018152645, -0.11199906342243657, 0.21807747398786803, -0.12170222530950026, 0.0643895605622295, -0.6631289779610503, 0.6418791701121727, -0.8350482561656325, 0.3341635728662414, -0.028262516268823156, 0.4049894210370847, -1.1007730311401964, -0.28595870223017966, -0.27267062779101287, 0.48058360486092744, 0.7166146542135404, -0.9097640626017214, 0.9564604411187982, 0.8221391082951011, 0.23876975591993438, 0.028708095487623236, -0.15859109404046542, -0.555222642328192, -0.10223684432863468, 0.4185902476182536, 0.19179851084566532, 0.2559097083215597, -0.1324958036736275, -0.061312135593138646},
    {1.193945439210449, -0.04416267505124005, 0.20407319243162178, -0.6910506113745086, -0.2240417787526086, 0.6225772737898289, -0.2817938030781504, 0.35695517813960675, -0.8825593300799122, -0.4178032686645572, 1.7412509531665186, -0.07883990772866206, -0.4289856092025488, 0.09716771825205411, -0.43834347676833224, -0.44631618823105157, -0.30425828325002147, 0.3062525163301019, -0.0287452723895507, -0.3687533433707468, 0.005563058919228508, 0.6049159117772582, -0.5085838435899126, -0.524642648125289, -0.5531624971125952, -0.4130006261371086, 0.3447022711357277, 0.45514591589892894, 0.3791190652101672, 0.11213334767651262, -0.7866852172865465, -0.7083868573256312},
    {0.9295982436395597, -0.36962687842250364, 0.046568821149117874, 1.357157607946432, 0.30485867032413166, 0.7267085864625233, -0.08323029346516024, 0.1810196775531412, 1.651082164580637, 0.05328251074245219, 1.4088458458110262, 0.6794423759911336, -0.6200911782154711, 0.9410126417801781, 1.455822179649538, 1.6733877504653434, -0.08068632066293184, 0.6826223165499227, 0.9349450655868349, 0.9242090982022517, 0.007688067638400059, 0.20183762276033893, -0.03969436805267657, 0.09525942878862975, -0.18822921614257954, -0.5725052577203472, -0.48140517553760254, -0.7702409977127582, 1.0906391805045312, 0.021352216474534006, 0.06935886543669403, 0.22486131796206307},
    {0.4052646510319166, 1.126879469593568, 0.40176975302401746, 0.0053664179195874115, 1.4278623101838468, 0.8333025948995563, 0.050251036084713145, -0.2423876323885334, 0.29756794238351614, 0.5761030184068016, -0.6850461157271832, 0.9616952494076149, -0.5259194540145293, 0.22105338590122886, 0.3557682752067701, 1.160711188373454, 0.5628713078876213, 0.5822237698885884, 0.061141368501095944, 0.3593756071966524, 0.7621855552103726, 0.3171142392912463, 0.8930541681387311, -0.1809912057750272, 0.6876268607373013, 0.17400991468757435, -0.7177087647728879, -0.2861754056480432, 1.0880473711318943, -0.4054888603492394, -0.07500876274203139, -0.20185650873774721},
    {-0.9354588394209077, 0.22794343355384178, 0.5235170021615441, -0.3377478877292398, -0.4140653060669165, -0.5020608779819603, -0.4464852473506588, -0.16865624755305506, -0.24923079074131393, 0.8439311265646618, 0.12776055254113416, -0.6611882340110309, 0.591481706628778, 0.2503611182557685, -0.37579718613902674, -0.6333137072434526, -0.1989955703540263, 0.10068167517671364, 0.32366186845603057, -0.6311242386971728, -1.9272918219870252, 0.10497841343371819, 0.43465133399860434, -1.074393422870683, 0.23336245688003784, -0.7718469422460831, 0.9552749817749153, -0.2110675413510761, -0.4002467305245267, 0.7652742865325491, 0.3321265050622727, 0.796243515303673},
    {-0.33581198110902205, -0.09354023743375411, 0.2118234768377788, 0.2227217185033146, 0.34526557251986123, -0.42084235233062806, -1.3348950930151695, -1.3186776318402, 0.031119081018614925, -0.1449556557625167, 1.1750530641998074, -0.777380867484438, 1.62958511683815, 0.11718882430631902, -0.03721928262706184, -1.2036315418921661, -0.3954158601861354, -0.15572981838382813, 0.17218100206818038, -1.2375329916357023, -0.5877128839090023, 0.07646800526186161, 0.3281534450490355, -0.06403753827973802, -0.17997338800143234, -0.20108763142418296, 1.1530932413705222, -0.2903427617055122, -0.1990727060903792, 0.18680830276443222, 0.45325105342921207, 0.33485268684923986},
    {0.273009111118947, 1.0794442153252017, 1.0728187288303022, -0.4163276636226427, -0.21623921106863322, 0.40108801074392203, -0.011980586802467844, -0.2654320032197371, 0.4851390444306192, -0.03525640254396273, 0.5188739244712774, 1.0756475047197551, -0.2404787783740704, 1.6460006954359763, 0.5476464673697454, 0.03629255540089532, 0.00047695341490788215, 0.20912884681009547, 0.4365836751367672, 0.44810756898891, -0.3551311842420934, 0.6016231793347917, 0.022264201356974978, -0.6233556395546243, -0.013887905180249804, 0.12069091316674031, 1.6989901038099977, 0.6642242514414068, 0.17444480136016058, -0.22514588405310532, 1.0959976517087437, -0.46323711975618775},
    {-0.3059537560905477, -0.5699708098452123, -0.2631679155967241, -0.14709722059861635, -1.4270151739786283, -0.24916967854093117, -0.26191569272704707, -0.40866248565881086, 0.3347252699851518, -0.7763210912346291, 0.8532272505105063, -0.3556074983948021, 0.6255412722668043, -0.5681742708045213, 0.872975282671177, -0.39445278772911635, -0.9387329211680315, -1.0748014076465822, 0.14266614840127534, -0.8422874968678349, -0.8032769054683492, -0.3842468993844975, -0.9939714545268749, 0.5015028747565995, -0.6945507923724054, 1.6752254996716043, 0.8607520629455842, 0.7131997615408338, -0.24467023228288232, -0.43330071156987926, 0.746456116134012, -0.2772558892690754},
    {-0.07107621922184852, -1.387775026718266, -0.7447050855140764, -0.5159919108731406, -0.1661125959034477, 0.40597725946366736, 1.141157501092677, 1.194705794764573, -0.4183128998193232, -0.20633556922273724, -1.4099353104814791, -0.1842040332075239, -1.525613687776955, -0.9950263580249676, 0.04624354069140956, 0.6335535813263776, 0.5411352033914038, 0.10151521958065207, 0.16830440927579532, 0.16357204367787878, 0.4066335517442052, -0.26063413272257824, -0.4708140626098434, -0.14334649231898808, 0.3153342822187439, -1.505336212485737, -0.7936936015309857, -0.18236024142187754, -0.321425574750991, 0.395254432230772, -0.8302748118148836, -0.7144000560063725},
    {-0.34718541960752464, -0.5061180687434953, 0.16270673390318804, 0.2623185429891131, 1.1811463044635981, 1.0292893744403304, 1.5845227033345892, 0.5654197084405215, 0.5049047408870808, 0.6103014878727417, -0.5479411847405973, -0.3146857914449484, -0.6860318859031475, 0.03648570767361633, -0.6253694899207122, 0.8943430567234297, 1.3405553669761583, 0.7772473791396657, 0.15567470186991053, 0.7070858155246174, 0.7394574624529504, 0.46830727744404427, 0.6617111169458468, 0.5019656620002005, 0.29607006214286735, -1.3230840713006904, -0.5489742601817182, -0.023446972948397014, -0.2666428104708894, -0.19767711769462892, -0.9274851600264684, -0.06468601920109067},
    {0.3696520743362275, 1.0504046873208657, 0.45206080620381167, 0.5438977948735944, 0.11929651004934566, -0.11793203927789372, 0.8234402087320601, -0.560271106934953, -0.39395716194213226, -0.15850918600242514, -0.3641141258458691, -0.8337851542926781, 0.6334950274040768, -0.07492731247097013, -0.835525839645023, -0.20221844511851256, 0.08701046626182567, -0.18330793528558018, -0.712241171129268, -0.3609152971691832, 1.39101137782116, -0.6643313070583715, 0.17640777722421272, -0.26821335120238177, -0.15404919272512022, 1.1738629417904218, -0.12776680334987364, 0.5117209943442433, -0.44750443400091017, -1.0273876467218845, 0.3230627456917869, -0.2112903061457672},
    {0.007598362423103419, 0.4931073029885038, -0.029173311411154867, 0.3568149241662822, -0.9485718241379208, -0.560199001911734, 0.17816907811744068, 0.06496193152117466, -0.23007107112185143, 0.07083411683191744, -0.3077598237211175, -0.09443976755747563, 0.5576074408479984, 0.15482185332707557, 0.17436835411489202, -0.035173788081992334, 0.23768360726347934, -0.017017231288991977, 0.009347232888648558, -0.4398410195615621, 0.5253989385326034, 1.3491368896916176, -0.386147154249101, -0.10872961270549078, -0.014857903106886807, 0.1073501932105789, -0.1797226010199022, 0.5895127046297541, -1.0129048740295894, -0.773781106617606, 0.19782954577956083, -0.3651213307281295},
    {-1.4690360919733227, -0.9942606791995583, -1.0048549722616111, 0.2994772181981047, -0.3697369123278118, -0.8632282039156157, -1.165795155573405, 0.5334621108206445, -0.3107619725985737, 0.05428766105191673, -1.1013793218417887, -0.7544538471097827, 0.7413637481132167, 0.006344123747012801, -0.7991088516102366, -0.9027352981473283, -0.09887397042305317, -0.26756460696317663, 0.25446300753030615, -0.6629723912316573, -0.5445231634458336, -0.5282022476818046, -1.1321278973729958, -0.9186911436688375, -0.938046299931376, -0.5734630571630048, -0.01997037046717146, -1.6207166993573976, -0.9584253223919524, 0.013230995791554538, 0.7063859492082651, -0.17774655198459033},
    {0.31570887988615587, 0.3435898386786849, -0.38166213838590984, -1.3869218156792402, 1.2312651284998515, -0.23968436828891274, -1.1213230440832864, 0.5033309797648423, 0.6622015900139305, 0.011698343286621775, 0.10016802482007763, 0.1722380470976859, 0.6951929097608311, -1.643890612430047, -1.166404541988128, -0.529825600649518, 0.3527439335053414, -0.36353764479062955, -0.6869570922999628, -0.04732309072441125, -0.15846743741226732, -0.4817827108596383, -0.6285513580646545, -0.2834144272434038, 0.605005994524172, 0.1325040654683543, -0.9335452322582113, -0.9637970438189476, -0.2374481856439827, 0.04258252675701908, 0.6815498685649234, 0.5687759593502683},
    {-1.0077418090604586, -1.0297981335253903, -1.1078517199825904, -0.6366972710675121, 0.09712933382457486, -1.6173606690095401, -0.606403575766907, -0.7743435402314688, -0.2932473695194247, -0.7876182934066708, 1.0708617318437608, -1.4702886307306762, 0.7885649653457223, -0.7122644234201629, -0.6681323947533148, -1.170374987578094, -1.5937436556445839, -1.6477401187575222, -1.5576817986744709, -1.516664076157544, -0.3994481982306436, -1.4985393834583391, -1.2616180992144335, -0.09721729690157871, -0.7397933888118855, 1.0574115973562945, -1.1089197111855336, -1.0265823328021784, -0.9675984478523578, -1.1003493488985927, -0.2654325541374932, -0.6996614978301708},
    {0.30768536342223257, 0.014584817658928537, 0.16255844254213705, 1.0521980082074671, -0.4535600275327367, 0.5144152807190406, 0.7037836426346716, 0.20734564752248727, -0.02251468803069843, 0.7841881303157354, 0.3516020091748897, 0.2568050682631285, 0.07936652037230654, 0.5087845949146874, 0.28002548823534384, 0.623942064896485, 0.12291629709650793, -1.263165142897271, 0.26620524172907517, 0.5782666797109618, 1.2743193716920123, 1.1399102972570159, -0.026543701028921656, 0.6783558999674191, -0.9684024036916007, -0.6831452123739183, 0.6530749070770965, 1.1237514397575532, 0.35901783925390857, 1.3941435784978535, 0.1135012267985973, 0.5681752663597056},
    {0.47045570253556984, 1.041231034421788, 1.3103213570058714, 0.3564043967780706, 0.9504010608818291, 3.223033281143552e-05, -0.32770897335138, 0.4656405175955605, -0.6450549699606594, 1.2382578647636318, 1.3670116531754226, 1.1568453100250369, -0.40262266648959366, 0.7424748478959641, -1.0256285797253895, 0.4998347522384906, 0.07540366146823266, 0.04447610241263177, -0.2326583650160112, 0.6344935511493406, 0.6763603708388916, 0.11587444574245341, 0.12669064661679447, 1.030854617059309, -0.43196221397347223, 0.6280849461905273, -0.10615906795448, 0.9496917194997949, -0.31775306400940445, 0.09239110068235366, -0.9780448894092554, -0.7475372813785511},
    {-0.45694217410963545, 0.36907460038053125, 0.7048081489616849, -1.1049314337615497, -1.6274296816995981, -0.7517050583548555, -0.58649969251236, -1.0547928177265646, -0.2654544326502479, -0.08274639017067693, 0.2649509583901943, -0.6633687838097061, -0.337407442651227, -0.40041420588664356, -0.6265229926115294, -0.4087269757185123, -0.9190998068220682, -0.3211463038234896, -1.101884463877947, -0.8242289304589724, -1.3226900220946305, 0.5949907172258322, 0.13087720303784078, -1.1053196468740658, -0.03983602759577819, -0.1481997250407614, -0.36947072692919053, 0.10624719650930263, -0.16370142189583767, -0.6052845213591258, -0.46044103474706377, -0.6809512380920713},
    {-5.357799551436836, -4.697900538327084, -5.172311512782815, 2.960937630994746, 2.1174682063455146, -5.640345804558207, -4.7468746267875135, -5.249063659735114, -1.7107676319754979, -5.164196837433745, 1.93562175893694, -5.8858498699875685, 2.7789528651898614, -4.889570197167465, 1.127579206939965, -5.136175065354112, -4.885798338096052, -4.760368149710264, -5.5931041887005915, -5.054182396938201, -0.46154048654464486, -5.007883901446012, -5.049806301993427, 3.710210296134249, -5.589048454189421, 3.4541447754955406, -1.8429726312097987, -5.5409254422271, -5.449948822704085, -3.748611879232879, -3.649480927579419, -2.213131681217158},
    {-5.237948188166675, -5.455581524722174, -4.931870645236259, 4.242997106754459, 1.7511029913493636, -5.140140845420277, -4.365741228608167, -5.19447105791276, 0.4608977476526646, -5.653646259221381, 2.5746756651870886, -5.380292848879316, 3.9431394339680432, -4.935661557079699, -0.5203827026502454, -5.684421214976641, -4.3569480096283, -4.529173038126444, -5.115052888592651, -5.207163427059995, -1.7207961158028908, -5.014457804446519, -4.561762486761758, 4.435345948720573, -4.548539936795766, 4.482989385894906, -0.5547931053275226, -5.838645182610607, -4.352670595296051, -2.7174677879085154, -3.5946121842353786, 0.5993036771063275},
    {-1.6586535289764603, 0.2519062644527316, -1.5513224180862994, 2.5532920658983067, 1.6011271790965245, -3.899880555182588, -2.8214741355760857, -3.3676687064082813, -1.7591250066774153, -2.735218659698813, 2.601988909294304, -3.2504807183506244, 1.6632333545079923, -2.0984384820045743, 0.5527909447600297, -3.4687019283720324, -1.6369449890671062, -1.754853120658475, -3.550454206048326, -2.943214689312149, 0.5839079950924874, -2.5285839483746075, -3.362561355110899, 3.054443013760675, -2.494448751351343, 3.1707369067879645, -2.8527927888664677, -2.7098076397206503, -1.2593602142609173, -2.575485346780893, -2.369523554547456, -2.4521639394183268},
    {-0.7777820033940911, -1.817306465450375, -1.7723889771581243, 1.2396017314166083, 1.6520463360607462, -2.8373429708029785, -2.781621110997449, -2.766956504271809, -1.7850837750764026, -2.4251580641201396, 1.4005736377071027, -2.6216886294676995, 1.633907398649124, -1.8562248383333548, 0.6193859993712827, -3.422877022007, -1.6727314358493532, -1.9157159731195041, -2.4687590901555447, -2.247373706856649, 1.0542037958487263, -2.5902257816077294, -2.866465835560786, 1.1630049511459264, -1.9159230590077914, 3.4529195088298934, -2.7837603983967907, -2.1578407441000076, -0.7880345751220199, -2.7112482854207234, -2.3668539416429684, -2.3607803466356856},
    {-0.42796368219372277, -0.7663280627856532, -2.136235499484149, 1.6234179318789022, 2.282912752805115, -2.0316878195784454, -1.6618924492761806, -2.223733169640728, -0.9697594092165706, -3.1882876820266772, 0.7840764854885149, -1.1423984511789422, 1.8958814585262962, -2.3514615660901756, 0.086822219843345, -2.01336577229233, -1.1075382415810202, -1.5819633491317349, -2.0143268758872668, -2.4158549422477273, -0.5625135135493016, -1.9475875552125752, -1.9329722903503912, 1.637807175129725, -2.6858946544986666, 2.879308206675175, -0.9816099290385899, -1.9554777810976227, -1.6413280763921092, -2.032976946525619, -1.2786002391779945, -0.9222630730240591},
    {-3.034982563922579, -2.2022289214487807, 0.4819243403795074, 1.9821552031485883, 2.3363843731407465, -2.7227373658952865, -2.7460856644692186, -2.971603008377685, -1.2859937665358487, -1.5992577566525032, 2.0824510546070996, -2.6848274702057897, 2.750230514338877, -2.9944490414519276, -0.19332774056422325, -3.3008169700584085, -0.31184410896522924, -2.0086951926931826, -3.218248355152516, -2.267699326831967, -0.32186729644253426, -1.6599138129534703, -2.0582617248339363, 0.5431965020193681, -2.682744045039501, 2.7487339248273246, -1.5047188921995565, -2.9496038571101653, -2.07675237332053, -1.60359088031165, -0.665029384428408, -0.6968785522326133},
    {0.0907442525543367, -1.6220839558297295, -1.215992727588482, 2.4676819616801335, 2.0253199077939064, -2.6585638947305736, -1.2031150020148138, -1.6725805480814515, -0.6764316490296097, -3.1196068743635355, 0.33441234797072317, -1.1508292411070482, 0.5912977687255188, -0.027538271658961295, 0.4925819633266788, -1.9428477748799726, -2.283058836739285, -1.8919489557857077, -2.1858529729519742, -1.887510138843634, -1.5153356127843585, -1.5070752018101186, -1.4257062238189864, 1.1614965606743621, -1.2834753357145623, 2.148140608837956, -1.3240324240512957, -2.664668989922602, 0.13152437888422144, -0.694126763271242, -0.5856776904331429, -0.3432088666982833},
    {-0.7384910582743239, -2.1784828453002847, -2.231071444726119, 0.8367530513807181, 2.1199229488784876, -1.8625868954397768, -0.5652042379024442, -2.0905321363827882, -0.2488105754430189, -2.988703269434175, -0.8994943170904458, -2.8201056118809493, 1.671823303236904, -1.609556034555629, -0.3354204565558431, -2.0822314789225906, -2.253952265302045, -1.2056884464372941, -1.6900372943090407, -2.696881510177245, -1.2133319193092127, -0.6708018477324389, -1.501633181262316, 0.02102081824003562, -1.328820863483489, 1.5405065248960326, -0.9515886163533592, -1.9985221636231079, -0.27932596267063503, -1.520827887298421, -0.7095974475771075, 0.9191018367465404},
    {-2.0475470868807233, -1.3937889314953624, -2.2178042724693032, 2.0734801360004407, 1.9295948230593805, -1.6052122326641545, -0.5702840436726787, -2.8755246206376803, 0.39023096233941906, -2.3249588908446803, 0.6599273327650043, -2.868283691967309, 2.601969562930625, -1.4700593744008588, 1.1073469962688633, -2.139952413471161, -3.0947042294919234, -0.7805491101188985, -2.0809088972287078, -1.7576622934967145, 0.35803182366358277, -0.9017340120916054, -0.8197067645064203, 2.7768129047234362, -1.3279701512495137, 2.3745059327332845, 0.3683044149004644, -1.8673146795372642, -0.8395848354009554, -0.4116000168247003, -0.34463074566563257, 1.6830180084939024},
    {-0.5139809737821122, -0.12476721912979576, 0.4324218106985112, -0.9841333188935083, 1.8324769272123664, 0.15509568027577822, 0.9900525819781385, -0.6710383970410645, 0.9382537150851323, -1.3323574897385129, 0.6905957487199952, -0.5771386462133188, 0.1062304317844805, -1.23669788085676, 0.9496292143209292, -0.6859076627276314, 0.15641063578689346, 0.47018941888650073, -0.3964971042940412, 0.4887973835425298, -0.4757805274615138, -0.14936482860954897, 0.5122344791957035, 0.7581486311682878, 0.6346259459337584, 0.5406245925484284, -1.569472699481709, 0.6294555454077506, 0.6914209711401031, -0.3493856262576436, -1.187459824224482, 0.9149341017088463},
    {0.2877476948747223, -1.8157185546918446, -0.9551377745452982, 1.7597650440440695, 1.2447746837843674, -1.4299773321519738, -0.19678077821823317, -1.3758697141784308, 0.457911932863733, -0.6276061089027595, 1.405774849815721, -1.1282537331264928, 1.5319253952323517, -1.1824611893869201, -1.1021042085148067, -0.5522438582953245, 0.09252994241126747, -0.5625895608466106, -0.7400391275325935, -0.5356614136307302, -0.9011746431657742, -1.0550315388287725, -0.9713644714210268, 0.3833014130652921, -1.476831067308497, 1.5430626300215669, -0.9569681070803404, -1.3964987717034807, -1.9369203463655829, -0.12703171374694028, -0.1432262083886672, -0.4837709770913544},
    {0.10024429805795552, 0.4946975734908016, 0.5619354138597283, 1.8746338228326573, 1.341529650502456, -1.6570390301491407, -1.0950061254434078, -0.9493437243656472, -0.6389816167181668, -0.5725120905504906, 2.092345120043045, -0.7971090640859076, 1.9756523866077116, -2.197343335052007, 0.2952796009359107, -2.0444021947922093, -1.0695347732031835, -1.6126326403497853, -0.24031119428251588, -0.9156346886727608, -2.6225791035174453, -0.274843766763318, -1.4649528250009232, 0.9854109948150842, -0.13326803963825465, 1.5126446614236104, 0.294950085037125, -0.7886435280468277, -0.15079552841749944, -0.32114998988584814, 0.5090844277988741, 0.4891005380608003},
    {-1.7146915515065075, -1.6124148599962498, -1.622180729424887, 0.3800869523615853, 0.7577166168694499, -1.8527075587771118, -1.296154443925608, -2.332353081144586, 0.29747036721711867, -2.554142084705361, -1.6187001751497199, -2.705455897579506, 1.9588931294564742, -1.8063999430190723, -1.1211005631250597, -1.8371416436069734, -2.2148247040311038, -1.4854574456750143, -1.9486105805623004, -1.6812704668967975, -1.5960465732679754, -1.1720310556760596, -0.17036147462807802, 0.9088188024980772, -1.275880832926993, 0.9986488840245105, -0.8823063365072494, -2.1772009792552423, -0.4959356490115329, -0.7988672774191674, -1.0906093377998378, -0.10671243210698383},
    {0.0781277411822375, 0.552445079080657, -0.8304494992150979, 0.010185269533043937, -0.6278323089164104, -0.6009513716100495, -0.11638917385098743, -1.7763147743589471, -1.5188949654664314, -0.834193694563581, 1.4872920614884757, -0.7126338234934274, 0.9849985756042606, -0.4210504962819666, -1.7253101255087355, -1.3806043630290135, -1.7774346984531488, -1.4737779050119724, -0.035040890888867963, -2.4571817633485638, 1.8558025051685185, 1.2022919781700663, -1.065321310577379, 0.41549810524659897, -1.6587332467514926, -0.38952736430990403, -0.6277808333278552, -0.19908833366269937, -0.34023670063626826, -1.9260827534590228, -2.8982168311904792, -1.7227923721488918},
    {0.43012469503322176, 0.5920011447388287, -0.7622872033423905, 0.30111555334873147, -0.044043225341129685, -0.9091823555815317, -1.440341442595751, 0.11242012874585566, 0.8141662440063642, 0.3155251965540121, 0.8702548112786809, -0.7288950692436112, -0.05039468830351651, -0.0542350975580422, -0.5210317556007917, 0.651251727395041, 0.2975153683587695, -0.5194087311908949, -1.1955908349698934, -0.31559358560119516, -1.253075689588546, -1.1636999746605903, -0.8612004779157049, -0.8828443488313085, -0.6351386850646698, 0.6076875793320442, -0.37606578493011467, 0.30031427841021135, -0.44779615159838665, 0.3981328299797854, -0.17821767583738923, -1.196276109150386},
    {-0.5343786059649879, -1.499888208577738, -2.76590714242955, 1.7671503579939263, 1.348578549841317, -2.130225657866349, -0.8234971450079052, -2.2439571651279078, 0.9759035273838264, -1.6188354343151425, -0.890507425459905, -2.062614083420756, 1.3910259161953882, -2.099005235411684, 1.7802601482454128, -1.132718330867933, -3.4638559601908923, -1.8248318058772388, -2.0000961486235744, -2.2713413781351703, -1.254760965312675, -1.1653377454266691, -0.9383908315092756, 1.1869707790065656, -2.2218071018369443, 0.8989170752769562, 0.025098700373605568, -1.9633251587583112, -1.0591842842633472, 0.1557081524670398, 0.5365660699038095, 0.8562295897636698},
    {0.5893077247446935, -2.3475153943964875, -1.4176829833065083, 1.7661379009398426, -0.1164783290828237, -1.4430983306104543, -1.975529781980742, -1.3039097827335644, -0.7669456639290404, -1.2392838837134952, 0.17191622225245679, -0.6435395281902889, 2.516660027128325, -1.446016631723159, -2.3624701185613937, -2.299766344966487, -0.9218633359155092, -0.9261358814967036, -0.005035994884924711, -2.05889108375225, 1.4145428876937414, -1.1698045103046597, -1.5206250814039957, 0.3678818278535612, -1.9794629031497357, 2.6642428887623177, -0.5100821720649827, -1.5721968122461156, -1.898074841107168, -0.6369241116140736, -0.6566592818921961, 1.2540191471127893},
    {-1.3738853912565878, -1.3157934015498225, -0.8171497750708253, 1.480216132275862, 0.09687603888956192, -0.7914218211289236, -2.072499806470161, -1.5080354336206834, -0.7483514918187297, -1.0776040368379354, 1.067789819855795, -0.08576815751532699, 0.8159668302183894, -1.0915587461948093, 0.29056346629489616, -1.6488082145403087, -0.43491713545715055, -0.31062559593461675, -0.6880797634279011, -0.3970953058979743, -1.0634900401612832, -2.304722249565001, -1.0548321172678183, -0.03160766644989744, -0.41040860818285085, 0.9016325651058309, -0.42283323498948633, -0.8390170701428319, -1.2846060622123001, 0.446080730428637, -1.1719167960788168, 0.01957523601369723},
    {2.0761839484296525, -0.1580446984193591, -0.5835906696870917, -0.8058824426720848, 0.4265190295700187, -1.0798282927295153, -1.0313476685276894, 0.5156966848269322, -1.5288757226854812, -1.407712141762166, 1.431219096014747, -0.6612097937877139, 0.7525882078240644, -1.0142164148708206, -1.495858984867052, -1.3505116096410654, 0.8756826836306453, 0.12183161624260079, 0.2536748727283041, -0.5370327283028842, 2.054906652531118, 0.9732942851900703, -1.1838662941785902, 0.4559204920756884, -1.7172460835657897, 1.5061064822073311, -1.9833680463256975, -0.15997133588709322, 0.5699777548731987, -1.1987326851668696, -1.6544498983344584, -1.1853761030819112},
    {-2.0928925799472307, -0.4898926176800864, 1.3566997839033768, 0.47497439364661587, -0.742972072160562, -0.593898587496703, -0.5208888945230711, 0.05289233668882556, -1.3230868226040693, 0.9876649891219429, 2.9273855749181052, -0.32137880989878687, 1.464675717102379, -2.4216816445936598, -0.7159526713990947, -0.596355675311333, 0.5267647695335472, -0.17373238291265247, -0.3085666995584092, 0.15251138887502316, 1.299637014563581, -0.41492748568011134, -0.5329494984521389, 0.34805060080803457, -0.3402585294426329, 1.9728546663851902, 0.22174695026025157, -0.24481334937131277, -1.0733650855505241, -1.2869564359747312, -1.7096461944142738, 0.4908089787489688},
    {-1.5736049440186979, -0.7363648601323851, 0.32397537456713754, 0.22089588708623645, -0.5637941848152027, 0.3852920840750428, -1.721011317943543, 0.3286090885622978, -0.3141566816914216, 0.5277658628055214, 2.259337771879789, 0.449579287673246, 0.48725138247453537, -0.8437873520662018, -0.42364285439888927, -0.3463691137151748, 0.9207796874526447, -0.02486268191880417, -0.9669251209982014, 1.002754815643404, 1.4656027211384097, -0.7945426875965939, 0.2600728478328607, 0.6601876995496546, 0.6329284683431897, 1.6285570999668104, 0.18578485037411768, -0.04815545379346176, -1.0300261811012281, -1.1793220761521104, -0.44378785230212797, 0.2378221291402766},
    {-2.3535761823855594, -0.5539488608731161, 1.3582670180086032, 1.5434094936548086, 1.1044071158150397, -0.4484209252300393, 0.6866518805788733, 1.0450666221478417, -0.3867903285510962, 0.718540701259602, 2.0866430852109223, -0.5581871526608841, 1.3499421044667748, -1.0964637018225063, 0.6823865468531287, -0.0020312219132144105, 1.0814400768447745, 0.22400244022236324, -0.08849728527634947, -0.2746148760581002, -0.22836492632531968, 0.23985782651882076, 0.32791275048493396, 0.2707773803479786, -0.018134437400044143, -0.10129929009127762, 0.9006191730563303, -0.7735126937802804, -0.35810421023220773, -0.17351176957452674, -1.1359221357498064, 0.029115923692128145},
    {0.7568308954910616, -0.5018995303481565, -1.1587796092167828, 2.7714981436250103, 1.224933970468446, -0.8225910242676774, -1.4058011895269884, 0.4166559125965679, -0.8133778331319861, -0.34271726452419243, 1.231772021764485, 0.21628881832790778, 2.763906706063033, 0.8289838707666115, 0.2942848113464211, -0.5494482989952527, 0.9617581296407841, -0.4211357911083551, -0.05067914203143942, -0.7712010454423357, 0.25437502080660374, -0.3174716391157986, -0.19331829915807905, 1.403674002449061, -1.16334001307344, 1.863831030652538, 0.34768457653568685, -0.6374334178195632, -0.2846658644132345, 0.5880529801898684, -0.1555098407154549, 0.6192641448203088},
    {-0.12646579571769456, 1.5689636336749075, 0.6073459506310223, 1.1213902598040886, 0.5653653701940747, -0.25087919131862807, -0.12583476763401893, -0.062343427821420924, -0.28851716982849696, 0.2895121692080365, 2.0005316879516424, 0.07529647221521905, 1.2192024996923296, 0.3839495329248746, -1.559196971880113, -0.16997874457867332, 0.8835138281352377, -0.20339844228487303, -0.6203303893947423, 0.03320392035599024, 0.33121770095232683, -0.5235755572613553, -0.3115988821242834, 0.6590881634045247, 0.5025597018833873, 0.7687489658339576, 0.07790725153991603, -0.2507512947632865, 0.015013702839733566, 0.8537563093516681, -0.44459053015423067, 0.5144096108552597},
    {-1.557728243411123, -1.0755797093719348, -0.47929280362333104, 0.895967408757617, 0.6747093895351532, -0.12251398772752463, -0.6366573006796855, -1.3802163611064509, -0.16540421138296302, -0.5612475655122141, -1.0714591330036678, -1.6096787038666198, -1.2638728364651455, -0.04921908396082617, -1.847011599955318, -1.1940881425295566, -1.2788388099459, -1.328028647130732, -0.9059219977928017, -1.3063494972770253, -1.6585893316629905, -0.391707795707223, -1.3084821645345046, 0.8315313038972241, -1.6067955223134254, -0.5200450863978094, 0.030153675009513797, -0.7639500875651506, -0.6715893701276611, -0.44844098255559134, -0.23692465630087134, 0.33892960646031384},
    {-0.5305268167546182, -0.5102623982190366, 0.9801304217556631, -1.1153203338749118, 0.9647418215326601, -0.9799150302247971, -1.1313833055287439, 0.050979821168402856, -0.3303878406243817, 0.1289855518851851, -0.5862098375011036, -0.8804606902366062, 2.4811665436832366, -1.2642278839210266, -1.1309857755392378, -1.9041034353726285, -0.5633072872972991, -0.034506965160135974, -1.0892217950153997, -0.8575106662837844, -0.9737511414456348, -0.3612078996915252, -0.10282863577465097, 1.225482899312906, -0.322280231493805, 1.8046143897183549, 0.01886229931654325, 0.9419731041535991, -0.008484374172191167, 0.19376791461938314, 0.2876611464665139, 1.4726064115529465},
    {-1.5729293078140023, 0.2935040254364765, -0.8659599096370092, 3.835541800295646, 1.6771820033701264, -0.7502529794556713, -1.760978502318564, -1.9482183798834283, -0.5400694964926895, -0.676303981423436, 2.591435490224327, -0.18091006814926516, 2.138678045637302, -1.9244781664924209, -0.7395980814545272, -1.823023398064174, -1.0894373250178422, -2.005881942027187, -1.8384428991825148, -1.323616592849657, -0.768735091596288, -1.6528370503598646, -1.657626166457867, 0.9436805813238208, -1.8945540267697252, 2.041402790150283, 0.07872799769392881, -1.1132792126418047, -1.1918160042547685, 0.1646120585138544, -1.6663465076637825, 1.4063146622043385},
    {-0.7484583273534285, -1.0670440978441322, -0.08029838791480023, 1.024315438976165, -1.8655606767156077, -1.0981066980424068, 0.07841738863075513, -0.980240187938132, -0.7803443803221857, -0.8565840678454864, 0.5594600636010817, -0.01818576863749975, 1.9331523457135364, -0.6567523833403935, -1.586397889886227, 0.06780457208077877, -0.5619305389102821, -1.1050573234325642, -0.8551007125367803, -1.0620902200492748, 0.543596599323293, -1.3624109490042533, -0.28913838235413725, 1.2552360318936064, -0.9843231119281626, 2.076944569625622, 0.988557793055332, -0.004961268073451389, -0.7563206270875633, -0.17273678082399654, 0.5596748277821935, 0.9729865969908936},
    {-1.1052228482540893, -1.0370251218825937, -0.8652787384011612, 2.4051130011923996, 1.555259010555303, -0.19533775801004616, -0.1812223740311215, -0.9062946158874652, 1.6172900663499623, 0.9905483495258596, 1.2357878056371887, 0.3422164236501749, 1.791441067190823, 0.45944630245769075, -0.19095655781444384, 0.5036004774686202, -0.43615016742526275, 0.6030062471802845, -0.5033324873573137, -0.10814188364431729, 0.10965467706321351, -1.7270218403293822, -0.05114384755288518, 1.139181472200601, -0.6700834745040802, 1.956243614540633, 0.9303046091955429, -0.9388787522771758, -0.9154354913671402, 1.2988559260055885, 1.092552447274136, 1.342233159926385},
    {1.2005612186362031, -1.2986944749383222, -1.8031757664082355, 1.490029276552181, 0.8216501949696133, -1.519294200422307, 0.6924898237653792, -1.04225380109655, -0.5774186589890167, -1.7271880489924056, 1.8569161035181099, -0.6967007426983892, 1.6345817874365747, -0.7287773083781722, 1.477244782811468, -1.8602024577689211, -0.8631061370351966, -0.9008096323344157, -0.4721932354700497, -1.702631952057486, -0.39970313010704567, -0.6511510694635836, -0.4746957635629813, 1.6427776195207486, -0.2518154744139367, 0.9971620107792513, 0.4943403838951022, -2.1057053948549966, -1.2608811979534527, 1.077361184723786, -0.03253010559438353, 1.1093732735119104}
};

static const float b1[32] = {8.159961394060321, 8.055050997045925, 8.226755649977814, 8.725140226759523, 8.10234095567265, 8.143266188036737, 8.185159540192636, 8.25465761685449, 8.527766998783676, 8.172420160301172, 8.618311630778361, 8.22591291067273, 8.720810305824044, 8.113340756160065, 8.302312760247686, 8.205862935128499, 8.240635848334229, 8.332844568723662, 8.10968700359765, 8.227669718650933, 8.202005629989172, 8.153325846569313, 8.223570099871454, 8.713068886504534, 8.188984569000946, 8.61368216352865, 8.688174419044392, 8.19888451247502, 8.264907701069058, 8.256379710366625, 8.425723817935438, 8.793120192335397};

static const float w2[32][16] = {
    {6.866717603841699, 6.974752175692103, 6.898729810829665, 6.939396555498954, 7.052943484970977, 6.75317428794369, 7.254139106556992, 7.207451358089807, 7.32021889143924, 7.2602894803801705, 6.889013087236111, 7.274525754663493, 6.474782168117487, 7.3327658362372645, 6.366750188555483, 7.083539206118625},
    {6.737688741250254, 7.1872348303444005, 7.16487004266874, 6.501182957373744, 6.774665764012938, 6.941471096720116, 7.06595431043927, 7.593279960191318, 7.072323407125067, 7.072371825938873, 6.999044913812904, 7.217713068815168, 7.011815204767711, 6.649387514827057, 6.511919722280848, 7.159826070765499},
    {6.664118623833229, 7.125273729725753, 7.121341713040031, 7.1251725595954225, 6.956186421050397, 6.869574038083293, 7.105629778837855, 7.299335586922716, 6.991624063808899, 7.090505554273827, 6.703752412091948, 6.756489823321152, 7.075842900957503, 7.366935890812645, 7.0122664772571355, 6.914605162053993},
    {7.015613092638622, 7.6510155221396845, 7.343128447409784, 7.495367775894878, 6.946455691619821, 7.368267329672104, 7.503318902974377, 8.02825921289042, 7.370316220096016, 7.728790279044373, 8.063359248270078, 7.54377461767274, 7.7124487644749555, 7.466416116623112, 6.699079400979161, 7.066080289442915},
    {7.4498725585749686, 7.294996970787817, 7.705064048586843, 7.544162766831388, 7.570000314987631, 7.512775710219446, 7.289039450090911, 7.239373141473632, 7.657111473909811, 7.095997776539825, 7.6981179429701765, 7.041200413050283, 7.9082511988285455, 7.8134237454198665, 7.456311163396659, 7.981369997431486},
    {6.750946580133477, 6.821011494110291, 6.722385167241267, 6.995593594867945, 6.910773764084312, 6.978717900442692, 7.090529522451341, 6.686768801470541, 6.905464490149229, 7.3606477943373445, 7.2432170827546285, 7.1025915124402745, 6.524403983843586, 6.8387008943363155, 6.764345639178508, 7.262096485757124},
    {6.9374789556111995, 7.174326436851939, 7.161737530153281, 7.094537839851193, 7.585010178222234, 7.061789057586649, 7.234673489550326, 7.255452079356024, 7.006114658720617, 7.160183826253861, 7.377161992318514, 7.385445906132255, 6.874728767962535, 6.880297754442281, 6.524773129054137, 7.557288253131326},
    {6.757335904554361, 7.260900277127317, 6.700488792070109, 6.821907690702857, 7.16584237736913, 6.862498946689556, 7.0785204943412685, 7.419232279586548, 7.110314027547302, 7.146976761942855, 6.8620242962335976, 7.037915147295064, 6.654275097434973, 6.704232957541215, 6.519138438745192, 6.843764176292557},
    {7.6365170679804155, 7.6368912207596775, 7.853894307176701, 7.302961404268962, 7.6191540564704505, 7.991171529887007, 7.351977145855233, 7.8528547709190715, 7.599509818444849, 7.98601603320674, 7.788355261747732, 7.97546546241683, 7.352068123679904, 7.809965740625045, 7.744647939618954, 7.639034090643815},
    {6.692275412569335, 7.0817035295087845, 7.110659866371264, 6.702518152617632, 7.3161524370800475, 6.973818249696141, 7.149193592357745, 7.245247701062851, 7.079901489948745, 7.28011654010112, 7.241917636789211, 6.847487346583679, 6.635808223854062, 7.405066201924957, 6.572301012289296, 6.720451885449672},
    {7.169965463925028, 7.413329997018952, 7.646142699672284, 7.646609790579643, 6.902671165602037, 7.122047039452087, 7.40249315813822, 7.180376700577095, 7.531198525073102, 7.653679054165028, 7.506009074220795, 7.392723569184714, 7.360407769444553, 6.986023783040092, 6.929879270967984, 7.132481722325221},
    {6.621445209626742, 6.930247460199272, 6.9976177860032465, 6.999528449867732, 7.469057728323924, 7.417652773722442, 7.214140377061707, 7.232920088598069, 7.30278387022868, 7.229924252209474, 6.734190225264363, 6.735115668296466, 6.786113501496946, 7.421028902448156, 6.891284648860438, 6.148072806034833},
    {7.3437107917074655, 7.998666502688186, 7.273423049795106, 8.13359521635094, 8.456005980088362, 8.069525664145841, 7.781216166138357, 7.6421285984179015, 7.957087699613863, 7.584313227072876, 7.976619039163494, 7.593231277814498, 7.732606381962654, 8.134207599086231, 7.787693861909794, 8.291385619424506},
    {6.529205498195845, 7.077935511902551, 7.470197222044089, 7.22878794474074, 6.891393574605919, 7.103484175373597, 7.116603330765734, 7.700751317376784, 7.096268731114783, 7.323825442692511, 7.1112501037279054, 7.1198634779051, 6.757806612965608, 7.282427734609248, 6.758358717634508, 7.666518927087715},
    {6.753193952481618, 7.970412247515419, 8.153816509188406, 7.5881297327513915, 7.958396172967282, 7.451377389472961, 7.489796627347191, 7.4743440044560225, 7.29652830689343, 7.514220803041041, 7.24749677766594, 7.256350582287377, 7.840229623116446, 7.544088388743912, 6.968122282154158, 7.6572548498726585},
    {6.522994148343223, 6.9987162270693775, 7.309196455548652, 7.253824958159929, 7.015364347261077, 6.830461549576219, 7.072340236601054, 6.914392702283432, 7.100298567468439, 6.6913833710176585, 7.510214256320038, 7.119074608858482, 6.968172412175491, 6.966838151134275, 6.774042706708771, 6.427287544217009},
    {5.985831133368044, 7.23558765810443, 6.870161431370469, 6.906278394266589, 7.161969105380647, 6.746769999621423, 7.009589917120311, 7.231896878561028, 6.800241184525339, 6.847754905300025, 7.277981836439403, 6.6545018530710855, 6.742324762926995, 7.230505595351755, 6.636325655266702, 6.858661862442438},
    {6.642850735091452, 6.8146026890134825, 7.284120504014216, 7.105872893708616, 6.906529510267306, 7.129829499220299, 7.338129134855717, 7.016480034068797, 6.9676603587982715, 7.032140066152896, 7.4075554305907865, 6.593498546767869, 6.826654905249976, 6.484258407526497, 6.726197909381494, 6.69234186093313},
    {6.394918865578776, 7.428625737916433, 6.774592795323057, 7.247704758672749, 6.632722277752657, 6.9009953301780325, 6.939171528066018, 7.029537844939253, 7.300310520697578, 7.134713028330483, 7.004284047306946, 7.146730703874513, 7.008705074851931, 7.543195650741122, 6.808623543120327, 6.971458524577488},
    {6.558598889721777, 6.879548814935257, 6.815021537466584, 7.180879284478691, 7.047520527599263, 6.939674388897442, 7.064483559790368, 6.997138142441167, 7.630678542288533, 7.263956661357367, 7.193172034493783, 7.141253904373093, 7.031225938489986, 7.057328611680414, 6.635131661902236, 7.419819477610524},
    {6.6238210413550025, 7.241139404907727, 7.220919887465222, 6.922398873195351, 6.672851348429601, 7.317108448934088, 6.5615498174112945, 7.237932921586826, 7.384256852044566, 7.062775548842216, 6.554211683689416, 7.077472206673771, 7.126577236801575, 7.0677941179997275, 6.616578026587022, 7.1726768589401875},
    {6.1394173712303886, 6.823842158589782, 7.225736673221698, 7.100395037357763, 6.966674498277319, 7.110720532153757, 6.8118701000591395, 7.289891594933859, 7.096605185270419, 7.311767761466777, 7.357685611085628, 6.911072092610245, 7.003490688550234, 6.624137830112017, 6.468553261348858, 6.841948393637822},
    {6.96678285995507, 7.676822745405988, 7.377470622886349, 6.720167540024702, 7.272522514239755, 7.224129320667549, 6.619479822595625, 6.923859122593624, 7.274741174456779, 7.5706243107818985, 7.186136051857582, 6.817586582309357, 6.6452022641363016, 6.99460406520205, 6.369825477627642, 7.01767018340288},
    {7.68553059662717, 7.868709756542624, 7.540773521509115, 7.8879675796073645, 7.811929376792294, 8.398668168933726, 7.839109145532417, 7.945014064390424, 7.686422985450351, 7.660075322945525, 8.232401496163284, 8.094623765787716, 7.521142512419914, 7.94259599039086, 7.585762292736914, 7.358182840970707},
    {6.760181630346355, 7.149025546694245, 6.762901206812588, 7.143223939864658, 7.195506171069058, 7.152613070057697, 7.374438757617497, 7.561719363177736, 6.918662194364561, 7.139104729666418, 7.011972036990555, 7.067482129501544, 6.998127274316824, 7.531916720179777, 6.300689987584362, 7.201407782220286},
    {7.376908034760233, 7.474149848619309, 8.0650405411641, 7.86955466233776, 7.610518962610142, 7.738827258472982, 7.284221373113478, 8.112183145204554, 7.5054716471320795, 7.669317249573522, 7.666464437881958, 7.659871725760647, 7.506088033265907, 7.444179990212374, 7.1297793368270765, 7.125637505476908},
    {7.614014209382313, 7.563132805500939, 7.296951694339185, 8.091952588961679, 7.958058026570895, 8.024326742873043, 7.854768338469904, 7.592195918707307, 7.696741331515042, 7.992329856458749, 7.915316921323375, 8.07994343420673, 7.933548069099144, 8.32969862199666, 7.974920057286309, 8.061980686296577},
    {6.370638170666678, 7.271836831493348, 6.812076616225213, 6.852995041174627, 6.501717633946055, 6.869629138024392, 6.997312195220901, 7.061486723114562, 6.984530465921068, 6.65110866611944, 7.014942487818704, 7.253505887953877, 7.175791269277522, 6.864950318334967, 6.615429917278426, 6.431519081603412},
    {6.341575489466362, 7.450747950854529, 6.833181779828091, 7.003939370425935, 6.804365604878281, 6.955016152032911, 6.801209644671578, 7.078519738770022, 6.646626561883358, 7.405407427763397, 6.806294246614859, 6.808516128075514, 6.615551616422366, 7.284644946672636, 6.7691701860122055, 6.643562787372169},
    {7.276358866749165, 7.73046110900692, 7.760601684011073, 6.9447853398771455, 7.594229967429974, 7.552500526231264, 7.121937794917984, 7.562079997579274, 7.5766414866686995, 7.733221194413181, 7.5271194974872655, 7.379450144379995, 7.7427531409116925, 6.8452892373866145, 7.156095719627266, 7.193426859459456},
    {7.201189126100831, 7.821013626464167, 7.721450350856156, 7.9340342362263225, 7.749710887239281, 7.038835812073983, 7.120094900045539, 7.832861815933854, 7.6568923907515085, 7.630930532542121, 7.673288180875112, 7.4321961849868154, 7.570202202571828, 7.738827518299009, 7.066732748363391, 7.515183277706373},
    {7.108693296054375, 7.921327245609383, 7.415726002049231, 7.4979003206414685, 8.110391316762428, 8.127133477777035, 7.8344801110786975, 8.109004969634617, 7.890229671867168, 8.2684294454519, 8.37797045555014, 8.0484390419326, 7.740643640968461, 8.032759562278182, 7.458722487337195, 8.001135270176462}
};

static const float b2[16] = {7.454987397851849, 7.159565707549568, 7.0627685648316305, 6.789648027573087, 7.221106918967048, 6.952443510697899, 7.122099816234008, 7.071287378618448, 7.132311528131384, 7.215275788303423, 7.132021768227407, 7.248853786655422, 7.255033717649148, 7.25295379751588, 7.3177249901782195, 7.290631666552929};

static const float w3[16][12] = {
    {-4.689477701249763, -4.309970399741312, -4.591826973189604, -5.104569858459464, -4.533341818059399, -4.731415992374695, -4.5905218612776215, -4.1725696770238665, -5.003273014739721, -5.1316986203207025, -3.8836677048701818, -4.9622526586627105},
    {-5.225065169130165, -5.020475104780874, -5.503360961679505, -4.665183318212007, -5.437092505552598, -4.134241413809035, -4.945195363552928, -4.327309442984285, -4.869095450935622, -4.599042121446188, -4.682921823847333, -4.8688596869987695},
    {-5.108616149467396, -4.636796374747538, -5.498962292658935, -5.146707083688872, -5.658672834105364, -5.1292064152838535, -5.392213842645862, -5.568710692137706, -4.860119646914198, -4.919190321109575, -5.071801682589883, -4.456498796682848},
    {-5.335763272744981, -5.11167739905462, -5.0601780852087455, -5.253185992011724, -5.038107090430976, -5.244285894638898, -4.99182711835021, -5.121219530227723, -5.591316699319673, -4.968231225475498, -4.714304309110473, -4.433629352217216},
    {-5.252832943979187, -4.701232125952142, -4.703330231646066, -4.433598119069841, -4.166955203030453, -4.812851016468883, -5.008591914871367, -5.222910696139306, -5.0953462476953275, -5.45763119670666, -4.858373634518498, -4.574746198890223},
    {-4.700015937722441, -4.75401222526285, -5.301644921324487, -5.338918879084042, -4.98680591451143, -4.648531909534563, -4.922547904498149, -6.263605956386675, -4.458910082420805, -5.683203666564191, -4.967316568602711, -4.805073437971353},
    {-5.075782223724682, -5.480043548639159, -5.019345967235029, -4.457809776108775, -3.8984197389020627, -5.3737998031074055, -3.9604058505197384, -4.595470955364429, -4.529372483463401, -5.322111395987987, -5.05469097602741, -5.224969082419235},
    {-4.73733293300423, -4.829798170621411, -4.96871570089116, -4.55572444466228, -5.463067320014735, -4.75146429937218, -4.822901054922581, -5.131190678904904, -4.690356131937348, -5.2377715509724245, -4.930047617117802, -5.232263286409084},
    {-4.576497974831884, -5.175414847004104, -5.580998643284971, -4.897485490575633, -4.820744874113739, -4.786526018653927, -4.982622348094902, -4.784501125455044, -4.984888945053616, -5.121040402397234, -4.978282377552299, -4.765881567333893},
    {-4.648898106116641, -4.662677642990112, -5.012581990927149, -4.873550658364506, -5.053193774407712, -4.989580865270953, -4.933583662937478, -5.020770080414726, -5.3299687575157595, -4.349520702201891, -5.240414106539021, -4.906247478020978},
    {-4.865549025776388, -4.977646767526494, -4.94136994574538, -4.890327205378948, -5.156040342025156, -4.696987298412915, -5.062985437931404, -4.61244253857664, -4.798154656198462, -5.139573045460677, -4.799255667529818, -4.969181408886455},
    {-4.532682932023529, -5.130847284846325, -4.007990952874619, -4.772428424011194, -4.376523631702722, -5.258546214931691, -5.375784193645613, -4.797617113950993, -4.160308072209005, -4.500488558461256, -5.548302906865084, -5.281201151114024},
    {-4.878279027898075, -4.50151886851661, -5.195789383864175, -5.505100813881223, -4.569066880827076, -5.164082790484323, -5.18756472610061, -3.886912712854976, -5.4097741071843926, -4.60611086975199, -4.729194356067744, -4.577118988276617},
    {-5.006362637188073, -5.277359317434814, -3.9435250969500024, -4.581696673488199, -4.6543274730931685, -4.64061784071223, -5.060628055653266, -4.662821375648505, -4.700706422866965, -4.46570058657515, -4.937266779664597, -4.899928786174316},
    {-4.674408995357838, -4.490001604835451, -4.49207110056518, -4.309875159318762, -5.267955333024714, -4.241863597790179, -4.009819987676255, -4.590402556576851, -4.414840977266381, -4.164419944664191, -4.249202091220689, -4.8540213765643},
    {-4.624802512949258, -4.802934619138956, -4.080639099634168, -5.09026343946139, -4.759698747423407, -5.2451354967427, -4.634314403493672, -5.119125150724746, -5.026838464558302, -4.148617852043439, -5.051958706693896, -5.102101611781283}
};

static const float b3[12] = {-3.007236112561705, -2.2968151727463444, -2.355735865976211, -2.3811034931915978, -3.5678208471382273, -3.2365318941045667, -2.860158929920903, -2.7008957785362306, -2.8403264761053126, -3.1333327651939373, -1.5412730740617964, -3.2153316570303203};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
