#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.025438701747110486, -2.9534105474818046, 1.4270916207953621, -2.4199944175934043, -5.306951027119453, 0.8412863477868598, 1.4135428117682909, -4.30732748519893, -6.472447847954085, -0.17760212309513088, 0.12350146867425145, 1.8789838765736193, 0.5593928140430071, 1.477104347221763, -3.9908657755395476, -0.9068716679138753},
    {-0.05059205032279081, 0.27071718484235285, 0.13131250583298065, 1.7244173716063789, 3.618300930949381, -2.49848222212603, -1.390483273326577, 3.5538846044361776, 1.7789764748904513, 0.5377518153492337, -0.5484939008461887, -0.46620496434949377, 2.9013260843463953, -0.047691026469430235, 3.281039367101811, 0.1162527977217709},
    {1.0776772874419083, 1.1112148902354273, -0.845760506169775, -1.293872467765559, 1.1639114804108592, 2.267876724059943, 0.05399793062414691, -1.2802638412348504, 1.5207660754436372, -3.525695081674678, -0.8412346458430436, 0.03839074869138349, 2.199980577839856, -0.4793760427765494, -0.6399050215777359, 0.23926693087824727},
    {0.5997635485080894, 0.5087945299704304, 0.2972856226942651, -1.7169734413454878, -0.08864506223852905, 1.6229369165986571, 0.7882255931491976, -3.0534432355799987, 2.1833349302039293, -0.27767651062317383, 0.09100999427122687, -2.5370153760914236, 3.1093745305151335, 2.8607414679563448, -1.3142760756400647, -0.16973900635258116},
    {0.5648749390945945, 4.004187392072723, 1.0825721271469855, 2.2805249932718126, 2.8164562142158767, 1.6790165903591758, 1.7193230571210807, -1.5326042515055085, 4.758788561688355, 1.0638417545753727, 1.5941334810995833, 0.7139219962356755, 0.028892178293565586, 0.4288871449568164, -0.2789683430908802, 2.954437783942219},
    {-0.18055209535932534, 4.404445908269294, 1.515198511041457, -0.6195115591742135, 0.5909697945796575, 3.6454087234217547, 0.3348066918170464, -0.08062817893976591, 1.935397858608309, -0.22397997855297938, 5.4936067540626645, -2.0750808723481717, 1.0208027682005443, -2.6278168172530396, -1.0034889669171418, -0.294325087394647},
    {-0.8327882401389373, 4.579527966111919, 0.6088421046671524, -0.5945828607501654, 1.5752610311055404, 2.9044691193428993, -0.8666951669582039, -1.0358307744165571, 1.5547511116382735, -1.2817233684346814, 3.494814888491167, -1.8758580390325827, 3.4898703794510895, -2.2219271886076655, -1.2360363355120347, 3.0993532645737654},
    {1.5392712559150459, 2.1329415531227185, 0.6945816794673526, -0.18233360224175435, 0.40252153440851624, 2.1080985138349755, -2.391337233851136, 0.07179986084254737, 1.9788321854503637, -4.063422533158769, 1.7145851472517453, -0.032868204934233244, 3.121283919927774, -0.9629818264399616, 2.5172243862744526, 1.8173010462226413},
    {-0.15165105110141922, 0.36116844572386747, 4.326934159657494, 2.382310446144077, 4.767229682939935, -0.29432722107751386, -4.560993685836938, 1.3590610922500272, -1.492051321421308, 0.2517152650289587, 1.4674961348325446, -0.11300636626274495, 2.525977395514159, 0.6877858414978975, 2.5592827281207406, -0.5679258226227824},
    {-1.7460760595602227, 0.7557817044798307, -1.0621056329912377, 0.2742521006180525, 3.1826269521447053, -1.4662051522828807, -4.358805944172131, 2.580449440399296, 5.143620218263201, 2.6902345408924573, -1.8433620925022551, -0.4846273805938597, 1.6938677035555136, 2.573623989564069, 0.32719512003799145, 1.3471855166006634},
    {-2.7430020296617723, 0.836477190113014, -2.4738731126673428, -0.14753786078889053, 0.9365638942758593, -0.943986001877358, -3.4271575033227872, 1.2872343979588112, 0.6127811076244464, 1.2036008819677855, -0.053503576445814785, -1.3377404950783605, -0.7090941898833802, -5.0876345035537565, -1.3656910799738857, -1.9399347789720462},
    {-0.8242953017661528, -2.282117158171591, 1.3462130156454277, 1.0128758346904878, -0.0446749881497517, 0.7388415287830771, 0.9676072242816314, -1.3481163872910156, 2.3548628685016615, 0.8282712526086606, -1.4032319129087099, 1.6784467631864033, 1.4550577172782377, 3.064451019403056, 2.238869986560356, -0.846040795879879},
    {0.4867499231464079, 0.40152043110404295, -2.6119029296737453, -0.0003665693779614233, -0.04570560640551085, -2.377265029572701, -1.9073413817170486, 2.2492737500786992, 1.0778156526484852, -1.5719155171432673, 1.602826568965034, 0.6139995977036226, -0.42289077949104337, -0.9779864050796153, -0.7994654604187061, 0.3866680275611497},
    {-0.6848228067262563, -1.464026195088111, 1.313998943716223, -0.3674291808447134, 1.4439130979880765, 0.26835984177830485, -0.6676366617955329, -1.5204672670452053, 0.43750416382305674, 0.962970477940444, 1.5186978815267531, -4.0716616202268066, 0.7445620155553382, -3.0399863137936354, -0.2330784846931837, 3.116750246528719},
    {0.7402950796606009, -0.4892073829475286, 2.214222426142672, -1.6150275001375247, 1.553468624821484, 2.4812172161602355, -0.08357143315732207, -2.6420644816141996, -4.232756869652056, -0.37445562295077145, 4.726791500512658, -1.6286157293297228, -0.25938902874930925, -3.7174295068225756, -0.09494958052387023, 0.7230523641951775},
    {2.0106121541955537, 1.1037999213875318, 4.31971248924725, 2.8533965611295233, 1.8918964335476542, -0.48646219368288407, 1.7351649215783327, 0.8939164319883481, -4.908146887937251, -1.990233553725698, 0.6767933191396202, -0.8171716361952496, 0.5296598057175262, 0.04852864794339758, 0.28957846150321276, 0.7358567848324031},
    {0.8934216992340919, -0.11718393621762498, 2.178344400429276, 0.9273820989928409, 3.7041423829758346, 3.224763633475557, -2.992731297004946, 1.259551253015729, 0.9373024834163447, 2.9039864912572866, 3.5384797339533085, -3.2845232621228466, 2.4280586879653634, -0.9120494371377342, 1.257032324754615, 2.523943043461711},
    {0.00915194798234704, -1.0315286557839445, 1.8189118805430364, 1.524823542822937, 0.5950077450538045, 3.4346350196779163, 1.2494365205087086, -0.7024490869265498, -1.8712778197103332, 2.1080155995450527, 3.0677864601859253, 0.6489299234982098, 2.3019625604698706, -3.708323248064547, 0.2655721202628639, 3.031737205466959},
    {-0.8907551417971135, -1.0670269445363632, 4.190410923285314, -1.7092835602391896, -0.41465525811668963, 0.23854276878080083, 0.9583267970545432, -0.4978290147566142, -0.2637287027031963, -0.28787966235765156, 1.8196535419573772, 1.578426075172893, 3.890703094800659, -2.253796557798657, 1.8944559006683257, 0.8538385546617949},
    {-2.176633368705898, -1.3856359575808896, -3.62033073934188, -0.7716433045598743, -1.7220452470108067, 0.8504543595601465, -2.6431300274659075, 0.210404572276619, 0.27459101425836746, 1.7988095529876302, 0.32482049530783835, 0.4865518473505603, -1.2997080804335268, -0.7139539094153774, -2.6056282725758853, -0.7390793581969767},
    {2.921553846473034, -2.036628942798974, 2.3041635977966535, 0.9659205227744039, -2.1683817230221143, 3.367527648152091, 2.148618121723094, -1.4487297245294186, -2.3351322084273662, 0.8439769216524189, -4.452526570369782, 1.609131339199482, -0.28040240429246205, 1.6554808622652246, -1.7678222436758357, -0.7163032708246713},
    {-1.153595969862048, -1.6169049911939368, 1.0274023633134968, -2.1679734456296047, -0.9654480571832934, 1.3982369949242879, 3.286881160197214, -0.1813912619768563, -1.318864576171712, 1.9030409792319616, -2.335921780363089, -5.681227068301908, 1.9431332370730126, -2.7283408289535793, -3.674514072701576, 1.848377638786713},
    {1.7631875185610604, -1.2353948345374737, -0.21398778981999356, 0.6869105637976396, -0.6692472749706154, 0.011864919110121287, 1.1819957213018373, 0.6048698229182505, -0.9574119725216576, 0.17483009998909652, 0.09557084058959536, -0.45863769023378215, 0.6466052892478453, -0.567200289851186, -1.3773373291973992, 0.26998463748849405},
    {-1.0821843046924062, 1.1556770380796806, -2.8401881330041934, -2.9735620170205825, -1.0424729453680395, 0.3515396424740013, 0.7997208583232549, 2.8983759922504513, 1.3954248578743056, 0.4641735551824448, -2.977314112163685, -2.4791973295006313, -1.154575905854676, -1.3731942766881249, -1.0285218376358172, 0.9915158427960896},
    {-2.707046195385999, -0.2621020685577684, -3.05740022110504, -0.7387173560982597, -0.5847258110757431, 2.27671879763479, 0.4820595718205356, -0.46024382227549554, 2.7935289002418378, 3.3276864805419177, -1.2213815661216698, -1.2878916931619886, 3.3192282617274396, 0.3545719210440923, -2.333852276001289, 2.998092026758376},
    {-3.0490174214224197, -1.7239978198116077, -0.9316341164752501, -3.611038787725338, -1.712557182715729, 1.840924133031976, -3.8730928704252023, -1.0059705836428194, 0.8966859406104116, -1.8922626467816506, -2.6390309001020906, 0.049878453414242546, 4.004329504178434, 1.9563619170712805, -3.927467367335511, -2.0198228945316767},
    {-1.0483895766133666, -4.579952383678312, -1.548994248163381, -1.1159213104387402, -2.3217145517140665, -1.295572910480881, -0.37126630661600113, 0.750633712403027, -2.116825286384439, 1.311620544495941, -4.287533974620314, -3.6965828626429587, -2.042343426543506, 0.09805826921880463, -4.605045321145465, -0.7321640311440133},
    {-2.3223817306483237, 0.27698006489999705, -2.5218373136571643, 1.4537381085754466, -0.9951685017502484, -2.253946040271913, -0.3401502434289536, 0.23674841840650096, 0.9907790234469018, 0.04645991816973478, -0.16046203905283185, -0.5580610022175132, -1.4312131275728024, -2.0344298742870737, -2.310781073921047, 1.8264730766736657},
    {-0.9783587741961556, -0.7801134454425371, 0.6850023549079898, -1.5019041304771164, 0.7468352892463501, 0.3586904521860281, -0.1940132444002697, -1.2788479680823708, 2.656196147267507, -0.552744256272217, -0.5058707929196656, -2.6167989318975535, 1.399586635449928, -2.841740136839891, 0.2529259120082547, 4.1980840977840135},
    {0.1016211286155216, -0.7824231431659504, 1.155918801724904, 0.17659063506018527, 0.8096765020168633, -0.1731044678148487, -1.8185834571128456, 0.25087665976006734, 1.2805346800508317, 0.7045123322425054, 1.0513438665207075, -0.36267941573350315, -1.6264441506146468, 1.3312395630996665, 2.202384587880751, 3.423878964922355},
    {-0.3872917075669107, -1.7264645838692643, 0.10134480098898262, -5.42483011763379, -3.865427372902783, 1.0846466658011813, -5.398561555723229, -5.372459152514728, -2.9612581208740023, 1.639692533467496, -1.641278030410641, 0.6105732491002965, -0.2835227597018475, 0.7272488054491292, -4.610569537002735, 1.5726950397237969},
    {-1.5973390456964949, -3.175645116906295, -0.7963832881252986, -3.5867136455969395, -0.9914309930882668, 1.0472209548385576, -4.089657108899943, -1.6695812851038965, -5.079030251628464, 0.7381388383465378, -1.0658823072227352, 0.07867797860430685, 1.324791800701319, 0.056431632395261555, -2.8018080481957885, -0.6845653580438144},
    {-3.043612618565538, -0.8532273877604578, -2.49054384123516, -2.6101416764976983, -1.0951948075859834, -0.5337018005490942, -2.565017210004918, -1.043673333818256, -0.6987905983122119, 2.0290438350265516, -0.143594364208255, 2.346963554071831, 0.7843488058468825, -0.4603641268939709, -0.4999019671922743, -1.315781635505596},
    {-1.255897234467028, -0.8046373478896738, -1.4912938949187469, -0.9332197164072946, -1.1529544092768294, 2.4499592157441765, -0.13369037367147638, -1.3438390163847336, 0.67109340654302, 1.7605386213621834, -1.4803792903111488, 1.4857178210245905, 0.5475794747416993, 0.7029205532242898, -1.0697015568347092, 0.7346755145080267},
    {1.0374602452089943, -0.17089514909635778, 0.7593801298403905, -2.728786891033622, -0.8998233394817816, 1.8056021486209768, -0.6328438599501596, -3.412540271219188, 0.5025294021101112, -0.8675812305485004, -1.8300359546604505, 2.983703796113157, 0.9461050326267966, 1.3951935145279835, -3.1709699189757887, 0.6815436179163055},
    {-0.9848593989145097, -1.6569842937519612, -3.078697108783782, -3.3307542353305966, -0.7449571936585968, 2.075165175464232, -3.8032666384714546, -4.5085876371046805, 1.303331190196931, -2.0502642743480495, -0.4184652691809275, 1.4327558352081922, 1.785216379789452, -0.9123451829568828, -4.263920450270776, 0.6822212604996819},
    {-0.5005944230131479, -1.1499404137580302, 1.3473120958033813, -1.391285822312749, 1.156544896582604, 2.6246508717754224, -3.2940630452088393, -3.850494654367195, 0.48892036652559695, -0.620382144473313, 2.2791146810038336, -0.5916531807869357, 1.2733172511642548, 3.6163644372215518, 0.7501404991380036, 2.6475612269102924},
    {-0.9824208435410454, 0.35204261892396416, -2.6611483336605697, -0.3339040162473989, -0.3647985255231336, 2.5691568007177583, -0.1200683149331269, -0.8224769814340905, 1.156199082345898, -0.7704040411252461, 0.022984714750458882, 1.0989463799103676, 1.743371213305977, -0.6079249678585555, -2.140261079051428, 1.2336525840901071},
    {-1.4066428792290693, -0.1382944549809924, -1.612089319887336, -0.5597812515173851, 0.17159048627155563, -2.170089997636748, -3.4637594957036177, -0.02881450356532496, 0.10507256492400906, -0.10430308351559256, 0.4339921008572968, 0.40180214829007865, 1.8592404864715486, -1.547401818061068, -2.948654762677297, -0.1997914993484695},
    {-0.4144273310785218, -0.8008956087962378, -2.844661462300438, -1.9197304206339352, -0.6490878264424395, -0.7912382448152133, 0.5576720671464933, -2.6292327692721775, 0.9091380929154498, 0.08327219041979436, 0.13322281029914468, 1.3096642623917971, 1.6291194596206853, 1.8343676146722143, -0.31809648779470284, 0.5501040323757598},
    {-1.05111430197702, -0.8806286477630682, -2.170735646894245, 1.2161117692130878, 0.878414519053905, 1.7719032938151353, -0.7669438816280485, 0.6492028727667787, 2.197746945004899, 3.4313816394642815, 0.9090578499299471, 2.4330362734280815, 1.558926537337019, 1.9310673445980966, -1.9341487657453544, -0.07389069897910092},
    {-2.3400927803174945, -3.06427358045288, -0.6790051915529699, 0.6306785418457914, 1.183969852869222, 0.18877699648746177, -0.9126985485811786, -1.8566129246696936, 0.33980199281262496, 2.7156222543518, -2.5998878105317527, 2.6339459712479125, 2.7677402530615174, 0.8643755249199871, -2.443968350482825, 0.7045502856783369},
    {1.2007536346967707, 0.5843989007513885, 1.0282225259809754, 0.6270527820382836, 1.1370553801614256, 1.6421169498659227, 0.08807687591497837, 0.179883070704491, 0.0896924928698934, -0.5098028367299182, 2.223693502754853, -1.994648127688637, 0.3079015687490764, 2.6553001131085696, 2.670250509603467, -0.40495840550774553},
    {0.1430822308514526, -1.7259646921471226, 1.5143688265374415, 0.3808786027831151, 1.9024035287819092, -1.593982707042134, 1.505317766500777, -0.9171582136700615, -3.0918279568378226, 0.13204552977158046, -1.813723326471562, -0.38538657216890615, 1.950979084883493, 0.9187905967061565, 0.49891660163636964, -0.5988218067255386},
    {0.06202232489878124, 1.9744155365204954, 2.2484013330457437, -0.739896126289732, 0.8949636961611462, 0.725587542716814, 2.721083125831188, 2.109679456897244, -1.1551513819238441, 1.0858909488913022, -0.4624481288116427, 0.8279444962609188, 2.1919635869824896, 0.020129948228002778, -0.1630913148556768, -0.9113442207863953},
    {-1.114900557301534, 0.4837147723309914, -0.5276355952962535, 2.1257507669915823, 2.428931037610302, 1.034368454504192, 1.8545747790476668, 0.17441468912218527, 1.7100091014070844, -0.12259274881547078, 2.1606608632155297, -1.1271804502654508, 2.2231095943906767, -0.21395239382002193, 1.2692580399259623, 0.6369066280808408},
    {0.12139019583670073, 1.016150313428674, 0.5966186501680577, 0.4072938230400772, -0.9599890786106221, 0.06324393580771635, 0.4592401420925273, 1.6835244062898174, 1.608966005945112, 1.1831530177767384, 0.5986270739952132, 0.7198668696693923, -0.17421677549487624, 2.4662474502857754, 0.814742190805787, 0.5711645203782976},
    {-1.2314947092065456, -0.7869340012603439, -2.6217925781361835, 2.4245996990904515, 0.007684756125924778, -4.237282112877122, 0.1410153273524218, -0.35646496300975095, 0.9769008513512305, 1.6252293302378877, -1.3568930636783139, 2.9208834081646313, -2.0961307620946923, 0.5784832863385446, 0.2508704580801133, -1.266957306039713},
    {-1.085795265415256, 1.076043281813196, -2.8183520432918994, 0.6359367022225523, -1.7563421950269906, 0.5064189448949389, -0.708455850886409, -0.1826740430475399, 3.673609158871033, -0.16008937595034523, 1.2370166883490012, 3.1222932326494353, 1.249432874892092, 1.0637372461106196, 0.9488057321653571, 1.5156292552856452},
    {-0.6138907994175167, 0.13683440147359105, -1.349911165132234, 0.6694086933792217, -2.001336423437803, -0.6440508780397693, -0.42511532126763935, 0.8820037519982085, 1.452503576533509, -0.00378123244110792, -1.1922979133353957, -0.6275895797110976, 0.5280488532034154, 0.5054271864972504, -0.507617180886751, -3.568739094329436},
    {1.26095552811134, 1.5643056066160614, -0.48266129729965823, 2.743423361850676, -0.7270134509539213, -1.1244276636178752, 2.673719037865123, 0.7916593533599438, 0.6332612679484755, -2.8224295002050823, 0.9510895805869559, 0.4600512614233114, 1.9726285770942678, -0.8593219605258444, -1.498211198467383, -1.6122777751512383},
    {-0.48091196611191556, -1.3916467274831328, 2.7384005932056144, 0.5679669271872784, 0.7811993721722901, 1.4325705939433282, 0.14384706185191856, 0.20464111295748014, 3.048288045519493, 0.9143202489112879, -0.6931716017750117, 1.3727857905618672, 2.0099562393421144, 1.1425055293216024, -2.231712157682627, 1.307517282293039},
    {-2.4332700020042646, -1.251361941445073, 1.1729069007649164, -0.3987938738568518, -1.4832334783436643, 0.926356699189036, 3.2136026577309065, 0.7686334618912632, -2.473649343982391, 4.758006879447007, 1.1645447921663696, 0.43878429943851877, 0.6273945837441905, 0.9272830932957689, -0.5119369783568986, 1.0914538362136892},
    {-0.33185267284377923, 0.32592382570589834, -2.621479435311832, -1.8202466407884959, 0.07418025972743998, 0.08482919263484971, 0.8674071432526179, -1.0320410794401955, 0.92528164632652, 0.033827490208247886, -1.814874044185846, 3.2103924953548546, 2.22449560776501, 2.019691781964313, 2.618873106574835, -0.6556036400601124},
    {-0.7492776744610633, -1.6600296083857327, 0.1575582290961186, -0.8647443811196518, -2.1902065164140114, -1.9422443295209848, 1.3820038541106276, -1.2336426726431355, -1.3462998390885035, -0.9116190025237209, -0.7922843954102505, -1.126006751428543, -2.2874417413993813, -1.8213964724274194, -1.076719681039356, -0.6049712000927403},
    {-0.3816374094155797, -0.5258510559174143, 0.5654839274340326, 1.7815931993643492, 1.105094550836177, 2.3622794852823077, -1.8744580857792634, -0.3167572134360433, 0.659313067272647, -0.7807781068837233, 3.316770362430265, -2.392215477381279, 1.525306471029067, -1.8180257715286952, 1.9387691382646288, 1.182483738309279},
    {-1.1700963455616424, 0.13626664059768623, 0.8829951560258658, 0.2329088763852269, 0.1847794773473159, 1.8269911928400748, 0.6709975247867745, -0.2519040835602163, 0.7672525573945141, -0.8892430489724218, 0.4654738586913672, 0.9176301433018631, 4.198214850222234, 0.3261360893242636, -1.3529542708223952, -1.1067687970689224},
    {0.5038449780224009, -2.540330464410786, 1.817567014864397, 1.9818883923281911, -0.4017696259011534, 1.0678847639235165, -0.1923208372982418, 2.276488249470923, -3.079607692655908, 0.8411765505821266, -0.6900981251938589, 1.0732795470313092, 0.2820753596153299, -0.2565440626027811, 0.1938043626908767, -0.03879133437157678},
    {1.5236553115493963, 1.302178153498254, 2.197806119571034, 1.0228657045945249, -0.907030250031637, 1.7033393819367486, 2.04271367298096, 2.9681506133128064, 0.7895253570772462, -1.5651823758906644, 0.560738746213702, 2.004908730936093, 3.363723114504074, -1.0261657588596755, 1.0025808938647374, 0.32813441534291443},
    {-0.804291955186013, -1.920059166285498, -1.2293671481140518, -0.6471607833543613, 0.5950388332436088, 1.3592612704968476, -3.747863646728595, -0.6726470100896654, -0.014169208910008833, -1.8512263267674738, -0.22963986140168632, 0.5045417487077188, 4.885428949522896, -0.6642246113501252, -0.1272219857154629, 1.8090897703837887},
    {-0.03165914708437047, 0.7751048188798568, -1.5828011095175891, 0.9946005879533928, -0.4003161896715746, 0.7162714321391209, 1.4378905942693347, -0.3197132312632512, 1.2729217250656546, -0.711287051828584, -3.0257527376042543, 0.796551866448798, 0.653369975316319, 1.009174911460182, 0.351577558104618, -0.7204873192791229},
    {-0.2993869214954997, -0.5633934459953235, 0.5967427046660349, 0.40450367905923906, -0.4403247185875697, 0.09810229758987926, 1.901682836512131, -0.9165590385669854, 0.18831749317220678, 0.49443428257497435, -1.6896491710286234, 1.1332888781756056, -1.2039894491033956, 1.9019117229739295, 0.5265670954223272, 0.7557967476825443},
    {-0.10034649536430659, -0.3880519135009289, 0.005219590251221682, 0.3309053623152515, -0.7974693428787766, 2.614450053250804, -3.948462995852213, 1.4477935584617607, -0.2126294068049461, -0.016182736378320295, 0.9702155209926409, -1.9778233657506494, 1.2985180027899266, -2.318908311959571, -1.1920837142273508, -2.3670895526290354},
    {0.23723497442388364, 0.6261374919613257, 2.4401765656453587, -0.8313387353284464, -0.4164621604764844, 1.9593213336522544, -1.9503514849926422, 1.1909078512158744, -0.4521100335957142, -0.5854717013554518, 0.3369269672846117, 0.43506161777690133, -0.05957767221965745, -2.6127401553391447, -1.0124720938547997, 0.7498387637638049},
    {1.7419267853960059, 1.578715618938205, 2.194672637228676, 1.0992484811046366, -0.03566115470574027, 0.8942292408546909, 0.08031225376403898, -0.0919246920000601, 0.07169043679600422, -1.4251423284605966, 1.1505881264792903, 1.188688718681428, 0.06040358737790681, 0.42798529340219477, 0.3941532602978465, 0.601570689772376},
    {-0.6819469208283185, -1.738823895210216, 0.31617582043695414, -0.29846558648947963, 1.011394521248901, -0.47857795413262916, 0.571848884141167, -0.9808755823428529, -0.2881798878699269, 1.36768510447617, -1.2036147262152876, -0.8632659886318333, 1.1334116915428132, 1.3062503245505683, 0.29538391682266973, 0.3469770652452653},
    {0.7178336010433711, 1.6473076556827368, 0.5858847867181499, -0.06255630102844317, -2.857387748246724, -0.7866473127712623, 0.8522990549017115, -0.6293119550942847, -0.0777201086743576, -3.854164057086162, 0.7481747122459647, 0.2476122049402248, 2.9455980341761467, -1.0859295028115161, 2.380968759749399, -0.2975990278753532},
    {-1.3925660070274284, 1.2330911750611964, -1.0631149517975873, -0.7187792095165254, -3.6052642996173985, -3.0112108046401587, 0.4425087462075633, -0.3735397109648027, 0.5979573744977601, -1.4831440728012986, -0.9141420814961592, -2.8084580356704065, 1.205175160604104, 0.24801878013942288, 1.7223299809841157, 0.22393006138160865},
    {2.0961822930969602, -0.7975913184345216, -1.531633917336967, -2.4003050251693328, 1.281445530533345, 0.6799279103427717, 0.6973439222065067, -0.30514903965369833, 1.9627492944958118, 0.8715373978988254, -0.2543629888402389, -0.6073537604164645, 0.2708893111043814, -0.5228796378136714, 2.2662609156154634, 0.34811589510537605},
    {-0.5554569517558516, 0.2501293145319183, -0.0011468987734494555, 0.6649829523349408, 2.3382201723009493, 2.730658812574409, -0.14788602778005583, -0.36892554539832556, -0.27998701433161044, 1.7164375708476955, 1.1995236949897725, 1.952818860901294, 4.076845604204524, 1.5948473810722978, -1.1230628463560308, -0.16391902246301046},
    {1.8466981389577126, 1.8665877974763285, -0.006316134491989601, -0.7551966711484986, -2.578740976519624, 1.0110703237611298, 1.5193327256060158, -0.8597430965417137, -2.8588453008046084, -1.6498814553054588, 0.44813971401360864, 3.548393867984126, 1.2243911677807477, -1.3508380726349494, -0.9417047453582802, 0.7349480706859671},
    {0.07557277361920234, 1.756897695527561, -0.43281664497953903, 0.6973093552237949, -1.870380718436993, 1.4545901348082197, -0.8547643632445253, -0.589442052696947, -0.4266405139499364, -2.451825600337232, 0.5421753154723126, 1.2944563018503412, -2.3630851765870897, -1.9930193291285194, -1.5523063586355634, -1.540200489326461},
    {-0.8733191360723324, -1.595211197213056, -1.1143605355713917, 1.8754448946209885, 1.4872659834943536, -1.0038165212688532, -1.9166276913741536, -1.9444949184677986, -3.7376740332699483, -0.7377591031829696, -0.7022699616275848, 1.1315686046278226, -0.9222190960524704, -0.2255216290491977, 0.9801921575506582, 0.16810656646245975},
    {-0.03962282146170398, 0.705986535704389, 3.8892883850252074, 0.4742413617490889, 0.9234954005408449, -0.07811404176863025, 0.28332858280192025, 0.43122243205074395, 2.3986861349652187, -0.562188993341129, -2.099210960655193, 1.2262703677477134, -0.41601179232563734, 0.787884041951935, 1.810447119051833, -0.22466732701246964},
    {2.7326653246469483, 2.4044010192520515, 0.5428994126515354, 1.288956010817349, 4.008591564095487, 2.4885767692939056, 0.30619163727395066, 1.507739294923206, 2.3037850234126305, 0.3090686343662265, -0.010695792481119593, 1.5166745439442697, 2.4479756290471686, 1.0588595810001178, 1.0071883695579258, 1.4167026611770899},
    {-0.6127109985376588, -2.1463616138704458, 0.6947946317830803, -0.29793037911776304, 0.3369794894268402, 0.3845049313275989, -1.3478766991130169, -1.5068738384283968, -0.26396055000569835, 2.5786429981502246, 0.9111728038162766, -0.37263021092681875, 0.7782238298446066, 1.4630848308002098, -0.17520573366780778, 0.31902575654692145},
    {-2.2532223554109385, -0.44755511648902874, 0.996558701526076, 0.49753551609392505, 0.22842085971936205, -0.7470487038729487, 0.006380141869908162, 0.2533123245965368, 2.08083538941796, 2.376215164810731, 0.031113224699921175, -0.34419330787172997, 1.2236388777428069, 1.5473843623248336, -1.6163582043937041, 0.2559618699272318},
    {-1.7964752947562892, -0.28001678799258134, 0.558880889694208, -1.4047637870150815, -1.051935251239069, -0.7815739518731285, 0.13206340492312257, -0.82514062190775, -1.3008676466184699, 0.966427069453969, -0.3257367416220848, 0.7290655734573722, 2.5146443979007467, 2.1230588957735144, 0.28707813249877606, 0.22780460165241617},
    {-0.22466336711980017, -0.02425736068614289, 1.159840440890102, 1.8940155098991436, 0.3824570791326344, 1.4542881261118055, -0.247380173035932, -0.5194457316378785, -0.6766094727109173, 1.571263674567129, -1.081222695358123, 3.0963694891246294, -0.849892503966703, 0.3715972427212199, -1.0338704959782663, 1.1732751108018267},
    {0.051352524334133794, 0.6614295177384399, 3.3839995113082733, 2.089559735472705, 0.8562247272859408, -0.7066972118044291, 3.0973039260534647, 2.1841712861972526, 1.5059398765398488, -0.05655379115557392, -1.833500885930746, 0.7068349077418635, 1.5079661701667777, 3.0308998535962157, 2.0633896817578092, -0.5280289266873747},
    {-0.7289178976211582, 1.7960726572873558, 2.1937725238434895, 2.9709008709645666, 0.99562241922665, -2.611379829859549, 0.5845962483620312, 1.324433204132026, -1.2934132642813179, 0.843241523670488, -0.9601297807318888, 0.6384617674524632, -2.457489954881633, -1.2108412201903842, 1.5562996213823024, -1.4402921707407064},
    {-0.34064161145744415, 0.6053478191573666, -0.9439218328247093, -0.4125141577646148, -2.0406693862133034, 0.8368403621104391, 3.3586682938843584, 1.3083035354225425, -0.09267445016772213, 0.9439366366388804, 1.5895710505059135, -0.37249601913055896, -1.3381814573928694, 1.3165261240079664, -1.924694469614571, -1.2619656136369641},
    {-0.5929530704786489, 0.6240786779488571, 1.1245543224489782, 0.2930115015630565, 0.10518856269452981, 0.46213032930718406, 1.6360898624570972, 1.2200145573890493, -1.6874604295053905, -0.8969043809572808, -0.44274429151670386, 0.179565399294299, 0.025405229674091416, -0.3644925748684421, 2.107799122771352, -0.860712379175983},
    {-1.2964094465263756, -1.2724713440514797, -0.9157745571386462, 2.629136101901995, 0.8136825138114712, 0.4041480786540252, -3.729869151328269, 0.13559097473134513, -1.5323084542083136, 1.3890817158471747, 1.3910247899951536, -1.3091945723050666, -3.506758375477633, -1.381765420595971, 0.7938500576171011, -1.0906167552532837},
    {0.16516438286995488, 0.9225244879448983, 0.6975919235200382, 2.9990584467639145, 1.211840444517237, 0.6385225522523953, -0.007698142737783324, 1.3743435737413985, -1.9248176037121327, 2.7602048443137432, 1.3162659380991266, -0.6835824173603703, -0.7653233234609652, -0.40968512765582255, -0.5992270297363583, 0.5959371002595888},
    {-3.176017225720709, -3.028827119041212, -0.15642518557165086, -0.8369696235684374, -0.25795008112413187, -0.8157371470550226, -1.0385565006753856, -1.6763133290573775, -1.7319018564217397, -0.5677889123339662, -0.1531358548794088, 1.3788076894100068, 1.6146694820519378, 1.7571356687502586, -0.02143802798391211, 1.683364370524486},
    {-2.1376959881366897, 0.8365707008598273, -1.532630587730568, -1.0338796768303375, -4.776780101816912, -0.9637299862167094, 1.3965383605895751, -1.0974212374998276, -0.9000239822883225, 0.5768225124184683, 1.742376544898941, 1.114904498442747, 0.32600746101661343, 3.3027469297426584, -0.48816493633587393, -2.859068328841209},
    {-0.243470041666254, 0.47771879769879066, 0.03998505212316265, -2.1714753338285844, -0.6506573292677862, 1.5282306909803351, 0.5292538943970463, 1.4250696598285029, 1.464873807938989, -2.6947948331036637, -0.2500733308528987, -2.154017407160843, 1.5978035621351452, 0.07717689988087473, -2.5850955574255714, 1.1100790559243312},
    {-0.22869128733676097, -0.9700155678375137, -1.696561698526664, -3.1714003217481106, -0.19610268975910383, -0.6178169676486331, 1.6105327104114, -1.0813693173127699, -0.617963172531086, -0.7243714864417772, 0.370156137086527, -3.1351256948317587, -1.1163395022297509, -0.48523907386187176, 0.5375825360027243, 0.5548540395042361},
    {0.6427424420968799, 0.06390492630587341, 0.41722402698879224, -1.6971816605019883, -1.3834820634862908, -1.19195529992434, -2.3333086281973285, 1.213329646328074, 1.8040620638625415, 0.8119057430147244, -0.5281209856740812, -0.9434724503229358, 0.21743907606431576, -0.6961153919826135, -1.6948065018268594, 0.1627734303224767},
    {0.05737410710352629, -3.067618325615665, 0.8127590706415729, -5.2248677173150835, -1.0691895829319333, 0.7630194756037347, -4.787738877444965, -1.9081484513900122, -3.6050643918951777, 2.519340279176097, 1.306496483388736, -0.3454870454076141, -0.743382585240336, -0.9465011632832283, -3.6321962011590796, 2.039247830423843},
    {-1.1980925288275523, -1.852525202766538, -1.9579810559346598, -2.7251546883075357, -1.330247718346334, 0.9415819239103128, -4.247875603691156, -0.10484906595096406, -2.4647858571413104, 0.8922425663618219, -1.9184419906784682, -1.3899087149890976, 0.9241506673357317, 0.629324428759603, -0.7322174778559096, 0.6085799904673054},
    {-0.22932335980450574, -1.6189786621643079, -2.7356116607323355, -0.6809640704628851, -1.119725839741672, 1.0105560394904927, -3.3930279842501805, 1.181428305564664, 1.5918490112053991, 1.020087943806352, 0.7183486508095585, 0.13121510132705408, 2.361346937309197, -0.7675713437971179, -1.909165371107526, 2.6715458135074353},
    {-2.2914705223142984, -1.1429155323351643, 1.0178974676636763, -3.3471091557458332, 0.31019929437550287, 0.6847602782148977, 0.3837475634694714, 0.7740609108126381, 0.28252370229659696, 2.0046346230891663, 1.1559626312158615, 0.1312974407862413, 2.3744516469545114, 3.5039233781023937, -0.7859665009843673, -0.03735657619120928},
    {2.749009622497751, 0.8890375877063168, -1.0155183930150211, -2.385863344110237, 0.48960737821795075, 2.6246410824730098, -0.024999368644999753, -3.1627566161357286, 0.20228176537801185, -1.3194509084646722, -1.614642889393611, 1.416799279480729, -1.0474280110911867, 0.6417657494059671, -2.8263894695738827, 0.35070478081084305},
    {-0.8923213997317402, 0.8240485603927391, -1.2158380589259625, -3.337456394138502, -1.432353973206048, 1.471369230881719, -0.8649043307462791, -1.003172585421549, 0.081931988465251, -1.1726850795471193, -0.5201229942133146, 0.028059900515167498, 2.9782427948143733, -2.9949081456063107, -1.1213526629838497, 3.239006750154774},
    {-1.3487497783900473, -3.08510181661886, -0.20842514023871986, -2.25456478212559, 2.8897143932243288, 3.142739963995155, -2.1775231190885487, -1.1759275029372143, -1.2936924562208536, 0.09910816847820764, 2.688368715355952, 0.2661345638828248, 1.8953888870837288, 1.9500424650997943, -0.12556274981855262, 2.8369097161519043},
    {-1.2929114825160664, -0.2900803253132601, -0.17135097959761, -2.089516101609807, -0.15328223325553197, -0.20080789826806883, -0.33197433865428383, -2.9209999244922176, -0.23387615435355588, -0.598770019304855, -0.005142873202271672, -0.6071725849984387, 0.11677321698992339, -2.0871531492502515, 0.25634033764674125, 1.9154498448716095},
    {-2.4354467488326335, -2.3750138966986634, -1.2984587123379931, -0.22208092924614511, 0.6435768351628524, 0.795084245406798, -4.253199541602853, 2.5063434449179525, 0.615705393207938, 0.4766511761085418, -0.9510359193245875, 0.36107022701939684, 1.4142190659765965, 0.18419170225483775, -1.777771379701775, 0.9235592401952695},
    {-1.7496315609209785, 0.6547106282194081, -4.863609566993274, -0.21245410173892076, -0.4477778896190037, -1.1394868238002414, -1.321790000356229, -2.204668687882485, -0.2659517167170136, 1.2020691224997038, 0.4609673811578796, 0.5436457737614411, 0.4704078200579557, 3.0574478568259464, 1.006123881713105, 0.10807480786374053},
    {-1.6643213299531923, -2.2368091312439833, -1.498750440279782, -0.46762436298866694, 2.869173198874976, 0.7413528864928267, -2.129796948947547, 1.4983099158281055, 0.6835715845608197, 2.064977372488011, -2.0180500798638343, 0.737756808189933, 2.753430336415533, 1.6883399147356213, -0.32400041219089887, 0.9370499456392122},
    {-1.472109645025386, -0.3711250787352418, 0.7748290350772522, -1.2388635155094894, 0.8518124871185963, 2.2455486614892215, -2.3362702087684104, -1.2018362919507604, -0.08561551474797766, 1.7961947344292655, -1.3273999816455349, 2.469366081482051, 1.4913896022050122, 1.7110127871720129, -2.3500371686468937, 1.2030740610095665},
    {1.7208186529024418, 0.6621214656989237, 0.36166624560970684, 0.3871402608170456, 3.0611452278259588, 2.5511639722227355, -0.12525540707327307, -2.0114412553411047, 0.9906724543997694, 0.4149219402162227, 1.37692202948479, -0.6709113869560098, 0.996948308168542, 0.5405918588167737, 1.7470553296311566, 1.8862437384703392},
    {-0.7707993461226951, -2.265254362914694, 0.25615037288754783, 0.2042676704992715, 0.693286503771057, -0.2679138992181456, -0.17914242736501976, -1.5786046678940577, -1.1923721244101355, -0.8770814583768507, -1.3089344890861543, -1.4196645153417786, -0.5267553747909487, -0.3085597419251676, -0.011390810086572107, -1.693052886663819},
    {-0.3130139364234468, -1.4489570648739492, -1.0868010189000097, 0.042444305891558204, -0.627381008445098, -0.33088856774807596, -0.7672878612648578, 0.20380681843653936, -0.19761183932671625, -1.5956544766176177, -1.7385226716858553, -0.9430856746309589, -1.6460510185942683, -2.783198663355632, -1.8828047089179487, -2.0193018641616387},
    {-0.8518030801388219, 1.1773486287166526, -0.7843676790769657, 0.27380504098439973, -3.0484302278667763, 1.2467103628664924, 0.736372230788663, 1.2798296941174103, 2.6601657982412057, -1.1707756644896523, 1.498586812081037, 1.2367836059347461, 3.7374613548125746, 2.0697366554549372, -0.8664738221383109, 0.3632947061926322},
    {-1.6123337649881906, -0.4632003094852006, 0.0728133291313175, 1.6918598014521096, 0.6958703278234631, 1.6073238999530148, 0.1332470108631459, 2.3076313343537067, 2.701573905920413, 0.6548584813261196, -0.08785766160560923, -0.5226676314153178, 0.10125801183080717, -1.6291096616224985, -2.0205927633105696, -0.7118184921842801},
    {-1.8284134941010606, -4.337067645424703, 1.9791123441312801, 0.5321887220091798, 3.0005748303416717, -0.707488809279336, 0.8925316787531495, -0.3262953192710226, -1.6541091673547819, 1.2866933134061653, -2.9417720095054496, 0.8900130078507937, 0.6876280722215345, 1.4164024591874704, 1.1662936379490445, -0.6817777489633469},
    {-1.8401017095659908, 1.5536096156437464, -2.4912955336612597, -0.36410304571229896, -1.8927794365731798, 1.108265710929588, 0.32660612304481346, -1.1011023485094238, 1.994187130596913, -2.246171961040111, 1.3295992030685968, 1.5152250112608192, 1.3009833017987373, -0.2389503575863484, 1.4838716740461821, 2.8605895351698023},
    {-2.486181363758266, -2.001439050940372, -2.2190417068080803, 2.2946809980506, -2.8227089007735566, 0.8184487599224815, -2.479045145585352, 0.5975278157096232, 2.292275512821563, 0.8059894987900752, -0.6157174750703782, -0.667798404041829, 1.2743887224918036, -0.17631270055203765, -1.6908508057617802, -2.5349615916873707},
    {0.34232563715559355, -0.9868949142520475, 0.08467695566023302, 1.7585736031687083, -0.5256525100358866, -2.2801688418496364, 4.059195076436463, 0.0012378483089113476, 0.6173301637351137, 0.46542000993077715, -1.029007300062907, 0.04181307874645096, -0.615960664583022, 1.3096105272241412, 0.20119865935141376, -1.2313282600539326},
    {-0.7163319910566044, -1.3564012323195223, 0.4546732661868778, 2.114937544756471, 2.1916377925602637, 1.571432614003885, -1.1128573372875143, 1.4033062999671466, -0.6721489772649217, 0.38938150593108145, 0.5356825022078127, 2.4285259452990586, 4.637167564217902, 0.5728812571192328, -0.6965636317397486, -0.28534666359191463},
    {-3.635890921844361, -1.1113225771179636, -0.0272324348473019, -2.3537050954034218, -1.950841558546596, 0.6514695589398498, -0.33285322395665895, -2.469049863004799, -0.610167002757761, 1.0216601325435253, 1.1265345861043996, -1.4471924576982629, 1.5186155462673958, 0.6934804931257063, -1.8399146182518675, 1.275740604014582},
    {-0.8833018054961921, -0.5913979166823047, -1.9161598847744417, -1.1181706941820466, -0.09151151889092655, -0.9308976767539127, 1.8856283942007874, -0.3604618461823368, 0.991664163514981, 0.8539264940284778, -0.9619167312836079, 1.4272666581942335, -0.9699572850697699, -0.5070118662339174, -0.2986236762801299, 2.008004008660276},
    {-0.8175220121433067, -1.8926066423357735, -0.6921388164968924, -0.7031838640634167, -1.977873466509256, -1.829922755163148, 2.5675442009469105, -1.949516894843147, -1.94802691559326, 0.35931515793205515, -2.3576786846967486, -1.5694215414100503, -1.0013592953795047, 0.13390057616090134, -3.1911367314132426, -1.7868748951611115},
    {-0.9918181117867142, 1.0063476545579784, -0.37454173523551176, -0.4974757564881187, -0.4472375122622609, -1.2009452560934788, 0.8549555214773729, 2.451071841924289, 0.04064221768033504, 1.158499143293402, 2.343367965330164, -2.843275740269212, 1.4254779065176355, -1.334768466240313, 0.291559458077862, 0.4717813812921487},
    {-1.3088693696779365, -2.10426254252421, 1.5472493515540868, 1.645586687104057, -0.6777484707967679, 0.17729554909567882, -1.0863723132154557, 1.370212822694795, -0.2736336414820297, 1.031082491276781, 0.14430251176046688, 2.7079592865901203, 4.21471524917786, -1.4663711798992847, 0.7971939235627199, -2.6769348896497447},
    {-1.3814118954147105, 1.3592278175586188, -0.9761458808433768, 0.2497146176612314, 1.752737752967583, 0.05459694239833406, -1.2396892572142535, 0.06058909127748114, -2.7216909631990194, -0.4542267342856878, 0.2215986233198964, 0.731369998442266, 0.2952880675542036, 0.7842061046867567, 0.16787285790073464, -0.8968104633924415},
    {0.828209193963732, 1.5160717614513877, 2.7843500373832275, -0.19226022009195284, -2.0349035873942936, 1.7346686677471883, 0.9257761857379515, 0.8414870887186611, -1.3139280834341038, -1.8865571037422082, 0.24507341555925172, -0.4666300541113066, 1.5324885862040827, -0.8662914515643251, 0.17893683206983868, -3.107033014752216},
    {-0.9210978694342755, -1.423375330281227, 0.5141287113496589, 1.2389269890339332, 0.7754369066255926, 2.130803720522839, -3.8192537363320995, 1.3746246678600846, -1.6239047942252847, -2.4379571266821802, -0.46719065987333097, 2.057457555382702, 1.7453940227326168, -3.2679265222026364, -0.18764310768292272, 1.2956940849727303}
};

static const float b1[16] = {5.210425251873729, 6.579204596925347, 7.5075517100390226, 6.4664258039388995, 7.477200388322092, 7.324521507495244, 7.993409580361921, 6.283240538645488, 7.8703226530793255, 7.591132508394285, 6.11395510473598, 7.229368777899011, 7.555156979509458, 6.58584769024741, 6.995208913086543, 5.346042473239452};

static const float w2[16][12] = {
    {-2.746465187517543, -4.911292869608969, -4.439233509187926, -4.259960194386578, -2.348217801379095, -4.559949981402791, -3.2327154859394454, -1.3852976662538299, -1.6229916457159401, -4.374876342153764, -4.483793210086575, -3.768464728313168},
    {-5.567906912954713, -2.380860751481614, -4.697422406830826, -3.3245109796173207, -3.755834177896208, -3.437240990177401, -2.5243414178104002, -4.065165321746615, -4.477373192164954, -3.6607291349897, -4.365099339987904, -5.085702995950381},
    {-5.057682947989731, -3.6065685399533214, -3.3833927557560246, -3.27764899885801, -4.061936135916897, -3.7235351647518256, -4.467736126514877, -4.2703788015581905, -4.982342300320825, -3.4823455115232735, -4.783479122125384, -3.856918568656326},
    {-3.685019857910715, -3.3588950015189285, -2.9920183119233243, -5.594645778826562, -3.078479839558232, -4.835721439731293, -3.0467356681393105, -3.846330931098732, -4.1853045624794065, -4.462171425650168, -4.728026516132523, -2.53038213607085},
    {-2.769925919120324, -4.0771269419259655, -4.807824531106095, -4.019562017677782, -4.15273529521276, -2.7067336252820136, -4.2812554726737035, -4.281117571399212, -4.394642760223501, -3.1322772058959405, -4.101072049103394, -4.891773664955845},
    {-3.655775374918324, -4.227757735734927, -2.3125327374480484, -4.1784958733471145, -4.78957654751565, -4.6952437068613735, -3.6074795004061087, -5.98462970477097, -3.425739677975353, -4.228096927413472, -2.860179172207095, -3.853868551682712},
    {-3.6264948144304197, -4.2163014795369165, -3.58417772981778, -4.70327035771685, -4.686187757282591, -4.105586059936155, -4.166179827439687, -4.6651372312070745, -4.142770611411334, -3.5026476041830943, -4.153469881316664, -3.9546027451090766},
    {-2.4886532260325724, -4.836694231064495, -4.754391409927875, -2.194696525650709, -3.4375084293328717, -3.585726116998063, -3.718911880754848, -3.5165232420793964, -2.192618914383915, -3.573811140530916, -2.646035514509039, -3.7322439769767657},
    {-4.203637533114833, -4.573305932059956, -3.0701658013071773, -3.536891105390926, -4.147988714795226, -4.650026211645004, -5.291238973188118, -4.7836328773561405, -5.22655977925593, -3.8629021640359498, -3.7767865612146974, -3.5371291518909325},
    {-4.904407260457585, -2.7514795315644713, -3.6577102198129094, -3.8169139223410613, -4.483416220060075, -4.410009062729369, -3.795455974298991, -3.6461516354031076, -3.6732665318380904, -4.463350648720018, -3.6376186095010024, -4.849594450782311},
    {-3.2181840091845677, -4.084383166126664, -4.159745205040972, -3.930936374824241, -4.137289602826187, -2.1243626031038807, -4.235784948633077, -2.587516585303784, -4.93551486570404, -1.993856926702077, -4.026796983859016, -3.6253958827628328},
    {-4.351759194291484, -4.272946979554216, -4.460118016210627, -3.157044343853147, -3.541171785036338, -3.7824198957155355, -4.79747140504287, -3.0115023193506434, -4.576287696377644, -2.85274496041864, -2.858833193477909, -3.5626535820680814},
    {-3.6322120183157462, -3.2128422026081136, -4.454535448168097, -4.847536651278029, -4.204815040162598, -3.653483321962943, -2.808456887804921, -3.5172782019517097, -2.9490185358350622, -4.669064152249578, -4.338497485626794, -2.7880047228233953},
    {-3.7079142791077078, -4.3631381377288125, -4.241341831104541, -3.216367594646391, -2.8991498946088017, -2.597589616133251, -2.8495185242459358, -2.8275919413133286, -2.9240679675788654, -3.5639626906908064, -3.7405267275252894, -3.514277465549677},
    {-3.7328994787528553, -3.610668058109146, -3.0407030113777833, -3.1848264264780073, -4.44705430552977, -4.088817840645283, -3.9560652918424384, -4.391595036405036, -4.271049238125309, -5.369601625992421, -2.986693085142499, -3.908701921999806},
    {-3.35020103025688, -2.3881088082501467, -3.4016209953343854, -3.6035090332627364, -1.590265837242467, -3.665555224664556, -2.8332122927770373, -3.684302309273637, -2.2309793168782326, -3.429817344777129, -2.946324939400441, -3.3300074076269364}
};

static const float b2[12] = {-4.535054266052867, -5.047170395219732, -4.662980609042894, -4.484961532293369, -4.8695317472641975, -4.712216444684377, -4.825051831163791, -4.771797768445675, -4.099762022734241, -4.7545844950740985, -4.38549220085512, -4.628145631208815};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
