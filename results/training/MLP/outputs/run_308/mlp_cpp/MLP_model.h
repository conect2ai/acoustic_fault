#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {6.21329952242665, -1.3223449560230396, -3.20178027601509, -1.4876416048614698, 6.669739502879718, -2.199932515637779, -1.715187767366103, 0.03933835961647469, -1.6520396421638195, 0.6045449784202561, 0.4726142419999802, 1.1264863388311508, -1.1867126123157974, 0.4315170206969767, -0.09776040474074826, 4.477768363976909},
    {5.573066717076513, -1.5058347102410803, -1.89473660111738, -3.270983552294717, 5.508889039819, -2.3988134492272555, -2.54164519885027, -0.9165467561846624, -4.984749677904165, 0.6558969191670436, 0.3426434737700133, -3.7109950085995664, -2.7327171034782656, -1.9065587467184992, -2.321836204815573, 1.9875081825718506},
    {5.292516082732743, -2.9942657541030595, -4.0818086743270126, -3.7028375546843666, 5.775402231439822, -2.5821505166363043, -3.578054521672294, -2.519840992349757, -4.41270491936766, -1.7724039454698675, -1.8927746424388021, -4.233353203115613, -4.84753401862176, -3.0962725456918134, -4.754387927185791, 1.6911459398702304},
    {7.009887937833786, -5.453322898857679, -3.506737796745695, -5.355984648986619, 7.327530209674683, -4.531235305438285, -5.851963079730726, -3.223570035208485, -5.579614753742691, -2.6273229104595304, -2.3637357149412352, -5.681409203920416, -5.252490934666227, -5.091002598508467, -5.107826917928908, 1.6464988619669851},
    {5.076894277913619, -6.154664263914654, -3.9430567413430953, -6.487245398173517, 5.426422868570916, -5.8978011166241195, -6.201420070205695, -6.3828523412444165, -6.777872881328133, -3.9486753809413293, -3.5470243000130908, -6.443476164216982, -6.520076482981445, -5.502343075575974, -6.9974705941237945, -0.831759202222489},
    {3.5741825741455178, -5.610577679494952, -4.870082176600401, -6.549402258437598, 3.993773596166548, -4.737013794664665, -6.314928351579375, -6.663714401715676, -5.60104410181849, -4.385923219641583, -4.4418881992421015, -7.1903294810722755, -5.005534634173088, -6.337882716426086, -6.285524060049508, -1.4704118355400666},
    {1.2658071734190115, -5.15331791178887, -4.238513361978783, -5.6862041615974706, 2.2081841815789622, -5.5653986188980635, -6.052863151467676, -4.615616069370282, -5.854533591667505, -3.4674228142814774, -4.462302349715645, -6.741296297347808, -5.110044706719621, -4.385749473027998, -7.001957977062088, -1.6229405949542706},
    {2.967176145505211, -5.917532084305171, -6.059366409625347, -6.070436824623827, 2.747645149197143, -6.134913450432275, -5.388685530153176, -4.8360442071526295, -5.762279921469172, -5.285228030718848, -4.3446175741372155, -7.095539985868917, -5.296999134140474, -4.263225811612011, -5.856973666426233, -0.9773136884003526},
    {4.197134956773299, -4.106117310823583, -4.416993278283804, -6.692805280593255, 4.972886150275445, -5.74329958547079, -4.863057548096591, -4.994987552225094, -4.846841154776936, -3.7854970730728756, -2.879110657326303, -6.038422050256283, -5.865392720179226, -6.14164814875974, -5.6407401590797885, -1.147079304745998},
    {5.117401903694044, -5.403108505266373, -4.396392965594887, -6.052427111775536, 5.162139189597739, -3.9427990577430405, -5.027721024033306, -4.897806585422815, -6.146254074623109, -1.8841643834233388, -2.0493588687863147, -4.994926805472708, -5.688505200705252, -4.505124364282986, -5.275463305903944, 1.8914127313264546},
    {4.5777180848870165, -3.352467642218659, -4.65434493953685, -4.092122846123007, 3.4344481668982043, -5.207819609335879, -6.0513230166787615, -2.948631785370185, -6.033825395179896, -2.346668273982103, -2.1126124513549733, -4.640823780394361, -4.965264068227822, -3.8780053013132494, -4.168024595613328, 2.131828376039225},
    {5.1867707462715344, -3.370073436127812, -5.162757880879892, -4.5293351094792556, 3.054501545368713, -4.908843451448464, -5.482712217694446, -4.978041334903903, -5.978488069641313, -3.9062145976105147, -4.025085264151171, -4.8631314108221, -6.536462587566465, -4.934802954283658, -5.117049111203109, 1.4275979774079255},
    {5.737717475665994, -4.903172963730089, -5.7471525555576015, -4.613015957970538, 4.463468994045464, -5.8729700605021815, -5.0694872515902745, -5.92734011879668, -5.797079434934834, -3.3832691031710898, -3.8399279192367812, -5.446765858716771, -5.79109647942569, -5.396576903935524, -6.372479247984016, 0.9271522423647394},
    {4.215638346249948, -5.045985772598427, -5.939666308961084, -6.3600193328745345, 3.359778095357719, -4.845588781803653, -6.106233351920726, -6.5660070539936655, -6.917777741290817, -3.944542338224325, -4.705283365423228, -6.494469762100067, -6.0491136685574505, -6.227417780130395, -5.347736826558003, 0.2755191847577103},
    {4.960882740760616, -6.088142013578785, -5.988333947096381, -5.593029981463553, 4.587499351859412, -5.143350523206481, -6.379855129448362, -4.939060761329112, -6.166853083800833, -3.348819610083886, -3.817888840741299, -5.721787317026333, -6.373980372432557, -5.908567575835528, -6.070203705753306, -0.12630466051320485},
    {5.683101315277707, -5.468143404408393, -4.389108719918045, -5.552645854290435, 4.181339738495821, -4.336793066236063, -6.519931770434789, -5.391874774244308, -7.035418069119914, -3.1552159155575317, -4.4504916640086485, -5.12063374196894, -5.773044676775474, -6.205782233110448, -6.868573674268536, -0.02292332536938778},
    {5.166384090523784, -4.708988383629585, -4.8699235239323, -6.224559203672932, 6.0626626947619595, -5.651266003407886, -4.481354779698955, -5.208258021377526, -5.598218209829452, -2.5937932535392734, -3.6502638855358516, -4.919684235237398, -4.8982889415010025, -4.770067047794497, -5.261951744569087, 0.2462609804043522},
    {6.011508710068982, -4.772721505330758, -4.912754302437033, -5.947662241832234, 5.925776655628834, -4.228317276184961, -5.870278826498244, -4.454943602818232, -5.728884867527478, -3.167274457693204, -4.405343867692435, -3.270246035177296, -4.933332665303564, -5.2191941525215615, -4.645137790505189, 1.4840945177540346},
    {6.360512721052209, -4.452009896117894, -5.229204940320825, -5.475603332785645, 6.5695091447129625, -3.6750037434363785, -4.481732521186587, -5.077161960232879, -5.494224525878441, -3.2587023984521815, -3.2610610571266205, -5.466508436538329, -6.436330241015237, -5.537650342732965, -5.794167375188113, 0.5416309843801066},
    {5.817959331073713, -4.200884043766826, -4.516400569319778, -5.298761494255121, 7.231704116129141, -5.167701924726814, -4.835149686112207, -4.52038586645229, -6.261677434413135, -4.0762364129967725, -4.9357778413791715, -5.2014862472852, -6.127479227401062, -5.533689144494651, -5.814390288232037, 0.63747896056972},
    {7.325917469188036, -5.020316311568216, -5.0980908650802625, -4.521673049654945, 6.22623679451247, -4.847278522684496, -5.433077399729261, -4.374973486047629, -4.979655004287594, -2.968177161766995, -4.365276767929874, -4.860421461225585, -5.749014767647879, -3.6613618674862627, -4.465908723111891, 0.19453795160995535},
    {6.392341741735513, -3.589150499689353, -3.742759743562768, -4.4632977990569564, 7.925416858609518, -4.483996398899826, -4.426331505729245, -4.441477607137387, -4.775048528509964, -1.2345835179144191, -3.3298789251177343, -3.720110947035834, -5.521054827596115, -4.02687871171104, -3.642308021548993, 2.406160609191288},
    {6.573969618416345, -3.891174278436887, -4.199416692251626, -3.750409881975704, 7.136449296645975, -3.387786656466436, -3.550315765302232, -2.577794842010941, -4.486023037720428, -1.6104485965017423, -1.5416781311341226, -1.0938793378672738, -3.9908773690970856, -3.733363199880687, -3.577020247433924, 3.2032022221349443},
    {6.085040520297855, -3.733914207614039, -4.178157561286542, -4.067375454256534, 6.858810188456581, -4.638007771185549, -4.600471320462863, -3.4619934714409477, -4.6917415181954185, -2.6254103483472466, -1.9790951656720632, -2.5579329404379054, -5.3927230743111, -2.9159155698404144, -3.993092760566189, 1.4355950390075716},
    {6.764866878397316, -4.611781000808818, -4.801177419622521, -5.232751338052173, 6.674470181631706, -3.2007476259465744, -4.224594867797021, -3.38657109722275, -4.533742102648438, -1.9354365916495002, -2.728607757345046, -2.9283350391237826, -5.0770172007588315, -2.975609352462624, -4.635818333653838, 2.5437227685717323},
    {5.7066755780423755, -3.780281059953508, -4.056535264076773, -4.760690291545596, 5.657535568874513, -4.753159997089285, -4.925362585311459, -4.319217809788557, -5.243319016577885, -3.163534414755373, -3.562831458361276, -3.28654821358394, -3.961703382130751, -3.170797767369987, -3.8135516983080424, 2.3178663078244037},
    {7.684481568611578, -5.484273863825223, -4.289012706521629, -5.029691195688437, 6.545241232840443, -4.2585991080074, -5.431780662473669, -3.0655054716306784, -5.873998015769707, -1.5525182032085272, -2.4863533291614157, -2.9159495191156255, -5.249561844992317, -3.848649878165239, -5.195944018814482, 2.106969551270786},
    {5.780637387540585, -4.443146451373974, -5.345200279637879, -4.047208492529922, 5.985122140916006, -4.237514306133598, -5.790666437168809, -3.88047469068879, -4.735405618209303, -2.1843800126100206, -2.373863522815571, -3.221353303119973, -4.942499091429574, -3.541297334059879, -4.339700752432518, 0.9662881278892316},
    {6.681422355160212, -3.515490832496157, -3.841453399983394, -5.968640171701203, 6.394074379384421, -3.7468176403232136, -4.89549034285976, -4.142685664785511, -5.458987411775139, -1.8355656369855102, -3.0590983203147433, -4.45492993320475, -4.7190245031376525, -4.938681071679718, -4.479403528982166, 2.3069325876749196},
    {7.387150242549908, -4.282896513375226, -4.574527356304691, -4.43262557661224, 6.275720264309468, -3.457685865346291, -5.9338178691501815, -2.4308849341974486, -5.019743293895873, -2.357259543320244, -3.9790019336147617, -2.967436755605384, -4.463972934476872, -3.416063527316931, -4.08315823487978, 1.1243733934815516},
    {0.03650257983073782, 2.5620349573467562, -0.5116163327697765, -0.40749898533151324, 0.742163278221026, 1.7018411414068333, 0.4066988873321321, 1.3679137244724344, 0.5193615606372672, 0.7852357664599786, -0.35566003250612116, -2.0106100183981392, 0.05376084658089754, -0.9069759610282847, 0.01590156346859487, 0.9483407155266479},
    {2.3622421143338275, -2.593120083276808, -3.333262705371873, -3.3650049390168357, 2.6815181781861672, -3.4588315415283986, -2.285633598657071, -0.7306385984005965, -2.7525938280867654, -1.2834585540585526, -0.4515163611171039, -2.1074628693105057, -4.310570621322684, -1.939583088158988, -4.132777593137599, 0.09745138854366427},
    {-0.597522381407155, -2.341736631402511, -2.559678789349112, -1.8309816282135807, -1.28811202924924, -2.9517789491560773, -0.49514035972715265, -4.166521029619681, -1.0233561351172598, -3.345887772885376, -3.622774107567653, -1.9256788777588874, -1.8566873151588417, -3.6486534709958187, -3.176103065082187, -3.771447040766895},
    {0.07425944507044291, -2.34906654104634, -1.100209354290066, -0.8043655215937765, -0.6568032323430302, -3.07337584609506, -1.4645824406378787, -2.2512767178882496, -0.4187220307892954, -1.7647512236858307, -2.5242127265112537, -0.3822425713390442, -1.2180697825626128, -0.9634357436642564, -1.5173162583410755, -2.278574392839404},
    {0.1701880810069095, -3.464062525016155, -2.723265458874762, -2.965589764719807, 1.5428445460466569, -1.267890279404856, -2.2979927303766754, -1.6125971826635244, -0.9398715991491509, -1.7382992131964814, -2.345465915900669, -1.5706064096143926, -1.9273176720546517, -3.0947319830739075, -2.117810128259385, -1.1059611069723605},
    {1.2351963975563918, -1.9034337528360301, -2.951292655941885, -1.5670867551993979, 1.644500943134041, -3.2105814462222555, -0.05413377884159007, -2.679510468445759, -0.37288644491131623, -1.8471138192414125, -3.6919899138075523, -1.8262148395802384, -0.9767154404692275, -2.422513155329345, -2.3697497406801014, -2.977853392074763},
    {-0.7796574443205005, -3.037805194396572, -2.0605225204243696, -1.7562388113284886, 0.7915528048660638, -2.7928856754657976, -1.063142112123394, -1.0049194602590632, -2.3459878731723487, -1.8135318183800948, -3.4969461150422254, -2.4383300151320597, -1.8916196167258361, -3.4904520310045677, -3.6000357478229725, -3.1329857705834563},
    {0.9802649993747699, -3.0724043905661254, -2.549856492330386, -2.884154566724105, -0.5983537969947308, -2.605182763445581, -1.9025906779533541, -2.4242441110327064, -1.6735679884940708, -4.0152793296264155, -2.6606144149987263, -1.229742264445814, -1.955890824460782, -1.7623981108513462, -2.2764551696855664, -1.8424871738672142},
    {0.3881519000820319, -2.6773336196529653, -1.9004919035786663, -1.3185700002041578, 0.5052096072015806, -1.7308246184734895, -1.0281333350604271, -2.4280841068599646, -0.46920244678069173, -3.230813624480322, -3.064295453628806, -1.9163395810649428, -1.2297050241779017, -2.0380693042760356, -2.766990938457957, -2.4757764114618435},
    {1.3360308227602378, -2.899306193500706, -4.657783317392061, -3.9108165821876577, 0.2835998460317672, -3.590729728968788, -1.9150996997287852, -2.212795909619545, -2.051172992683741, -3.3771021907975225, -4.619080973474136, -2.9455742210957587, -2.691369324672516, -2.5138951645296794, -4.13635024295243, -4.0722251081038126},
    {0.6486136152924391, -3.060196495971736, -1.9256325929136027, -1.5128858076862413, -0.09619484741335532, -2.5303187535588108, -2.9373935350057585, -0.7818683990500036, -2.011144356495054, -2.2935804593218716, -2.102788599235305, -3.184405470342856, -3.1827778952705357, -2.9454309665118164, -3.263727424409053, -2.091760007972111},
    {0.6544733076867004, -4.082001485346233, -4.497602072668163, -3.8247130755021383, -0.9601308996613475, -3.9425715908202226, -3.776288628015351, -3.9664302822915802, -3.1842819783460143, -3.2977102559246365, -4.1203886536861, -3.6588609643659242, -4.263538764913783, -3.2820618159690156, -3.120016651530541, -4.046748409796955},
    {0.9416631834748057, -3.5729652417624735, -4.46109240952611, -3.344274377557486, -1.0083036298237091, -4.173351197343498, -1.2003789974051147, -2.9211726938712808, -1.97973340098383, -3.309709029497132, -4.909144449865605, -2.4467502273712793, -2.7768716808403706, -3.808052759467451, -3.7831303491782267, -3.37016764755786},
    {0.08168738887409797, -2.754111963204498, -3.3251982252703502, -3.89817433124409, -0.007064019782789325, -2.9507849415353204, -4.107460772796992, -2.9731653211505176, -3.205405612292167, -4.406242650739845, -4.872790312675009, -4.12522859885857, -3.796378287018356, -3.761690471201936, -3.0770224395791685, -4.1285847221479095},
    {-0.14807615956387543, -3.072748880743689, -3.13447010613508, -4.569781955187622, 1.6153829043624375, -2.9680406932978247, -2.30581644587841, -3.546407548632781, -4.056755203324729, -3.3115274085947104, -3.995515266353103, -3.6804763464178185, -3.0853825629129643, -3.8864025728758285, -4.063718838387262, -3.9428301003389183},
    {0.35208631225080317, -3.466697681690702, -4.446444909757083, -3.9725141974267837, 1.5877652899453254, -2.6701614917167404, -2.7137973136905087, -4.176200513984629, -3.4194860832306824, -3.157641023179449, -4.622914873635001, -3.504466871182115, -3.171888315790961, -4.0069319901581935, -4.575776664890034, -3.8917802305129103},
    {0.6818642202677065, -2.729053060438786, -2.1529213686694653, -3.692908543948272, 0.5940770754344742, -2.177011789427636, -1.7845783770982564, -2.7611717413180634, -3.0968586150466924, -4.044586056381363, -3.0738254353227297, -3.6899020263769744, -1.5864403610283864, -3.4111760858190707, -3.099361296228409, -2.220902424658588},
    {1.6392989053764202, -3.08175344439907, -4.793289953534608, -4.4798745736011725, 1.8617183539207771, -2.896591379228777, -2.431090805596205, -4.726601970440439, -3.592468786592733, -4.456502907312385, -4.375333309965322, -3.4527652903796313, -3.516984023841604, -3.2267300944471957, -4.164486777188815, -2.358799751149035},
    {-0.030615534992123355, -3.689843010971739, -3.75811080372385, -4.110552103893293, -0.4610278319431854, -2.624851789107237, -1.452290982360497, -4.435596260402306, -2.745992308274839, -3.7513372620581023, -5.760909914329958, -3.641745477570257, -3.2671152838221085, -4.201762683155686, -3.6907728098261856, -5.777607619414318},
    {0.30756012300638197, -3.468488833105606, -4.798700763502187, -3.397203707973381, -0.07733313387062217, -3.7710053872118943, -0.3223462081970377, -3.924785377429524, -0.3217216732059414, -5.1191958870408225, -5.099620364334974, -3.303624803886048, -2.070697818470966, -3.118567653082144, -3.556956497233768, -4.835835463390534},
    {0.6239005260790783, -5.24074920428255, -4.420846630391254, -5.1086964981273875, -0.9036315118732031, -4.715800415965172, -2.316160821762796, -4.427271744779244, -2.1042369795266413, -4.332230762150095, -5.243100165002289, -4.0833062137046765, -2.555401853978462, -4.5550190566624735, -5.189935809188443, -5.439040568154039},
    {2.8199125310306314, -3.6794575531720763, -4.319978740410775, -4.16745810799711, 4.395230231381426, -4.75162110705559, -4.249441130513527, -3.7251795423081147, -3.2650271623750764, -4.746858983424669, -5.261620058618598, -3.6784828384107597, -4.1264302359036025, -4.7501636450536795, -3.9607492030646276, -3.141945986924161},
    {1.1558778730634778, -3.874939168268551, -3.472354147589615, -4.615035132887079, 2.4234254237515573, -2.5169934584191505, -1.6586460884033496, -3.9521223703885138, -1.5576943746955083, -5.122457279803565, -3.338758283686715, -5.473989915046426, -2.3991499579110283, -4.598890704512971, -4.018843314294188, -5.5728424350699495},
    {-0.4570657815665203, -4.225964093155023, -3.6313056977600837, -5.081180388373097, -0.1167163834998302, -3.8610355174808646, -1.429809177445621, -5.2261078634615075, -3.146049950348381, -5.796161586202208, -4.193364346656383, -5.014635221425418, -3.0944332245099857, -5.759749824552941, -5.440771906753142, -5.971178630392756},
    {-0.7605957881869413, -4.102354437075493, -5.507335743146134, -3.546368205389985, 0.5067110362679313, -3.0940424523785373, -1.9872470419699768, -3.654349405842671, -2.347300736943338, -5.244334276483239, -5.028774044770595, -4.258646576698759, -4.55070165353161, -3.901199573772185, -5.009411854467971, -5.338493792285917},
    {0.7655308390440522, -3.520088220262495, -3.8727943979044857, -3.5309423981155166, 0.951974558331532, -2.7350953719251314, -2.390939459533184, -3.497747263872745, -1.8245623185065525, -6.016070872355214, -5.717048678103955, -4.841277713014179, -3.288874571711316, -4.733555961640181, -3.2057554703750966, -3.920815795348748},
    {0.775954975680609, -3.6411209859379223, -4.022099945267624, -4.859551714816866, 0.437615071092499, -3.4021137251821365, -4.288424191680643, -4.937256160192055, -3.6513419592435206, -5.477851477837939, -5.595493254191337, -5.330252929345839, -4.415657512087309, -5.835534293210748, -4.60402193678697, -3.923986543939006},
    {-0.21411860615649456, -4.196211328132449, -5.737910446122692, -4.623783426735625, -0.4346148865027103, -3.6806002083306812, -4.077395813907828, -4.3638103668008394, -4.296066580283284, -5.937499313155009, -4.883443725767201, -5.484308594012566, -3.430661585621225, -4.520599131557924, -4.542625968714345, -5.800915699490983},
    {-1.0823400656462605, -3.9563222577801573, -5.88780371991024, -4.993299860923674, -0.36372981675163824, -2.3388034601754453, -3.7162419349815874, -5.121760302009864, -3.049948688244774, -5.0922362781969, -5.50937028055558, -5.47871083575661, -3.7194925314275418, -4.159626991828421, -5.686793445761928, -6.1038041568637595},
    {0.9957970216051044, -5.029767951750167, -4.065340529112252, -4.115248094554184, 0.4283468033547508, -2.6963920015169225, -3.5963101283007393, -5.56511787036547, -2.250123694227727, -5.881894261706419, -4.773668123149616, -5.8262294139803394, -2.538072894554684, -5.160602691507564, -4.077636420786072, -5.791949938093596},
    {-0.6367040886738183, 3.133276509945829, 2.768183112540699, 0.6542443990382494, 0.684869594392494, 2.41804439275314, -1.9630578933822331, 1.118805398713255, -2.558404948808035, 1.4019111558775157, 2.1096914802594067, -0.31424418414522126, -1.611484131269861, 2.0040909136593017, 3.0061839777304, 2.117133580446187},
    {-0.2228165457044053, 1.6004105691458463, 1.873546253470286, -0.13138459147211612, 1.050334047218271, 1.8366504981838587, -1.219775001827487, 0.2742499116597073, -1.8308169324239023, 2.8410023270974736, 2.3734530165439383, -0.7515495303086757, -1.7013363574749372, -0.4212207499568267, 1.8581700617391739, 3.5084155009683045},
    {-0.9010410252051325, 2.0726383003602264, 2.5403950529643224, -0.614307906763464, -0.7105949408014967, 3.0933551968945543, -1.32192852473141, 0.7575701315500136, -0.2525309762360837, 1.744356641621332, 2.85633506364188, -0.9482370663576448, -0.9650321538651213, 0.43134001701128266, 3.222684558193485, 2.919274587534165},
    {-0.29285823710834663, 2.583000209666169, 3.006102756103581, 1.1706882460281298, 0.30310389340670807, 3.630667427503264, 0.22850012874823433, 1.6234496547130612, 0.2978087677613449, 3.034296218952162, 3.7304256435813157, 0.5747053589821418, -1.0530508605014646, 0.8198702752272224, 3.1127947359671144, 3.0057138700599917},
    {0.4496928329773427, 2.4391827478487036, 3.42622496867194, 1.1874280023220054, 0.3649879665469821, 2.3641976883984355, -1.162128532289013, 1.077002714246289, -0.26253396713341753, 2.849365990208858, 2.901362980395952, -0.8932995906444732, 0.08256217193350456, 0.5125650373908223, 2.2897217075871934, 2.115634403790202},
    {0.06607985104225754, 3.2631494413826583, 2.632096249259005, 2.205155079702932, -0.2376893567991412, 1.8426415681182917, 0.9235792236746985, 2.1829116710394643, 0.46547635307122665, 3.3116593244677035, 3.9672441607160787, 0.018570552002607755, 0.1930417461129165, 2.349959728399472, 3.8530086022332877, 2.34433831769498},
    {-0.8974965201452385, 2.8066274199693333, 3.7270992903185123, 0.08403142839288509, -2.094918075132586, 2.8490327859286535, -0.9948651086064435, 0.718016438169941, -1.8165639117312382, 2.0308966537261615, 4.183449279888949, -1.0529589708707985, -1.163475660596431, 1.1648063623143188, 3.55490344732267, 1.682812606566727},
    {-0.5458812788348735, 3.2794739180187493, 4.360757343333667, 0.7979238510872437, -0.32992469285268683, 3.514045820965876, -2.33132039732911, 2.0499682285730088, -2.1530129325172522, 2.0195058095475678, 3.977844344952222, -1.41567388713347, -1.2710712823972756, 1.1037446866700917, 3.484359564550616, 2.2746284367999037},
    {-0.3985008043040364, 3.1011444575384184, 3.389330814022156, 2.430569644830532, 0.03610857145971305, 2.9156522181691997, -1.2544618624208714, 2.048887227176591, -0.4754478154990743, 3.165744049176174, 3.1946826683841802, 0.1678353922093996, -1.716970498156911, 1.3734317662478754, 3.62680661796702, 2.183682875405184},
    {-0.008343022359246713, 3.40889013726327, 3.299049273393023, 1.316526070744175, -0.3013675274479692, 3.8877949380734087, -0.8605025897556491, -0.2331849220280979, -0.5658157180846306, 2.3926652985169308, 3.1618779820207714, -1.040954567497182, -2.149813507418863, -0.5310584682449538, 3.3578614211761932, 2.3480976035757752},
    {-1.9119902801677233, 2.02839242755215, 2.445682943058813, -0.7479652102604912, -0.06405186500076383, 2.884319431815088, -2.166042354389594, 0.7210920881182551, -2.7713741797313816, 2.853326056671894, 3.4392867466908776, -1.078687124305406, -2.471419643036523, 0.6077108592993056, 3.067517014709811, 3.3894306489211776},
    {-0.26830319250868423, 2.9804037177480702, 2.9604532753743062, -0.41746854239317793, -0.6215141332176816, 2.4387702033874223, -2.1926530338236114, 1.2771997829982729, -2.57313169788164, 3.4888489625827295, 3.776237223615898, -1.045712025356788, -2.573404077138275, 0.6911192698745046, 2.70324038174791, 2.5643154460162307},
    {-0.1741901918212891, 1.3475846258516821, 2.024323524959052, -0.8859023326439588, 0.5848372890787981, 1.8760901831767267, -2.4302899303919783, -0.07770301754952533, -1.5615919467139456, 2.4292188570848685, 3.2823893279347827, -1.4366516916340377, -1.5673123926095385, -0.247227586010988, 1.7250840485077807, 4.294582807023821},
    {1.176344596639755, 2.4184555366860074, 1.5910077183297542, -0.31744727457668914, 1.2162629233667772, 2.001027802947821, -2.244071030558839, 0.9312604580063855, -1.8631210893932775, 2.0972402924528297, 3.961092577428855, -2.2609858931383044, -3.0493787150103726, 0.919855127598887, 2.0755357586308985, 4.4619299954533},
    {0.8038960117736955, 2.4400274676688785, 2.4337941277606165, -0.46906560551634874, 1.1508389164991777, 3.1548108901899554, -2.8174866698497176, -0.03408214349612348, -2.8492488185323626, 3.0360896328466276, 2.318948008610847, -0.811052127381854, -3.530419993123185, 0.29637786935798516, 2.859803563045823, 4.285815578890483},
    {-0.17557046254997344, 2.547487490113836, 2.7111571877667155, -0.5943272041365328, -0.04109605609563529, 3.5085668690746625, -3.1157999908057543, 1.1112074257277162, -2.8608292212432525, 2.884579690871193, 4.438144866769997, -0.376831961476737, -2.182902964928396, 1.064721149072567, 2.6850334193917837, 4.746493003405818},
    {-0.34074289425355797, 3.7574582467715354, 3.0041927949741187, 0.7158344316843973, 0.13744150531765206, 3.408344367391411, -2.2950577292194554, 1.511080695353643, -3.189714073922995, 3.340679199667995, 3.2490981116340287, -0.7495340367599226, -3.3564862714197474, 0.4510179163451878, 2.729791615080687, 2.929048222326885},
    {-1.114578075140433, 2.7304764224764755, 3.0679948226243767, 0.7280773244928793, -1.0954755442787592, 3.003483783524446, -2.2210534651330622, 0.7088012679336545, -1.8940373665938712, 2.9218346600722347, 3.215900489520164, -1.255496944019795, -1.872701395230316, 0.5242453890001051, 3.122171142628036, 3.552908404186107},
    {-2.454473558040379, 2.8637764012960525, 2.6439498739804828, -0.21119148659031298, -1.7059652163422847, 3.829445820594535, -2.4139739421801476, 0.8991608179829665, -3.2901054614585585, 2.5795398330381007, 3.710572282437823, -0.38159050580858495, -2.828667079923045, 0.2724906348920831, 2.596712343638553, 2.0663177355884312},
    {-0.8417207859882438, 3.1372154434531105, 4.009359020890668, 0.37270762336597923, -0.877608812675146, 3.0995856523897545, -2.9989131043421953, 1.1494948393969175, -1.6920652708097617, 2.7810201728775463, 3.3988251307800637, -1.6683078463443783, -2.9746136589022445, 0.10020900947958904, 3.740565445189661, 3.1406895355893405},
    {-1.4373418469946997, 2.6404498229952917, 2.416429477314153, 0.38857060938977583, -1.2918833261023233, 3.9311002164256803, -1.6592725841513365, 0.6994497700018376, -1.8604099428780163, 3.240710522401416, 4.430153015286759, 0.43867018198802454, -2.3933206655622468, 0.7950290534440998, 2.8115239529294827, 3.549760264015446},
    {-1.2789340550926178, 3.4194590862182936, 3.603885080382191, -0.1820178255490318, 0.08634096643827863, 3.930321135927655, -3.6892677410236105, 1.6813340021430863, -3.6932507410970605, 2.9106889491647934, 4.242840679238647, -0.875700580603477, -2.8307714963835835, 1.2754490907350147, 3.4402822630628003, 4.050936417856406},
    {-0.791754459521421, 3.0528367673935284, 3.188138347483075, 0.7935857557766635, -0.6199827634042184, 4.344819173278085, -2.4273540774246882, 1.3496707364993115, -2.3715354490603997, 3.918495573765717, 4.171061603685535, -0.48775739166042853, -2.6792590559635987, 1.7102160043647936, 4.017559561042387, 3.84129535799342},
    {-0.5226246246025688, 4.33559694502927, 3.9467622786937766, 0.4442077289265112, -0.3656834114948871, 3.396200992777751, -3.1572962353949334, 2.3553818795214454, -2.4926540249039677, 2.259484756086614, 4.28419138494866, -0.9608311600013958, -2.4381320845057224, 2.0869002571636974, 3.3853634662122705, 3.3811138070503697},
    {-1.4580527507002088, 2.9155157965106624, 3.648582917691351, 0.05794639950348127, 0.3983318856040003, 2.074059102057655, -2.170122795174233, 0.36252429852773954, -2.906440155756512, 3.6666662371769374, 4.084204613835707, -1.9459434602054426, -3.0678520459013283, 0.5320710267730762, 3.45785711299433, 3.011220238008412},
    {-0.6608929803770129, 3.485484187861358, 2.751959929705666, -1.239376065899499, -0.5316980640672729, 2.968697101896444, -3.0501441826980855, -0.01266797723812746, -4.357226325266997, 2.9226005603179197, 4.6533338235200725, -1.9180669355287316, -2.7902595989231003, -0.7378779849521028, 2.194798062925714, 4.243133064498806},
    {-1.6343452268041212, 3.709596151087913, 2.6497545194434498, -1.038231956270632, -0.518474288215976, 3.402725429145948, -3.6415829436376645, 0.9662237914333432, -3.473596853369937, 2.435526822471578, 4.133083809489486, -1.679710889920044, -3.4491392355441177, 1.3027284743633611, 2.8273606404399922, 4.126502376037248},
    {-0.5580094771746431, 2.6508878712156316, 3.1222291088549783, -0.26958409007543527, -1.6467630394768435, 2.924218391103931, -3.9679120036123394, 1.404489295573491, -4.123238502889516, 1.6216262390168632, 2.843994227748464, -1.0069159394527234, -3.380994362170717, 0.07783398607291868, 2.2158820668012797, 2.5063438291252087},
    {-0.19564008033778282, 3.899515720189393, 3.8259085315524466, -0.6105288317814125, -1.0798832419848408, 2.7609363554746396, -3.9269745616065768, 0.7836276688736146, -4.030305897702746, 2.3253191482783224, 3.226340261236579, -2.6699538065184876, -4.022802737034509, -0.2860658307867198, 3.2252781500602623, 3.4100879439330125},
    {0.19184210381954678, 4.344520562501041, 3.555862744900412, 1.5976444777222913, -1.2872147691575693, 3.9220869931783953, -3.0644909079362916, 1.4316754576819553, -2.3604649471059056, 3.5117794496736496, 3.9636689775551486, -0.2647879909759537, -3.0777959616626633, 1.691331781439604, 3.6730008503249394, 4.215472121746143},
    {-2.226958625195646, 0.22807979927286445, 0.14719175640568774, 1.8082944109799948, -3.28125010568973, -0.39457644104596135, 0.1168873319812176, -0.29536479364512574, 0.06614165908843261, -1.885211511297457, 0.02065303461979762, -0.623403487280735, 1.3836691450370255, -0.1585595895686919, 0.5619129633981458, -0.06935291055792044},
    {0.7715515217670412, -1.6473148045606378, -1.052353489736479, -1.3316957000765925, 0.44516600583366145, -0.8814819598872904, -0.9344367092972032, -2.162361240925843, -1.713250236973097, -1.973179476987902, -1.9828907552434265, -0.46609493949252, -1.9990638628646877, -1.540332625730006, -1.8882476575320983, -2.4544230778949867},
    {-0.3273052618122032, -2.425794574624168, -2.1791579484937436, -2.836204816962404, -0.5387014499846161, -3.573424656510395, -1.6192923563380652, -3.3581317373311323, 0.006507409595868747, -4.006568292903475, -2.396111228329944, -2.9059374865536483, -1.195347219479257, -2.457857623276434, -2.940909191054715, -2.1636065127390376},
    {-0.708155921267016, -1.2611962064553968, -2.410888134758251, -0.591551939856972, -0.7891866318851785, -0.8900860508511073, -1.6524768507888692, -2.4035639923852385, -0.8657673422122147, -2.3004193897912013, -3.077497867611373, -0.6063545261826856, -2.146688460132769, -1.9898533488511985, -0.6664877357303564, -0.8184032930765703},
    {0.9430785592902641, -1.5180033092592833, -2.4427605040989593, -3.169201552230854, 0.6617625603235042, -0.7196569141970476, -1.753277502214115, -2.116302972242651, -1.2264055995641423, -2.2097313969467307, -2.2846455483018437, -2.613640649653925, -1.7963920521560368, -3.174939879343984, -3.301393550996016, -2.187391013303889},
    {0.33073567797973263, -2.5175069575905806, -1.3671725393917442, -1.5165836709744758, 1.6082019277815982, -1.364689578207969, -1.3566732866729927, -1.8813051430438235, -0.2977927130458709, -2.568926341935897, -2.8617973268094548, -0.682385576002999, -1.4757182115825696, -1.5032811517366154, -1.3458970212318346, -1.8273216114912332},
    {0.9351645163187413, -1.2476510072196625, -2.2076385067653423, -1.6441832947013046, -0.36091652042089645, -1.4037113209103798, 0.20764504060491557, -0.6388263366461892, 0.4031246270290297, -1.2143423681284706, -1.3001427036573712, -1.5317757449937588, 0.2990233292864576, -1.211489465368972, -2.053445081169093, -2.477180813400433},
    {-0.48141181191948984, -1.4148480090157594, -2.3245077792084112, -0.2875229435997926, 0.1713145771755146, -1.2719424852389616, 0.1563458523403569, -0.129650540474712, -0.5110394933273271, -1.8498343635851247, -3.081076164303203, -0.746583162946317, 0.2249427330341667, -1.904130141404136, -1.5683081197594695, -2.428333778503707},
    {0.3814927614476329, -0.5179382076569365, -1.0774830566833957, -1.2012907497077858, -0.030071703554775755, -0.5537277675214526, -0.6465037707820523, -1.770965657192504, 0.12652603253266878, -2.910538403347851, -1.4053449616614668, -1.471646630459312, -1.130940365712799, -2.0577703212329292, -1.2689246420759566, -1.1409279795405167},
    {-0.4447032427235936, -3.716974582258509, -3.38067875563555, -4.107511953261213, 1.049807253696788, -3.046272973940788, -1.6549014732510725, -2.98696073767797, -1.780097022217458, -4.033378724450075, -3.1596206225676378, -3.3173014465851662, -1.8716619615652919, -2.8130476961450577, -3.8695405799331195, -2.5654539196041},
    {0.2139295624858282, -0.9216331210535537, -1.8448155535819137, -2.0486496025343897, -0.9294578875738942, -1.7643741030901625, -2.2669211828446527, -0.9861405578688974, -1.9964048988214382, -1.2421847063520401, -1.2406092194989076, -2.9066808277010225, -2.7005362464124376, -0.7584450076347922, -1.901084424513706, -1.4813210307715285},
    {-1.0400566529023354, -2.979384981775538, -3.2508330532993277, -3.691352026645047, -1.295285075415553, -1.7035376751618498, -2.5646359802312677, -3.324094008124928, -2.235324009145885, -3.6951782862863642, -4.5076900954787025, -3.4303065187173214, -3.0219701541861967, -3.5351537057706754, -2.8690332820645983, -3.9001738290416625},
    {-1.3385724602052873, -3.017527272097675, -2.992310273051542, -3.152163284612519, 0.25978209430034477, -2.8260456539319825, -1.0868112437398172, -3.40413434153164, -1.2979020740623923, -2.6651373591682295, -3.4717614510708206, -3.1911102440637853, -1.4282684245854012, -2.6168627334728707, -2.430018138194325, -2.672799724268857},
    {-0.2958878241002704, -3.4729582029325807, -2.006309522046341, -2.575787363477112, -0.6509056232518005, -3.06417077891484, -1.8232467353824988, -2.3833417261865875, -1.094688358524779, -3.5597622770366737, -4.117776767748347, -2.224045381242146, -0.7960221123335738, -3.010626804689344, -2.6548831162725306, -2.2766983546269626},
    {-0.7491184135924204, -2.452371979239878, -2.3190401800601355, -3.5053531795353967, 0.22581612738938847, -2.1166175891633543, -1.280566846733329, -3.066812683566946, -2.046932165407374, -4.44985560691955, -3.3218146695625927, -3.3878146791716595, -1.4326154036100431, -4.8067453284125, -3.42715471287193, -3.7380364565219932},
    {-0.0959320928768653, -3.2035421545465823, -1.8613312864690672, -3.9551615541783547, 1.292366969956132, -2.9975152303963575, -2.0208242087142794, -3.881092868890916, -1.565190421838298, -3.787193038140988, -3.453023935037145, -4.02142326421804, -1.308554506691256, -4.244412884603915, -3.3164767040269996, -1.5592511130590656},
    {-1.2641747691967269, -4.014174837551437, -2.818313617206726, -3.873407318409521, -0.4397659777641618, -2.6315463643219967, -0.9110802375895047, -3.3929949254416245, -1.3894823550040398, -4.384029220534882, -3.3466651458046845, -2.8022723821828137, -0.34772257942613216, -3.0741163332629298, -2.3013646890860184, -2.2623506067603887},
    {-0.43460649403435697, -3.2908294140006897, -3.5580944841855744, -3.8584713748494996, 0.3418036073314132, -2.525295900239521, -1.2147548312014154, -3.919152298086579, -1.486497988421246, -4.851333277424713, -4.813417773678225, -3.094360836678426, -1.9466984999333368, -5.0718543906917715, -3.7791668219375714, -3.266290322419423},
    {-1.4972795568303463, -2.9534577979691488, -2.858697855196373, -4.128077000116081, -1.1494427485444951, -1.9214096977669997, -1.941429362596265, -4.199047705699637, -1.7396011665444104, -4.967265011356869, -4.415637930280758, -3.574688217005036, -3.13614062733575, -4.623081890152192, -2.0752687747765015, -4.7928767987366925},
    {-1.0538110688571383, -3.0511934803887995, -3.152860992115311, -3.0652262680920086, -0.5443538968129957, -1.9435454769896732, -0.82584071572364, -2.5631572945308183, -0.43689184008850046, -2.789416630411181, -3.6567183077150873, -2.9716669585030924, -1.3317934105626434, -3.2013182054283393, -2.808992685483524, -3.1094907336916218},
    {-2.05055481956919, -3.6563436875539193, -4.364702915885651, -3.2540408317975493, -1.3683886080207495, -2.831037204552009, -0.8586801320637145, -4.662704171679625, -1.2260994369147835, -4.1900920580732475, -4.009441986220671, -3.0186802715958603, -1.5638547687788291, -3.6082834269843165, -2.840387892885829, -4.943977684914345},
    {-2.808591542206689, -4.866772090624273, -4.421119315254267, -4.671756813400764, -0.6794853833433404, -3.826130976892896, -0.780579374069432, -4.116837254432781, -1.7052132647824942, -6.215877449831883, -6.032403044275087, -4.583159515617395, -1.527541698544706, -4.75344733764666, -4.688082220140283, -5.756046903501411},
    {-3.138047648881307, -3.0304965235760966, -2.5247304098534893, -3.275398440293987, 0.7541490640099938, -3.033448162088761, -1.1527591738512504, -4.833692355680522, 0.534467596493166, -5.4299462243987655, -4.3156303696851355, -4.608646277477203, -1.8174973334728934, -5.204610492928754, -2.780595287042841, -5.081197480870245},
    {-2.4608765622056836, -3.4791873543826775, -3.836951112056926, -4.956079288905733, -1.1649658282929765, -2.140470973903923, -0.7461384291759168, -4.136845275236459, -0.1021837945505365, -5.523848270713391, -4.806144891057293, -4.684172591090764, -1.1409145423038032, -5.735469687913106, -3.004010787915583, -4.9644246269729955},
    {-2.045837805885629, -3.8378250478520997, -4.268068482028856, -4.20701635920467, -0.8291313076923701, -2.5788439789914483, -2.566425555601423, -5.018015751900236, -1.615019765716893, -4.987132946176723, -4.565325177377231, -5.214201539015003, -3.497804355128258, -5.228717176097375, -4.753503988159019, -4.031975756266864},
    {-1.4359005882478126, -1.7813817590218861, -1.8136902838095599, -4.916439301026442, 0.5637249394419132, -1.6346418389282182, -2.638751428722554, -4.140729556701475, -1.7643220871442182, -4.4839428777910815, -4.221002330148199, -4.482484003361214, -3.1976909114251146, -4.699659994520345, -2.644343676864974, -3.374657418375695},
    {-1.6432327586693414, -4.007051227153769, -4.7751084756791, -4.049847052302302, -1.2714929636763095, -3.015780945098828, -3.309869807839726, -4.550467493954401, -1.5509380943975766, -6.141030782366693, -4.532044546235115, -5.631207793219552, -3.894839493876244, -6.5260180019342044, -4.3112376383189295, -4.592881241769319},
    {-3.3271412430946543, -3.1920285111010167, -3.8118928457238637, -5.107002305795795, -1.251828288883111, -2.0679134260801297, -1.569441530728692, -4.933713343044936, -0.9618025186288741, -5.420725830364089, -5.8510607783570165, -4.677364065813477, -3.125766751675644, -5.5412524118589666, -4.964074904820167, -4.842057175148956},
    {-3.6659412077112044, -3.335378898919167, -4.866631658971177, -5.675186472549802, -0.8407373560353106, -3.19331929869043, -2.514395773787591, -5.531968155452924, -1.3315177338176651, -5.4708476460393936, -4.775069780864503, -5.086981006110028, -2.5381961609633996, -5.789424004813672, -4.906939460907499, -5.6536044233167555},
    {-4.171715187618909, -3.1755221169631973, -3.5130027731403985, -3.2031807003684842, -1.125586264219565, -2.919108740639456, -1.5739220756705337, -5.846767754077043, -1.3283121538344238, -5.494201869990536, -5.766858487841487, -3.993342458409803, -0.3914203003428176, -6.6180478599479144, -3.6617019158085236, -5.17215212241774}
};

static const float b1[16] = {7.484489700167946, 6.727373162042188, 7.057454283043905, 7.26848257584855, 8.067870528359135, 7.216930664331341, 6.908009561284849, 6.787130719629185, 7.500254844316797, 7.342925535258186, 7.562785527067825, 7.670828491083209, 7.6414876868220025, 7.121205972615846, 7.40939285267669, 7.623161788100009};

static const float w2[16][12] = {
    {-4.835141311237623, -4.869863699023901, -4.7208189889072365, -4.455526410744571, -4.71430609170806, -4.1866301798982555, -4.228957901527644, -3.8466299560719466, -5.290575314487964, -4.477355184681379, -4.411707458454461, -4.757078562139697},
    {-3.1066251301238057, -2.789282160488298, -4.269495088117977, -3.2001651704856857, -3.173235764747821, -4.356884696327177, -3.1795541882057283, -4.727789496207618, -3.606001392311715, -3.118471397378395, -3.1300905680044484, -4.514955489045498},
    {-3.6022268963832085, -4.583849774392668, -3.5263604831536206, -2.8042178095858774, -3.5199703456117395, -4.607609388539841, -4.8654193526148966, -2.5588803175869708, -3.2727199985679976, -3.5539348264484927, -4.621665160494554, -4.400461007628201},
    {-4.104755353996316, -4.218551191185669, -3.5119379205923313, -4.729220793907377, -4.2063904465197846, -3.608308395161093, -4.251670788467158, -3.1881897943551545, -3.3409038401764244, -4.107268938809343, -3.1273152730223055, -3.5671474848278186},
    {-4.416229333286534, -4.4760555237253286, -4.750657339870464, -5.317796009448058, -5.098616343498807, -5.223017888847498, -4.935417908650547, -5.356054041188784, -3.9208999294144147, -4.853458796430665, -5.038525828979982, -4.352636668418426},
    {-4.386043574446599, -4.6184654305226, -3.651332053952946, -3.7987002031851933, -4.413203701078684, -3.651229895663282, -3.8684444245232057, -3.3716521640675956, -3.046462987370422, -4.914857741668626, -3.1921605038511935, -3.5172531270404996},
    {-4.284409665628107, -3.661786555800917, -2.9822976497319744, -3.822631901667323, -3.018763498401257, -4.221302648020068, -3.966620511782667, -3.502960873026231, -4.301571073816263, -4.904138402674422, -4.367299823185653, -2.997297992252395},
    {-4.589336443597534, -3.3602005834950233, -4.426844713250614, -4.337757743466906, -3.0238026641546294, -3.7803690613084817, -3.6805896468415007, -4.9976504101939785, -4.547102558895045, -3.635924413025373, -3.7881197001358022, -3.2828806896180622},
    {-3.3619163391147806, -3.267606964073136, -4.3600303050913265, -3.6272136196737397, -3.6545131799906505, -4.01787146468477, -4.5869588550810985, -4.430393926251292, -2.915170038069948, -3.2935297351918855, -3.6859534325373624, -4.281482596387378},
    {-4.217897689446427, -5.178736341091465, -4.016200695596283, -3.6145940255978473, -4.270712489156488, -4.765263767216616, -3.388869961838309, -3.2262365135595203, -3.7167452279967312, -3.6889758598649816, -3.7396532545215337, -4.019790742834041},
    {-4.534761282572102, -3.5407505539876243, -4.3271647728056735, -4.8169797950298765, -4.68299035965842, -3.6921992419532685, -4.568045638504064, -5.062505601376618, -4.886113612095829, -4.778248959904584, -5.033856729318492, -3.385623065089828},
    {-3.2114669658523143, -3.1249369943412595, -2.918366360259021, -3.392001599163038, -3.716707213704004, -4.042135434498232, -3.867006794275436, -4.766430901315786, -4.6754778494865255, -3.2611782308854114, -4.692958408508115, -4.446989257587443},
    {-4.4518672612511745, -4.633942498108536, -4.626225484656406, -3.9719591842579978, -4.779146665678424, -3.046728298223769, -3.2087383372102614, -3.528183387196939, -4.336617824228023, -3.543118570297913, -3.1880712654774426, -4.3918981020690415},
    {-3.1092539116955846, -4.863906472596643, -4.453891683403706, -3.40619961896773, -4.228358712401991, -4.5038947347571145, -4.0100156232898465, -3.3051611376281778, -2.970017912956958, -4.6056505605964695, -4.335958207214604, -3.6061997211262318},
    {-3.703082344652598, -2.921774254710597, -3.695549225863591, -4.922196401965844, -4.006539330539706, -2.56429387136853, -3.41863703611277, -4.262875137438384, -5.092740884982501, -3.3854658793995718, -3.9665258020865872, -4.072791868512065},
    {-4.378599715604219, -4.177910238798097, -4.016131086216118, -4.151600663248282, -3.7710729321888534, -4.100598143993464, -4.387107596548148, -4.273410758426545, -4.373944165132049, -4.082278504533952, -3.9223407052369708, -4.657843485024729}
};

static const float b2[12] = {-4.625678990314597, -4.825258783963723, -3.7428458464410763, -4.219520820425559, -4.801960749776703, -4.1411195226733435, -4.438557419154657, -4.76156744164503, -3.129991927834671, -4.541364260305694, -3.216258870776299, -3.946068753591545};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
