#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.8574335523809311, 0.19474604091688041, 0.344128252932186, 0.34128393850728117, 0.660262733219735, 0.7288047562129505, 0.4086504161876023, 0.556863203381442, -0.2208938425228387, -0.03526165691276577, -0.5794111176107435, 0.7751356026627748, -0.30407212545211965, -0.16599240346558883, 0.581884571918561, -0.476961088824076, 0.30501977613800396, 0.1929582053253246, -0.2880558840745328, 0.6542013813383034, -0.3190804373487621, 0.7982980803046275, -0.19671641396237974, 0.7715612088248313, -0.49144147572040414, -0.30092522679057604, 0.2777965017299625, -0.5388866414800357, -0.36476657089605025, 0.6640458543027413, 0.8349130472932041, 0.5892074217143324, -0.4883013864359002, -0.029319449299668954, -0.05707297283931682, 0.0854767099829684, -0.04475022818822528, 0.21866786870782878, 0.7361991266008708, 0.839650755450218, -0.05022099032028857, -0.26519397511943116, 0.045650662950639395, 0.4090643734744849, 0.6419541697473209, 0.7226713795220839, -0.4059144660812117, -0.3514573574013091, -0.41140791254593645, 0.7834041515512035, -0.09123095626022237, -0.2843225528034312, 0.5592836193240399, -0.2500999705905146, 0.7455143049030646, 0.17602011994849417, 0.7629852484776337, 0.6641816931536099, 0.6363924637004866, 0.7261568193747105, 0.818923768687669, -0.3363214103823918, -0.11576731161607917, 0.5146418587088689},
    {0.5079538722950782, -0.3591819143801147, -0.009191147584360185, 0.8105225838935392, 0.5164511357757997, 0.21145251856673716, -0.053527252606025616, 0.3692090642197783, -0.025621575152913984, -0.3854466855939876, -0.713130332997687, 0.4553249939382591, -0.7990225336997617, 0.055404751737540246, 1.0034961904269517, -1.0230503711319983, 0.5402214133335496, -0.3077226005689768, -0.09967285787550136, 0.4221359561813365, -0.7297153382387858, 0.7569827731181302, -0.4986625085808993, 0.44755078476063803, -0.5646223637095833, -0.36685516096757487, 0.29865018784396424, -0.5848446534941805, 0.2425397720552265, 0.8304126850763575, 0.892055928235166, 0.7557127162637426, -0.5765121935937232, -0.15654485202692006, -0.5512874700101802, -0.14539254994830844, -0.2996955084970979, -0.5953869192626783, 0.8965405247004664, 0.9012069820420949, -0.10259315492133773, -0.14205729887799448, 0.5263350838776764, 0.7369417625882602, 0.13161437643032944, 0.7322716817454211, -0.6458899223355024, -0.7980809972172331, -0.27596103458809174, 0.8421256650017305, -0.13976509642117324, -0.5952354921732884, 0.3347225921660222, -0.43401997864573194, 0.15604632297807, -0.44991027293788344, 0.6746214341697035, 0.4086096952458259, 0.4634690454867176, 0.556654940257042, 0.6910612326268574, -0.4256721755369218, -0.37268844165420634, 0.9351669223295315},
    {0.7829119499943131, -0.14919309007099904, -0.10748550712523804, 0.16687516915607578, 0.4294495957667897, 0.13656101644024596, -0.27169639550127983, 0.23440487809500704, -0.4404016641554339, -0.5676850129399305, -0.7471890210266677, 0.9655026674910956, -0.6194622751879227, -0.23183476104053352, 0.7110606099041887, -0.5879526597916248, -0.001696056692407492, -0.518797793437146, 0.0015672915756873066, 0.2997132137361389, -0.599225079425231, 0.9751012011623589, -0.6128434542270438, 0.9845184276575181, -0.9637795814757848, -0.5748354485345434, -0.003617599313371807, -0.6390166012933167, -0.3781444853820742, 0.8569288588853132, 0.9813260192375387, 0.862564248089511, -0.6529896237508973, -0.17836360495690826, -0.41580544435702915, -0.41759030737358016, -0.5722387591334483, -0.6953679066354853, 0.5183801319222076, 1.0090618193588525, -0.30732287941505737, -0.4893211823389062, 0.08991918300085491, 0.6546679430823221, -0.10565507279217144, 0.8831550856751608, -0.8543868846969376, -0.9001944346349361, -0.46022071209158194, 0.9220763635067258, -0.5090945583178563, -0.6582181717872577, 0.03508001735784152, -0.6247547311296141, 0.41196846352044025, -0.4450341984095397, 0.6188773804405513, 0.6947202968534137, 0.5240029936493528, 0.5314600018323203, 0.7421868067317892, -0.6493855077785867, -0.5350475918174992, 1.0147238647634353},
    {0.5872132068468944, -0.32785304317993214, -0.6206672776686574, -0.27314281146520414, 0.2661350988934724, 0.2405876007419228, -0.6097342170797291, -0.12769654179807963, -0.49812514215505727, -0.7265430171890461, -0.892553973655096, 0.2568648066803609, -0.8244216689241419, -0.42683570206063426, 0.9143715726286282, -0.8452425556826452, 0.20354892988919585, -0.6102882797388361, -0.4461331458441811, 0.7367774023074306, -0.921847624103849, 1.0001142575696909, -0.5936043050327234, 0.8621494208403395, -0.9659445880310423, -0.6291178678566698, -0.10470889632818844, -0.7370631826659796, -0.46417239497458346, 0.6857647906010477, 0.8465174137953244, 0.7027906189612098, -0.6855304620262989, -0.2524769321066526, -0.9105819502246192, -1.0179805799908095, -1.040928129054302, -0.7433602206339869, 0.7483008932956698, 1.0418130377230426, -0.5606167270804286, -0.6517071508018424, -0.040313405926142375, 0.3465567030253708, -0.3547828988477623, 0.7668225012486606, -0.8133236197451038, -0.7573251428079282, -0.6394130735803115, 0.7567963703518383, -0.7727431077367911, -0.7435677279572583, -0.34350003863950734, -0.6139281532531179, 0.48824613156811936, -0.5443691613569073, 0.3075748404359269, 0.509856722418554, 0.3122284970917891, 0.5930814823712319, 0.4176264284953709, -0.7783847401379604, -0.6672537078332218, 0.7052998355283232},
    {0.6233314302585665, -0.48362601296500213, -0.7330898282801588, -0.504885101047303, -0.3486414419736552, -0.13196372365927617, -0.6586645697517736, -0.5476055520086932, -0.7058583537630885, -0.9331860397527483, -0.8733765342162015, 0.27573008696471296, -0.7129025765344027, -0.6254605282291263, 0.48175556640264633, -0.7668700467873886, -0.07425208544379815, -0.790842772460527, -0.3269227164978062, 0.3055970937943207, -0.7835100594757104, 0.7456965262186872, -0.8635779897949725, 0.4260371131014252, -0.9048984528445922, -0.6324728337530304, -0.46912140629673815, -1.025894035001028, -0.7216990959268692, 0.5034062554672168, 0.7447355967694191, 0.3783945864015281, -0.8697217699729304, -0.6889420610415868, -0.923570773586384, -0.6964313421210068, -0.8491193011431423, -0.8600833583503821, 0.3058599528103326, 0.5948080638632672, -0.7990217903122522, -0.6313362470967117, -0.45298264055418447, 0.6866438336350923, -0.7233540722490313, 0.474904080072064, -0.9474624955219287, -0.8548466714244277, -0.947112262636379, 0.5989513096435701, -0.5789988357965832, -0.8834197379632329, -0.33190384428114, -0.9155395843472753, 0.2978101058661539, -0.46301911876206514, -0.034266651079827425, 0.18921268932408208, 0.06546003532149619, 0.26824895909561225, 0.1496424594046523, -0.6868144704894243, -0.7274729725611581, 0.5469749353463417},
    {-0.005215896013941389, -0.43453679451537186, -0.6215833960763617, -0.609763018053688, -0.1714664200284201, 0.04575311199395907, -0.63925090589081, -0.46261951393048945, -0.713685881063621, -0.9092454010340847, -0.9775024524891119, 0.2957721172583097, -0.7514191252044917, -0.6633243225158638, 0.3258766730026656, -0.6673334507359006, -0.07871090024626343, -0.6474104011656975, -0.5017945453455073, 0.10492334299200215, -0.7175310490214196, 0.4269875602059729, -0.7949791978433339, 0.5352766893788585, -0.9004629660179231, -0.853248914770267, -0.36452120074838207, -0.7746536665070303, -0.7062815626572949, 0.4103691809405642, 0.7582351292555813, 0.2347053811468309, -0.5354622925580974, -0.47184779412859396, -0.9516123305656918, -0.8584949529558054, -0.956517048104418, -0.8430642440407466, 0.3125237433077357, 0.16181762245664696, -0.5691029370032185, -0.7968892725919744, -0.7100189191335138, 0.24497489148913987, -0.6697087054943186, 0.43124453989254974, -0.7619515345096902, -0.6299346191931243, -0.9370793653386894, 0.49308886996178397, -0.8989649985538051, -0.8155722732074445, -0.3781418290514788, -0.9034548507758147, 0.24962507701692685, -0.4142005521186893, -0.35626161052527733, 0.19623137279449138, -0.04086243014047502, 0.022363121910109085, 0.1809053902196797, -0.8702378419198646, -0.643677977117933, 0.480170504238957},
    {0.17321223763943044, -0.6298189070284638, -0.48429147858359534, -0.5382836567142563, -0.25833692443042044, -0.1340108565029125, -0.8025391028494598, -0.3545510505184207, -0.503312482968941, -1.0299343648605452, -0.8733356615781823, 0.16667085271014193, -0.7249954953795105, -0.6513136879992297, 0.5635421780375995, -0.6942803790679745, -0.058593768969736566, -0.8147959074001155, -0.22182320596154195, -0.07886929904061503, -0.908508941824421, 0.4408915332456678, -0.9195343257152715, 0.4969645174304375, -0.7956204899117665, -0.8637921051361425, -0.04413130721142633, -0.9126541752497751, -0.5511606094323945, 0.41543937564231176, 0.18357622254783934, 0.19494920834569404, -0.8311896794466712, -0.6699571446840933, -0.6874689693985323, -0.6836502631740979, -0.6802871154251946, -0.8374906214621248, 0.1402140836428637, 0.39074637421084296, -0.6723819481979209, -0.9003226709475873, -0.299543742765543, 0.5142873346862953, -0.8130622353314293, 0.33120500542871667, -0.6896195366525752, -0.6364657743626203, -0.784044186404397, 0.8088464912558326, -1.0545767049654196, -0.6063199359523753, -0.6289080715201465, -0.7776702573197117, 0.21539353458498162, -0.39566617077447425, -0.315011655897946, 0.3233348066924089, -0.18711521093509112, 0.22209879278783465, 0.12851839110963564, -0.8874169188355724, -0.8971536667722135, 0.4462790445249405},
    {0.28944746718979847, -0.5989238573160997, -0.8802151716962483, -0.7157822801822155, -0.14007715487205666, -0.11038176569638461, -0.6113715403496041, -0.5578250609217273, -0.6659761950166366, -0.7706444520045047, -1.0732276984969786, 0.3368947482771387, -0.7707563910977401, -0.6508147532690088, 0.6812574078098115, -0.74683813395964, -0.06683606384401908, -0.8055104689244412, -0.8363196698207407, 0.5990213110934671, -1.01707600794178, 0.5908207951867146, -1.0506509310450938, 0.32196947917749125, -1.0061391964856148, -0.8408660186059976, -0.3147387698554109, -0.8869009842266607, -0.560980463735917, 0.4618516368380256, 0.6914174393686539, 0.4151596676302699, -0.9935162084843244, -0.7511440187390557, -1.0323984579744718, -0.8205655203157196, -0.7362318954819246, -0.7942963979648705, 0.14505498840368053, 0.42536724625431155, -0.45966927778410527, -0.9875856306566885, -0.29326671572796764, 0.3920400561871182, -0.6602839873451015, 0.315414895955868, -0.6605171228168968, -0.7359539549436674, -0.9545695191537765, 0.751977448468318, -0.6987335361288226, -0.7885360306911045, -0.1467351191006274, -0.8431921865764387, 0.2853340637221665, -0.5101359891738053, -0.07043460441340194, 0.30723038829997046, 0.1640276981944722, 0.4172244012481899, 0.3180074775411746, -0.739422959620683, -0.7423901157472877, 0.3616459929949041},
    {0.6615586585586885, -0.49406090098429456, -0.8230976591495921, -0.4050102783040555, -0.14579346263833914, -0.053634023625634644, -0.8850736861021872, -0.254792195318711, -0.6007402004012464, -0.7249841553917152, -0.8203158479295285, 0.29665295160463984, -0.8293481750125893, -0.7837359842078316, 0.4193583147110628, -0.5780360199934362, -0.11986681134411431, -0.9124789150014282, -0.5145798003031339, 0.08502415345283042, -0.7983963757627567, 0.7279055824474024, -0.7903269615051467, 0.3691998149325627, -1.0063308359152372, -0.7401343843227288, -0.798455449284995, -0.7699888880667585, -0.5741270879418325, 0.486752885046232, 0.8035449328198451, 0.6881348326662676, -0.6938806151954378, -0.5928467361660946, -0.7780660116611795, -0.8466634199809373, -0.6586692289806528, -0.6420125746187548, 0.4676990613001091, 0.5912042742621836, -0.7672997635162184, -0.7100621391017562, -0.26385347481487886, 0.3114954116395014, -0.7190208782074837, 0.37552382387798544, -0.9138614161029828, -0.6770664811324782, -0.9508316395070748, 0.7705429679617656, -0.8535514341693641, -0.799941894084085, -0.2023419719263887, -1.083038379520843, 0.263304253478775, -0.4915093705111339, 0.1766931281361629, 0.4132309801889802, 0.13662906792665885, 0.5518722442092374, 0.7413737896175918, -0.7911238154850729, -0.7865957231087769, 0.6716331340984876},
    {0.8623619104581902, -0.6109406293592822, -0.21284806011718774, -0.1119969011754266, 0.04556895843858551, 0.17416728327887454, -0.2928526507390336, -0.20131316917631065, -0.8328752644953148, -0.6211949540865395, -0.8079302413891983, 0.5479263614351978, -0.8128621154961148, -0.3319524131159515, 0.8097290120448446, -0.7207668488151856, 0.2170797026451691, -0.9251056323369321, -0.29997113875317244, 0.022418145601115057, -0.7529954847780859, 0.9124383192598542, -0.6803772122032675, 0.7395356389819636, -0.9559061041716321, -0.6649625647873417, -0.34122377148385113, -0.8424433060194265, -0.451812414928344, 0.718778084924503, 1.1246254847126893, 0.51810751972383, -0.5966847136977829, -0.48933646875282977, -1.033193717592908, -0.8414484143384384, -0.7803948790769605, -0.685659323323886, 0.8050357867532708, 0.9610734156340953, -0.3610896751516414, -0.7514143839062879, -0.10073974790283703, 0.5853482524950963, -0.5770378190409129, 0.6290396309531082, -0.7078111964208322, -0.892749996196613, -0.6144528216098462, 0.8027390913448103, -1.0273915566662741, -0.9409564399435113, -0.20050266806988706, -0.7736196007093478, 0.42659308544539243, -0.3934369636183622, 0.20967476974135396, 0.36471530812742614, 0.3147574886042584, 0.4720865255549344, 0.4684520374738867, -0.7984023178584813, -0.8017695243756923, 0.7496014007961458},
    {0.4103652407647302, -0.44252436544997237, -0.5700593420847719, -0.5330241616480492, 0.4920417962386929, 0.39384451376171115, -0.528056852686045, -0.18865574234251223, -0.7366610339289965, -0.40705664206331055, -0.9320642655576075, 0.23848678335859255, -1.0398797161309143, -0.11230685962727492, 0.4630514679068196, -0.8699811191423954, 0.2622030410467305, -0.6546086196192659, -0.39590400469513437, 0.30661119070414916, -0.7788850333527199, 0.6247178021342273, -0.712748494807448, 0.5745380030885964, -0.9600798528511477, -0.5355282272988687, -0.12207775615192216, -0.4779385579234489, -0.7572183993602909, 0.3909043845626163, 0.5469886264686457, 0.4135480651143145, -0.5642875338109367, -0.3988251849210839, -0.7536866411691346, -0.6539418431372995, -0.6508062039088941, -1.1314711563225193, 0.6433190641127494, 0.739911381698771, -0.46926000643778387, -0.8088443930850993, -0.11598079387499667, 0.5450762827264624, -0.42177919855631785, 0.6561386157223166, -0.7466875797707263, -0.8757022680151977, -0.7535948037900838, 0.8843290591307319, -0.8588846295989326, -0.8411962907568146, -0.19075217592325555, -0.941073853458891, 0.30153526402284225, -0.30534120530644215, 0.29906816658408425, 0.11413318862899252, 0.3014879242927656, 0.24099527377935429, 0.45528309765015706, -0.7093842173834455, -0.924956859251874, 0.7356234162663019},
    {0.5382063309766055, -0.29949121071688795, -0.6479728227481494, -0.4278702639655134, 0.23809829428083656, 0.22753060853554724, -0.7987078458569913, -0.10843849477808566, -0.6573086055051476, -0.663906459297484, -0.9554876838741444, 0.30055139128502456, -0.871089367830729, -0.4215065509100322, 0.43493195000186247, -0.6970628065828811, -0.09064553897800813, -0.6960421841085614, -0.5523164247916853, 0.38880983343941344, -0.7240651240226889, 0.47639937883289224, -0.7240650251794891, 0.34564262159860204, -1.0642011584403457, -0.46407172506235733, -0.42485795870263143, -0.7803171300006305, -0.7470844137485677, 0.25273837444259317, 0.506251377274263, 0.15565677040253548, -0.7316026620311973, -0.5465421837498823, -0.8415140629199893, -0.6246375074363169, -0.7890631466126183, -1.0087032213488885, 0.1177887036955829, 0.44802462506470286, -0.46501717338912923, -0.6637050005900514, -0.06923995817434207, 0.3389511047290268, -0.3970322524549444, 0.48195415641837663, -0.7202057385649787, -0.7833468355639465, -0.7333660868178364, 0.3457533308040961, -0.7255797515661205, -0.644683159552274, -0.35239017396086214, -0.6510150817061429, 0.29798920148014546, -0.5289852435235678, 0.0017422650107553242, 0.708271572607828, 0.05038889812337152, 0.4898693141641911, 0.22404974923292986, -0.8595143948431485, -0.6434078144545664, 0.6014076306575697},
    {0.3847219981587329, -0.6075562388092238, -0.6392633929782453, -0.4915894267602374, -0.08249135342773299, 0.028270655837180747, -0.6103543524235283, -0.10252348219963765, -0.793972931539295, -0.5487186590099805, -0.9371902080816572, 0.5071677831176307, -0.6867682003954758, -0.4344020451658379, 0.5499343267233324, -0.7463663709914461, -0.019136740984093348, -0.8736131207438915, -0.652351062441417, 0.1696086635296225, -0.972020586881545, 0.6711387787010495, -0.7614863236920355, 0.604935791302667, -0.8942053135639982, -0.6156048955296223, -0.4977731449600422, -0.5764308788520377, -0.8354751589692739, 0.4402032981690422, 0.48389458945944364, 0.44546020495700445, -0.878776838173549, -0.4382499644538173, -0.6937098998256396, -0.7270161441075205, -0.4527490893250895, -0.9671855819095635, 0.5501189750931288, 0.7041478530814714, -0.501578214731064, -1.0264684998140456, -0.0739625490566869, 0.5325073926946314, -0.598440772137239, 0.6057086106289885, -0.4339271607912339, -0.62769504653333, -0.7484162784988961, 0.45312244057422557, -0.6720070358836807, -0.9141834337858834, -0.0066357126078064755, -1.0899018220641972, 0.3366789328411411, -0.47844999283614903, 0.11292187648980698, 0.21291732732632038, 0.09198761182960331, 0.6249268440902405, 0.5681256093371659, -0.6044348337952584, -0.6927943131260819, 0.7375067907392936},
    {0.7355502929141928, -0.5879487299082514, -0.7418006107742847, -0.3201834906157975, -0.3097628549534072, 0.0023756603099318488, -0.5546731451790855, -0.3188429982319345, -0.7791032902999652, -0.8916358103427522, -0.7653890811210725, 0.5822160062971735, -0.9650617585800021, -0.6083321059574868, 0.9144228113646695, -1.0105724307406128, 0.10378696932668906, -0.6677901619512746, -0.6828921768264168, -0.04376261354864061, -0.9417965338086003, 0.8719228408813856, -0.592081322341137, 0.665100196594385, -0.9463738531644845, -0.5076397773678479, -0.37142097852654754, -0.5849079042152481, -0.38047807021804203, 0.6471574152804539, 0.7895847735060523, 0.44001356898911853, -0.7062793700591855, -0.8893912277000899, -0.6532114536269017, -0.6850381676517822, -0.5616206110393425, -0.7923604997278706, 0.30755867840012713, 0.5887924589947542, -0.7331206148885122, -0.7661599718804452, 0.14462781009141784, 0.45219634703140305, -0.6975212324768635, 0.2971154119971472, -0.6694219197621788, -0.7418493400464556, -0.4754347361648536, 0.5597044438060462, -0.9528821184909464, -0.9694711844699072, -0.38459731045005935, -0.8897528870853637, 0.4844413139665291, -0.520698562253161, -0.04280541873478595, 0.18634718111339926, 0.43997678586720707, 0.531418289934702, 0.19580824161049712, -0.4286425794809863, -0.7110822430265592, 0.6135008456462601},
    {0.48592498304142495, -0.48105048534881767, -0.41596393205112847, -0.34251944855467803, 0.07772345992744219, 0.18857233060728398, -0.8518395815488604, -0.18468159222935956, -0.7391699990437863, -0.7763688653973114, -0.77538381991259, 0.4903786498121689, -0.8512119276886216, -0.29908832607562735, 0.6212370259060142, -0.8685671736070468, -0.01948291646929157, -0.7203420561262543, -0.599853252577957, 0.4137361735457255, -0.9549086559571606, 0.7213563192246277, -0.7568053635637537, 0.5657965187823293, -0.9994960177629892, -0.3515533163337246, -0.24776103313723358, -0.6665384148910618, -0.4160056670094228, 0.38380545347465006, 0.9147360096686888, 0.5225108694438211, -0.6842770715393777, -0.6704740169278993, -0.8160688161387251, -0.8088004893201929, -0.5756151190054445, -0.8851186124090104, 0.5253096003984005, 0.6355114123046808, -0.7447712042788763, -0.6395615836620354, -0.04967388647560496, 0.2838920501225361, -0.7325958718476443, 0.34232611043176825, -0.6724529102596107, -1.1316634791880398, -0.5127327820608016, 0.7542280337594213, -0.8204122998291279, -1.0027495353110862, -0.06407154258258027, -1.1215616222871279, 0.4781051650176652, -0.19453762781917577, 0.1988666548579667, 0.48014560173857274, 0.24634026295307374, 0.6929918219495864, 0.3807980143700695, -0.9584855881043434, -0.7180674118639636, 0.9216310037602395},
    {0.8297653071180027, -0.5930718567236479, -0.6316718028205123, -0.3827935983830654, -0.10687109076676211, 0.07321730068156353, -0.6975506569568942, -0.09589054414688097, -0.6230590198963898, -0.6513483039723875, -0.8630891707466788, 0.5220551993455572, -0.815710357408299, -0.2202152344446108, 0.4238709235564362, -0.9686067179690067, -0.016805886388773023, -0.7559712861409518, -0.4625799182380519, 0.3824345810083396, -1.120979053558478, 0.6673389623330613, -0.6492099446565164, 0.7309415242570434, -0.9131526760904702, -0.601981026658081, -0.4672143735403094, -0.8423298893741016, -0.6622413226139777, 0.7480312825592328, 0.7763383904518993, 0.35823823743492145, -0.7429309092930525, -0.5212093641886008, -0.8248738220581535, -0.37016618180717825, -0.9159420785762191, -0.7595563266611414, 0.36645125761187647, 0.6546656545320646, -0.4248942267788686, -0.6217882765716346, -0.2810103981771765, 0.7410282934278026, -0.699903329409342, 0.7574132802086488, -0.7802853327926338, -0.4319183815762553, -0.8574493926308214, 0.8785321080216293, -0.5544424932629255, -0.5644781593206796, -0.20710145666947358, -0.7148823539500107, 0.30722593779961443, -0.529958171516017, 0.13745316149300432, 0.31201351499781066, 0.03296455580414593, 0.4121898430088118, 0.23405777483072035, -0.7194886103565464, -0.8583407884159058, 0.5115676595491062},
    {0.867666912117831, -0.3889861588315667, -0.7252949431792789, -0.17608106153461847, -0.05399480064966453, 0.47415605469040184, -0.4412490272942249, -0.25938544054190865, -0.8307736669959442, -0.5660927212576528, -0.8161187439953923, 0.49383763526961727, -0.7923526138856793, -0.23749175129385347, 1.1572031260708036, -0.9366767810981181, 0.21850729177210956, -0.5327949352756219, -0.5585358556841195, 0.29867554551345726, -0.6866256160616954, 0.8744005281839129, -0.5758673921554106, 0.645740991255423, -0.7408937559101703, -0.6205981142890296, -0.1990000339503649, -0.8209086177324728, -0.3918273745018789, 0.5860310839791387, 1.0037250703507683, 0.47831254181187255, -0.6342113574712448, -0.47370372532102084, -0.914967225251382, -0.7677665438768244, -0.8453733689203226, -0.6715929892793799, 0.7368480778672885, 1.0322388087385865, -0.43346356497593247, -0.8467700092547958, -0.07729846399173264, 0.8510408560553914, -0.48443369303274697, 0.5335508415394783, -0.782133101146083, -0.8760682889083639, -0.8536303771437166, 0.8430303727737869, -0.6621479461077409, -0.8500311444525744, -0.018642140210334647, -0.9292274449832447, 0.561686003628269, -0.4593628461618008, 0.42583108076741594, 0.5434992088143753, 0.332212329898871, 0.7757928843518638, 0.45851844917072265, -0.9179446043449833, -0.7955083453528229, 0.7005014264236588},
    {1.0329922448909579, -0.48380880537504545, -0.24383102281856403, -0.0009082673501137445, 0.41231195039155966, 0.2949590366253732, -0.3432437509254, -0.08295237632028275, -0.587121706140734, -0.3962171351443712, -1.0565802012324974, 0.8571085003145236, -0.6150205847931877, -0.25484106872643214, 0.7280285144668583, -0.9453669503143757, -0.12631251748303007, -0.4385828337802484, -0.5316284492427161, 0.5311805603980386, -0.6008484010102494, 1.0664275264555896, -0.503596163313942, 1.0147348421799212, -0.9422010221010494, -0.4969363914269202, -0.253012456929708, -0.6098818364505376, -0.6561121470363158, 1.0414704043864929, 0.7207854154504757, 0.7457425154380417, -0.6132807827138396, -0.573760467154412, -0.6081425516067288, -0.70383098149881, -0.5171255061617985, -0.7984635486575263, 0.8313887614317215, 0.9897737545516262, -0.38988232319655325, -0.514170022010622, 0.041589066552204436, 0.9076294194815779, -0.4163925155200375, 0.700479679868622, -0.5853650928911369, -0.8274470398900552, -0.6843152327415071, 0.7888322378246999, -0.5282322805030012, -0.6070257689493416, 0.07853642987265538, -0.7243623547222828, 0.6748460435897691, -0.4596619250338596, 0.7265659570096682, 0.7190614766485446, 0.4420894692281573, 0.6589916806668163, 0.693936745345897, -1.004130924517557, -0.7521560856333404, 0.8639365621136337},
    {0.7091733267513018, -0.42782547577900076, -0.5958229833666324, -0.109828465288366, 0.0620029949904387, 0.1545362987819709, -0.3900210964374255, -0.052302452263473485, -0.2921183355552502, -0.700279605220485, -0.7310394416343311, 0.7174930296772328, -0.5659587662240203, -0.36788551547170156, 1.1950248018544338, -0.571478671960609, 0.31151005349552724, -0.6118042247457253, -0.5174487628885818, 0.43672458564896977, -0.7412526177251326, 0.8690076860843982, -0.40454794599196153, 0.7865284037385142, -0.8361698767743166, -0.46818823446523966, -0.4629285871918603, -0.5706943016208413, -0.31337802711864976, 0.7454706697289869, 0.9950192017751045, 0.7606635118459909, -0.6499894558510397, -0.3423799545036535, -0.6499049726339572, -0.7465372683887075, -0.8517308269388518, -0.7497044296346272, 0.820389118576005, 0.7624963454721396, -0.4204228392455295, -0.5205629900081008, -0.31521071910286125, 0.6314984352938814, -0.46688495286807463, 0.5932876106050508, -0.6603487428081063, -0.8431654378745154, -0.6059867813957682, 0.8508065829358441, -0.7950544519660132, -0.9007936092258348, -0.03354424510796001, -0.74534182338727, 0.9178176701247683, -0.36725220024810856, 0.5301920807854161, 0.576081492036036, 0.4220236485617135, 0.8189591836842189, 0.4936522515731483, -0.6517441206940052, -0.5534562045949687, 0.8628523403576644},
    {0.6210272631662938, -0.7741538419063692, -0.6844788893735495, -0.46085901003927376, 0.05334083188421958, 0.4035334598380959, -0.6371096729815364, -0.19094876492220803, -0.5622978175408392, -0.6593113216939385, -0.7911960692858878, 0.314798077013836, -0.7590549042781131, -0.4133507231907507, 0.7053906346816979, -0.6387105470607988, 0.0614232554604955, -0.9401571249967039, -0.40405762258209654, 0.548481650975976, -0.7586585230416663, 0.8066202930538701, -0.8776734609162808, 0.55657879120549, -1.1018913417113343, -0.5936727382752371, -0.25089709943579735, -0.6871818531480381, -0.36828595690145316, 0.9073322633199132, 0.8889692772130917, 0.6391588246769956, -0.459999818875479, -0.41788742828364406, -0.5954141691898037, -0.7700998838834875, -0.5274296210499919, -0.8371609609503811, 0.6341840783392056, 0.5539088783705547, -0.7133484770168902, -0.8171983803162481, -0.00022112746102135634, 0.6241305582619612, -0.4962744302660173, 0.7693793589942771, -1.056079538920473, -0.8493810257700765, -0.8458706868105621, 0.9186233665780427, -0.8215022222455997, -0.5088322215464023, -0.04097399239131305, -0.6066001284397396, 0.8194140004556192, -0.6473855943715332, 0.4280410583221698, 0.5098313550146216, 0.5744718549804573, 0.5082982322157467, 0.5216235066956082, -1.0244083633126635, -0.8949862927792419, 0.688878048915088},
    {0.96243972098023, -0.48213071273082325, -0.5741727548064309, -0.1884869397207151, 0.2385391188322082, 0.2740171583002978, -0.506111840890519, -0.08566752465575256, -0.4582221523283518, -0.617833880522305, -0.8398587398422637, 0.697455792315871, -0.8550527836130328, -0.28251425043788225, 0.6468050316572369, -0.7004376392290979, 0.2860445020883217, -0.7167814191975872, -0.30661293945538676, 0.1586890026704272, -0.9150602272461335, 0.7798212480070308, -0.7943614061629933, 0.6770603755064752, -0.790423412939789, -0.5865738390055036, -0.2407311292781019, -0.8083646703635439, -0.49961324477391267, 0.8632018577597838, 0.9446053722468434, 0.3460571062273084, -0.752632313950486, -0.41766880757790215, -0.7792372920614995, -0.7540671787175072, -0.805076904248069, -0.8814493207888644, 0.9548374519739058, 0.8444265334543075, -0.6008885756614776, -0.6355890890957445, 0.20683645808501344, 0.5688756302932617, -0.3131022905036735, 0.7258454700726155, -0.76832587807919, -0.6688691844554954, -0.7928677556627753, 0.5535448585189293, -0.6989501084223807, -0.8410821864902303, -0.25001000742025853, -0.5962572801362103, 0.33887591728488736, -0.2531473469386832, 0.22233349474138364, 0.33612597305674446, 0.2567987580223204, 0.75407439529075, 0.5368829493628168, -1.0933885087801114, -0.7740017024391067, 0.7675075095261323},
    {0.8779198497887027, -0.5758809898948803, -0.1646236041396365, 0.04011887153738593, 0.22619967151587209, 0.44844402647076215, -0.15818550217762353, 0.009156830329954126, -0.37802139337612994, -0.26523629554183425, -0.8050080170787628, 0.7434475054293603, -0.6201824980343842, -0.4856718869766319, 0.9477529578939659, -0.9219684702748653, 0.5091642116336764, -0.7784548668728564, -0.4108991174212017, 0.4125762606181201, -0.7155255475077268, 0.9384116851540679, -0.5233236737848939, 0.7983993561876767, -0.70685261339465, -0.389748437023556, 0.0250814595166528, -0.7714370993352047, -0.36120924120880676, 1.0131689454556796, 1.027768541838123, 0.6802850200185137, -0.7179883308336285, -0.4686948437287851, -0.5650805705464238, -0.8272079893831616, -0.6888163354777193, -0.8411196868137548, 0.8530814197824114, 0.8479522978374243, -0.5420748445063315, -0.4696324203097253, 0.08852995630972889, 0.9613140301318461, -0.3410264408004561, 0.8019391052608602, -0.9572384989422678, -0.7164515551046897, -0.6676670466171106, 0.8418663700616819, -0.43152674704617017, -0.7857414190825439, 0.16217756495705332, -0.7076058012696661, 0.7178340797909212, -0.6273619212228213, 0.7291492062171648, 0.7333399270263196, 0.3591942100902713, 0.8043720384847225, 0.6671543257133908, -0.6141976340191108, -0.668913833576177, 1.1757783004455593},
    {0.8982838636139199, -0.24851207380955634, -0.426131747275298, 0.3048888902116386, 0.4328206820090516, 0.5953392768264686, -0.22348914873582035, 0.13885824156605578, -0.29717059231346443, -0.522499000175396, -0.6836495053908477, 0.9434019077380144, -0.6777179889475023, -0.09142856728573119, 0.8918353463615359, -0.7859176158114112, 0.44238171221995587, -0.3538061255944098, -0.5364518078436149, 0.9198788226875738, -0.6983890410705514, 0.5499737949750957, -0.5117789335865279, 0.7169424440426825, -0.7056194612077961, -0.29697085333528783, -0.08644581592301444, -0.8022424231705045, -0.2949802578658239, 0.84922050518193, 0.7500318380616774, 0.869239063107926, -0.6861142323216622, -0.28674393430580336, -0.34483554076050843, -0.31697208754650963, -0.5662809698873068, -0.6785984885939853, 0.8271893046497675, 0.9273627949546239, -0.36517255567206836, -0.41497941079664974, 0.08954322004820171, 0.9540617898491813, 0.006630558200773567, 0.9114553362803961, -0.4238100417119135, -0.7118409567716674, -0.522716589608668, 0.8924860126959094, -0.5110815227715125, -1.0146575515472636, 0.2971647557651341, -0.49867771396549204, 0.9513499711477126, -0.1817090603073182, 0.8201440085803594, 0.784415214174465, 0.6342559056383585, 0.9852174260098043, 0.7558937165321032, -0.3690318651415871, -0.30666301779587457, 0.9165849601104765},
    {0.8869613596231778, -0.47690137870190247, -0.3186380810417609, 0.22062103808977795, 0.2375857300627315, 0.6518073197406518, -0.44100148605566253, 0.018507503645996192, -0.5213121355953324, -0.710400402800243, -0.8726824659046692, 0.6637782504131995, -0.6740846096927052, -0.2627697448899757, 1.185084340524939, -0.891322589123744, 0.3886239077812092, -0.6117959120962588, -0.3656367383576016, 0.4976573382441953, -0.8132556569582939, 0.8424083288839299, -0.6569736666695563, 0.9542717093352086, -0.8575781797429545, -0.54214331213759, -0.05761318607170986, -0.6124992547368115, -0.14025132073549457, 0.8373275198868012, 0.9315584896286451, 0.6034131071934589, -0.6759970302543649, -0.1346874091318058, -0.40431641374080907, -0.4643887432804911, -0.37297489290571056, -0.6421729450518409, 0.7399546463574856, 0.9779739154210277, -0.5284472482418092, -0.48945032473037353, -0.07598713311191337, 0.9297588592147323, -0.42759110228792974, 0.8375332906097973, -0.8351830768184615, -0.8325042574316679, -0.6404449736572497, 0.9199403672081952, -0.5648633769497148, -0.6200865702018208, 0.02409407900929519, -0.671659840538411, 0.6303479588948409, 0.14034603429370285, 0.8394036739069733, 0.5819182614487179, 0.5852834590023359, 0.5869056825328907, 0.6037199272942771, -0.8431572695283329, -0.494335511711758, 1.0216858952161498},
    {0.9465193781768526, -0.577492723542338, -0.18247499445336296, 0.06127567616591562, -0.1662698317824529, 0.3004755418599735, -0.24819033624460865, -0.13945034827019895, -0.41728407922721383, -0.617236229065645, -0.7619829318473148, 0.6037018261976541, -0.7097245973709878, -0.04902050973209707, 0.7095993926667507, -0.5233579806123851, 0.39655963412196976, -0.47910646697481674, -0.6254959675427236, 0.30591141660410054, -0.7636538760873042, 0.5980700515822963, -0.664384668538186, 0.8210612924053032, -0.9049793594641863, -0.35140708693567885, -0.2925975744393973, -0.787136191848402, -0.23581343282011558, 1.154364356100511, 1.188871288805541, 0.7243370993895784, -0.6689387447980647, -0.5620863108881199, -0.5692425864283046, -0.6582043456268457, -0.8628133530100068, -0.9084181526453072, 0.5839552538314091, 1.089633279002453, -0.18480288372683346, -0.6057079656402237, 0.20225703784900753, 0.8063482605759154, -0.33110344579776096, 0.9357596310693546, -0.8536951733992721, -0.890261030174193, -0.681890670011835, 1.1174254793649732, -0.3499741504888871, -0.7918908844865579, 0.19063763354078161, -0.762971835475253, 0.5345926548449026, -0.3173517292088963, 0.3801413840738156, 0.46083350956997754, 0.36096974703727147, 0.5611799775410614, 0.42065376710594127, -0.8309580280158514, -0.5428938841521324, 0.8973343915570633},
    {0.8255318566869524, -0.39189366003790005, -0.3789982321243436, -0.2005230080215563, 0.18475965502877043, 0.5112915259674605, -0.2358512602768463, 0.08674160769054863, -0.5086944738986727, -0.5539956934487127, -0.7304941583471893, 0.5081897327093319, -0.45675282847496684, 0.04046346038600057, 0.8862683935115923, -0.6704580088888171, 0.10098850630610821, -0.49022051848381637, -0.2538999126256958, 0.41763950954086776, -0.6759470784073032, 0.982830713277156, -0.6477818092315115, 0.8247882013526341, -0.7865269400711731, -0.7277119841176642, -0.29312770403545013, -0.7424972481252397, -0.16662114638125758, 0.9509587399508089, 0.7832812474006099, 0.43550368963474073, -0.7616186343727767, -0.6989598220331754, -0.5645456547697396, -0.6393134324894848, -0.6244615947737341, -0.8719012719049243, 0.7519705119133864, 0.7128637693962311, -0.489245991003207, -0.534819772664489, 0.15409151129152598, 0.5303291876047331, -0.42084262242051423, 0.5307694941791454, -0.7347010875169045, -0.7575688253819388, -0.7368007861389597, 0.8636559452164937, -0.8142336422170381, -0.7348407576440742, -0.03217694365361426, -0.773079095006796, 0.9155838901031766, -0.28004780150264114, 0.40426767275551273, 0.5136306553183368, 0.3703227599313948, 0.5256277925121315, 0.6076195133627149, -0.66978498160151, -0.6401234556036011, 0.9407315365287311},
    {0.7641204856251139, -0.4717551325573263, -0.4380442009140134, -0.24473043583863874, 0.2564584559357966, 0.2578270261657631, -0.5455134218422865, 0.18837772175094342, -0.47385136295835023, -0.4448742103706488, -0.8335119378709287, 0.7739832455459326, -0.6925635867791432, -0.08078352263538774, 0.8750811632698045, -0.7219394270649394, 0.33265194993177255, -0.26760064129251365, -0.4289982018740381, 0.43006884426312864, -0.6692571556118463, 0.9355400343533229, -0.6732117249760957, 0.935638488582363, -0.6922648899147217, -0.6207120234672628, -0.10419967512921548, -0.6444428348230614, -0.27612018590204945, 0.9704691539967273, 0.7788740644332939, 0.8406477307385868, -0.6798454974224405, -0.4474823677544739, -0.37745072271963026, -0.6883499309085322, -0.8333057640717594, -1.0841578506145642, 0.9755208170407592, 0.8131020978437414, -0.45045427401092825, -0.43848929399422726, 0.07026600272254076, 0.7135524328407487, -0.027090161698637344, 0.7301408219946612, -0.6324264084779144, -0.7506702195983903, -0.6673411939033712, 0.8802500556554621, -0.8320707453819121, -0.5977931661249877, -0.11514443432569728, -0.4504738458268126, 0.8310318677267934, -0.5046474532302323, 0.562981200926681, 0.5461087589525493, 0.34381435757105205, 0.7099295563159588, 0.6487787861827802, -0.38140933428684765, -0.6584229417921172, 0.9062174096956825},
    {0.616455568688386, -0.3728795532713027, -0.60259237101235, 0.007259268448241119, 0.2400387220425491, 0.5632757197622701, -0.32726110418277293, 0.03986100781376506, -0.5786149693100467, -0.5354272337239646, -0.7076090831192161, 0.5284667565420459, -1.1352002116877575, -0.36633219988060445, 0.972715129767009, -0.7099936763536862, 0.3596262080804983, -0.7349744639335989, -0.4650860788378255, 0.28522186938572547, -0.576968549342072, 0.8995784285516073, -0.66923522337171, 1.0704368273506457, -0.8167640140015722, -0.693100602654776, 0.20749117269821563, -0.947388496707447, -0.2335807236850468, 0.7930541106600856, 0.9720153545793336, 0.904924980178246, -0.7617407300320823, -0.32697254249269453, -0.5474413980456287, -0.5229705510807929, -0.6811982949410529, -0.8064523247000339, 0.9764867616334376, 0.8299293275762605, -0.4247450317318002, -0.8278877200908289, 0.13787658976784917, 0.6319600540741227, -0.23469432666800552, 0.7598915432628913, -0.6521529427612472, -0.9149135528601361, -0.7879603333054257, 0.953626896660652, -0.7114243270379798, -0.8906655787990102, -0.03813520193542986, -0.7428787073650104, 0.8533983672729071, -0.4533810476897478, 0.6895214671755687, 0.6346286915626455, 0.34758242123971284, 0.8325146925215431, 0.8643679496241552, -0.9603935977611587, -0.564936407552031, 1.0688098552002256},
    {0.8702602827228234, -0.48825234826223995, -0.4214261468801303, -0.03407917030326985, 0.13189428072550602, 0.37262742702113977, -0.08485726547123533, 0.22458432409343956, -0.2922790533266137, -0.2693213438969308, -0.7160991126579324, 0.6530470207336886, -1.0458142892817053, 0.023075014603388885, 0.8738373569968307, -0.650136870862021, 0.16891668714634736, -0.48877813382680946, -0.2657646979143989, 0.3225428213565108, -0.8361357883483035, 0.8281818280780131, -0.5104252856623003, 0.7969634272595133, -0.9681591612450632, -0.34663867349334043, -0.06149029842154274, -0.4996242228649099, -0.35516392386104995, 0.9443635140041774, 0.8571018894801384, 0.8096266442830145, -0.6172496087442263, -0.3524691763970063, -0.4444496306370929, -0.4423463209694387, -0.41435584938113984, -0.6167048058905319, 0.7972832171877414, 0.7578607939656765, -0.42704247380381294, -0.4465431684476289, 0.3808603142981176, 0.7139350617949013, -0.28063588706811643, 0.6972256605448911, -0.8600224660104944, -0.6843057270037698, -0.7478750094234801, 1.1168181925167844, -0.6324112962564878, -0.7337452740599156, -0.1539377065674937, -0.7623331985137622, 0.8192816185471675, -0.4238734384210914, 0.795514981670506, 0.2776288597780743, 0.6271106884463319, 0.6808248817454347, 0.49816206806202235, -0.7324448492181266, -0.7460349230369233, 0.7725773149553642},
    {0.7842968907722271, -0.6055684620943175, -0.18157125908014146, -0.12563746089666483, 0.41411468109033955, 0.4271460165681715, -0.1852184209283408, 0.2181699482673577, -0.1933185404655837, -0.4709681327429676, -0.6862445035373691, 0.3662001916893082, -0.5120172081865124, -0.02964851280060379, 0.7660463963746663, -0.6426757063155955, 0.23790869451730523, -0.6030535576318995, -0.40963779557187174, 0.4981388012162106, -0.6791545907575678, 0.8904975477390089, -0.6461368592373307, 0.7136610862103696, -0.7589706345309349, -0.39822017428139256, 0.12366048937073319, -0.6246853979595375, -0.21981849361232658, 0.8416362552801162, 0.8529110745223193, 0.6271849239751947, -0.6908774389766963, -0.47381613450483157, -0.35464222827376024, -0.5408901323207587, -0.5202683269018554, -0.8082736998675847, 0.6744303894716478, 1.0145200750609578, -0.23626523549299047, -0.45701259061660393, 0.17684882054646917, 0.9843724394357997, -0.15571217502338874, 0.8218895549853592, -0.8737173068248474, -0.856689952574336, -0.35827842103105484, 0.9934146811943498, -0.6698916264644802, -0.6947164157695087, -0.0026169290702492444, -0.5810961385871688, 0.6698921064010692, -0.5295019645444035, 0.6621239145550475, 0.5480656353454029, 0.5284831752108176, 0.6491468091844745, 0.7032665633874977, -0.6596659980143765, -0.7942928904975523, 0.98726541541618},
    {-0.3592476088134327, -0.12121015073093092, 0.25968422875833375, -0.21372959564108662, 0.1257329064385269, 0.4298260908262803, 0.09864735630837515, -0.1796916366574544, 0.30561178189795635, 0.26601674093722416, -0.06928586497779854, -0.12711058017422455, -0.018576194110985423, 0.13974785536531562, -0.25579338734711476, 0.39618652505466656, -0.08555826371393098, -0.13200859909308607, 0.030264058757639066, -0.057177394629987645, 0.22096016623957296, -0.03090009178605438, 0.3455050966185, -0.31366489248150653, 0.21488691312299987, -0.2738363072755532, 0.13636910072853842, 0.11560088979555526, -0.2414861819436298, -0.28710086811129665, -0.20006106391327108, -0.5666499723774538, 0.17946454023260355, -0.550797751391374, 0.30712141201526044, -0.05252584307591028, 0.05885093990540194, -0.29506276535339704, -0.09233333686745263, -0.2014641539822659, 0.014373779408869091, 0.20435848016974867, 0.09613890914082804, 0.17617785115563192, -0.6707637332276086, -0.04363174067057073, 0.16886828914433777, -0.10015474820764732, 0.31576652459835947, -0.44190218314778124, -0.5193480236605492, 0.2514739794640325, -0.30112560271925726, 0.13905120569259435, -0.08622462008226675, 0.025458663843959277, -0.6265944259351993, -0.0607215942266702, -0.019614769619734074, 0.3920752927621975, -0.23486112236522133, -0.06435339959617692, 0.07741408549498241, -0.11187265742223998},
    {0.46666301107193364, -0.1565759244927604, -0.18798876196775052, -0.13113362562528286, 0.2095137958828155, 0.2897465544664587, 0.10905134516165071, 0.2957808428620916, -0.30831645475796116, -0.12758932909094786, -0.910076683188048, -0.15510762453675253, -0.5635383145403807, -0.4590429340886983, 0.41518073388021365, -0.6843017601775953, 0.375843532602233, -0.2162369531217447, -0.1810195207610577, 0.3804867887720788, -0.9243641546691344, 0.29973607649122985, -0.034230724440951855, 0.47150803070142516, -0.13594702022099664, -0.3267576268234736, 0.07310881415584292, -0.41800272092816254, -0.293253316848256, 0.13269444043402734, 0.2769866323532923, 0.5175018489195299, -0.4470044124458925, -0.010328091280452513, -0.5226019255356678, -0.28624874780993476, -0.21184367616949853, 0.012401727658865125, 0.2555537586938221, 0.7622142531758849, -0.3311316715072913, -0.5332291617215112, -0.24240154288871527, 0.4027104086146918, 0.11000412929576255, 0.363724774518508, -0.45034037073861566, -0.44138354900717947, -0.4287883333670841, 0.21272053154528858, -0.22046075961252204, -0.30427437614381236, 0.05733014082113923, -0.29561324938629086, 0.3649643227027476, -0.25266916590617927, 0.4923580686831641, 0.14188498056132978, 0.292095957802653, 0.15894166874613228, 0.4775616014943831, -0.5461397996269488, -0.5818076632769641, 0.4575239627961953},
    {-0.7325572390119919, 0.36234515470024303, -0.6739804234460096, -0.7915072031749574, -0.18770582393079938, 0.16907552399852355, -0.18032626559106157, -0.6190506766423732, -0.48829488257675513, -0.40835519534504316, 0.15957027012416936, -0.14787973452814562, -0.20758814910988319, -0.5838467737710614, -0.4584759755744041, 0.11333839393404276, -0.6348293045794852, -0.47811467801171437, -0.6769175698955655, 0.29129431941937944, -0.4316651227461484, -0.5407579483598517, -0.2969939628337428, 0.1441951651106542, -0.2717522831474927, -0.481474494920304, -0.41862915390406663, 0.1373107667170569, -0.5932993797495929, -0.6222955795996421, -0.3079442774853482, -0.3290255637321505, 0.024626756096954798, -0.42936995135488265, -0.7121744293757656, -0.5932891121253232, -0.5172760186548199, -0.16838724644422567, -0.8776757519185184, -0.3158363514954834, -0.3942075742596406, -0.781738484789702, -0.5695833002634274, -0.537487628566101, -0.6597583819360979, -0.3625716750696556, -0.26209106825039025, 0.3058106520499785, -0.5784816050657178, -0.23883472104290485, -0.47118123186749455, 0.12549136575646314, -0.27343864021471664, -0.2421275337919416, -0.06580995720270008, -0.25978029849383194, -0.5980892948958545, 0.13162277321253982, -0.5747784158149382, 0.011132660905761966, -0.0410286152187249, -0.49943629057137634, -0.3208796685668705, -0.6326886857428543},
    {-0.4898194875038898, 0.18733583649827393, -0.3418807369007651, -0.7368932463837672, 0.15716680582482154, 0.15663097445959923, -0.2281270559793133, -0.39698262904132764, -0.48338476516019246, -0.0713656621168529, -0.12908234222154855, 0.07696104726837258, -0.17757589791570597, -0.4883028367979575, -0.37313322913918046, 0.17467127484905765, -0.537836275637995, -0.21380503280418367, -0.7523534344388616, 0.05622792770829862, -0.07854010626199805, -0.08483468577807626, -0.27613073648972236, -0.062242284398487266, -0.22322488687619102, -0.5157173746912994, -0.28101577318917603, -0.307705378736609, -0.6426138423595112, -0.851985283488463, -0.3297715310534785, 0.02259722642559726, -0.15333752583677723, -0.5177492396214168, -0.6552309555149266, -0.5036628423896269, -0.5889613284634151, -0.30047295827861253, -0.31797155954282985, -0.4607946503153786, -0.24067249693906323, -0.7638513390105305, -0.740778603911783, -0.07498664657808521, -0.4441187498622579, -0.24404193559980888, -0.343442313880055, 0.12034192933207878, -0.2384448421659379, -0.22073814384116353, -0.3388404360486639, -0.5333260491187267, -0.2739340139257269, -0.47664928358254216, -0.04105495615802797, -0.7918837863245363, -0.3967229537824587, 0.09186303350830978, -0.6454350268889618, 0.3261919237962589, -0.06636428559530162, -0.27006576712271396, -0.31453486149153415, -0.15935755678837396},
    {-0.45120838457401957, 0.40805912959191243, -0.3453438932743605, -0.38880753012941544, 0.17350940677412202, -0.20043804293216638, -0.7535281378771381, -0.3691991033197122, -0.5682665231975229, -0.45615947305055454, -0.4318509727006635, 0.2648146480520644, -0.7144845828765497, -0.6932546169565739, 0.18878317510122575, -0.42303740433834963, -0.37778625651362413, -0.5809276686434048, -0.6711685484342708, -0.24355026297419474, -0.5236261966451162, 0.05403813842480498, -0.3659893768740408, -0.005177650162794108, -0.34020817439498213, -0.7861500932866291, -0.22079216926932196, -0.42309409053478164, -0.760960600018912, -0.3188446931389196, -0.38077955165451965, -0.04489997569742573, -0.6483560287754621, -0.4506279318102611, -0.6446612157629894, -0.45607522780109855, -0.5615640416068651, -0.19309588566242217, -0.3789908448158184, -0.14166325950308914, -0.48679755020398796, -0.5645857959684413, -0.4321737616118493, 0.1045157945958772, -0.5571663477447033, -0.07126622424082615, -0.6718350930614744, -0.3375439760039206, -0.6041057921579183, 0.01850333828805046, -0.6295898845963076, -0.7086839271003661, -0.40710688827647307, -0.6977640203504748, 0.3198978978255192, -0.6007787304456979, -0.469863499039208, -0.05633091085904124, -0.46956990111539115, 0.40723179599884296, 0.14866071454027258, -0.75207331410111, -0.5701506589422023, 0.08091374753901197},
    {-0.17702499547357972, -0.06625480966439601, -0.20911586581445799, -0.5628525517611587, -0.05270092752849673, 0.2860774288569322, -0.3375231238890528, -0.28435501043237427, -0.7334736159527854, -0.7329555008920206, -0.4698222238436965, -0.3030334105214162, -0.5874928021477961, -0.6678638016321473, -0.11124651615144152, -0.4402239749081173, -0.4612407813607171, -0.3484950692416156, -0.5787557073662696, 0.3202997462221826, -0.5683985353092783, 0.11430713110509773, -0.44392588460292026, -0.15915101605482943, -0.39907014395323487, -0.7229783331748325, -0.3399133542088528, -0.13659236229756785, -0.44478503882979603, -0.15671364984647432, -0.2810670111786163, -0.161289121948844, -0.6007420341238213, -0.3386437489584254, -0.41899731589907424, -0.5563752142853189, -0.037556213115507185, -0.07495944820308956, -0.1021162834528058, -0.127950628915105, -0.24058057802775812, -0.5237431252975505, -0.6014541078968771, 0.11521766354432449, -0.6077532244494768, -0.0628003770770522, -0.27445976439623043, -0.4851693995084608, -0.690180994155657, 0.16296230752866492, -0.5046453693659734, -0.39325960855743614, -0.02791132480821003, -0.7770596333351367, 0.10554834237927789, -0.692591615643175, -0.2584968353023377, 0.04522872655971387, -0.43677412252922954, 0.20539101884990524, 0.15092089988887086, -0.6134010610018309, -0.3902522088973061, -0.17671254922767737},
    {-0.09391262437973445, -0.02551204427799526, -0.255126676788856, -0.49743282370232067, -0.20865841055711962, -0.01463198769478387, -0.3894605154465923, -0.44028394801733706, -0.6337960621018148, -0.731222134800067, -0.49037490251439436, -0.24386076593908695, -0.674358982540175, -0.6435769192619692, -0.15025075297346308, -0.1645063002051162, -0.5814683526657327, -0.41744084257149694, -0.4326426057567018, 0.24794654944278513, -0.7989472818314789, 0.11037129787269441, -0.18040522357273753, 0.25927729298647234, -0.3478677203100937, -0.5796404397822462, -0.5042927479652413, -0.5083300004507882, -0.8236691684018196, -0.3572274367663296, 0.16036577318970155, 0.19348157424171009, -0.592285075443588, -0.7091079407561794, -0.3329630869382384, -0.6077110515569134, -0.7047428059363532, -0.13207072109118542, -0.20051476388472336, -0.21568206609685123, -0.3315113679870601, -0.6744241408865185, -0.5765538626227448, 0.018482203224871284, -0.5177102337629779, -0.23667822671477756, -0.7100380483106836, -0.3976343763516854, -0.33909746285407255, 0.26368520103242726, -0.5850421117633057, -0.3595733974311524, -0.28360994663264083, -0.5397425471289501, 0.19140411602235857, -0.2915523363263174, -0.10166062124343002, -0.1144452479366294, -0.5014653805845176, -0.016977024204333176, 0.24030353516245284, -0.6619235818176717, -0.44252301700769875, -0.013288516568188989},
    {-0.17395856174053131, -0.34624028785925487, -0.6290390664174546, -0.39944802665472323, -0.1623260262473567, 0.058082871741282724, -0.5368116818531119, -0.7121596491521253, -0.6409052608927576, -0.5500459189102652, -0.5024199952186142, -0.11572277310389005, -0.7425527627714211, -0.5822243122306834, 0.1882954133140999, -0.17295152796268898, -0.6543662919893383, -0.5514166004294577, -0.32801191583603717, -0.006836703367967686, -0.423853713339616, 0.10269916826171602, -0.035905223531097805, 0.021919348890730987, -0.5973571133234397, -0.5682911315972535, -0.4463839729255749, -0.5595426670830865, -0.36470705721855007, -0.23173077273737427, 0.15197546435080597, -0.10817490987010625, -0.5420153883751591, -0.22480103857647243, -0.457405908451258, -0.6312285787247591, -0.6312177557222302, -0.59290750683312, -0.32315693089386144, -0.1483334832347048, -0.4875630847145927, -0.6232011455609162, -0.4898387345030704, -0.35380413561644275, -0.3334017576839075, -0.3293514866404634, -0.09002349615251941, 0.15350839544720007, -0.3518110906182018, 0.30962082658110496, -0.7290795533496662, -0.48155380710244317, -0.08325019966161581, -0.3905112809387394, -0.011063331713482278, -0.5956131986898607, -0.1866728984042704, -0.27808312723631157, -0.3991589978402084, 0.22058283026449402, -0.08487618441384025, -0.7665383650478759, -0.16260521442406403, -0.06553013431241902},
    {-0.3660382669460687, -0.1432997717120462, -0.5638873813606152, -0.837025762992176, 0.007563248483473449, -0.20116417381220747, -0.582839296149043, -0.4902928132115428, -0.7960850394565869, -0.6234570178777131, -0.41508022269251726, -0.2491371607096693, -0.5288554388340486, -0.8088371779106398, -0.2412957852356222, -0.5885241118191962, -0.43820712159543584, -0.36033133298683523, -0.6045081456845781, 0.3157482011090046, -0.7138406566975972, 0.036820554842672465, -0.13579192415750563, 0.02764148190774427, -0.7107004939174576, -0.637627880940251, -0.4375786422516832, -0.5053994287661014, -0.7586543814494066, -0.31577278132586034, 0.2581049543344537, 0.29485055855207337, -0.2680924266487713, -0.5760151155121267, -0.6425493774627664, -0.8056892885962458, -0.6301272493283326, -0.24966060317751446, -0.39457741836046933, -0.3413621689364456, -0.41738971990992385, -0.8596985396086145, -0.7506750963517421, -0.1813337800704947, -0.6066236973684966, -0.18420081923253082, -0.36659182498482734, -0.2633278093139572, -0.3079804753173099, 0.2684585992885378, -0.7641441006122517, -0.6512853380917126, -0.4052967979135947, -0.6871494086124598, 0.2815360281580396, -0.7371537990545932, -0.2405465516583892, 0.06798222907650354, -0.38879773258791306, 0.42546166128668106, 0.07699551079295631, -0.8899586463015415, -0.7548448354922892, -0.17581417390805204},
    {-0.41233387102458147, -0.031504316831092484, -0.31956716613128144, -0.5302084977012957, -0.3214744027706913, 0.324129217751315, -0.4208099976122826, -0.6807647433052342, -0.2937072697086178, -0.7448830028823039, -0.3903968911401185, 0.2325406431588867, -0.498714393247543, -0.8336432389396079, 0.20869961604098416, -0.18796195170626387, -0.4399224528902116, -0.5666953122429192, -0.2888483324624839, 0.2912342113728711, -0.5917209841621753, 0.31249342941628183, -0.14108424110227508, 0.16285023758984585, -0.26960742249245084, -0.5939488598628055, 0.04762647415152039, -0.3066269728387483, -0.7665284194018717, -0.21051635857345544, -0.15264951558892212, 0.20106986000518964, -0.5510129458138322, -0.5879241565577454, -0.5200952434745792, -0.4140645342944636, -0.7905576299103676, -0.3082362385192832, -0.29414656563590413, 0.021685393775940705, -0.5052554051852113, -0.9731817993177914, -0.4683394654894669, 0.41551865594815507, -0.48590381230081153, 0.0733844538303988, -0.5082430423343849, -0.0534485974504222, -0.4119739360635352, 0.19501887193901812, -0.7839526175179304, -0.4899763034599721, -0.2444562297184813, -0.6677033962403185, 0.24415480130627049, -0.47158430840607457, -0.7242502264552316, 0.08309369633167951, -0.2193586329881808, 0.6714007010516558, 0.011341042428640064, -0.8157630834335278, -0.6032044227559358, 0.014726157197338781},
    {-0.6727663877125418, 0.26132856468342114, -0.03417453709063209, -0.6801354864763594, -0.15220747586129968, 0.012093724046363776, -0.6447654398873796, -0.5175094941931617, -0.2423621415055343, -0.5407963179381181, -0.5928492315219579, 0.09936905039160386, -0.6077955505247665, -0.769495676266146, -0.07092615529692295, -0.2010914875871455, -0.47976190441575584, -0.6732853834852989, -0.42694112007407153, 0.08873898011070279, -0.7165665060819124, -0.2267373736521963, -0.08924591848572506, -0.009343436554761067, -0.5394533036050368, -0.5697579236554235, -0.059900840581544, -0.1353785179047478, -0.5884841376939347, -0.5092333215356296, -0.07623471773380229, -0.09579333335492855, -0.3637887263696289, -0.6054659472341947, -0.6013212707863224, -0.41727549674802195, -0.5006357402293653, -0.4351687867479178, -0.47057637546056036, -0.0031665408681613933, -0.14548529176614813, -0.6400077431262998, -0.29977641497701624, -0.27287938854054933, -0.38222265370638936, -0.03182294464866025, -0.4383244064578968, -0.40945723350528535, -0.5000601649283481, 0.01591941398513762, -0.316886619784185, -0.4794533597281031, -0.7186977316690378, -0.5475376836648383, 0.027424318305848936, -0.5236236330171801, -0.7544319675008271, -0.31497556014422007, -0.6050922486927764, -0.13509080268401177, 0.015546417088690844, -0.7275556912033141, -0.26632541002029597, -0.21791445325891964},
    {-0.20711748043191047, 0.16686958299714458, -0.19279580512270894, -0.6022931130240949, -0.18390034414762899, 0.3932192028889866, -0.6576203819481886, -0.6071746391683376, -0.5084980589321703, -0.5907785421200198, -0.6108377222185032, -0.05460854546531877, -0.7215290179327037, -0.6648323325641022, -0.01634954189355587, -0.4813635819730713, -0.7099585793985131, -0.34786658799973563, -0.8447311304708865, -0.012118563917367564, -0.49399966335918194, -0.05710338169921665, 0.20750488212319584, 0.163778954627115, -0.4186768613788486, -0.4338319821839578, -0.2803154790781188, -0.14415500393800296, -0.7024371137964119, -0.5170145266662246, 0.25799823273802674, 0.0460763946968552, 0.06719409920221923, -0.5247926207186862, -0.6102099152647156, -0.632071577031397, -0.6633522847274141, -0.5307570500616446, -0.2576161628068478, -0.27963885036527747, -0.414964707124855, -0.6602854187418253, -0.6767667540156828, -0.02542919164640077, -0.8375258731376536, -0.1436743751851374, -0.6229581230830871, -0.38938982910282455, -0.5031417667767277, -0.013903214652186907, -0.499114607035325, -0.3678470212278713, -0.41358938189498057, -0.5438572978338724, 0.19867452143029993, -0.3577611341469788, -0.5566203505285506, 0.01901555359050172, -0.5849156567582732, 0.5472130505801721, 0.07047149947469275, -0.6483438998494636, -0.509398157756246, -0.2420768331130785},
    {-0.34227106074804087, -0.05241979622434301, -0.6616418879608069, -0.443664115274413, 0.021155831575709775, -0.04604309900288959, -0.8401549581730623, -0.6319122474382303, -0.5655849887309985, -0.4469519311333401, -0.4647553166745229, -0.22168901769602442, -0.534963765234743, -0.7896406475493509, -0.13463711200787468, -0.2857369881348548, -0.6448392157806936, -0.9611590249381815, -0.5650994228262377, 0.3845883792106058, -0.4800331777020974, 0.06995545863669995, 0.20456075808424284, 0.2102472396998643, -0.771748743381972, -0.5450379053690501, -0.08711196034475813, -0.5956031568947341, -0.5560081261130132, -0.5978565626274741, 0.17616152018381953, -0.16635734465017885, -0.293119342999375, -0.5184055825104416, -0.42588009633941576, -0.8482591990109669, -0.3939957591521097, -0.5607087075932227, -0.5761037128420814, -0.26926389985262805, -0.4768640524465754, -0.7663137898134018, -0.8568393697632606, -0.16572115015901948, -0.5648233362617904, -0.03696319912209961, -0.38522005962994077, -0.15485426765662735, -0.8072980325508615, -0.033902622500894174, -0.4360739121615883, -0.5275777671033678, -0.6082914569558103, -0.8199271962492577, 0.10537411976162907, -0.6742278685688174, -0.41655434970276045, 0.15895504215282596, -0.7015726768958138, 0.40524794638129563, 0.20894434589912403, -0.5412644882629088, -0.6860743495060996, 0.03659634936503518},
    {-0.5470609767040333, -0.14169325084148787, -0.44775427656832534, -0.7206836094309689, -0.41987034765608455, -0.0301476673030279, -0.8395415333035646, -0.6698962290938724, -0.5422202770370728, -0.43650881765349636, -0.430678246772776, -0.10562655251594855, -0.5560726350991223, -0.7026923247722178, 0.0008237414354088504, -0.662545891815223, -0.5668149084483447, -0.517157051324729, -0.5666403445971223, -0.07735966672446778, -0.490808711856061, -0.1781521129496085, -0.1439917649879104, -0.033418788923640336, -0.676445809967129, -0.8449322225688427, -0.05500862465571129, -0.5250386303292216, -0.9308561306228315, -0.6418436308948596, -0.34672489018824365, -0.2600331305487178, -0.3724364499776759, -0.7990101649280629, -0.6623427376229437, -0.6800675541616799, -0.7747561149017093, -0.38818901299591757, -0.2989240776408071, -0.05930241298416376, -0.5410850322672167, -0.6146100657873077, -0.8595922978812398, -0.2566903188878819, -0.4942230628858614, -0.5963203078705267, -0.7094137573093959, -0.48085262997415723, -0.7139626006399475, 0.11634676695959778, -0.6459494051994796, -0.7684011982556305, -0.5373355517004881, -0.6307145311665212, 0.17988832543955158, -0.5399411959356004, -0.6264486194998905, -0.13907490230456648, -0.5530874485600625, -0.23537853468162256, -0.14769534168205375, -0.6103972417814895, -0.7121470922832003, -0.3172538394192907},
    {-0.5489465448096125, -0.12280143991497976, -0.5023096718965067, -0.6460064308664165, -0.36009563915030424, 0.09563019846613721, -0.4429434486688146, -0.5075390422101161, -0.4685054915763781, -0.4045347755057125, -0.49753326241796947, -0.030704066486789753, -0.6701085107113856, -0.811188468531915, -0.01148673262932282, -0.5503117440120875, -0.7192034067076133, -0.582486389975392, -0.5368609937931867, 0.2294442708690747, -0.5162264710526311, 0.05073188974049369, -0.46849434158374814, -0.2372580127919421, -0.5332306326262208, -0.5996726402921004, -0.22816584729146633, -0.22886346872714372, -0.6320576585726797, -0.3042359845798984, -0.18861736149930675, -0.17363008700612284, -0.37637989762520835, -0.623280805381655, -0.7056253425490883, -0.3812067790681311, -0.9667784348963703, -0.2952596500868645, -0.41602016048626533, -0.23116036281507737, -0.437853418297765, -0.6643357620788354, -0.7425525401568168, -0.1579907631357422, -0.7678164982342627, -0.2482223975376166, -0.6658998185138852, -0.36466625299965094, -0.8634072723527989, -0.14590333385904583, -0.43775480512919834, -0.6833163085890643, -0.5409516873356759, -0.5217166766071303, 0.11492865324016309, -0.4294322341531049, -0.549123932573688, 0.18901727523889833, -0.6168930451004399, 0.189206077467021, 0.2119805202988181, -0.5954409544149679, -0.42749325208589417, 0.059011797318652255},
    {-0.5717009299177309, -0.08865873821799536, -0.35559584765959196, -0.7728927364738961, -0.017375565088566275, -0.22478900304631522, -0.5236532765331868, -0.49775146679829485, -0.5331514021383578, -0.5480468442557047, -0.49644144591211886, -0.15910758133819983, -0.5346733191840757, -0.6543077299783345, -0.3225377749257261, -0.2828208114403961, -0.9495164418317152, -0.7682987692207461, -0.5302776102218005, -0.009493098270055846, -0.6554037867898349, -0.002491448192630858, -0.3273781161813763, 0.01815021550159935, -0.5047313876180403, -0.9549795824214015, -0.37431409282102285, -0.510830952477051, -0.5333634280185093, -0.4810178210380401, -0.1942995756343871, -0.12227393030747791, -0.528794775054041, -0.518645963322968, -0.3956006665974633, -0.6811886857266715, -0.7704295973485877, -0.7244412718362173, -0.29409324307383006, -0.18938690196758268, -0.5202111766529692, -0.4956669143530239, -1.0146737679325826, -0.33634311734655853, -0.6092498783348869, -0.1994592794660708, -0.6808299935077283, -0.30949093951080586, -0.5947647518448961, -0.19032104095799612, -0.6330814295881175, -0.48381588771261275, -0.32887025273708587, -0.5844234366323497, 0.07303811997346045, -0.4477796770649574, -0.6302047878389769, 0.10813416587366446, -0.7032134382866309, -0.2744470105320576, 0.034835972884197965, -0.48053858738799066, -0.06943353239320899, -0.04891216893536916},
    {-0.42775388867582614, 0.05127012500749496, -0.3690126410438229, -0.31377811678371836, -0.20548974017173913, -0.08199354324343064, -0.40641930713276603, -0.31200361671117915, -0.5697460611374893, -0.41655381274670006, -0.8228625667774875, -0.05101986810735183, -0.5694437462627087, -0.6746830543690854, -0.4192400012061689, -0.2330444921600518, -0.48776430403410387, -0.6546144845310408, -0.6872678015108428, 0.25383664504100345, -0.35733442871217463, -0.28711584572137244, 0.06201795433070891, -0.06999514022183013, -0.16839487516807838, -0.4692367619972189, -0.37766136859130706, -0.2690233277589449, -0.70970956563178, -0.4072756070561483, -0.1613156574534751, 0.12785258512620112, -0.17097993950292517, -0.29605256036999195, -0.3609628779925157, -0.5249738159434634, -0.545387366935719, -0.27704693027245697, -0.22261820928943174, -0.25360794347473026, -0.29839594062446534, -0.4279561697172171, -0.7707373442991777, 0.08625895216927673, -0.48848074062441255, -0.016393068440859655, -0.48916481819567065, -0.3463408253237534, -0.6285482368006668, 0.002486247308503608, -0.5793080811562527, -0.5141069431125798, -0.21172364543564043, -0.43479768722559103, 0.2580894771365587, -0.29008023991297377, -0.21294930070501308, 0.10416083683782464, -0.6258613083796859, 0.08021703547608182, -0.041069906811382784, -0.5876882703278282, -0.26271598504358207, -0.29716770108434404},
    {-0.14789038383702807, -0.13680114647440153, -0.331854356491056, -0.3049603796567264, 0.416651872110815, 0.10526103374060461, -0.37508994951627844, -0.23030556321347834, -0.7507641974161953, -0.5571261297788522, -0.43965334973602127, 0.23646190803868045, -0.4629663842627813, -0.5794809822151448, -0.022983263256568125, -0.193858308029609, -0.5028753864423016, -0.44059492583320325, -0.536330309285542, 0.05786550021167143, -0.36157291919019896, 0.3688313109416788, 0.03032213704447506, 0.299663112941736, -0.5035722197483175, -0.6998712180234891, 0.12294662901920314, -0.29205787229708974, -0.4993847229634074, -0.28645310593339146, -0.02065212326277291, 0.25766326753564606, -0.4799695421685176, -0.43142739315936357, -0.414176962777313, -0.40659474433967174, -0.22746985673342443, -0.4048744661421782, -0.1105618770660833, 0.14624843378385527, -0.5739186276320833, -0.4285168821706663, -0.8591579902770903, 0.028231273124243, -0.41360741618017755, -0.06435476227822103, -0.1483294120466486, -0.4088110516077113, -0.6304076503771696, 0.3789033111134369, -0.5586134049067597, -0.2757683369690552, -0.12980973669981932, -0.4459607791914664, 0.23700646803536282, -0.22201969408479516, -0.23429285869678626, 0.2810018370904227, -0.5354863129331872, 0.2772219047905743, 0.23398941341373253, -0.4380207813845743, -0.1867272727456335, 0.033136103851866265},
    {-0.6762432066450015, -0.021682639808199972, -0.6886535721885356, -0.6791349937176256, -0.05292685855745725, 0.02614709029221043, -0.7921592718385204, -0.47439019249278863, -0.5937980426359409, -0.8278941870962898, -0.4644551344176075, -0.32124257750463847, -0.38018299364496383, -0.9097008118817056, -0.3531188192591443, -0.4327278219727902, -0.6329630755715523, -0.4276619581378589, -0.543389908713187, 0.27228902089812895, -0.6844067815209297, -0.14365550606450708, 0.13870653665560145, -0.3683773656595644, -0.5055325432458982, -0.7896755582584141, -0.2534645320277673, -0.28107181058311365, -0.795588071403155, -0.7424109970256667, -0.32605724895939153, -0.14331901800865315, -0.5531125854921191, -0.2499834933497616, -0.48017966482979235, -0.7729211543825184, -0.6049144492542031, -0.5078622315272832, -0.33950242541790726, -0.4362984720735839, -0.41649293190909775, -0.748890799462502, -0.841551110093061, -0.21080159311035104, -0.667400554714482, -0.3211608539087833, -0.6686046693963303, -0.029806576699218473, -0.37542366679911543, -0.24257229252969337, -0.37696310091473634, -0.4718895005972891, -0.5940078241788853, -0.6637917362495537, -0.031936371845627566, -0.6445452059470766, -0.5418991937280707, -0.29419376895211374, -0.8598779482238749, 0.1500641535423615, 0.05295216530941925, -0.41593298624632036, -0.3879674004378405, -0.340981604389563},
    {-0.6356564767956063, -0.09162454923444074, -0.38472043054431465, -0.7593608210432543, -0.12349198942153922, 0.09742048704509197, -0.6578167766348236, -0.7829805590593553, -0.5588310034875769, -0.4671575271314029, -0.5478949561375358, -0.06610489268310332, -0.4062452358538038, -0.7934345238402561, 0.10186132812137258, -0.3762234143272193, -0.7396494672609798, -0.8234544063250618, -0.3346315567152814, 0.005344473135331791, -0.6521469038175113, 0.009525348265408231, 0.3194815268200704, -0.06279730708015176, -0.38275803958557836, -0.7553147902519102, -0.1775244202878746, -0.38339326299006304, -0.4816384068051412, -0.6931843006114852, -0.10346794279869378, -0.005912772418683282, -0.21411240725313388, -0.45815255937006705, -0.48273915550167834, -0.6879390404445266, -0.7495890614538979, -0.2481966631344142, -0.39457461320830867, -0.15489488128056567, -0.5280422065384527, -0.8114609606301282, -0.9128653550043394, 0.08924079124455099, -0.975631481455701, -0.4778125129921733, -0.556679905267735, -0.255770899110051, -0.4876261345438331, 0.26149836318515335, -0.7539039600241441, -0.6977193245807982, -0.5879751083731708, -0.8102739376562608, 0.15672408795664033, -0.6880543281486626, -0.5833136042858025, -0.13620608677728296, -0.596288079899735, 0.2776591387921612, 0.3659790598280459, -0.2639525407099484, -0.5739619711974281, -0.14556777532017462},
    {-0.5376723765530494, -0.1305659197630128, -0.6899549498562294, -0.41077115943847387, -0.33506662029811135, 0.30212666972852265, -0.6376073171192311, -0.5084723492798496, -0.9727514846762142, -0.7108965188423502, -0.7087090418429246, -0.04802935590612249, -0.5027154742181564, -0.8769972169420339, -0.019556952919623005, -0.33876710003327865, -0.7191012943031773, -0.8121327846742201, -0.8876746607384729, 0.0045141724735328695, -0.5293132484095495, -0.05336420298934779, -0.2600923061509597, -0.06878691451018795, -0.7077588032829111, -0.7871241637517508, -0.6167354841308724, -0.5374398037729917, -0.5845397440964614, -0.37054117721129715, -0.14588766850299675, 0.07205853408099039, -0.31235286012509034, -0.6286948694873007, -0.6692351698601935, -0.9026672602773527, -0.6793321154549018, -0.5255927186719976, -0.4076369210085902, -0.010637866167433502, -0.4163665630570895, -1.1871831241951414, -0.6697986828250841, 0.010474372440997809, -0.6320516084650732, -0.31951268851233294, -0.8921053294328782, -0.41915092299102963, -0.7999395435477724, -0.13442326383916198, -0.8499829162795689, -0.47760113777068974, -0.6873871609302465, -0.6147583078776865, 0.26054225736193753, -0.45021702501446204, -0.5721288359534283, 0.02203057811324166, -0.8678308504991799, 0.38829561289382436, 0.23041960925455612, -0.7736251075831366, -0.7295911110321077, -0.193795089304541},
    {-0.020335312148047246, -0.026648738811764883, -0.21836975217876162, -0.5926239857812117, 0.23279390065040945, 0.48114012511062193, -0.5002684187197719, -0.3104880922950212, -0.7868983559669154, -0.636449624623385, -0.3474574644585059, 0.10020668480187633, -0.5813581486701555, -0.9560471666980488, 0.10365461453244251, -0.07321547997355696, -0.6487348465434678, -0.8478388241632497, -0.46515874800816004, 0.2041177920055515, -0.3452344570513551, 0.23855430195244615, -0.26079208151401556, 0.39109626741468007, -0.41558553041406854, -0.5735920653173168, -0.10831609098376337, -0.4286019021550863, -0.7122927823186359, -0.12524354539752341, 0.27456761237095917, 0.06913262425826656, -0.0774836987843614, -0.6005932450102209, -0.6586713599033855, -0.6074470498256437, -0.5721790305074028, -0.19432050598159722, 0.2471646449482086, 0.3771909191662032, -0.3550087606299702, -0.56895182335784, -0.7200665180111459, 0.28694166279673905, -0.5199097988782142, 0.232544788047356, -0.5726388231589131, -0.29285443667737177, -0.5707782144092078, 0.4278415697236991, -0.7522220173084168, -0.45027550561569424, -0.39491073102256585, -0.44792470164791576, 0.4463708712269941, -0.8442942413351021, -0.1748211694169138, 0.5731465066419725, -0.6083711553321726, 0.4050039871989924, 0.5344696168813157, -0.5707461460850931, -0.48020597130663817, -0.32768356076209043},
    {-0.6800539112380536, 0.2876276943306671, -0.14612090906625536, -0.5613072116604211, 0.20739443782139028, 0.6432351388717278, -0.29197968920981837, -0.38699019437459997, -0.6025201909514045, -0.04740316450114307, -0.17023840445575136, 0.19607671670376803, -0.11347812221632046, -0.9978738275683626, -0.3556174984969819, 0.15797452349775187, -0.8765863769749463, -0.4579747065058382, -0.43009051908053897, 0.6032909851237597, -0.10772139959612301, -0.05420124511339976, 0.12994205424214283, -0.029361294334795018, -0.06301891148852858, -0.5601729061732514, -0.16567775219230235, 0.20823792142222472, -0.865949002567492, -0.5652797991870501, -0.3034514069629292, 0.16582990378178647, 0.06628518667119493, -0.4109302124816477, -0.12908538168996272, -0.4320966991773137, -0.47435165046528815, -0.06293927949906365, -0.34214011746359557, -0.3072063241814669, -0.23501934674057387, -0.5288711174432037, -1.013713726461662, 0.11985055126031381, -0.6002698784769558, -0.06724171114809097, -0.15126529184889065, 0.1808930062444893, -0.2524142402695403, 0.15595043868446884, -0.4622839386913534, 0.06901518182387863, -0.5221175629138858, -0.3001989784962228, 0.4984953294283663, -0.38635623419144993, -0.6575022617327851, 0.34891730818592254, -0.7987569704092572, 0.5865670764367993, 0.5422002526026012, -0.16569191712204356, -0.17594624912954354, -0.15754265484036314},
    {-0.8923978467072855, 0.12131397093121746, -0.22891663523283967, -0.8777478888347453, -0.09490886619490373, 0.4337421749838697, -0.5337359223547727, -0.6028093969617182, -0.7197428062093193, -0.6945850130440878, -0.28222680309443793, 0.23240454715321035, -0.09428251639309676, -0.9193039018219071, -0.35774038510667017, 0.2253106284189848, -0.7920649279540335, -0.8438239189579615, -0.6173158505554462, 0.07702669326365297, -0.27363335437539477, -0.12240144836655496, 0.11218374595887246, -0.1973730529779469, -0.14976743160780606, -0.533963742888613, -0.12863641029236947, 0.05623110747758733, -0.5670325844758535, -0.6743631084361519, -0.5812595740025934, -0.2622884459940921, -0.3502449180055531, -0.6570843297829655, -0.6360342332734658, -0.46411429357949974, -0.7334011680209411, -0.24314109578398688, -0.3815770763554464, -0.5577175638673585, -0.35288751979150124, -0.6240688219811849, -0.8094933524953707, -0.0054408248026214115, -0.9131261886011184, -0.45090954221706114, -0.7421905377560271, 0.22677758415884702, -0.46326913009381215, 0.1527249452478436, -0.5475969504170076, 0.16302820112425534, -0.4464430562876417, -0.3163299909314862, 0.38614239494664454, -0.748015295646662, -0.7960418327219556, 0.08413624591621784, -1.1544033918229404, 0.4109469579136305, 0.17272759649702465, -0.16327007961681037, -0.317827876826043, -0.4632651507753},
    {-0.9064748427365671, -0.03966127986802309, -0.2683324883178988, -0.9221431675392295, -0.034026651357330906, 0.1574198849292542, -0.8440498752711086, -0.8134555344814461, -0.6907730269653414, -0.8809427854731275, -0.48735297975385006, 0.14051502232486426, -0.43959431704787033, -1.029016811853924, -0.15212075371349537, -0.568261724941842, -0.7060657157490946, -0.69158273657973, -0.6022061306701477, 0.3584415931730776, -0.7418234634489844, -0.05509725659327784, -0.0499845312557476, -0.2308729851978103, -0.3320167422967269, -0.4666103558568597, -0.3839016769759367, -0.40492201326539057, -0.6230404550801294, -0.7734513588137079, -0.2647448681695807, -0.34762133489961566, -0.640728715272707, -0.8607853757868471, -0.7445156770720294, -0.8338172556143726, -0.6370728929709232, -0.6637640055624305, -0.3625090437167324, -0.21514179298904884, -0.5245172727686049, -0.8644062499454938, -0.8371224300134348, 0.03369221292059511, -0.7663331099380785, -0.15623686761418026, -0.5712428631423362, -0.322245506004365, -0.6979020102747481, -0.03523628005842714, -0.6279772909923328, -0.2095953752256954, -0.49495265438811265, -0.8148030713987852, -0.08588939016146853, -0.7429175020406249, -0.5840881585144027, -0.05986300192453325, -1.0144905845556476, 0.19457087392090053, 0.26137438203306007, -0.7144350029581884, -0.7157167047307811, -0.4763773497275132},
    {-0.7457733189443619, 0.14703369511587852, -0.7077261727741079, -0.8588955239717256, 0.18135847738264993, 0.35802354585010365, -0.7520325254701391, -0.7034707551199993, -0.33306682231099904, -0.39328933087436063, -0.21614374766110883, 0.28094247841395326, 0.09727454900611483, -0.9258655192044891, -0.5984023526702784, 0.284077919507365, -0.7889778089271778, -0.793042961040206, -0.790758812038339, 0.3938763170110786, -0.13141930636816132, -0.4411782761342615, 0.2919799178942787, -0.10411863998451448, -0.06724228197721621, -0.22013158174323788, -0.37437677812396747, -0.1721695456708132, -0.8680091382355284, -0.7981920132851362, -0.5566937416812078, -0.2904317824627987, 0.12772405018634933, -0.36929167089514076, -0.3389581781413079, -0.6042956062252358, -0.1907872307411804, -0.23812280896708612, -0.6458972715589633, -0.40792962737142296, -0.4244696328982793, -0.585485547282923, -0.808887568419394, 0.20241637051220854, -0.570431482691242, -0.44865131270376485, -0.435384709703572, -0.2124425971595035, -0.3338128543493073, -0.14293648322645722, -0.5892895591010037, -0.06203661751736799, -0.6590464565599587, -0.5722621078836495, 0.27006781014637654, -0.677943661107529, -0.5714041223265716, -0.025006520049863507, -0.9949042107992332, 0.415302847584763, 0.37097328139266095, 0.01897920479829225, -0.2819632272719463, -0.2708514989759375},
    {-0.7212098936236815, 0.2665419511071751, -0.36708848386478865, -0.7260218607987505, 0.01228905919538919, 0.48551095714054743, -0.763109868496013, -0.31269804521045313, -0.7696584928341792, -0.4349239660472737, -0.26501282364307804, 0.019908780586375158, -0.44767069297103584, -0.8507035685459726, -0.1451810396959838, -0.03300564781270531, -0.6967805644262433, -0.4009145811952585, -0.8043081961034815, 0.13605062338134957, -0.29364937093122495, -0.02428054594341036, -0.06604350414484696, 0.006405157775552564, -0.14565641927779197, -0.3621187819255812, -0.0506925786606146, 0.07257217525255505, -0.6054719997402004, -0.5443310676867773, -0.11998320925297203, 0.11505188770601404, -0.017464685100743168, -0.7059275717815825, -0.08480112836550342, -0.44730482340295474, -0.4780580115790162, -0.18966284580880163, -0.49102139599496136, -0.10165771498664349, -0.44956791298589854, -0.7503248899157058, -0.757284160957721, 0.2674128111212942, -0.5376905008039019, -0.3994267008815176, -0.18522653272933753, 0.1404700483560323, -0.6764804031899988, 0.18805159968841065, -0.6561895933355504, -0.11235658097406445, -0.597233438142879, -0.4813176486467049, 0.23316585888374194, -0.4843864318845874, -0.5317253718999478, 0.08712555686972892, -0.9714368524680521, 0.4123532196215458, 0.2906462454008828, -0.1896543928137585, -0.4398169537936396, -0.13209655520401345},
    {-0.6333602022801205, 0.09746973437349314, -0.31969935023590373, -0.8669165207986267, -0.1660859383775465, 0.4737365265911265, -0.5461450186740255, -0.7440692601179775, -0.6099027220906528, -0.6924397435452262, -0.2694842965670495, -0.07030468590312394, -0.4883371294528904, -1.0112039524460217, -0.04860345740226949, -0.1806525172545846, -0.6972966266279065, -0.5759158478166633, -0.7534035153020936, 0.325924875479833, -0.32383234518756165, -0.062221609044162414, -0.08672645608622996, -0.23241924465553096, -0.40902361287001887, -0.6617634050958745, -0.2826580755513531, -0.226816822957799, -0.577786560708147, -0.5293293158657827, -0.32926110591987034, -0.21063047957216743, -0.1318385419630842, -0.43772234422968476, -0.37959629296927777, -0.6341419814059939, -0.337260643771627, -0.5570226819460524, -0.2632098916471963, 0.12545397011037418, -0.4741313837404705, -0.8437239790211701, -0.9042233934280239, 0.3692984139591088, -0.7269732201644851, -0.26135150576682664, -0.5182188481673372, -0.08335976591991388, -0.6021145620542557, -0.0950162828830128, -0.774259675593927, -0.1917927980921145, -0.4086073286429782, -0.27339624663023687, 0.17238026439006165, -0.3839109458007769, -0.25249292949401003, 0.15754491701806594, -1.026391017466874, 0.3168560224774567, 0.1664678557056453, -0.3618321627179802, -0.40817882526179505, -0.2181821866350997},
    {-0.697601303546208, 0.4960751236313832, -0.432050597355478, -0.5273796814078946, -0.15142174199438788, 0.27705854938707963, -0.3645446632520846, -0.2925067900585628, -0.5820464749033476, -0.6612660283883904, -0.13592608094730016, 0.038157743792487556, -0.2558112215260715, -0.858023164216491, -0.45508742512091555, -0.25208545190021925, -0.8611803592882501, -0.9651588024108997, -0.7194414245996613, 0.2947988911122655, -0.2953099957485164, -0.14913991134987037, -0.07997890076550455, -0.014889648212286924, -0.5247899949593995, -0.6343059721606902, -0.024043165025764663, 0.11371955094980578, -0.8694851810506393, -0.8687933891762292, -0.48618716180221266, -0.28597597701790056, -0.3333358166838055, -0.7321070911620848, -0.5325471933158271, -0.8286873186849518, -0.3672941520776694, -0.23867987421778966, -0.4262311038349999, -0.22262117663346487, -0.6091829151820278, -0.6797536868325307, -0.8119557124128335, 0.15495893290664395, -0.8427153299375939, -0.42727537613944444, -0.5934501421771193, 0.13172413781235287, -0.4521844443458277, -0.20689431573440467, -0.67221857790719, -0.1059614336547606, -0.5437463883181504, -0.42104072482273286, 0.5617951313002159, -0.7146996892359534, -0.6629463276890653, -0.18186353618543644, -0.7405640274567773, 0.04573048796554958, 0.18491883847490914, -0.3440786083747483, -0.5580351957651297, -0.2953907725849015},
    {-0.4961880804651111, 0.29575817389037906, -0.03798953866199403, -0.7307078309999354, 0.30785226909175145, 0.6143207203060652, -0.7078125674905174, -0.20849975761666353, -0.3959832982270737, -0.3116966732798078, -0.014381601951740628, 0.1407705476369249, -0.24554327460285402, -0.5724025631322157, -0.08179680818992294, 0.11012469639553628, -0.5444105570220861, -0.45664801174203895, -0.5231862039032849, 0.24997769435487843, -0.33347455453174596, -0.06759086622886017, 0.08975924924360168, -0.11328077653887925, -0.22194436864609693, -0.19778909673974424, 0.21493280029385547, 0.03396086015324684, -0.447189149532208, -0.7941005052058762, -0.12070656487361349, -0.023807178715502707, 0.26931712515731043, -0.6195325081539041, -0.023644086132975518, -0.45626910266573145, -0.5218463799986924, -0.05129750277388614, -0.3373185512100332, -0.25351580966295845, -0.21398073545438112, -0.5395056889905452, -0.9064781651818683, 0.15482674076264138, -0.5534177031988663, -0.33142980235160197, -0.40927357100701584, 0.09919396320204589, -0.22560344396007523, 0.2212622048177145, -0.4346716347918212, -0.3164298162085943, -0.2569530483419287, -0.25814480041541993, 0.44093932527506235, -0.45270061659732524, -0.2671712384952103, 0.4334861899205821, -0.8422780326137317, 0.4132872650963532, 0.8131057665049934, -0.13813510529405398, -0.4514901526550769, -0.3633214103496935},
    {0.004811940362828001, -0.5123839563367221, 0.4936300841987211, 0.5696168996004511, 0.4058343178703581, -0.2866679850132783, 0.481202195350108, 0.794932859735949, -0.2619120120771713, -0.19174285175619604, 0.37024060378532503, -0.9097834102618072, -0.018004342870485735, -0.05969711940551747, -0.223288139531533, -0.21587983425845275, 0.26895594847119125, -0.7761317373550927, -0.32478524148477966, 0.616671046229466, 0.29375317695649267, -0.19411178652374525, -0.14632835925857796, -0.11725838240470665, 0.1415139303701642, -0.41109698164999053, -0.5498566612681958, 0.023105102529173714, -0.5162744307857436, 0.014938080615044244, -0.30638249073658697, 0.5897435057838144, -0.14933774761817417, 0.2828106884294507, 0.15601404858502657, -0.07473897489488195, -0.06422645491128372, -0.5365361457030842, -0.2766733132694538, 0.13079023946518717, 0.6767173707459275, 0.3172863127958106, -0.26410739655998683, 0.4847619383450324, -0.13535817987216545, -0.04793666224006456, -0.22422753095718162, -0.1328926918951804, -0.059295887842302095, -0.34774269328252605, -0.3040014916148611, -0.3011869178791188, 0.7031074409340285, -0.7724058287454336, -0.6115547178536057, -0.41692929689134633, -0.28358581015243145, 0.39535549994493974, -0.05978385052585736, -0.4474741082771727, 0.4256467064562321, 0.2196905789871265, -0.3115168827275296, 0.5445726038274399},
    {0.032163074984726085, -0.16834882895586478, 0.6503526207969175, 0.8530016864068988, 0.6822198394125847, -0.1808338868450018, 0.42839852951354446, 0.6227430440230028, -0.5549609587260139, -0.21122641604203485, 0.21935730912680595, -0.47776231849113676, -0.16133410843898982, 0.22494036710741647, -0.2813740674484139, -0.22305679542104664, 0.17963268627562373, -0.5375501985756982, -0.2557324602875669, 0.6343481187832262, 0.12104632070883777, -0.06101024509421639, -0.5344862848922193, -0.39978563425578656, 0.14488109655727988, -0.5638792289933979, -0.5982544199315336, 0.10613859431799098, -0.3808066593306437, -0.01709903486433305, 0.23527059899541242, 0.27247662572032827, -0.35548055878008206, 0.6153980912250077, 0.16298155742190126, 0.14875054237737248, 0.4970972709286044, -0.23183377880967884, 0.019601371233209614, -0.04819075144264252, 0.5403935354836163, 0.6114242000668509, -0.058639283818784, 0.29196544673690905, -0.055598493724545985, 0.12692244854389514, 0.21363268262536234, -0.08226806599514415, 0.13998777247382133, 0.04830989062450376, -0.3407589472600012, -0.13894766340579304, 0.812741269272692, -0.47160513554807054, -0.32805253058944367, -0.13675624128570274, 0.4149851119312594, 0.20957013065724983, 0.28480911805573683, -0.7080987275254638, 0.5640419586428769, 0.3857391288543361, -0.5216597726985068, 0.44874359312921724},
    {-0.24713678060399175, -0.3265821996694863, 0.8608290892393896, 0.4837061659309741, 0.8673390122215724, -0.44287473131925315, 0.8393156544741491, 0.7568102094907062, -0.5557999400235766, -0.32485836041544586, 0.2011127892846995, -0.3955836250927062, -0.63974228453198, 0.21372136717188348, -0.352965491855571, -0.13152297551109313, 0.24924160111287094, -0.5402263133234545, -0.6243008539139779, 0.8310577321651359, 0.1441547464459368, -0.588598935245497, -0.42771063410444826, -0.3932540112133479, 0.14350268408539935, -0.3826028311305953, -0.7573191648767863, 0.2607348395238038, -0.6928246473606898, -0.136537300120571, 0.008783337010506534, 0.3958937740912917, -0.16594883050307438, 0.6099249319058353, 0.49692846201806745, -0.15254893367405611, 0.5623722375618838, -0.38526507697979595, 0.09925058365942015, -0.11609873779933502, 0.6362566386725422, 0.0601696966686663, 0.03138866600113038, 0.4100312502995735, 0.2162212175107739, 0.030467906005695076, 0.5637166282173679, 0.27097810337261785, 0.7888299978230423, -0.30461697690733447, -0.3212439089571577, -0.4238686736710186, 0.5689061384763684, -0.888149981908029, -0.5455296771637584, -0.6339798659309996, 0.32164592242480033, 0.2168875959700674, -0.014353932698067381, -0.6769008619974536, 0.5298140179850735, 0.3504658720557142, -0.7136669567680164, 0.330562697916309},
    {0.13370410025757068, -0.8673851233886453, 0.6524121770742967, 0.2826783303221816, 0.7212516264424058, -0.31920044764406236, 0.31352482306621293, 0.34635920111901247, -0.3195021561242061, -0.6839019622977325, -0.018054442484267765, -0.2244012422968496, -0.2471304061635695, 0.23548241104771134, -0.6384241718424809, -0.2459961258613551, 0.15286492077670272, -0.5085278040322595, -0.539685899141234, 0.6285422661331601, 0.13420885387848294, -0.4205870365834335, -0.3162098677718302, -0.2518572655389117, 0.2306752681806727, -0.46439140514060023, -0.753539575554408, 0.4918637560492102, -0.4895500145862629, -0.36186442812649433, 0.02758828064564348, 0.5697364949496055, -0.4830757659539821, 0.8257458931402721, 0.4422711738264342, 0.30928823041947334, 0.5192349513205277, -0.6099764174353939, -0.06040891250830195, 0.019331099304432976, 0.6369835602676746, 0.1525402533548409, -0.08038117512565822, 0.5734634120482159, 0.4163464706918434, -0.05319512510951359, 0.5436171953517568, -0.20365263736807793, 0.5859252289465732, -0.5815692039359561, -0.47215728813818425, -0.14836496054642248, 0.9352180257587047, -0.6666915107209036, -0.7509264006772765, -0.6489199124641604, 0.5845280685942129, 0.6862315527843849, 0.039995250721278186, -0.5792876743902946, 0.45872970989662, 0.5182519136084487, -0.5554106639439934, 0.30629549601885087},
    {0.39361993202994716, -0.8161295503027125, 0.7234333242272069, 0.3993324329353435, 0.8429053465003565, -0.5877335370340917, 0.5484466529566016, 0.18486558124569327, -0.3093335221382304, -0.49513820428386024, 0.21114574107408057, -0.19278277775405944, -0.4832891609963156, 0.4142935679733738, -0.5517558067471514, -0.16304981205620322, 0.13824453530496955, -0.391362892400768, -0.6522813904101052, 0.6644825573901014, -0.09672753643390886, -0.09099123923035611, -0.4018919203095627, 0.16911117531376976, 0.4989904896015459, -0.1881127558444718, -0.6415361698646028, 0.5011476313696793, -0.3724514783745872, -0.22486699208347435, 0.06080927200794738, 0.6371019579371924, -0.3677293593026165, 0.5921141457583751, 0.5817633675905599, 0.27542741545336236, 0.5785517136604378, -0.6075118168317105, 0.3249725640955197, 0.1002731276279559, 0.7169592805218024, 0.07089220022346393, -0.32535442370408374, 0.594576384320634, 0.20059153789800938, 0.25951815788873395, 0.44684562003983425, 0.006493387563942605, 0.3791827970786446, -0.24606680738179312, -0.3612431476157804, -0.1272640682331308, 0.9432134093331915, -0.22295717952321645, -0.5543530556846961, -0.5092667325985302, 0.30548821394158315, 0.560744232458556, 0.19428912947125945, -0.6405079799697693, 0.41004981297182186, 0.5598788080390866, -0.5153528356890817, 0.14982310530902437},
    {-0.2618704945661497, -0.7900385070509327, 0.6688999660949099, 0.587522755591067, 0.7426695220483711, -0.4722846017025353, 0.6455248487536221, 0.373684766121311, -0.4933505544210432, -0.4181089065465286, -0.060669400854481983, -0.4631079481267462, -0.49589318424946227, 0.3638813866152617, -0.33944763709860337, -0.02644887909883331, 0.006298789448054564, -0.4971245713407112, -0.6621450586436227, 0.8356789739932476, 0.017793704147598958, -0.0556215264023107, -0.32892396386436734, -0.1707571908019624, 0.5368347630445076, -0.6685592573002623, -0.7221253366278514, 0.3780373055250393, -0.459203921325423, -0.3767223088079007, 0.23949649122864747, 0.43458156989218377, -0.26124312860795, 0.6746246042045757, 0.864603041573284, 0.20674434057295302, 0.5606232475073822, -0.5187606339519378, 0.0739650896341637, 0.25135080380065444, 0.6095065176321961, -0.23863354816546345, -0.1534044676240481, 0.6232574031293862, -0.008775771768708978, 0.04732492080952415, 0.3606892266974926, 0.04989244362291484, 0.3703311264451093, -0.05845880979905334, -0.060395224756956474, -0.08337334480538722, 0.5543363970457872, -0.5167766452523463, -0.5824215763340062, -0.3703413806989227, 0.10575053786185287, 0.7284230700856159, 0.2487554411949325, -0.41761129037036315, 0.5125831246638477, 0.34121290375121355, -0.32166567730728457, 0.3810414886761058},
    {-0.3635061693050971, -0.6741716605341489, 0.4666995424919335, 0.11663778219161298, 0.5957814171227499, -0.5197027219700976, 0.6396356074949632, 0.4678961567309918, -0.2683476680333592, -0.5080041499064321, 0.059590277229089314, -0.6863046766519474, -0.7000674315901583, 0.23936197330089654, -0.4560690680986189, -0.43124680869857546, -0.09992017889427468, -0.5828272698297015, -0.6095309776298793, 0.7799758166580891, -0.13401674862125285, -0.2468524309816233, -0.3294354129692446, -0.3573502245823492, 0.8034024164516737, -0.4481789944697682, -0.6014557121650362, 0.4499503396995344, -0.624974496408084, -0.28106530462174856, -0.014615212728259263, 0.34847425523542574, -0.5037380878280645, 0.7098677694953841, 0.48745393743652965, 0.25071694257950344, 0.6885886431310879, -0.619604196448774, -0.07908104001145534, 0.23207683024762524, 0.5089019159282103, -0.20890857017765313, -0.24105875714560834, 0.4799842832928762, -0.186545406036718, -0.1437331324954591, 0.39752163871426593, 0.11196563574052193, 0.4255710356157591, -0.11820121256881508, -0.3998999159317931, -0.02117053647747166, 0.6272585335374736, -0.4620696588865633, -0.5663742365213792, -0.6965043197364826, 0.2343859103447135, 0.5615281490580352, 0.11932235482156107, -0.6102886457784249, 0.7818502534617011, 0.025171994240274654, -0.534209294106861, 0.3416570873983995},
    {-0.09207987387403933, -0.7054919128641524, 0.7835613835091587, 0.41546919892256107, 0.7535269078035083, -0.38195879067225985, 0.531301241532591, 0.49531062884185273, -0.30100062171577174, -0.11085168693907314, 0.14157283525807024, -0.8896849159684954, -0.4544089087827545, 0.11408548580343242, 0.17682314939920027, -0.17939219675269805, 0.05014637965584993, -0.482066840065162, -0.3784895745753545, 0.3847994651233182, 0.31262212538918654, -0.29196174161641314, -0.6385999434375279, 0.00844614377714311, 0.5223889773608357, -0.4141791420098915, -0.9694067094695202, 0.43655094404456996, -0.42519608988545404, -0.053718479030826945, 0.18808019314319288, 0.29984213301618, -0.43064004890299806, 0.738489473935248, 0.3941813497705625, 0.16998803464821285, 0.4754272879924168, -0.7633482120173529, 0.07162622622363168, 0.20943271096217753, 0.593666612749449, 0.3416472552065104, 0.22498781944120802, 0.616747475691726, 0.09367862082938122, -0.006227310511568081, 0.3006979890126863, -0.36038437816225605, 0.20575186904121895, -0.127791152893911, -0.0064397264528372935, 0.05283829845232462, 0.29305022711824674, -0.5642549461153041, -0.5490838274609084, -0.7568485199414051, 0.039262131723026845, 0.4564988326118511, 0.2902153437568703, -0.6182667913542694, 0.5762834294907382, -0.0009479837189119461, -0.3553221682183669, 0.5906395307029075},
    {-0.20877835080473287, -0.8446751976715294, 0.7923886207773464, 0.3811783737838541, 0.8849348531158922, -0.9071823258284804, 0.8447401009352613, 0.8540415311974119, -0.44965838285949444, -0.4224607229499973, -0.05673528026243851, -0.5351021571277643, -0.4049413259631943, 0.27483004751268225, -0.3782158736829238, -0.04772654956786351, 0.1930917623719358, -0.5621463858041637, -0.312446264074639, 0.8663056578970022, -0.04781793010025879, -0.3175452966179259, -0.14090885137690232, -0.15351372528493473, 0.1374184991089702, -0.6426104756450945, -0.8709599937283616, 0.3541962295065204, -0.37314773889613345, -0.11791588525300377, -0.041183378870817994, 0.2955380544977238, -0.4806812405260907, 0.6368390929498212, 0.5224953634189327, 0.40760487077310925, 0.32119144145594797, -0.28423375779918497, 0.0507513291421013, 0.10324560775752527, 0.7550277365991817, 0.5437204619667664, -0.11273786075531522, 0.11380328263138009, 0.03824502410133569, 0.23232619551365866, 0.5173741862227035, -0.04685249898826013, 0.5354228500692872, -0.8266014550119336, -0.30975811160607025, 0.09367970856128614, 0.6559214512792029, -0.8605886533049645, -0.48762565179273976, -0.5833537122603143, 0.2963264923631535, 0.7868444825567021, 0.09045336194949617, -0.6945032353627492, 0.6140331686548579, 0.26124702426979884, -0.5946283834719875, 0.20992940469473803},
    {-0.027554390768756796, -0.5021531781951919, 0.5361137874223307, 0.2810885066993858, 0.8433528105463782, -0.8067145175763842, 0.49728085358009944, 0.5158760699863187, -0.41122907079489734, -0.19656790971933055, 0.04681120641447439, -0.9080338105915293, -0.5045191920135024, 0.0456354910453725, -0.4856325374479237, -0.20229243475154027, 0.07258894593983051, -0.4670361406972167, -0.8477292293513221, 0.6671137490750875, 0.07259443248617592, -0.6480962607930852, -0.48395843067970734, -0.18422583402470397, -0.07506895453922098, -0.6926278224177269, -0.7439864559412523, 0.31743576801696194, -0.5804382796079813, -0.2506752587069128, -0.04780926599356252, 0.45848491495177346, -0.35282167195858044, 0.3967015691638023, 0.5033972521151547, 0.6431496890925852, 0.34582847863659993, -0.5750922539475158, -0.06186283550012041, 0.19086096737739047, 0.5541332499867897, 0.24319436324937735, 0.0591733795463209, 0.18190492833277777, -0.08707003845311055, -0.1560646510818206, 0.30723235617104355, -0.03356973875363881, 0.43763987119432646, -0.5990192608325193, -0.39391757518377296, -0.030741982567185133, 0.7010172018659099, -0.5703661465621148, -0.780466328255276, -0.1489082152697083, 0.3944808811830707, 0.6513379335785046, 0.18911109378690955, -0.2580445540128053, 0.6781937752816337, 0.3214921582053266, -0.5746914286368876, 0.052209480579143056},
    {0.16800552167043176, -0.8136351625687109, 0.8164457836203767, 0.22964749031305828, 0.8190028950308444, -0.6083615773744682, 0.627914943830388, 0.4560144160070494, -0.4250230641370208, -0.42267277179392504, 0.16191076075883776, -0.6751555490621626, -0.4659765277914364, -0.020721848385065945, -0.36063286056084565, 0.22526836571571754, -0.1560567373483243, -0.3511360176117136, -0.519272068373811, 0.6830186777691652, 0.23365518863084292, -0.07442850265721437, -0.6249036891389611, -0.005876481574122044, 0.08223729618383267, -0.3865477916366854, -0.7533339440713662, 0.4445682332992826, -0.18928233080699186, -0.21286717311319517, -0.07303369462324501, 0.6848596267392992, -0.4265497280161693, 0.5931055077284707, 0.5033575695780919, 0.5237270037886337, 0.24810847285023913, -0.4763766788144474, 0.11449384260598963, 0.472076696995054, 0.780731565124199, -0.25192556631196095, 0.08890552923309918, 0.4847616844388974, 0.03045746034527468, -0.08231098375142339, 0.24668354631792394, -0.1407670045689183, 0.28761004747965474, -0.22281499264772758, -0.4287545376102119, -0.31284339241878906, 0.3468758072112668, -0.667263195125097, -0.3530589865826894, -0.45258959329093545, 0.05482649357979334, 0.7299875229724623, 0.40799734188890197, -0.47633599529002096, 0.6784230746547902, 0.40214286047296804, -0.5157575921688796, 0.26961825666684996},
    {-0.1240634979340602, -0.6972635452186592, 0.783450941110708, 0.587696570913102, 0.968925621574516, -0.8363889921061808, 0.7139165987653376, 0.6995048885857027, -0.7318211868651258, -0.5160028282589744, -0.09767515804171423, -0.7197840659358962, -0.42487494398146497, 0.3158178918208976, -0.5269091963523763, -0.026675496699957054, -0.02373678879800193, -0.3432725090789256, -0.35691346851489997, 0.7999654101405459, 0.1813938066262293, 0.057496162454431794, -0.6044711813528917, -0.4398885916658247, 0.12438209246420229, -0.7311739007917505, -0.7319258159798087, 0.45784031179798756, -0.28292594411152544, -0.45587297400913596, -0.2357684637687814, 0.3906288159787602, -0.47083025265146405, 0.6857232621471339, 0.17648674447695897, 0.05886434849608651, 0.4645980138430172, -0.5773254868824118, 0.2340693101880162, 0.3844747102561815, 0.48578079000053725, 0.4018379523259518, -0.0808226860031685, 0.5701965486676354, 0.06685373048080755, 0.15608380505633768, 0.33199863883013575, 0.3419997862022567, 0.7105368119518751, 0.08990892559244383, -0.27702866521655944, -0.15421068604362775, 0.43538523082180686, -0.7085564302959956, -0.78619612926091, -0.501413137723517, 0.7327346089821362, 0.42593274975196577, 0.38818586172145936, -0.6796762653921696, 0.7454507363302638, 0.3071776225785817, -0.5100799294167305, 0.32496702844242964},
    {-0.1033603826295731, -0.5424018015160901, 0.8449032672153843, 0.7197925472120221, 0.9088749399391083, -0.6162898261313706, 0.9432363771483552, 0.8133468855422733, -0.4551029208664603, -0.49536024066620554, 0.06887482251701961, -0.7934799558770927, -0.5132323020084771, 0.40458309691707967, -0.3875056991136191, 0.2273096823354306, -0.06172258169866976, -0.6207857501967212, -0.7130139314945454, 0.6762343680442913, 0.335148181810836, -0.32345948855740425, -0.4349312520261206, -0.22746317047398226, 0.06036354762598355, -0.7691921993445208, -0.9991850334408285, 0.3991164163891139, -0.28183697857199996, -0.33837875631285563, -0.027578800510569244, 0.46677903807575666, -0.42807747510104305, 0.5065991479722068, 0.46655347308226175, 0.24842797171743441, 0.21855110894808483, -0.4989346531297423, 0.03820335864920784, -0.035058255784671644, 0.8364336639990487, 0.665687669856303, -0.22209159398162978, 0.5762306763975663, 0.18534490812325868, -0.17634059344878017, 0.20645356976092782, 0.1509047704831236, 0.5994111818827913, -0.726302115658193, -0.37987818156331266, -0.02843034137702525, 0.6227667754464531, -0.46544326629850274, -0.6668016396453749, -0.357724536679216, 0.4943482624952241, 0.862395499646513, 0.0840291776974709, -0.7077844457368819, 0.7464984760625221, 0.4146674037906828, -0.4120116116438868, 0.3406368695920131},
    {-0.3258050928288001, -0.6271103471949352, 0.9779802544817027, 0.5616443578696158, 0.9544971915081264, -0.9816653766421286, 0.669868842643211, 0.7059448150113147, -0.5667692148814457, -0.3333632282755546, 0.15398636955408537, -0.3239600271161728, -0.2123675703633999, 0.4366985291237855, -0.10608292629764426, 0.15017738554302942, -0.14983806097560168, -0.3592578082868229, -0.49622630492669717, 1.0049025874050939, -0.009417855620651474, -0.35469326392490613, -0.3617161651095299, -0.17334618110995673, 0.22246374060881677, -0.4516003897193986, -0.9520007047052852, 0.4925174625561999, -0.3119491892916398, -0.09320368491906048, 0.0769032461066391, 0.548985161836799, -0.36893057661227524, 0.717579828732264, 0.4107382771551861, 0.1676973261700752, 0.18323912285105495, -0.7057075082116938, 0.07675670195642043, -0.3109269507392472, 0.7469092368999566, 0.38210717717430775, -0.14106539166486937, 0.34022118176713534, 0.3463326361763607, 0.07251534962684711, -0.09278104069712836, 0.1674376507108257, 0.4986182240653055, -0.46220299311593044, -0.462954314595322, -0.22770450559601513, 0.8426244492194785, -0.5275224879511032, -0.610853896793033, -0.591378019576952, 0.4317675849438713, 0.7442062577383894, -0.22247396755007437, -0.5143514697438616, 0.7675905368980702, 0.09655164865211946, -0.40354670078960436, 0.14933502229553536},
    {-0.21517293386895245, -0.5248791599674524, 0.7349829559469181, 0.5059936391591164, 0.7465591424992581, -0.7297103812524935, 0.7605629194798039, 1.132078531611118, -0.297736574763068, -0.32972403838502906, -0.0017797193700967405, -0.9058259758940506, -0.4550653831155433, 0.030943919032756676, -0.38921955311554546, 0.09079222601378312, -0.15648088911139507, -0.6128069562819985, -0.39473675241028655, 0.8049751568945351, 0.211938363602539, -0.23140484446212203, -0.44017405006195326, -0.2797831137617854, 0.33521943965265366, -0.609102929004245, -0.6257143227291873, 0.4073290875389187, -0.19807620825402153, 0.039006966782949556, 0.040335292720032966, 0.6301526345319229, -0.5029847935892104, 0.4696603065935025, 0.29752271366524236, -0.11160497978643459, 0.3995784271062193, -0.4058616333629925, -0.11917949650490565, -0.20861975832173657, 0.702302908327088, 0.3025651222160194, -0.23336759963286371, 0.658452021163771, 0.1730134317193616, -0.16724510672085766, -0.3747405064334075, 0.1966475143532011, 0.12315566858070078, -0.7700997955020569, -0.4155775855531936, -0.09839141209457118, 0.7943002497785167, -0.4618746004479821, -0.4443296394332014, -0.4247950499722319, 0.11685221818800484, 0.774158738150005, 0.06397609287433592, -0.5279257679656081, 0.788339836565573, 0.15438644826372738, -0.5432384235254286, 0.06151793815181162},
    {-0.12947525116353437, -0.7681617787954753, 0.7329762950216078, 0.6858247826454067, 0.8433128074380791, -0.49156183368826506, 0.5815395532502975, 0.5380995447895567, -0.4417093649190653, -0.40198691749640253, -0.0775021932320367, -0.8113973098577542, -0.20082122348444068, 0.054710822462799874, -0.4875507441176778, -0.2961537823711779, -0.2057921464455863, -0.38386698404617725, -0.33940814600685654, 0.8344151218705365, -0.03842065241499701, -0.45348868406911486, -0.5536893827376828, -0.3711301665183333, 0.015457538967154036, -0.5908120889643045, -0.985077584117015, 0.1754628002807228, -0.4746207369418141, -0.32277767620586684, 0.08592230229344482, 0.1058791674168542, -0.6844709066285138, 0.7168227528219445, 0.48474505699120324, 0.016126195113381248, 0.23176964943897113, -0.6794890875397483, 0.03343228934117502, -0.3172594050338341, 0.45035917274149356, -0.03345544180965859, -0.16656176324944535, 0.7326651128734214, 0.4650260444411531, -0.2027914552433113, 0.007071195960502856, -0.3082542308645978, 0.2292020577996097, -0.7186825248347669, -0.4631050463261678, -0.3259804405751912, 0.8587444586369101, -0.4131709374000636, -0.15579809744001386, -0.5388521868172308, 0.3568962374520944, 0.5498245232077694, -0.10266621624690461, -0.44528358967036413, 0.758373389783534, 0.35519314814756314, -0.6520529993254881, 0.2170954639100516},
    {-0.2513188530312723, -0.5933904926103379, 0.7870547514205153, 0.636060603776914, 0.7392381779018975, -0.7910663173141428, 0.598690776208616, 0.688209874377226, -0.6666679342386672, -0.14129204856240138, -0.6348384903029738, -0.5595806080378766, -0.45024597436228486, 0.17186229564116356, -0.11724330449219701, -0.2149717012044261, 0.039082685473121645, -0.6608917127395652, -0.5142977039957425, 0.740026317418702, 0.25225012203883657, -0.0045754061877640514, -0.6552024512771858, -0.2877615467949577, -0.28433548648022466, -0.5741567900999746, -0.9469205741367821, 0.210375708904975, -0.6213392635515831, -0.2806012560216049, -0.002268590126901932, 0.43356654803258565, -0.9413095160995455, 0.5442114033771929, 0.6292838981996247, -0.0853243608196245, 0.41637505396600316, -0.4919753062210384, 0.14935616466577317, -0.0841633471212317, 0.7566061916493935, 0.7557599315971207, -0.3838518159167536, 0.5990746671928223, 0.39634357751153837, -0.0034446112723157687, -0.1448606001241625, -0.10788181504678034, -0.039463108050910016, -0.25705248953892523, -0.4683117890452175, -0.4314505162438205, 0.80622606510823, -0.6033443267564904, -0.3649808818883119, -0.5862981057261383, 0.40014884355415065, 0.7204384121564893, -0.015089993411271782, -0.10824098086264755, 0.7410790081200778, 0.4201835517688893, -0.603475750312381, 0.20664313887539423},
    {-0.2701732757878829, -0.7045599214540185, 0.5879770061402602, 0.7180378673306604, 0.7803546436263813, -0.6494091270229959, 0.36504709188173146, 0.6169882091080345, -0.6291032830645692, -0.505503185472129, -0.32579092126667775, -0.5322602371131476, -0.507490158786326, 0.16719252432265083, -0.19435823632701493, 0.09886010436295115, 0.5027362442226833, -0.6244385755395451, -0.6249656864939528, 0.4201415084203091, -0.15823588184008913, 0.08113375849009748, -0.5536699217120978, -0.29290869364501654, 0.11276425219013407, -1.0181533642680671, -0.8931440058692395, 0.37785697699502435, -0.8008836739964935, -0.42001492594040923, -0.21100003427359162, 0.30609058216802687, -0.5033529107189231, 0.6748933060971123, 0.6502459213117082, 0.29031734672938564, 0.40559117855538024, -0.7133380322565365, -0.022640523403734906, -0.09930898813325291, 0.6559601446941267, 0.47177985078176027, -0.17300067457574417, 0.47499310608301104, 0.5141653673240361, -0.08342633865288192, 0.020874976194232713, 0.060800620593802215, 0.0729161202748718, -0.3494622977120616, -0.647498142099206, -0.1759959276972077, 0.7476418645177241, -0.08136637291497262, -0.48758089176874986, -0.5650072037005056, 0.5116914192181127, 0.485135581325287, 0.14417409744981866, -0.1442022779671109, 0.6312593483379357, 0.5651696665478348, -0.6963551874575199, 0.015450411071936641},
    {-0.44402733266146205, -0.8506862586912382, 0.9521965513515481, 0.4971782537965713, 1.0073579247143576, -0.4217717228639499, 0.852656712301279, 0.6929239640715721, -0.6434020418450009, -0.3072139612312973, -0.023575402108669746, -0.5828410081261326, -0.269698915870765, 0.2156100638382109, -0.3372549739296006, -0.10106340005625077, 0.17694254548017432, -0.6126568495051162, -0.6239148751634607, 0.8824952455145405, 0.047998667724271755, -0.013755216904460885, -0.5200687070477023, -0.3867717038843128, 0.18263431610933684, -0.6223390375365666, -0.8965484286983388, 0.25899966128588525, -0.5764645149146612, -0.2996777581362685, -0.22097685002580608, 0.5039344182671851, -0.46754378399980046, 0.9272659604199195, 0.6791855020398867, 0.14383722318080278, 0.1215842873812143, -0.4406285036552832, -0.04969665104748462, -0.49040092633341353, 0.6196586442917233, 0.2427088065181017, -0.21328909245769065, 0.6845935919211463, 0.14797973383961882, 0.06968984022446625, 0.019757076343976946, -0.18320184085791041, 0.3607445299619701, -0.33093617927155544, -0.6320979425580007, -0.2448223707587068, 0.7150769090978227, -0.7282268832210098, -0.34337255198728106, -0.8562857709323868, 0.543826158069048, 0.6604747961165006, 0.049995401324871125, -0.39411085458674466, 1.0355635656597424, 0.578885801889773, -0.8747688190939631, 0.2562634464265378},
    {-0.2575515701101604, -0.8163249159024717, 0.5908920771485414, 0.6407950246212257, 0.9080239857707068, -0.3734215486473359, 0.7490509364169164, 0.6039843628967305, -0.8324601874816518, -0.48287744230484375, -0.02348955946637769, -0.8281695787073218, -0.5228186061382727, 0.18893568933340318, -0.2274188179217321, -0.02048349739685768, 0.0012985494326114087, -0.7521545698915443, -0.7251030985356807, 0.7667308243899077, 0.2968652610791561, 0.15898981632740442, -0.6251197544168977, -0.2103405556351031, 0.26300685873162843, -0.5163831422012629, -0.6603487536266242, 0.2400083330326833, -0.462250033759903, -0.4803149202424803, 0.0803328916949576, 0.7545832489693574, -0.7074219637394964, 0.8377483952454032, 0.11276147932677304, -0.0023014103312718605, 0.40579084878196897, -0.5189958228375252, -0.1481705855999928, 0.06485360562578489, 0.6967405291176804, 0.3064984989415019, -0.2586750792850427, 0.6941817242685404, 0.5527238990221223, 0.0036019682289183124, 0.4236731591188514, -0.07413976166408234, 0.1896268863720991, -0.3702165745062851, -0.26974064425200894, -0.251000606258592, 0.8307425498532511, -0.35091437247534607, -0.2876434754657747, -0.6675080220018905, 0.6692593362718035, 0.4957019649494046, 0.08692998142496007, -0.10703130002279139, 0.6283056247493338, 0.5071916642103824, -0.6120529654158835, 0.0589820115990088},
    {0.009906657901057407, -0.8138781317567247, 0.7352502067483794, 0.16131558972630067, 0.7519684723777477, -0.5758505810370287, 0.5200886385829587, 0.9064419064974011, -0.7166347740683359, -0.28086436408107834, 0.1288010456548707, -0.8422811254225471, -0.2994628376179837, 0.22538369348690998, -0.1411546707172194, -0.08738028970986941, 0.052387319663238126, -0.6266165615341195, -0.42275257755496876, 0.7137308775933412, -0.05683357655928097, -0.21164720084837094, -0.56791318484002, -0.12423310896410057, 0.07709342249977816, -0.6383511015600779, -0.8200616238628192, 0.28268505829695645, -0.27512482005859973, -0.26166053001272144, 0.11246676595857151, 0.4274087572221831, -0.410983100888487, 0.7990901608702273, 0.6526760246057769, 0.33388644309053916, 0.32126768917757237, -0.4013582224255707, 0.08081506449186616, -0.023915310044612843, 0.6134164464645929, 0.35250151724888784, -0.0875236922066233, 0.5159893233228219, 0.403160161517708, 0.010449262486070178, 0.1230016237751074, 0.1397398089886789, 0.1608123319823992, -0.45346792836721916, -0.1649868844682988, 0.06421371080481465, 0.7995926730716508, -0.18265470700617156, -0.4392792901015353, -0.362654903177446, 0.4155483610807346, 0.5516302302355552, 0.5873586144512704, -0.27351600671776855, 0.6715736033130922, 0.3063920185082798, -0.3930600345071724, 0.43444697298666557},
    {0.0851287819227833, -0.5000905887228867, 0.9652838501875174, 0.7384537445160725, 1.0529716799331805, -0.8982285149057203, 0.7157667278353729, 0.7659748957714722, -0.6449666146338294, -0.14813732806517937, -0.01751865816157447, -0.745776513293919, -0.42453171372026316, 0.6199926423899143, -0.30852651606996473, -0.252731993829974, -0.024605556280593386, -0.5524628948595302, -0.6805020565043909, 0.9221017146028865, 0.12854432888529166, -0.35019268412730953, -0.3984212714962505, -0.42948490129832995, 0.06863539318340728, -0.3903392492090483, -0.5741850387445226, 0.7378462755938546, -0.5078059105756458, -0.05517454278928626, -0.12050571724380797, 0.5171767694059742, -0.36160564861738986, 0.5150443516978881, 0.7869205921124282, 0.06323954158066405, 0.6350716951610575, -0.5427005400729153, 0.12959714645018386, 0.03047701301014676, 0.8166774792124166, 0.4803306953407007, -0.2577624850559027, 0.7971595060770735, 0.5949793027267357, -0.0158008372972809, -0.1384419114281045, 0.20637330385864625, -0.007078048218135349, -0.4110200875623024, -0.10585080900350309, 0.04748696041123719, 0.9066095165416421, -0.3518056607963173, -0.553764492437668, -0.5446223153054844, 0.503905436679146, 0.6585227939516332, 0.1924253416586164, -0.6606107581685811, 0.5930685690975687, 0.2297332840000906, -0.735167284162403, 0.626855649251963},
    {-0.1468384802058571, -0.5753046167864695, 0.6953466129195222, 0.5153648273974553, 0.8578343755489003, -0.553278631442165, 0.7563665332820007, 0.6220144930884283, -0.6758528971463585, -0.07330503146433866, 0.1382412970753726, -0.7679285033173981, -0.2623358628279916, 0.07404017579715769, -0.04696530913646344, -0.3388658263187592, -0.08210693303041104, -0.3653937280473498, -0.5547753405228386, 0.7851812737335537, 0.12295078026762274, -0.5484036880633885, -0.6325880456416302, -0.4867726719217241, 0.2590028275906496, -0.38496576506218055, -0.9820930651949273, 0.34036848008708925, -0.773720137479684, -0.5589490350830237, -0.33631562405945514, 0.4852065919045349, -0.18423319578935513, 0.9005852155011205, 0.7400029531252454, -0.2225680518590496, 0.2796437175924034, -0.4342073917983448, 0.05462053928512291, -0.1955734629362316, 0.6881736269573611, 0.5315229339584682, -0.365419541653193, 0.39242688725599867, 0.5656724517273057, -0.2217137431782253, -0.012416014955145136, 0.22713467753288513, -0.2970875721920343, -0.8673065620221702, -0.1334996393675489, -0.03694927446625932, 0.6704302074920824, -0.36193395966151426, -0.5362936785058716, -0.6077035436051567, 0.5254024824411171, 0.6601918893262823, 0.11772089299039795, -0.4234382755791749, 0.8139266474190165, 0.2796332459189751, -0.9430345192395104, 0.2791544812732979},
    {-0.06183476025533098, -0.6224857657880247, 0.9274765264214146, 0.5005873713543881, 1.1255985392186643, -0.6976907839783919, 0.36401440869940194, 0.9659538678450439, -0.5371883608960577, -0.7189270773453745, 0.2733921100035672, -0.7992031716307957, -0.32257798702411694, -0.07147851380920599, -0.5850023915597985, -0.3406316547306769, 0.30028199014610246, -0.653032070986588, -0.5434493334637192, 0.8033723082951155, -0.07410261647393634, -0.13800410823372072, -0.8748568121415494, -0.4768214582501702, 0.4316673973930449, -0.337471488307836, -0.7015599765762283, 0.3392539059896743, -0.6761458376308271, -0.4456185840231301, -0.4043430631546083, 0.4040256414889202, -0.41610871317452003, 0.6133678077607772, 0.6300682905846274, 0.22783112975166842, 0.43727734120128986, -0.3921794284117296, -0.006922131086235272, 0.19754980900539412, 0.9223066972773608, 0.6275193398238326, -0.09575407215678122, 0.609025688357135, 0.7386786241030001, -0.11725621776087683, -0.22690150271823803, 0.0053576372285049495, -0.0050851125652801015, -0.7434347147611539, -0.37885466202682366, -0.3778670796657016, 0.6720140782789293, -0.6893540216102345, -0.6095990480027854, -0.9117772881835033, 0.48866485594417197, 0.7917627730928658, 0.49659192798782753, -0.6690467652083779, 0.5229012965749337, 0.013888370060409128, -0.508646629993022, 0.11253063535199272},
    {-0.1004365360224874, -0.3893061636023809, 0.4514167903172722, 0.5829234412812943, 0.7402430615221797, -0.7559320084134445, 0.9875953661252386, 0.7462718743944888, -0.5503189551146646, -0.3552254482998985, 0.07887813938371681, -0.5125801247779349, -0.28074259060484513, 0.1030116264326789, -0.16120238818327307, -0.13733878492373885, 0.01501496146198395, -0.5462689126919061, -0.42730528726654365, 0.7808565734221375, 0.2420260466497654, -0.1432121262334501, -0.5536859517858154, -0.6195105802658295, 0.6091789190080017, -0.826485544147967, -1.0891049840889921, -0.014602213802071785, -0.39840842900541384, -0.45618008854628644, -0.2521833382190445, 0.3613669231660043, -0.38166663421759905, 0.8471038008940219, 0.20991061853022072, -0.5222601986906811, 0.1765008788191607, -0.5012043479764379, -0.005666295269980044, 0.1275508481653528, 0.655427911814347, 0.5957289700309827, -0.3770840780943447, 0.7381921804711011, 0.6411245510970462, -0.24095660873323801, 0.04254021554642672, 0.10613635135384106, 0.0350448896221189, -0.6527718699918887, -0.34832970990698514, -0.33422774700322966, 0.9456193365155027, -0.9123196493171744, -0.5350801905389357, -0.6499468244981154, 0.6345457658928354, 0.5820292218904223, 0.36594117469885257, -0.5766239916977633, 0.5960485801427616, 0.23289479746439865, -0.5934062439954774, 0.4469662081558653},
    {-0.2280765264335725, -0.4642188592257338, 0.6875820207706548, 0.5074097658449375, 1.0306191074217124, -0.750134797841206, 0.6251825586222115, 1.0151074473046304, -0.8511775103715099, -0.556204622175958, 0.04835382437080194, -0.7755780617281558, -0.20048887778084803, 0.18514109984817895, -0.32872159010187463, -0.32620276937945974, -0.08663109403448452, -0.5748914602303717, -0.7586401443726003, 0.7796788732692476, 0.27466394685148027, -0.17894702441983257, -0.6777883032346855, -0.5198689704456962, 0.3817389941102836, -0.4162389605391002, -0.7847035699783192, 0.4046581699844255, -0.612545652870197, -0.18291033262610518, 0.14339553063324278, 0.4594906043372705, -0.5120147564929826, 0.6913843671644998, 0.4247020196922656, 0.0747317345163175, 0.6449881286146059, -0.6230478361148194, 0.04741972117855007, -0.24689601965188193, 0.6421236959723996, 0.602499040953945, -0.4686195390032587, 0.6242592749352429, 0.5285084263260563, 0.05668904074774471, -0.11616624548082022, -0.04122638817084684, 0.054336348848877114, -0.6300778863682637, -0.5197714122839222, -0.3213026493203185, 1.0296883424621894, -0.5448276402340426, -0.6930911679475055, -0.5620367274378999, 0.6501750478258009, 0.5183893856715013, 0.14350764923403395, -0.5592087585495472, 0.48777876519599234, 0.42445299612718945, -0.6466840219279303, 0.4116563749744802},
    {0.061478198449231095, -0.5225802898126249, 0.6904202557186324, 0.6850141826360281, 0.8111800498910312, -0.5492591668935383, 0.7980139407197111, 0.8302843764945828, -0.5661834734994179, -0.4970533584421806, -0.07071364844613465, -0.7331638582807971, -0.1728081642966398, 0.08896471652634931, -0.12081407397879322, 0.017423303127928478, 0.07323137177340268, -0.6221366033730475, -0.7729169397317048, 0.8946408462875293, 0.3062437650635786, -0.28881769303147187, -0.46852437731155533, -0.20021762922114955, 0.21744693485209066, -0.586290929344019, -0.8961257466473873, 0.010223342730680306, -0.5015249861367125, -0.5020554836182549, 0.05137085496562726, 0.5312321011988317, -0.3239202810187439, 0.7542406612687651, 0.5410220763885949, 0.47982647125112593, 0.5917899048257403, -0.09809751161965298, -0.21069734475429258, -0.10881663016234233, 0.6104923809085085, 0.4003414186234477, -0.42199212992310275, 0.6502964257965785, 0.41691901806962606, 0.06375917478765444, 0.2662602753446314, 0.13837845995589929, -0.0931378971246056, -0.49898184123770767, -0.32311902887912924, -0.17020908901680998, 0.6982790741929118, -0.47048587262405406, -0.6612130175566221, -0.2930417717853003, 0.5918865999338893, 0.5571763359354881, 0.11694083118688149, -0.3038975531551929, 0.5656060931676782, 0.3982617631085429, -0.7061511947826244, 0.367759107427105},
    {0.003414511392411784, -0.8907976828791506, 0.5095310110499331, 0.5197072452062573, 0.6417723798781857, -0.670185237314471, 0.4510082209635458, 0.8929668612832862, -0.5676515491989088, -0.42162173381356527, 0.13114939724786845, -0.8208346152854794, -0.4548958110478157, -0.05451936594334476, -0.2549519133179913, -0.32856950531394175, 0.0013319397247038085, -0.46765077098833113, -0.620157338100552, 0.6148289300215749, 0.031930769237095716, -0.12531309765137158, -0.4996316918778369, -0.5203597428443262, 0.2879499864631383, -0.6605862312686588, -0.7011221944545173, 0.508384952800175, -0.536831561375543, -0.5355336837809707, -0.10933239691342397, 0.33968574709827387, -0.49585578846460526, 0.5195462794975608, 0.505412069008101, 0.3253028118810364, 0.809784978367405, -0.5780222152403293, 0.04339212070296904, -0.23366398042479786, 0.6026098384594138, 0.5795298829538933, -0.3903196842798973, 0.5165525841672872, 0.33646845659877544, -0.08229758540375366, 0.1800736686930962, 0.14689199375364298, -0.12335328717186253, -0.6599676120774238, -0.5039646824113436, -0.5023452378351444, 0.7058066832338885, -0.49876537838039575, -0.5046639827994823, -0.7772481608992861, 0.3774240270753095, 0.5208820192197202, 0.2077641703261182, -0.5778285368656263, 0.41755256502191834, 0.3741138977022206, -0.5742250615671454, 0.5588356458497653},
    {0.09122750434170313, -0.6052896304229589, 0.797414910181231, 0.7056951588196391, 0.6657440165282293, -0.7231607235816255, 0.8666718686899253, 1.128836741528337, -0.5905013152961104, -0.21917923433117695, 0.19370375435254708, -0.6280078676735634, -0.7093498949058776, -0.2112280924520318, -0.11405437249203992, -0.03590659263236377, 0.03607849749633346, -0.6283993424844061, -0.6383982603136931, 0.6923017269554702, 0.45009749385638365, -0.025825665364297614, -0.2782616671199829, -0.22122750143511308, 0.20204373798315087, -0.651052132519401, -1.0010648263077588, 0.17612531417151436, -0.6975162125890373, -0.42339246657853374, 0.0027866985786341378, 0.3119057732996048, -0.42194741397591423, 0.6650529633423294, 0.5046127220496902, -0.09709562518484184, 0.5489408854260428, -0.6265102729812609, 0.07349058558259233, -0.09225127572231856, 0.8223539854011525, 0.5029267718752137, -0.4747632494873217, 0.9026000319634805, 0.2712870180707689, -0.17037360105679236, 0.030540756363595038, -0.16428802992089875, 0.18783328646942554, -0.58185822913796, -0.46340981948456095, -0.03704888307432957, 0.8531664103495084, -0.591207381863494, -0.4614788627868007, -0.5958419437546416, 0.694244291362394, 0.6500940921006212, 0.37144404010735926, -0.7800573251370506, 0.6338327950867413, 0.3584356728446513, -0.773641238912584, 0.19571468774888662},
    {0.24176929226083857, -0.731958818352276, 0.5864699785472901, 0.6589512059909468, 0.8142271934046834, -0.7100552883619274, 0.8626195734928614, 0.8449655889601458, -0.5453877775684097, -0.38998790166972086, 0.12621332139139393, -0.9927512297649874, -0.36029568517781746, 0.0904190097311217, -0.4833173227176845, -0.09901224789395499, 0.029303980166979503, -0.6988976641173893, -0.6913215346686739, 0.9089759686580766, 0.33005411427539944, -0.0896039830670865, -0.29598071572971696, -0.24763748954488826, 0.46331509364111323, -0.5561479111518548, -0.6790445059262451, 0.3201940442802099, -0.8208397912091239, -0.5377399765228332, -0.20935436281064868, 0.3889159628693333, -0.5688882326361271, 0.8278108234249243, 0.3076367642046522, 0.3806094798788008, 0.208789395085161, -0.30724497623524033, 0.003450648492420748, -0.23028174701115867, 0.5081640866741854, 0.4752018026367731, -0.3957918786857153, 0.6181154351790706, 0.6952290137250571, -0.004657385612843467, 0.2372455087633714, 0.38432715604162065, -0.07113391989277051, -0.5011938984549664, -0.36435580393815387, -0.14816575327993609, 0.7655328141252447, -0.5915690511291853, -0.5602803967880186, -0.4130797216035513, 0.5784635446953237, 0.749584215467602, 0.05625541291937163, -0.707404934183126, 0.5435406958622072, 0.21737255871063904, -0.44645517053551576, 0.02494369917236695},
    {-0.6202868348483815, 0.2501590997290389, -0.006835302382895221, -0.2761810820168405, -0.10759889137373638, 0.4853168939459511, -0.17334186439143995, -0.2619288931199123, 0.27219368241761743, -0.04574665919645728, 0.28726884831888705, 0.28423405159210247, 0.3647202935267781, -0.024907257986403582, -0.535757800455373, 0.49293673535076116, -0.3291012525951126, 0.20514178073555203, 0.1730568015505961, -0.012057869758822094, 0.42311478700504634, -0.8411715708364811, 0.46327467547562073, -0.34025758075683477, 0.269757311770444, 0.23186856266651362, 0.0744106092100601, 0.24257852548386583, -0.13168186161575432, -0.7836765622494782, -0.2644298383187603, -0.5139608335179849, 0.4139568005915063, -0.5505124076130415, 0.17752535633438973, 0.09885898396006465, -0.15499692269722323, 0.08780079808908747, -0.671781964583925, -0.6275420515810266, 0.1850618969957199, 0.054567460278672285, -0.252593196911574, 0.16164601474399756, -0.61475372795725, -0.5912715483645012, 0.7574403572930605, 0.44731378883659056, 0.1564660400106916, -0.630406153342872, -0.28485418412086877, 0.44931490249946265, -0.461135372393956, 0.12794182828089434, -0.025341445854303826, 0.10978683178223436, -0.9292847452780364, 0.11024867371973926, -0.6250916545780504, -0.05472723238759287, -0.1555049228714082, -0.09733039211736257, 0.0930245474427732, -0.2702919066921374},
    {-0.10404086678541956, 0.323188467880087, -0.07579428593804452, -0.4641522683881768, 0.25385066245113075, 0.30065781259343294, 0.09395473117729135, -0.20981136606788733, -0.2239243596151275, 0.14585549976512593, 0.11510324709518878, -0.23066426043083602, 0.13377508638759214, -0.02433032564683511, -0.2411149016744085, 0.24059436000279727, -0.1785873418746912, 0.08310267115070064, -0.1937359749093107, 0.07687228135245967, -0.0692611315064549, -0.18117793368572735, 0.22414311022718994, -0.08935539481083651, 0.27849407763960315, -0.35290980398560523, 0.061511782976045974, 0.37487686504066753, -0.38882834077570666, -0.1244074540052511, -0.18486204079128776, -0.05119908482330173, -0.14294690757231507, 0.0871570401065582, -0.31485881294241685, 0.0644082087539964, 0.21706322521759708, 0.26527430921285433, -0.330470849638058, -0.15344610784163218, -0.018249370136118687, -0.3958464371910905, -0.13629921342678253, -0.1910294038211526, -0.0016810290787114294, -0.12023420720258605, 0.029405857208483845, 0.34412866436138084, 0.0453886028991203, -0.03496190953549361, -0.33174727956665934, -0.06161391824755733, -0.07942030321437728, -0.11368567280428743, 0.1456939729733259, 0.019608047345603362, -0.4631308496992846, -0.028063629802739527, -0.4276517207335506, 0.14850806561600746, -0.3089043572204435, 0.398226743627623, -0.2567740622342427, -0.17862525663870735},
    {-0.4549103974786424, 0.28369790575527604, -0.6295700736370703, -0.49716364760444676, -0.0671282830168534, 0.23014238798696293, -0.5653897947963389, -0.5801275064338518, -0.4434555236835195, -0.11363225640691597, -0.02044519006588019, -0.07859069404981578, -0.20991992073357107, -0.46768009121046483, -0.36544923836881127, 0.3138583447525261, -0.6778885012877791, 0.07908731432712066, -0.4183298665218701, 0.1885480333219407, -0.017020438691784826, -0.34039169361988825, 0.1304619979794012, 0.19164857366360036, 0.02680915286168068, -0.16399122455971377, -0.04024307057555827, 0.0341130003283031, -0.5100959212046823, -0.4920154930048504, -0.29467386713658095, -0.5304878429385177, 0.4226123776848818, -0.49686312145040473, -0.5814697023560177, -0.25392103248668446, -0.3462247283810024, -0.08837298697144785, -0.53326630124286, -0.288594333325184, -0.13849683957592485, -0.6517918521147485, -0.5626743978811757, -0.42468533543070436, -0.698090839523678, -0.4113906206308192, -0.19464604887098022, 0.43558847216073604, -0.14346910945249955, -0.33353307822359063, -0.585213610627421, 0.176725670772195, -0.48380570880046697, -0.3915594463536225, 0.278045292668446, -0.39452704363140184, -0.6736103582969775, 0.1354722873660398, -0.6313832360449215, 0.545203845673371, -0.35075716362823717, -0.1033890068470628, -0.27793117792187116, -0.48744665196678405},
    {-0.7872203072242201, 0.07744985716454683, -0.4198017187452814, -0.38474427917917114, -0.023947944444673745, 0.13328011337216164, -0.0014760789537390114, -0.2770983298912173, -0.36891145191841046, 0.15629011993812592, 0.34000445966396226, 0.36838078179362815, -0.08391207716365755, -0.46786782162111984, -0.45784704397571724, 0.3206598348158585, -0.46779526712147534, -0.11484100901882502, -0.5403764152786091, 0.17297616879920658, 0.17725021918608133, -0.2506867193541821, -0.0249886213701214, -0.1516463271529305, -0.4058809713197708, -0.09238614200997204, -0.3402826376378531, -0.3008869228671975, -0.20291397715003637, -0.6472709935114802, -0.3402445169027817, -0.14166516823653674, 0.11826796566675474, -0.5677787630231924, -0.5187606803453658, -0.5534854326395817, 0.12968289411086556, 0.07833110060887731, -0.431257288288452, -0.5970834854637581, 0.04220275101894377, -0.5151014787235371, -0.8273313384825164, -0.12245251041001715, -0.5402045532427133, -0.45383826863712073, -0.28400767725016207, 0.15460542673473696, -0.08674784241201756, 0.07659469071526087, -0.17791366824905022, -0.04644618558600593, -0.013926759193397746, -0.16875160717510987, 0.1088115776779457, -0.31948654543634897, -0.527673154953555, -0.10024978141987778, -0.47061523145112455, 0.16883297072012554, 0.12961435747153477, 0.019022979257503316, -0.4394264339146665, -0.3044985795582678},
    {-0.23285222647432516, -0.09840975044119421, -0.1943634238443216, -0.5342490891626266, 0.11036690725027398, -0.2391595998135278, -0.4811135134929231, -0.24305013409630058, -0.2405553164512827, -0.23546752328735898, -0.4001277992309634, -0.01715509804730115, -0.2096573863990214, -0.8630261867314183, 0.0008868637394242103, -0.1310926772579283, -0.5764326518890891, -0.29342453389963924, -0.578329545949677, 0.3924488337821916, -0.2558815723568348, -0.029209137287688813, -0.32255498641851904, 0.04672039996799937, -0.31145284231848547, -0.6099943676672507, -0.2341145683588391, -0.4019166359821533, -0.5523412994695476, -0.30186033615577, -0.3995297143168929, -0.11560475499602882, -0.4726795270909016, -0.4575659608601203, -0.7803614311168671, -0.5107295948523295, -0.4120241116989769, -0.16730590068992507, -0.18814260668042904, -0.018880994335104682, -0.18817136037119261, -0.5202211547943939, -0.46908885203571415, 0.16753547338941918, -0.5057053282785173, -0.03720874004107204, -0.46097561364775785, -0.3720881138096625, -0.7716357679009604, 0.15950055949374448, -0.2764065402975562, -0.4885179808027693, -0.02783826674067199, -0.7007912960997955, 0.16192896655504846, -0.44817180859233346, -0.2725540633349858, -0.033975745811242714, -0.3866673307530604, 0.2557199516952968, 0.6908519583138804, -0.7239027516273088, -0.6686139414022503, -0.22814339174110163},
    {-0.2145094875898, 0.036364548307950176, -0.0585362001794918, -0.3403142002413244, -0.19086757934923693, 0.30288024986183393, -0.39592010809392675, -0.26689614535347433, -0.7005381344301648, -0.4001764323567695, -0.3116290906186369, -0.14354352650638263, -0.17850856022263492, -0.4766564420022781, -0.15976365969396958, -0.5267342422985971, -0.7181523890862859, -0.41971548933616115, -0.3460583096345898, 0.5445562368901398, -0.1506353331946306, -0.022240874797156033, -0.34956698976199985, 0.06356566479298256, -0.3706414403483918, -0.5244614066276122, -0.3059639508270579, -0.22428563044762145, -0.5882540243229728, -0.16265640743684415, -0.08801761742011546, 0.08237879056505021, -0.5966482050785059, -0.3445142434208234, -0.4796838449205126, -0.6881854992606005, -0.17082594080719243, 0.09520310657716123, -0.06498787800794335, -0.11178267277751519, -0.17051864327148322, -0.4066033950100509, -0.5304474426054796, 0.10941206706653188, -0.4657858665574289, -0.13328435651025583, -0.527419380734319, -0.14175332125681028, -0.6391759529857028, -0.046198068279762944, -0.23581076079669305, -0.28222436248133514, -0.2604204882999754, -0.22609859220149903, 0.22279602916116106, -0.12861453735147774, -0.31548902166997767, -0.1926305948062736, -0.22939739733863226, 0.08865111094675827, 0.3610599433541206, -0.21270563480516377, -0.138467384327077, -0.017930966601265714},
    {-0.2112793623167513, -0.12358395712358734, 0.09336654297997404, -0.6342983367663869, -0.11928683753978622, 0.0705433948652239, -0.26258345727349525, -0.16213353079926304, -0.432992932827425, -0.26975361833677125, -0.45239761202534207, -0.4241869787325974, -0.4003881619818008, -0.7224264423630433, -0.031495885352617624, 0.16840122391346055, -0.4745563131843586, -0.5319089966064584, -0.36666417663425277, 0.24420571464260943, -0.18781045185605594, 0.02643311854054151, 0.005649661199648732, 0.07894627917606581, -0.3490556137647254, -0.5211366668322004, -0.47183253982962725, -0.3564816399224555, -0.5484417144618505, -0.2414032957508954, -0.23971236439720287, -0.08438461077081645, -0.5207175705919471, -0.3360266147749627, -0.19645506789140318, -0.149077235519958, -0.37853667606255936, -0.0571935047563645, -0.5673015052712227, -0.2289382817478211, -0.3160275937827281, -0.811395095232022, -0.511749017143206, -0.23771158105403048, -0.7694079070365043, -0.15711335388345496, -0.2269683363830043, -0.02047049430704646, -0.6974289683853514, -0.13555051424041425, -0.32862005066167743, -0.12257090495432843, -0.5489760908031553, -0.5163981203250844, 0.19031919228195426, -0.2646066733504577, -0.3896215584689724, -0.08157319585596452, -0.3791248578757241, 0.4256717567227905, -0.04056267341235597, -0.43689567558147324, -0.5755716153270357, 0.024810899564115675},
    {-0.04961075115211208, 0.1582348105980935, -0.46188256529479377, -0.5802490898915111, -0.05745179540113757, 0.08731705205740341, -0.4556646098564271, -0.4736071689130515, -0.3845584400728133, -0.15862296016233268, -0.26602073013346395, -0.13761096050632662, -0.24572980201697428, -0.7197908661841637, -0.14043738158358857, -0.09826149449278952, -0.7804037489457838, -0.16689105359071071, -0.08073483073143223, 0.2257239961077445, -0.23610665310263754, -0.18770306489979083, -0.01776026047059152, -0.16971519933928772, -0.4468083516749142, -0.2841908402346108, 0.2341173108386697, -0.1974836614868639, -0.24152338465439033, -0.058920046931797344, -0.03150557823462954, 0.15911429933312907, -0.13550191240578854, -0.6071461464766112, -0.21575342435578132, -0.25837995135811603, -0.1558936974612491, -0.2524809720378659, -0.19238437482614187, -0.007132868678952363, -0.6167686330142012, -0.3894339922743398, -0.6346451201877817, -0.0018255632761038675, -0.35512977542816493, -0.07658350035237609, -0.16270889839513486, 0.16987976900127638, -0.048996465589935326, 0.1870564000348424, -0.3548493777404016, -0.23298836722537644, -0.5954341091753343, -0.28339856974152156, 0.27129095992036023, 0.04556505369321925, -0.012353211572164449, 0.268925689651612, -0.3368984829762632, 0.32545962990863275, 0.05857095241864378, -0.6208315265552481, -0.35426360724423706, -0.0757656175266969},
    {-0.38571765338377484, -0.11163374471265564, -0.5659539377134271, -0.47245164592314104, -0.11503268737837852, 0.2950745630350259, -0.5754413945990027, -0.5415027503721851, -0.16434523621366812, -0.5265743412902507, -0.17963140670540428, -0.5674633270407303, -0.48236831163032984, -0.7500563856351947, -0.24861754129616176, -0.23260978331569498, -0.5079696549083282, -0.13504443953907094, -0.2842755880548334, 0.1578440905077911, -0.4501682583771144, -0.29613357882458985, -0.10283426719688324, 0.07457568883301184, -0.37332918307913177, -0.5844744222777841, -0.4048466410474268, -0.31219857907564363, -0.5769583437663786, -0.28964652900956817, 0.023641728802520554, -0.017698740341657783, -0.21555852172179815, -0.34731254762771024, -0.7775969771810479, -0.5213059571940427, -0.6614988543416296, -0.4247548894890178, -0.29578630312035215, -0.28822402519706375, -0.5362897494230785, -0.5110913507947411, -0.8627457354029828, -0.1665065581313965, -0.3933432854356551, -0.05255594290158624, -0.1070815235147919, 0.21746728990241154, -0.4202953974162755, 0.22051138013801364, -0.291331352820649, -0.2862564541301122, -0.26473687881934177, -0.3921293222300589, 0.3719775427721756, -0.5531243556883334, 0.03344096363227618, 0.05652866587714128, -0.3107117856856803, 0.5194814809322745, 0.08642157126397212, -0.47874986899020566, -0.6627663796450018, -0.02251718642907853},
    {-0.10337617443214632, 0.11059134435392623, -0.30348908589393236, -0.5870596051439004, 0.0830914797537987, 0.609812501757803, -0.6407532725796041, -0.24238142837825352, -0.23419723928066996, -0.39300447758344587, -0.16144765397090405, -0.04837949172989483, -0.2226085803123372, -0.5609810965300456, 0.08975192597086239, 0.014686825011261156, -0.13589910869433305, -0.48095643987123265, -0.29344251389248305, 0.0379256438744982, -0.518855106718823, 0.05403787031486192, -0.16207031899516547, -0.06947424477159658, -0.18307649625804756, -0.384188601591459, -0.17374462182583075, -0.19431988850834256, -0.4058751427304074, -0.10372533659344697, -0.26424480557665603, -0.020775832155018232, -0.30788642234995983, -0.6070023189943546, -0.39591566757819524, -0.613082320585142, -0.512910454353269, 0.21836034678361316, -0.30415096454188406, -0.0427977749219645, -0.15065155228703278, -0.38404042155670326, -0.36659007238734337, 0.23558638673751908, -0.33559681383166085, -0.14663737854160316, 0.04542939933429963, 0.3062676333163792, -0.4429071850536375, 0.444602931318191, -0.4826564057417669, -0.09371084124753166, -0.18154561956354295, -0.6077951733673842, 0.30667074779292947, -0.48815002122079804, -0.7129395245650417, -0.004264540723831045, -0.11408925395432953, 0.5659009600736985, 0.20458465773558207, -0.3110527893755142, -0.1958768308010204, -0.14897121678675332},
    {-0.45685673898715534, 0.16741467219685668, 0.3419366896429071, -0.5031182159822272, -0.276589258731381, 0.4226817370968304, -0.40166809415947863, -0.4185537983483102, 0.14662549460368368, -0.4760294985567347, -0.14711231722700993, 0.010521927282494011, -0.14363661649103923, -0.5797609770721893, -0.5112214040229613, 0.41110429882065763, -0.12430974820139955, -0.0819314626953138, -0.036984975842347494, 0.009461746374120521, -0.07854038746202648, 0.10611139637410859, 0.16117675718805893, 0.11323383408336744, 0.10040836669039406, -0.2623024669882058, 0.0006739803258727144, -0.00781517981473591, -0.469424625014064, -0.3441335523372729, -0.2127908311643426, -0.1635246847119995, 0.18154225835623083, -0.45511700300213603, -0.5034607298615695, -0.1900572503462351, 0.30591227624543077, 0.283248353137934, -0.2611754358046335, -0.20455778662585783, -0.3136874336330468, -0.22897088150867367, -0.19136483625055783, -0.291494417326942, -0.2302647643041387, 0.033908489193815804, 0.10161739425928194, 0.022726841217577644, 0.00369163754236575, -0.07078398528405122, -0.12030207258476411, -0.04894953054472459, -0.10897651084037854, -0.17538087115375228, -0.14908238443960903, -0.20870496647675682, -0.6088713911243018, -0.06165180751905922, -0.37042833121589314, 0.06247925237512353, 0.061362276444931765, -0.13316653798456585, 0.1368703934269092, -0.6639431336135443},
    {-0.3161530733506903, 0.11002723241622817, -0.1891355672372207, -0.4965230494898095, 0.3802701471015081, 0.16295878799615734, -0.6650839931464055, -0.40713317873988036, -0.2015390401504428, -0.5403016097226739, -0.32874639340279865, -0.23262630609221405, -0.5963330407411536, -0.7888998098425118, -0.1676623756202718, 0.27377044313102666, -0.7327689366885111, -0.5243060677204622, -0.6982878634014772, 0.24821205929053436, -0.23014583449648346, 0.09495518068523075, -0.0023215698406872025, 0.06790212897313982, -0.26301682837906043, -0.26146669001198575, -0.18459967003161845, 0.21149186380386062, -0.20401858736104037, -0.666210544358922, -0.026097036175047723, -0.030972685762685345, 0.22406450200230696, -0.7288189428985619, -0.6193795250928328, -0.6902355724763817, -0.572557542496949, -0.14484198623913938, -0.5377763166101402, -0.33879969791894154, 0.04114978665929783, -0.6987822099945106, -0.3866565687280361, 0.20084011851406486, -0.5630545086449037, -0.27785705771140085, -0.06402219090330544, 0.09735312758603962, -0.26441529122425333, -0.03875342927624554, -0.6036344401075694, 0.10031217719747929, -0.357853029620058, -0.41577763827624037, -0.015360762679192806, -0.27012141466348083, -0.5114929012171385, 0.16217512785112748, -0.45003277889500304, 0.4743248905270244, 0.3906005134906818, -0.42301870413948356, -0.36283443627810996, -0.2557768445371774},
    {-0.30337545842967373, -0.023362338120643752, -0.4959646832851302, -0.5628512086198206, -0.3759991317351039, 0.2446981939098566, -0.27532403810993283, -0.28828648683815905, -0.3299721024691537, -0.38108415493457787, -0.2109451898458126, -0.05855131062333593, -0.296949300069825, -0.7025565484041039, -0.1769694591528269, -0.09397562399888443, -0.197179232661525, -0.6189763478138987, -0.47459377920255436, 0.32068614685506464, -0.536017605526902, -0.14359276155614922, 0.35408428979688145, 0.11319874075456707, -0.19891263836921838, -0.5294161864748393, 0.07495231789434821, -0.05536786864074904, -0.36993231677001365, -0.32871375221807775, -0.1393283107562667, -0.26473319179812016, 0.1455792835165655, -0.4736402176446416, -0.20226169164966923, -0.24367339831946752, -0.05688682475192454, -0.19354040712174447, -0.43608645697225995, -0.1640757287741002, -0.05147178712401303, -0.5159414028269268, -0.4775214391509298, -0.26651859193481753, -0.5031490722721428, -0.08191593418852529, 0.19949666448308093, 0.05675680694268285, -0.3659696815549724, 0.1551611500948943, -0.4710647035647283, 0.10168007500275184, -0.6600569389774228, -0.24173028321303341, 0.23920948373564083, -0.24626976886421817, -0.745179917120142, 0.3102837883196569, -0.5351686325900096, 0.30140516937364037, 0.526729060919236, -0.4124182221665492, -0.4372672020777547, -0.1512336653424439},
    {-0.37792288619902037, -0.05720430511698682, -0.47864899392869353, -0.6014864720084702, 0.06978027549318953, 0.12322360658422393, -0.4606890867962281, -0.4860417640140785, -0.4501172745219521, -0.6950087630054193, 0.20378098851362716, 0.08416038495469799, -0.0787881017686496, -0.8483891523004085, -0.253661225416804, 0.019387940324551982, -0.5908008107747579, -0.45215010038445447, -0.3901507912216209, 0.11013624926431702, -0.22635210222349003, -0.25596027067356114, -0.2007668517390562, 0.03974104990424251, -0.39225176254045785, -0.5127085456296463, -0.17693965703758394, 0.11930452738235152, -0.6853403524909615, -0.2923605221280881, -0.26613614136816527, -0.4495832012279721, -0.17097895939053911, -0.4676475926606661, -0.3158118678187275, -0.3069430406777937, -0.25455143741886804, -0.18182415311867578, -0.30889498343030486, -0.280542145276622, -0.3468327150644933, -0.4734447531760446, -0.784097916363525, -0.4646239349575718, -0.5728355361260982, -0.23027817972858564, -0.5324312713053517, -0.11513440279255588, -0.4117164476757104, -0.16032548967961263, -0.32202962911119287, -0.2915991894740096, -0.10015056921595367, -0.2398677424824227, 0.3155051504626708, -0.18643789927357318, -0.5603481870863829, 0.23028229815560525, -0.6498038941296753, 0.1754073648707915, 0.37727461448679434, -0.0937973878367193, -0.3325618150671985, -0.21648269069780787},
    {-0.5157682429034833, 0.5291424176587267, -0.262324697118489, -0.6524311979614139, 0.030955028712988917, -0.11801910661595, -0.27184755330759663, -0.8089445946418959, -0.3092400426354365, -0.3555728105567202, 0.041833676130486636, 0.12533044024373333, 0.12104694712292445, -0.8035590162569209, -0.22695095728279646, 0.40310928983501837, -0.6980563543669519, -0.001030980815468551, -0.5496838196215297, 0.33730798529021955, -0.40908416891767413, -0.0838618680957633, 0.01168003925040095, -0.04408650947985887, -0.12995968177448738, -0.15414473042670673, -0.09553499240899503, -0.16715197267621765, -0.7709103861898791, -0.43787217903576914, -0.2290812095519924, -0.2266074491236805, -0.08862657361576279, -0.5127209920281183, -0.29038877671688734, -0.3052895228519566, -0.4196349833436312, 0.08357981035937499, -0.15079113655027657, -0.36873744049179236, -0.49292520060468875, -0.4388074975847325, -0.7918576598110109, -0.25893434638252616, -0.792269670336845, -0.3412097099298438, -0.22675594477014577, 0.1580659970439698, -0.4740540300580086, -0.30544706692416695, -0.41467900115103823, -0.2924400469910393, -0.4429720146448137, -0.419563838668173, 0.07207333656942523, -0.24502997214615832, -0.2933976661639243, 0.2830799924949278, -0.6483914794243204, 0.28715909493740305, 0.09015757412649916, -0.31065777124872246, -0.2239899075074649, -0.09126004391895394},
    {-0.5463698775208385, 0.39241042065275483, -0.2853602242610627, -0.5845879307809971, -0.22382496023285436, -0.1684705829265342, -0.3073643013084982, -0.3036500468735388, -0.6027114902879654, -0.6427921106850149, -0.2940944764538197, 0.13878067389599252, 0.29736643241311994, -0.7909971842874056, -0.37997571674168673, -0.10282484177252263, -0.6374241208189605, -0.4390782431739148, -0.6866450807606043, 0.3363201640806179, -0.10255722631168428, -0.1721574190739777, 0.0963069166810992, 0.13530361280461842, -0.3111427748457816, -0.5642773385687937, 0.03357754369779354, -0.18244237123496412, -0.5342416481296763, -0.5155492191133494, -0.42589897156712836, -0.27539979483939697, -0.23479438803461372, -0.4617680830909618, -0.36171710533886614, -0.3866358308031584, -0.3112010771786102, -0.045272353638985297, -0.6520112882448519, -0.6431595260987241, -0.3299654999639939, -0.2045568921542392, -0.6791654972931622, -0.22100036928092515, -0.7028696225594013, -0.39488797058224934, -0.028782372083768024, -0.09344023432860818, -0.364029190854874, -0.03280038815176552, -0.314735203993815, -0.4755330079828523, -0.2935798459286708, -0.2536403909960248, 0.2993710314204384, -0.3470054741216146, -0.4567254036568401, 0.09223681591225334, -0.6530680829367626, -0.009584283194466602, 0.3591687267829634, 0.04422697284106107, -0.22390839653720707, -0.15555809775791368},
    {-0.2581696988097052, 0.36360563566393994, -0.5624524303033221, -0.6622554984719689, 0.10627434267919754, 0.4174140057653561, -0.6409915881197479, -0.13148629084801186, -0.38950244248104027, -0.4527147241478924, -0.15241772718275287, 0.1686396367761272, 0.06777669721410183, -0.3982308145228391, -0.44260821913890086, 0.22883008692513473, -0.4488682174434881, -0.49984578492048026, -0.22108409166487764, 0.39194589796899826, -0.16047436953640482, -0.2014126101499023, 0.4017106895959198, -0.15437530309477562, 0.1277726490074348, -0.3342626958170685, 0.12381906892951795, 0.45644217220185784, -0.3630433659642965, -0.585048206933412, -0.5055407215434506, 0.007449657359598028, 0.23931224065869516, -0.3123452763251831, -0.3266496426399434, -0.20742047929193863, -0.3334776621068172, 0.08638929459616917, -0.3470833839831572, -0.8070198810685645, 0.026540960890956738, -0.23967552936557202, -0.9782130495752365, -0.46285788951324375, -0.44596907618530396, -0.25885249651002884, 0.06543444704386707, 0.39247401185253966, -0.2779214550697979, -0.05067126652103017, -0.09234508942252219, 0.03358532907165003, -0.27849303446663076, -0.2962532915850472, 0.027489161954556522, -0.44053853119925457, -0.5115384480021733, -0.24645435165516444, -0.7428970778161647, 0.4435355784786884, 0.3675427227941669, 0.11258083990465674, -0.2986118129754941, -0.277013310290049},
    {-0.5596232111802426, 0.35245120194718327, -0.20635664671157616, -0.7824538407835402, 0.2515246990411717, 0.2190358255589617, -0.5456319115261511, -0.38501266098840553, -0.5933361755065935, -0.44624640026623014, 0.2589284903674083, 0.16637518172564542, 0.033321481934937884, -0.7172897033716966, -0.6183819955454449, 0.08783687855818596, -0.9057780246857455, -0.1510818457895111, -0.6759575622997281, 0.4870948217041312, -0.27799642653100226, -0.3016176987609963, 0.08149276276932456, 0.11896076494630566, 0.10265534314204491, -0.37229213879909817, -0.22282801153768794, -0.028333971195601985, -0.6795978412917645, -0.7248822539904175, -0.4681645024536477, 0.05616191259525389, -0.18716547700420336, -0.7537652884146568, -0.10892747855378375, -0.5876339104356135, -0.27669793691756084, 0.189532349506602, -0.6374168729609169, -0.6759085643108467, 0.014472859333039044, -0.4521948345944079, -0.8266851390470601, -0.15129253696482148, -0.5914529817761812, -0.5246291901850221, -0.008781481425226317, 0.2570909066070932, 0.003608729216155078, 0.04938894992951165, -0.325609029642405, 0.00272133519546343, -0.3648618673243326, 0.08036912853439869, 0.1217386135722256, -0.27816036740486455, -0.5613836346896628, 0.01598808969222944, -0.8756746873531991, 0.6753317305582036, 0.30045323965467996, -0.13008814683024508, -0.22646725845310756, -0.3185273624199448},
    {-0.8368431072767639, 0.46351509999100615, -0.4921303784176966, -0.8845040532346223, -0.06222948784966397, -0.010867926676610233, -0.6293323247829964, -0.4747902997010841, -0.4460687995814328, -0.48934340258579706, -0.041576059403352524, -0.11828256488486835, -0.01705568921269387, -0.852609200592598, -0.6014225269795611, 0.14271997383020862, -0.683238523449646, -0.3084006221035624, -0.32231771741618376, 0.08155865720180515, -0.006833631345347327, -0.4222745366471888, 0.5603790416940717, -0.25158403082512765, -0.10148424642983235, -0.293971658062119, -0.13923941853547964, 0.013396325397279786, -0.5315132014235029, -0.7115054423711393, -0.6235773315904651, -0.4610795583454357, -0.24569397946975755, -0.4138917751974857, -0.21707997875641866, -0.4974155584044238, -0.41451742586792356, 0.08370557753703434, -0.6948747338417512, -0.48456929886946065, -0.3165910199866882, -0.2579474823701229, -0.6489643139510586, -0.0936836120034889, -0.5966825119245462, -0.5138209523286617, -0.4919847796890736, 0.5067801483054905, -0.6107254556455438, -0.06673047283222934, -0.32954201604393796, -0.004692157552301092, -0.45226551741045945, 0.20558317352169597, 0.2041207816674826, -0.728784264690946, -0.3654643129875873, 0.38379983032461124, -0.8187201934050307, 0.4365960389679478, 0.3433335951809263, -0.2976579759301054, -0.41437567517356394, -0.42834874216835994},
    {-0.46367969488197724, 0.3936911754271806, -0.07754843008531839, -0.5983015137106968, -0.24839521657198527, -0.12089660078847111, -0.5001077872952054, -0.6905193483148602, -0.43153188610907023, -0.6584373236539597, -0.11940963001836283, 0.23697731394623694, -0.23956371872636742, -0.615251342209627, -0.23955785750406597, -0.08933125076722195, -0.62309036105707, -0.6713352680291945, -0.5606182547790489, 0.02922840716717709, -0.04253167480464904, -0.3760091941174791, 0.07157689851680199, -0.09929596356648206, -0.21843823703640855, -0.31239500528853886, -0.2276348846156535, 0.21768557184735923, -0.8197284972320729, -0.4613941507545506, -0.5349786685486954, 0.030925144862251085, -0.2942930551300922, -0.40738830896151523, -0.4785489852529091, -0.30072668317886997, -0.3576731611980081, -0.2937781983393105, -0.45283893635741435, -0.30721841272975786, -0.41389640756827567, -0.47379800214818424, -0.8778738614673628, -0.27638511558810835, -0.6118867622255764, -0.673715723188652, -0.39391100881431684, -0.006708135063484866, -0.29756698672979165, 0.13808308310195674, -0.5673223964659533, 0.032428853408516436, -0.5349685494979345, -0.26720034393966235, 0.014804335578715182, -0.5574518020363068, -0.678654049722414, 0.19002292893843786, -0.6330906676190978, 0.07399221059839031, 0.1848398415742582, -0.22179531095440075, -0.5918933852584527, -0.39722553618229894},
    {-0.6010896682989402, 0.3446274252633971, -0.3619124970626677, -0.6008750771947328, 0.002045606452453613, 0.3021748850819914, -0.629794597309677, -0.4723119771575294, -0.7132135463531613, -0.40745660581862697, -0.08657296213088257, -0.06359772266459551, 0.24567598446677083, -0.8527771049946725, -0.6725235308283456, 0.24376570912516035, -0.667765176826368, -0.5365281951703775, -0.592705177576397, 0.15344283097454067, 0.27060793281890044, -0.1646845672634382, 0.31802539531716223, -0.3368402891996463, -0.0014953686941683606, -0.6644008741831605, -0.4583215625147889, 0.12585438348155337, -0.5350608095343885, -0.5803309339710271, -0.29264668551636164, -0.00204544381638729, 0.3406428404138138, -0.6628334988429078, -0.4776512214450559, -0.4184910619480854, -0.32901165592600984, 0.08689094368367038, -0.845320250579048, -0.3736239195411969, -0.29307685895774127, -0.42009739785879063, -0.8423520835711833, 0.00807318778208492, -0.6136446122155199, -0.6020522483826592, -0.2501928060631064, -0.12296389386223462, -0.5373533840506294, -0.005873669690643138, -0.4567487363003293, -0.0326137679746321, -0.5885591273488497, -0.45891311860942147, 0.04924286928779223, -0.18786068400130848, -0.4054895814692987, 0.27178045656004984, -0.7938823082905309, 0.3851598118104759, 0.3339533012743599, -0.42601220971331405, -0.5890011770809164, -0.5393674479993624},
    {-0.8938257175816428, 0.7381733082019116, -0.18476472347180709, -0.6951423924239952, 0.1424906687223152, 0.610497225502413, -0.5348609731348601, -0.7994938214440954, -0.5724693171942018, -0.5411978854775717, 0.03609109802104469, 0.34609730430681784, 0.2937832736260485, -1.2368714602606288, -0.8856996222211031, 0.24704500339239563, -0.9743461355479924, -0.42051448179793316, -0.3901222008839316, 0.334908983754917, 0.4581219582373887, -0.5767806818403036, 0.20006257295043475, -0.31370325023273266, 0.0076105896186170465, -0.2839474307038195, -0.22163114135718223, 0.30898565896372227, -0.7034526526475733, -0.4198998631181915, -0.7901002205915248, -0.24004047733150077, 0.014179501641570563, -0.46006951751476444, -0.03919788124775421, -0.2668317909269362, -0.017645425944446125, 0.07387097727614816, -0.736671566230305, -0.5891006908775992, 0.08980637956148356, -0.7191845619429716, -0.9787859112335052, -0.07822023558847314, -0.6474413995284902, -0.5815976557139143, 0.020521157057678655, 0.2897497632199017, -0.6913208420693271, 0.08864134102840066, -0.13937975933535723, 0.5104533231474998, -0.5566314868020014, -0.02458670885321552, 0.8030966017626889, -0.5307492727012882, -0.6284110588329839, 0.6400427607349002, -0.7997364527413119, 0.6517601442096101, 0.39811272123527375, -0.00970783835237155, -0.4450087357083724, -0.8381408351536292},
    {-0.9910942372972281, 0.8031342354869112, 0.06046371063667344, -0.6920933905417211, 0.2149495335240637, 0.8051650495877732, -0.29263853932761213, -0.4067350315468574, -0.5279984338509419, -0.35058261911523747, 0.26878782375724397, 0.2618737739793351, 0.5937688395159656, -0.8614420719235542, -0.8871617365958897, 0.8662191099642536, -0.8757587144245469, 0.052128532531000915, -0.20501934389660176, 0.5403884408724374, 0.3613056681726201, -0.5230958232309942, 0.33316522777941115, -0.5293183954415589, 0.4145514056552627, 0.13646233691244594, 0.18634143067940961, 0.14703483848776056, -0.6169633446242091, -0.8095663362630414, -0.7158874227499559, -0.37355522514736506, 0.39148923738241526, -0.40083544137798555, 0.20390171674482976, 0.2485306212453447, -0.055267935700693785, 0.712554229888607, -0.7692505802520814, -0.8696198652807081, -0.1934054629098418, -0.26722867160913377, -0.8953822914041745, -0.39191076768152444, -0.8945865233897732, -0.6698344192023958, 0.17926301664456365, 0.6477903678957454, 0.21060702826247923, -0.23112407935286353, -0.14902356269687878, 0.6980471397613321, -0.6025149880324987, 0.2820487816651623, 0.4175941180376425, -0.16028108148081113, -0.7768666977161617, 0.3913628796482193, -1.1818790018838643, 0.537143536647671, 0.4352330965833611, 0.334784227615186, -0.033202840368844834, -0.9014753237809426},
    {-0.763095322968463, 0.7265301507415503, -0.07502894656305219, -0.588616434863959, 0.06194734853853743, 0.6305746007340821, -0.2995307416643723, -0.5303964056359703, -0.4241247990830281, -0.595363071108384, 0.28344204606115364, 0.06254571135735613, 0.3546867029616023, -1.0727438694783187, -0.6518579521047976, 0.6743947129164539, -0.701618284525847, -0.23765002204481708, -0.5109380955110282, 0.2477942840736079, 0.23849372480168665, -0.2699546251757488, 0.36175533887818634, -0.3148282756989955, 0.15367099128613765, -0.20617752402435463, 0.12344800460929675, 0.2843156618170882, -0.6820701214149362, -0.6461089881668702, -0.9002836415178506, -0.4094819423603978, 0.19864332679449845, -0.6407036045789218, -0.06649549286024643, -0.2494489934653582, -0.11942852413614159, 0.3777794088613779, -0.8035692707062507, -0.6687112294903041, -0.30131096608705205, -0.47081957858306145, -0.9344133184374068, -0.5376974340161874, -0.9269634495964494, -0.7505655017913867, -0.016628965723733867, 0.7081030628427446, -0.29124079620641535, -0.3207677908579801, -0.4104131989353874, 0.5902698087097943, -0.7527536409991886, 0.25752563130247613, 0.669212923516682, 0.03582003405532014, -0.6898563559309776, 0.3119031796414202, -0.8119213308254367, 0.5621824417180409, 0.19771477367165782, 0.07873843312075447, -0.12093398927903033, -0.976328971088433},
    {-0.5749992552459906, 0.4298631081268922, -0.22778062664192833, -0.6127429021706741, 0.1359912606610355, 0.09205608600837609, -0.7397937978335793, -0.6151278258905855, -0.38726994582882196, -0.8268902268535339, -0.24195547445146467, 0.08976566525557386, 0.09450437102956963, -0.7768139518228168, -0.5673338048245545, 0.30007522472841225, -0.787670941768721, -0.630774049288688, -0.5791801074329747, 0.4148634139882449, -0.3429475798628988, -0.5515164430513722, 0.3366153654709048, -0.45362772462359274, 0.05783889850347034, -0.31042944501571385, -0.3721912255026959, 0.3765749751573625, -0.7528424093552456, -0.8384973458397548, -0.5577814330667956, -0.3281141319959469, -0.017954834564399506, -0.640428952117677, -0.5430551780323669, -0.4663976853567653, -0.15986313792886842, 0.14709460689512946, -0.7637471650267166, -0.693892281573507, -0.12321599592963559, -0.6211108157387804, -1.0383686072760194, -0.07252445450554287, -0.8851109422821213, -0.5663060881183533, -0.2568040117466803, 0.24360194956629175, -0.5182395590970011, -0.16791288260155987, -0.8251022400701763, 0.24181123469550797, -0.6003327415749669, -0.39605895751637166, 0.42010996330279615, -0.3366464656505827, -0.6002019182371711, 0.3667018956165783, -0.8821475998288266, 0.46445120552195657, 0.19171736736226855, -0.1686534431077783, -0.4345343904098612, -0.8155192677183065},
    {-1.0067900831039398, 0.5096247528234608, -0.18793902941874893, -0.8731453689018682, 0.21434794705638063, 0.4704775648123118, -0.6585153361345109, -0.48132367441706553, -0.43776181821298293, -0.19781474756173228, 0.27577469886053607, 0.23902815636658187, 0.27472706640243105, -0.7823830989165478, -0.8886417658861084, 0.6374409132212323, -0.9542991552712006, -0.3098128880965902, -0.4907477830007947, 0.4562993653559736, 0.22045291716902218, -0.5237644343662416, 0.34855391575253636, -0.37918220549579634, 0.3274959431512075, 0.06837826884156412, -0.021837446538364124, 0.3277344993348937, -0.9429738781824096, -0.9685572500878107, -0.674353660276888, -0.45436771296982237, 0.2873732918477767, -0.3339153105592877, -0.2880088787375248, -0.23735071737056376, -0.07737110971083817, 0.4661175100169357, -1.0424994376173362, -0.5714549663294398, -0.2009937191332623, -0.5755077232422823, -1.0152247463136392, -0.15129518072123027, -0.7285916830442062, -0.5902114670048091, 0.20024506846861087, 0.6136918703614216, -0.2538323130359258, -0.06830962125737668, -0.2699456666802793, 0.500470183331469, -0.5043390184659243, -0.027137494811001122, 0.5144580034623126, -0.3259662211034997, -0.7090273808050405, 0.20680654865311773, -0.7124141366644753, 0.16873480485870496, 0.41585840067345425, 0.3957056179253907, -0.06953560173547868, -0.9003393326139725},
    {-0.993850220456749, 0.7127103862084252, -0.16543284276414044, -1.0719807404905448, 0.028358720930888485, 0.6548799153342267, -0.40728780105319407, -0.40316330275496876, -0.3067783522389087, -0.012758826066479259, 0.07571041724398965, 0.16250092876495675, 0.16110423735686297, -0.7151032224412608, -0.6389519062386612, 0.49387570508963, -0.7668655112806311, -0.6659698077770109, -0.4690979911058971, 0.35116416436698356, 0.08577527019583259, -0.2863733359146454, 0.45616944683587474, -0.3236669269594901, 0.20629854374136944, -0.04281701413299073, -0.060577702719430436, 0.5301745226590187, -0.7783385992218388, -0.8237714856737983, -0.6834207498936639, -0.38812879160180624, 0.2842122253080505, -0.24305729212333047, 0.012844819569628694, -0.34259782719531756, 0.258414046139892, 0.39509339911357977, -0.6800626996899563, -0.6182155542553847, -0.4444223410617912, -0.481542935691094, -0.8999735242121292, -0.09151809942767139, -1.010067293409882, -0.8977276295920057, 0.11341253368266765, 0.623461603145852, -0.4774836497873478, -0.23145372030021838, -0.5387862574771679, 0.6031631951259401, -0.4499163033456559, 0.10056092065775277, 0.5151369700988853, -0.3570611999967886, -1.0261759803450223, 0.07866914636441062, -0.9876076253050675, 0.5804320227846597, 0.3275939985971125, -0.05738955989607213, 0.06106208380533927, -0.6616157063265015},
    {-0.7246040245015196, 0.6016311548344467, -0.2554345810581668, -0.5623603757664324, -0.2635502169367744, 0.4060904504486559, -0.5922757404822743, -0.6094106865826513, -0.566602227398404, -0.5681798422588139, 0.29111806966290155, -0.17486466752301502, 0.5241230052401815, -0.9677941793798286, -0.6560147127297196, 0.49882681478320584, -0.7505796653810509, -0.7615757276651935, -0.5578509080023051, 0.07138586375808602, 0.19036186728080057, -0.2353675374004694, 0.16668351653670277, -0.42110842148516964, 0.0710460555723295, -0.2447032097508011, -0.3941974249357314, 0.4394895948732168, -0.5255010921559039, -1.0723314355083653, -0.8874122233862564, -0.4458627054313047, 0.509236411074744, -0.7303971116029319, -0.30259660688505174, -0.21221120574529398, -0.1781208611040968, 0.2658267191707622, -0.7701417260369358, -0.5658163433543572, -0.23605305963704803, -0.5072375337995546, -0.81651460269383, -0.08034578168460328, -0.5377410636827629, -0.8500039953589296, 0.5736619851726236, 0.641836782135749, -0.23065382295353665, -0.12362348837361894, -0.3373348465345061, 0.3033190383563589, -0.5514573439439159, -0.018225900747841917, 0.5069626889628671, -0.2121994067183286, -0.8039380577191513, 0.3119872857636253, -1.2994410894770028, 0.15671340455858881, 0.09104001598960813, 0.06801176884372809, -0.1595689921451569, -1.0153256888221225},
    {-1.0903294207104985, 0.5239497270384103, -0.14061286636069753, -0.8026751911057822, 0.12749294348941484, 0.7521446388006308, -0.27363213197813774, -0.534218722180456, -0.41582824990091516, -0.5364305160717869, 0.16845257113131845, -0.08198718529540151, 0.24414263785590787, -0.762522390396103, -0.6420564288737016, 0.5468238369178335, -0.9076932316242354, -0.3787165114477783, -0.4909703490379788, 0.036974693761167375, 0.36798534609291095, -0.5139906657230979, 0.4463457584672905, -0.5272760076130524, 0.3704048954929533, -0.38977810313993255, 0.019981690294967405, 0.29375481635474066, -0.5531816785156977, -1.164674808950573, -0.8897994139789168, -0.36213373674036153, 0.5236457811009662, -0.5025497713661894, -0.05721511985584164, -0.3052503319942575, -0.27486222007550726, 0.22613515153155717, -1.0032880863305984, -0.5810898694010702, -0.3125509214296999, -0.39955068949552314, -0.9980203984425793, -0.25932135621960767, -0.837338853671994, -0.813812566800713, 0.2027878832861276, 0.7594160719142791, -0.1519874817653335, -0.37087808505441666, -0.42335554552583216, 0.32097892509127623, -0.481557432708243, -0.004109836228896322, 0.3662374790244665, -0.4846435221614971, -0.6465616052965606, 0.3534873803705072, -0.9309827197964679, 0.1859028851176355, -0.061469367679778314, 0.1940624052678569, -0.3672776292798922, -0.6709505571130043},
    {-0.8556577206180083, 0.9290841457698125, 0.1725268130293645, -0.7547341016281732, 0.1531800311126713, 0.7817315385566866, -0.5768720443862475, -0.1578787121309676, -0.2881935724781375, -0.101223961820799, 0.2762769224488374, 0.06600396536208214, 0.7951681062229116, -0.8277750170484223, -0.9138812610576289, 0.5667569345618882, -1.031024998869028, -0.22358178734117215, -0.2982846233481261, 0.37559362911167277, 0.2991388076576547, -0.595360830577175, 0.3827459233118357, -0.5033710922803509, 0.2772452037086668, -0.12482094534824036, -0.04300836768381606, 0.7190425105504276, -0.6170073375902653, -0.7736106514449691, -0.8499772347212524, -0.4924237465850692, 0.5231146242790009, -0.4359454960803173, 0.09168314752887383, -0.025277954506861162, -0.20029629745757238, 0.622618845417348, -0.8231726615326731, -0.8187195053507481, -0.09969144743362819, -0.26737894475274904, -1.0308638800399073, -0.3218840997742095, -0.6964673817177347, -0.8222280174116033, 0.18585556915472573, 0.8007650499390337, 0.1282601721180826, -0.33579164811339446, -0.1561137025713259, 0.5568524535568233, -0.6136176064182001, 0.31877455148746753, 0.5331605667768656, -0.40619200767843056, -0.866307931118844, 0.5051046068712822, -1.086275672843371, 0.3163835509421686, 0.18915239851639762, -0.07688887503557558, 0.14743540101059902, -0.8621485135727456}
};

static const float b1[64] = {0.9815358179588268, 0.9621206481089827, 0.9720913827437174, 0.9949250010629056, 1.0675925336841354, 1.0806348472450606, 0.9878237414565316, 1.0201593210615554, 0.9334845561460159, 0.9770066964450204, 0.9838692522948234, 1.0523633612400178, 0.9523771037328943, 1.050211830306298, 1.005951778517652, 0.9615411224540377, 0.8600272389873121, 0.9660354694924508, 1.0342821814143208, 1.0518885513473837, 0.9578630067021238, 0.8689016246884292, 1.0003015463028249, 0.8166320086044219, 0.9808960265856098, 0.9182719249642851, 1.058111029934936, 0.8470958812957226, 0.9359922132663101, 1.053762698984531, 1.0616954649716535, 0.7855746083396026, 0.9407197011884424, 0.9618627580614193, 0.9543246389564131, 0.9280627081606838, 0.8925826918823847, 1.0038679011781066, 0.8312077572366516, 1.083089940741681, 0.852000118352882, 1.019583164019007, 1.0621917075690255, 0.949090974035079, 0.9514642538451117, 0.7680822781747398, 0.9330496696419159, 0.9755701228375518, 0.9556141236421531, 1.0328790660257183, 0.9324706199665658, 0.8882684480632673, 1.054925462663402, 1.0253818526343257, 0.994197243509101, 0.8341636548028294, 1.007407433130194, 0.9161990259348909, 1.0470890834969329, 1.0645361423698319, 0.9980802789157575, 0.9099325208104209, 1.004995662527751, 1.0666847489556077};

static const float w2[64][32] = {
    {0.9799211270405079, -0.28336564132252856, 0.880641534486679, -0.17157380215944368, 0.24370540011128208, 0.4950135750143543, 0.7447370687171296, 1.0655863691309475, 0.9268182001300327, 0.019757593584923194, 0.9461788725498744, 0.4200604513362406, 1.0421403491187216, 0.939447579001587, 1.1446545236222758, 0.623997542422481, 0.03356948761957207, 0.9787299189547268, -0.14744830339341108, 1.0361104263970526, 0.08422114455196342, 0.8121194312528783, 0.17266434995061, 1.0447362922222807, 0.028248599732814662, 0.8899932196179756, 1.3838578713306688, 0.9108414245353486, 1.0545989012501535, 0.9265548223542939, 0.9004294580874672, -0.009973114563425325},
    {0.5946575715365202, -0.08670696782920627, 0.8858996371878104, -0.05564818133495733, 0.48367996927655904, 0.7711432487107815, 0.7515827250785435, 0.9124364183005044, 0.7801575771615356, -0.17629722871604792, 0.9102240077278312, 0.5024463052022965, 1.1178953394567452, 0.8384232794619457, 0.7386963608184143, 0.877127452358371, -0.08049629024298816, 0.9324175330677829, 0.10529566007309824, 0.9710487670871175, 0.13079933663742532, 0.6109818820160242, 0.04601337584471883, 0.9630798469915696, 0.056297304292641154, 0.849103839517353, 1.0085741924661469, 0.8200985372162289, 1.0458271946158466, 0.9184147814994603, 1.19021034229834, 0.009503989808485167},
    {0.5358397629257401, 8.755018085620808e-05, 0.41643641204189497, -0.00014201186881676844, 0.1702699658983891, 0.25380934279594514, 1.016517024944373, 0.8910296823116548, 0.7620059032094899, -0.05629355399553141, 1.1086571984083222, 0.5423193408571174, 0.7782734566728051, 0.847916503498123, 1.0838224851952885, 0.8963419372078892, 0.21513819072126472, 1.0795833463667768, -0.009425054292341941, 0.755320046332082, -0.03658714598042662, 0.48080986126241687, 0.015767745754564116, 0.6611946710422812, 0.08100193562582673, 0.5366027780920155, 1.0750682402878873, 1.2079320741272188, 0.714431363795617, 0.7845364470059348, 0.8762781100265598, -0.26563792031028705},
    {0.26941133214094554, -0.0005284968927508179, 0.8564346492068886, -0.3161165364484625, 0.25539276148994605, 0.6301645869439745, 1.0411699731671595, 0.8619477794242278, 1.0333712621140514, 0.2542338738151746, 0.9041933167607394, 0.6541235148279847, 1.2941259475584603, 0.5345064191095398, 0.7121481756657804, 0.7787354657956149, 0.1625665946504625, 1.2661272923877602, -0.19071463009092354, 1.0937507056355527, -0.16308721944634072, 0.7070869355362863, 0.2290341553833477, 0.8242076613833675, -0.11265961222228175, 1.0578710084558025, 0.8841813458149456, 1.0560273368550186, 1.0507224732304468, 1.0212578050277903, 1.2098562501125842, -0.039187747519726236},
    {0.3056977573274619, -0.19990916564265487, 0.6172448675753468, 0.1073408310386368, 0.17711681391624645, 0.5501685550509, 1.1740920447245105, 0.9142844178903814, 1.2877779605278556, -0.44756966395746933, 1.0795689736679404, 0.522379627999277, 1.1152744086673587, 0.7237529775638699, 0.7537291498807297, 0.649879833700972, 0.10546241262199228, 0.9686090069981075, -0.20732481870900427, 1.0257777196155826, 0.2560620076769097, 0.8079483568018226, -0.008649895740337464, 0.9446519048005618, -0.17566510367436014, 0.8922966553103361, 1.0214694265221893, 0.8735863462142032, 1.259475872145228, 0.8966888017551514, 0.9233297381514237, 0.052538757528589074},
    {0.34605867579003874, 0.2565137301847712, 0.9774198237126743, 0.22529121635419586, 0.16826235924340613, 0.2868335729579392, 0.5287703918947166, 0.7893674776358683, 0.9770730261099626, -0.24920253951309712, 0.9486309665988574, 0.7216113649245229, 0.8817071823691423, 0.9326105120609509, 0.834406582622837, 0.9840372737866893, -0.10018195359427688, 1.0976624334462195, -0.18633448886326448, 0.8816338374692296, 0.027576295170443632, 0.44344528138610617, -0.38463321989702187, 0.8940692400988579, 0.20782700142831673, 0.6497433390822626, 0.8834026024964953, 1.1526941524825354, 0.9823385385589812, 0.8400667021851019, 0.8334754812513316, 0.03291814256864426},
    {0.2839699886255783, 0.007848253681165394, 0.7022853709008469, -0.06203764850477468, 0.4639905597005661, 0.23363547933947268, 0.921480657856017, 0.749834566525665, 0.7691280782519486, -0.25144372711905855, 0.927245944356815, 0.5356098109849394, 1.3461726069058866, 0.5719870812624013, 0.7152035589359496, 0.5120637988881359, -0.07118636009039199, 1.1005084871286963, 0.07816435417004798, 0.9798967332394269, -0.04218314450301234, 0.5143513737923145, -0.05944168320093829, 0.7570325483290025, 0.23433202405360026, 0.8181345948404098, 1.0869059596437554, 0.8762716100051667, 0.6372165488196146, 1.1317740599191068, 1.3921146687732877, -0.26732506061036376},
    {0.5597942923639603, -0.17030369795503694, 0.756493509725582, -0.034412172417976616, 0.30462957271954305, 0.3579639489066499, 0.8949378247061853, 0.7878533798747807, 1.0847168320516127, -0.21579804797622848, 1.1064671825793002, 0.5007796184247658, 0.6661289630987824, 1.2017546792906235, 0.8304602020974279, 0.6317263774938612, -0.10471139164528447, 0.856561717798691, 0.03828236497819876, 0.9486199470668755, -0.12921750928936201, 0.44860585665926145, -0.2750215728552659, 0.5805211312599774, -0.22815504347618296, 0.6910711223387965, 1.1006720685060074, 0.9616567399268285, 1.082126212664012, 0.8160308277477427, 0.8145936246209275, 0.001504940873114938},
    {0.5437100579850606, -0.31502756003348337, 0.44477752213271776, 0.12024173812011864, 0.1981313364942383, 0.7459683546582133, 0.9131773269428813, 0.7380214499607524, 0.8043524918995657, 0.36585648402798127, 0.9581267817895711, 0.553995752919375, 0.8100150380478461, 1.0113403521948305, 0.7621836620301605, 0.6298351230376732, 0.1304374369876683, 0.6158270489336322, -0.16875482725083357, 0.8516198922698878, 0.07258640915191901, 0.7046607632010236, -0.05933507918985685, 0.8448786422040961, 0.34557465004515137, 0.7092485939952876, 1.1580863113798916, 0.8488868670021108, 0.7435941601303834, 0.7195034304519826, 1.1249741540757605, 0.1257324980377903},
    {0.6630012702645686, 0.24344032337051985, 0.34895191862398217, -0.23540349126926696, 0.3873156259447293, 0.2759508556564678, 0.9944125055899519, 0.7584646535751471, 0.8836171971985977, 0.2832616332700181, 0.8286539998599226, 0.2594884836711582, 1.057878061102929, 1.0158760193159817, 0.7945956953458331, 0.5693384164066763, 0.08603468718859084, 1.11429827185475, -0.4190998120418881, 1.2221330948899427, -0.07595006076700071, 0.7951688629004586, 0.03934916285008456, 0.7754952607564781, -0.37474389867593627, 0.5321021369615363, 0.6746171991926354, 0.7951896601913332, 0.7356062919817682, 0.5641753971090451, 0.8030531340867887, 0.3008756321640681},
    {0.35199832252357954, -0.07310977631921035, 0.6196973167349551, -0.24108650118393654, 0.2238521917256585, 0.45053086917863655, 1.0098829235624103, 0.7650416236052764, 0.9894246294026757, -0.13182281437243337, 0.9282099919497749, 0.2079968297103164, 0.9080172860296191, 1.0414761144163291, 0.9234426492677223, 0.6100758951363427, -0.0027885770248662965, 0.8764480821818634, -0.26185003247709704, 0.8011198359847008, -0.25373214049046117, 0.4364708591603716, 0.17138519107504063, 0.6540219366267231, -0.3493521736686519, 0.9144169822257227, 0.72178890902345, 0.9667536294285816, 1.0056174577695798, 0.8985113389090421, 0.8738345183320392, 0.2902589106011897},
    {0.4521196465558094, -0.08970344216763428, 0.8113236808626009, 0.14337339484705341, 0.41266085662740754, 0.6527871578512697, 0.9168608819677339, 1.072241234909266, 0.9839526111148135, 0.010503464345358982, 1.0086820926538276, 0.4162887073115002, 1.0135911778888886, 0.9081300502880099, 0.5675074428439884, 0.8453765296769914, 0.012907391919881762, 0.9957227258031189, -0.11037758804326155, 0.6455927338059673, 0.10543043489294035, 0.6985160699519645, -0.10334048218809798, 0.626459206114479, -0.17790093961595313, 0.9354164920292184, 0.8863973554059117, 0.9898104105806955, 0.9333418433405622, 0.7551838809312794, 0.9717343063490138, -0.14077829378606563},
    {0.4250860543715661, -0.10270491973938987, 0.4220444283495516, -0.0010051687045058797, 0.2732825675666282, 0.508514491147818, 0.7130426185988589, 1.2099898351117448, 1.0043623206356442, 0.20812227026918104, 0.8118504380490018, 0.49559463410844, 1.170341006310588, 1.0213973320032512, 0.955116550108081, 0.6182542705301123, -0.09432971952720015, 0.8719880068180889, 0.19128460781234713, 0.7616468897755213, -0.21747160715574432, 0.4663629920385277, 0.18671104390919568, 0.38332189656521204, 0.3225332978527279, 0.7585549558013669, 0.7017532062367049, 0.7861688667107022, 0.8775793238654076, 0.8855516420211001, 1.275154847968185, -0.005006690518182137},
    {0.5310946522338578, -0.055223734962489446, 0.828599312887563, -0.013872564108322999, 0.23639843957229573, 0.2771786133999588, 0.9652845964648565, 0.8714863734627604, 0.8557098609080099, 0.13884225679073425, 0.9874913348966176, 0.6324607604396999, 0.8216384075697235, 0.805756308832275, 0.5573400924093813, 0.7889996166500912, -0.06572847944788014, 0.8780297232633009, -0.09750247014360922, 0.754914170581077, -0.2986258057229401, 0.7083578483345115, -0.037816652464305184, 0.8156016447230466, -0.04412947476784749, 0.7186412193007853, 0.789856263400042, 1.2041351640829387, 0.6825632932858178, 1.0162782537197907, 1.1039647643987196, -0.06799001592137645},
    {0.47610435889823455, -0.2782185206633633, 0.46947080486351184, -0.19281573886430367, 0.1031343891511805, 0.6597650599592809, 0.9671314434791026, 0.7737611466505546, 1.0171352564762532, -0.12438994999393604, 1.105695468977194, 0.45129722199871036, 0.9369591645566342, 0.8465965094910364, 1.046883192439965, 0.8706211501742986, 0.18657010194307128, 0.80971121811915, 0.17038485114524282, 1.0837467192540107, -0.44255309842678076, 0.6175545017888782, 0.0634418379304477, 1.0722740869206786, 0.36043653780211454, 0.9646737474839758, 0.9591681848683359, 1.0378763895946765, 1.5215048326056417, 0.8160970547838898, 0.8485824724888652, -0.2731623833262607},
    {0.4546609898253794, -0.13576143071505284, 0.605477606745062, 0.03239354989015797, 0.3125060097831466, 0.5614629009019565, 1.0095464330837387, 0.7330809052106774, 0.502024779857068, -0.141874027725119, 0.6306566229938647, 0.6495679329864305, 0.9932271921489015, 0.9367943795105685, 0.8604672005444681, 0.44255935082825126, -0.20862857494179785, 0.7080645864387819, 0.1924895608314015, 0.9594640065714308, -0.19554432833150467, 0.3539179271052381, -0.17677797249076, 0.9415607218481411, -0.05606581900926202, 0.7757530319522071, 0.5108525628937015, 1.0267123829140823, 0.6127016582433458, 0.8538862040210987, 0.9584290297081864, -0.011507554791453142},
    {0.7291773770557328, -0.09311941229244991, 0.9066984252341532, -0.12560346374895995, 0.3099926615268579, 0.5133985583333218, 1.0955752327646864, 0.8870965294932878, 0.9443289432717078, -0.3656220882742148, 0.8730202818029186, 0.41176526607189257, 0.6035779500655613, 1.0304296397782158, 0.9365604034079006, 0.7757719960243267, 0.09362803010612825, 0.9909048423550887, -0.06590420701708122, 1.0310454802773688, 0.3218728831487081, 0.5515856644592847, 0.12231187210329965, 0.9680446672969335, 0.0598788730243586, 1.0275343092030649, 0.7851557234420734, 1.078477226683998, 0.7798446980217585, 0.8502160060836387, 0.9560556549210045, -0.03945123007965985},
    {0.34389368547343935, -0.04320702345517659, 0.687942914889709, -0.2837221135724642, 0.23656395421990606, 0.6052891591745386, 0.8974727399825316, 0.8073348493672082, 0.9618311623745114, -0.02579377326496779, 0.5687524149889904, 0.44091008929729136, 1.1362941212275073, 0.8412316884637803, 1.0767410946163283, 0.47011072952471505, 0.11405655131655466, 0.9046011200331472, -0.1617875171441221, 1.0056877177942591, 0.07148868865543712, 0.6513557144060561, -0.12704022593097333, 0.8456374581485077, -0.20019083575475158, 0.9388749423610079, 0.8965829667944639, 0.7208891338096413, 0.8226102874983751, 0.8310989448319931, 0.9419050756994773, -0.12931747126970713},
    {0.2961737382937452, -0.1781025986363302, 0.7153374831927379, -0.24873446915573186, 0.3321978832418627, 0.5038099581437804, 0.7162475908769133, 0.9005661693833578, 0.9815180726578763, -0.18109400825807323, 1.1576944861175305, 0.5481874818432854, 1.0526728745963099, 0.8253341191406464, 0.6879441868931294, 0.6329421804474642, -0.1949313742152986, 1.1503984623080081, -0.07627228538779124, 0.886567110753982, -0.08665422693941305, 0.7259330671863976, 0.021228869631203035, 0.7168841012192062, -0.0005060683451578074, 0.8634985052636759, 0.8002850183964575, 0.8537981068154391, 1.3267021384872426, 0.9731624706325532, 1.087415359169031, -0.14015068013459495},
    {0.5423769159621528, 0.044751338427816485, 0.8706476905752745, -0.30740811216515346, 0.2400693765529442, 0.4668765919508531, 0.9553817175663564, 1.0830884635155693, 1.039019158628714, -0.0593129022216345, 1.025928753244835, 1.1095917038775254, 0.9143034439305484, 0.8797382601771964, 0.47625382622200113, 1.0020838604535802, 0.04461962005182205, 0.8045464889725508, -0.17471564445771043, 0.7574655153717132, -0.15380983788170094, 0.6183006511044348, -0.21354866297369932, 0.9986278139402854, -0.1815780868986653, 0.9096658484463468, 0.9017241682782118, 0.7858830311104579, 0.8009286397035044, 0.8659801321747513, 0.9849310746770585, -0.04994681819431113},
    {0.6295939387503341, -0.18377740947029836, 0.7524699113838997, 0.03771995492720383, 0.0461209471617085, 0.48117713504693904, 1.0860922270247255, 0.5788273572594859, 0.8374096239841502, -0.14278218833729525, 0.6801023195936667, 0.544732913371415, 0.7268285211325769, 0.5976141331694949, 0.7986967092119532, 0.637273837183591, 0.07159159756495707, 0.815389503043697, 0.21047871677302735, 0.6017059233724507, -0.05212624384288965, 0.41205827117322863, -0.22632832483704202, 0.828322277147734, -0.06846481928933759, 0.7881572135804482, 1.0881785757345388, 1.1702425782949817, 0.8667417638256832, 0.7491469267811418, 0.6953675590864401, 0.013750486241415174},
    {0.8594821967600927, 0.1677994623185117, 0.9802917836476507, 0.120415758033571, 0.5741082977485198, 0.5941599581367029, 0.8699891774795181, 1.0745345691978279, 1.0895393565094105, 0.04312286531807608, 0.5385762032870185, 0.7596674308716673, 0.8406664739003473, 1.0105684467093905, 0.5981566019811644, 0.5503198069343402, -0.05770503695545114, 0.8239023292827774, -0.22944599874586247, 1.2392342586890923, -0.3823676926315717, 0.41961120812965985, 0.07013994064151126, 0.863294556789808, -0.2672993041223719, 1.0142392904874447, 0.9039781386186322, 0.8528665058787684, 1.1505911346353317, 0.7974102883356718, 0.7186917061113042, 0.1451599423729323},
    {0.46446866321895847, 0.07109687209057865, 0.6484550235357462, -0.510712569873685, 0.16125216085071112, 0.38236355520584714, 0.9009580845172616, 0.8157301974511691, 0.976256621389162, -0.05545556275728918, 0.8319874120159109, 0.7666281510262909, 1.0785597352506295, 0.682533164865764, 0.722763391019841, 0.6001117740727092, 0.12744276951992464, 0.8378309190292117, -0.18124088013627773, 0.767118992511394, -0.12179527772913268, 0.5427812562484899, -0.1694279212282579, 0.9687512491508852, -0.4945120075342473, 0.91695696899543, 0.7052459205843951, 0.8018369181770488, 0.7807401797295875, 0.8456282237264249, 0.6688444861236066, -0.1882424393736393},
    {0.9438098647442832, 0.1769761274794152, 0.32926273060006134, -0.17370975743821476, 0.49425300811988676, 0.13779474263087393, 0.8039292647723202, 0.8439609724866042, 1.1047152864851315, -0.12069936430927727, 0.7742120923530913, 0.5808240423707963, 0.9848432789630172, 0.9464356996743934, 0.6846011939953641, 0.9628887997019344, 0.06070537561641917, 0.9217531564894854, 0.23587324513425426, 1.068281233079701, -0.05519193289778748, 0.994428289791042, 0.05317483485508509, 0.8854375859613302, 0.029981772290958913, 1.0511345595209713, 0.9225378157244131, 0.8432301148445985, 0.85527058706759, 0.6414835793112789, 0.7005472916619446, -0.06635313958964614},
    {0.3946691371563853, -0.15508770483437515, 0.48197101429748684, 0.10480230310557752, 0.3239643406562248, 0.29026443471813707, 0.9923709836421764, 0.8447984808368363, 0.905412428972078, -0.22008245614574215, 0.6523012959173478, 0.5217623233335715, 0.6485065700166932, 0.7576033252296791, 0.7581764353280238, 0.4950174359490308, -0.2309961928615434, 0.6930244163225837, -0.0798901315795393, 0.991986090169877, -0.04880895613469982, 0.48143550275141417, -0.012013792671618015, 0.5485643459717613, -0.07362589868183271, 0.9213967753212172, 0.8273338315464813, 0.9852141151886701, 0.4853235219376967, 0.8434703008767097, 0.7271394440023288, -0.146201828606989},
    {0.23372580840223492, 0.1122503451748406, 0.7829436821485665, -0.22277580847886888, 0.46008951543009796, 0.0084948114092097, 1.1273741820138272, 0.9917688879368951, 0.46708663072811235, -0.0942397962449731, 0.8471108537767104, 0.21255776522936984, 0.9045195480757486, 0.6383808988508463, 0.8679233631993605, 0.6285691533811888, 0.04204935965655512, 1.0068773406064142, 0.12616464689659676, 0.8507556050618424, 0.17155873169777286, 0.5530065146692694, 0.12186848332804194, 0.8015589366037226, -0.1262672957216968, 1.134527950523082, 0.6219297802688202, 0.9915513094833747, 0.7374885185074534, 0.9152001660712176, 0.933082964556753, -0.05897156767445232},
    {0.36825761278175795, 0.07369241919453591, 0.6917814130826381, 0.01777629211158554, 0.21290257844048976, 0.426684349827081, 0.7431655220872909, 0.8842570274316649, 1.108682923256305, 0.09563797864235998, 0.9199894353342631, 0.6158250072335302, 0.6706713471097827, 0.9935391735486235, 0.5875570078469575, 0.4678207272300483, 0.010973574069323273, 0.7083656591661666, -0.08932843313896817, 1.2874785901110275, -0.04206766786835571, 0.9416312543636255, -0.157869093191171, 0.9262623266892772, -0.29210923845281567, 0.9360512425455276, 0.9979904651720594, 0.8656903491608285, 0.6872925551747846, 1.0549276274431372, 0.8788064183305623, -0.031029278227339124},
    {0.8482146476083833, -0.3213394463435314, 0.624138483926177, -0.3248350339741988, 0.43079769518108874, 0.3526086207792865, 0.7779527506085263, 0.619911179643167, 1.1681825673523878, 0.044439956504784474, 0.9323484574117779, 0.6783507814663466, 0.8662154373547498, 0.6937637287717182, 0.9492026477537998, 0.5044608260785702, -0.29966718610901516, 0.7851652287613058, 0.07319022793338517, 1.025624323974202, -0.3016449581589278, 0.23514733461357065, 0.09680007623748828, 0.5286352425176573, 0.017737570153953035, 1.0099581753830786, 0.6853775441595491, 0.9636816862135223, 0.5986989106841583, 0.9615998109894309, 0.685841846149091, -0.15653315605649493},
    {0.89134319249055, 0.09250771823594321, 0.7225606322351189, 0.24880827239259842, 0.5709847043538331, 0.3266323685914391, 1.0448703637530725, 1.0169526918094975, 0.8025883641593115, -0.1160548739641201, 1.0658337352847533, 0.6336966403945477, 0.7897469835828381, 0.7260671042581608, 1.1207008365129514, 0.6976759299356122, -0.26275608846280324, 0.9591150842394728, -0.16158964395505085, 0.9959386882672494, 0.09148758888378646, 0.9897606946166825, -0.11260699532145414, 0.6692917462223007, -0.052314746754305835, 1.1435712578234627, 0.7586466594549494, 0.9505586756320438, 1.1079678598074072, 0.7760814956812618, 0.8369117249535813, -0.11281778093857439},
    {0.8906798669448194, -0.0133345427086375, 1.0555838742142845, -0.34304299372079, 0.4854813052340182, 0.3242537840088854, 0.7511934793406156, 1.0955710728709016, 0.9736583493755095, -0.056757060333650244, 0.7990521841933732, 0.3842993181399994, 1.2250540436139783, 1.0926141613985993, 0.8240885252398209, 0.6470193937553225, -0.243640256046837, 1.1942903939048823, -0.25378651557889154, 0.935257836501639, -0.1829257096807688, 0.6214372317795315, -0.22010645091952893, 0.9309698136248653, -0.07458798336070616, 1.0450781702771277, 1.135561671762479, 1.018324283073775, 1.1551423675901598, 1.037671743229753, 0.5808352383710628, -0.07177861060876863},
    {0.5166747853227327, 0.1056759259048504, 0.7476229281982918, 0.18754128818586102, 0.28751465346388455, 0.5497113327339209, 0.717557191922696, 0.9075019206042656, 1.313279875265131, -0.2021996370192843, 0.9977782691626966, 0.530153252953179, 0.9618787249055974, 1.13909123741132, 0.7496465806216124, 0.5250380885337711, -0.39408029194668337, 0.7575494187040502, 0.1597645089836499, 0.9773662001769475, -0.23632203186039133, 0.6294658452644616, -0.18711533026781682, 0.6727175936632439, -0.11472580083465626, 1.3389061450045658, 0.9260310459813699, 0.9953248494205849, 0.8117611107359808, 0.6811890508054528, 1.1062775863635552, 0.09601448523352661},
    {0.5665742979588838, -0.08761731290418175, 1.0414407841589066, -0.22733092010655287, 0.10078599755069646, 0.4390781972853496, 0.9002632321659295, 0.6986264515942788, 0.938830614981934, -0.3973575593093871, 0.5829999491644406, 0.6531590195976984, 1.1844175694569896, 0.877727914091106, 0.6022651002341206, 0.7021095204133847, -0.21933904572649132, 0.7901002293988575, 0.034809777863219434, 0.9676955773912425, -0.23637318887338046, 1.0277939586625147, 0.023561392362348863, 0.7620355292507816, 0.05425983730784194, 0.8474134540822955, 0.6158973392859711, 0.9141273071861814, 0.9943788384834894, 0.8883241082325251, 0.677307906485673, 0.17145025330963512},
    {0.2581780614666486, -0.010633649562984338, 0.9851209238872178, 0.028671195875791245, 0.6865747947052196, 0.947926560069548, 1.0397573817735484, 0.9446278235506735, 0.6511702815648458, 0.14474852173566738, 0.7860406184260198, 0.41852049032169036, 1.2972403869979114, 1.0172378720729407, 0.7468100540395967, 0.844354488475232, -0.10068922433051355, 0.8406156243241287, 0.07311369766070606, 0.6045646844735392, -0.07686523501159474, 0.4827135188902416, -0.04525085529256426, 0.8296284307602505, 0.12163685413912023, 0.9918539123444667, 0.9410425110631697, 0.9379715321724468, 0.872255913669679, 0.7403161932592658, 1.0358207702574587, 0.1031503952870082},
    {0.9178206006652243, -0.10848979485218994, 0.9875097363048639, -0.12375023967903004, 0.3189909664304599, 0.6946272733490374, 1.2365936706317446, 1.2419107955995135, 0.8485056923650873, 0.11918590941088494, 0.8409551473221326, 0.5587005377844039, 0.9485608604775675, 0.7995937746384719, 0.8374644501938879, 0.7333971450033546, 0.09243136791438207, 1.1291614792459683, 0.027873193139980837, 0.9276292174573746, -0.2914358176463958, 0.46673343014227586, -0.3618240126573081, 0.5798540155810371, -0.11032675231791282, 1.0437206999339854, 0.854878330205988, 1.0327884174350062, 0.8194467381542485, 0.9816139568841247, 0.9434469843243829, 0.1352598807091863},
    {0.0952667648997641, -0.03374549426572651, 0.3861369181989972, 0.02511535266167543, 0.30431883742811744, 0.3797306317411372, 1.0549783767252445, 1.2216094345366177, 0.8483222267309853, -0.007204823748624348, 1.2298145178732125, 0.6637478989340059, 1.0435375261851718, 0.47713774461547587, 0.9819314678796999, 0.30585631303244776, -0.0022688253148498805, 0.6567222900792474, 0.053823760676692034, 0.7787196149326147, -0.1681804449272759, 0.7094627566928963, 0.08613958729637029, 0.8147927979651611, -0.12483469319513761, 1.126303575138002, 0.8588696803804308, 0.9509700952607772, 0.9598390548121324, 0.9655792707686975, 0.3663544373307467, 0.0750751351698651},
    {0.5509629520743318, 0.06784599770160633, 0.6307294889984081, 0.11480069353722933, -0.17507865299807115, 0.29563542502834034, 0.7182501795613606, 0.6816842624412047, 1.1781542437190442, -0.09607123441676459, 0.7966870285013193, 0.4900791764052876, 0.8964024965210794, 1.0061740558838643, 0.7846834035660457, 0.7771757461410456, -0.059710268690130984, 0.8626183054460088, 0.0059584614529273735, 0.5462346361294059, 0.00801080507093981, 0.4231803898149032, 0.09968375195654257, 0.30682033149070853, -0.04602411340536401, 0.9656175758546437, 0.9089225400251909, 0.8330071507590409, 0.7081744335630561, 0.8548531314071873, 0.8663226243241536, 0.19352578988485994},
    {0.5484664789231712, -0.23656016940151736, 0.724310668559209, -0.09430195015364494, 0.0645728757398268, 0.1848240521530125, 0.8004274770434066, 0.6259437588360308, 1.0109047607315547, 0.48941392392261457, 0.9944034572424674, 0.3960037776964964, 0.9993696627206415, 1.0787340968976706, 1.080641391702409, 0.6710405945747877, -0.12498840732604885, 0.7590632492365044, -0.4251977292559675, 0.6380895678496715, -0.15508372468457796, 0.44285481880051886, 0.18474323569189807, 0.7020431249599768, -0.016314933963311313, 0.7710672718377113, 0.7738441091673772, 0.9088972683456484, 0.8230369774424353, 1.0076920860783396, 0.6135569871039415, 0.07554058353859122},
    {0.44799471722112477, -0.21113350370515896, 0.8475896199385548, -0.1402033350138038, 0.2684795335630527, 0.544173773393886, 0.762070682196629, 0.8154173806501995, 0.8168309834864217, 0.027329664453046014, 0.9158641378071306, 0.19003948315208655, 0.9679861872650793, 1.002682830206486, 0.7525079131568794, 0.5191453082963927, -0.17538291401381892, 0.8814165497666021, -0.21723370225070462, 0.7117485564035859, 0.07436813583570402, 0.6992171736924555, -0.3891941825947551, 0.4456990647941826, 0.18516500286903226, 0.8995563553981902, 0.7017124459625311, 0.8562690392335367, 0.79134341290408, 0.923911292407838, 0.7867139138185857, -0.21617749897370434},
    {0.6725926279875398, 0.043064369141263166, 1.0071133200218498, -0.20893574595653003, 0.2542741732849279, 0.5281882058116346, 0.9192860749919815, 0.689120216461537, 0.8863823754026738, -0.370916440395157, 0.9880417857622928, 0.7091354855949702, 1.0527824496962976, 0.804345642897228, 1.139184806853957, 1.186906776534953, -0.2809275744136452, 1.1594857009396926, 0.10661415924587472, 1.0204721314497538, 0.228751843903004, 0.5804224375911293, -0.15069679574988734, 0.6713756670597751, 0.06276138634055375, 0.9088443282439884, 0.8419208412392227, 0.7913601490438298, 1.0890199605536381, 0.7582576992384916, 0.8320223318124923, 0.05930947009424734},
    {0.4517197717289884, -0.45799937529343554, 0.7286788076217182, -0.23906870953716716, 0.4251401922484577, 0.4437274742651383, 0.6704930571229233, 0.9979346644346831, 0.8312647234431264, -0.11150800340610431, 1.0584633977035365, 0.5427325025632064, 1.3111394944258024, 1.098572258867608, 0.9343585913216544, 0.7927644590827755, 0.057910019639725904, 0.9187294697788067, 0.06624331551250817, 0.9064342835646472, 0.20012886738798846, 0.5978361684905654, -0.21914972025736884, 0.9263715647654458, -0.11208976940480507, 1.0852629772688949, 0.9213232195042839, 1.0250831505019775, 1.0820179343300598, 0.8113733541827908, 1.0910222210737917, -0.0736793905174841},
    {0.3986723933900751, -0.039860354341400464, 0.9488720075620003, 0.31921880590742036, 0.20578480407541894, 0.597699779187514, 0.9201924450786089, 0.786926056259524, 0.7028470975538366, 0.1900491926448852, 0.9538312169922922, 0.5777396125946639, 0.7461838289394866, 0.8654972381864939, 1.0352484749123385, 0.8377071573682331, -0.30802909672750145, 1.193941397961127, 0.09989992632140406, 0.7320320794783993, -0.07302006301914624, 0.4871728671136375, -0.26497420059486326, 0.8507615104777332, -0.06954217526342538, 1.0495793758726382, 0.8696598044168202, 0.8050662534481936, 0.7186635447746066, 0.7212765073061591, 0.7064485263684459, 0.12867357778792893},
    {0.5269649857670852, 0.2792831361003448, 0.594142955104122, 0.09634754858319063, 0.04089842563425971, 0.3936819969736302, 0.5980164514812044, 1.2171303472243684, 0.8278903905657896, -0.09409966746822744, 0.6740373387890077, 0.4472161161589785, 1.0898502568689559, 0.6994366190897668, 0.6729369107837642, 0.46416027753040184, -0.037375016700116746, 1.1303353573273227, -0.3164547434430545, 0.9265594156711923, 0.011147295338671792, 0.6448072888500522, -0.02671044018637446, 0.6839762908580367, 0.10437758700024455, 0.9473734437670958, 0.9521012630204616, 1.1937224416182584, 0.6066998594958404, 0.9731052017904221, 0.9493219974118299, -0.05563055661830793},
    {0.3026230370334647, -0.059024568728483696, 1.1461491784102233, -0.5482105751586486, 0.40734346263359983, 0.5354016588653295, 0.7407281893396751, 0.9276135427762813, 0.9018574316965343, -0.3309820532705752, 0.7220343724102825, 0.47166965567029456, 1.175179528010918, 0.9476456328814323, 0.9958320088293213, 0.604085298566885, -0.12766909918393013, 0.9830501161704122, -0.002849070744378545, 0.7173871313701151, 0.3445833887929905, 1.155053311741322, 0.06844349083719828, 1.004021818023087, -0.4898236550694309, 1.015255625766677, 0.9545723681142634, 1.187523830441617, 0.9662611673132485, 1.0354617865467908, 0.6626739962994938, -0.016938987897094603},
    {0.8367810253708209, -0.037224036322523905, 0.6912500754033578, 0.03486097734816039, 0.3712049776128563, 0.5189950277280245, 0.7061803467809745, 0.9794533901757355, 1.0845670037848065, -0.018183575682033094, 0.8572921062857171, 0.7633815484840397, 0.7671888898873566, 1.098958353974951, 1.057331160071113, 0.965340840167843, -0.19723404444410267, 1.0635601030493422, 0.24587734745321752, 0.9796207499206222, -0.030886031132859478, 0.6957654982835844, 0.13774465369710992, 0.6348523486618846, 0.11388193962151276, 0.846058178323142, 1.0536871258837146, 0.7918269051255041, 1.057998130290615, 0.7786520966160034, 0.830396658561072, -0.043299608423497914},
    {0.5399863216993482, 0.06801785568284542, 0.8517050992446343, -0.11405080053209005, 0.19960218335470345, 0.25444225765950546, 1.0296042347080256, 1.0589846518530608, 1.0106608360758795, -0.1165681756786863, 0.8261454546295434, 0.8260373323645902, 1.0718202510287125, 0.7709638517591063, 1.019907705519825, 0.5866060753030825, 0.1932006555623018, 0.9158503548028978, -0.1311573864940012, 1.010075282027544, -0.3478690961435506, 0.5299176015162207, -0.17591213932328478, 0.8456416302695564, 0.0846580534668144, 0.9199625401430226, 0.7795634666205392, 0.8499989336326259, 0.8150422354868553, 1.0903347990857586, 1.0140895604334945, 0.06800182864685761},
    {0.5733185256680535, -0.019733473016347227, 0.6750008588293144, -0.009018100107189776, 0.3180402060687927, 0.5672188631101108, 0.9006951553798268, 0.9587615668825538, 1.0100145030232235, -0.0683380872925329, 0.9515994032537113, 0.781588406233373, 0.8633954946533371, 0.7825718125704347, 0.95900376706187, 0.5979122959461053, 0.13164622323515981, 0.6748613210545762, 0.2812704829303642, 1.0588097390284823, -0.21097449152524025, 0.7529764301511604, 0.30627754621128855, 0.6666587762165328, 0.04339597567032384, 0.7038292344360156, 1.0217593950007473, 0.5501180446743186, 1.01180411268703, 0.9563377924841363, 1.222160310396124, 0.07699528654973628},
    {0.2364886173820269, -0.02041465876782674, 0.5755715707890293, -0.21068037003291945, 0.47491258963203725, 0.5444488705242325, 1.4567660562133258, 0.7391320598085025, 0.4913583336926573, -0.060997782237678995, 0.9594028260651704, 0.5270349694990106, 1.0895448673226458, 0.8782048756492605, 0.7014146555921463, 0.5023894634381577, -0.17745560632067242, 0.9159860477665427, 0.0717369630002093, 0.7217472206184452, -0.43929840831322625, 0.7527412514868942, 0.10543766735365807, 0.7796609533379696, -0.11471246468266875, 0.6376023094167208, 0.8726070321743185, 0.9262918215415358, 0.9330909909065346, 0.8960414477055534, 0.7029142041981895, 0.013763140034193804},
    {0.6511082841768645, -0.19273947788819912, 0.7948516113380449, -0.0881813409591415, 0.15458814165941662, 0.3809687833826996, 1.0723663042150877, 1.0229758953524168, 1.21521609867002, -0.04334016223815196, 0.9877452766068239, 0.4405022452159904, 0.8302431479570113, 0.6735269322771889, 0.6847288160726233, 0.8936478080077657, 0.0436440152007972, 0.7482352066449519, 0.024391150495734246, 0.8523022091195623, -0.2188908550227723, 0.8145064888773123, 0.005418968115827776, 0.35296424117771413, -0.03957294854998866, 0.8660616201206662, 0.7307559683375531, 0.961155143258123, 0.887990660951952, 0.5938990708847195, 0.8605335904819127, 0.027119607649844998},
    {0.5207902214518235, 0.09467421877545017, 0.2690605494532184, 0.1769992166426662, 0.22224548373326528, 0.5647627336654855, 0.7565496976475655, 0.9666003428638585, 0.877607320156422, 0.02696412376859233, 1.0051180008822733, 0.459078153118082, 0.7693317732247438, 0.5924360562011828, 1.048436142386891, 0.7788197165364451, -0.1626333218416511, 0.7456062115360184, 0.09962046425843815, 0.9662269369855626, 0.04362160117015776, 0.2520012189435891, -0.1907952138617736, 0.7324482709681123, -0.32476649772696575, 0.5606149201222801, 0.9780842075834022, 0.9104877383898313, 0.6965185290812791, 0.922332392919056, 0.8251596695113251, -0.34081292806755215},
    {0.641755290160815, 0.20964058312635162, 0.920986076987911, -0.050897539825338824, 0.3929791916918103, 0.48723504444125415, 0.8163964853744354, 0.9396671932457494, 1.1395777656280934, 0.11630127833230156, 0.9118263461993169, 0.9525431849999824, 1.132276759515032, 0.8644668802800217, 0.7949143014509619, 1.0087199819560906, 0.10592777801298879, 0.8234839758095089, -0.3237665047273779, 1.0360481642988388, -0.1253517414460147, 0.5013106079987205, 0.0939988495215455, 1.1035037237297387, -0.03997029975417874, 0.864460345095899, 1.194899664955148, 0.9160583789756557, 0.8370703595446193, 1.1229777570537256, 0.7835544476092288, 0.18183187830395894},
    {0.2873419605627689, 0.16770452428438673, 0.7222936257494137, 0.03246421964280058, 0.2932176658334918, 0.2351718363887508, 1.059419843971504, 0.9134450699242199, 0.8514034047636233, -0.2227011537364653, 0.8865331412759516, 0.7364225117617756, 0.9285369789440032, 0.6674406215196274, 0.9030153111780295, 0.9209006561343192, -0.14001769508356304, 0.7297150090293038, 0.09065428245338639, 1.0203201634599404, 0.12262843166441334, 0.5657352533322043, 0.39417901303664327, 0.8164004051565887, -0.03532128876886354, 0.8978558578127818, 1.053460094025129, 0.9830864592204459, 0.9774710515420381, 0.9983219793580972, 0.8978460743581904, -0.04507960458551434},
    {0.11674506204223356, -0.2866676706674268, 0.7016005226688615, -0.1920659918205174, 0.28302517961087464, 0.5576823220588512, 0.9286603106309032, 0.8501566116841359, 0.7252790512016735, -0.4694398750933224, 0.6910108021147696, 0.33442975605043385, 1.1037785794850263, 0.7140837195350248, 1.0192380606934788, 0.8291976964001279, 0.460766456161634, 0.7343052560227633, 0.08605469391511564, 0.7784434477999449, 0.010111613994885445, 0.5749743459276635, 0.15772764213835314, 0.7683603294299299, -0.15014410401687064, 1.0729659350827323, 1.054440342254018, 1.0275375190573932, 0.9288595503566337, 1.0053613577278113, 0.8785444905142163, -0.021073968659353876},
    {0.5262430027893814, 0.024189446455013475, 0.7390503893008743, -0.1164860541584177, 0.24093238621352528, 0.7937691676614371, 0.6346490902017303, 0.750433893570879, 0.9054422664915225, 0.16980075633642736, 1.0350943708489906, 0.8804844637326409, 1.0391506411051372, 0.6806178656241236, 0.9562746566543036, 0.7906525447977862, -0.25203046651014505, 1.1923658129786396, 0.09464357302887502, 1.1520178447573033, -0.06391098238465642, 0.6062576048006513, -0.16297548515896138, 0.9515373253600783, -0.10577964835827021, 0.8018563091527724, 0.8532008772133917, 1.1219716253374117, 1.0121024171947879, 1.0385380095172496, 0.9272654810584398, -0.11152091425782742},
    {0.5541250141478856, -0.15141951594779102, 0.43012128374569103, 0.05900620965479342, 0.196385660987535, 0.09191119576231462, 0.8408093957371693, 1.0163895768390263, 1.0175846254535508, -0.3792808661942753, 0.7514340138342227, 0.6898530972901293, 0.8151455372792468, 0.9927355695725683, 0.8801245817037522, 0.5699194799497667, -0.14194741867725685, 0.6204564893554225, 0.05932959512650194, 0.9779291625147047, 0.07118864230169955, 0.5653633116977713, -0.2740479776569138, 0.5633035664891006, 0.012548929265794338, 0.7057636739872821, 0.9927624544898274, 0.9829286583202126, 0.7051890109404042, 0.9647293325075625, 0.8844459604652958, -0.1509485560923985},
    {0.5848560331714823, -0.1392640621518121, 0.72812345754378, -0.21848465864545208, 0.42477251729668886, 0.34002686134464494, 0.8286589351957293, 0.9688796930997675, 0.8832912930094605, -0.4447539145242195, 0.7257950144498936, 0.7239724543672924, 0.7536262153665019, 0.8802698139483303, 0.4167312379113576, 0.7444670542471803, -0.04958351582673262, 0.9933158619105869, -0.27092953802861813, 0.7805160353048969, -0.0004931680701588127, 1.002877589492453, 0.26506739345740554, 1.0048208200947364, 0.22354104962140015, 1.0556215242749227, 1.0675169801296542, 0.7241802180965669, 0.8379953362319635, 0.9388277128318352, 0.9264981573767423, -0.37879864963660714},
    {0.4809077922311783, -0.3760245432014125, 0.9166597661311933, -0.05727294437190613, 0.3027578865170483, 0.6556460191574194, 0.9447377417562631, 0.9751586801139358, 1.0768423586731513, -0.20140101335456503, 0.7709841597614707, 0.44202561321555084, 0.672546646371116, 1.1841372852328977, 1.0156513823172422, 0.8613044866292215, 0.312023063508539, 0.7382011043560449, 0.030719516083979357, 0.9851507557220348, -0.056983328584282615, 0.7123974026272398, -0.003850423012639057, 0.8009488851069062, 0.15283207791378947, 1.057911256610949, 0.7133242931330527, 0.7409924192588995, 0.8443444115780198, 1.1503169813734921, 0.9703618945278252, -0.14953091481879965},
    {0.3109153946127719, 0.028809380067015705, 0.8879690474220225, -0.03570873332957889, 0.26723798904169094, 0.4508391842411195, 1.147494432930255, 1.037187830011925, 1.0674320488904223, -0.19908610346685068, 1.306205167536505, 0.32936745813679813, 1.0043780385853385, 0.9213432547302018, 1.4277250776651387, 0.9949277264787891, -0.03861970970951587, 0.9881984982626364, 0.002809497734795218, 1.1422568600330394, -0.019435835135894697, 0.9473331804297052, 0.07848035233294993, 0.591079930515597, -0.08793048282695269, 1.1276891487124174, 1.2847157521319168, 1.013429557053674, 0.8234598793457887, 0.9863860605606521, 1.0599965299998324, -0.1521856026213977},
    {0.7861286553431244, -0.3722235481316655, 1.274144138102822, -0.06648757389092298, 0.11653899473367564, 0.5525512465111301, 0.85043540319789, 1.2204866035357496, 0.8037039818829183, 0.03475414551398613, 0.9200740552605766, 0.9084050475089372, 0.7744997711269965, 0.9615368316357575, 0.8340865193936774, 0.8568359668085598, -0.16440430006262938, 0.7671247934042338, -0.25529443024703236, 0.7018975792386712, 0.1042870475903974, 0.6339176904276669, -0.11442910019117561, 0.5612984683528859, 0.18903986612320006, 0.9039256958915449, 0.9973748822945269, 0.8313890580730358, 0.898432203282344, 0.8186708724088423, 0.7731635233450005, -0.16234558129928944},
    {0.36154768361690487, -0.027384147488725332, 0.8240197607728943, 0.1402970251899174, 0.3595173843987961, -0.0926892660974485, 0.55261850859214, 0.9876416927352886, 0.9521453135185962, 0.044667464115638954, 0.9611148222127764, 0.7099775261067959, 1.1642873572773724, 0.8591986434347528, 1.127747989682796, 0.3484283716829805, -0.07256623163538789, 0.9583270987711996, -0.21480140109728146, 1.2047505300154882, -0.010861806247682553, 0.6408691694339033, -0.12076887531263396, 1.068184901194006, 0.15877682228957127, 0.8023438626990395, 0.9557074396396069, 1.164551150885443, 0.7498473836226243, 1.1896899082004844, 0.9634988994703294, -0.13794375427369934},
    {0.7664790406985449, -0.23461144619895472, 0.6022042582831543, -0.052200788177010356, 0.248375914654289, 0.11961951337228818, 0.6221246686019095, 0.6231435665307719, 0.6454204515393647, 0.15220006028377966, 0.7988628212586233, 0.16889083602213106, 0.866114706418497, 0.6725193646427063, 0.5776284423812148, 0.8415711383403611, -0.20051122106077413, 0.770994226552055, -0.1054027575663086, 0.8678548128066146, -0.22480567528846113, 0.6564400180279495, -0.15609272747303027, 0.8825279238122037, -0.3135107417322465, 0.9522672330931709, 1.1163493566850275, 0.6915617248070481, 1.023168088789566, 0.7275938942756616, 1.1174272442217403, -0.00746233486289162},
    {0.8340062437455646, -0.21849472209783657, 0.6281288909845927, -0.1448281924391482, 0.5393775654483848, 0.03344930870721379, 1.012360549138471, 1.1877095817709202, 0.9070096965112485, 0.18402240460777405, 0.7842576691257807, 0.4113837042292512, 0.9383130881585205, 0.8006147099485708, 1.0194783506073488, 0.5647944666331913, -0.017417315893964933, 1.0504721136627881, -0.25898117428865913, 1.040234859392611, 0.002826928176037238, 0.5234543065222889, 0.12148648364324935, 0.4994625953507363, 0.049508147543605864, 0.9721606152839786, 1.0702077030042845, 0.9159169044033139, 1.0899766963953237, 1.287245923984021, 0.7995723423880297, 0.09521602254469692},
    {0.02221177776736544, -0.17521042878462484, 0.4510658810671611, 0.047493279786006766, 0.18032207728912697, 0.6107107433994701, 0.9378488112727453, 0.8768603643580404, 1.0535704839415636, -0.22374963910681883, 0.8938196305305062, 0.43772823329342136, 0.5924237617428666, 0.6172445207712992, 0.6304109491166481, 0.8467182442030141, 0.0929500001559435, 1.0673100594164182, -0.1825354923038721, 0.766591563609296, -0.14658657719923107, 0.7534727216958442, -0.2112327330313508, 0.5462215417717309, -0.07519436711973647, 0.7403984469547367, 0.9706529838889334, 0.6267184433719764, 0.9132627696789821, 0.45827603288740665, 0.9161012096391601, -0.16928034103756742},
    {0.6087193340076801, -0.08126579248018027, 0.30775372900489256, -0.2025499028266311, 0.014279644210271418, 0.6759470364466881, 0.9619382683176748, 0.6659327913739603, 0.49820822054488817, -0.3239849140417445, 0.7969730327312261, 0.2463675033603471, 1.0736476377385737, 0.7001936511181233, 0.7109163832720996, 0.48019683791518336, -0.1632603458968996, 0.7871988812147093, -0.057942632326994176, 0.8189953135918403, -0.09214734894089008, 0.443723730449753, 0.09640919150850864, 0.5664437004152837, 0.19379477094007408, 0.7845167144133554, 0.6960883202756243, 1.040767878714227, 0.7517668624632718, 0.9795791397539251, 1.1918492581066058, -0.060163237991898794},
    {0.6739699510551271, -0.12711502200949473, 1.1716275001639687, 0.17073637018074717, 0.22732283015207386, 0.44972224987486875, 1.1169813418640546, 0.8534487144092842, 0.7590531335974113, -0.15380710104949902, 0.8391282329054484, 0.7454385557121785, 0.9129270091929758, 0.8435868631902954, 0.9369030333263909, 0.9656210473106113, -0.060389943622022005, 0.6506724436052608, 0.13855620976114677, 0.9789909224747932, 0.011417480482901315, 0.5312269077351052, -0.18560493001018608, 0.5356318769941717, -0.3358964118049461, 0.946807418127956, 0.9634494507914972, 1.1664866893527692, 0.7679314657956068, 1.1360446928756536, 0.8608982405281888, -0.12468124009547982}
};

static const float b2[32] = {0.5976778805806303, -0.06042365001272372, 0.7194536784824159, -0.06600005934538472, 0.20290167722469607, 0.5230415825369992, 0.8321703520038585, 0.8418559223812689, 0.8890555481843847, -0.0499917542690035, 0.8373616088119247, 0.6684611770685327, 0.8758939670062033, 0.8722957784551663, 0.791331686365838, 0.7384673423325084, -0.07570440285230655, 0.8705278232129016, -0.0357628764161496, 0.913800059250874, -0.01688618251005007, 0.6958072410455869, -0.05081016652363722, 0.8375148666148287, -0.07819237604330406, 0.8406796361746014, 0.7989022512077107, 0.8551060260770689, 0.8521990372227438, 0.815526557051848, 0.8494648476126745, -0.0380759088261903};

static const float w3[32][16] = {
    {0.4404539638099732, 0.6923122359162468, 0.6822546684000181, 0.47253078719489355, 0.321327665492034, -0.22873757358594773, 0.8490688094820195, -0.14436414971446515, 1.0054581467640946, 0.08966727994359885, 0.5548323538541012, -0.1358868395206244, 0.1827032162544399, 0.1634566656784543, 0.8226607265471932, 0.5772103329664222},
    {-0.10633632009273626, 0.09705985282139462, -0.34681498434885943, 0.21861257791116007, 0.12492145996860596, -0.10320080736483923, 0.02675242250981692, -0.008685025676414698, -0.15921129710943946, 0.09157705694335598, 0.022141738319932353, -0.2786703644438926, 0.0017444703689854235, -0.15058385940766905, 0.16291923477764955, -0.05028267917046322},
    {0.7253050195532034, 0.8669483799803981, 0.8933329942843892, -0.17957764542191465, -0.10772437785804971, -0.06102484625673329, 1.2340451170780706, -0.07790078650103432, 0.7974868405523461, 0.2173068687694876, 0.9777163487322572, 0.2006662380299959, 0.23961288239317335, 0.07142374872963551, 1.0300311817643504, 0.8742872980374516},
    {-0.30705211027216434, -0.07325590025282158, -0.012480588095914109, -0.12714840386253898, -0.4655043359767904, 0.39722271484599286, 0.05960532281209118, -0.229476302302015, -0.33576628731690794, 0.4536300103330529, -0.25456736869834007, 0.2487289220681789, -0.5696680093582592, 0.33138409704372834, -0.11088126807039213, 0.0018182332636308017},
    {0.3470824335445109, 0.24292864678261286, 0.70703850104494, -0.26301470355542833, -0.006527541313451236, 0.3044418274444756, 0.4194463047930639, 0.10384953875745312, 0.3835951586346117, 0.09311172616188133, 0.6360957672725936, 0.07774152791588279, 0.277337263652862, -0.0837791793819187, 0.5106229695950215, 0.08165464990573267},
    {0.9735998733876511, 0.8491478406448317, 0.389343688923357, 0.22146627198959176, 0.05388218526334036, 0.2723445806973113, 1.0297085660941308, -0.11411676631625503, 0.1330437571328187, -0.08473824176913074, 0.8131370607392543, 0.12794484231146772, -0.33476760008564715, 0.23085725636776314, 0.6340128361656211, 0.7268563486660623},
    {1.4184196500039143, 1.0156508896524077, 1.0173034110608912, 0.25155518327480164, -0.1856135072684648, -0.28013491568121385, 0.9244246324843853, -0.21073362635308812, 0.9564644407848205, -0.006782332623211483, 0.7483229516786613, 0.07871113569183506, -0.41102605167018885, 0.2900578417931038, 0.6747877857693203, 0.8625759373028352},
    {1.1120092239884538, 1.29514133890931, 0.7496617500825685, -0.08181241383185543, 0.12834407595843877, -0.3607083581447471, 1.572211340373466, 0.17399161835214397, 1.1593297458706586, -0.6796612357344815, 1.1281268246841234, 0.01557225396381284, 0.46668688788914514, -0.2612828063363999, 1.0315418267622047, 1.0817018656898687},
    {0.9409207642680953, 1.157827758203705, 0.8506704555661471, -0.265353748695994, -0.1791465859404793, 0.0735495634476892, 0.9032663879753198, -0.4107176345762092, 0.8188698717037649, -0.45993945159334604, 0.9669048825974923, -0.22832431110337426, -0.19330294092160571, -0.14670801892752947, 1.135362067894312, 1.1967768116904016},
    {-0.4688065295003371, -0.4074492293415349, -0.32277895221752523, 0.12766829394187917, 0.07779537637484525, -0.038575628198860595, 0.45799176407772896, -0.05408783073216549, 0.01573189438401914, -0.34670580095740516, 0.6719716574718435, 0.11096675446304577, 0.3709389430413261, 0.3501860951492874, 0.21177128474753726, -0.06515097862657973},
    {0.7697446399429261, 1.1409121994111877, 0.8464385529407854, -0.1659513471446132, 0.386746337234138, -0.307469054067395, 1.0730209533786734, -0.10095112255227476, 1.299530449892579, 0.1863196968907034, 0.646483467947311, -0.33991721488382615, -0.28908760378170606, 0.1969792738035392, 0.4242818918918228, 1.3021221825704716},
    {0.7860386243284774, 0.9274217827223, 0.433262924449786, 0.26010562749597577, 0.20812070470879637, 0.22115276646275886, 0.8081379247199959, 0.26093021122119525, 0.9581859807410529, -0.053227570203986586, 1.0346980541964084, 0.27118365569612773, 0.1740167462016592, -0.16635350183818354, 0.40762891233530946, 0.4418704595652686},
    {1.0535500636119433, 1.3516437224413036, 0.9352937370367415, 0.18155929299655857, -0.16531977133102002, -0.16102636243755022, 0.780992770926592, -0.31498651009921685, 1.2063209556720456, -0.6611158796846903, 1.0982741948337598, -0.11571278889286091, -0.0703553142391587, -0.1765052587595246, 0.7927932350845787, 0.9065972924857323},
    {0.9012945417502347, 0.8557183569845132, 0.8596155255201602, -0.494103524755804, 0.25101492226699507, -0.28379471271577056, 1.2128392959704732, -0.3080931685697416, 1.1598670196496383, -0.4425152566134764, 0.9127114799972977, -0.2828922584222805, -0.4093044509712822, -0.2181288715242896, 0.4910968177952554, 0.8322710276411326},
    {0.9153381668916463, 0.9333580339495894, 1.3378540229789095, -0.4627514073923429, -0.07044253428313275, -0.03513293397928906, 0.9731728333393789, -0.0982713038725206, 0.8070887337433713, -0.09604378071697194, 1.1069089023725807, 0.3385734308620786, 0.22718053474439007, 0.258573652850426, 1.023509855419752, 1.1935015655661332},
    {0.7339143389465985, 0.7781996070891248, 0.5398634835280218, -0.030997306114553452, -0.41914089531689314, 0.07092109787813786, 0.8843799447434496, 0.010684677792982041, 0.6875672908998283, -0.07717468696779939, 0.7704922555439205, -0.10316181201797628, -0.2592306186437647, -0.27196612298516887, 1.101441450856716, 1.089646221428666},
    {-0.717874402300972, 0.042705341401817934, -0.3235549877912041, 0.21887833737504506, -0.17503970204789748, -0.09346884389811454, -0.06869707090897385, 0.3706630311069055, -0.37904931113681767, 0.011427308956096472, 0.2941348588932108, -0.25516813724093834, -0.3118893805687893, 0.4125136265287486, -0.21151547914982533, -0.10207565137950929},
    {0.9822000941890359, 1.2778919998114313, 0.7084254448605405, 0.04147560399876255, -0.4034416577666049, 0.11562795808703014, 1.12776669598559, 0.11264595118980937, 0.7910085104548675, -0.14219241107243907, 1.054906286738203, -0.2735518313647355, 0.39054692513260364, -0.14321954117173305, 0.86909834968087, 1.4683284418526374},
    {-0.20082046388331562, -0.04410991941316037, -0.040449012303417964, -0.00771759960024744, -0.1265312876266866, -0.06552680825690523, -0.001138838193111819, -0.064595972374062, 0.23242488011793258, 0.3117664369091601, 0.05860302009012498, 0.33074296420749855, -0.27601518580072437, -0.12960085312820124, 0.07106660402394528, -0.24549750684104538},
    {1.0271536844110851, 1.1891050999818509, 1.1963702021411442, -0.5488817853729188, -0.3163118786418827, -0.1266017095426594, 0.7861930718285135, 0.19037680038680932, 1.0836940268869646, 0.2911275611377792, 0.6332892566114572, -0.29054576012391364, 0.39575053720103964, -0.4205832050059953, 0.7648439867476998, 1.1261207787556358},
    {0.31638152081060145, 0.09715023528523756, -0.2545782431114289, -0.17645258256567353, -0.48860719217805715, -0.047833407516402346, -0.11766723834903549, -0.03397643245913736, -0.39786428155373055, -0.19455308983195996, 0.07928390523810115, 0.01844963311712146, -0.24503873857103553, -0.12402696707317613, -0.05825203260260816, 0.28674618707758304},
    {1.0952971818065667, 1.102127667972239, 0.8856664951825799, -0.07548946377179881, -0.1953043831872312, 0.029889033301652414, 0.7854471456313799, -0.3452948205009896, 0.47549870666535105, -0.5471034982543792, 0.6384321837268484, 0.2315318976438633, -0.34278838759421104, 0.16555179969956088, 0.8153953156977559, 0.6747382050549765},
    {-0.061859947592524805, -0.03317133666238937, 0.15695493527049784, -0.10033778859264612, 0.17885495313000804, -0.23479104505933499, -0.33009406119741064, -0.07779581987884104, -0.4570690412932144, 0.08127602358634989, -0.01481898823152962, 0.004405801507184088, 0.4688525282448301, 0.2725398306073758, -0.25737054157291134, 0.2843649545736423},
    {0.907261646747083, 1.0657580689462094, 1.1664597140437523, -0.149833997919555, -0.024906603103141155, -0.06106408585046222, 0.6332395654379267, -0.19502536725144354, 0.9135531657035477, -0.19124146388636518, 1.2361556843556192, -0.022198894966459347, -0.1405121464547639, 0.3672869326426462, 0.8961100188664929, 1.0510076824371377},
    {0.29669991838751353, -0.27770742678039473, -0.3900562249342685, -0.13318730599547246, -0.4860543485486867, 0.18548737653816372, 0.2912789464884913, -0.04063991724270343, -0.09102291387085888, -0.30832849567233944, 0.07816085607410737, -0.07707619282531954, -0.09343512910700197, 0.2963625581580498, -0.1189615424950837, 0.10060939886727359},
    {0.9147778898268759, 0.9933912594122027, 1.0806084670280245, -0.16851162843008669, -0.285627079952256, -0.23752114567249263, 0.9447461784906995, -0.01933601741119404, 0.7874942794274441, -0.15255155313422367, 0.859954143978716, -0.08557578370651217, 0.10459252311672135, 0.24884534133654615, 0.7370389948122538, 1.1280264006364307},
    {1.16649592185604, 0.8629696186845158, 1.4079645374663747, -0.5762349698868877, 0.42983704139942097, 0.27607258094710047, 1.1544845756352424, -0.1957991319446454, 1.4707870642899372, 0.15906809810889166, 1.210227134835151, -0.20172090276259091, -0.11336318601282777, -0.07320737283814169, 1.17893904028785, 0.8291574536984565},
    {1.0092063410683625, 0.8966383523890535, 1.4151697450772904, 0.2037062285948392, -0.1917322596249916, -0.08732966446782404, 1.3792510238767506, -0.30862033537434524, 1.3617681683519853, 0.3253804180139404, 0.7065829127186194, -0.02455756226234516, -0.3310467074972909, -0.21331387697270116, 0.5170600213397331, 1.113918570176176},
    {0.9487140785747699, 1.23485897847429, 0.656464852311724, 0.3527687030570766, -0.05839994259256188, 0.22065687261403, 1.33786415564699, -0.19450469158144654, 1.0953240322298463, 0.14632020281788607, 0.7483487553785373, 0.2120669756706921, -0.13722458557525208, -0.18273453650722565, 1.15659904950399, 0.9217817490392888},
    {0.935221391593064, 0.8748962770767098, 0.7652019808701562, 0.2756677581721661, -0.2949020418807488, -0.015067463369154748, 0.7986072209687837, -0.19176018694042452, 0.7963884014100042, 0.18211885861469598, 1.183250684995919, 0.22049663685594806, -0.09434321904150732, -0.3111897884712192, 0.665777676136848, 1.2383369600734186},
    {0.9759660448173755, 0.9242528837385695, 1.0067855077595673, -0.41006636327729584, 0.20482375089536037, -0.10024091840066196, 0.8925045277015933, 0.4661241308381344, 1.0432526296721991, -0.0334017300630193, 1.0636734455732566, -0.13823010669740932, -0.013434363211762583, 0.06783849106222874, 0.85160144093623, 1.3839101886522798},
    {0.21920186262697391, -0.2977485910933288, -0.03279687713450574, -0.12108896238040374, -0.06504066235349329, -0.44128131340748966, -0.15843044986370602, -0.3872564411235157, -0.176379112392649, -0.3392308759364339, -0.5074931288961012, -0.20330992376810367, -0.059017892677660125, 0.024854729549130594, 0.12891481047868192, -0.3786598092111622}
};

static const float b3[16] = {0.44861291631700184, 0.718482913647813, 0.6723560747678924, -0.06970965032459034, -0.07346943217499126, -0.027992004058927503, 0.578127214065474, -0.045552444139578714, 0.5919905424633602, -0.015613520575494413, 0.4897113885845931, -0.029779021265486316, -0.03594278361891195, -0.021505107153871883, 0.7062071749601407, 0.6128870733003314};

static const float w4[16][12] = {
    {-0.7169308034641748, -1.1541415051732948, -0.2940573843506022, -0.3089297326533446, -0.43220221846810314, -0.2521351458512272, -1.5923723139641688, -1.2512970440990565, -0.5088900318352844, -0.5559876425431278, -0.6081798364464716, -1.2575220057557714},
    {-1.109324672516844, -0.4975983482366036, -0.5629720169143969, -1.1191604667627826, -1.0888918560628724, -0.756079427824082, -0.09308966091963244, -1.0073462175806822, -0.9891516317608052, -0.7834774945876091, -1.0951425983485528, -0.3531341350776113},
    {-0.5065836903925326, -0.8017912046200913, -0.44173214538147243, -1.290615067781817, -0.49461602616001377, -1.5049588450278524, -0.5037217050970694, -0.3201152302348324, -1.3180161387112457, -0.668463125410932, -0.9127637698256945, -1.033652418591087},
    {0.40031299080522026, 0.8466695247055083, 0.7617712742521726, 0.15313924885522434, 0.517836998549545, 0.32921415114009706, -0.27422550079545854, 0.1322173497216957, -0.287480660785689, -0.16674988129192994, 0.42303332624079376, -0.6249116273793792},
    {0.09404079059945626, -0.4921605424559466, 0.021724986396424673, 0.4263414465917744, 0.5128791615946331, 0.05517748836672426, 0.4806462624564171, -0.01822319366150518, 0.5653117949972142, 0.1171826723491705, 0.043512524521872736, -0.357122472328598},
    {0.10738310310830525, 0.0231739424187297, 0.9838451025329676, -0.23509418529254075, 0.07126989880117507, 0.5419313527446851, 0.4845473879055771, -0.16572342155130715, 0.2392506906699286, -0.021452957975539328, 0.20385329907017363, -0.2571325939280325},
    {-0.565577389287776, -0.5600674753629182, -1.137989737529614, -0.29608171728852795, -0.8136810105912384, -1.0727803970516678, -1.1457813621280335, -0.14593352975567767, -0.49985757565767563, -0.9150279329952097, -0.5271410739346784, -1.330557697570349},
    {0.11167957468653451, -0.12681277311627787, 0.10229286244263595, 0.8951657774730948, -0.27818932051496914, 0.6425628161898194, 0.6116974932329872, -0.054400842925407686, 0.25086870165778935, -0.39242527090592133, -0.0035458953615529667, 0.6724888188485731},
    {-1.1364014560219267, -1.0618662229664395, -1.8267055396391012, -1.1136652814211394, -0.9388010295224789, -0.9837415122693324, -0.2164323645602456, -1.110427526149995, -0.7669209632901094, -1.189469399516169, -0.3482270768976314, -1.0018909659555815},
    {-0.11875424945472052, -0.060686776210725706, 0.2142181556573715, -0.07329616976143312, 0.09361252562901831, 0.13336612990047247, 0.08236117266607215, -0.3470106103340308, 0.4715098694632515, 0.10065377876742412, 0.4098298664908507, -0.23645407438150595},
    {-0.4133394599424249, -0.13562242466716704, -0.9178331798337414, -1.1942430800061508, -0.6616200727497078, -0.7276913191633798, -1.1886803199025011, -0.8105818104939684, -0.37912951683955215, -0.30188932372052185, -0.7897642236168774, -0.40117864447061163},
    {-0.8234037613783517, -0.3709692965121049, 0.9160905193676511, -0.27968841833698016, -0.2250320760817752, 0.04039923314322136, -0.1368183512927378, 0.8467478042065252, -0.08755945830185574, -0.05290400918180999, 0.8616013712890653, -0.345163791770783},
    {-0.06544810829777699, 0.6215051244434825, -0.20455090974688755, -0.20325453074049246, 0.3805052588939916, 0.3737766522762582, 0.7160666617651461, -0.0946863923843252, 0.21203904605216392, 0.6005630570011931, -0.02336998821717362, -0.5238759458025807},
    {0.37768503499650263, -0.11323910112307484, -0.0685761797163095, -0.1494912864016804, -0.1316222589781499, -0.1268812547000816, -0.38106121737012516, 0.31529453609461294, 0.5672648371955166, 0.3636306492919617, 0.316384691714121, -0.1702040498883049},
    {-1.1306603865572358, -1.030785064062708, -0.37318540594245264, -0.24180116394756457, -1.2275000974988193, -0.6116742532097406, -1.1558399545061344, -0.68774104747501, -0.8162881093318097, -0.6183474949366569, -1.17655509155355, -0.3477859881518464},
    {-0.8101084432759431, -1.1503363445566563, -0.6927326145571507, -0.723655595849674, -0.7295804443255253, -0.3995367292350551, -0.5419428886351981, -0.978828467274303, -1.1007680050259, -1.2586949760406358, -0.9885085656609458, -0.5525716853531164}
};

static const float b4[12] = {-0.2069372569425062, -0.14545147505106804, -0.3588001658397766, -0.21185340940428926, -0.22531410037963226, -0.2099275583464103, -0.22634327357574735, -0.2883577429680704, -0.279593630983869, -0.31164571592668666, -0.2146771977462873, -0.32262153022627055};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
