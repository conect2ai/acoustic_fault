#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.4784208984310679, 0.24508582449565522, 0.6382010966215031, -0.28284630479185335, 1.156047025056323, -0.9875867402198231, -0.9756033467824433, -0.40782863564556604, -0.13958812495029366, -0.7997164657751773, 1.124225931344985, 0.371702858262053, 0.5750312396286789, -0.3247527414918486, -0.7353280365244218, -0.14349475234952955, -1.105969396423299, -0.03496052768746497, 0.6467286016764592, -1.4622493567906243, 0.8104373975241468, -1.1936383540144782, 0.6248419324692892, -1.208703856772464, -0.840994457173555, 0.3884937494929555, -0.15162512133883901, -0.6907958596103223, -0.7165596383521503, 0.5431833753935602, -0.33800894472189963, 0.6131306728321909, -0.18373675643301407, 0.4403615060471484, -0.2768925634645409, -0.726855084254221, -0.4598349840834659, 0.8871945061941185, 1.0475771054609238, -0.6779405594041354, 0.05155358409397412, -0.9772247144584867, -0.9821031959323788, 0.601755373667342, -1.3169420316966234, 0.32558584516311345, 0.2219635730064011, -1.084315101271872, 0.788905408558023, -0.5152661905691399, -1.2827539843418339, 0.5060187611563065, 0.7013971441943058, -0.7122765174226819, 0.7139800847485539, -1.1831183627988724, -0.8531622734128372, -1.5616030118246227, 0.49474850745050725, -1.2674959252094438, -0.011075277060552814, -0.28988059052453724, -0.3838192284908744, -0.09563824860234742},
    {0.8405246219793437, -1.0898579104494168, -0.36596253215547103, 1.187102733739844, 0.41881880061682125, -0.1775624732865582, 0.47988655000888775, 0.6314798751104829, 0.37934600024082965, -0.13536169544970225, -1.1988830589606332, -0.7108397577868231, 0.6676333792875513, 0.4397304880483613, 0.396986975062483, -0.7384295743261714, -0.016691043106397484, -1.0600268615688766, -0.8834274478439957, 1.4581481112619818, -1.395451199684335, 0.9420511242166482, 0.9325695174744136, -0.8181655184549698, -1.0699850206448238, -1.0508489242690733, -0.3370952091812576, -0.2997696333552565, 0.9476633322093001, 1.572677799653768, -0.4350895208821165, -0.5144189719722219, 0.011976721579628626, 1.0322134434255426, -0.42224164139228826, -0.458569813286283, -0.44631035520382367, 0.8313830525554942, -1.3970942176679184, 0.07468882178028205, -1.5091354661475638, -0.05357963922449357, 0.5010828124849432, -0.7206628430660096, -1.0213755613306406, -0.5249001927365475, 1.068440251247849, 1.3125087937027335, 0.1959450940654395, 0.9837782321173567, -0.49279148740225404, 0.10031261496374551, 1.2626010441722824, -0.5858225898843433, 0.06756652019167496, 0.9366762094861131, 0.8846286556178193, 0.3404002348105766, 0.5460986037946257, 1.0114116555931991, 1.0284221200332604, -0.7259771718139751, -0.5489785261062117, 0.5150260388435302},
    {-0.9012590020746836, 0.47319363903339645, 1.0301361090895516, 0.8767048575456586, 0.11175565262179835, 0.6648464910450539, 0.2644873399364979, 0.1817484326801492, 0.921690636717179, 0.9694859654758371, -1.3424233067052322, 0.11905401600563913, -0.5212221523623406, -0.8792858016340718, -0.7241522259679777, 0.7769900130809781, 0.24925321325513272, -0.16557458544642278, -0.006271644773606237, 0.9695598934037458, -1.170758600294236, -0.7097500212950184, -0.7803849667025998, 1.038260201596531, -0.4355388639461269, -0.056403485414679135, 0.6775207877976995, 0.8395910988629798, 0.814945599209518, 0.19268532377751585, -1.0333755966401132, 0.292515394250683, -0.34784103679994205, -1.2160153520543773, -1.093181869594774, -0.8736978711210451, -0.20822250206350318, -0.5461681305056868, -1.2467949440425206, -1.4049404016885345, 0.07122072881871992, 1.2607090274727741, -0.4088387686771082, 0.7701699755741662, -0.5560131137696767, -0.1608404632380781, -0.5763201772899298, 0.5319960647504491, 0.15330698260533912, -0.11440245859278254, -0.5995674377704445, 1.2448675233894622, -0.08924074931400477, -0.8585656075954693, 0.6183774736241595, 0.7557017317340966, -1.3424691575605256, 0.2257820844304674, 0.02102327810952852, -0.3846138583429766, 0.3436641253122299, -0.8580195249397348, 0.7748076664290164, -0.5415894041649296},
    {1.2304277008797833, 0.7322316036548464, 0.4468326705750942, 0.42231715629665023, -0.18107111217623548, 0.419620503376405, 0.751126284886261, -0.6180729926898785, -0.30705672657476524, 0.1531627084683971, -0.5913489229780189, 0.57029628217321, 0.31887658152797066, -0.41817812839736235, -0.45644306910034194, 1.5459423675157857, 0.7694485504457085, 0.48774341568493856, 1.266718067795388, -1.3363209742484161, 0.45644310567810936, 1.263569954389891, 1.1385042435773154, -0.2997149953068535, 1.0092144499678621, 0.3802658322969028, -0.1577950958501165, 1.080839482888881, 0.5047362949313927, -1.2322793204905464, -0.02473413728057371, -0.44276034808224196, -0.9767583953804206, -1.3004405328693573, -1.4876901686149595, 0.4801370825466598, -1.2460176817432964, 0.6028372070870538, 0.37400239647587713, -0.4955774221178153, 1.3939316002759798, 0.6904567343534677, 0.3729931053966986, 0.7146869561298673, 1.123333494036523, -0.24434809154810905, 0.23254545575651978, -1.067222993037892, 0.06354256154188827, 0.260945898303428, -0.6276038006771559, -0.02259782515327458, -0.851504595074102, -0.8748177276643258, 1.4480894345537914, -0.12763534088527073, 0.04047829958546171, 0.033717947754594316, 0.9419495639916369, -1.324452570713567, 0.868349916514421, 1.0802649246507139, -0.8105424825105426, -0.9429470629093437},
    {0.6636722400685604, 0.7769826133866902, -0.0334865521068885, -0.48199268245624777, -1.4091610446726341, -1.0944968241702315, -0.5759284734511092, 0.04473985271043542, -0.07020957134865356, -0.8552438269273626, 0.7492934692606147, 0.1310736742934637, -1.09700857018653, 1.46688830003528, 0.7711967165253713, 1.2369812367483786, 1.405512168994862, 1.014246519964633, -0.10187610334040935, 0.1849940010083723, 0.22352369168240616, 0.9901160346425745, -0.8795096017380328, 0.592156071242075, 1.05272628243186, 0.05724162361831608, -0.2762940984402735, 1.2153080257803919, -0.13329392078299288, 0.5213907757723548, 1.0629575339801256, 0.9443993302574407, 0.18175599735179052, 1.1026118735109796, -1.0476415839641955, -0.7511639700250514, -0.3699408033611181, 1.2904388870052355, -0.7002890294943667, -0.09556716212474994, 1.2782880770402416, 0.615842866118168, 0.3051191211512408, 0.5647862377317957, 1.1268861321984633, -0.5308615055376813, 0.24424069339612192, 0.5961244748158947, -1.2948781638491864, -0.39821051729571505, -0.7427557564697628, 0.974330801459978, -1.4994138761080127, 1.1157681206295313, -0.3517255753716798, -0.6066460039874717, 0.6198271611897358, 1.5885945813061906, 0.5043946998523605, 0.2574784714974868, -0.7134005160901811, 0.9945386693252047, -0.9056768072836368, 0.7200344216767165},
    {0.12763064625076395, -0.6116061611129776, -1.1980835187125392, -0.3530362701209637, -1.2363518044904371, -1.0906072958724504, -0.2760094111091455, 0.3721673663548931, -0.3918997303221353, 1.1136889789851419, -0.23491077163059398, 0.18937520068808092, -0.7120432062454221, 1.324875930089632, 0.6635320159364159, 0.05169611282021604, 0.1529857809490715, 1.0848767295214918, -0.4483417010469561, 0.5233934918417379, 0.7689121774345793, 1.4573011451623574, -0.962528205896071, 1.3508162705517364, 1.4789988057999965, -1.0659447926132568, 1.3525300786767729, 1.4943786884783523, 0.7418106141671726, -0.5947184714442931, -1.0402640080585193, -0.8189638447395537, -0.49777184467948654, 0.8063180851045482, -1.0537183350779362, 0.36665486926432206, -0.42903297494832715, 0.6985685921609434, -0.7464698586763266, 0.4543996304423443, 0.15363676028768014, 1.301802714046634, -0.7386898507354284, 0.47775770166177656, 1.555303703577152, -0.719971033613497, 0.30348719635036253, -0.9468640624286951, -0.43922602311362086, 0.070444648555561, -0.10422229099167345, 0.4218137428970111, -0.31976105454338855, 1.6219228220102933, -0.020252235533787823, -0.8590828567609494, 0.6780579408006734, 0.37864717756501026, 1.2494320609778817, -1.284104991197489, 1.047983447378763, -0.33266843967690707, -0.517224194836256, 0.16271284802435082},
    {1.168668419160713, 0.8834049912340176, -0.5867548351198539, -0.382913897228816, -1.0503674199963253, -1.2933118161335906, -0.725914997084581, 0.9781905641022929, -0.7593491686509106, 1.1864351299878424, 0.6568440790124295, 0.6000618767435554, 0.5309616022232803, 1.5065712697771088, 1.4964699055114314, -0.18902580746002645, 1.345210214587026, 0.758343849081938, 0.15993565090845221, -0.49171005392423633, -0.43865121942489277, 1.2644582276962255, 0.9662887089984549, 1.719903217936056, 1.7255295054252426, -0.9226103080990486, -0.04799687370881729, 0.7568189334385095, -0.5215881997859207, -0.24247638727339826, -0.569861779905628, 0.1613622078530013, -0.2020107173216729, 1.3603670586039125, -0.03263195941406518, -0.39312116116325496, 0.13869717101891044, 0.7736635987758463, -0.9128639937099949, 0.8493117035269061, 0.021430020495783145, 0.9592841167448569, -1.1802432355341927, 0.766373959587651, 0.6291759231284848, 0.21251261554164116, -0.7129470163158097, 0.6136979557193668, -1.5203142013457496, -0.4020210554205927, -0.8740526280093057, 0.8756667797633808, -0.07801273844033119, 0.9104702782694057, -1.1062459726534453, 0.6497309307787937, -0.18837928287620054, -0.022801103807006895, 0.5047312129992625, -0.9627825055134295, 0.6615058751384723, -0.3194496604334398, 0.8746343226898756, 0.8927836411009478},
    {0.3875159779674565, -0.15427255414064012, -0.8630830645654228, -1.0867622532156767, -0.3474954791898812, 0.2192477777129926, -0.11490614324643247, 1.2574829457802614, 1.4612387604834314, 0.011978733519305883, -0.23519026591492356, 0.9263304899807199, -1.1122194168695272, 0.15081410639417753, 1.50937547887054, 0.8555972993868197, -0.23205813858531474, -0.0958870996666025, 0.5539159819707239, -0.30595283728581485, 0.28627311963589475, 0.13674680836808964, 0.8322652325070523, -0.625635126711481, -0.3892961357329007, 0.5522125210660318, 1.0610463469955034, -0.3954265974900996, 0.31551830094971306, 1.0444268701330235, -0.2931922965039909, 0.166202268570976, 0.14544720253524562, 1.4503299615811032, -0.2760212919644007, -1.2523747335108106, -0.6129751413608279, -0.7045505569448035, 0.920441081498951, 1.4045735125508811, -1.1892720122625713, 0.7395965697992604, 0.7621805864701263, -1.0963197631022048, -0.43419739506682015, -0.6747705881363061, 0.2539008772217713, -0.5907351224219717, 0.06878751229139803, -0.4481596286873517, -0.495741831838323, -0.3730769059595337, -0.7565031824782859, 0.36273829700784094, -0.33382667521233683, 1.1063653447904398, 0.5606311317345564, 1.5087416231630744, -0.27758548213663103, 0.44082369399987553, -0.12222891775031611, 0.8217639888748892, 0.7870364851182942, 1.624148394275341},
    {0.9573142015979506, -1.0368671351250682, 1.134435490863242, -0.8449175014728316, -0.029759324092470493, -0.023146900428467777, 0.17693379311924387, 1.1898665114355076, 0.739258170047241, 1.3470534866003394, -1.2551036880046553, -0.8656948400739548, -0.8680065656991262, 0.4282610976441419, 0.9685389459213978, -0.2433241511370164, 0.19412122004692123, 0.1923650845189676, -0.6497222531771306, 1.0413817278432236, 0.38460639611121894, 0.3090647354584988, -1.3135324967490096, -0.4831531966804734, -1.1690076253841493, 0.6839595499008324, -0.2403728841908042, -0.44895062050569506, -0.3556939262491304, -0.8617922789653916, -1.1853988673024132, 1.115087190999647, 0.25297414349505076, 0.5795452736181465, -1.0838546403742617, 0.32993782407637834, -0.1895781234634993, -0.18779763571648234, -0.4405103009372975, 0.9286021192169559, -1.1658470603618174, 1.5567894402581315, -0.9287204968954166, -1.1034092038122598, -0.002049383159745852, -1.154193849891966, 0.0032448879983265613, 1.0843963676108832, -0.15858965894929206, -0.8124139635763118, 0.7531747019350329, 1.3641702098406419, -0.35410622691895893, 0.640750797210524, 0.8991032034546399, 0.7997093056227872, -0.3381021978942349, 1.1132206111696024, 0.8213724792440084, -0.20538277973255326, -0.7420782711166884, -1.2055284024811377, -0.10483142094027109, 1.3344509412631245},
    {0.8821743255455924, 0.3612083964571951, -0.2816765241209385, -0.5103542355741656, -0.6051130392697057, -0.23317865770141716, -0.9645824992654563, 0.4288292779964045, -0.9898183686324329, -0.9620575706252494, 0.08637956085188823, 0.7023342362338435, 1.401454830454804, 1.1986719999248434, -0.27557262740547506, -1.3022737092075596, 0.8859363870801689, -1.0775664122258812, -0.577460828710342, -0.6965457880473619, 0.16211157117418676, -0.9071196632324601, -0.4276136479904777, -1.24405137854501, 0.7136922257844451, -0.3985428658641241, 0.2525826711615292, -0.24814560607550076, -0.7970555391635106, 0.07198131695993762, -0.2785060416904801, 0.08652503840188064, 0.10140946710016427, 0.968339520460842, -0.002733878397731991, -0.3359353514933079, -0.302701901525377, -0.5337853717765563, -0.1403193546787523, -0.36538940103443385, -0.14705382155577415, 0.4755618539385392, -0.23267899530524083, -0.9488826387875088, -0.031165518910826605, -0.4320018992945899, 1.0817967619287652, 0.9722390579293547, -0.5524459090664087, 0.6992124793825345, -0.5779181133530634, 0.5609661833630302, 1.077157941749011, -0.4813020578107393, -0.8578025821499753, -0.4323554944425351, 1.193819544724262, -0.362468849738747, 0.23047734021482763, 1.1684776787753945, 1.3480535846769413, 0.6794783915804424, 0.00012756194404819874, 0.6905435988030465},
    {0.4042215097125454, 0.14927194432782703, -1.0723775617346376, -0.16001854473346766, -0.7096773156782752, -0.2994604806608233, 0.9370330085463877, 0.911461698479352, -0.8718823177113416, -0.640749637297671, 0.37625153672358874, -0.3723933763022674, -0.35804694322169084, 1.0407055297498908, -0.7655218081864841, -1.2042311288157845, 0.7540110951160767, 0.9292125256726353, -0.2072022582429008, -0.5672104566024022, -0.7094407211759677, -0.706262864547576, -0.20531317139140723, -0.43525801469130315, -0.10092350272934163, -1.3603769068212566, -0.7040972417611198, 1.1539296192055555, -0.40813757967975095, 1.0031706748249025, -0.898254096660582, -0.49432057602321366, 0.8425108962910706, -0.4577476620227415, -0.45562527927851404, 0.04618633610363559, 0.3330667432401384, -0.4640816768691997, -0.22511105195882272, 1.2680142868376394, -0.7072885383362041, 0.5935655295316156, -0.1766322847349347, -0.7570371857738374, -0.7041447866747491, -0.9885784970724709, -0.0506274012254206, -0.5907907386944563, 0.7061424323633007, -0.018522424869665374, -0.10889642017070904, 0.07181488308018412, 0.24385731985254158, 0.6521349944954765, -0.3316786409513456, 0.741325216808488, -0.3951520079347128, -0.04709990602295721, -1.0081563514812513, 0.21503313855475226, 1.028913407451803, 0.9922748261780815, -0.8786272080672134, 0.07292904871934835},
    {0.2618078057075346, 1.14563634859123, -0.3668608141377457, 1.0817641895365635, 0.7595720492613323, -0.653905298873971, -0.10061111004143734, 0.8648954673212618, 0.06273543182982716, 0.527029055924851, 0.4561232398211298, 0.997961952186957, -0.7838502243640274, 0.8778055862692195, 0.26277279356012934, -1.3002362675865187, 0.40663776998265727, 0.6882882231677658, 0.49030524516036417, 0.8530894566381827, 0.7822953021523015, 0.05968511695376588, 0.8513375674160722, 0.26445215109625253, -1.3809344506102792, -0.847499684386979, -0.26396756991847914, -0.6875717933382754, 0.27448178927657474, 1.2668656339856152, 0.6048257649772611, -0.5565823097795913, 0.6277337276367173, -0.6583817648396255, -0.9151110758761036, 0.29705697960482846, 0.14743650348190326, -0.8866952407574336, -0.7104987993112265, 0.8194932578149428, -0.3026346650822215, -0.1280372859003422, 0.07668366308295048, 0.9280548306326043, -0.07574097070599328, 0.8505702990434382, -0.25423404164346586, 0.2816473796867068, -0.9677403848424732, 0.8487547530443326, -0.35814033632212405, 0.47122580521178065, 1.062188774843134, -0.7366361903303702, 0.3785845980682173, -0.5514267787397027, 0.6929299219407082, 1.0123236662647745, -0.8471853979572777, 0.896602403129512, -0.9361338665445197, 0.4690542924675386, 0.4095107137397362, 0.05863824236725727},
    {-1.2149459524961659, 1.2177998088674629, 0.0025190109518141907, 0.5867534981362612, -0.10480725408320495, 0.8117820477789445, 0.342966848402249, -0.7062940695318506, 1.074482688661945, -0.37785078090453383, -1.3772081023527798, 1.4628481833525127, -0.5639132474751034, -0.8092814255911848, 0.5185731859928677, 0.839022291330404, -0.26608380809312027, -1.0066490388070755, -0.9780112057664169, 0.25654925674265905, -0.6408296667645703, -1.3834800669077718, -0.20175410190138043, 0.13675316299284992, 0.9409328172811966, -0.02083323508970497, 0.5084844880374328, -0.9771546871528954, 0.41798308848240245, 0.02081795357417824, 0.574019448112897, -0.711624143100711, 0.841310894581148, 1.342686377991341, 0.7557396472359772, -0.5939456828501971, -0.34966217929201876, -0.32984101743696825, -0.5176559641324368, -0.06968147304415248, -1.4295813546967449, 1.4866122828110184, 0.09629950110608422, -1.042223767923647, -0.2087416369794801, 0.8734596605644981, 0.9096789828864994, 0.9739830204076875, -1.128565194651928, -0.9581057250184963, 0.35064532049539754, -0.5938224112526946, 0.9349095399734549, -0.24564093225745687, -1.4099755814844743, 0.70801873376483, 1.2289834157980366, -0.0027823370152604303, -0.45526256684070143, 0.39144611010160385, 0.5517553441683435, -0.665637216307254, -0.8488624181602402, -0.6971354961990913},
    {-0.10142073195809492, -0.631302569475305, -0.610188492745611, -0.29191908902090974, -0.055571871118423405, 1.650359055628003, 0.9677229361487024, 1.6207091076208224, -0.32112216860417286, -0.11585763553868937, 0.37926191825907973, 0.5443765258375559, 0.752602084832406, 0.07272158004656855, 0.13003867212752585, -0.43994339948853955, 0.4014476349868076, 0.9677560685005135, 1.5235661998520886, -1.0938812984139745, -0.8860714719264287, 1.6078236705961177, -0.05365578063382729, 1.8061497942826987, -0.07475936186813212, -0.02838733258326341, -0.9752233174066082, 0.708258923943655, -1.1755205594781533, 0.5657319533361517, -0.9877897517460585, -0.15912113460416713, 0.2856352040670018, 1.0904136607384736, 0.6777916661931411, -0.27274805798511353, -0.5445922258226445, -0.7708297247209872, -0.25568439357672357, 0.6954347118009289, -0.595068491624664, -0.7949550234845143, -1.0500890613744915, -0.20822126560930743, 0.4188772176176388, 0.35847889656743437, -0.8625188292461711, -0.6865107417177089, -1.1496237002235759, 1.4636108430504327, 1.168816702711151, -0.37848049430532626, 0.10961604875339326, -0.9187311735479823, 1.2741680237385096, -0.1973020432387694, 0.1737839203710431, -0.4702389059471159, 0.9589355563982541, 0.4883444845818041, 1.0504675344991643, -0.2077792838129221, 0.1629519569310849, -1.5530815322766192},
    {-0.3992382668598678, -0.48713269554530847, -1.2402654097683765, -0.5223247202081299, 0.10364383385477623, -1.0109831716950488, -0.3037714467722278, 1.2436076748303222, 0.4263129875246075, 0.6132910867507854, 1.1581002053780782, -0.3312801754116336, 0.05428242886791486, 0.4894500689959346, 0.7556616682076025, 1.4052402876656138, -0.1604887025249942, 1.502371177444072, 0.5365838283116399, 0.2686759976805034, 0.9773446148990594, 0.8249581112563678, 0.9620091200170675, 1.2172991423602604, -0.45760922697641604, 0.8380668701585287, 0.850038601613747, -0.9894517514047945, -1.11867944168602, -1.5272232132849748, 0.6031081184222855, -0.3848171643273243, -0.20225764497388735, -0.7033057617941048, 0.7379869569534472, -0.6718969122267641, 0.5125444739398471, 1.043948202356929, -0.47343988207455334, 0.8894926240890969, 0.9812360612806104, -1.10881149018048, -0.7107325005004509, -0.1723357441620118, 1.2804412466754667, -0.3322602370565604, -0.7626126896166161, 0.7406020043500291, -0.4231916406676131, 0.32565121926021057, -0.8661737626254038, -0.09793194724838648, -1.0512785815952577, 0.5127181940463507, -0.21461996068331185, 0.7561294727330308, -1.3279411457526709, -0.11842377741519766, 0.025561819278270823, 0.05239504667296037, 1.097868072939021, 1.2484305095830983, 0.043630737510603125, -1.693371527899707},
    {-0.3094279921504976, 1.340373433230187, 0.7412660829824655, 0.1864956235998656, 0.5374891848443835, -0.944007911979515, -0.9637069986696452, 1.0675350724819581, -0.6692110728302378, 0.533080572006787, 0.6087808547764991, -0.428837958008615, -1.293488400173738, -0.7955187256509595, -0.5400575527372599, 0.26788999467418123, -0.38908308340979775, 0.8433119085767544, 1.127314434164696, 0.9661164025752985, -0.9035224032983273, 0.0910767047264629, 0.7384115673479806, -0.36397410246343803, -0.5569711118155838, 0.11702540224784534, -0.36126818585621684, -0.5695839428678583, -1.4007328492898505, -0.36162689406090737, -0.613479331568805, 0.9453524815075707, -0.2480787817934729, 1.2715467559526388, 0.175213366450535, 0.6403544740084394, 0.5408236136153339, 0.3060509732799583, -0.7611670678491766, -0.43969954315810056, -0.570311728221879, -0.38091781093404775, 0.8602527853317566, -0.35860087402096863, -0.309306147630075, 0.684547883131252, 1.155301509593758, 1.261515565565776, 0.7887106582393398, -0.9774745130913434, 0.8333484453564695, 0.025575365245778345, 1.1857030652722031, 1.0278469678608064, -0.17984637564307895, 1.0065752196477638, 0.05781485968360334, -0.6676383433632229, 1.3727279492905236, 0.2857327943964319, 0.4093838108997679, -1.0938870461631203, -0.5664325334355617, -0.6428322686533854},
    {0.47305534245358644, 0.29569982538535755, -0.79339276698926, 0.7362955437323218, 0.152369502437204, 0.0013690682628271574, -0.866373271706134, 0.8439020810073699, -0.7798974652669451, -0.09372824792859008, 0.7231051796487155, 0.5023331406564427, -0.7680133823019183, -0.7692634044412573, 1.308914257509258, 1.046927203964223, 0.6160405619539447, 1.670129470997869, 0.9196932599519264, -1.3009894617143742, 0.10302760896721835, 1.53065862698678, 1.0919100916869031, 1.4723957018466642, 1.0807718438901888, -1.1863494575184546, -0.7450636840587246, 0.44608264758588434, -0.38187738982492825, -0.19314140264635593, -0.13789215320694137, -1.1615681501098138, -0.19533015732861436, -0.22904588925995575, -0.045203348734514995, -0.7180123175182674, -0.1371214906022887, 0.3404644353541124, 0.7209988104460427, 1.2041955990211328, -0.14736350133321408, 1.0756471953421551, -0.9132528106817127, -0.5116683120169205, 1.375518960350852, -0.6839816124167653, 0.6380345488911041, 0.6404952513251843, -1.292779809480545, 0.4971598037203331, -0.6978065973951751, -0.05315579131313962, -0.26169279621308955, -0.99948391844478, -0.748244591783242, -0.936435925318049, -0.5352772063825886, -0.6093125322619495, 0.6546961153269341, 0.33337521382546503, 1.3952104199299995, 1.481010071902623, -0.9894072696596402, -0.45594528588527866},
    {-0.5464424600709767, 1.032683518553486, -1.3113231611581035, -0.3519097615793503, -0.32222886691663405, -0.017799028128422753, 0.6991534967246873, 0.9886740572294815, -0.9383175043736119, 0.9090730510540657, 0.20220611718466738, 1.43260335575914, 0.6782510990527203, 1.2747251415622398, 1.3562566827076146, 1.0304606297888763, 1.080966358296735, 0.2086615672025526, -0.5537656063555302, 0.5198790119225636, -0.4437631261215027, -0.4765376652714219, 0.8582918776070642, -0.47513595418195764, 0.7461387010125677, -0.5334098303442636, 0.5009255501643404, 0.5806067161204127, -0.015220044036934685, -1.0315142339697216, -0.751861763863255, -1.2822910801411442, -0.9001773920514464, -0.18932486358717934, -0.2648838169341732, -0.7231912154030065, 0.3502065496730098, -0.4178184644001042, 0.6011672249080976, -1.008989214483514, -0.5606811183278277, 0.8002536378395275, -0.2950003118948064, -0.8205625796913043, 0.9823128656111616, 0.46148356930818635, -1.3195613220944487, -0.030947499742236925, -1.6466500213448787, 1.1431816586861085, 0.3831982688157762, -0.2597632262709766, -0.6700500743827381, 0.7732693299621143, -0.2504461237070728, -0.5287138700070597, -0.6790133280785066, -0.804724824168018, -0.30272218736411977, 0.217231191963405, -0.2852964009223378, -0.1578686006686749, -0.2511633133469659, -0.8839774012046062},
    {0.13606488607042364, -0.045315835615560546, 0.09002350333915912, -0.26185948944061666, 0.2614782544090601, 0.5692168136144611, -0.09560281059098748, -0.6423507634663147, 0.9027919468071124, 0.17643550630776883, -0.06803004464752552, 0.4159505332781929, 0.2763221704728382, -1.0510282105469342, 0.587007886085396, -1.0075638797315658, -0.3869901962056452, 1.439508244925856, 0.6619843852937491, -0.2067414429353754, 0.46384477902408405, 0.4007030076939494, -0.45755481966564804, 0.9932970801987153, 0.5797783881353586, -0.46021713851570617, -0.5335942296550547, -0.4988205720207108, 0.68460650687719, 0.4346738464354147, -1.1011018739083835, -0.7935225939873048, -0.3775872712764582, 0.4421060431269438, 1.1050559549013594, 0.7979872785297678, 0.5189847272441391, 0.4741699302246141, -0.6669531956013547, -0.5036644078600431, -0.604162651512114, -0.19201756408466253, -0.015860428343101637, -0.30085426645082863, 0.6434817648808262, 0.371217506071042, -0.2644029482652873, -0.8413886387134758, -0.4733976509556277, 0.4580145493303099, 0.5915438583968117, -0.4932237168505468, 0.3130001124776342, 1.087539310686728, 0.2282324753197657, -0.8167273544658362, 0.8745039909331632, -0.2461574440346256, 1.2315874393259234, -0.5975434648707099, -0.5700112142266035, 1.0970123268340344, 0.6431323281186214, -1.1421939333502213},
    {0.47050998925287035, -0.7534240281557997, 0.1032943571222997, 1.4394183271973504, 0.14499089685592018, -0.49562907723782695, 0.345833388815186, 1.1423223504225906, -1.385534863854335, -1.0820186652890202, 0.24317766953579936, 0.4773832206007007, -0.1551213890317296, 0.07460325348042221, -0.49230754122095527, -1.2945565906388192, 0.5908133395976136, 0.22669533255448215, 0.21201307371947528, 0.18717138809256595, -0.917438630878075, -0.1122292671226916, 1.2696258342406783, 1.324181754145729, 0.6279125016828555, 0.37079742532905413, -0.6862263406119412, 1.4454449528783178, -1.381285360089888, -1.1107798174543955, -1.0786484456921135, 0.27294811612250763, 0.4847788480457072, -0.7007149973000296, -0.6692558868510099, 0.04961445574186467, -0.8483929256128884, 0.9510676547128369, 1.1615496914747596, -0.33745507306316785, -0.5961595587835922, -0.2792645401784535, -0.1493507978717172, 0.7606793851813736, 0.9159539676545639, -0.8363806153724296, -1.0435014663271829, -0.7891941564499007, 1.2712136367428462, -0.9795714743465841, 0.7403404331677356, -0.5236735932657605, 0.5008573363444698, 1.0166302111444598, 0.8919892321087051, 0.40275894686205665, -1.0492184145221126, 0.005244512029131143, -0.31738065748804223, 1.1404562895141372, 0.6516558895560867, 0.7510033422557468, 0.6442970863973151, -1.165870814320906},
    {0.7953659772658832, -0.7468416112715891, 0.9149324188623522, 0.3806397426311443, 0.8795607558678129, 0.5026101189098953, 1.073543190693178, 0.3938320875810365, -0.8763592529183964, 0.7138311384995358, 1.6123693117251319, 0.5133700177217434, 0.07139132344650945, -1.46636755621753, 0.2562004056248276, 0.48250704618590606, -1.1632846877619505, 1.2576469385236608, 1.0085609282881856, 0.011557000908957398, 0.43392317961005605, 0.7008087757352768, 0.7501315864390878, -0.7150695877510623, -0.7601532243170718, 0.8254684781538987, -0.09927501056970998, 0.5529121154819101, 0.7848112145176215, -0.7629915837924754, -0.643423964104615, -0.5333445369760654, 0.45544389853417766, 0.7363554576492205, 0.5081304360186782, 0.44172672135498486, -0.11604719179423856, 0.8165972660398031, -0.16134125999593127, -0.2980036473361869, -0.25482592948857447, -0.8496803282318633, 0.9185910869511188, 1.2471258496202813, -0.28934772137096515, 0.7486656105861033, -1.2262301496077248, 0.6827756646565001, 0.6765250017270509, -1.0711838976116512, -0.9633263180024056, 0.039501579057753394, 0.354020972801868, -1.1260725694280085, 0.14049832116581193, -0.7856407647949265, -1.5173046329976372, -1.0019693210583496, 0.013949796572587748, -1.174394388115799, 0.5087990692002755, -0.6917830791331183, -1.176913363126831, -0.36279415284153943},
    {0.5346945116536352, -0.2510642691012268, -1.0540536607524915, 1.4621658227691476, 1.5558378088408191, 1.3812109242131676, 0.7557653123649161, 0.35036057962089945, -0.285258234642475, 0.22671094038730438, 1.5672026520996414, 0.8868666133783147, -0.24727169709334335, -0.950524598737781, 0.3935447122927114, -0.4806842654302152, 0.7664874036119815, 1.3177886089471205, 1.3403297969984582, -0.16848443655848594, 1.229127475174975, 1.1644971313661783, 1.5141594447696167, 1.4468544327591115, -0.2985754002158931, -0.5351775466677443, -1.1321368613772376, 0.9947114543909554, 0.529421260641689, -0.30856052081331536, -0.6045426588198781, -0.9393230996813509, 0.006572139051861233, 0.31104594817896425, 0.028378729417699495, -0.5601317555502248, 0.07694712279914301, -0.597757516735804, 0.8824143132888795, 1.082118864131911, 0.7629122879911715, 0.4245554139613609, -0.4009010430939723, 1.511159731488155, 0.9945115235068696, -0.5732511298131509, -0.48172781402745257, -0.14223432538058975, 0.4621141292795097, -0.3224881554047678, 0.8516427809089809, -0.4387932595994827, 0.37054990088318834, -0.9890963262128742, 1.7646312641010071, 0.4265090930639528, 1.0847716851817226, -0.6241984307334605, 0.6907970344583875, 1.2757479180165443, 0.8410346357618874, 1.1739000094019834, -0.9715378045089522, -0.2283775015792421},
    {0.2502328992339039, 0.6230909648201819, -0.7426993529641481, 1.4840609047061721, 0.2943805933601136, -0.40080793684065613, 0.6447214041083089, 0.922012429486466, 0.5412471424905585, 0.9492889668485294, 1.3283429188612945, 0.19758241361139772, 0.5508431967619056, 0.5295596315501969, -0.7084736493368516, 0.736053249527439, -0.7483603728207894, -0.5814528710225416, -0.27214488318129837, -0.9771427249843103, -0.9752263372303711, 0.38308031656992114, -0.22637915678621953, -0.4943450182681161, -0.6356446228436473, 1.25688560856611, -0.45412372075830293, -0.6559272986954667, -0.9621034085747675, -1.3350095427936357, -0.6122932002573578, -0.5984040349421654, -0.026015933455231583, -1.4873424090012102, -1.1503579487920055, 0.741929564545015, -1.117485165801427, -1.234016581593772, -0.8246206906911694, -0.2104061863936696, -0.5851350887240013, -0.8491327909832492, -0.427299825581653, 1.1962884961264737, -0.769057395469849, -0.7631204822652213, -1.436894123153062, -1.2812853730773446, 1.0975759523706528, -0.15429742621373402, 0.8443625981754039, -1.0106251957630112, 0.22466750252518802, -0.05834005128479035, 0.8711404371735365, 0.6410175923815312, -1.3753280839214859, -1.3300815576433382, -0.16657727580312712, -0.7630771497228322, 0.15007405047595462, 0.4841229381054366, -0.5381964259709785, -1.6270854845400242},
    {0.5203977252302164, -0.21347093626872726, -0.7475505725792853, 0.6102939047773608, 0.9829639131480209, 1.6351110728481133, -0.12332993152694194, 0.6136468468056536, 0.1079679387152779, 0.2281289269649586, -0.4542054125399629, -0.6664623224979803, 0.04759009326759041, -0.717239755868865, -0.2761379907218154, -0.15763423716572647, 0.29429986119725676, 0.156613124079385, 0.39083105631196174, 0.7360470144954729, -0.7648406061908134, -0.5558076247502691, 0.05201115500840301, 0.29846911918008623, -0.07633963000950625, 1.3176540829114416, -1.5646102511063062, -0.6179500714695568, -0.7053287921191244, 0.6762011178511607, 1.1389828115579148, -0.7018492018868565, -1.1471775352674374, 0.0692339677078443, -1.144051233796376, -0.7761927464449951, -0.3366292211459003, 0.6138869375301611, -0.375475646367882, 0.20305821525024453, 1.1205345243211051, -1.2616811179277068, 1.168007858106077, -0.2725339696043633, 1.0179939024355387, -0.531428950475911, 0.7586701261055143, -1.2208494911938221, 0.3948196710831678, -0.05446211422727982, -0.8086889301464055, -0.30726707084414034, -0.29799682352538404, -0.08961978929931337, -0.3756813505678854, -1.4408246856272662, 0.7875228274180808, 1.1228452473703177, 0.5838634401819197, 1.1308552126738567, 0.1934036307633314, 0.16203636871344415, 0.8540436276008256, 0.6427267949369095},
    {0.5579029678152138, -0.6838529824125034, -0.0704195317143484, -0.6398026216556055, 1.6175692139667408, 1.7637586069866653, 1.0177174241311513, -0.4258939320914406, -0.7598516990850307, -0.20908609698384334, 1.650282587276583, -1.1448464866702022, 0.8910932150098453, 0.5347607037979418, 0.8267626773888772, -0.32280988868161103, -0.2658523655626903, 0.36792811720298896, 1.2911889322051744, -0.7161915315289253, -0.2687962427763735, 0.3905316943140974, 0.8568598810520714, 0.7362713892013699, 1.1242977336860782, 0.3547150891002167, -0.428006240508614, 0.21756235958652836, 0.15040516545218227, -1.1887158148484878, -0.3775603312196392, -0.7449889074173514, -1.07328323299979, -1.2583330083103534, -1.3809532223117, -0.4502428133498065, -1.3553151924680311, 0.962748438114517, 0.30214475082067715, 0.879217989834986, -0.1207573090727053, -0.5665773074534846, 0.8347391605390094, 1.5586475120854373, 1.6337099368794543, -0.7412593255742724, 0.3503558003003234, -1.2059114306761656, 0.5383150863660525, 0.5044861398510158, 0.48967449048043105, -0.8093334596470042, 0.025175456910652715, 0.46703121447746504, 1.8328040773901393, 0.1801224689588183, 0.9581406415890131, 0.14588798219179347, -0.3161096620722715, 1.1962604877056349, -0.09568043661654962, 0.5866382378430254, -0.9389230821854131, -0.8546015369144876},
    {0.9665533799602175, -0.9958372818997187, 0.14151300015421847, 0.7085036988318476, -0.026757823986430184, 0.2774353792156693, 0.0863358158582257, -0.4017490125887244, 0.042272873768021024, 0.5119963376693569, -0.03068646526305486, -1.495687250085965, 0.21372894833265552, -0.20944135136867909, -0.22177247068885025, 0.3692450183927198, 0.04629449021705317, 0.35093920302532117, -0.49503912284471524, -0.7989896612343033, 0.6626377979543783, -0.4602499232282726, 0.29664529408179313, 0.9493502856715398, -0.26226748929741306, 0.6974490298379757, -1.3483677630452453, -0.03689208068282345, 0.1307251801835816, -0.6245797480881624, 1.059443700147597, 0.5504764450339581, -0.4325819146366917, -0.9094087795097336, -0.44146808553791, 1.1619767709865656, -1.3498541421897252, -0.7445008169499756, 1.325360469361665, 0.7362376734984826, -0.6660162221575006, 0.37609195790287264, -0.833314723679145, 0.17969268768453206, -0.31899630119281686, 0.2999855175504247, -0.13502123974335548, 0.529152068335276, 0.3500516982949999, 0.7535486349296774, -0.29436293500794075, 0.28553565298905526, 0.6987829787517351, -0.5361663385849802, 1.4555848969273284, 0.12944679944290824, -0.8286863662353547, 0.09555850579064885, -0.022386716285130916, -0.7386797116958215, -1.0876897677631951, 1.5253173715935568, 0.693601630128433, 0.579119367971683},
    {-0.825104416663777, -1.3947273302737675, 0.15747106342626813, 1.0565758257030042, 0.19267796140402532, 1.508709611621299, 0.5179748475311052, 0.2420570055911301, -0.4947376032589703, 0.19834624532549744, 1.7155282711059028, -1.4795226690312275, 0.3743128625328818, 0.24592577067874438, 0.9061021532068856, -1.4932954535650391, 0.8760400354392772, 0.2148991296423863, 0.88059641670315, -0.5546771991458014, 1.3564340549115106, 0.1680963619368278, 0.6108760173451452, -0.9668395580895541, -0.05511813901870698, 0.7425404683724375, -0.488100882629171, 0.5714647230288021, -0.16022674064080453, -1.0541985024101876, 0.6186905836045304, -1.2513289258946352, 0.20615564054956037, -0.42612730569033186, 0.8635839513231719, 0.4203819076087139, -1.2291187797088274, -0.2739155175405424, 1.2667784647967892, 0.838497364253004, -0.6751047726153454, -0.621357729940136, 0.6186073241296279, 0.38596722590290194, 0.17563042914584226, -0.709678836145024, -1.3229239552118541, 0.35124679540531784, -0.17231209249908225, -0.25737880472267144, -0.7747302228379335, -0.8364501493935173, 0.512330314233992, -1.6431326294025037, 0.7533075106828108, 0.16238821901583825, -1.020626485780378, 0.6615862570257467, -1.4453710489586051, 1.058518277356279, -0.8444512991864286, 1.3211947243698834, -0.7783791985635933, -0.12844131832180916},
    {-0.13522812993271766, 0.7131836804973767, 0.10872081396590659, -0.07518471958359113, -0.8411028146327936, 0.18739396261470048, 1.3125861152105578, 0.8747723667428214, -0.39467189452260254, -0.8151443891521212, 0.9411572423237597, -1.4232979540990132, -0.22494827792007457, -1.4564687110154442, 0.6541110248786153, -0.7617114226150471, 0.4895934108799137, -1.1791903906644838, -0.4975238037259508, -0.10912933889544225, -1.2842122834646763, -0.6205223728829109, 0.16016806046933113, -0.6915715463243218, -0.4293909890125893, 1.2636783012424913, 0.5018872219357383, 0.8739271401884319, 0.44894489796791337, 0.6597408306965971, -0.8069110288002722, 0.7210385041530665, -0.8179237789073245, 0.3190640267961572, -0.9211760944335596, 1.1773842068427178, 0.29017432708909185, -1.1512935667445048, -0.3523935854661495, 0.3525030101300142, 0.6835842968950352, -0.6753358206835554, -0.4280448915597536, -0.7703692764052019, 0.6027332062906303, 0.805295706397356, -0.4811013047981162, -0.29660497284027165, -0.10485260381343683, -1.066954952493415, 0.9757203502808703, 0.4611338589591576, 0.5149375383074611, -0.43414710609195983, 0.6051627227993762, -0.9394322181728241, -1.1368234157390182, -0.16246888522566794, -1.0538276337279946, 0.13459999800509698, 0.0826388014991264, 0.23993982838118363, -0.8337289721837542, -0.410728343671255},
    {1.4109301926904905, -0.4311746045783632, 0.2775872226178114, -1.0430735805883005, -0.05875782387570729, 1.6335879524343035, 0.28587082809066694, -0.35253791288990455, -0.21281747486239175, -0.23594870585623506, -0.42860259276920276, -1.404007060522005, 0.9391419410776198, -0.31212174557126476, 1.2426406230792582, -1.059438833455961, 0.4448683162479721, -0.22275621958987943, -0.21729735695256813, -0.5394615340293043, 0.8329373383080914, -0.11452081597662543, 1.5325620854683097, 1.4666871699041935, -0.17949840374457884, 0.33593422149195007, -0.8636283725008266, 1.3933754762873247, -0.3912212228065388, -0.17941923578473157, 0.24418430868294835, -0.8400693898443433, -1.4296917440964367, -0.41062521157670967, -0.6047165635094172, -0.484615402837266, -0.4368103077574184, -1.1061736061675524, 1.3448294857080738, 0.18831341982861666, 1.0820434452865486, -0.9919564017862308, -0.15445678728681284, 0.2760837592439584, 1.163676172312921, 0.1541457536456619, -0.6051805141560493, -1.114300855049659, -0.0749320094713215, 0.5367362408085891, -0.3618983449320883, 0.18249590088451187, -1.2148405233663626, -0.6848951467586448, -0.3342330357225762, -0.920271633313819, -0.3256910726853074, -0.3695366443027841, -0.58175998099068, 0.03255890161498307, -0.3736919014841762, 1.6179355300926397, 0.6203453786492887, -0.94065915127004},
    {0.38061655937994526, -0.09738029383539802, -1.1494886164907454, 0.8763522718984967, 1.1096483220707336, 1.0417035221867832, 1.0310896374533498, 0.0461785145091202, -0.3417190941884251, 0.6330812667077138, -0.9440473996684492, -1.2836816754983758, 0.09829039840238123, 0.7629352106831243, -0.0651633805495973, -0.9626243580339975, -0.1843767716371957, 1.3560639576903712, 0.16805230624267983, 0.8474596490875091, -0.21655258477244818, 1.003154711566524, -0.34704833114476485, 0.6090119310064503, 0.6567205936614006, -0.2603889988240975, -1.4780432880791725, 0.07627043314062364, -1.3152643364604706, -0.8094711077431479, 0.2573053491558128, 0.07570279071450554, -0.43846616793500104, 0.3357672829025686, -0.051127422929752496, 0.6992391377165197, -0.6361926079409975, 0.10417414384001565, -0.5607432875286099, 0.32261712878620386, -0.3782323653310536, -1.1253508755624606, -0.23071436509547624, 1.222092911388093, 0.4192840192038474, 0.2938025609187944, -1.5520899468631115, 0.8694186552276238, -0.5544665247998649, -0.12618586544294833, 0.5338934916197788, 0.3109757294327407, -1.580770819603468, -1.470077775856555, 0.5009419184628862, -0.9022783974934361, 0.15751129612963852, 0.5798641069523327, -1.6102421123595363, 1.0360926297721809, 0.24150957095176606, 1.199432113423364, -1.026305772702969, -0.4623634962009957},
    {-0.9489868342648178, 0.24607179597229825, 0.12662799313671166, -0.2883053428928403, -0.5106511317625416, 0.02861869247962764, 0.10694808296996255, 0.21077814036483553, 0.4662302034475399, 0.09334493165145079, -1.1811890189204146, 0.02580724861685301, 0.14532329419884396, -0.3789022571832936, -1.1672318379378874, -0.7904228915774343, -0.016358121569818602, -0.6536931254269606, -0.8569166969011184, -1.3804655786858375, 0.8403158697351844, -0.9833958327659683, -0.06787041422625613, -0.7920673940332621, -0.01841631892344483, -0.1934307623359655, -0.26536858598226226, -0.47541884293740144, -1.8407365063584689, 0.049865321759445684, -0.02100534668752262, -1.3349784506944833, -1.21037705242423, 0.13224413143382807, -0.10557872989246707, -0.6768127948444304, -1.2034443515171511, -0.11563963191921132, 0.26337206216359527, -1.0017700287900164, -0.3024846647617379, -0.9117847674860842, 0.11175441624858792, 0.6476169947087791, 0.1596267389698724, -0.6343551427117436, -0.6799104604544792, -1.594971055104736, -0.4569195656874144, 0.05874746263799092, -1.7540840577860908, 0.9140706782146762, 0.759822269919749, -1.1492812602380817, -0.7918425269100375, -1.3657797112078458, 0.23582804334546348, -0.22612408538035006, -1.9998922924670512, -0.4947598680505093, -0.7743679114105471, 0.17192243026437512, 0.37344486854088405, -0.60099795146173},
    {-0.617848874371459, -0.3739197065402658, 0.724292400382334, 0.9751273246310326, 0.8478514811565466, 0.8290049556884034, 0.1805064803964613, 0.8583701378787584, -0.5341263819741952, 0.09353993332235114, -0.3790819940922747, 0.23992277458500408, -0.9716053279405971, -0.32391768430526807, 0.29702757627940685, -1.2973279090697107, -1.0694249302167054, -0.7346691064263676, -0.15910055469442602, -0.11161840539245925, 0.1878681871969351, 0.6809605512164396, 0.31224901223090146, 0.8874541686032381, -0.3261105804493156, 0.02579911807056568, -0.8631802235380067, -0.8486141317893791, -0.816587706830146, -1.2531785563491107, -0.9250093419303503, -0.5958578986856942, -1.0530474817590147, 0.2261227933633282, -0.03873926049655096, -0.7973021224454034, -0.29055825506458427, 0.24205252354274776, -0.2841950231309005, 0.36340454266041444, 0.6683664925506019, -1.5869439202496365, -1.0259779950858787, 0.5613140052244859, -0.933532589677451, 1.3272852946264224, -1.2954874771276979, 0.2214372297024639, 0.5241514514282397, 0.9219633564657798, -1.5458121823470943, 0.8113801009738587, -0.7947973567569551, -0.49272053612635336, 0.6808413622382461, -0.8297120779742541, -0.07466116057938249, -1.4711185821903519, -0.1949260116948629, -0.33936405911225154, -0.3710929959501157, 0.9843110803853932, 0.049133795368268715, 0.48109869509617553},
    {-0.2755741426063351, 0.07774953159504633, 1.1584050537894381, -0.3571373142454991, -0.9859090889294785, 0.2290032550843995, -0.7712071479333897, -1.137641531183915, 0.2874273483146508, -1.3340766018157908, 0.2876936761676277, -0.4962963815387111, -0.6563792584089411, -0.9305101035162481, 0.8303109276418176, 0.5123330555271955, -0.004815140469167663, -1.5546181717924235, -0.9152983602705557, -1.0000506562587594, 0.35177116084081833, -1.6941520752101173, 0.2392024745221305, -1.4392162512962032, 0.5628156804257614, -0.8014572520685953, 0.7625560103931438, -1.3074888734660755, -0.5721415838512934, 0.7312124426500922, 1.1213519896091808, -1.0478764613638536, -1.3944148852725577, -1.0299751796228405, 0.6898565276098843, 1.0484785498661366, 0.3509496459021249, 1.0926563004293441, 0.42094424502098254, -0.9336191553441081, -0.06938028758303497, -1.1326465806412453, 0.10989247418693156, -0.9333731204066456, 0.8512037888288244, 0.6311533022762762, -0.9149767561717029, 0.1699474143567076, 0.7883299368521124, 0.7225952848588625, -0.12101276482903313, -0.605615997593894, -0.4327251458163546, 0.13042427433829906, -0.9591782165211947, 0.7611662552276856, 0.4711032590448579, -0.29115441348585236, -1.1975972700865705, -1.0573226393190112, 0.07415651205866995, -1.1243195797404872, 0.8382526416984055, 0.10413627054916914},
    {0.8399641172110477, 0.12261449092738824, -0.22846615656215216, -0.4785274618576256, 0.019642482802907788, -0.1794674589581342, 0.5887716426326892, -0.6977756703097938, 0.9248280553671547, -1.2936607544502754, -0.10680064902455857, -0.8300381197705881, -0.316503627913682, 0.8336668878203807, -0.8612030676603195, -0.7441711822546253, -0.5910356353254022, -0.2578850773554938, 0.4118153453912922, -0.5333372004874857, -0.42822336293799046, -1.4330047372510681, 0.14325650569608592, 0.394059621014134, 0.38294722763071726, 1.2519824846821215, 1.0947450742331832, 0.5235953577155135, -0.38122378166503473, -0.38186112842519143, 1.0975248027410107, -1.1547133265676348, 0.8029070595069904, -1.4530373672392805, 0.5679913065817154, 0.7652203332588411, -0.8686253407807986, 0.8670165508669434, -0.6012005074219179, 0.6414471480725423, 0.9835088413139721, -0.41059775333969245, -1.0747537955129234, -0.17959014099925155, -0.9747863513616251, 1.2052309375600103, -1.3323288753995854, -1.0738060297219656, 0.7608438661995703, 0.4955375194864589, -1.1290064995635714, 0.9987314292626619, -0.36109339158604, -1.2553378931724715, 0.6668740377626574, -0.22800727610360788, -0.9488351776969138, -1.2405975227318533, 0.6718017685610322, 0.10427822962281307, 0.5761848345425663, -0.5953546690389097, -1.3551998773583958, 0.4231545734876965},
    {0.8544795626546036, 0.6901780358137621, 0.6883662442102596, -0.13845606464570825, 0.8161608095771776, 0.22280769664389583, -0.04873398694988321, 1.4323544228976635, 0.48404128439611455, -0.7259764321925074, 0.36697741356039754, -1.1053646044643624, -0.8318825814876644, 0.06431943934995583, 1.2419091268166975, -0.12598942466577515, -1.3640275474973924, 0.7100218216877179, -0.78326721655981, -0.09744703349862044, -0.36686793967301823, 0.4604296874071745, 0.2297118304904541, -0.9588580553046246, 0.8680932869950694, 0.08110374908063772, -0.15165033808074893, -0.628732596506109, 0.7494584279092354, 0.5917893660105206, 1.1670272269036817, -0.8050478935687607, 0.14089880880344247, 0.9202893794645078, -0.6769430069604505, 1.2220404977810533, 1.0326223733366826, 1.353805585168401, 0.7443834992721848, 0.2730548448821844, -0.4893389737388011, -0.04045027540707138, -1.2385755696447536, -0.3950493695348106, 1.3920652011819854, -0.5614793071017901, -0.6674174858927319, -1.5163395967113311, 0.2755841343274883, 0.8498784458963693, 0.6445711827197155, -0.47978966116243704, -0.5316110821248793, 1.2982178303486223, -0.5687008942468327, -0.5969756037549457, -0.4723696714676641, -0.8188942477008673, 0.5001132449166814, 0.21831219569448876, 0.09293402107613273, 0.19246932133948727, 0.7294707894403701, 0.18679403308744422},
    {0.2678533116843974, 0.8390267969868278, 0.8203763577130061, 0.1828149911167179, 0.4524473826275054, -0.7124449335933487, -0.785914289030119, 0.15939191918539328, 0.1064785186798167, 0.3940495170098232, 0.924874046343109, 1.0502699449183015, -0.48857512350248083, 0.11035090636041944, 0.2521692638204713, -0.889596840172795, -1.0197536215179546, -0.10883444750900521, -1.0598523825149078, -0.6552409327597384, -0.9289624535816405, -0.7379687005390073, 0.7210617831411461, 0.4877852049741353, 0.542274285624654, -0.7957132993200172, -1.153906870690226, 0.3795667573776867, -0.1763409984834656, 0.20249013987819386, -0.7385904068851533, 0.4260543967824876, -1.1440199558000081, -1.1560971658764445, 0.9598030201914333, -1.1245806023330303, -0.33936844720660575, -0.8770513181984907, -0.18259202283013345, 1.0063671507761338, -0.8391259096542399, 0.3882722367564638, -0.8717420086138139, -0.42897127345726466, 0.2725058129253335, 1.1120752132518177, -0.9287044669553691, -0.6495276050027822, 1.2906282108921077, -0.3717504419241417, 0.3784090930570946, 0.48190553483204185, -0.3418907695692213, 0.49417551688147004, 0.5626389283683704, 0.5462517272670061, 0.1908398279178814, -1.2649265476203528, -1.0013393962700101, -0.009045721363071196, -1.25178507203438, -0.654045123197167, -1.0315836693873064, 0.1823428034449797},
    {0.9152735828110944, 1.4347246890437881, 0.2889361343214985, -1.2879354009836101, 1.124711782919631, 0.8059772065298714, 0.10315689063570528, 1.2110272271975182, 0.15870522040622384, -0.9486164898645645, 0.8735534199715239, 0.30992975410876333, 0.872252115859539, -0.9866328629280722, -0.11212742220510773, -0.8922672827810908, -1.3071828635911424, 0.19430987878223338, -0.625590001939785, 1.1293269975524698, -0.5416340580862355, 0.10240281945030229, 0.2657526715518757, -0.904853912610071, 0.5206536877435488, 1.0262428797424845, 0.12183288537717636, -0.6283122769606131, 0.5225179813985452, 1.1991802195218035, 0.9919637453425388, -1.1393805255686593, 0.3243295855238651, -1.42558309734654, 1.2718085478639523, 1.4517304899842134, 0.08679190455318778, 0.513034907540194, -0.5818485917708348, -0.5747593934487442, -0.027177241444283573, -0.8978695362149441, -0.3314557785926996, -0.9994924961148317, 0.48531473438594913, -0.7895629262540239, 0.8159105967230224, 0.21012735608871763, 0.3825390931134657, 0.6347824782232029, 1.252041284275183, -1.1004082585361392, -0.3797444924606995, -0.35825365628421957, 0.12450155785391524, 0.5352429906871315, -0.005599851158272717, 0.3356721208978187, 0.388221726324934, -1.3862783212825778, 0.3750168265453026, -0.9108091285394815, 0.0900878541505416, 0.7712220574468784},
    {-0.32212788721367336, 0.28992792128063083, 0.8953786629864724, -1.0064119866096608, 1.1620027048231316, -0.9459475668456183, 0.6905394982688527, 0.12075719394456347, 0.2789350811500596, 0.5109002939468684, 0.09716391069639799, -0.39260298164606594, -0.2589724102025854, -0.5814038606844665, 1.0920306067841168, 0.5271464755514191, 0.7346019377170516, -0.12297239738748844, 1.1752363365479905, -1.1585367483606483, -0.34158227723457674, 0.6438299633864466, -0.1568459624262278, 0.9761375333790062, -0.4951754734144631, 0.6151285225544371, 0.7084925520043764, 0.31877320019754807, 0.5008898903496524, 0.33223843411822074, 0.5945856152623266, 0.016229035389506756, -1.1259542987461448, -0.4688525089776104, -0.8510717661919324, 0.9521376860452809, 1.4435063253141356, -0.9970428380933775, 0.7693600013062049, 0.7092624935679523, 0.795335011016311, -1.33930367011876, -1.2001981655517355, 0.30734217045298423, 0.07058246818877163, -0.8787952065598379, -0.408353804207005, 0.5410265856492169, 0.03936575599257508, 0.8379173452252417, -0.09795636050679112, -1.0382075909147228, -1.1564466333915313, -1.3278521812062418, 0.9182970186518212, -0.15446331866582375, -0.3289999904447746, -1.1845259564440553, -0.8902140870083646, -0.19251228828566538, 0.23930487307079892, 0.4384894056224765, -1.2995629955768089, -1.2078937240248788},
    {0.4931041303524527, 0.7400444330092912, 0.9681775481791299, -1.490932103882553, -1.0239887506077747, 1.2612361792865883, -0.5071194612604236, 0.17744477573197698, -0.40056686139766645, 0.4848191869872097, -0.10266171583351, 0.5566898275605588, 0.687873929984878, -0.42899513405021455, -1.1127588438504488, -0.6837672896778941, 0.2564316407072479, -0.5647238237274017, 1.1711891758165807, -0.5632862157455273, -0.3340096293761019, -0.6241690863580004, -1.0848287088486284, -0.7416574751761235, 1.1480261096719253, -1.0092455618308365, 0.6995682593634018, 0.3518308228001376, -0.8008932903304513, -0.3184794188556649, -1.2643265256986023, 0.6215547032975698, -1.4906319489092263, -1.0087852929106043, 0.660308591766478, 0.8318838034043253, 0.9788800240730673, -0.08034176124163582, 0.5732419066029601, -1.187544260287669, 0.17302362510273878, -0.5511727702589131, -0.6374500999593729, 0.8233337174920916, -1.4359364707576976, 0.4102495014713602, -1.2783134054672434, -0.20305592680401713, 1.1669892615333588, -0.43968591353351477, -0.7847175122422679, -0.6012863047207277, -0.9918439838566363, -0.44945859958632406, 0.8704208183560764, 0.9029969759700943, 0.8794702804317142, -1.228151429777255, -0.9524962388360206, -0.7871860900502904, -1.5392052796822577, -0.23289785693786064, 0.8371061953166768, -1.1567688680721324},
    {1.3132391447497795, -0.14099782739524064, -0.483490750930797, -1.3743011462936103, -0.7745778046149104, 0.19755408975579608, 0.47421276552260044, 0.35858769919654016, -0.9469868974989997, -0.1273683334591125, -0.6244445593566532, 0.014204189405154933, 0.039026293820708755, 0.8396171150985309, 0.3219369223652092, -1.1144961303030334, -0.4645004817071888, 0.16180064723140045, 0.16590836175739368, 0.2194054139257106, -0.37682321672313934, 0.6422763743820947, -1.1442752430408973, -1.1546918625374234, 0.4226255787756832, -0.5143187800905971, 0.21110480006956373, -0.5898544936016815, 0.5487063176438758, 0.45009150597809233, 0.05660704548600304, -0.7474357319284937, -0.8606933958854811, 0.48707556550361103, 0.03495229972168504, -0.6914201798321822, 0.1785648539544413, 0.8951017835887409, 0.8005659883951619, 0.2707011032439461, 1.0158733489382783, 1.1695317833258418, -1.191262378655816, -0.06700716188413174, 0.21861485547631487, 0.9655715003817668, -0.26764425865201774, 0.5676623399771802, -1.3197235853732887, -0.3153707421809777, 0.32391270218593143, -0.2518729288196072, -0.2561867066585187, 0.12297252765006163, -0.41867981949744515, -0.7808724039871024, 1.0152051589779416, -0.8829901060080364, 0.35640475021928525, 0.2952413943981323, -0.3298848551564354, 1.047759753141405, -0.5156025923690055, 0.015546195599202176},
    {0.038371960128168375, -0.39309631157127, 0.38221082288773117, -0.867434876849581, 1.4390307833434468, 0.27147801218967366, -0.5479142832842872, -0.10826893923615011, -1.4305946849339688, -1.43415235952342, 0.9243396353605768, 0.6592180807607936, 1.3318559792254463, -0.9159561241399992, 0.5653725137558157, -0.029484684133656482, -0.8702096637946773, -0.3912994295439723, 0.2986330242727491, -0.10850582442449748, 0.7592625355078035, -0.782848949871445, 0.313212690505337, -0.5122930242571687, 0.41868472796526734, -0.03694061055941094, -1.0120566767167951, -0.8132859566213262, -0.8135063107322235, 0.2644761362110856, 0.5346337977481378, -0.42567515693703156, -0.6704573376024906, -0.5883667932871334, -0.5402347687967278, 0.21153704575124443, 0.6274995629528045, 0.9442665611854789, 1.1883847690261133, 0.8869934241933374, -0.8535736811647681, -0.8687882121989059, 0.9976406097942214, -0.8236888812935442, -0.8838245505908902, -0.21025177820814375, 0.8653527470388097, 0.5250789660122417, -0.519390072291505, -0.09074698083313261, -0.27991432995116455, 0.7913834768497491, -0.14464475311843486, -1.09993014524174, -1.1120845759447886, -0.03049059668301085, -1.008605381707863, 0.8689611312105099, -1.0765024064653468, 0.5727347911066193, -1.0544831570370852, -0.482221573210617, 0.7726791168257133, -0.5579480440618412},
    {0.5839920870919064, -0.8102154362136241, 0.22015033555790367, 0.8760038030990663, -0.1842765162884716, -1.1263746649745223, 0.5734590039545028, 1.0086182785393514, -0.707839010157894, 1.119097661318971, -0.45713862466665955, 0.5578274362880031, -0.7795063686129229, -0.3731293607441681, 0.5887954475883449, 0.6193598994929852, -1.0125442293086886, 0.5824685870980115, -0.9151134611373537, -1.008259526193485, 0.2444604499999157, -1.2304582861550706, 0.5098104598962939, 0.09111255131857877, -0.08585021203319103, 0.054112380318607704, 0.22169093151084537, 0.06740119217763385, 0.3818438428087211, 0.4507045369602943, 0.9397806982147506, 0.8632630473349137, -1.223147353090598, -0.3075521752502863, 1.2820438521714086, -0.022452290021436574, -0.6178745767046206, 0.3492430906569416, 0.37220447026119863, 0.8819310633702325, 0.40251422003895354, -0.2568419762520165, 1.2090799758150588, -0.9524569760937426, -1.4684465036294665, -0.23164466364790376, -0.8797794886509224, -0.38983960640925197, 0.7405651274667245, -1.2790371937674654, 0.501832320617401, -0.8674876757778497, -0.0053342437211079405, 0.6712914239101295, -0.01484566532620173, 0.6292352130750044, 0.3165388644553638, -0.3145823537043243, -0.3289050487425217, -0.4046000025889941, -0.02716306541924484, -0.17564400912639372, -0.5508651130393665, -0.5451847083044616},
    {-0.0648230914533126, -0.74439420683102, -0.6860509961871737, -1.1009921957198312, -0.6885929911933162, 0.03410119427894688, -0.7867859922338161, 1.3673170574244984, 0.18180936071273388, 1.4257401415445308, -0.4610398827961073, -0.04879586488136061, 0.9359053665616704, -1.17543745660436, 0.09718431862698385, -0.2588639528811306, 0.9570316124350609, -0.613950748507107, 0.8776002946715065, -1.2265270767494385, -1.041728989791802, 0.929354034723053, -0.686350206162991, 0.765889855942582, -1.3345640262215248, -1.183610066089744, 0.623381148112878, -0.2667018790826687, -0.4010364815849554, 1.0672632982553132, -0.12051314167191068, -0.5984953231909192, -0.5211541893126996, 0.11011625103959248, -1.188020621972306, 0.26242686239318214, 0.719484186186757, -0.45615915714045413, 0.3041641431360618, 1.3798709129905338, 0.1534137358813752, 0.3957945900212562, -0.0953716069434196, 0.5361045881213538, 1.0502587090816295, -0.898140195740517, -0.3041396594624501, -1.1792017204477994, 1.336269210906403, 0.9899176940120101, 0.9127712806949658, 0.9924510523645425, 0.5639749941328542, -1.2769199394880177, 0.03790836370513484, 1.170462440494327, 0.8672320436535693, 0.8869294053928523, 1.0978647993494641, -0.12876910481949674, 0.4430176717113948, -0.3066081755673258, 0.42860883751663226, 0.43159145968528906},
    {0.3968995572894418, -0.903339932614737, 0.16728381814813992, 0.555496412968647, -0.5734196486528703, 1.0042882547499001, -1.1582385655214862, -0.004524957027264124, -0.3139085519497046, -1.0998807843364709, 1.0679233544284716, -0.15986053167899522, 0.2711256914524338, -0.18031809866483461, -0.25026972238652695, -0.9382687795455176, -1.2180176099788536, 0.5441708155999518, -1.1820030998868967, 0.15397107429572768, 0.6116920819048128, -0.536753197477792, -0.006611807230907045, -0.1741320695160486, 0.6168333123421261, 1.14265702220314, -0.8601113918711103, -0.0642516866255189, -1.1244954382773147, -1.1599133043042893, 0.3595144602654924, -1.2353853045939847, 1.0770501001864308, -0.1289308341442316, 1.1382459249005932, -0.7985010417978863, 1.0291034594301984, 0.9158621363256951, 1.218407930453202, 0.7864330379150675, 0.8762314119481454, 0.9216614856736245, -0.5505044092135688, -0.7270629216294063, 0.29036191941697986, 0.7706582679017814, -0.3529765944971574, -0.12022877221610145, -0.7034434253946887, -0.45890300112226334, 0.6192074040008688, -1.1064099174229642, 0.8914343767771167, -0.5665389659938597, -0.6467838013909586, 1.0149582251426867, 0.1429659369907002, -0.9333533377175739, -1.0442614147019877, 0.8487317923855376, 0.08045921315716882, 0.4793013379831534, -0.7403583694727521, 0.4856170388541244},
    {1.2041996596280526, 0.8210280808729757, 0.40587071991593854, 0.5671767232120605, 0.36039110586994844, 0.5217683002102603, -1.104074868612251, -0.9127078008375917, 0.5256259792753023, -0.5214507264319643, -0.7630028912767497, -1.17349275276482, 1.4059690791314157, 0.5461986457075004, 0.7430085506529547, -0.9112748228558754, 0.5750926368991375, -0.07768506957907337, -1.2949681584612742, -1.3209651909567512, 0.46167359420647164, 0.32380118141297276, 0.23566230535515, 0.37828301995130625, 0.7225018997442635, -0.4250117855697057, 0.3616813937940135, -0.18676355738987166, -1.04159433225494, -0.4229502885339068, -0.4078581611588662, 0.8170868830683178, -0.25285367085643135, 0.5834270529958273, -0.6565580136542228, 1.0063660985181835, -0.7396426138290095, -0.5525391582011538, -0.7388320446441327, 0.03705058011200575, -0.1242925958940063, 0.48421504105884366, 1.031870896471055, -0.6639093906410038, 0.6753569112286267, 0.4210136830410548, -0.316659578550037, -1.1938177155513172, 0.3890940291400319, -0.7851951599297812, 0.46449685586780715, -1.1683796189994677, -0.4826759592867341, 0.2438518059138573, -1.1733387661561108, 0.7327379821307357, -0.0726261435742021, 0.6154596030234785, -0.9401640276484544, 0.16319651323184964, 0.5080678397759563, 0.161714250409512, -1.2179619399318584, 0.9469762517046288},
    {1.277007183799962, -1.4655736718795147, -0.678030325528256, -0.6749819254143954, 0.6226806495832338, -0.4824710631364337, 0.1321472925873277, -1.1991993235781393, -1.3236227923056163, -0.06665471856866734, -0.9584856180834079, -0.333650334629925, 0.7403715257588943, 0.061661548384469946, 0.3233017816088122, 0.8852042953799673, -0.9646007160628055, 0.9100674880996801, 0.3473665477520168, -1.0028230080340925, 0.7948570798416935, -0.12389994396478952, 1.0257099107554992, 0.6539517737441307, -1.1586258141483023, -0.07807270513487817, -0.7396795478821923, 1.0831789717893427, 0.6230407926140334, -0.8325837633399934, -1.035428048210863, 0.5874791503017769, -0.12287739459509639, -0.5582713705925316, 1.1275817862805655, 0.7855349219763484, 0.6676770988028397, -0.6181223564234657, 0.7150343497511578, 0.9406205602616243, 0.04676956778838033, 0.09859023258802704, -0.8979608345624542, 1.255773233006674, 0.4647895226595947, -0.7625826257135596, 1.2233369458050103, -0.2995723910899877, -0.4677796588976661, 0.4050601453096887, -0.9317888500673158, 1.0925378241269392, -0.6761403281540218, -0.19682906369341296, 0.20528065579773466, 0.17225596630651122, 0.6583868744810858, 0.23793425443449284, -0.898214464851858, 1.148989145811209, -0.31103396644171794, 0.6047004218495626, -0.4864783007787841, 0.6166121387497723},
    {-0.9414129910260829, -0.7813902321710646, -0.6425102622167449, 0.010488458904392414, -0.6621170659013234, -1.2246548836076712, 1.0473926982184882, 1.172640000910658, 1.2948509917036612, 1.0570408341299173, 0.15495299203982799, -1.197006223522276, -0.1505314448518847, 0.22360570432069715, 1.1671424272115032, 1.2171846627363407, 0.1831642915945203, -0.11551200643507607, -0.40590871136008694, -0.8307544719815745, -0.020392352534939782, -0.02475944603737684, -0.5711673868283476, 0.46401608193213034, 0.3700512948561142, 0.38643567167330695, -0.33114940998208114, -0.5980844260403627, -0.36720580485634363, 0.5638083447064033, -1.0089989732368119, -0.7106050541341599, -0.11109608345937957, -1.2540752525545442, 1.0208855980394511, 1.0986442248247623, 1.0424376266027924, -0.6122689840819743, -0.010101514588528981, -0.7345095661455615, -0.38743539510085084, 0.3256922208156346, -0.15847963343613297, 1.1152200084047061, -0.6272570567634809, 0.4528797164153317, 0.47870474633457205, -0.311493952081547, -0.7777858328166914, 1.2483856036830554, 0.14741907178685307, -0.006763002249743966, -0.6466514354687509, -0.6859975643294162, 0.7997646499778781, 0.44292350324414004, -0.4570010226580189, -1.1612034727385832, -0.9648613232533301, 1.0029665632890459, 1.1035456056281883, -1.1846841519337048, -0.9513049705746949, -0.07687307092700431},
    {0.4784476657338437, -0.9219051032679979, -0.40022157025835664, -0.06327448819062831, 0.08778124380756262, -0.39905170369427956, 0.6240891510890814, -0.7709743377014502, 0.8318523383591645, -0.2581032247240864, -0.7497713488317009, 1.4535291637695449, 0.2805878868844911, 0.9418634284787992, 0.41154036570113156, -0.12057064538286681, 1.210921288892936, 0.1785093882788272, 1.4579683569847226, 0.1000784872066956, 0.5016589691939031, 0.30633668569095274, 0.7657335767537459, -0.727845661767814, -0.4908784103507499, 1.0216174754902467, 0.5854353158870172, -0.6253973755959201, -0.3816305275183105, 0.6181860088166674, -0.03740478435244902, 0.8647388414418529, -0.5308268012391638, -0.5724643049365915, 0.6001101797805707, 0.5716683231601003, 0.7586453824677485, -0.5660525710885344, -0.18822990175118381, -0.39838135356819643, -0.5669718051404199, 0.05357877899675148, -0.27489753062047345, -0.26365352345912135, 0.6157156969340531, -0.4193221884137534, -0.45303138060184195, -1.0628271573526635, -1.2872771378061265, 0.7964938979780265, 0.5778671336241261, -0.9925954210358435, -0.609562414673295, -0.8740447360232848, -0.35419294527548256, -0.500747369418274, -1.183578806938581, 0.3828593827716555, 1.5212088401476207, 0.13572697377685944, 0.8419601599044659, 0.4344028250244261, -0.27101415595946143, -0.7912199387421516},
    {-0.016272451138806234, -0.7945613456420446, -0.36483199534621963, -0.6967063331290642, 1.2571199697539652, -0.9658949870001304, 0.7445265017792584, -0.10602652020744975, 1.3932858202543776, 0.7562576246316381, 1.207475623782576, -0.2238304796560992, 0.19634179062392063, 1.4055228894274978, 0.8389398858603944, 0.373981884105251, 0.2727582151501877, 0.8626289562194964, -0.6422850046040949, -0.3587823065000622, 0.17644057427838902, -0.7537900423560878, -1.1478848043882834, -0.8111277490592953, 0.23798592538654603, -0.504699507066635, -0.7579099102054155, 0.07454287398959902, 0.41643200751232157, 0.1035070922705304, 0.3274443692313435, 1.0679019058575552, 1.384039276999595, 0.7767870217504595, 0.8845817954445391, 0.19283054549725429, 0.6744258969125796, -0.3383340986618169, 0.6439446275821523, -0.6659501602974334, 0.6407548287392668, -0.21327292546902896, -1.175341064591483, -0.3708247607971888, 0.9074942810499835, -0.6847374537195218, 0.9452557210108518, 0.16038061279726343, -0.6980141647865525, 0.9046097007983409, 1.4591802734757466, 0.3729647429273722, -0.035834809205395765, -0.15853152828611516, -0.39681897958948686, -0.2804759114219509, 0.3436701443390969, -0.4454628853411794, 0.940193894522505, 0.983804118241454, 1.2330493590715472, -1.1254193388188298, -1.0587987892761446, -0.4846356274453722},
    {0.6138742843722385, 0.0809051882891634, -0.15325528187656218, 0.8544823898733115, 0.7554403127689572, -0.3213680022678266, 0.2518112927594813, 1.000154416679945, -0.24228110266210265, 0.937558398337191, -0.45522846654549576, -0.9332446781321575, -1.2048928799964742, -0.5888560758599239, 0.3543320167579554, -0.7371866942522755, -0.4507104762090247, -1.1571611859576587, -0.960718895400655, 0.46619394290086913, -1.3314152132333692, -0.2924537724329855, 0.14307817879872195, 0.9530514648408923, -0.9122118963095341, 0.41428670884058005, 0.5139188556690546, 1.248929322973219, 0.135415087728055, 0.36347920234620046, -0.4593479695351945, 0.21507276966843233, 0.9327484490739494, 0.47679071455090083, -1.0537123415128513, -1.121375018416998, 0.6454019869313309, 0.8279113075093603, -0.9754598066199597, 0.35322366941111805, -0.5642703721623425, -0.8644799890832079, 0.3467013649717673, -0.7605068078920206, 1.07280890871828, -0.15864307791987745, -1.2199162124834202, 0.6598534328263038, -0.6753434323125058, 1.1583818053743036, 0.2600409515657832, -0.43754039818388407, -0.39691801458157105, 0.6224158643444803, -0.9220933551159589, -0.7712257826927436, -1.2695399713177684, 0.9521424106599414, 0.20310967195271065, -0.509967757730708, -0.6573759993129857, -1.0836276435502146, 0.19948940689294176, 0.06246273201720261},
    {0.13095910043987505, -0.9114419003043038, 0.05297194089991495, 0.9133160714559194, 1.2534272703852603, 0.424132399408464, 1.1211661997195892, -0.7316282785651788, -1.0515515169244474, 0.9287527593450855, -1.4442361075865322, -0.3085494373881948, -0.8970862541120771, 0.6402926714298114, -0.6728985439140567, -1.206361058548049, 0.11738761260509768, -0.2616944848882662, 0.8327183666423716, -0.5968926030664088, -0.7231200731639138, 0.9172323874665635, -0.7698461472942926, -0.11156485379065613, -1.1713928751425338, -0.10344607754818765, 0.5325726144965292, -0.43026172992390904, -1.0910574912566489, 1.3155898681153808, -0.9980887472186137, 0.729193405718473, 0.8559683848958699, -1.166026442963292, -1.009194726563814, -0.8252338849849505, 1.3491836092854073, -0.9095181089958633, -0.5655875518464605, -0.9081688025780472, -0.3874879754957621, 0.17778358533417415, -0.28189393346781977, -0.7390323056091128, 1.3268051405586316, -0.8259873236740637, 1.2419994022263912, -0.5812897503748038, 0.803737573201807, 1.1089860469543598, -0.636921213523072, -0.18465893093957117, -0.9718974782906225, 1.331994627535313, -1.1581930914554268, -1.1430070049506027, 0.6150771663942245, 1.3624331794111277, 0.8670237635572909, -1.3410672713757539, -0.8445653237785994, -1.3217841910733763, -0.5693051886248758, 0.8030175281869718},
    {0.3469828104696635, 0.27843296411566837, -0.8747257244000741, 1.2551734259313547, -0.05725815784525894, 0.1733981464618975, -0.002727387528383631, 0.01998810064240426, 0.40729567186441984, 1.3961577225009691, 1.2551778801014772, 0.07473415518743767, 0.9437460040271491, -0.06116578736420029, 1.4908086058667342, 0.9661613487433568, 1.2757907633210914, -0.9066349971843131, -0.9483103558508582, 0.0040528956553935675, 0.8457025268979086, -0.001448691492757763, -1.2388196505671862, 0.9139265740495424, -0.15453465053968854, -0.5237068836492197, 1.0477933783288278, -0.8025080391665458, -0.6035059253196378, 0.013173574502258341, 0.17075530232942712, 0.09374284930479618, 0.29775406020829615, -0.3782419867359219, -0.750309414394458, 1.3919995403615912, 0.05392927233697475, 0.43159979850590324, -1.1724446213514115, -0.7705653712325569, -0.48502254559427205, -0.7320564043904864, -0.37660976307427746, -0.7902856521373609, 0.5781221516447091, 0.13983605490278844, 1.5611827123795503, -0.31083326307042314, 0.26959342896452587, 0.07025667899100309, 1.0769342368277772, -0.8840680485017064, 0.03388471644216617, 1.0336865549604475, -0.23413510922525155, 1.4404687398714426, 0.26308914979255726, -0.14814781892817733, 1.1051597142956278, -0.5683758620121767, -0.35722330524035995, -0.09384481993050564, -0.9637352153822847, -0.6913874815033137},
    {-1.23051445952893, 0.6567069053028223, 1.237184536392852, 0.36820558892230115, 1.193398508014648, 1.1263743144536196, 1.2528196748543472, 1.203371981188746, -1.0500498736717625, 1.2511406402184568, 0.5641060989076272, 0.7410826483848778, 0.5225707533083617, 1.0477265725848037, 0.07396675042742365, 0.5599083604841687, 0.022201141032830548, 1.3425959235299976, 0.8955309036839842, -1.210223923069602, -0.29884711783796564, -0.7996037870705488, -0.3295341663035018, 0.8785371078135037, 0.28638701591687216, -0.7593498258758858, -0.2143726180279162, 1.3612117769168963, 1.0357762343614851, 0.0650341661831559, -0.9846998131136762, 0.9452989233358586, -0.9307670420553851, -1.0468267107744829, -0.0229927251501501, 0.25968159441582633, -0.5630103110944139, 1.1395524302266749, -0.8088996306121392, -1.3104327195705188, 1.047820532410737, 0.7125423836756307, -0.6277785032444535, -0.20376972558604953, -0.9434660866506012, 0.6368726939733613, 1.2311907395897395, -1.1074683494864725, 0.6076530573585089, -0.06917274952883982, -0.813773149523404, 0.32708321303385046, -0.3802835582873627, -0.8846402956438205, 1.0106050729782086, -0.4493591294573657, -0.9127697711747834, 0.6021393015605901, -0.8482613730237538, 1.1276710369175762, -0.44957685893270505, 0.08772234084207159, -0.6869328702544963, -0.12329659876466624},
    {-0.9271781033988502, 0.3043517172013005, -0.6185813807262599, -1.1335075950505362, 0.9897983811557981, -0.8196629669010743, -0.055804392708671054, 0.1694115462508576, -0.0551470676338057, 0.7960097992190426, -0.7089373413020036, -0.08092020346311128, -0.9473000484995078, -0.5294632045037918, -0.5182395022993561, -0.5298089690015848, 1.2679536236718847, -0.4590199535519936, -0.747511744311548, -0.2283076621009874, -0.5475273887836959, 0.019076081592502056, -0.5641990011464232, -0.06378672932807107, 0.07488635332498651, 0.7444195021027481, 1.0226606143554304, -0.5252776932569238, 0.20028148976160132, -0.9293386410640667, -1.0012190151736826, 0.08569931908075154, 0.19548545589978356, -0.21799468267489583, 0.9490322085910207, 0.608928394690635, 0.7056560839392299, -1.299607202230136, -0.5499221239940216, -0.6700630782009603, 1.161684355877028, 1.2251637244186155, 1.2506266746992385, -0.46687036299445656, 1.2795137443688436, -0.6057813244867776, -0.7357857315017792, 0.42803905794165803, 0.5511217588875096, 0.35540715938078726, 1.207130512359866, -1.1106668046703867, -0.7710940372795133, 1.3382590025385324, -0.7333598499918076, 0.742711689017539, 0.1318069812408329, -0.1494555163453325, 0.9896355309238188, 0.6126075964654893, 0.22324180089954274, -0.046575096117825066, 0.5774448528100223, 0.6539445757472998},
    {-0.37064741189322004, 0.06666193472676804, 0.6782871349753482, -0.4006995462068222, 0.9703482676435196, -0.8577581036556221, 0.127649639759725, 1.1859787181939674, -0.9369615702374953, -1.1041588749328821, -0.49328018725097683, 0.23835139908363662, -0.4171960202645612, 0.3422400574993048, -0.5866536669570898, -0.6706985007897491, -0.9373436678407626, -0.08843148285793742, 0.2991565880271854, 1.0254630035984003, 0.9593045790847566, -0.3292234835331994, -0.6913234049997451, 1.1039635641866288, -0.5230505898383321, -0.7788241947100573, 0.613531017640369, -1.1256293956045167, 0.5922333912038177, -0.9807488828136286, 0.9767197993816487, 0.8801423688596369, 1.0291866440404256, 1.0970520399482604, 0.7542945413864258, 0.9144599363094307, 0.2503079763713413, -0.6841228457929374, -0.45298878477214044, -0.77749914120563, 0.937835084411359, -0.45061828153153, 1.113382533049355, -0.941159596687417, -0.01008963007162518, -1.3107420817359932, 0.7178682031990241, -0.4041326865867607, -0.01631589976375215, 1.1590293070927185, 0.7239710334641152, -0.13808831545515185, 0.9178281939600963, 0.2682219722848816, -0.5342726577293064, 1.323975222367451, -1.3641843322921525, 0.9977068972604358, 1.0063800032053625, -0.7097521474198563, 0.0826463440798556, -0.55132788153304, 0.6324258726803647, -0.9975638004547376},
    {0.6145923969673633, -0.20337942761881556, -0.22017161619436107, 0.5189131886580641, 1.0118000172284844, -0.027173891099093826, 0.04078636062781801, -0.11898282706496591, 0.6798753832600777, 0.32636285710343826, 1.1028886406705554, 0.012105726790592191, -1.3341448029902852, -0.28704819266593495, -0.5249877748071735, -0.8025206357202637, 0.11408876748047743, 1.1311753560306295, 0.8416387351206492, -0.7034131535978243, 0.4276763896583002, -0.8665912592496547, 0.6788623231641374, -0.6565116594873031, 0.7049586821810613, -0.1503013659492811, 0.7449435150031056, 0.2574872954156638, -0.8861375853340306, 0.5897312406938099, 0.6115236100467883, 0.4807621663812363, 1.0854369897914298, 0.9153761607827218, 0.5727445131826389, -0.05110673593438599, -0.8717899117438388, -1.1387185149102586, 0.8836158193370982, 1.421641280529446, 0.8650104970581379, -0.8453719331750624, 0.78456609223415, -0.4718633785205518, -0.9991484696588079, -1.0465857329978758, -1.0913810577556535, 0.39533749314112565, 0.4478470979410802, 1.0846744892103177, 0.8636613810873789, 0.4195460665422058, 0.8834979420250246, -1.2158706045713878, -0.2311008888152224, 1.043096815316776, -0.17148181665108572, -0.34745212819390675, 0.2560949573133697, 0.28135776765474013, -0.5159890412700876, -1.0112756994948706, -0.9887497502222099, 0.15371769713119518},
    {0.8843630566044675, 1.2750936391940966, -0.06176440121452912, -0.9730068264908057, -0.05244822835763251, -0.6732053477515039, -1.2684201392226107, 0.5406345852866309, -0.6886044498148881, 0.7215349518093738, 1.048773230681372, -0.03741020016597965, 0.7930709755886938, -0.6783525816741881, 0.9347157072264723, -1.2678504896376832, 1.026351635982987, 1.1722649784195098, 1.507674647404096, 0.37134466569024166, 1.0727596299094087, -0.2643056999854282, 1.209652138642063, 0.8388442499235171, -1.3104540020175015, 0.1478480192810731, 0.09573526069496772, 0.1162203845030725, -0.5688558818969207, 0.7737964265604116, -0.47518307960572637, -0.9439176993367228, -0.025002985726033076, 0.3632930029189769, 0.040958055018617906, 0.019851333263916398, 1.0806679392816736, -0.13630175925839658, -0.2537715357751702, -0.6952389629586914, 0.08991074696954479, 0.11594051949176354, 0.9465560293915208, 0.32101511249853254, -0.4437078011569427, -0.9775047954027177, -1.007808689416338, -0.5901709450396077, -0.06986219214865677, 1.1363088884331949, -0.08641532226636242, 0.7048728581953632, -0.19372347217402885, 1.5357441532923928, 0.9461528876738007, 0.6951633258503211, -0.6518120509239622, 0.7632785256624938, 1.3099269305901555, 1.3584690113548854, -0.17111748795109352, 1.0890021696248158, -1.279092409405081, -0.22861191756990273},
    {0.49490494016859143, 0.21103131547253284, -0.6295899766180973, -0.9337555452333065, 0.2179067854413052, -1.4703284696386687, 1.2658020581543221, 0.16556830917293544, -1.0324023246453105, -0.43625302322023657, 0.40902091251877704, 0.8673726646660087, 1.03357387788652, -0.7526835367492516, 1.0718817485681298, -0.7626031165440486, 1.064560092247093, 0.32530433614001875, 0.16606755493993952, -0.48142453196548257, 0.6170671298115954, -0.32057063748793635, -0.11280091631077935, -0.46901599474612354, 0.9617645805860553, 0.37606480255325414, -0.07204132891990597, 0.012769651402720315, 0.5930568863105949, 0.43295343092622696, -1.4145418216786318, -0.6218983111203705, -0.41218767327709704, 1.0495883640346482, -0.2612862052953244, -0.32657606281502055, 0.029857054496585763, -0.4178616459433878, 1.1970877059930396, 1.007647882969322, 0.6852715931373066, -0.5080070362141214, 0.13952022478333378, 0.9440272749403208, -0.19806322612277352, -0.6684542112616424, 0.5926041108922746, -0.4049984968789516, 0.9431915932554388, -1.2275393848526999, -1.1623163070085745, -1.326438675492329, -1.0174814981044293, 0.11706286788544668, 1.182297300235258, -1.0319538516084226, 0.1831821074022944, 0.609716048360202, -1.4276340818039308, 0.8258264775746151, -0.30390106406940065, 0.3768013338450529, 0.8215894270334179, 0.9501872341030139},
    {-0.6042597523911898, -0.6975214267645504, 0.20646931255784923, 1.5736914241466282, -0.08479157433242134, -0.5447563376081315, -0.18625117285713128, 1.2050483744085057, -0.1797212373267373, -0.7741386327912074, -0.8996399567742447, -0.949285950610893, -0.45320335450311616, 1.0038199642263708, 1.0990775824211245, -0.7790132717058393, 0.23425352945657718, 0.8620261762383498, -0.32670175873060214, 0.8917162580675422, 0.0817953903355173, 0.8953094039209939, 0.696572016884837, -0.2711805909423322, -0.49820567360193496, 0.22532278319274443, 1.1062979586488912, 0.19778533605519266, 0.13059152092949367, 0.17470486265486773, -0.9838091952492728, -0.02378942904628232, 0.9520123298409331, 0.8220927880435044, -0.044301132816185015, -0.6135247997259646, -0.5383531118063757, -0.8692405853595688, 0.9347034137302845, 0.9261983126659579, -0.20131474735183014, -0.5173300401852094, -0.7039324471661724, -0.0342933869124208, -1.0889045354468472, 0.620407095961499, 0.0730542025275052, -0.7203297794038958, 0.14811392914500132, 1.346858849377539, -0.3880129789523575, 1.107891643497443, 0.48383370922136487, 0.8088648832824477, 0.4908166333113233, 1.1386321610492844, 0.12703566329028584, 0.12154083013631994, 0.041654206184516936, 0.5849069288091291, 0.7667134899335233, 0.09639887448284104, 0.44468326307631145, -0.918182754237882},
    {0.017463176728213233, 0.6769035339071171, -1.1404233152952232, -0.5085819968189933, 0.17776832905679257, 0.06501008798376756, -0.10459381526548524, -0.9921390742265426, -1.129151969189364, 0.5645218894062888, 0.40908753681929844, -0.16337641058385788, 0.9925365765022525, -0.734614814142692, 0.07229517741233445, -1.0440114018398248, -0.3123980176326485, 0.8759999517361777, 0.13470453540516497, 0.6934625232142735, 0.9026981283693541, 0.6688341676706008, -0.9304490638573583, 0.8080221131892387, -0.19814593744084122, 0.7705379513356134, -0.5223263014898908, 1.162494632576139, 0.22364544492207536, -0.4016935105633379, -0.7149079255513848, -1.009268870578022, 0.16032740444610089, 0.6196755905421804, -0.058023039591901734, -1.0765173648811572, -0.9313798827499091, -0.19219229426809717, -0.10868972105531431, 1.150230689269059, 0.787356386654569, -0.9809219382589267, -1.03318526911196, -0.28757710857394647, -0.17526263479813028, -0.9122520740407017, 0.8689524160917572, -0.3380460581430227, 0.5918077140757131, 1.2798841243098569, 0.9361451846112, -0.408539017726898, 0.2816726661599381, 0.44466349619860207, 0.24920920630500212, -0.5199793887314221, -0.871738028400433, 0.5474316658091967, 0.3989643100045522, 0.2641392514777117, -0.7795223517166869, 0.4721392593054918, 0.84595643176149, -0.2895150645030681},
    {1.1648767999017782, 0.6765072702531807, 1.0931161074886524, 0.9359971413918092, 0.7570101398308956, 0.7043042688790186, 0.07842838102181442, -1.1046367575072542, 0.8656441519576635, 0.4190520363677983, 0.7669077677740103, -0.0739419685071533, -0.3010110552292297, -0.41571289811650125, 1.028776998676156, -0.3867586786380087, -0.5493169475153425, 0.9926228994163466, 0.6511245778870073, 0.7891756852188159, -0.4906003650975733, -0.5366764981341535, -0.1972975755142338, -0.5797410162471939, 0.803253881344047, -0.16295229681266274, 1.255952010189884, -0.8298065522807352, -0.048485510585161505, 0.046929743076306686, 0.6622233377874701, 0.9071944494942675, 0.8234889895735436, -0.3348306984301274, 0.14659213387653447, -0.8477219010729031, 0.7757574518929482, -0.29850270914092175, 0.5756470844425543, -0.05389273176902486, 0.5282445304453011, -0.46343323003341846, -1.0352684849427058, -0.6852772051386258, 1.304561491564603, -0.40787243403578893, 0.2223158790115858, 0.010019730020025618, -0.31761020220740965, 0.4441903375057452, -0.48648267712676124, -1.068106910773294, -0.020322296273930507, -0.016327017473470852, 0.10780857853324531, 1.3357121396075238, 1.1372733890121172, 0.5660837243839845, 0.7698574914742201, 1.155053454622676, -0.04351129122552843, 1.1531056986266404, 0.169327474996679, -0.853873461231678},
    {-1.372811975883688, -0.8019655421599502, 0.3926847821457696, -0.9385365289982297, 1.0421882360933765, -1.2879385722867307, 1.0878597553299774, -0.7433195703751394, 0.3476345707569998, 0.3359728081119648, -0.9160378243969475, -0.32526146335365513, 1.0953040927126028, -0.405822382984531, 0.8681444953584655, 0.5452666316939901, -0.7187365220710207, 0.7744260535533525, -0.6530976250001618, 0.8063402726265091, -1.2789004099414898, 0.7575812656215374, 0.201795850852215, -0.1238101517720513, 1.0657904219206777, 0.6193202967216135, 1.0073334533244123, 0.7984446830863885, 0.8235618158255853, 0.8483947499526421, 1.046059640925907, 0.8031087489407447, -0.9655442779643155, 0.7911686998637388, 0.6729258264990854, 0.6034110660488256, -1.0155603042679315, -0.26671869069978743, 0.2242817300504283, -1.0666993327237784, -0.04407945342893395, -0.46016953151843326, 0.868216774077976, 0.7470242080605102, 0.5644638152254422, -1.1364888162684321, 0.7947370050304814, -1.2120324620100094, 1.1755346545484733, 0.5110360006871512, -0.8632348905737862, -0.9067529695733921, -0.7661866688855858, 0.3703556291182676, -1.1647604556201883, -0.662508489016766, -0.6773680535427701, 0.1675931240214953, -1.207187108570793, -0.9728679230577795, -0.4510096520157652, -1.0652245602024772, -0.07800988151983135, -0.5580887208735535},
    {-1.0712391222134936, 0.94026426504383, 0.3300291315701655, 0.6376081698176957, -0.5915439594100358, 0.031538912997534384, -0.1921807363008858, 1.2278832420273784, 0.9511731923137581, 0.6530913445998645, 0.31800991362478553, -0.19671555547916508, 0.2739724476664364, 0.11731464504752256, -0.07887153290133875, -0.5450272084863985, 0.15096167006622466, -0.8168352327455112, 0.17194972028111222, -0.12875153398894804, 0.5463979084367514, -0.6583391413716174, -0.4852652930155595, 1.0177196159104411, 1.2076171025217963, 1.4337951708666608, -0.3803314533286708, -0.8631363256242192, -0.3650463870609304, -0.9843437448332204, 0.17894426751612716, -1.0323830830167948, -1.1400405213210012, 0.22731095451782565, 1.1609657195540508, 0.8375763392231976, 0.8029641879208075, -0.12905019628802172, 0.21932628284779607, 0.20925618632536003, -0.773836816890708, -0.9367244144379532, -0.45994562918949883, 1.3117751045049326, -0.3838511067592187, 0.6136145522298023, 0.4113845338843531, -0.9121090474793468, -0.619128254856289, -0.7952680473203277, -0.28907031460731075, 0.19877756050997877, 0.023447991158899707, 0.09270305210501756, 1.4232365081428022, -0.5703997012516955, -0.3065867700535355, 0.9031711368379937, 0.9404242783574432, -0.7230262957942764, 0.03517274431143283, -0.8610401537096838, 1.0773758001584641, -0.6048485545435948},
    {-0.716819441750448, -0.14001471653461833, 0.20173577094373138, -0.2539281861931057, -0.09280265637674066, -0.91671891407593, -1.049549330103926, 1.196844217060876, -0.29317387229623887, 0.8355856237656423, 0.13246350263935538, -0.8833856671004661, -0.5941116233641821, -0.6462756229643971, 1.3681790666881002, -0.2216771748485065, -0.09686050227465835, -0.28088705686098014, -0.27586261398539497, -0.9636270861413869, 0.9962152583522524, -0.89741274472203, 1.179567765150046, -1.0078451967551039, 0.9846058102680646, -0.33442500881271053, 0.2068255561537739, -1.0949118440938959, -0.26266011894203534, -0.24729087076284512, 0.5236183652056119, -0.4256163584896135, 1.2901566096164883, 0.07785009243732044, 1.0369215876373417, -0.4407277801243996, 0.3697862787872716, 0.43691242294538596, -0.2344672377765592, -0.9451711766414027, -0.07698394314154702, -1.2218281090032233, -0.5604276623918389, -0.6770468993709705, 0.381893176331847, -0.7254361217985019, 0.9552279979549286, 1.09710648402292, 1.0959226053662028, 0.34976569764405674, -0.11010740099055069, 0.1554738404189176, -0.2285778392327198, -0.10838115770674389, 0.5546929386538302, -0.20810285166673498, 0.39341226031657817, 1.4623535342816052, 0.6792126710375062, -0.9519821885095717, 0.19771458957367574, 0.9834601050610399, 0.7912458480621545, -0.4200637900946086},
    {-0.10137280515015913, 0.1419696698899813, 1.0123895548009199, -0.05996223565469092, 0.264951807206695, 0.5877110550944354, 0.7622071053391204, -0.08683410274536718, -0.9613911956100045, 0.4995710448161857, 1.0427186329186013, -0.35614279563081735, -0.3832240922882014, -0.23635863096236892, 0.10709306527948297, -0.815243758821907, -0.8402998413270092, 1.1640989436425038, 1.096074372880811, -0.883843893250665, 0.44781890676825414, -1.0431960791698596, -0.28023523190798066, -0.1517947322371121, -0.16683588485468026, -0.5204785916054679, -1.0426542415821953, -0.9178327661513925, -0.6125071161355036, 0.5042196613910112, 0.22082472183297508, 0.9080228595380943, 1.0803215885419906, 0.453122606789003, -0.5445582259582042, 0.8601192402596842, -0.13733634263251146, -0.46647362141979526, 0.9547548801031057, -0.9219202244092289, 0.2636386755843509, -0.5852393571213604, 0.5211926581003014, 0.8087572444972042, 1.2859557131882897, 0.19218635223741848, -1.3035914169196499, -0.5042898988522232, -1.033849018706545, 1.246268587824075, 0.37818240739597764, -0.8358206059908615, -0.9109816213652614, -0.536979362930884, -0.9632112781719859, 1.2982166161672215, -1.3373508173358621, 1.4221369483843018, -0.46557133102598963, 0.7683794046960539, -0.7905139559894221, -1.0141295766998688, -1.0664305343521223, 0.20303039569462467},
    {-0.45714793543156684, -0.5602175925245738, -1.039623206825925, -0.2699234612396051, 0.8248746664950078, -0.9231402231536983, 0.4781062710879678, -0.5375348732079094, -0.10943828222691107, -0.5104213556792369, -0.9050398278197039, 1.0827276274300122, -1.0328373710013288, 1.0717780576949139, 1.1122731816252418, -0.7532955709590633, 1.0387504414799573, 0.6807285700387654, -0.5529859667362013, 0.12285386367043098, 1.1089129490251792, -0.6386641617100725, -0.23701241592105174, 0.09411200948155346, -0.9245607136086286, -0.9534306567468208, 0.8157218463942637, 0.35421975159590574, 0.9601132542288855, 1.1324278773901115, 0.15147670157506973, -0.35029520563875854, 0.913947477668997, 0.7646839923783939, 0.8155868166927247, -0.749647478890034, -0.13256548760833256, -1.221910199398074, 1.077787386304816, 0.7233678516232844, 1.368905188663709, -1.2691005470972814, 0.7792296266600367, -1.1397036174562314, -0.5568743180872548, -0.8775728552938978, -0.7787675813293645, 0.39569794836641814, 1.0773607006904284, -0.37133176497911385, 0.9068971847560982, 0.5587632797035404, 0.5280080356370096, -1.1210094529123462, 0.4203481441767285, 0.7747525817068028, 0.6966497296716101, 0.3125990274297969, 0.22537293887121645, 0.12101960293366068, -0.842377607876999, -0.6280190001680501, 0.23423781565278412, -1.027800199414915},
    {0.2785574287117713, -1.1068229416090027, -1.3531671727043089, -1.1560320572848142, -0.5560377672727796, -1.2424770873380282, -0.4761205919728835, 0.1923506878445311, 1.0808591164585348, -0.37913889274223384, 0.7255806287823487, 1.0233405223890912, -0.684248713018885, 0.05458818013940371, 0.31601004898088875, -0.5821268421457869, 1.1609239589105114, 0.8792281549735902, 0.7853837330405788, -0.33876636604560917, -0.821297359553501, -0.7423456517420185, 0.17318425682364796, -0.34244683030694295, -1.1035718488553437, -1.0432796899492294, 0.3045860187851887, 0.12051013940798967, -0.406860000858963, -0.6246572445724763, -0.5021316762883867, -0.6027551758056627, 0.1742169189387661, -0.661574631119815, -0.4817124490231787, 0.4128138929174701, 0.47937413886842384, -1.360774135137992, -0.2565414386108857, 1.3275199041721242, -0.3767131384926138, -1.316316249583179, -0.9534184702737082, -0.5555184492133781, -0.13770273200687616, -0.046576475037690766, 0.21048956097388963, -0.1279865121216916, -0.6717815060065414, 0.23528757209846715, 0.27449488299223573, 0.8441421424116062, -0.932777649057502, -0.37644025701397094, -0.11149781260015135, 0.4199291726830382, 0.20542859347246706, 0.22751174459379764, -1.0876837143335203, -0.2729849507491988, -0.07454176745862855, 0.8418300980791775, -0.656395485541101, 0.26560277678774363},
    {-1.1944190050437002, 0.8345095473228367, -0.22484182652067067, 0.17107479162683284, -0.5843049213244811, 0.17344476299136014, -0.6939620628599866, 1.1863212817831148, 0.922704055499022, -0.797694750996713, -0.03392115159625319, 1.037828039642509, -1.3950225878553213, -0.8734103455442678, -0.6187306940145594, -0.7531166086231605, 0.3939485671157922, -0.35697469682069527, -0.9719991724500195, 0.17192996641225997, -0.04696803880555426, 0.20031729927688222, 0.4801959856334938, -1.020332529480461, 0.42404809494296136, -0.6184101256815993, -1.2036070985882696, -0.899817750783167, 0.6717595693128005, -0.47784153003676577, -0.5671836725760042, 0.35026096819189734, -0.04610454372011769, 0.8432047587187047, -0.17525242720819859, 1.4376041269839697, 1.2959747351726651, 1.1180473829334487, 0.8766823367564951, 0.8656409891251625, -0.6389409318828824, -0.37190121496321576, 0.5088399225520681, 0.009431892408948164, -1.048610249160824, 0.14541787472711137, 0.9498402012660951, 0.37485846554660057, -0.9393669516687019, -0.4366140726062948, 0.9123568834008784, -0.459456813961547, -0.13497257407764562, -0.01752946005949677, 0.6382798506293197, -0.0843828608695543, 0.7629002098691947, 0.3248047460440607, 0.5255555104210705, 0.9593634526459409, 0.6646508605864874, -0.05218819326471429, 0.5498672653508891, -0.6470592615568578},
    {-0.41356767307286985, 1.0652982690295343, -0.3875663176726194, -0.29566094273060606, -0.1340672385336585, -0.6727971631795101, 0.46573706130561854, -0.9906333877299767, 1.0297019358815753, 0.3478351506826988, -0.8792429291902466, 0.41673982411870547, -0.3073613907132551, 1.0222653233119343, 0.40279599063618926, -1.1188016235611251, -0.9036411130848633, 0.19215819252252048, 0.7885897573126099, -0.17348551310306784, 0.7699787785614142, -0.8061619913658785, -0.9472363694776648, -0.8968976818711633, 1.2463772827208242, -0.7457866590157398, -0.04439407478872315, -0.009873899919259247, 0.046561850135518994, 1.1363867790140143, -1.029222740589612, 1.1139462266386533, 1.114679100994548, 0.0693911564777264, -0.05007567292940564, -0.031341281042707766, -0.40532635640154224, 0.7688996794473253, 0.26878601367520855, 0.4452744736177119, 0.1884858084826874, 0.6567350382139201, -0.009658272958532792, -0.34974882516381595, -1.042888714111746, 0.6270259451069292, -0.7563547936901879, -0.4590201311250304, 0.9473543916667745, 0.8665962310861526, 1.090434484981078, -0.9474127572552334, 0.9007388598231553, 0.5890844039750215, -0.5554375084600635, -1.1662730194683721, 0.9498934004365582, -0.8969219997611356, -0.07592840250598867, 1.2781458270361132, 0.3843847937578917, 1.075746698870264, -0.8995271092707027, 0.34208564412006726},
    {0.7404679163528248, 0.04459536295849184, 0.6189425066389503, -1.3070326917405244, -0.19007769757997328, 0.6019734475691682, -0.6875510364823518, -0.8005307518863842, -0.3287672862597791, -0.28468616293890325, 1.0023419775968685, 0.7820181904430198, 1.118183050069983, -0.8975003992537144, -0.4690386432052542, 0.5495847467740098, -1.0212192264924889, -0.7294603616442848, -1.1192699082784767, -1.1118334971985915, 1.0539619192820837, -0.45574117769876993, 0.54867913841004, 0.37132898106291873, 0.8461977581468307, 0.22751595018203008, 0.5590599056254717, 0.09609021897550399, 0.9853659185144059, -0.1826420698918109, 1.0200448542874607, -0.4330368224773544, 0.8032041482628673, -0.13993420920868954, -0.8612725092918254, -0.9423174460704662, -0.6101078623875578, 0.22298304801500074, -0.8497731021468663, -0.506425001278663, 0.48781090644631436, 1.2003642466992999, -0.38430415854567185, -0.7373457061647356, 0.6099151663788955, 0.3720555205620195, 0.09424615028631461, -0.7019147558285278, 1.0923173483859692, -0.2058101457799061, 0.7261536778765586, 0.49776318713528156, 0.8057870890363733, -0.4465686283339657, 0.7775101617789282, -1.0128052001572072, 0.0348134524423449, -1.509514014384241, -0.755513228928379, 1.2108918468793899, -0.9775009658054045, -0.3140054006993442, -1.3247230431566317, -1.0881055000351663},
    {-0.23246361113158445, 0.737488689392197, 0.892500308533478, -0.6514041221412523, -0.027594345980150634, 0.01626262228393497, -1.1808901052854817, -0.23894402975632378, 1.0806540921039278, 1.105219526356567, -0.43406371968080193, 1.0885039645276853, -0.7631666291834891, 0.5450532309466869, -0.6915059156745944, 0.40279889583419787, 0.9630293605906737, 0.05401158389861013, 0.8023326142707083, 0.12226486332523137, -0.001075588705382993, 0.02720247020809131, 0.6624027432545242, -1.291860477929367, -0.48966369028098505, 0.693929427345911, 0.0913217608747383, 0.39429965701612574, -0.9402660229712775, 0.40634151546915664, -0.17733806951166098, -0.5862014604033062, 0.7182763985413295, 0.2904420564462628, -0.82099023507633, -0.9588609729107345, 1.0979377025919255, 1.0530385903291903, -0.16778090305139934, -0.5857696976230994, 0.24997557343458846, -0.5313454928751103, -0.12439126956390904, -0.9184474091541378, 0.6544006403801831, 0.6118158827653262, 0.7479272096247138, -0.10218380081256576, 0.7603510615618058, 0.3042395671500172, 0.5037614446100707, 0.3238716047786457, -0.3745433901303211, -0.6929484288792124, 0.22594607021303637, -1.0016205424581788, -0.9875265734327267, 0.47179875251576875, 1.1904193907874576, 0.6490211784248363, 0.657658707114915, 0.6628918845806058, -0.48089463170697333, -0.4623607038647223},
    {-1.1763710337645419, 0.44845367581468654, -0.010098890223313601, -0.2232882825609283, 0.49161061140959117, -0.8036161878067721, 0.20012346016271715, -0.23799261641649228, -0.1179822950879407, -0.5516906410109326, 0.06613678136559537, -0.6870580145498554, -0.33221461663391666, -0.9276242436241872, 0.13740955591480822, 0.18169154761094466, 1.014647093722201, -0.9485882557959059, 0.9464318255104478, 0.6556287407856282, -0.8000184525012985, 0.8574884608972355, 0.32702459447680526, 0.0256270552349687, -0.3375325777819674, 0.4580174845851975, 0.4469463887319602, -0.24496762303854022, 0.42812183196408893, -0.8534134349179521, -0.1826069023606876, 0.7317687872413984, -1.4641015970748532, 0.04938295471097372, 0.5052352757356168, 0.6014301721973692, 0.5973235020110543, 0.8918414982119378, 0.9483903657442856, -0.6381156519401595, -1.3629898784592496, -0.6925916849650667, 0.5231720656026841, 0.683610261315648, -1.0897209302791846, 0.006555800211887872, -0.9172387163193567, -0.18219586868118512, 0.7196015855782448, -0.3315833684172857, -1.134114708207992, 0.8980324723359786, 0.6386009095655315, -0.8225699402701377, 0.11863849066108606, -0.4976878240614089, 1.1128112339717726, 1.0840883270548627, -0.6644638291604373, -0.21880900623791075, -0.11672307667101589, 0.7163896767743447, -0.9706081553085383, -0.46946598259352973},
    {-0.41059888285775836, -1.1738875002619893, 0.1825642209713054, 0.5688325023474, -0.9058958738129901, 0.4265628990063537, -0.5822294593430004, -0.7342615693774933, -0.4850400826565643, 0.030035355895030993, -1.0319077352398274, 0.22311921921521302, 0.40673516799261716, -0.036283076781203204, -0.6234154923690652, -0.7079473527101385, 0.1417708049323557, -0.16299248390121027, 0.1380022962462461, -0.5762741906452213, 0.45853756390345385, -0.8751966798860132, -0.07371305901706324, 1.194612366092388, 0.412676751286651, 0.8543264612814178, 0.03684318329881739, 1.2423150915356629, -1.120377145017856, -1.182805036942475, -1.3805385347572328, 0.8854705160527852, -0.8843127659496565, 0.35091418329126206, 0.2887874996436441, 0.7720928630761464, -0.8711343386476422, -1.2046790358296076, -0.9778989890027258, 0.8134252582239265, -0.5664887817714144, -1.3371210840413597, -0.43214319756199154, -1.0058606401778623, -0.5639855502170641, 0.0412021624112592, 0.6088871659338615, -0.2513255691151962, -0.12130904071816878, -1.13262588217817, -0.82584611199435, -0.4141450734396635, 1.104502222784411, 0.8548381143929711, -0.8266551798964233, -0.4646519553913347, 0.81119955211438, 0.3178049439292372, 0.4392453402173693, -1.3191069588297297, -1.016900817022379, -0.5406371290656803, 0.7108385249130557, 0.8875661362911083},
    {1.1421227815133124, 0.8718093807060956, -0.8765083292232227, 0.9789227264588923, -1.1748968502781176, -0.7066796589595941, 0.2274949915334108, 0.8629202473849086, -0.24330315121948712, 1.117794167892494, -0.6564184738725244, 1.1698471432732225, 0.5639967335413953, 1.0828207529013123, 1.3020840420286277, -0.6145683314164546, -0.650889675751252, 0.11413446948425132, 0.572954378655148, 0.9928596221534733, 0.8867386084722919, -0.06597069597151971, -0.5735202400164989, 1.12949769970523, -0.39058811268878607, 0.8699452933463396, -0.4912654703122917, -1.083617927508562, 0.9655406946795764, -0.42250956887820584, 0.5578302657129762, 0.8512433453317227, 1.1310428310765892, -0.16532610055118988, -0.3097930572480734, 0.019777933761567345, -0.2565973662453438, -0.6575879330835449, -0.034628054396270015, 0.5984462938356473, 0.2622767816855522, -0.9536646293609218, 0.9183227864683643, -1.0988867028053007, -1.27736733357538, 0.8554448328425208, 0.4236108657877223, -0.030355308448589573, 0.3606876017347766, 0.7891339556205218, -0.9130391451521512, 0.12894902903373118, -0.5374971157263781, 0.7254296140039068, 0.9763364952667773, -1.1482050875020269, 0.15359730039071423, -1.0728013199275859, -0.7630685500101305, -1.0960419748458488, -1.1562585287394984, -0.44016365685951053, -0.5745754292830032, 0.12771246312118822},
    {0.5625055890492547, -0.12938518863707177, 0.6285194346479562, -0.006219068692466574, 0.5144198623672369, 0.29128552558814563, 0.5982873899012776, -0.95748706255244, -0.6328025667931704, 0.18369996542938544, -0.14377854874813858, 0.3578542832771276, 0.052678414848703364, 0.7720969011996228, 0.31522297292514084, -0.5982513336524238, -0.12910093563966316, -1.2548279797035975, 0.9143765836518214, 1.3356181135553449, 0.1855364663933, -0.7797483592501734, 0.40039929994422446, -0.6185243892143647, 0.2270014883200671, 0.20537446186469385, 0.7974222666510029, 0.9102206587403158, -1.0824003021739461, 1.2834092062114582, 0.21767025768148654, 0.29813379111385147, 0.6584731492135667, -0.3178895207833043, -1.128075204236229, -1.1803176157045454, -0.9830719291291325, -0.5405289762734324, 0.8658918953699417, -0.9468598483844727, -0.03350043343463341, 0.04253107872684245, -0.8869593935983111, -0.3956771824400861, 0.767360179252978, -1.1059126341320953, 1.0621561947087796, -0.5576499180276075, -0.38226869065070723, 0.3435129994481874, -1.0876016506678816, 1.158188752659261, -0.3167688302002168, 0.5762866672420421, -0.030199208029801285, -1.1338954832385, -0.9466675057148533, 0.5454794423011262, -0.34576563999490767, -1.3136283324123477, 0.7908107170093854, -0.8889954853451569, -1.1628103402083658, 1.0309187145838046},
    {-0.45420329871298826, -0.20451309385169886, 0.5750629639615241, 1.023679633572553, -1.0054951891669923, 1.1110629788662645, 0.7481664962705559, -1.12339846444207, 0.7770733359453895, -0.7706270388685175, 0.938564312641304, 1.2959753522676953, -0.6994046612908797, -0.12972427252696014, 0.97584167619705, 1.1632951174914126, -0.3451402030666138, -1.0638822521643572, -0.5213698240993544, -1.0674139625531427, 0.5958971963867933, 0.6551808340750933, -0.3588422811307105, 0.5374939225368836, 1.2632947964361332, 0.7965444151287857, 0.2894874596248639, 1.1064205425229179, -0.4642284489041571, 1.2852392524448122, 0.21753747059140643, -0.6520081850490982, 0.521272172513764, -0.4264981006199104, 0.7499912593337649, -0.5073452872788321, 0.34168791012279076, 1.0719532147375122, 0.7231886725076838, 0.8411378010597818, 0.11377764811306018, -0.3726505333483747, -1.0699655417951313, 0.9488849925293468, -0.5098480466746587, -1.249800341031057, -0.7168723497707137, 1.126085747962187, -0.8648038824079374, 0.437663265394002, -0.7647969980129422, 0.6257902424355135, 0.33513079341488283, 0.18213939599296475, 1.0363924103611701, 1.2527358454652358, 0.02548761059289924, -1.1756654379483704, -0.675463776575206, 0.45594295821701936, 0.6439208507790265, -0.09289648555900114, -0.040154366562279525, 0.43586805754269525},
    {0.780438027384456, 0.8132546212553389, 0.644799845619313, -0.48757974156647577, 1.1677928574215495, -0.3593800996966304, -1.13615032385402, 0.5404361324832186, 1.095588815083222, -0.6707248829000532, 0.7778572080578192, 1.2267162822757358, -0.32486172340866726, -0.13255382475200556, 1.3324278463222465, -1.0237310084000213, -1.0735919857487928, -0.6828176924574674, 0.9081352987508641, 0.11387598333022822, -0.9911008154089053, 0.3315281935018672, 1.1292827018946845, 0.19266232639323824, -0.48061800031340757, 0.7000886245006331, -0.7048084133526675, 0.04344357019305959, -1.135984088038675, -0.4490812858966694, 0.4597976296099994, -0.4360622919504721, 0.8288440953146083, -0.9178001166835307, 1.3908077870242448, -0.7309214308379386, -1.0622215886518849, -0.15327528677435182, -0.5119518416354829, -0.779257195720199, -0.1902852182633791, 0.10307432477351973, -0.33900863244506757, 0.11793001108626974, -0.7680337216571964, 0.3721647949144167, -0.966051352583653, -1.1295092808944571, 0.1384920699813837, 1.0405752459253537, -0.5582936746690881, -0.2133952160703498, 0.054694180071942385, -0.04348961230687397, -0.8765686102087084, 0.19730304812316168, 0.5402309619833362, 1.0487157787652996, -0.6765471133506603, -0.04827319081500291, 0.02810316826935015, -0.8155845591640567, -0.7300533759785819, 0.6660377172471593},
    {0.18233331113253068, -0.8925653727373984, 0.1576643153304055, -1.0023309542725076, 0.9976495006053873, -0.6057982540702185, -0.992847992910578, 0.5143722339134004, -0.12855087305332705, -1.0457659751124952, 0.3727827957993754, 0.41976007900185586, 0.3049705579035165, 0.06761559821727224, -0.15751934546735202, -0.6675054947482153, -1.1140981593390475, -0.23418579085684577, 0.7978513006469014, 0.12274653101260768, 0.46300783036500626, 1.3242179011709592, -0.5082456425820088, 0.4238872869242702, -0.43732028083003327, 0.3015043805134808, -0.03632373493066456, 0.14915119848351682, 0.666966250379835, 0.12088244900113575, -0.20627379363645154, 0.4848619699011791, 0.9593549824637426, 1.1895411341155884, -0.8166355874043899, 0.35385301311001466, -0.9029772851013009, -0.7189869479833361, -0.1808751919416945, 0.186585341660785, 0.9495382305201052, -0.40040663022453804, 0.9517224230428472, 0.5430165738423203, -0.6129873136091337, 0.6754385795425438, -0.46284451594955556, -0.9714418215597286, 1.2446087273883877, -0.6491490569569833, 0.6910627138080528, 0.3342251582414656, 0.8920759588702589, -0.09363901860549005, -0.9228395154128193, 0.1058030291890054, -0.6939020595400618, 0.6160267012638596, 1.2170837415544502, -0.31980283466144355, 0.08806999523082865, 0.5323240992125776, -0.9869064494567965, 0.010685708982857447},
    {-0.3720476611121403, 0.6944398212612444, 0.6994729034124243, 0.39868315279642796, -0.8675870059954552, -1.1286945854373973, -0.050218154773849784, 0.6523441590581782, -1.0665339967715313, 0.4959766529081543, -0.4186980190059732, 0.9103654021276484, -1.0869691446767025, 1.1094133611277306, -0.5359672847482894, 0.28284064953906596, -0.9608853403593864, -0.8818121915821653, -0.37039051474198303, 0.32159224164001193, 0.7235107238812147, 1.1183944318433516, -0.17386244031284123, -0.7752401338447094, 1.031299198220853, 0.28799314716832564, -0.6723720957579572, 0.6114318950751226, 0.6374503418697761, 0.3387328333388794, 1.1279004074326686, 0.38441956682337824, -0.5797977079438688, -0.802622030190422, 0.44858683834693736, 0.6153193891463787, -0.08687934090867715, -1.0403071157293289, -0.49379082443935046, 0.6920894578618553, 1.1769966968078525, 0.8867079595880635, -0.6618060258050275, -0.8132071669131965, 0.818276625277957, 0.8353002425043526, 1.3066206257629944, -1.1017580568555614, -0.4042073253930428, -0.8896419750265573, 0.35610189619800453, 0.7915737442415569, 1.035793456464038, -0.37137145786814996, 0.9818722894367758, 0.4406580826413002, -0.3502727259251699, 0.4937975384834756, -0.9283855702110614, 0.31351696608887825, -0.7151978517423634, -0.1312228669664389, 0.3776687463759813, 0.6623698133084657},
    {-0.23428746640394407, 0.03984111484946932, -0.15331681330910799, -0.3994281634678079, -0.3850953507134976, -1.0609814035504426, -0.12764467164745485, -0.1235046097749333, -1.255228286590874, -1.0600876869139497, 0.018925137764918946, 1.1587860783024593, -0.11215877117372562, 0.03327740095447484, -0.47906614823531407, 0.9383931176795051, 0.34206771053338475, 1.323617903547334, 0.4486583984161893, 0.07006339516949842, -0.0064521446786546385, -0.17670914191844866, -0.2770180445204251, -0.44522853493465003, 0.743004682297744, 0.6470901185439124, 1.2349476125401901, -0.8286711217869412, -0.5373077751097737, -0.07596582101112812, -0.8887638577524011, -1.4605989188811208, -1.3035442589454336, 0.1344950394844629, -0.31412987103414053, -0.6392137282067342, 0.47178995513152594, -0.8162708347093764, -0.33939792670221164, -0.6565038703013527, -0.32324170364720517, 1.057041442796642, -0.2717273419521916, -0.8819599326621353, -0.08979380367957157, 1.416428357540777, -0.5052188354757529, 0.584986385383709, 0.7774480220909816, -0.3592563770601466, -0.6236312025313426, 0.3186866477465194, -1.238698483280793, 0.28070567285167286, -0.8924331629564338, -1.095917426288125, -1.0655769582564987, -0.9380037551537368, -0.3597305215279387, -0.7236361812055953, 0.3009817124378127, 0.556556529091385, -0.04587730440960292, 0.9584541033648761},
    {-0.22512943877763786, 0.9579701473911642, -0.6948895659191233, -0.5626464583801158, -1.2329535826053126, -0.36041461509755884, 0.9917806790955912, 0.4238108820458813, -0.7138567900543471, -0.32386433054905145, 0.37088727022934814, 0.22124172131347652, -1.074676523394183, -1.2531047040291639, -1.0540603366090615, -0.04439987311176504, 0.10771520843323827, -0.022886609062610454, -0.4221104050852639, -0.5361269089179679, 0.3217947518849505, -0.8337545837119653, 0.8274789154150156, -0.10074940880965559, -0.5446660323775799, -0.5612838549312592, 0.9155892187902885, 0.39557523362149316, -1.3173672607507687, 0.33630173751151643, -0.2557607034940633, -0.7157182696401304, -0.7831507930115333, -0.27970026968892225, 0.3770948923571159, 0.23204524084974604, 1.290226676938993, 0.3415731266395592, -0.7805108632968085, -0.9168549145881485, 0.7761049847489038, 0.9500942680471836, -0.2262705737789921, -0.6864192737945517, -0.680728735340876, 1.0456324625202265, 0.5231393288800154, 0.7994412225437475, 0.23174344437685823, -0.7631063289815024, 0.29040649125140344, -0.24648109996321751, 0.31175545806709043, 0.3601964362622281, -0.5177784956714472, -0.8801625541091197, -0.33519403781594975, 0.14241540864354682, 0.7955906345106635, -0.19407968660996214, -1.4388492320831239, 1.2277280296723374, 0.9539816946434325, 0.802041049158834},
    {-0.43671570798375653, 0.7973323202899939, 0.8170285468721048, 0.2537306550617504, 0.49632977100634773, 0.880549108849072, 0.9908064096709042, 0.31474853242011014, 0.7517109602689402, 0.40182890370413127, 0.9314240632914429, 1.0940110258486313, 0.13152357190000996, -1.0897955106553554, -0.8233482316780657, 0.45859172403542897, 1.0211886592384858, -0.9349144321079979, -0.9905453914303706, -0.9076690507987095, 0.44935479580273047, 0.7497438712299991, -0.014140307940958092, -0.42795289887351956, -1.322658295085265, -0.15339511823039956, -1.2492741221439738, 0.309511712082657, -1.2249086360891546, 0.7081534938018623, -0.9445825005527773, -0.07010084764549844, 0.31908702447528864, 0.3348712971314061, -1.3524841220133093, -1.2098569826419459, -0.13777574952282604, 0.18269065101063542, -0.576400082378991, -0.7681296046172466, -0.8837726614010253, -0.7857419912982273, 0.9132297188987281, 0.29742313725558395, -0.4796754178912108, 0.45475750482784255, -0.960380537581717, -0.4593426713519, 0.48850562827791477, 0.8460838821936892, -0.5243590802872011, 1.1574139352859516, 0.02756749322224984, -1.2661350802059774, 0.7089355209891778, -0.35093953689504925, 0.5930270016975728, -0.23144151269132215, -1.058721917104902, -0.14517732905147313, -0.06268184057864452, 1.3612548791432428, 0.6342035794555151, -0.8584693204696527},
    {0.47856663471199656, -0.7759839334927271, 0.9056526042708718, 1.301441395117528, 0.5554015118743177, 1.052859602167779, -0.5444095702386772, 0.7945240462826769, 1.0613569184923775, -0.9278492248319177, 1.000687815884006, 0.9230482615532698, 1.1598325068171602, -1.0926193989995567, 0.5011534503143353, -0.8624873039704202, 0.5246854392893172, -1.2382655466210115, 0.328452277394617, -0.5570259951710456, -0.20671877230115984, 0.4527736987204235, 0.8080919495817395, 0.6733789450514448, -0.18860566526597802, -1.1525221902467904, 1.0230759034283399, -0.3366274263970867, -0.8833684869226891, -1.1289402084795326, 0.6687137675686852, 0.436213723395865, 1.3580246359817179, -0.523353392427646, -0.6465066688609994, -0.2078007881833562, -1.046814174896902, 0.45902619787933324, 0.09148947761372124, -0.9421548876156715, -0.4990203161307305, 0.6071676561541092, -0.07120926918033661, 0.04380694515576844, 0.8510612093440714, 0.1899826929666858, -1.0005763038458366, -0.0985580019726789, 1.2991942235561444, -0.5586546078293555, 0.4412991394393014, -0.5976502479298162, 0.3297896476667582, 0.6227768517367227, -0.30644838415253445, 0.5544371172014605, -0.8006490220537482, 0.10219718875274612, -0.27543388589263246, -1.0453389752008813, -1.0036777890043964, 0.4454580088097372, 1.0373900038301276, -0.6162100443668408},
    {-0.3041935261535772, -0.019185861043955477, -0.46721705495590493, 0.4784875558507228, -0.4551264580590976, 0.4170070353602152, -0.8750308441380101, -1.1544946906049265, 0.5787831341131559, 1.0237574328196626, -0.6529786508595893, -1.0466542460977661, -0.7061145770289217, 0.04545917006887835, 1.2898850558321726, -0.060152796174330544, 0.9754564958990374, -0.8991995666516783, 0.17272689873069827, 0.6279852084304339, 1.0236711768705051, 0.753493142138644, 0.8847032677918638, 1.0188240185020159, 0.003725202355295419, -1.1826754312942191, 0.669300421980267, -0.8677223515450326, 1.189441365679997, -1.0510119242544471, -0.027318162171888406, -0.13582807824381435, 1.0373952147829586, -0.7784470585071123, 0.07908151845135655, 0.7431200310697894, -0.8155747273842158, -0.4604582029154216, -0.08648553597344988, -0.3378301198716305, -0.5204333974693995, -1.124622488879003, -0.3285296376247103, 0.0545612458840842, 0.9300092721888522, 0.04821135281983921, -0.07062067701691607, 0.4983300036213436, -0.8353629138590241, 0.3418271228461402, -0.8708184933489839, 0.7081945500340301, -1.1893763292521176, -0.6862585851713993, 0.9781360778886514, -0.7430076419234848, 0.17370623348336714, 0.9804783263016976, 1.2164190554204932, 0.6814766159107891, 0.3683130928865404, -0.20462939201984462, 1.0956926361876196, -0.4894502253703836},
    {-0.10198763433553772, -0.7204613892096416, -0.5779662908937497, -1.0904503111400508, -0.9030849178034908, 0.47896340526333725, 0.35643227368481006, 0.7196909650383125, 1.293467844970475, -0.3208588076203388, -0.20407636976001847, -1.279938724830316, 0.7182934494762719, -0.525471385438308, 0.7813221875674043, -0.13570570249913172, -0.4102802037200742, -0.9140016512887594, 0.5676648720518708, -0.9469453715464237, -0.8709129303622252, -0.015920159369859493, -0.14217894294609737, -0.8499115607804341, 0.8391536953602096, -0.3620919823303083, 0.27070554000028113, -0.9076047861730467, 0.34761972285256604, 0.6213105144550001, -1.160870510080588, -0.028871163584554497, 0.8231919049689378, 0.9155588935175552, 0.8375905323181446, 0.5211166036682894, -0.07953285204797489, -0.9449438466957718, 0.6211954951992191, 0.9516147186051643, -0.20430876127157824, 0.3593346564760283, 0.6151841733769144, 0.4568791913526612, -1.0793625944241931, 0.22087168990508801, -0.5720455818035897, 0.44953062959129514, -1.1391582131091351, 0.7229513000334454, 0.790568779381765, -0.25614649884962876, -1.0656523179664916, -0.9425081987586391, 0.47360007570605905, -0.3211572160426648, -0.8013557691097096, -0.10828406951444113, 1.103581176035375, -0.8914911640078547, -0.1990209375984669, 0.5421677078158762, 0.10943936556217992, -1.0316643130559386},
    {0.4171122091632198, -1.2699704149525313, -0.0850120356490862, 0.7252932111315027, 0.57606366163109, -1.3686520220708402, -1.2920562439896641, -1.2717769073388825, -1.1735508001440311, -0.3572841367191431, 1.0799849300374469, -0.6642073371832768, -0.23988819846363474, 0.6061066719354563, -0.5524260112319576, 1.0559303208288813, -0.9248859967245597, -0.17906372418128622, 0.7662516859178917, -0.18731633946401807, -0.6482552551441609, -0.34805539028946286, -0.3026470116679175, -0.6254195876172068, 1.038601792594144, 0.16858921802592486, -0.36979831004051256, 0.6004082706499163, -0.029637342891316424, 0.2697637443900992, -1.019581089317127, -0.15271569277218308, -0.260927476211985, -1.1763351348907272, 0.3275758376501474, 0.45014663793420845, -0.8980781069279619, 0.3047943694985851, 0.9214713997220011, -0.7355554957033457, 0.06071593226390066, 0.22117593142423222, 0.4899376356547169, 0.05720253268735694, 0.9973768659786864, 0.5588225170828033, -1.4010947603100434, -0.5678248672622275, 0.8825786472336039, -0.713373875257213, -0.8370183645652588, -0.7780019330792369, -0.3508880863761154, -0.8893841627650358, 1.1933392353511145, -0.21194838911808087, 0.87779940226314, 0.11419806575888326, -0.34873207014934376, -0.9514917042124965, -0.836107037100787, 0.8596567765165665, -0.05455216941323853, -0.7983861269162242},
    {0.07582640487075172, 0.6966999318058883, -0.35911852831070745, -0.850050582222261, -0.9757500716290963, 0.5743784723948906, 0.8835767687669221, -0.1465013817181305, -0.20602605416407452, -0.4630909075563164, -1.0866354140421377, 0.22020438619006596, -1.207129468099387, -1.3474415849157992, -1.2874764770218208, -1.0421006902489267, -1.138208188139162, 1.023212277911833, -1.0107616863163293, 0.9192018450333145, 0.2159277857966262, -0.8757103426691175, 0.7198044582917938, 0.17365279998267158, 0.7629104100526768, 1.017780145460474, -0.7833672125001824, 1.4501412469033679, -0.5161975106482851, 0.9303303452154387, 0.9780436803564148, -1.3661758246889475, 0.37198097254935103, 1.2333561468575787, 1.096491874314393, -1.2116848003291452, 0.3973348693207457, -0.057737599966363656, -0.7984862826149534, -0.4850390258880534, -0.8872099076416453, 0.8520784416192534, 0.1872318951117999, 0.8054651638471121, 0.5519597027196508, -0.9293286056972041, -0.8238568821455239, -0.0823173337673672, -0.8459992051468846, 1.1764215852823747, -0.2371151128817771, 0.8788686585279983, 1.1567047089280251, -1.1506465648196451, -0.9999715925610586, 0.3326642575664372, -0.5808251532143381, 1.0557733975910883, -0.5623775494807035, 0.6464908034761953, 1.2349116969607692, -1.0429125330483262, 1.2900558294368223, -0.41707037779411515},
    {0.15106556806402846, 0.7571816881116575, -0.28834404418966814, 0.47863852386593914, 0.09081825402567457, -1.3149508429881736, 0.5914978068346735, -1.136420770787894, 0.3961785463651512, -0.33942600965500286, 0.6901350972917092, -0.2322326614387833, 1.0697694913373637, 1.1109300928882335, -0.5221225541985491, 0.051606010110167015, 0.524880826611302, -1.0535898752593447, 0.24500642001540887, 1.1530747791103284, -0.07983311303336497, 0.8083312716318419, -0.6946732208262639, 1.1242819405512876, -0.4123384631385438, -0.6200675162328491, 1.0100770705657953, 0.9896025977662872, -0.9306285897107641, -0.4074338635981149, -0.0308617800046183, 0.14605849838406829, 0.49211067833407546, -0.996898796612146, 0.10466173065845112, 0.5416720718961772, 1.065885591178104, -1.009011450236855, -1.0807982351053826, -0.6095440297551884, -0.9732962043093217, 0.693573135222387, 0.2877972056983008, 0.4701203745858841, 0.6103316991771397, -0.42240144250349715, 0.0010844494858864794, -1.4833327269465721, 0.07113373866451012, -0.5481633068328916, 0.5570411979774432, -0.6262780053975183, -0.48177106056974167, -1.0698432270440161, -0.10337853538783091, -0.6879706363336331, -0.45424887433375316, -0.013742620342271833, -0.21207848451944356, -0.9204974069371815, -1.0792068673089357, -1.5831931246310924, 0.6620318222856041, -0.11806060205105512},
    {-0.6816671521780043, 1.0415438703348163, -0.9217067833604632, 0.4346726569114878, 0.9772902180587748, -1.0306675278328472, -1.0219935322360394, 0.539952874647749, 0.3507533699889444, 0.679160965692897, -0.33406524124817066, -1.1003663421926737, -0.014505049824331696, 1.3170711811428515, -0.14542078737284633, -1.316699871798463, 1.0314874829623994, -0.6229837709323011, 1.1369768964629225, 0.24870272704982593, -0.9962639047308852, 0.6518348997987119, -0.6822174684605335, 0.2697931404912945, 0.7376021970559885, -1.162702101481899, -0.06595443684473122, -0.5309156652756329, 0.32761967570194145, 0.1464885993257483, 0.013303719621305837, -1.2981406881147075, 0.11722371895100588, -0.032704078141728966, -0.8624699839300698, -0.3091031123348218, -0.18111604633731426, 0.5751756180103391, -1.1711251921714987, -0.320438942560604, 0.8991906406842658, 0.2787417675314566, -0.2562137220391254, -0.6178857360215398, 0.3917383284088428, 0.13883306212522503, -0.4142168973081951, 0.7367654300518024, -0.574019004130128, 0.9614049874559693, -0.01011602125615553, -0.556068947284414, -0.3702942634671485, -1.0940619014924746, -0.8351358922891976, 0.1319227068749653, -1.1868338268383603, -0.8955261039579652, -0.5953000096280335, -0.5312453008763295, -0.1784033356213807, -0.7370702795216107, -1.426140285863667, 0.31572524559282117},
    {-0.042305566076392784, 0.5625755609898955, -0.7226688018093792, 0.49141541251852183, 0.11714454990200165, 0.6774340871063493, 0.8593116673967965, 0.43194172325104757, -0.8330219805017275, 0.9694109109602175, 0.6635278807528242, -0.06863503397485306, -0.263129610945545, 0.7065211280983782, -0.05617530785965669, -0.3263864558766173, -0.8416395908845467, -0.830127478901737, -0.356687601441186, 0.14215786035006323, -0.61253012996601, 0.29855085327613595, -0.4360859896468176, -1.0869071042591287, -0.891771591297164, 1.2292934035222873, 0.7110734349097748, 0.859313247857171, 0.33187715960344166, -0.2947027841973613, 0.34398114765740745, 0.38516541257448095, -0.04387049535769878, -0.39090028960498396, 0.9610972924786526, -0.31706274888121333, 0.47032026053607084, 0.4935034877400349, -0.2917020566444243, -0.6757575553962814, -0.05935347012544177, -0.5930759694868799, 0.683431982528198, -0.6649479958567716, 0.3264004412122879, 0.4038364493404034, 0.8676214753573035, 1.0117877906655675, 0.02883058475081369, 1.1735478742775245, 1.2913486325718866, 1.0878713677047958, -0.946218806142997, 0.21960334966648054, 0.42955562461686714, 0.313855058751044, 0.35916310731667195, 0.11863191620267621, -0.3493946006675804, 1.0175112157283652, 0.12775368784725338, 0.1468962235529298, 0.6564933682298275, 0.18650497134185007},
    {1.0676479035676307, -1.1826604534828533, -0.4056386198526421, -0.4726477342989192, -0.17407197074350475, -0.8384414712583919, -0.8813883371070701, -0.6322752027689242, -1.4053023583840651, -0.8239591334407713, -0.7842983244297216, -0.05480892923633756, -0.6280422052178265, -1.0484252858232237, -0.6698889586039724, 0.4133371945439594, -0.17720231651837068, 0.19950286692259955, -0.08649700591380703, -1.7125639117488998, 0.8443326535627405, -0.0324211246215618, 0.8035451233331541, -0.44704260691978115, -1.2095934623301121, -0.8226430303579987, -1.7182558019618572, -0.1493617685668356, -1.0114148296597214, 0.28453249585158585, -0.11807044715939967, -1.644255615741546, -0.22881100389753598, -0.969787878502327, 0.7833821016013685, -0.8455130647800346, -0.7719450403333712, 1.2482358125455313, 0.7519425930441395, 0.6663960365044176, -0.3109503525272033, 0.16976400984271522, 0.5194771580424585, -0.2690256797724378, 0.2101935443847784, 0.9989806112901896, -0.48551326946924916, 0.23634958089555805, 1.0287618018385272, -0.10832479304411782, -0.002323434364153413, 1.0365379670133463, -0.1664164631692459, -0.2895155217969589, 0.7651630631996047, -1.2473605444243039, -0.3736455755206006, -0.36561368002885625, -0.748112223174635, 0.7766220000175565, -1.1800291851886366, -0.20108578453174902, -0.9205549361974094, 0.36348682340405664},
    {1.1657593637370727, -1.3336782189782042, -0.7366130943563439, -0.4726409425414431, -0.5643746147534837, 0.3756811685019187, -0.6501880812234775, 0.5111604742070855, 0.26678027232489626, 0.32615743274923575, 1.1664198399249788, -1.2320940589197775, -0.4294672618091819, -0.6013998895142222, -0.9804296210066258, -1.7153537593725363, -1.1738650573156553, -0.7969095001548867, 0.8371699922449395, -1.160959034384879, 0.8783176990218707, 0.22586723438097453, -0.03709194276538413, 0.005165591450288921, -0.4566345130084658, -0.9065225434899927, -1.295507218561533, -0.07702908178331148, -1.504002129820944, -0.3629094714311, 0.10432574064926348, -0.3424205635710556, -1.5620354986414307, -0.5864643676742477, -0.921230451498371, -0.26672841514848294, -1.4422251384210873, 0.9919626215327761, -0.5597361519339721, -0.3840527125492711, 0.8963515253891354, -0.022062023924186165, 0.5058511845106842, 0.834728366771274, -1.6297684577266396, 0.9078994430122468, 0.26681973687984023, -0.027875658705586934, 1.2570604588544319, -0.7879723686656523, -1.4929562518438992, 0.43575429580385183, 0.7532120387200665, 0.3647251332408869, 0.9322758245537779, -0.736667564691014, -0.36452609224869353, -0.4616699112093926, 0.550103653395295, 0.6860355701003703, -0.43285418448476654, 1.5033944965979982, -0.5048601417961645, 0.8693551902356097},
    {0.874106459087978, 0.29318263040450476, 1.2663989579815322, 0.8725633416678289, 0.03304174892148943, 1.3136259674841555, 0.369744425348244, 0.4447918113248556, -0.15864019620156572, -1.4246519435147178, -0.6028747362069008, -0.2826750661170454, 0.04099278210344792, -1.1717958069822756, -0.9843594207438452, -0.9732915000741306, -0.9115454252488678, -1.4446791068907108, -0.9814303789186183, -1.1297238117931174, -0.9089288735533019, -1.3754981597912548, -0.30742254270956015, -0.9451254572941741, -0.48801345573331123, 1.1155094438683029, -0.4333388448843785, 0.7373888930337781, -0.9124429489299141, 1.125669866134201, 1.1640791398381725, -1.0379032080663784, 0.0773770820079608, -1.2713912586162766, 1.1721360674094388, 1.1086632914534191, 0.10024234695100452, -0.4873760742804413, 1.211467053945977, 0.4847008876000442, -0.20614857753160426, 0.3222664032283794, -0.9899832983114246, 0.7274990856059098, 0.7515542067688735, 0.2764667051408695, 0.8608309144132993, -0.2330373465896249, -0.3804275745818686, -0.7333383758866127, -0.46916498289574116, 0.4488997843458363, 0.8463794592794497, -0.09497293584346797, 0.3182955936922924, 1.1148977690170625, 0.21756306747167226, 0.43745330600076104, -1.0098600997482003, -0.5647086096859819, 1.1142840131493745, -0.9941062869993927, -0.47725524255307217, -0.5223496438424039},
    {0.3294672680675746, -0.19707896982824902, 0.3102238300404536, -0.005142660112573594, 0.3778418222655526, -0.6125801882145299, -1.079930287053701, 0.5538733453070174, -1.0553254006944133, -0.2838220260879651, -0.6726373205146589, 0.43849788771043297, 0.06694403370652895, -0.7449862981835211, -1.4953095166729296, -0.1425240683626152, 0.06171005795582418, -0.30134761484458944, -0.21707695636697025, -0.7745948599352701, 0.7315593017935431, -0.44977149145133005, -0.8800049348268636, -1.2796431036376321, -1.1986188648596747, 1.4250856171276283, 0.5915902982380223, 0.21664844563080835, -1.211709470318861, -0.4895499177742353, 0.21890967144617718, -0.2089477241089688, -0.36230290201374554, -1.4197021379369559, -0.21404547278347869, 0.40806625592941137, -1.0366341265975476, -0.06194944455315975, -0.453306339110088, -0.04709338047011581, -0.8334313789948486, 0.0987055622742085, -0.3555466599025605, 0.9207813131813701, -0.4280602615792465, 1.166823492156949, -0.13814878789764617, 0.6723725990074972, 0.6475609516927776, -0.5309597273097465, -1.119447749336482, -0.4034956947943792, 0.12836372509186295, 0.40987783589105226, 1.0382520753882707, 0.8108978608082779, 0.7901229762436125, -1.200448839134908, -0.6492884377489678, -0.14463351481496914, -0.17057891510865064, -1.0008618978796924, -0.17261273567926277, -0.8156436522170014},
    {0.29575221840463606, 1.204315383069927, 0.6950698416731369, 0.9585421479521516, -0.4392341711674665, -0.5133953769627753, -0.3940430089499859, 0.7562260258491484, 0.38102538781673345, 0.9395264269599369, 1.3055672744945552, -0.14552738392066858, 0.7274509876123291, 1.0743231377142402, -0.4938136195545914, -0.701808822081079, -0.9052382303869431, 0.26684593923739247, -0.5194740478237788, 0.0014704027939738422, 0.10678217036030185, -0.28541286643140884, 1.0059256124353015, -0.1714119319386368, 0.7840330616215817, 0.7398103638820159, 0.35441254838387437, -0.18685830001674442, -0.9060408877313594, 0.2623634927333119, 1.0860387849242694, -0.6393116709496277, -0.5917894180755278, -0.10288521309481062, -0.10396348542938802, 0.13143064355312029, 0.21487969057805856, 1.4597876297060892, 0.3825027479298108, -0.04627393415507809, -1.120286445725479, 0.20636463500068533, -0.7501970294024938, 0.6738840358754637, 0.6737312639224535, 1.0551011996064656, 0.5603034178118036, -1.4740389389077946, 1.4487576725127025, -0.4178020090541675, -0.40543724381316176, -0.3237561487901504, 0.1714405823076961, 0.425112988410449, 0.4455165691801366, -0.34864236792939296, 0.1815660569871691, -0.14787099755521912, -1.0080047125775997, -0.7064549090676651, 0.9818714708039322, 0.3819286135498217, 0.930824071492755, 0.8606519373545226},
    {-0.2987567537314801, 1.1900545220441379, 0.07635599315082613, 0.05091139715212733, 0.977652410567479, 0.5738363811518539, 0.04256191034983808, -0.9516641185790934, 0.7598441922387902, -1.1922638946727562, 0.37292342515674526, -0.41063945958933384, -1.077003849906959, -0.4309974334268342, -1.2522537000504286, -0.9870556144388752, -0.14408426475099867, -0.01744844893280339, -1.1194969696583867, -0.7435544655928371, -1.087030680491985, 0.0834598033746008, -0.4137921100529244, 0.6824312690158746, -0.0836411298050267, 0.1546845026691308, -0.15572970678182704, -1.1158129499300156, 0.7751033966440928, -0.9365604667200074, -0.9255146224359897, -0.7454457275810676, -1.4728267039739336, -0.8380457965770923, -0.19883236012942374, 0.03849947227177294, -0.30921739495734585, -0.21380782884351804, -0.17318219034624113, -0.3810071168161951, -0.8211846865609935, 0.33775075748749045, -0.9697336368628344, 0.9951612400940528, -1.2594100016896792, 0.8158945011743006, 0.9841749722204615, -0.9123172411815927, 0.9543099822086449, -0.011339148329034383, 0.8118539671498688, 1.0623248791283013, -0.35028279985930744, -1.0084059504358953, 1.2094167418920483, -0.8310890675738312, 0.651467217837769, -1.3195397086984606, -0.007730816693080806, 0.308858915309821, -1.529056353805317, -0.874265031334612, -1.3334703662546383, -1.2165582897298663},
    {0.4181322740997627, 1.3047184293613747, 0.8649711984068109, -1.4122021526125714, 0.7523014117368784, 0.5381859648520605, -0.988319607977313, 0.19366988709372346, -0.268466905763659, -0.8601865305312212, -1.0358638732597414, 0.5349399955979628, 1.0954475368130685, -1.0429536887526563, -0.4758556954793924, -0.5249441729490173, -0.8273002201889533, -0.5092408247251721, -1.310143926201893, 0.9644843324548591, -1.5492768408608135, 0.08909567065255725, -0.7360620251181169, -0.6049476335618642, -0.15617498024815973, 0.017334693045566986, -1.1916448563377893, -0.9233999799552892, 0.8991689791934709, 0.26684738198910846, 0.4072339446427166, 0.43768579695250953, 0.7986950861487677, -0.18978331565357537, 1.1544597397193725, 0.9964788564085769, 1.3116754947878042, -1.0021630927479985, 0.7842269073064385, -0.9991332078587475, 1.1061195073956502, -1.3748983448157632, -0.3667917383357808, -0.38457841484177374, 0.1265902362843145, 0.6312503441764834, -1.0891250551671359, -0.4729251386785843, 0.5471229890299701, 1.2919077134817452, 0.2605561044463304, -0.9379952902481012, -1.1699718988631704, 1.3136682159272304, 0.7688689081937271, -0.43819689243308496, -1.0039240234943159, -1.2205219502396538, 0.8071199448342727, -1.020845245974935, 0.9059346877552141, 0.9669887966677833, 0.6606055662916799, 0.13033416353005006},
    {-0.127402097773127, 0.7437860792745187, -0.7211446904941851, -0.5258143526295123, 1.429817512439199, -0.19934530834093864, 0.5636450155798476, 0.6086963663105815, 1.223992918003266, 0.6658696303001929, -0.4848476655463973, 0.22166434811878497, 0.7567315254921442, 0.049981928038854505, -0.09136052609223824, 1.033998278917829, -0.2831222548651987, 0.01694533279890773, -0.6106199681828902, -0.2834324606593372, -1.064162998395443, -0.8661161099029919, 0.31878689574826086, -0.49213398766459937, -1.1010862954382785, 1.0173813552943238, 0.42002493926573325, -0.9890693759009564, 0.46490196712346754, 1.4489783956258373, -0.8343623161244231, -0.7021679609714702, -0.35612683694133396, 0.561009962384249, -0.7417784859040037, 0.042428284078650964, 0.029133568216193517, -1.2978416618943924, -0.17027734078486184, 1.2682578148653016, 0.7127252162880318, -0.40506881765511515, -1.2032910164335566, -0.6192168723876653, 0.1756002736384716, -0.7419890132495712, -0.41441862598887436, -0.9086193490678413, -0.36720622533525427, 0.5132342012668579, -0.23383282917397416, -0.948482057273989, -0.2660928223150315, -0.5949789166404141, 1.0277590979245599, 0.48874027553575006, 0.15728977287217355, -1.2301226730908232, 1.198307904758391, 0.37505144279504377, -0.40774596476108066, -0.6953302062887996, -1.09126380590562, -0.10102759376330306},
    {0.41480150646381886, -0.57943647991765, 0.16212700769737523, -0.7769963888906124, 0.477737202806288, 0.05224925741140187, 0.7866432557369272, -0.9132874091319285, -0.9524707488141999, -0.03643111742684141, 0.25418181849690646, -0.8213337085061295, -1.3088034155928285, -0.7402062387901099, -0.3542326250502725, -0.35969578565636945, -1.1147195740959435, -0.9993657407835375, 0.9507580762783302, -0.3379761480967321, 0.15846725435556505, 0.6759328377468282, -0.546826681117797, 0.00044022044814032315, 0.14457786276700732, 0.9246227772383432, 1.0135234570421792, -0.6362435591075408, 0.4880146619496642, 0.42957331651581115, 0.0062782016226589675, 0.7578359160483554, -1.4871991334198174, 0.9354341585400251, 0.2912592908064305, 0.12889370938958358, -0.13088540729790854, 0.5506921214167938, 1.1071154772375977, -0.03410410087893043, -0.922606319486903, -0.41885259983369416, 1.0909378831015475, -0.3914839341021324, -1.4803552388164172, 0.5840007083298158, 0.49197416071222205, 0.06935903541408675, 0.5670612185112123, -1.0258035749458623, 0.6151988855113757, -1.1224105456991407, 0.5925390874423274, 0.32369136004721055, 0.25419489731042144, -0.26251497403258667, -0.7004535425031007, 0.6830513871661034, -0.9660585871537246, -0.9619285834303978, -0.5775940420652237, 0.4632200902619003, 0.28663815983667346, 1.0382838344043857},
    {0.5212897405413852, -0.3801565942021286, -1.2904865262923353, -1.2162305188651743, -0.2644817268709722, 0.9968271690593367, 0.6462642169038598, -0.24842733425370228, -0.592761417298508, -0.3233664316443886, -1.2118904850635825, 1.1932559914910559, -0.11973734367630084, 0.42201826454323405, -0.07831627565713556, -0.4923847326841962, -0.5221762188778849, -0.21216520563871988, -0.29548952402115475, 0.7725937980717441, 0.5041291065269315, -0.3789777679175104, -0.22377236280608498, -0.047373134925272606, -0.8363326796354488, 0.6231622015043561, 1.2690363202566044, 0.38637041863787985, -0.8768182467925869, 0.077253313851359, -0.3611517916525478, -0.594779105307827, 0.3311227843637958, -0.39689484054874635, -0.5233978907587115, 0.5269995652890379, 0.02298897500108591, -0.927703179524239, 1.0721179455563243, 0.5217818746415646, 0.26567810714058365, 0.3688378483179949, -0.35710515934225534, -0.9705524508640095, 0.7042633493350023, 0.23826568151944538, -0.7410252948271785, 0.42731015970088526, -1.0856721608046258, -1.1543417033247472, -0.8627215179225362, -0.3714303093411954, -0.9522427327564694, 0.3283038845609665, -1.1467312236037188, 0.29244316155000366, -0.4579996167466102, -0.7194226128945632, -0.5403921936675525, 0.6562784873784824, -0.9525506198934051, 0.11789554405066367, -1.2083900053053354, 0.0394922608065547},
    {-0.3881121589812691, 0.07429277966140503, -0.4001533729470565, 1.0121707802402282, 1.2876604030071919, -0.8854740813463788, 0.4030154336774381, 0.777727903119085, -1.2021011780542357, -1.5852332845864732, -0.16483990598269516, -0.4827203444208243, 0.6779000948910932, -0.016100790742507316, 0.10376450444680956, -0.3290140513763214, 0.9754749898592602, -0.412672674057943, 0.893414321470801, -0.24196703361827324, 0.7343519338876504, 0.3757833129516171, 0.4292986483854405, 1.0611591623827716, 1.267700583919006, -0.7856212699598831, 0.6994704586695365, -1.0838096992591575, -0.5218270151480556, 0.2376007993236398, 0.540948934502814, -0.04192735090241807, -0.3659777033506323, -1.0759415578623701, 1.1205013705321358, 1.04572570884019, -0.4121417900526486, -0.589832505814291, 1.0700777696249284, -0.5397035280739176, 0.8890561925250751, 0.048949032090765815, -0.1265521010877882, -0.30865873472120237, -0.44474367463559394, 1.094876188784772, -0.05643244529330804, 0.8816769805909933, 1.3511918378950283, 0.8803346954173196, -0.12697590213566237, -1.0938204206918507, -1.0724414204611659, 0.2436637213517697, -0.1265678881109373, 0.0067862143872235905, 1.0997958677905388, 0.8403560705222667, -0.19468611580866116, -0.11582700505802483, -1.0049740460020968, -0.7798793803839457, 0.19233917449033439, 1.086560005969252},
    {0.19149441161761352, 0.42180555026339545, 0.8353819439128182, 1.5700152086449235, 1.012200814092066, -0.7185623885541998, -0.48449594743480684, -0.6699554984964281, -0.7503975787952423, 1.1726668376332285, -1.2307771313346052, -0.1481273160160779, -0.45258656559237287, 1.126765051423189, 0.11036208555088099, -0.8688738450494552, 0.25655671758916687, -0.6842999109862302, -0.7652762177080683, -0.5537907172089909, -0.47746268308786716, -0.7490081932668716, 0.602711819333856, -0.43829693751788407, -0.3179807489406682, 1.1564214448561636, 0.3117078329582758, 0.121002141520472, 0.46655556657940483, 1.2496506142698647, 0.2130567965785626, -0.8660767200282306, -0.24265115018985783, -0.2617190744434196, 1.1832106153335549, 0.9979530581948057, 0.890343648706591, -0.013439327500848525, 0.9994318316984132, -0.22829843975230205, 0.161733784840118, 0.37405898751553995, 0.13914846668821187, -0.8170840061609418, -1.1178464222915339, -0.7012579688736202, -0.08204064625314711, 1.1882177227149513, -0.046036059797282425, -0.5121353613559869, 1.4072873496796434, -0.4383727254709126, 0.5171592752090974, 1.03664158734823, 0.9112593524004444, -0.03372746274821194, 0.3015685168267024, 0.511033473449972, -0.41696209736942774, -0.7564997619438698, 1.2274902222463953, -0.5547692010071532, -0.7766833338937775, -0.2972560502521137},
    {1.0264997705137715, 0.9730042547717331, 0.9785731969241543, -0.005455261505783309, 0.958733745378327, -0.1364950382757671, 0.7582964940728364, 1.4507262225250515, -0.1564569389849707, 1.1570122520268393, -0.4050650641500882, -0.4616356550246874, -0.3952489836733932, -0.5446280134167367, 0.5987839314324056, -0.34938210367634404, 0.680727992774252, -0.8974211455978982, 0.2782593801188867, -1.2985965526783163, -0.1404228815106081, 0.900294962554613, 0.22767812604010265, -0.4656897282500547, -0.06318442637444822, 0.6090011893270926, -1.0537322089585157, -0.33250359325444856, -0.39003197014187424, 0.48250070292633085, 0.5755815847922431, 0.20895241204712342, 0.008769552824910591, 0.8492684655648056, -0.9124196413918796, 1.0177764426320683, 1.1562741293154175, -0.9748225673276876, -0.6491497350730786, 0.38349863724351535, 0.4312019913341454, -0.011055197414011913, 0.7943018446455647, -0.658438637044627, -0.9875399342604464, -1.0837418623314818, 0.7853692522821242, 0.5886715419106477, 1.1291105521843072, -0.21781864085663527, 0.18166301798761283, -0.030470178997096996, 0.2905819630453389, -0.6908736770329186, 0.23391160314166742, 0.7129214593188474, 0.9084421627913967, -0.17371924621315027, -0.11832688598157803, -0.10337250957578892, 0.18140130411406963, 0.2844800890900638, 1.051862690925557, 0.44303034844413414},
    {-1.223633832111617, -0.958408697137436, -0.7776703096203466, 0.824873237112587, 0.9852350323922168, -0.18051918006440665, 0.5256407132856651, -0.8490405367180587, 0.9021397785541093, -0.09333425291159164, 1.1384781434819577, 0.9451748295154884, -0.5014527112624767, 0.24977553694359603, 0.16299141302894452, 0.884859331722843, -1.3507274039443953, -0.5375975734596733, -0.2170786011658878, -0.2951208676658104, 0.6052897919795106, -0.3947919562408945, -0.425002988374896, -0.8911428314580389, -0.6248874541853603, 0.851842333992203, -0.3451510578300488, 0.2673325853538109, -0.5508702748665093, 0.9706353337156867, -0.06762019008555975, -0.11271782329191517, -0.11010995849394939, -0.6372754852472506, -0.6556099145126556, 0.2961284838018055, -0.468379938183187, 0.020587806145911283, 0.38522216050549224, -0.8559242470032401, -0.7121276126927187, 0.12196914411607745, -0.8698294520443425, -0.08311880973003881, -1.3256442979130028, -0.34239545561105295, 0.8089919049486326, 0.6924870582088429, 0.2539443031812369, 0.23057061890739444, 1.160555861054104, 0.47283571942098673, 0.9135119834118353, -1.3741494646995323, 0.7227835728616689, -1.0286991895911222, -0.02548369807351339, -0.20929571995507215, -1.3256880598637784, 0.16570285928674244, 0.5305651851070036, 0.5305737490324728, 0.37108842153901417, -0.6990533406118286},
    {0.008436405114092323, -0.5210622395938366, 1.0132008697245554, 1.090047109492083, 0.664664481870188, -0.2867453990396035, -1.1243947494810405, 0.6173421135527806, 0.056213327822075006, 0.7969898865771865, -0.2383203428903512, -0.5686515279354114, 1.3799042995296051, 0.20338969826412007, 1.3712721151658673, 0.40719536201644807, -0.20085874656145344, -1.1768695833655631, -0.8711753553774867, -1.4045678310420122, -1.05399722114788, -1.167974367243782, -0.8577471948055834, -0.9408135895245116, -0.16240544267099405, -0.7810478217143441, -0.05218440023003137, 0.47292147208667923, 0.4019816961045967, -0.7075172543695488, 0.5483000840989639, -0.7902531706484236, -0.622984647148139, 0.8187151366823296, 1.070461683362832, -0.7342266997366191, 1.1374583791558144, -0.30632164911459003, -0.5222949378904614, -0.250907072567524, 0.40202397794763284, -0.46555424894967745, -1.0902096046003662, 1.0557081459076623, 0.4316518711061202, -1.1129684870557068, -1.1451119454762366, -0.713773816750205, -0.3509470027977407, -0.7426913228546184, -0.8163630133228836, 0.14013284823298133, 1.2393648284254422, 0.1757407741405211, -1.1188261640163588, 0.11884392257004699, -0.7684905876553355, -0.9443284609429986, -0.39449887907062614, -0.6324461820132636, 0.12289921570169639, 0.2707691699013255, -0.5888602148742551, 1.043268693045534},
    {-0.07233519623519527, -0.9929385994949038, -0.19579786684296982, -0.8753300792106556, 1.0941406198066868, -0.8645019053644023, 1.073960938887038, 0.2929352713148132, -1.1507490160750977, 0.008275613066761446, 0.8575518150258485, -0.23342702200183044, -0.8673765605517361, 1.0989688275913452, 0.9813902269960085, -0.25058113274629984, -0.635070473118854, 0.8996050617223603, -0.009964972575087475, -0.6975676938878169, -0.28802399715352034, 0.05153731741946601, 0.721866028967774, 0.27649918361942877, 0.7947664307950433, -0.9795429179836465, -0.6782395365029464, 0.7257380580409221, -1.04779731616813, -0.1557934302943868, -1.4235288921781843, -1.359968993275755, -1.0052755387789643, -0.1729408792357068, 1.0852765972475902, 0.9624251921186183, 0.8720984644600133, 0.5837976826807145, 0.8650815794477019, 0.7243632981145209, -0.343710175366811, -1.4928760907301701, -0.8214304166541789, 1.2321611887723296, -0.5569084235907027, 0.06803886332567086, 1.2565963806278027, 0.7515398629187408, -0.9814851377857977, -0.23096734119011497, -0.8790102363455664, 0.726348102992025, -0.782285097955785, -0.9615828752705285, -0.01914788767517959, -1.1321546094862924, 0.28238511337119865, 0.23112562781083326, 0.37533999565640774, 0.020595341467497027, 0.8634635822002815, 0.8569926490940084, 0.3179929978081764, 0.8690429671334534},
    {0.3565046466582544, -0.9743399386719517, 0.9688825734244375, -0.9684590065233795, -0.7115720678583853, -0.08509981770218766, 0.24513894161033736, 0.03593021243970339, -0.4094062351935788, 1.0531229335689087, 1.0826587107547805, -0.8475958809913032, -0.00459772217406934, -0.98552621585754, 0.6544088080207556, -0.10421111826118455, 1.018601077169739, 0.45780422617291355, 0.9873567713926933, -1.1760335263788477, 0.5209072809076789, 1.2011618607356565, 1.2465077012652026, -1.0766189951499643, 0.10532068795912661, -0.4329511708762123, -0.5277481857278453, -0.7109656675733349, -0.23890800911104546, 0.7890672513411894, 0.27519448999852225, -1.2940235660136485, 0.16693032665289248, -1.0491532580213712, -0.9646625560985476, 0.3832672095136785, -0.18712008904207275, -1.0991508883681753, -0.9988091821079912, -0.02631879610370275, 0.6942684888621142, 0.5680572554236205, -1.0828531703406774, 1.1513429078503008, -0.4515647713282089, 1.1167238146114347, 0.6104638750331607, 0.967635695216189, 0.4183104811230636, 1.0512038890898354, 0.42825284012940285, -0.16848609894690492, 0.8499491724718544, -1.3173382547585644, 0.9379939107676379, -1.0904054634580866, 0.5074694088359232, 0.6221923911261543, 0.07780120018155784, 0.13482591312212994, 0.9636385971652021, -0.49037256573496363, -1.2014645524515548, -1.1593544087569863},
    {1.0818697038360883, -0.8988709208826866, 0.5605176432981456, -0.6172885365154147, 1.2803680233470909, 0.03773323625161664, 0.20374075137640246, -0.4672994245391898, -0.724763852617558, 0.4977646728281373, -0.33088450371127476, 0.703379801862311, 0.09931498084669312, 0.8593527646270227, -0.007938582088251855, -1.028517889464704, -0.02860450106492527, 1.4020656434225909, 0.16845938807811597, -0.3332484319420896, -0.20706836015154156, 0.7370152769996473, -0.6777540808775444, -0.7595574088578203, 0.6851406269627774, 0.6665397269849354, -0.621298529494375, -0.23205326339741478, -0.542766450397328, 1.1012020151591095, -0.05621000350770079, -0.6556451508076746, 0.014144771101326748, -0.04621408236854211, 0.4051025667407035, 0.09548251923763762, 0.6379830618149683, 0.09303176115364331, 0.06922757371630921, -1.1632555461901073, 0.9131418499222064, -1.1850098778479075, 0.18962605123109588, -0.6892216531393519, -0.14211132576362567, -0.05353659292527696, -0.25760028416297187, -0.9083407845979977, -0.8988465706495993, 1.1880654548466059, 0.5808592388266761, 0.21974283765928562, -0.12011749710709367, -0.31320140420855724, -0.1377048841791636, -1.070957183546145, -1.3084643513068934, 0.009802694850969757, 1.235240568369575, -0.8757312391289641, 1.257129622957472, 0.539725959230187, 0.9010272269443176, 0.6000788949661363},
    {0.1525885218179613, 0.7814260964999182, -0.6000575910176658, -0.5584496729416516, -0.0958017148113156, -0.695279661661087, 1.371866521448791, 0.8825228662159751, 1.1364572742877066, 0.4531977936196323, 0.757591782519258, 0.43889452013247193, -0.5379601907655323, 0.7594699906146939, 1.0998546362739632, 0.6694356729982418, 0.702127272448525, -0.7884028530777358, 0.4739333391673704, 0.5779524844343177, 0.5198267739955945, -0.44425499968189625, 0.8120648986254073, -1.2283551475173815, -0.5495103470200556, -0.526935408984194, -0.19801497278012317, -0.1621786124237431, 0.20473667765347534, 0.7487385926887529, 1.311174244392308, 1.2114467741963346, 1.3442412005790696, -0.5776171993754605, 0.9497022265858851, -0.00667800042995762, 0.2564083292183238, -1.0935007594229786, 0.9246001170108589, 0.21864645149272474, 0.18493031333127727, 0.47010548402492297, 0.06450056609874996, -0.02826947989622094, 1.4004556951188596, -0.05543038022676825, 0.5104226877038589, -1.1423077288839971, -1.043125754215969, 0.2491440994950735, 0.056982259387948715, 0.8335945203240487, 1.0780453519809643, -1.0366837605614496, -0.20074465211934808, 0.04215392926937556, 1.2551305662580443, 1.0489079732410438, 0.4951170199185196, -0.43685563318523307, 0.7979482313617372, 0.38059086624746025, -0.4907818008223694, -0.405087342970009},
    {0.36894718509249913, 0.1332269502251173, -0.20757526628357523, -0.04708827839214028, 0.607891747342737, -0.16669011512567647, 0.3219136681041279, 0.3762084931429457, -0.8230355133071212, -1.0401080863847223, 0.16214814828551988, 0.9813217526162111, -0.764180807866957, -1.1233322634163319, 0.33674048368215187, -1.0140962930936201, -0.3815029413948258, -0.7128814520451477, -0.2580211773223242, -0.31984087321463783, -0.8167249229309994, 0.8717642068786989, -0.8018800039992539, -0.8589188302917447, 0.4359528910885224, 1.0337820229176247, 0.7098746344746029, 1.2129014550662127, -1.240902636692223, -0.4714298077104666, -0.5560339758429257, -1.0649062975444807, 0.026937196311820448, 0.3008360373746504, 0.7895896201141764, 0.029505485119799734, -0.046465917274789596, 0.895700385990249, -0.32054375820871656, -0.3764874932890096, -1.4497681150165262, 1.0220365374119127, 0.5432558973249367, 1.0119751522820741, 0.042055591666674066, -0.6598068850102543, -0.9117354734372964, 0.6964942080072892, -0.22397161808392638, 0.08023686376747972, -0.815633319916702, 0.5245490286691242, -0.27654103402544755, 0.36340272884743624, 0.26520729501195744, -1.0285745493200826, 0.46468047240638294, 0.8241662247584635, 0.16959171502957512, -0.09837180865793099, -0.048360765951978114, 1.0334875601450684, -0.22327833207791653, 0.4745941973928042},
    {0.058237983221972475, -0.8315003833654868, -0.8248299219650257, -0.72969200624302, 0.5132093033619162, -0.6993944443650186, 0.33490618300949165, 0.2637988816606894, 0.6019610470415081, -0.7650295960989311, -0.5494622743793668, 0.015155957810972003, -0.8258033358944611, 0.5359739008543303, -0.5619105499226605, 0.12288761895235996, -0.5262839500199193, -0.9004661218922212, 0.4361043627116612, -0.5044245508590022, -1.4293758208857348, 1.4692526187909325, 0.44366090717842704, -1.1588055575003309, 0.5688884606306197, -0.5830690091431251, 0.3178697786908846, -0.026216316617221465, 0.4140397086866302, 1.3811192769478642, -0.31864412324310065, -1.1020681665656624, 1.395746451952138, 0.8254202544078645, -0.18031333391318166, -0.5094431957247822, 0.21384352642208046, 0.7524476105457181, 0.4936870580946201, 0.32775803605638465, -0.8009435376881742, -0.03465593669199484, -0.3350635925342758, -0.6645594737588426, 1.5986741697359146, 0.15824509696479558, 0.09346935001101377, 1.2142321870381487, 0.8322437359798731, 1.6306368490278327, 0.25844786373145795, -0.4643791133120597, -1.272625017786268, 0.327282648004008, -0.4455258593082434, -0.2532875800380138, -0.1495890185721054, 1.4306511636630683, 1.295524606556218, 0.35245646284073306, 1.2139053889469895, -0.1767224150845794, -0.9694320559675382, -0.6180994004499932},
    {0.47721429848487246, -0.2019089597639214, -0.43807347971260546, 0.6827657709945295, 0.32588245862562215, -0.4357027885803451, 1.4621025609146896, 1.2374099097884623, 0.5298691112617736, -0.5913959406954997, -0.263069551326014, -0.6779077963963351, 1.6184606668198163, 0.010605024470073391, 1.358740164184703, -0.6388561453729767, 0.21008064325593423, -0.3649082699101705, 1.0058969909852988, 1.024043287589838, 0.06301874300218945, -0.06274928287156605, 0.4956563121829338, 0.5078145174509301, -0.8568795305908508, -0.11159025175955874, 1.126785671597446, -0.40781990935471635, 1.3362814593805106, -0.1410355275573598, 1.1349398182437356, 1.17412386194612, 0.8934566989728455, 0.13434252325065763, -0.7864197417690661, 1.2746064960041097, -0.5499261439799747, 1.0704551129629298, -0.0639830137070655, 0.8866417959035363, 0.6581095590268006, 1.139165949935359, 0.906108405601081, 0.2776338063542563, 1.530813838322627, 0.928198258983864, 0.5355676515729499, -0.5504898197113096, 1.4671614888532296, 0.7741205352079795, 1.0993849276371204, -0.986026042804911, 0.6525430625248495, 1.5252823606363874, -0.27114749934691706, -0.4175819739008692, 0.29920659460946875, -0.940654302588446, 0.4713338552676056, 0.8130352577664416, 1.2363861462338634, 0.2252746131806982, -0.5906940464284607, 0.9997624621938952},
    {-1.0272164715093093, -1.0691794411252955, 0.5333282348055107, 0.7068967705608038, 0.3054105076095995, 0.29633024834050764, 1.528420746301428, 0.42998479381185456, 0.22083100959462967, 0.8757175364536136, 0.6922755410139446, -0.9586417157051075, 0.9638250560368324, -0.5555205573019801, -0.7531067807438653, -1.128681351264174, 1.089209309194042, 0.5311755603693453, -0.5443145909827334, -0.05225114998506337, 1.017675556809408, 0.6760866034237455, 0.669392593179274, 1.090350399039671, -0.4989727306398118, -0.9255492120644279, -0.1632996696285341, 1.172988985062234, -0.7793663734909386, 0.8471916947057919, -1.3895124225487168, -0.5099946701701512, 1.1614678870656845, 0.9232836787064387, 0.43333744340175295, -0.15995775289999692, 1.106369360095542, 0.14521894774430946, -0.9328759388186403, 0.047541278245377724, 0.9926300637733484, -0.9707411893976748, 0.9926540710447808, -0.21734013874206007, 0.9032206662796789, 0.4201131692063573, 1.0679177564634932, -0.705990806697841, 0.7074274834084106, -0.15671258956245177, 0.6756624654551571, 0.2566900288964538, 0.9629025138788176, -0.010484619775237217, 0.8456882197911056, 0.2986466778417685, -0.22214566221220328, 0.3768010456144104, -0.5238075233712405, 0.7339156824408032, -0.9303079824276735, 0.7474913368871156, 0.41413298676004623, 1.1701589330563653},
    {0.4987559699750143, 1.1043886393657854, -0.2638561590663582, -1.4698958179907962, 0.37905312289526283, 0.626302457683277, -0.39903372592906644, 0.6059251515526205, -0.4531661007020247, 0.9382242348384433, -0.3723828173903136, -0.9783006009041105, 0.33436781425715617, -0.11141907128217704, -0.12804577481129095, -1.3613703190370507, -0.35825445702986924, -1.2176414157205928, -0.1743009876855403, -1.0850762809709533, -1.4828927171797777, -0.12906646097863456, 0.1515855533406341, -1.3845330562676539, 0.7263955190691656, -0.6033406536120521, -0.7314523083188056, 0.7173999265339012, 0.6233225264098835, -0.18323289869573453, 0.6356559183651367, -0.5031530874824413, 0.759150269864938, 0.057915480979167454, -0.5497616264118236, 0.24764904801848722, -1.2442987034730544, 0.22993399103668408, 0.8782881579432724, 0.093209919995378, -0.2743273380074557, 0.19716448322373845, 0.9246359963389303, 0.9272344186148938, -0.900100964915049, -0.853180451637091, 0.33902783372482365, 0.7192165048301872, 0.8196112340188987, 0.8194778608043509, -0.9778614818459097, 0.7622265941657881, -1.2701076145732484, 0.4920022049925074, -0.7197924604915628, -0.9753469665818275, 1.0068318437784052, 0.5005954372171512, 1.0262485894411197, -0.5990028602007498, -0.5944849972405633, -1.4304637973694292, -1.1866632391920597, 0.026939332235172683},
    {0.9705282525787062, 0.7452652179757828, 0.1910419835743282, 0.36375105646795747, 0.05449585343245035, 0.46559064179109305, -0.47718229798966694, 1.050152545496453, 0.6025563858970067, 0.7119133414664078, -1.0437734253778077, -0.8160854522144997, -0.30040066148843503, 0.9300309389443496, 0.2411351406327086, -0.30176520261489204, 0.11539105183927632, -0.5110268942670609, 0.29541609605942376, -0.21504613169881048, 0.8682950211502672, 0.45064608006822265, 0.5484573656290294, 0.24547076777599494, 0.3993684236253481, -1.185519924791124, 0.8543867219863908, -1.1488564494820468, 0.4291238529038164, 1.1785669236527714, -0.3060911682095189, -0.8653029219541584, 0.4915234983854414, 0.9821752654773238, 1.0283861976562492, -0.11897020659609152, 0.6229485263414518, -0.8058527873475246, -0.29203681194963743, -0.7499216959579353, 0.35685707555902285, 0.1407057668120452, -0.5667593934037363, -0.7946762355568077, -0.1820935306758532, -0.8237507465450984, 0.6022220737539475, -1.4561273026403854, -1.1734883829746932, 1.4005891498147547, 0.5819688036431564, 0.9039237539082031, -0.48381561523945443, -0.4215623411567776, 0.4703225729542328, -0.6003981077791993, -0.9095564348205488, 1.2181731738654706, 0.7059392055798712, -0.32227267746131655, 1.2532366907318409, 0.06871461200837507, -0.6188063359993956, -0.5010945405948605},
    {-0.4794511285074305, -0.5539200785548446, -0.7014730618458715, 0.7365275548451892, 1.1741184218549963, 0.6519652162522616, 0.3855423588222505, 0.9108452053958709, 0.5630420367509598, -0.8354571325738924, -0.6411545533667503, 0.450883892254173, -0.2572632081781655, 0.6065809230554278, -0.5694946322792811, -0.16993706637830153, 1.1999171699798559, -0.9527896817094217, 0.2427969586059471, 0.5004338853210092, -0.4785553804366024, 0.7391992034396991, 0.8525902060716807, -1.0488888439991102, 0.8873103081572922, -0.6886478944460994, -0.2945737109407346, 0.05279992353615672, -0.15299095078931754, -0.10030748350261492, -0.719599861016351, -1.0730300283019185, 0.30841283514627793, -0.09782239560205523, 0.5363382120760877, 0.05350058455011193, -0.8160516047712718, 0.5015296581963098, -0.7646996086885381, 1.0660052480887456, 0.00460396616788582, -1.289774975419649, -0.9050481268425101, 0.8802317755464949, -1.3018306455168691, 1.1049412465428288, -1.270849261495152, -1.0114822410385182, -0.7152292323405063, 0.3727390138516479, 1.2869521941317204, -0.13295388956441415, 1.300580835224478, -1.3425007113097458, -0.720701019565067, 0.6495399512733802, -0.9281395765084974, 0.9975093084668919, 0.7747651077518442, 0.6751979938582618, 0.1596657624467795, 0.652645323739479, 0.15848385492218006, -0.13678087031386932},
    {0.5566670373548397, 1.1106359834732293, -1.155779028502411, -0.48147252299452065, -0.370485007101737, 0.45749986273570353, -1.1810302820330083, 1.1237797747349036, -0.8999082037502738, 0.5279711120878329, 0.2556968295241391, -0.7934853282853983, 0.9014434359825902, -1.0786676935783108, -0.7718850870727451, -1.0773377078782587, -0.9524007282278194, 0.9350313725423508, 0.4616694664678309, -0.059691391520680884, 1.0372556297975857, 0.7168338266979526, 0.7293241010502052, -1.0161273373486135, -1.544547031737799, -0.7174063920452407, -0.12156337679913296, -0.525179584827425, -0.0601815057998978, 0.3852285688317007, 0.483841560472243, -0.5981436193745595, -0.052755314359684155, -0.6540235259568783, 0.3015255793775547, 0.7860569562369233, -0.3734877454666084, -0.7362813731933436, -1.2085161208249628, 0.6209271750577032, -0.7310284651047093, -0.7319130507479705, -0.03070380198003087, -0.13635484303516687, 1.1181699792972826, -0.4668545002443222, 0.5156524048050165, -1.2998497643705014, 0.17063777074944939, 1.129138285776732, 1.491406726415885, 0.6542506467841893, -0.20088518626716628, 0.895922057198157, -0.8166869451216089, -0.929579739086175, 0.2920145028046982, 0.12902053064486388, 0.10080777414274722, 0.9935680256327534, -0.4321023021056799, 0.34748180746354507, -0.5942363613937707, -0.5092600430924473},
    {0.45774448383480887, 0.18528578767968967, 0.4617984090330347, -1.295439306327681, 0.3841737050553983, -1.3360227400570766, -0.8981117676816921, -0.8693570792405948, 0.6287329806004804, -1.1055442649306848, 0.4096734313606872, 0.7426623381691538, 0.08493471385025388, -1.2293706752547442, 0.8397316817686634, -1.4862058396826592, -0.6767774415181116, 0.633389947713164, -1.3720554894480512, -0.7876048589494459, 0.17940118815009204, -1.5766779682380196, -0.15438762506699513, -1.3009289213301196, -0.4405042463842464, 0.8778418771408867, 1.1638674721238376, 0.44581663299595164, 1.1806375393987814, 0.5570230409503663, -1.166408536603291, -1.1558900412748678, -1.24103082844398, -1.3328284763874603, -0.10701315054082955, 0.03859864078907291, -1.1482671250209695, -0.6166871196634516, 0.811396114676402, -0.03673686966944792, 0.07771048080784894, -1.236854229301686, -1.0269406587685779, 0.4569436979089448, -0.14162934942898558, 0.9884456808236638, -1.3126834871342772, 0.47547311234022527, 0.1083447655924597, -0.3417374948171416, -0.4997963267756217, -0.4426670311627413, 0.15602926640247786, 0.7255215953580284, -0.6432855741482435, -0.30991855270498325, -1.0661582994214271, -0.7049084201905642, -1.5593525840125686, -0.13794115990561656, -0.806812729069485, -1.1282380424163898, -0.037579043229064454, 0.4651047644412254},
    {-0.30859137205389087, 0.5522667128623866, -0.28962320884269105, 1.306148231233662, 0.5491429800927811, -0.11864686070519519, -0.6745993246873849, -0.8194102236065303, -0.5989508476730426, -1.2530548371366779, -0.7335496571779508, -0.944963419599764, 0.8705735139726462, -0.7128677065716867, -0.319361663662048, 0.9799892471092708, 0.47118885516550035, 1.489703005529348, 1.1144408635258, -0.6895017758593585, -0.41575823557988806, -0.7349169665533375, -0.565507638255585, 0.261414720127952, 0.9378414084823962, -1.0752277686181768, 0.8513504972680068, 0.07816628672717549, 0.9274622483626935, 0.8647059966699265, -1.438021762567462, 1.1173058503606905, 0.17823189769634049, -0.16012485250484668, 0.6687609402969096, -0.6671615364974436, 0.3570066827468412, 0.15985746249664387, 1.2698740421314507, -0.4684290084348078, 0.8537014199140228, -0.004074363673833541, -0.2211333019827652, -0.5385857004057483, -0.8440449684428533, 1.3205428035417548, -0.25892755664436157, -0.11450954204737457, 0.6987069804945703, 0.11352848090453709, 0.8606173487748165, 0.4599078032535515, 0.25222326917907256, 0.23318995166699033, -0.5742513343795358, 1.3591350256750667, 0.6369031720009287, -0.747969579902143, 0.9817869806490734, 0.654496665040698, 0.5674152373789851, -0.05277691546061986, -0.9853004324121439, 0.24446490912689425},
    {-0.7948781403750453, -1.000751568614182, 0.7717403110507133, -1.0285516542031523, -0.586066205940049, 0.7866566503802321, 0.36100491467158363, -0.7667016473903493, -0.2515033689426161, -0.5517733650166362, -1.369624359414414, 0.1404342547640278, -0.8785618027529362, 0.35782712898617136, 0.3492089867151965, 0.5822776623942553, 0.716790059695649, 0.50672716134488, 0.9361686822940547, 1.0805083186096527, 0.19911519126456104, 1.150136538008197, -0.5772460740780968, -0.8517722925851265, 0.7733753654673502, 1.031619324352686, 0.4897616062470134, 0.36697375449312825, -0.6218027628027574, -0.9594948143672483, 0.35904162294091674, -1.3717594083911255, -0.8186191804583307, 0.7361994761713978, -0.59925321396577, -0.9595567946717501, -1.2251184460898472, -0.927432346047846, 0.4503351055205771, -0.5890470145864659, 0.4816567031311588, -0.7994407161729189, -0.8608097651426265, -0.3318475299936308, -0.33336788460854794, 0.295656190683581, 0.21429334313448137, 0.8759163124872166, -0.6742660991355329, 0.8323843692429326, 1.3351303727615778, 0.38134036946862054, -1.018480606708939, -0.4291007562543612, -0.7780573712352937, 0.1129668943686963, 0.645700120422599, -0.9023520620542692, -0.9351085704284303, -0.173342117070396, 0.3216746407273438, 0.6000971921656423, 1.1779939281189036, -0.8264068967060697}
};

static const float b1[64] = {1.5770285972532148, 1.486448438658514, 1.0698397632399868, 1.6632918145090623, 1.41453288645658, 1.564699397196472, 1.2248535768632047, 1.4314685987942024, 1.350967540557479, 1.5195236186163905, 1.6598905538703463, 1.464420599242437, 1.4371249262295382, 1.6151836792647771, 1.4091453320016099, 1.522893321925136, 1.2722842191052914, 1.5406629722946608, 1.2746819248094037, 1.56273626113015, 1.130736228833838, 1.35993900964186, 0.8243688627171274, 1.2415250604362036, 1.2562000604239356, 1.2438774887172062, 1.2038879632189887, 1.0758454523985082, 1.2497907303167313, 1.5667192316192757, 1.4318327812158422, 1.2724735851907107, 1.4292501380986442, 1.2287671825824664, 1.3551588975440845, 1.2830438780616404, 1.3919545119608572, 1.3517721976468027, 1.1327931898804477, 1.4350556395127387, 1.4079948703468277, 1.6339346626104534, 0.7380246823191868, 0.8264593087917917, 1.55020223150499, 1.05022527506244, 1.5089494777778047, 1.261903344395675, 1.6080761930586704, 1.4229924651259303, 1.5531747461886753, 0.918829763767099, 1.558564857068778, 1.7053685203282014, 1.364566959997988, 1.5558297312615847, 1.2645823556673312, 1.6701580421300497, 1.7649351046227184, 1.2541724534379037, 1.6778698452543521, 1.4552302079796726, 1.0794815504490258, 1.246655923304043};

static const float w2[64][32] = {
    {0.69927781161565, -0.5686386011353831, 0.5853479104649341, -0.9321147401343812, 1.9457844846082426, 1.6233605728770373, 1.1291462746892267, 0.30776746558943, 2.0254197323485483, 1.8532391938632062, -0.034323369843185146, 1.1556875539419207, 1.090143537865408, -0.06693492849762257, -0.49239893912605187, 0.7073573024905626, 1.5750427929211606, 1.650724041478081, 0.3267904716454508, 1.7573436948909085, 0.7592398422102075, 0.43446383045343295, 2.034715465739974, 1.3562509036302937, 1.0145104671180212, 0.568636099104187, 0.44194906478095014, 0.7519448160886817, -0.7809173209662362, -0.05456925271738367, 0.09943693881263606, 1.4486596090372788},
    {1.8066881151732566, -0.1869150639337809, 0.740918337927526, -0.4577943001598004, 1.8600371213259768, 0.7915176511500716, 0.7675666831570461, 1.7342336916788323, 0.6257624949540583, 1.265628537391642, -1.0211928807523079, 1.2341468581412753, -0.0527158804685286, -0.008615725652190912, -1.032683251798416, 0.9485531100125602, 1.871001519642469, 1.7350020955419447, 0.26024737049341834, 1.8135254828474126, 1.0391866476681164, 2.129115729883813, 1.9306684741470017, 0.2959306984999823, 1.120533059615786, 1.252248464787824, 0.672607530901161, 1.9805927432057573, 0.811553756694249, -0.8135650800994125, 0.3619600155307145, 1.7823876696012373},
    {0.8394779611781606, -0.41458099549670446, 0.20065664050165138, -0.4347845982357114, 1.4014803447091744, 1.1493267609244662, 0.25078975859286884, 0.9769192690547884, 0.30065014031446746, 1.6315081079392266, -0.6461927762735644, 0.18440319117665943, 1.750445323619343, -0.9139975012886632, -1.0062606235735962, 0.29800768178891673, 1.2237268752875505, 1.3499400691584929, -0.002050037122982986, 0.2716980671787897, 1.4215917161538896, 0.25780209396799075, 0.7402359147091259, 0.5092918625855607, 0.12854418251237434, 0.5563781920212815, 1.4142746040246412, 1.8733159586919432, 0.7453013942925926, -0.20884859344142412, 1.7591733993789862, 0.15823238216014401},
    {0.46293650636337763, 0.07136996280948454, 0.5322288953587446, 0.2599136184996243, 0.8317828009429735, 0.08622138245231363, 0.3510963211382075, 1.232552543674567, 1.6280058155792443, 1.8387508846804195, 0.7031367821414825, 0.4664986324731516, 1.8887678224843316, -0.5694645656472216, 0.7569057916464009, 0.040548897059840903, 0.41920474903915916, 2.1694024432994476, 0.375545955802435, 0.7731059083010291, 1.041632322803814, 1.4889594208917891, 1.580219543784038, 0.8434828081213338, 2.0134334436459445, 0.5440600072150371, -0.2564201812514471, 0.7178887256828027, -0.4077136292939779, 0.17547911029319574, 0.6145905721217312, 0.329298725646857},
    {0.2729661464651976, -0.5704090257626793, 1.7354193023395235, 0.1762953245083222, 1.5627422097331876, 1.236412593329425, 0.457670241175495, 1.1899778738775577, 0.2864091877753874, 0.41979685539399425, -0.2329879927406932, 0.8208113237847671, 1.3753465937632825, 0.7224477106447565, -1.026893871420359, 0.27731279261909814, 1.3351104711346027, 0.9183211386128595, -0.19906435668695907, 1.7760782524669363, 1.3963653736768626, 1.013725896062779, 2.3251648702762218, 1.7584871122446386, 1.0266491959409867, 0.15096071978061418, 0.4396194972733682, 1.1264151627503247, -0.027994430690435113, -0.5224518872200117, 1.382039222772281, 1.7656985780973429},
    {0.8464064858165748, -0.4660124540039994, 0.7903051999678634, -0.5052514163325929, 1.1938877814349247, 0.9087699699462868, -0.2920145977242752, 1.7334183590206518, 1.6944681103926504, 0.4711897980409635, -0.15048835390081164, 0.6897813471071299, 0.8243536610694605, -0.1988701122330161, -1.0585626262322119, 1.4295746604155928, 0.8438012017006971, 1.2304245548069528, 1.0424499301370849, 1.7934641604139494, 0.6449559355028981, 1.4607656264395075, 1.6958974979922865, 1.96793759190738, 1.3050914538261382, 0.7771303397382573, 0.4773368497082803, 2.1603698692513698, -0.3603590720016613, 0.37223449138596315, 0.6851351181664216, 1.472484911536274},
    {1.1098987066619108, -0.35664413583038856, 0.6906297348540374, -0.32275129459799506, 1.9441702950710456, 0.8868599667428145, -0.37327985145367226, 1.0512597311857963, 0.27634041816244836, 0.4653981085084696, -1.1494280556994056, 1.5176724095480982, 1.3287701926442654, 0.5531875686017433, 0.23278651722598542, 0.7151880459276112, 1.8004317910389007, 0.5789191437594696, 0.8796701479836272, 0.9659693735064402, 1.7283134840736072, 1.3098968438483145, 1.5124336627017914, 1.7318344315653706, 2.1341230145999006, 1.212582990140378, -0.13102308028286874, 0.5239041334458762, 0.6804749087798885, -0.002416371503617905, 1.8920801700754994, 0.4801402630819691},
    {0.3056130091054514, -0.6485398592954351, 0.2765437843029715, 0.03602189737984102, 0.5271226136331211, 1.5846382299072064, 0.0017240658973584479, 0.4496343595598756, 0.4903568069467517, 1.9868404061599318, 0.16570965502739052, 2.0569501192715878, 0.36718885020707753, 0.1867770332366126, -0.4899532608773591, 0.9222618368084916, 0.27745181750222636, 1.8869013501418392, 1.611892382825979, 1.4864240389440648, 0.15786096082574705, 1.7958782492915448, 1.0564914790627364, 1.9116401031147534, 0.5160955845996021, 0.503352756700807, 0.8021829589693529, 1.958118059640167, 0.7034965431609891, 0.2821235394354256, 1.3529090858246777, 0.6574827758020112},
    {0.30290682481209097, -0.10063199321044045, 2.053759760402125, -0.4415739763858875, 1.265135113746123, 0.2412627684545093, 1.283349450627149, 1.4286333611754654, 0.9315693393149463, 0.3795990646877973, 0.3786032916129637, 0.5672669061492994, 1.1054706816373367, 0.6165884400255541, -0.5615123598019983, 1.7291454226710479, 0.9905574131473395, 2.0271805089660284, 0.64533694664218, 0.9184502404033137, 0.5686404189602234, 1.2258966051776927, 0.7047887315279422, 1.4534694303623785, 1.646438421252254, 2.0741371755233464, 0.6825767835389296, 0.5772157185920587, -0.5233314703827526, -0.6146411667361592, 1.7445038600171818, 0.5303385736823985},
    {1.3345179368461946, -0.09218764459941599, 1.3844419492673445, 0.3692789342825119, 0.5829067399329223, 1.1460599155243922, 1.5602577103307282, 0.6744610303469978, 1.937421090484864, 2.011054341076178, 0.13038294262259123, 0.8485715883331332, 0.16911122191992115, 0.7306924631425034, 0.1673651582129716, 1.8546841137367247, 1.5635455407924432, 0.7190161411703975, 1.4742661654019829, 1.0076975795768526, 0.4152343937262938, 0.8519487824306085, 2.0496844498666844, 1.1649959115055484, 1.6459893331426119, 1.7203441154792156, 0.9886629657423887, 0.7763275464935696, 0.8564285893410363, -0.2658082841931254, 1.1312348702696342, 1.026813451478992},
    {1.3546589188807419, 0.32945171197508816, 0.9031920049203385, -0.300758389392733, 1.5953726796706205, 0.4997405010234287, 0.6403150723304796, 0.5417271597682032, 1.490511356962629, 1.6480507170392258, 0.3624370870311683, 1.1273880965932117, 0.568858359171054, -1.095549322473273, 0.6192047696256385, 1.2321697227847743, 2.037612050119523, 1.8001420633355165, 1.4163445593916968, 1.24725392290198, 1.8295831954118058, 1.532226345470795, 2.2531454916233695, 0.8031724772869187, 1.3207545177641085, 1.9663748378266324, 1.2979511018766128, 2.0752573715505296, 0.0864668281071621, 0.12121863228167874, 1.028990600962923, 0.44438510453535357},
    {0.7398890086343828, -0.8923334443510319, 0.7973291124251713, -0.09406934113235173, 0.945031991828794, 0.1171901104315987, 0.05387448512072005, 1.1887449014652978, 0.1745581365769636, 1.4576003400534465, -0.07698885078699107, 1.321475051608266, 1.4605420071695696, 0.3797779490715608, -0.926294441117083, 0.03274181386355649, 0.8658800364864571, 2.043007609287882, -0.11762959773643929, 1.3377889777218426, 1.524190323842426, 0.8346860285677743, 1.5746495769949282, 1.1889910603113447, 0.4910970462243249, 1.1712565525687746, 0.24279274190436811, 0.689193744170789, -0.5540273208091283, 0.6433973704270993, 0.09472512727983882, 1.3526052186084974},
    {1.6569962285269562, 0.23143966409552716, 1.6196587087313357, -0.40341359763051177, 1.85851484220203, 1.4577272304248572, 0.6986838988171868, 1.4936611310255683, 1.238888765828092, 0.2017106122058716, 0.11377394830798639, 0.19452087441418037, 1.0807598231537772, -0.7978747317282282, -0.8977020700693167, 1.0499297414620206, 0.7157689615782512, 1.372831762435145, 1.4618232246043783, 1.7998532916148873, 1.6122207509651043, 1.2738693400838719, 2.3402891594279542, 1.9781774742012346, 1.7223289492433909, 0.5568608215077558, 0.9828077648446408, 1.3465010634167864, -0.6049467582306858, 0.2006001947612277, 1.4705556966201656, 0.2842683510152858},
    {1.7236028821435878, 0.523618553564727, 0.6757166599137132, -0.9848962572762545, 1.6251132233473577, 1.1913162103792203, 1.3852935947759277, 1.4570185992555764, 1.8866506104863257, 0.7848790560899669, 0.5466427447978203, 1.0369712588319935, 1.0697254908404175, 0.1752653541786886, -0.953769478961162, 0.8669304863388835, 1.0649269649086284, 2.10514924829906, -0.12590076833735178, 0.7370345558757914, 1.971837380219175, 2.304497283724833, 1.3195386789993035, 0.371750261877936, 0.6325231719386626, 1.9865764866812585, -0.08501547763399284, 2.0872350523787726, -0.19994562287775525, -0.5794462210635488, 1.3698184803130051, 0.143618321523072},
    {1.2305275372636428, -0.37076773035955685, 1.7917874195482755, -0.4053074049419578, 1.0862792553396379, 1.6060803176321767, 1.345116266210147, 0.34495908327379127, 0.8428658473512292, 1.5812633296073717, -0.31656507306691134, 0.906541467532626, 1.6783885902846538, -0.09076956300232812, -0.7665595719678852, 0.9348724548434255, 1.5184978529984103, 1.4402836002905552, 0.6445890039130623, 1.6098677546353206, 1.7794579006298645, 1.0937234708621522, 1.3337190176859985, 0.3202753232046913, 1.2502102380707023, 1.9568255124321383, 1.2841908956369599, 1.024618056235877, 0.3024081506721944, -1.055995068917726, 1.399740914776691, 1.3489325698416024},
    {0.09530189869412287, 0.2745376518484088, 1.9671329107480782, -0.16560940296311796, 1.431701989725288, 0.6471045106403467, -0.061234976496213143, 1.0606853596653179, 0.6149638017788038, 1.1507123267408506, -1.0342561686339184, 0.13011787317519408, 1.0586825653004919, 0.12246846557578407, 0.3031920700392922, -0.050295124564956446, 1.5158151541650513, 1.1254950350032165, 0.564247693953164, 1.528801440518392, 1.6933314399809856, 0.5238761992698663, 2.0359632684852236, 0.8852120306891076, 1.7274944600349627, 1.1768081349007962, -0.17393862495599344, 1.4155303993414643, -1.0038638251955787, -0.17605670728455103, -0.029962481067932215, 1.5006764237857044},
    {0.5888387004060216, -0.3298738879424827, 1.8145216363118624, -0.5870022803655314, 1.9635257151575307, 0.48539056296258104, 0.2733028627327803, 0.24509163066304576, 1.0765393297265404, 0.13557728038815325, 0.5004994166747714, 1.3111381739299774, 1.8957764724618558, -0.17831977780523972, -0.18676653632056223, 1.021663556871521, 1.6389857676910744, 2.1265454449244188, 1.4492711290861278, 1.4996452217430594, 1.3401881586756654, 0.4387771045214789, 1.3847360673132267, 0.9302110362181254, 0.37118117704950315, 2.0377084480544183, 0.6351015913081107, 0.7568504066374165, -0.9832794913512045, 0.7136081703529045, 1.166467648401492, 1.6240528673110757},
    {0.20366221051869732, -0.8675995291901624, 1.4014732491285842, 0.03707118364364783, 1.5836239003771369, 1.952680631389076, -0.3144398380125961, 0.3647010479622907, 1.2241201876714514, 0.37998616034771243, -0.591250037239276, 0.7604137654515768, 1.255798200475153, -0.9239632719087689, 0.13609915811048034, 0.2976123159538908, 1.662027331371174, 1.3566288147425445, 0.025913217694461352, 0.5097240977799762, 1.6269893530572277, 0.7123695546244105, 1.8822304008767232, 1.5456144007600765, 1.4161782742703648, 1.079190868448825, -0.09145709450839191, 0.7454652104224183, 0.6784003526462032, -0.027004823171964305, 1.817230621061618, 1.2477056519482643},
    {1.6883888481633094, -0.1606499567812403, 0.6935822449955772, 0.5768079054373055, 1.1962318790334077, 1.2464820779162924, -0.33009874960990676, 0.16279143227810502, 0.48451963873813386, 1.3440441323703245, 0.4137571086842589, 1.4589197829351535, 1.512155027517136, -0.3227597652509298, -0.8863891821896748, 1.6593210473197229, 0.33434523603997784, 1.137712124962331, 0.2733871121358413, 0.509584736239192, 0.4932118435050174, 1.232817524759197, 1.4120998804390823, 0.8540655682722, 1.0103628152468933, 1.8656736197380457, 0.9276734327334931, 1.2680815199773028, 0.659495692064181, -0.8428008681860093, 1.0277581025719396, 0.9585478992620541},
    {0.45124078190456235, -0.7664683031483552, 0.6855215176073796, -0.29686640691210003, 1.6058220555435239, 2.012881616059517, 1.3857555111023288, 1.6294971912317309, 1.1996797192987338, 1.619869956157587, -0.7325232702700191, 0.696365194621776, 1.6501448161419618, 0.17347243402254733, -0.641688103643686, 0.5001477681100551, 1.3491220419921144, 2.2685406806222796, 1.6270080203109525, 1.2970579576016386, 1.2359354091342583, 0.5858110023669332, 2.126755532482729, 1.6916915936632413, 1.7590650258184342, 1.216866936243401, 1.403161545529793, 0.6766218917196347, 0.4604712790361394, -0.3771861525448821, 0.2180997155452742, 1.7165736629849178},
    {0.9518119832383611, -0.08514312454529828, 1.508696910165625, 0.2792439017285788, 1.4460817050505748, 1.509048175706194, 1.2719985408293168, 1.600444392863683, 1.2524798985219516, 1.4405371960172275, -0.09389947875011921, 1.149578066610733, 0.7664043625290121, 0.6214734171370194, -0.8369012413481222, 1.0572232256274408, 0.9439275520835977, 1.8173160905235681, 1.2184557001451861, 0.09299238026790545, 1.672539107214356, 0.22788295937934225, 0.4513538199524443, 0.30134950471305055, 0.8618077940735135, 0.1899588658278676, 0.8724990451532603, 1.7581130480743352, -0.47502906870431083, 0.25887985488777643, 0.5308177591114265, 0.4409225396509224},
    {1.328877629560609, 0.7354144105622779, 1.850146714000032, -0.0775605944632475, 0.6729934330036391, 1.1110822561399802, 1.1183637301120841, 0.6808430128237583, 0.7952836167139724, 0.4834437477303646, 0.48725105063762914, 0.3270603859110314, 0.23244315897928727, 0.4933279212688016, -0.7892223192739035, 1.2271240560854444, 1.8066942577999683, 0.6862578539295165, 0.5937622177876372, 0.2567494863686535, 1.7556474174858314, 1.7473334847478281, 0.7737245803035182, 1.9255444454003021, 1.4799466326890802, 0.4332709753683899, 0.5646116489052819, 1.1141223387515042, -0.2674311081813853, 0.38133561100265984, 1.5642856589604601, 0.7928933630996565},
    {0.7638200325406381, -0.07532985901052547, 1.0770850354662964, -0.7320672240402709, 1.935809118789141, 1.4010263559270995, 0.14327786611170368, 1.5497858512315983, 0.2217755657495688, 0.39379226354359215, -0.036099324501883835, 0.3537757981053386, 0.020567738720776392, 0.8107573527912221, -0.8359453543332087, 1.032307787323473, 0.768622078628366, 0.4666269089234334, 1.6236467415270561, 1.163832420937501, 0.14575927735425379, 1.441852075668498, 1.1211067806401114, 0.3608000820999032, 0.635877530383163, 1.2461663769937124, -0.023234167192200707, 0.9766556174499953, 0.5699146697948447, -0.7770518646369324, 1.347199813475392, 0.44866489163689516},
    {0.12242380494378054, -0.37028356409844204, 1.5598888910403261, -0.06544965988321716, 1.6574918512328292, 1.111321168813795, 1.1766450026855084, 1.0906168710048143, 1.3468584424475356, 1.9297999510659312, -0.9827432794659869, 1.515990384362108, 0.6914093980935576, 0.08959135386297132, 0.19975850381238594, 1.7290620635931395, 1.3139201611278828, 1.9886712510192524, 1.6909483853122167, 0.6673963694401245, 0.6179451183382255, 0.5282792592569959, 0.3921534476652574, 0.18454978164117317, 0.9519490153294965, 1.3959610931884068, 0.14507849140679413, 1.3324439929251974, -1.0463088796556028, -0.6076962230890988, 0.08659877355996894, 0.6183212053235476},
    {1.460962484357396, 0.8128654016017255, 0.6723534540941726, -0.305357553337041, 0.06310118699746113, 1.5881893689238615, 0.3643018324077492, 0.3858394645156513, 1.3090048605458262, 0.5854063258372053, -0.5310531598396822, 1.2694126321627477, 0.38086066022798415, 0.8503674887270395, -0.5931147499270396, 1.610597462770617, 1.6375693569529695, 0.9378665767904174, 0.3574478879287323, 0.7649424813382744, 1.2827117587463728, 1.4468235235553142, 0.4574432018182085, 1.2628882425862327, 1.76364781798871, 1.2272685987288219, 0.2585482128318951, 1.7527411337552192, -0.7117513612610245, 0.4643412880868933, 1.0836976385369685, 1.591229567953746},
    {1.6886046481639616, 0.6326695337663054, 1.219646101078698, -0.7582054634658025, 1.1143918364034684, 1.619634125716632, 0.2905476272428228, 1.5733017888836005, 1.169260170465723, 1.019602374796574, 0.48159669295061946, 1.7546388285476358, 1.5788685177190345, -0.45168201541861186, 0.7289323325297443, 0.7012736304549504, 0.38297249710410447, 1.879243621963485, 1.679277551528133, 0.9059309556347084, 0.36794363341549946, 0.19312204813178976, 0.8659554670363061, 1.8187261491862794, 1.6148019933606441, 0.1941213377453726, 0.4023476031938054, 0.5745379277263933, 0.4765029044841562, -0.16238766866158927, 0.8031223278335027, 0.6677069213105902},
    {0.5609408759644087, -0.7996031289997143, 1.7727892639305054, -0.085044947902326, 1.527024962567547, 0.6005806718183923, 0.41804124326811914, 1.7909136609038705, 1.5210713569719876, 1.0683066085811557, -0.31256141007141136, 1.9334291888396247, -0.0418375360168872, 0.39473778839335905, -0.8687684237484062, 1.0126340891815737, 1.0255136165422367, 0.5238211354724515, 0.05358378503074527, 1.5350559943500492, 1.528836177140546, 1.5928417190126105, 0.7759047460127501, 1.4385326676822148, 2.0035616804113894, 1.5929152349597193, 0.66257884778236, 0.31922757344418373, -0.1265303895858504, -0.7150656662438917, 0.5636674569644078, 1.0311353158662986},
    {0.7759223110839742, -0.5842536493140826, 1.3970910291717737, 0.05334066296801911, 0.5017752525665055, 0.5984592894467465, 0.032757838186875714, 1.5330075755650623, 1.9771578494770194, 0.7151725833066535, 0.5333813792861032, 0.197120827697158, 1.1724258250210706, -0.6806528666992047, 0.5697999171730441, 1.6409852449841937, 0.27123828333073513, 1.023008665354851, 1.6471506642931197, 0.5603430198956689, 1.0575011966168706, 0.5635371923834093, 0.5883952682658032, 0.5677180855649829, 2.095980311478543, 0.8031853034244024, 1.4450055313061323, 1.5981089654104748, -0.8765125763487922, -0.620796595530506, 1.7553180612182044, 1.5697735525724028},
    {0.6628033323418537, -0.022982733988723608, 1.890379621441385, -0.22410612663547402, 1.403816141308502, 1.6380444217014587, 0.8020256406470009, 0.2662099692602547, 0.4911474167529822, 0.2254763395488023, -0.6527380744468108, 1.871838001444407, 1.5443254404497722, 0.48169800024583703, -0.2893895473860043, -0.00687990217289829, 0.16084316097395254, 2.2515094815049745, 0.22353789931282494, 0.8266243846359697, 0.8127294251006254, 0.8713444881754357, 0.7230484878317729, 1.321336179394998, 0.6565277912279476, 0.7493451975900675, 0.07445358368641739, 0.7335567972778557, -0.571808992545577, 0.535344694388434, 0.9920703641131091, 1.8079306754570106},
    {0.017104687311944866, -1.0701090817975465, 0.6741467197046763, -0.6213733490161818, 0.8818188209331895, 0.956504898071249, 0.3033653162900804, 0.9521238720363973, 0.23817422141947117, 0.3709318160182602, -1.1518359292150002, 0.1773936515228037, 0.3802770330797247, -0.896678227080366, -0.29664903928872227, 1.9041070905098372, 1.4957794342037107, 1.421700064982708, 0.6081266886718055, 1.2707703419867966, 1.1588612936832268, 1.4408659657690388, 1.8479028587644502, 1.7310807695672814, 1.735244682084137, 1.336836861910397, 0.38060315339751727, 1.9934471194748977, -0.32845755719634645, 0.6303199812740914, 2.008976878516406, 0.226195182884417},
    {1.1891682316322423, -0.6978578706280842, 1.1616209186662403, 0.24767422725122165, 1.3025735329243595, 1.7198027832413827, 0.652241722762125, 1.4312231344451063, 0.7751189097726892, 1.2696088583610652, -0.0605851960786578, 1.9108246097220019, 0.09839585484647442, -0.5011821669400316, 0.5028204825790411, 0.5104023057207524, 0.8405925251700614, 1.411436672046201, 1.016728726284468, 1.681712859243236, 1.0920914888920317, 1.6609731851489122, 1.8939435383922092, 1.8957403096824794, 1.3901616028276111, 0.6395446152483363, 0.707123455657073, 0.30446222086970026, -0.21874970698214774, 0.2880279843428517, 0.31368067100166264, 1.4249909714424753},
    {1.5977378825395423, 0.13318053297531232, 1.4568765597863664, 0.4953899316283621, 0.14520316511654444, 1.83748003054128, 0.9235215559146012, 1.5823253827611334, 1.681945738849949, 1.288238312067045, -0.06097370687142616, 0.9182539532401325, 1.3504352777753128, -0.28718986087533005, -0.8381256943149021, 1.2526312797295243, 1.964751446372782, 1.8128306355460284, 1.0465341586239036, 1.7812497440379944, 0.7158098927977737, 0.48219011508720305, 0.6749482246975221, 0.7930766766478381, 0.5712310541410939, 1.8094105841205186, 0.25947907855164215, 1.8008196264882226, -0.18743883470264136, -0.3060100055500024, 0.5877811739095298, 1.56234937858626},
    {1.443691363518808, 0.0659823922149956, 0.41870906326313356, -0.9047849358891411, 1.4824372597811006, 1.2677632482489138, -0.10516589747666276, 0.10343230527130075, 1.8772703469639063, 0.8992957664187377, 0.06838568381037004, 1.793732844768137, 0.04524404834138661, -1.0808873759058713, 0.23469112085947022, 1.481511135449898, 0.9673001027340922, 0.9763820601836054, 0.6580482059840274, 1.4393400333883075, 0.18939367050571035, 1.8765173845920762, 1.3774236247084168, 1.694799321222198, 0.43369115291692484, 0.5140487445420708, 0.6262947730484993, 1.9358415114889906, 0.23166551480509345, -1.0324650460144569, 1.4282620622771234, 0.11418315455924694},
    {1.0900344402322135, -0.948949894890357, 2.0888954107928974, 0.7815707670347736, 1.7974833004129704, 0.3255367440494967, 0.7973790829325581, 0.6280118745813977, 0.20647709875005846, 1.6710251554726003, 0.5236896182167267, 1.711817410651316, 0.21933101608426747, -0.5569554795560286, -0.8169710466267778, 0.9041173120190679, 0.8906997809466647, 1.4742754760470063, 0.000506149032787376, 0.9492770834610347, 0.361535468930244, 0.8004372680202694, 0.7325561555600322, 1.1184246860250304, 1.3798292800568586, 0.17150130585905315, 0.35280084331186806, 0.6309482992647648, 0.2231470108756129, -0.17447989422460503, 0.7645248508215733, 0.05763827326193906},
    {1.484312966936047, -0.4921167936715738, 1.1710154110741273, 0.45425509308233236, 0.22773401220889755, 1.1042917364913156, 0.5835508509019744, 0.35697481441393564, 1.8454341396567484, 0.14277376136834713, -0.7695260954357352, 0.7749272332219055, 0.976302533107858, 0.7526463043653021, 0.4281857006304845, 1.9077599848271125, 1.5309666239896222, 2.143213115924635, 0.8572123295786137, 1.7992491532430521, 1.1035615571404498, 1.081262794204523, 0.9775252574528407, 1.8033553381380654, 0.5803364729882774, 0.3302900464676102, 1.0091133629983842, 1.6858379516848438, -1.0851251852579114, 0.12156773628927381, 1.701053739975982, 1.4538577176204215},
    {0.40274255787916974, -0.9201756040367962, 0.23054397550601094, 0.051101327619250465, 0.8806346609302035, 1.044101071850666, -0.1992731504265665, 1.652804114344322, 1.6028417420346501, 0.532395347341974, -0.5528216056863177, 1.9430387841125185, 1.8427673303196999, 0.24916273323232366, -0.9011449772861356, 0.5843673410171046, 0.7978663434605578, 0.9819010712289789, -0.054005529992466064, 1.6013578086688605, 0.1529572807121795, 1.8394857280584862, 1.5350086184177332, 1.15185369722189, 1.0482132655618328, 0.16171386662732282, 1.3859117548472912, 1.730637250799058, 0.5459662758079326, -1.048888383502357, 0.642757502858145, 0.2915650064099883},
    {1.8114943430442692, -0.5042101234051563, 0.8950958573898682, -0.47409212118439986, 1.4795623734431003, 0.1560531425224969, 0.568982082456861, 0.2546332258828218, 1.7342190270557327, 0.5718758498369375, -0.6107142786571108, 1.6089245168419708, 1.1409617664929284, -0.6366173876003381, 0.7421217675174042, 0.953063059297124, 0.43174190093849685, 2.2127785692265816, 1.3760940330821185, 1.0070682391694892, 0.29836962488101926, 1.3873790166596796, 1.0547769451139193, 0.47551692345623775, 0.4810900683200697, 0.23135659864930005, -0.0909237207027177, 0.2847658314788295, -0.3534208605506554, -0.16467897466483286, 0.9585980115858971, 1.664551451238143},
    {0.6217780309150585, -0.0592549733437161, 0.5110273578674412, -0.09505285923783592, 0.2641133478087294, 1.8724673135036158, -0.11246641625074008, 0.028416887859036746, 0.2943214594418595, 0.4798346005554984, -0.5666820775957014, 1.402605705870915, 0.7977780053831701, -0.13826234208259638, 0.5024724491832825, 0.8098852893355122, 0.9998332123868555, 0.8546104942890573, 1.0372257172015595, 1.2088634155842093, 0.710275247859693, 0.9898590796535538, 1.1533429653798202, 0.9093867803583408, 0.7041439865212297, 0.2667121577787341, 0.2437542788501939, 1.5195096884339676, -0.6926260386498041, -1.0501097444619882, 0.5921293738644099, 0.6292741420805722},
    {0.5947081286353706, -0.40475904659606116, 0.2872251738818154, 0.6051768032553875, 0.8808811642339116, 0.6682749842088598, 1.1062977200799076, 0.8090938336313347, 0.1869175481758976, 0.9043292508155587, -0.9569376189769877, 1.5522680954337162, 0.265296023731938, 0.6662941688616072, -0.5243095265807887, 0.45337261526661377, 0.9101046982989799, 0.8844892956432423, 0.7598964121755374, 1.8371329964079857, 0.05658212240763551, 1.2214870368413322, 1.3215181745936957, 1.2733581830696916, 1.453707656623737, 1.0178103356682222, 1.4872532972065613, 0.5714423215302451, -0.9136824516502189, -0.45345888829793246, 1.27618435992865, 0.9980347292615203},
    {1.6287073493835218, -0.374890888960384, 1.1565341978216315, -1.0057897904789066, 0.4604298353329501, 1.6577140432907786, 0.7620792261875938, 1.487461996102251, 1.8908070301543463, 1.101301830813872, -0.7457602620219305, 1.598346688947852, 1.780918753305848, 0.31233144701273996, -0.6093200728112075, 1.7576876920729947, 1.7521279973469215, 1.453413659354493, 0.5033657354967629, 0.5277620007645789, 1.661456388135424, 0.8536036067981592, 1.506019880231288, 0.8712856922577503, 0.4675531412165625, 0.3043950205609815, 1.455821307017027, 2.1040119815113227, -0.9700109675406666, 0.5153702326458575, 0.8599571073897379, 1.8240152724543002},
    {1.7054046989524843, 0.21203400711170922, 1.6974237414831659, -0.6989696679952127, 0.8393619729007914, 1.5005623697238941, 0.5309847772952542, 1.2376382319127563, 1.5800920951805768, 0.2957520105527375, 0.6003800685249238, 0.7752323848054125, 1.315102659528105, -0.8304439248855702, 0.31342231160051337, -0.08111849196449931, 1.760018398264643, 0.9596384553606944, 1.6421194815019617, 1.497465852095964, 1.6175482440612996, 1.6230098375734963, 2.0723051829622996, 1.5009364375781145, 0.39578394748914575, 1.6521378293294482, -0.17428824265896967, 0.306632150271859, -0.9944913051960705, 0.13533294783384225, 1.3418817351977947, 1.5386900173182456},
    {1.6584279978179008, -0.2406782621075464, 0.42468995152607814, -0.18133567159770114, 0.06227395948170518, 0.10610503717255888, 0.21453094288113175, 1.8653861108197023, 1.5928806746872735, 1.0512102263246965, -0.5199045783236836, 1.1337723699763906, 0.9593958926961658, 0.040091395359995646, -0.6696391856606011, 0.6411893129498047, 1.3289446478945404, 1.3807522392808989, 1.0298124728840037, 1.9216793824781744, 0.9578654912749459, 0.4665608752366558, 2.197476967829374, 0.7780686759672425, 1.8481042293613448, 0.13801659989451356, 0.735818387580854, 1.2165358918437488, 0.01194169605062111, -0.804828961700506, 0.3343395969962697, 1.664988293739379},
    {0.22149041764684396, -0.3475182795048285, 0.9004942743318415, -0.06350259333452468, 0.9338511621195982, 0.5910416868326904, 0.5480468705179964, 1.0958349775601173, 2.0948436439627307, 1.3527259670872804, -0.7623753976427047, 0.32276110191360485, 1.7103846601706156, -0.9361803922777971, 0.21795814111392342, 1.273609171616153, 0.435213616220487, 1.032873098127922, 0.12074979479604608, 1.882958433179984, 0.6163924868484691, 1.1476921204407557, 0.4034572740597512, 0.8457187844135017, 0.46628610366449585, 1.8077273681159103, 0.26355805076963273, 0.2976003065587988, -0.5723709802577286, -0.2953684529643947, 0.14729747324270767, 0.9575587746901891},
    {0.3464939789675128, -0.1263196977204228, 0.3126952537909733, -0.9150996475946229, 1.9893182899191975, 0.8799958013370077, -0.250575052737171, 1.2139260918460912, 0.278998583235821, 0.12264867442650937, 0.3488917279726971, 0.3669412078782634, 1.2587542569657202, -0.5667105879303166, -1.077251163738165, 1.8370899184137646, 1.352639809806905, 1.6720410303217792, 0.1612550559897166, 0.6390087162618001, 1.6295187395664004, 0.21767790014767993, 0.9674403590819983, 0.16832592783124936, 1.267341027866246, 1.8765490243245682, 0.23020532389783785, 1.782967953231689, 0.07509587300966473, 0.1286003502955487, -0.013880516024331706, 1.8488000495119372},
    {0.6672603997562498, -0.21772799178275454, 2.071847134200935, 0.2284328457376617, 1.191252238943072, 0.9276458741448015, -0.19126671499545106, 1.4363798384299362, 0.7243339928554258, 0.4041538588026615, -0.2998319630109033, 0.1538212958551604, 1.0256497671768725, -0.679448155730223, 0.5685234822613696, 0.5967600604163321, 1.1473925410261474, 1.2618845311374185, 0.6658340127509282, 1.2819495237756686, 0.9157137079014619, 2.2614778852389508, 1.3376527666942568, 2.0426959728293417, 1.8372791094362306, 1.640585067082972, 0.7832880071671421, 0.46674169442427993, -0.8927345106053715, -0.10220850808349363, 0.0822360102668229, 1.0111813398438723},
    {1.1074093303631578, -0.7381106752020945, 0.16017142491246258, -0.5016409389463486, 1.8079382964229935, 1.2408715829094972, 0.7340906938393541, 1.107990388327391, 2.0030197220913237, 1.0163811529246214, -1.076921407720388, 1.084777313542616, 1.5157867988874332, -0.7628871891646183, 0.4133859404058325, 0.016366773390457553, 1.4728226221221365, 0.776904953540748, 0.8413901280504593, 0.2808455953740321, 0.4126527439370808, 1.0932713311544702, 0.8397210130654112, 1.4169993695593226, 0.9009824243022873, 1.276620997538529, 1.5230594951653347, 0.8722062055725697, -0.6559721769395448, -0.10957983384888062, 1.2674980430493308, 1.3662480658562774},
    {1.3528964600056341, -0.18764629025550816, 0.6800227480404727, 0.35023380737706206, 0.4093147401234377, 1.8431495195381187, 0.46714895098163794, 0.40616875471092473, 1.3772734216537326, 0.5700282860796191, -0.2686547677407008, 0.6333570046011116, 1.4373548349180088, -1.0620558189713392, 0.6511748526417249, 1.1460113774266731, 0.5589067408593907, 2.2618288455210114, 1.0330494608232217, 1.8235569739277315, 1.7613169409528195, 1.3979829714383283, 2.292257148930291, 0.2906874012736646, 1.7686559674520577, 1.2219411536374487, 1.3957264395894702, 0.33462899834559107, 0.7995179593839068, 0.031086411097716798, 0.3558984531291038, 1.487664712507746},
    {0.9325509314212584, 0.23711896470746305, 0.21681412722030008, -0.7425866900679562, 1.3948763704222313, 0.37045096665096866, 1.3722754680863238, 1.5551588743055016, 1.5897430708106544, 1.9063482345635434, -0.1593697721564099, 1.8100947427179221, 1.6157265318778373, 0.0651103037925518, -0.7403194404996658, 1.679819309096424, 1.8934907192352604, 1.6258174164954564, 1.5520029609744266, 0.15179354645329382, 0.6188643832473877, 0.021767373200819257, 1.320162758823287, 0.5371912510480806, 1.3210726272986455, 0.7103381491998604, 0.07705898394435899, 0.5386862153052127, 0.039107662900635685, -0.7080678960005798, 0.27047921474389097, 1.7604943874526646},
    {1.8089227724228294, 0.7756275172055662, 1.3340471188143626, -0.6946052498138162, 0.3753217056001189, 0.42017775384742345, -0.15817910077757227, 0.7302335421873859, 1.7504962420047554, 0.31602862109064606, -0.6387184060218932, 0.8629578014346955, 0.8047823495935312, -0.504400974300755, -0.8372290729032644, 0.9075713491092359, 1.5160492679834339, 2.046697690696119, 1.392573020846994, 0.5217637690061552, 1.57377792206572, 0.5836031060598177, 1.8898318851050409, 0.6194271580430972, 1.7028030839192345, 0.5867658315473555, -0.21512501805492165, 1.0382286061331996, -0.009373561188216735, 0.40504087980135456, 0.0973048384134531, 0.642935226978377},
    {0.5648868521227924, -0.4804525821534811, 1.8901391681037152, 0.05856826518641355, 0.9300455473884387, 1.7804505419191927, -0.38195818129229525, 0.4036840207206616, 1.7498772797959703, 0.7702219599493562, -1.1481182149898403, 1.6207837519314117, 1.027321448974274, -0.27336445613454957, -0.8170485441241185, 1.1738602371472295, 1.2902677875456487, 0.6619976248794485, 1.3067676371361616, 0.9564866653829321, 0.7717012773253404, 1.6366687063714032, 1.3840802123038085, 1.580490343942931, 0.9334891838786623, 0.2334718079175548, 1.0975930910282945, 1.8918614837906507, -0.4300823804020098, -0.7807717966322081, 1.7250962021991434, 0.4283493273022413},
    {0.8189456575366576, -1.0122431861059291, 2.000926426605052, 0.5795346246576426, 1.5508808133608514, 1.761973579484418, 1.3663239251123904, -0.04869294823988488, 1.0270619533878467, 0.6104917401138483, 0.18327757458693872, 1.5839865919131249, 1.7568060005918094, -0.4729104346557015, -0.4003659550126888, -8.33541999154779e-05, 0.0757438934459313, 1.6870702988867727, 0.379081963578589, 0.12023048409208083, 1.0508237802165157, 0.8851832106526731, 2.017426473425211, 1.7997251665199219, 1.3767448791082184, 0.17010609650601544, 0.31100439123138224, 1.2727279415077155, -0.06888239208054346, 0.015758160350278123, 0.8059120615985562, 1.5593296990454162},
    {0.0927641791839329, 0.8314780001746043, 0.4386742652727278, -0.7239826742981817, 0.3002182354597165, 0.5830988671372617, -0.31893260192184275, 0.8440856113576716, 1.0273274311739824, 1.655467612907348, 0.1529272248456925, 1.8690328753561718, 0.08120868179326848, -0.8681008709466723, -0.5738114307665484, 1.1742089584621864, 1.455731940459132, 0.7407627854891179, 1.005885086313384, 1.1071211824414593, 0.7275778520074719, 0.4353995950253425, 0.769327353504761, 1.6695516883272052, 0.3094443374399238, 1.1577665473325116, 1.4443316225862919, 1.556988734656829, 0.5802949741198059, 0.5425617366028972, 0.7013140439546971, 1.0560849043398914},
    {1.8755238266302348, 0.4745367096215634, 2.0704343985170865, -0.4970843611415274, 1.2361433642463546, 1.5452579012144536, 1.1966639182798173, 0.3486055464831284, 0.6753886473404447, 0.9574062626946251, -0.7461491417409717, 0.7157608702755199, 0.7609508321760516, -1.0837662828646908, 0.6224204497390268, 0.5719538503039081, 0.09139368558245814, 2.080106506312119, 1.1949105835626799, 0.8230157408792687, 1.2122695252209688, 0.7761754080410227, 2.0696176566146303, 0.6240129134026716, 1.1541490406693027, 2.0742094679690846, 1.1034544118136171, 0.4925922917090668, -0.7949548048277354, -0.9776257706873499, 0.16367386775713094, 1.7494524809319152},
    {1.5174523981577104, -0.6908084370797992, 1.6107602178014226, 0.06273229416495928, 0.37606263250685185, 1.446855540992135, -0.2510172581910792, 0.7961829880650837, 1.8567026825079136, 0.9254148082037789, -0.8686668892502307, 0.9897151743215274, 0.7146619719992683, -0.901057964991627, -0.2363724595750975, 1.700560761163073, 0.09737322332325062, 2.160758000427407, 0.8709543440640833, 1.0290513219146944, 1.141059498682649, 1.336670123489337, 2.0966615866949327, 1.7662674366615803, 2.117982081194631, 1.4471076076897527, 1.5238929990204109, 1.7811662173355902, -0.23213261425284348, -0.032908167362820144, 1.5151437917349364, 1.364785988717418},
    {1.512753114469451, -0.7079669274332671, 0.5653677342334212, -0.20685205414635605, 0.44553943585108724, 0.9148709503826019, -0.3074394879197845, 1.5254533566771424, 0.4416194328734228, 1.0646304238056539, -0.9385053537975484, 1.715378642213052, 1.0482967554732212, -0.3683789009177904, 0.21518925336768793, 1.0127791266467028, 0.7272402443602827, 1.9710414024677985, 0.7833677600247156, 0.43209555808296085, 0.4349835737536173, 1.6762851063667878, 0.6065874032865487, 0.8841383579652989, 1.8028368838688278, 1.9796326537082451, 0.7462149778553466, 0.6573262375605877, -0.4868337418221247, -0.2886818599778234, 0.11832137056306982, 1.6418642363015326},
    {1.4955930289940136, -0.7378335113006933, 0.4219733181173667, -0.2864813603087629, 0.4859221949095538, 1.9590986892583369, 0.3727661979381828, 0.8171764144601956, 0.7406966443682084, 0.7656988813098986, 0.6279192563039652, 1.6690947702568864, 0.25000923187613355, -0.6924649965379893, -0.3649816642962916, 0.07563585486480469, 1.3946494168776622, 1.4364327684220135, 0.8453947803159374, 1.4385422230994673, 0.9610496395207483, 2.113608327509023, 1.4928348669733538, 1.3914085894591413, 2.0621939357460284, 1.0409991404504844, 0.5913842376245249, 1.610190665876693, -0.5290195753317747, 0.3298700000558699, 1.9445059483128042, 0.5024694700274887},
    {1.3770951439181527, -0.5242558052782343, 1.1803454615408786, 0.15220371324116277, 1.8809339463674046, 0.6713871127682648, 1.084134761011522, 1.2763272848171627, 1.2638739494095401, 0.6133311602826025, -0.9390336841347898, 2.011396974738868, 0.7619578991142738, 0.49998632315129254, -0.8138571130651112, 0.33458597963773373, 0.9611836327816996, 1.125725025027183, 1.29198187294715, 0.6024083069385884, 0.6335966750293521, 0.821080713038994, 0.6521556399617091, 0.8085951105599667, 1.934620873603044, 1.6520651233301493, -0.33881321435652734, 1.285940937736653, 0.27488698007100365, -0.9001765561694725, 1.8362927755291925, 0.6597235068724581},
    {0.9138088728641088, -0.42169204201585625, 0.39819719157274464, -0.4731958422977956, 1.0114268523834316, 0.8024316793105317, 0.09448306830694053, 0.38185746197858284, 1.564551518850999, 1.7977324548199054, -0.9145471596684398, 1.5122544578834956, 1.450315181463191, -1.0031846637916704, 0.5518067138655729, 0.3778363342912758, 0.37464240961599016, 2.076522119422249, 0.10320712026118452, 1.6215089530545508, 1.7494890544116548, 1.218680638270771, 2.2890608306442726, 1.4916262735691066, 1.7143436858989398, 0.20220494377275336, 1.6077348228370334, 2.0912027300139657, -1.0522106138362946, -0.04821654169929602, 1.3115854560476607, 1.8380691489320995},
    {0.27350927593815844, 0.6993222735045508, 2.0997829112334627, -0.6415622955929879, 0.18018525031944868, 0.2535295623394674, 0.29900151070004005, 0.5118352076953646, 0.6030759717664808, 1.7141767362917273, -0.2372683400889516, 0.8487861958416182, 0.30254688512039746, -0.0984426104435505, 0.7581298408373669, 0.3607126520105155, 0.13639763169654626, 0.9012340298796736, 1.5198654793499693, 0.2442192107732164, 0.7033608140478406, 1.9684300811014914, 1.8906715246410946, 0.552968041917897, 1.9386862636773787, 0.8040687740350355, 0.6291918985197119, 1.248751934734072, 0.3201116056166682, -1.1665458498254746, 1.5578930367273671, 0.8070991696595814},
    {0.1759105023858499, 0.08903052856955933, 0.854593851059427, 0.4794613557879949, 1.3880599111586618, 0.8156769763296776, 0.43166479837927, 1.1353848037099346, 1.4031176684271154, 1.2072607062702816, -1.0402151705845033, 0.496134820100459, 1.646679405446639, 0.7698418045906955, 0.05628224454864092, 0.7958746912442242, 0.537539395407355, 1.149389066554683, 0.5023832433831565, 1.1311289256785195, 1.2647074590789886, 2.067830682345119, 0.8190395387702937, 0.47389944693609404, 1.4274070729664727, 1.6855292569082472, 1.3642698107739377, 1.0794873188839715, 0.46395893164953483, -0.7959702053421027, 1.489208536892894, 0.3263728168854346},
    {0.5037438316915714, 0.5208147092612113, 0.3951797548127179, 0.5483868648111168, 0.35862086067757276, 1.0723131353111588, 0.22632229568742865, 1.4810045856759162, 0.7594594342663012, 1.1742034902676999, 0.5814317399213231, 0.07389749417536993, 0.5024735872723657, 0.04134017815064971, -0.8048951084471482, 0.10435435271199758, 0.5879081965132812, 1.057905323005703, 0.7618882859513942, 0.91084000963824, 1.4173929254692252, 1.6111751301518136, 2.3436166043577193, 1.2490442817223866, 1.2792138172496597, 0.24055048643354907, 0.6704379576298978, 1.7959619664555213, 0.8044185215784123, 0.12883198802603268, 0.11951940851010305, 1.807559777445309},
    {1.2902691471591852, -0.5818698575575639, 1.5791446519190877, -0.968815263960334, 0.9316439531248935, 0.5793192584273353, 0.8922240761236326, 0.1364290107675005, 0.8101437334119422, 1.934354368312608, -0.8730979401409737, 1.398316814733696, 0.39386493812734436, -0.2892803641661814, -0.023077965434099335, 1.5706056355124767, 0.7528858592985455, 1.7832250545767168, 1.176529792414768, 1.0151430774501136, 1.7537878851565003, 0.2031927764558643, 1.250951656071765, 1.4538196917992734, 1.9474254848803656, 0.8234801503465038, 1.5447765094172914, 0.5094413546402581, -0.5028314652895862, -0.19218345032223205, 1.7527458046860709, 0.17750863810410644},
    {0.8572616802893724, 0.038970312624552195, 0.2908803054370952, -0.22507067912894016, 1.3269771249820332, 0.2709611213579827, 1.4107338513145424, 0.5245984132628222, 0.44678806440677976, 1.2924060591180184, 0.5736377981828455, 1.7028609713164846, 0.9023335470161808, -0.7198893444881348, -0.8389729263427805, 0.8602816405119704, 1.3670571880719722, 1.2498577339540706, 1.5129633720083324, 0.16710140100064927, 0.8865967639731701, 1.0842480229402507, 0.6252096935608124, 1.2086575101819368, 1.390480509201201, 1.9745003766687443, 0.2418002527635703, 0.5671253892202792, 0.7785004194685402, 0.16155978267411272, 1.5005171570944573, 0.5282128705323218},
    {1.5635737631277233, -0.022848206315401735, 1.0858970675665982, 0.6694335964836345, 1.5027818850040084, 0.9700459059499451, 0.9494375801593739, 1.63293118608745, 1.5564070044574287, 0.9570373692609332, 0.39266260068383835, 0.617605649434493, 1.0144698847741904, -1.0313566444883924, -0.5647466744743428, 0.5479550441430098, 1.5275997270472368, 1.2196292028897104, 0.6244303375481003, 1.0510194180874521, 1.0930882840537754, 0.8131833899599591, 0.8170349269406461, 1.534819693187464, 2.0485556987572426, 1.2691047278452399, 1.4011493700452469, 1.3858314799972715, -0.9494128568625027, 0.5940291714261628, 0.8428570222383931, 1.8490977676235643}
};

static const float b2[32] = {1.1183067306968535, -0.20182206317185955, 1.2875353535375214, -0.2831600444546739, 1.027978631363404, 1.0833495513934366, 0.7764072214169861, 0.9956896776848952, 1.1983376945967068, 1.250178593165722, -0.36979017272399467, 1.16921461360498, 0.9853354386480045, -0.24130642469130595, -0.2770591544603576, 1.023403554775708, 1.1976432988738024, 1.6125589179285653, 0.8827782310012998, 1.0733885153359828, 1.1246501681080392, 1.4361714975133286, 1.583675627627917, 1.342370172343268, 1.4169485758617832, 1.2367802797404386, 0.7305476532027865, 1.2913392778021389, -0.17224878666443483, -0.36212546638384946, 1.0749926440064246, 1.048979441185145};

static const float w3[32][16] = {
    {0.665651313604096, 0.9373804366869953, -0.36894948145621764, 0.41520371023185304, 0.8445348115343946, -0.20373562906463705, 0.4895700979933937, -0.7890849404710716, -0.4869361246095084, 0.8932537581975452, 2.173880317717083, 0.8681524041610962, 0.1337960870830581, 0.5096232898256918, 0.3642058351195015, 0.838659355707351},
    {-0.2550742501306373, -0.2760054172689898, -0.07955271892553423, -0.3543325931360283, 0.41772361715852585, -0.2951450344589547, 0.8995768750985547, -1.034701452832526, 0.4787536954696365, -0.37761552065971504, -0.21402772522800295, 0.1400548712098523, -0.8457793632378544, -0.5389749597682661, -0.6478801124549606, 0.8336742526814481},
    {1.5585636170337107, 1.021795490027378, 0.5265752681685549, 0.525959606498477, 1.940934022762817, -0.9368389569948571, -0.8854392205731235, -0.6518693852885236, 0.5505650661499755, 0.7035227425256753, 2.726315717464967, 0.10012727019087568, 0.2065135707033942, -0.48854306927087887, 0.5391935253228562, -0.9192537721202158},
    {-0.9093190763640219, 0.2975229189676422, -0.4447981996841416, -0.539317559860575, 0.4264628633851402, -0.8976066163542774, -0.11500204875113326, 0.7645178790138493, -0.8382094520549412, -0.22194920628315826, -0.564023013706286, 0.7863541293860151, 0.8565182920920127, -0.5504779995190441, 0.3263496335794654, 0.39113120180931554},
    {-0.03649298170864124, 1.922332734072387, 0.5294891278684346, 0.7184908927328922, 1.5008059256157544, -0.9051123900317394, 0.6605964317059397, -0.9272596425650709, -0.5665566184472177, 2.177548257304348, 1.0268035328533995, 0.6843652249785104, -0.4070282680626196, 0.7141735401620655, 0.5417020423490592, -0.5456334198324646},
    {0.5176961237455379, 1.3234682995024378, -1.0562494058932752, 0.6686757586295515, 2.3050316489485065, 0.3855639278686027, 0.16334184938859475, -0.03726236943783201, 0.5118532652550989, 1.9316504258630014, 1.1854160843730788, -0.921684815724891, -0.5953350379252116, -0.08445950077482287, 0.7257587187326546, 0.22574090857287896},
    {0.8835060529263141, 0.5398830090358356, 0.6850038745340022, 0.0895815340885333, 1.0014367294502782, -0.8083213472463711, -0.22100283132029397, 0.31066912337126423, -0.752288194825708, 1.077192471473421, 0.6546476049144119, -0.7416080369655528, 0.5981342815236335, -0.37159261687403405, 0.22476560308767807, 0.725083981847321},
    {0.7880551913661554, 0.864545621736693, 0.21696206924341724, 0.2729402174187858, 1.9475981792849641, -0.352186532387536, -0.34134278349744446, -0.05098818720117543, -0.519726079562141, 1.4128282516985777, 1.0159126338245976, 0.4454898122811139, -0.2563371991895282, -0.7447088871704122, 0.053722253275630044, 0.29464361925980237},
    {0.15254983864175714, 0.5664779364304812, 0.08351502111050926, 0.14224183661054043, 0.787240932980376, 0.16693785793066798, -0.9389836633873531, 0.8047416510473824, -0.39085574990586663, 1.3741055579335295, 1.466697664560347, -0.7123152091717327, -0.9716717215914982, -0.7823318513146174, 0.1697474650241455, 0.2927430781170317},
    {-0.13584540914024226, 0.23091673654353262, -0.9682282325403571, -0.17572877079325305, 0.8721524785098679, -0.8819914323313726, 0.08180349641604517, 0.36416209892459944, -0.3875650686320145, 2.2170919189419687, 2.445715293273422, 0.4704653699897092, -0.3351230287713649, 0.0422365165734956, 0.16571018913758195, 0.25285145549650595},
    {-0.735003808553649, 0.6582037162986113, -0.12070612771950895, 0.45157426660909206, 0.0759712773670091, 0.21330308882973897, -0.03253297063482369, -0.09817238726541717, 0.45955323282437166, -0.676055836364025, -0.05424215105178605, 0.5318239303932706, -0.5374086142489313, -0.8015464428165816, -0.6273378975514143, 0.5399460946290094},
    {-0.0034339645950299067, 1.855839730076661, 0.6580554002088352, -1.0851212302041044, 1.6739371141173505, -0.6802485812690402, -0.052549683245570473, -0.22879648796690433, -0.9858634161732918, 1.5535649585703433, 1.1048362208820945, -0.07222479416056188, 0.045154762242333626, -0.6566445601612525, -0.028953554754560958, 0.4868977411216763},
    {1.1467943601043988, 0.6872079636964733, -0.8913599430579366, 0.13592110631762064, 0.7053019138611606, 0.4632717116638188, 0.4119682205401739, 0.22192133831943645, 0.3890034706565241, 1.566794625194642, 1.575944431870603, 0.43838682753431585, -0.005384573741471885, 0.811652823535312, -0.021726647945618606, -0.0418179918750681},
    {0.802495306181227, -0.4606665686568989, 0.7284481286596757, 0.5045206996360888, 0.4131023137372355, -0.5663661302818275, 0.715612378509231, 0.6696030157196785, -0.9025089948916831, -0.6216498982311731, 0.5055887927850488, -0.04645052299039259, 0.257912981379625, -0.4721445434330116, -0.42468898634369096, 0.412594218640499},
    {0.34334741835792015, -0.317607909369997, 0.15042829011936726, 0.7533492211889233, 0.3556308214706958, 0.08181985906603444, -0.9736333114850398, 0.32723232629737686, -0.7362788596083107, -0.3768660518355052, -0.5262373883475977, -0.19023151577420394, 0.21538480166204746, -0.026873992860532325, 0.6694338570011932, 0.26108419662910676},
    {1.3545256832035744, 0.369010431969934, -0.9586525736219451, 0.310717282267082, 0.5185768098938289, 0.3448968344107741, 0.28182144752702737, 0.03558623373878719, 0.007443049722646681, 2.0997747222731578, 2.292932803842195, -0.6250167470509177, -0.6921140719384204, 0.38855621987255673, 0.061756284799129625, 0.48901633498862046},
    {1.127740218815224, 1.652876835276929, 0.0074659941973589045, -0.7713615233052776, 0.7320783900072413, -0.725034664615144, -0.7173173840488765, -0.20862683907851917, 0.7100305245550876, 0.9502727148095993, 1.9559356194633404, 0.33703063429338, 0.43927874585747917, -0.23246315837686934, -0.6020825491524158, -1.1160837752700983},
    {0.9460796035151104, 0.27369774827214705, -0.27140811861008013, -0.5133782773534278, 1.484801468747669, -0.08606465801515513, -0.38301571764839165, -0.6020185480174635, 0.6463367923463605, 1.3377516092747566, 2.0622760814981063, -0.38802485375063517, -1.160676449226541, -0.009008040115994568, -0.8063415741220857, -0.340528486484449},
    {0.25948119676767617, 0.10025822777710067, -0.6801966341329679, 0.11707312828028853, 0.5221759803659625, 0.5147525222327508, -0.5443171848577654, 0.3019444282475592, -0.3200286684287223, 1.6948427154462147, 1.414885441276957, -0.3086512023004295, -0.663740234099408, -0.18988314911391715, 0.49889210692758756, -0.8836838516687379},
    {0.22635454860921114, 1.8762823628347443, -0.8376776405585201, -0.8200707639253059, 1.280344972866502, 0.8255137804672523, 0.7463102840571096, -0.8111535998719482, 0.2840236446857788, 1.557829913646912, 1.4656438520665696, 0.6959829946619934, 0.29387099915206927, -0.7377642235124139, -0.49040839390609936, -0.5436087009626888},
    {0.06538181828923777, 0.7002093495690415, 0.17825850142809682, -0.43077292473079787, 0.5341470907766867, 0.5170660649479052, 0.3235176565989528, -0.5641532646125275, -1.1011015394498125, 1.8118813213662552, 1.5251797210731646, -1.01140458181233, 0.6333065294862403, -0.3745095687925608, -0.4248748543114597, -0.6063708826527568},
    {1.2626581876246776, 0.5271638765390156, -0.27788209108893014, -0.9900398731629987, 2.246725091437712, -0.2362502172488241, -0.22865988718008257, 0.1879637160672125, -1.0132842939678433, 2.011019174787001, 1.6836965253368368, 0.05244061046292184, 0.39965135481693886, 0.0016353665965727002, 0.005150779173910035, -0.5769069951359751},
    {0.023319121213704868, 1.7818801385234506, -0.5160372110320905, -0.5851495583946852, 2.1380512983117796, -0.9121290161397558, -0.3358687408189069, -0.3057954710396025, -1.168244136004926, 2.2128368514167094, 1.872311571651302, -0.8367276089273613, 0.6242453195517856, 0.10485512305247428, -0.4504631305581618, -0.3226108720706738},
    {1.1844280236810307, 1.6323002281211871, -0.6268874643201366, 0.6416824334847763, 1.558886478639548, 0.48722150794698194, -0.8433171900516161, 0.5930136745139659, -0.6006129513736661, 2.5497124173488195, 1.2224010867928707, -0.5402239282448068, -0.24933043994953924, 0.0855671687502652, -0.25729981970049565, -0.9160693791011614},
    {0.023685343451594263, 0.7869201569395293, -0.1175169550205253, 0.6052198745603747, 0.9003384377913258, -0.7350411690292675, 0.3714051222535338, -0.40601432450730374, -0.13035550690242895, 0.798378725214752, 2.2387858757461494, 0.19258026441072965, -0.017355762972381877, 0.08766337015082007, -0.5638751314938377, -0.8191018207868329},
    {1.1439583325222578, 1.4777707081902058, -0.6541482635299619, -0.3004520931162441, 1.4639538704151798, 0.2979897445610746, -0.18977002403004067, 0.3157506309437795, -0.6561501477589796, 1.9623381155359072, 1.0213742878484995, -0.6900632299138971, 0.005717790385706196, -0.3341429591269279, -0.11214855024492176, 0.19844235935830037},
    {1.4598171422511592, 0.7292837650574725, 0.5993532745418061, -0.2881232312075825, 1.87730265588762, 0.17077862061938903, -0.018413769963165048, 0.013686113544359788, -0.4862671632183165, 0.7246896373852377, 1.0951833191112972, -0.3221712798602637, 0.21570112806663683, 0.20960295058152292, -0.41992722352463113, 0.3164574732345652},
    {1.2821306079021508, 1.3692724971412886, -0.813666009130846, -0.949841660391801, 1.4596746902648121, -1.036199455067847, 0.6816765959789101, -0.9797585072673929, 0.6847849663165653, 1.7907124168213553, 2.162787971504788, 0.5053700265384736, -0.3930276557389035, -0.3578476748843219, 0.1598996084848836, -0.2501330990488203},
    {-0.6993686062535617, 0.4673497057329049, 0.4454655836889055, 0.7964158578979829, -0.14335221544047877, 0.8836640110169449, 0.2278276090282711, 0.6266656046686752, 0.2313831304924842, 0.617962049017308, -0.16428695853039887, 0.28574528980161784, 0.42716245534335195, -0.4935831576848133, -0.29354995347307633, -0.9748990547981385},
    {-0.7905833720578046, -0.5652673028041223, -0.4447221221149927, -1.1497504198452342, -0.802506447071704, 0.23295172629249342, -0.7508700579587805, -0.6132131335385772, -0.5820157818109716, -0.48999974678626457, -0.11449065877663997, 0.48325574240475805, 0.18072845187651748, -1.0561144724310756, -0.7039803767191862, 0.46212637774462895},
    {-0.2829139455979099, 0.20331085618473174, 0.5179418437694385, 0.5502739051063142, 1.4671414110262875, 0.7719445216075732, -0.5794985924120954, 0.5457212027032371, 0.7655562226191793, 1.997121316058807, 1.88853163229643, -0.24700133838256336, -0.14655238304754045, -0.8008774088395174, 0.5113611768873007, -0.5086066418368143},
    {1.3839144126958711, 1.9991419392401584, -0.5837529045719045, -0.28878945373895454, 0.7817384519659001, 0.4453652993606562, -0.7831850612815868, -0.525994501810505, 0.2053629062478624, 1.3561187484860333, 1.4102526260983732, -0.695152982296079, -1.0621763678412421, -0.09271890428487588, 0.09113714409153076, 0.09614130562100451}
};

static const float b3[16] = {0.388177777144043, 0.8348875281409116, -0.1962412376431225, -0.1732367420246006, 0.9181370573131221, -0.2336874177339516, -0.2708173228533714, -0.17577340886270335, -0.2213049838868144, 1.247479780359956, 1.623930558773407, -0.224397093456176, -0.26027754143289633, -0.1799350293310192, -0.27638545513690116, -0.21659368457905318};

static const float w4[16][12] = {
    {-1.2929554786856603, -1.7417143248017797, -1.094229216065308, 0.1349788034668894, -0.6115211742122777, -1.4421773495148065, -1.2461539969119566, -0.5061529562080905, -0.20875181887532773, -0.1359601766086911, -0.9434835780558646, -1.3932536266871154},
    {-1.365418351583524, -0.8029048290252068, -1.2706204789282785, -1.3503176579983849, -0.9800379293889427, -1.4079421714068374, -1.02453670189951, -0.900284925942683, -0.3989351051376595, -1.2073016750055836, -0.9704557568959753, -1.3414509586688412},
    {0.27306838879273476, 0.74616565747748, 0.3861531745149444, -0.2007509189567347, -0.8081931542398801, 0.4028866373416411, 0.04587174385346176, 0.8482896321561799, 0.06651312255026184, 0.48433412369758705, 0.7498709512482491, -0.9144781284039826},
    {0.10229484624275931, -0.4250958904421628, -1.0573947803145358, -0.3967300998592152, 0.08318974054579974, -0.6164958709761421, 0.4099972363760279, 0.7879908110382687, 0.6151990484024603, -0.39171968305411986, -0.09297540659138608, 0.415804252685844},
    {-0.31662060015960675, -0.4294787592963579, -1.6154732118229418, -1.5756032995671287, -1.0288571398403576, -0.30882251530139354, -1.539744015421492, -1.7558631032881828, -2.115845112452136, -1.2827918177865887, -1.5159651414311979, -0.6590917917328557},
    {-0.9765583869670493, -0.8208768209681757, -0.4727681148062209, 0.28978879040502953, 0.6199878310876551, 0.5144692707017745, -0.7537311991525318, 0.6775557203311551, -0.8704734314910635, -0.4227070759061763, 0.752436541489693, -0.24318436000124},
    {0.4370356849868385, 0.21685168149559284, -0.4196818521474581, -0.44352752890234176, 0.67654206193269, 0.27388024076747725, -0.1471626586209869, 0.5328941801307645, 0.8798057178918631, -0.022145317763884804, -0.30344409686426255, 0.2534250793776845},
    {-0.4910842369581247, 0.2576827213946133, 0.8090100556375803, -0.8110753077022237, 0.726994896854607, -0.9726592353625734, -0.9390968133047655, 0.8540206357439546, 0.8783179069414078, -0.6142642324470998, 0.5573034426741574, -0.2315177930828039},
    {-0.9005787516161381, -0.10360213859333851, -0.6503171927966795, 0.7211513721128715, 0.6580447890214108, -0.2418944018043649, -0.555794087055261, -0.07807044388480502, 0.2938875828470805, 0.19681946060297073, 0.5376343802782085, -0.266978221468503},
    {-1.9357021178815081, -1.921430329957918, -1.2844164454575009, -1.3950395856906233, -1.4464234803512692, -1.6128675888464405, -1.4317742921684475, -0.9186354209576305, -1.5217161409976672, -1.2202570526358172, -1.4710693327682558, -1.4196653551793668},
    {-1.5954692364060477, -1.6964769777896744, -1.2839115007873552, -1.639365737318834, -1.977277707758071, -1.834341645504783, -1.3322004486819963, -1.9472417053433322, -1.5688512693456511, -2.0166913687887447, -1.4668415440997473, -1.7706090596479545},
    {0.4168220828255604, -0.8264253200289113, -0.7725929071777023, 0.5352006240645242, 0.006915187767426641, -0.4471709817892289, -0.41573265934558823, 0.7006912214140242, 0.41327424535134427, 0.8080437260068506, -0.8537047909293901, -0.9059640931170982},
    {0.803871839729669, -0.9936657292967109, 0.6660886574079758, 0.5714676909299251, -0.6455042037132538, 0.16811634766596872, -0.3662717816748581, 0.3981019377848333, -0.6282614106108757, 0.6772669690914859, 0.42488086862185553, 0.2024263543945968},
    {-0.9881456617190602, -0.34196277742359105, 0.06940675179693014, -0.519036319412709, 0.8568541174360533, 0.43664615145671654, -0.15478144638236266, 0.8195211044420582, -0.06103106353800837, -0.25789812352955943, 0.25359141617803366, -0.1553779990505744},
    {-0.6763438939494579, -0.19214750215552318, -0.2879825382201689, 0.4981182173124261, -0.8394422710162173, 0.6511819959576409, 0.4848950999020959, 0.6980181700793897, 0.37513743149913586, -0.6104544478900595, 0.07556867060241658, 0.007968841119189662},
    {-0.6708154530464199, 0.6566323809703118, 0.7207639873498622, -0.05328990338204608, -0.39999040367620015, 0.07826369252866364, 0.6348401776437151, 0.38577960164858605, 0.6716687034179174, -0.3963428602098528, -0.06875652753151226, -0.372519781987225}
};

static const float b4[12] = {-0.8713675652271392, -0.9473229906825723, -0.8459228831324204, -0.7955643154844005, -1.0070256442284706, -0.8853517339454101, -0.7643342529894575, -0.9053324465135295, -1.1283427264354806, -0.9550001097097058, -0.905530806790821, -0.8605535597924656};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
