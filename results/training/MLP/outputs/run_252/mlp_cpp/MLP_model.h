#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.7726513284511487, -2.0562223909257407, -2.2582348055378016, -2.388032206698016, -2.740323112775205, -2.1755402267480606, -3.524664081781041, -0.6781333034441457, -1.847911705392864, -2.637293507591777, -3.38103596916979, -0.5941508530239943, -3.1323501400341054, -2.5291151710603, -0.5907217791986137, -2.57810911697678},
    {0.41963119269188376, 1.9669939814742936, 2.1558304361228124, -5.846523175648463, -5.529345064894558, -4.562497991890795, -1.4688884860022264, -4.676730286017398, 1.1490218547412374, 1.759494725809827, -6.833203754674095, 2.9105704377626442, -6.8405027611897715, 1.817036998112522, 3.138592352900902, 1.3756973904033682},
    {-0.4079503136957036, 1.2168273043874525, 2.805972492165517, -6.927658668009173, -7.081154035155892, -7.184104639001434, -4.2966491965640214, -6.832408801096781, 0.4419936843664093, 0.07487490597440077, -7.069955984697367, 4.97494988882641, -7.455364835992225, -2.139609451612093, 5.117054173121489, -0.6018820066249535},
    {4.7443109245167205, 4.759791551865092, 5.5409260572855, -7.226734396106168, -7.061099954147051, -7.136457668419075, -0.43504870137613466, -6.7925735805922125, 4.502938718960609, 3.941190968581197, -7.446410900914516, 5.779937769277776, -7.508538079188012, 3.4266362746384655, 6.873334169017204, 2.6998748475777408},
    {3.169245093314197, 4.54069137735654, 5.030113533146687, -7.337240334963044, -7.202979896879318, -7.722474576430308, -1.6308335114210353, -7.353579105715638, 2.8345338909186157, 2.8796904951458653, -7.4022128852155, 4.800558320172434, -7.384730590355383, 2.5274529241466155, 6.063727909976287, 2.57300645546559},
    {2.4563411469687257, 4.095384217584201, 4.311360225683929, -7.196575338183106, -6.940664356951489, -7.373228930748521, -2.051035243194456, -7.055932377620925, 1.5983032184765629, 2.438523765446346, -7.04460030113234, 4.563988754849424, -6.820799933791229, 1.636335658035516, 5.262254640816436, 2.505913714522677},
    {2.6647343266750676, 3.801473603839459, 3.874022631128591, -7.333026075804415, -6.868034213012, -7.41637153576381, -1.7279963968648455, -7.156141196628802, 1.7720070805015826, 2.523016777424659, -6.703367320330777, 4.003948160063955, -6.864013739165556, 1.9963221878137858, 4.779092414699512, 2.5418944444695075},
    {3.8435739685031556, 3.4601481406903756, 4.123520264814437, -7.4684596005234, -7.323115657281642, -7.38884490239914, -1.5310759339220534, -7.099219251747472, 2.68847025710084, 2.5978220930413114, -7.381028914461978, 4.429009716919658, -7.213176914609814, 2.6625452475016322, 5.209490411712012, 2.894717648318666},
    {4.554262822196722, 4.019265366176109, 5.1149601830570175, -7.36457739211313, -7.217365452919207, -7.663608987107997, -0.4339408182109925, -7.061322223798416, 4.067901852055995, 3.4894588346457134, -7.803138897671252, 4.667159710848404, -7.550629938782787, 3.4336104114268515, 6.291229968850705, 3.743941671051318},
    {4.163190472528524, 4.63726819418614, 5.37937644941491, -7.411953046213208, -7.100076007820679, -7.138990931097507, -0.9200921902852195, -7.146396224282339, 4.26766576107767, 3.6060801482000118, -7.792708530415582, 5.3687865052220465, -7.92534471219354, 3.350663788695248, 6.286942322591729, 3.7321900266630506},
    {3.181935311342441, 3.9921098545453955, 4.112618861220462, -7.175211581412281, -7.145424790473636, -7.3796124848090825, -1.0918210971077613, -7.075305481645268, 3.226504644275119, 2.8957158594528223, -7.72470806248189, 3.6237795135953035, -7.7032333602513186, 2.740354947303933, 5.598482440810931, 2.788947773140645},
    {4.522893550559966, 4.650504489915932, 4.979755190805366, -7.505787791757767, -7.107845554056586, -7.073730594115758, 1.0701648479080088, -6.966488952216902, 4.3642703063660395, 3.268908120588518, -7.734170572638736, 4.707675893517468, -7.973201529357153, 3.1428144429512628, 6.36081029500817, 3.64016018396545},
    {4.8085075699147, 4.30640390843623, 5.173700544966839, -7.403839270917096, -7.096461981229381, -7.149562865476426, 0.7141482752358257, -7.247771749850831, 4.39920917428004, 3.046427135136296, -7.8682722766607185, 4.9115977691160015, -7.823303689482819, 2.958707889926812, 5.957103769835581, 3.765526217565848},
    {4.190868474482877, 4.146620627506659, 5.298904698807084, -7.660060662485611, -7.555843457990705, -7.156101979244439, 0.4667070823139253, -7.2251364146878085, 4.252362965219778, 3.162991932599959, -7.776683396772363, 5.425316837553056, -8.176554415871449, 2.8678646214041112, 6.089623344705376, 3.915885944397518},
    {4.187739322845685, 4.171422189121019, 5.0878061386988565, -7.377781666391895, -7.375569858112048, -7.29723292470066, -0.12890512668984513, -7.363135174132679, 3.9181210179834554, 3.5584840682215675, -7.743771911578779, 5.437679694743366, -8.029293319925765, 2.9354010554300722, 5.831056443736201, 3.941311386412794},
    {4.4324363143920555, 4.751929380467094, 5.770454685915744, -7.44943148818329, -7.5565403156688635, -7.2952143891836165, 0.6509257011856268, -7.089718627346895, 4.239527802836685, 4.195969991182416, -7.873259172537167, 5.895132336076563, -7.703176624751056, 3.6795834783832344, 6.285883284998313, 4.289806399766915},
    {4.831553896221374, 4.977185165076349, 6.073058172619962, -7.670667972365211, -7.601612263965174, -7.39880327238081, 1.1092669492312268, -7.297477148762352, 4.569048855079973, 4.354358582122481, -7.613195512821911, 6.352274761396543, -7.977285530748583, 3.863865571340494, 6.339401139654064, 4.464240568626399},
    {4.764339637150144, 4.39190682271798, 5.708904935049565, -6.81932591927508, -7.203321928216499, -6.8682853115771465, -0.3068319359161935, -7.1039339832188455, 4.599711713927791, 3.4083746534971433, -7.680470434215752, 6.493836436725587, -7.763764503433314, 2.442732496570769, 7.140150629666749, 3.8349604094329193},
    {4.307709922500679, 4.247428914740826, 5.483283125123809, -6.778603018434653, -7.343085862528828, -7.041498202482547, -1.22046601402963, -7.211346045003315, 4.109211742227141, 2.298862094768828, -6.945885644730617, 6.432901371599511, -7.614335758135981, 1.3287156764276586, 6.758917078945018, 3.207333552464426},
    {3.5800817746412723, 4.716540096977053, 5.706224057766962, -7.209232547755962, -7.686999237928698, -7.200948066706918, -1.0678860852304644, -7.148628320400841, 4.2887233124378, 2.221816553439469, -7.520750742348452, 6.368289974763285, -7.736426817287761, 2.2719067684053242, 6.9356121152483485, 3.196569167091942},
    {4.396068278859347, 5.226994268542522, 6.240745546720603, -7.553355635705184, -7.403180422119291, -7.441094733472976, 0.6495280354533844, -6.990710401279722, 5.199038634285617, 3.629044981103564, -7.795990544477661, 6.321489936603963, -7.964081011617264, 3.389311000519424, 6.982001962869592, 4.279500913093632},
    {4.838323895855953, 4.820018167054393, 5.883263619825213, -6.980573079650795, -7.617105311312631, -6.656107618989686, 0.17100302990629984, -6.604180200790437, 4.911598956692923, 3.5280675192583337, -7.749560118645653, 6.337048978710695, -7.70495343359407, 3.0484130466879895, 7.081818539463987, 3.2271176124139878},
    {4.059459890123463, 3.569703572452364, 5.165798396876072, -6.757799638095997, -7.253709664665694, -6.5713921389348195, -1.6933757734161932, -6.327203954565028, 4.145699246026745, 1.9972634053849923, -7.636792124377143, 6.129202724713193, -7.9567990811479605, 1.5083569180467837, 7.402317280367727, 2.0772198427939976},
    {4.92500329274946, 4.5032504788786705, 5.9452822647284, -6.825466584719262, -7.4604647543922935, -6.829542187515463, -0.4883116174874544, -6.798162007489593, 4.843036256420033, 3.256782715606047, -7.66304075855116, 6.42023824039818, -7.731908304964558, 2.8786287124877656, 7.2497246471868335, 3.479684042448336},
    {5.0420399320202245, 5.479389267851158, 6.211166615071524, -7.229264011017772, -7.101007157724634, -6.826854783746054, 1.289467625877516, -6.6759015335836125, 5.388446337002092, 4.20463563363048, -7.593638972804187, 6.466476914686883, -7.67686397922678, 4.01957045370733, 6.987698701511762, 4.476311054884627},
    {4.784091307825899, 4.7398321235346215, 6.083380137658762, -6.623141438525395, -7.21112920797218, -6.484869843148162, 1.2735002009347496, -6.4966739452316995, 4.727051058095884, 3.114312837831297, -7.539878798642895, 6.13183979444801, -7.550426962574446, 3.1908513916058756, 7.052644140282566, 3.7637110038115704},
    {4.203979222832578, 4.748816256590552, 5.886315818910605, -6.8812157586415355, -7.250598858989075, -7.02329215564059, -0.5400444414775945, -6.832527992044629, 4.434022017616848, 3.2247953341757833, -7.683333125910136, 6.1018164067267575, -7.697840633842807, 2.65199560366444, 6.896966198360105, 3.300542260797585},
    {3.789600962752216, 4.608720292142376, 5.830784529136354, -7.134619434860023, -7.47837418937718, -7.116624317534668, -0.6099987079031961, -6.904819277527757, 4.271295638322451, 3.139028809418147, -7.808388093371016, 6.355820018485427, -7.882289413478863, 2.449281386871208, 6.75494007369745, 3.30567655659452},
    {4.044776738985208, 5.060329145586633, 6.012373494673009, -7.100843511267871, -7.425285490189022, -6.915004862158409, -0.26326802120982573, -6.895594179380496, 4.533245499093336, 3.215774114260189, -7.965742528901065, 6.330146540642734, -7.7855182370831955, 3.0045809392428784, 6.839720880986123, 4.212674033868803},
    {4.869160812903595, 5.371228116678345, 6.257271018641342, -7.012570609269328, -6.967237330611123, -6.43200389268416, 1.5438590700592978, -6.164507200962191, 5.671867650423671, 3.879485135500384, -7.92832605481337, 6.540457514082709, -7.865945355228394, 3.974158502295459, 7.184371579357973, 4.666861269475286},
    {-2.3941841032139135, -2.3845865820732235, -2.9045950637588223, 1.6979328404919813, 1.0344300508935367, 1.282801240017444, -1.277705237996985, 0.22824697619253567, -2.6268281018134862, -3.2647652782437557, 0.8148229151365322, -2.020711528333944, 1.3091295327894088, -2.666442969913371, -3.0897736390844055, -1.933993414800741},
    {-3.676356493051349, -3.2796749130914877, -4.224833519847116, -3.122904324562413, -3.606204042146482, -3.257398000950657, -4.908141349333073, -2.35132718363245, -3.6381741843478297, -3.140063337834027, -4.9287454408001325, -2.838308501879784, -4.161788698988909, -3.4800529088932617, -2.9790174426873866, -3.459492411464171},
    {-3.1644493052773113, -3.8501169601048284, -3.846957800137617, -0.9306393675418991, -0.6446430687628238, -2.2129150747258794, -4.0830405451874325, -2.0508447590853227, -4.1404358227537035, -4.869557866460881, 0.31994972036072405, -2.747091563645658, 0.3573248601454341, -4.588572673840445, -3.182208639290449, -4.304582230189685},
    {-2.7939421362607617, -4.249532264116706, -3.8328587303773243, -1.606099570379481, -0.4978931056011455, -1.1564766223116698, -3.1519180660221267, -1.3491851817231628, -3.1404279030464464, -3.725900696448261, -1.3965060764158237, -3.7121297131688418, -1.2182445700848792, -3.35366069535587, -2.8352171410994673, -3.539524227853217},
    {-4.532760381231595, -4.797982978960214, -5.176457579602149, -4.817536524899039, -4.039859702378987, -5.327567844325951, -5.717356697808152, -5.063849378249958, -4.631529452826891, -4.395854921511322, -4.777616958656194, -4.25831957626365, -4.4675918884016355, -5.063253077515661, -3.3915026726740534, -4.754799505398283},
    {-4.601314572557705, -4.90874932668476, -5.243110101756273, -4.310211497851941, -3.488930374793131, -4.15166209957081, -5.618594522473449, -4.049502542719294, -4.251301751178658, -5.16431587963095, -3.9571048372158564, -3.9852614967931417, -3.3940559858311876, -5.152734672761776, -3.8598604216708594, -4.847151040012369},
    {-4.566033102002294, -4.834268966345, -5.092336084603795, -4.8015564645712345, -3.9694408380751502, -4.503509728723959, -5.439708060859816, -4.942265584526406, -4.580579590568322, -4.953237091157888, -4.801406537650316, -3.8811058827539364, -3.938801346656891, -5.09281417265069, -3.690168758699469, -4.879869506473351},
    {-4.4878169835101085, -5.395369802980476, -5.3587731068785756, -3.2958517939629943, -3.021585555777058, -3.8242866415407617, -5.426025686442078, -3.86600115038574, -4.587481061311802, -5.053454920575135, -3.9401102374884815, -4.2878138534003325, -3.8054743205370536, -5.414700896166201, -4.718719967444377, -5.2272825647248355},
    {-3.681835095531754, -4.84252350470584, -4.861526002947543, -3.888792090932153, -3.5558570627477266, -4.025147125856967, -5.656001301464358, -3.886380571299363, -4.001723684701074, -4.346720820556036, -4.010943407072967, -3.863035686046125, -3.781489950847349, -4.609750767132133, -3.4406889998265067, -4.639822089813784},
    {-4.063827116841073, -4.683333486592129, -4.754171800244667, -4.166074230960594, -3.925797078168367, -4.703460162453252, -5.258057563949267, -4.554575608077576, -4.561128920236431, -4.8741079293909335, -3.8852040439707514, -2.5945565127836123, -3.4124418283007523, -4.898544717785551, -2.850134015929883, -4.855839672282896},
    {-4.567202513213264, -4.657676539923207, -5.26554566980812, -2.849663636549433, -1.666750783164551, -3.0418644107481443, -4.69076645042092, -2.9712867934586846, -4.781721061237466, -4.802436423843646, -2.7839195736877134, -4.105304078623649, -2.3200665609067963, -4.934838679652921, -3.8476452322714905, -5.058843993983781},
    {-4.187854559744901, -4.484681000691033, -4.490785168755975, -4.289435474611133, -3.718999485630815, -4.559405961869998, -4.71700149697947, -4.503104182983093, -4.169493796866629, -5.0067352028324095, -4.307349383100722, -3.217806203525904, -3.483958363857802, -4.981160532938335, -3.4257205877739025, -4.477132254483833},
    {-4.228592481184676, -4.37421228004208, -4.415436720784548, -4.61936043627949, -4.526203385097684, -5.2277976406266236, -4.683164735026933, -5.03578364040472, -4.363414947462491, -5.006160369372243, -4.6001240055808195, -3.1206326221102745, -4.664741579415181, -4.7000168060279615, -3.5743724449793386, -4.846790700997479},
    {-5.259369146914562, -5.11882234417252, -5.155150645375656, -4.41333479166422, -4.240835931861352, -4.933279195983351, -5.586986661689339, -4.825709101074649, -4.891809824350022, -5.659816934617869, -4.4749064882788945, -3.218949863896208, -4.196846492281942, -5.698598259554254, -4.161382204989655, -5.6285753096310085},
    {-4.6376304275486655, -5.5663912972588125, -5.539399586414529, -4.497412227208708, -3.804182089184094, -4.995403815517024, -6.331269586231688, -4.783203172859708, -5.368832213619753, -5.630930829296808, -4.180133554555589, -3.9455895649393393, -3.774742230444935, -5.794783926122332, -4.003074046239873, -5.613112120972614},
    {-5.154345253335535, -5.76852848608466, -5.709783531685583, -4.190975092819828, -3.6016070781716913, -4.869275383238393, -6.40306881773699, -4.265263595034008, -5.338386283523113, -6.242509079169212, -3.919807370027892, -4.511050787980389, -3.5836863749908985, -6.08117187420777, -4.492389562990996, -5.881882481132326},
    {-5.082245224781939, -6.066664062150848, -5.9519410591262405, -4.143125182439638, -3.6503139147518375, -4.454522522651344, -6.2475776399613645, -4.263225597753289, -5.497934761046021, -6.2335330070890675, -3.747117631189181, -4.775537337909714, -3.8907231457846216, -6.311191882268556, -4.462420051072107, -6.157165189187278},
    {-4.654675102593063, -6.102434739571425, -5.748685547533103, -4.055073582274551, -4.21487086517742, -4.10972129255366, -5.849673082807752, -3.7795065015142812, -5.071738713333059, -5.5961606275604625, -3.7663974817010075, -3.6705108830241198, -3.9392431523472555, -5.595552439701407, -3.67134583344452, -5.31113481156156},
    {-5.93300652151855, -6.716383844150124, -6.743587193369894, -3.3977235873518454, -2.7009009794586905, -3.9744015503219687, -6.509064921644367, -3.9213923681724494, -6.0993086400979735, -6.491051613189821, -2.253366546239583, -5.11626963406685, -2.5422205941442746, -6.7968099420027706, -5.198576263963352, -6.579778780599799},
    {-6.257737966227286, -6.589590168618809, -6.47665607516693, -3.9859188205496023, -3.2998941075741337, -4.433039662651635, -6.959165520119076, -4.274265888856035, -6.334996345179339, -6.8532367914797465, -3.6726824325688927, -5.157228352607333, -2.9577494409449017, -6.886212240750096, -5.432726457793904, -6.602608382779521},
    {-3.06097293442236, -3.734192360074676, -3.39583549553622, -5.342627471894239, -4.50924464166846, -5.4598749831398035, -5.264539798171596, -5.1328004621575705, -3.1690862746013595, -4.023729189060783, -5.064527918548623, -2.6342713036921483, -4.2881249515833, -4.1505610094081336, -0.8727002787930033, -3.786093353958389},
    {-5.347749311474714, -5.380365300547927, -5.465698824176271, -4.208929065995183, -3.6832888880045407, -5.385870953364574, -6.941413116045627, -4.304551251413172, -5.806661009966354, -6.76583855406938, -3.487806839314839, -3.643292414709934, -2.7096736656418945, -6.557776663191261, -3.1141428957107435, -6.532039633553399},
    {-5.386508206011413, -6.3083088816327155, -6.546309572852732, 0.024929248047933967, 0.8138218228867751, -2.4508389756332796, -6.814795894765261, -0.7548225873305536, -6.769768921606897, -7.196215609242887, 2.2451619305176704, -4.749508589644397, 2.671819484261845, -7.008749945395065, -4.743168088554486, -6.774913167111269},
    {-5.549712900297851, -7.025845627068919, -6.4831333063408145, -2.7009543050672593, -1.874149162819207, -4.119896888567061, -7.240135030407488, -3.544972837912135, -6.728534133756118, -7.017289257784553, -0.2521351971964326, -4.6902131337413655, 0.37297199444952595, -7.152158267254926, -4.962004729447573, -7.0029568092017485},
    {-5.908114132368122, -6.427329962889868, -6.255170040093748, -4.567442879108817, -4.010055544309551, -5.38025884735581, -7.0796874071952125, -5.157161056508842, -5.934948197967736, -6.520490046455299, -3.7336652227612643, -4.561718576655465, -2.609208332687109, -6.9223633155483855, -4.444642582577507, -6.917992561930938},
    {-5.963291537412249, -6.330321847850619, -6.446191185571813, -0.04929127589930865, 0.7260397555155306, -2.0814454624143126, -6.363314406661684, -1.0156860800539227, -6.450468688533408, -7.234517438654148, 1.2170168321306167, -5.13262709678951, 1.6841637495348578, -6.870634648199019, -5.386224595870367, -7.044636855091501},
    {-6.042373952371008, -6.788589186675195, -6.714261992016643, -2.3220837467020927, -1.5529991617272207, -4.149483789904024, -6.965782056414239, -3.505132507872269, -6.763639697188592, -7.305310456474961, -0.5251908146125142, -4.96952275020705, 0.1820901974132358, -7.005855691001007, -5.675188782038149, -6.9232457881819505},
    {-5.914278302612901, -6.385741483087596, -6.156249771263717, -1.9775558431143707, -1.577538487168024, -3.4659358104646802, -6.690546978441942, -2.572368906583524, -6.276284004828457, -7.303993508421239, -1.4981885209331864, -4.240329772803754, -0.552572838886303, -6.739613680826582, -5.159408711194948, -6.9140332833092915},
    {-6.153197006944219, -7.183910521796029, -7.03738013678345, -1.5069867887844792, -0.8791971484211342, -3.2540850622845454, -7.301233726776994, -2.389895606812084, -6.930357875577824, -7.479095941828013, 0.06687713685619986, -5.214727714364517, 0.3795954654292008, -7.483436948795308, -5.307832911298764, -7.026695759967297},
    {-5.443663112248903, -6.590654149494057, -6.4250046889841474, -0.8223175104196628, -0.8299691760909285, -2.666349766859193, -6.808951145867584, -1.8189672015067417, -6.111259617575748, -6.893447364587429, -0.15246788348923462, -3.8317587132981963, 0.5345386390219377, -6.373629939419714, -4.690477597515892, -6.378652357135832},
    {3.25320276623336, -1.5549723038980163, -2.2490591588010798, 1.5533250724405607, 0.9674731612541566, 1.6246724212092367, -0.45671498593546683, 1.9860095249636187, -0.0654625855788656, 2.3870503852301055, 0.45414204308432254, -1.952989181542018, 0.25027948919723714, 3.0094818789626174, 1.8358944615391253, 2.7134421275311387},
    {3.8179464506440093, -0.6228773397359592, -0.9788491835294253, 2.3310055948347386, 2.2233730482179257, 3.0926935074941553, -0.6642919246791962, 2.9326125722241887, 0.6744251721341106, 2.77419094313891, 1.5412033270641976, -1.396954266748239, 1.8650851062530622, 2.897216630626872, 2.6727129363537783, 2.8902482914213508},
    {5.392378761126481, -0.9668353680433197, -1.3368290306494415, 3.0070269696022547, 2.2901359503672483, 3.2340891475152937, -0.2700631112808724, 3.964413514741952, 1.6020957814577548, 4.191140083142262, 1.7362653731004636, -1.1659288244970836, 2.2008017339276016, 4.0544694044378, 4.193204522152652, 4.142914414409846},
    {5.039925955908284, -1.211797559921334, -1.6059508664643452, 2.198055927056324, 1.3838273859219228, 2.9099785311135427, -0.36054669981689086, 3.4469503325949047, 1.357462197926872, 3.672711782757349, 0.1440073442243435, -1.885575367904507, 0.5819711697722714, 4.512000735002157, 4.004571635451718, 4.0378022594950265},
    {4.155454375467382, -1.2325469637441882, -1.3775646727554745, 1.2011588401022053, 0.32488904576422967, 2.2024398819657236, -0.306165962316284, 2.270392734950658, 1.1605502352876083, 3.273770261194441, -0.2432753104201101, -1.325683008841749, -0.2057710612810778, 4.004742559246673, 3.971468440120774, 3.655354304300078},
    {4.686092290534127, -0.978650574116686, -0.9460201270301923, 1.6874478254190788, 0.5217533469342756, 2.5343478773545627, -0.5852205242665616, 2.3555382536897196, 1.1311190494617782, 3.5932900841807145, -0.20199629272519132, -1.2072543983674286, 0.07107707354819993, 4.053148122236169, 3.9680177358829085, 3.732494340841466},
    {4.3847241535193, -1.5721172299033235, -1.8792945497963636, 1.921016582750483, 0.6558491595483377, 2.406686143905342, -1.505675778662515, 2.6304554480049913, 0.4911025814957391, 2.9491978903134606, 0.22274710388623656, -2.2866389958247195, 0.33629774311690946, 3.9059732835812047, 3.4740559400928834, 3.5846675700980355},
    {4.690566534355168, -1.8940036947802905, -2.2406748962409133, 2.479950353625613, 1.6476102034930942, 3.062468858219364, -1.2064001673847937, 2.991706203538816, 0.5500199865683268, 3.1986279366466475, 0.813906150357121, -2.7186766732050534, 0.7888442728947086, 4.132915683349863, 3.904436353619217, 3.9042443831563793},
    {5.184621016447144, -1.3484213216943175, -1.8786809711807955, 2.594096232101578, 1.7092362709122018, 3.350200934363876, -0.34610208377955143, 3.5582883599178823, 1.2819736273757678, 3.8255963422917474, 0.5856679604930488, -2.083648499366499, 0.4090088482168454, 4.692921795792599, 3.62434733635308, 3.810351998675578},
    {5.454902921640936, -1.4357753186895408, -2.1984451826245435, 3.2321501055433823, 2.0154498826883827, 3.8911096876715927, -0.5775730699652825, 4.301151408613232, 0.8855534193996722, 4.04598062786039, 0.5097654912389223, -2.196997878049934, 0.5455013720717818, 4.9655824528088734, 3.993515005094366, 4.088585018963541},
    {4.6354378847535465, -2.386480312916188, -2.9293870986486352, 2.253389519691961, 1.2393812084490112, 3.053480108797311, -1.2756325139253961, 3.18052380420509, 0.1491316524123078, 3.2153034850803186, 0.02272188892326814, -2.8310417140276423, 0.12416759019970626, 3.8582781727827933, 3.1627243352454077, 3.718971073989806},
    {4.527471324259799, -2.5876604509860885, -2.715903300500278, 1.7308225711539573, 1.3464725210494954, 2.810482392772513, -2.183651455388668, 2.98706462472684, -0.03959477678315589, 2.9011539584892896, -0.22298345809435807, -3.161165855164459, 0.16164951386883236, 3.7748568829072364, 3.2531319140136516, 3.349683531340813},
    {4.477917048178948, -2.087416353190567, -2.285614413652266, 2.558548898100598, 1.4894614325775948, 3.3364405767211003, -1.900001118526669, 3.484196479097703, 0.47735747784060406, 3.1621622788249657, -0.29477729417448756, -2.4746551331874063, 0.1553517013445589, 3.791046226800228, 3.304490305886359, 3.1924954679669613},
    {4.813765628696945, -2.2476552122313587, -2.60800501515929, 2.6265327851340543, 1.5835114214262709, 2.84544639786585, -1.8378127977085343, 3.3966537177237184, -0.024574569042350777, 2.4815711570017585, 0.18710917968138932, -2.850314717533188, 0.34924299213255466, 3.640365412001064, 3.017805444153969, 2.9626834688843946},
    {3.7444198105293065, -2.9867881728287897, -2.9885078244838463, 2.895584470949604, 1.7766358951483023, 2.961039103917649, -1.7051802259680058, 3.4643267874120536, -0.797724139184323, 2.4688840543822574, 0.0037672558190571448, -3.155538734566624, -0.21118652742069619, 3.5989596796196, 2.2812370922940493, 2.6453813799640837},
    {4.806135835994986, -2.2586069726925877, -2.3915231624393396, 2.086741551219218, 1.2280424530106004, 2.4918122766540844, -1.2813004055166703, 3.078345924684885, 0.05829628134286613, 3.2948209946873908, -0.21370940991459808, -2.6776634143411244, -0.1686690899549563, 3.955197971523335, 3.3885022246638803, 3.663717264934926},
    {5.201649124146177, -1.6751736477321788, -2.006750200579259, 2.1977372363445586, 1.277247449992545, 2.8828338609137805, -1.2882463326379014, 3.0683276244104967, 0.5299780004176193, 3.6677295488051436, -0.23659481768692253, -1.9623626182463438, -0.12893484142868333, 4.247920342719429, 4.728015217161126, 3.966476619225936},
    {5.164253881327113, -1.8066437226634129, -1.9360607291023924, 2.313043162381907, 1.4869209620520631, 2.4431885993813984, -1.7259499362704083, 3.2757482341657598, 0.23258996803319953, 3.3848415312047733, 0.1426818761368391, -2.284898301137661, 0.09648281759239877, 4.2874282910286174, 3.9959293048141222, 3.7594043644187747},
    {5.3113069590796025, -2.2687217997170657, -2.635055922468666, 2.5954047223411285, 1.9600942342643033, 2.858585427315277, -1.6402637797172384, 3.5151014018624127, 0.25500081805920893, 3.7485972069196807, 0.6851812395211225, -2.648300567259998, 0.41034969690323503, 4.611327548759226, 3.5575599253680728, 4.0529104652837535},
    {5.057390813747639, -3.0601110325389116, -3.347552830343919, 2.933839412615593, 2.210237285305839, 3.1536550439730893, -1.92436857903263, 3.7912826021772283, -0.31746585321124504, 3.3577857071838, 0.8668362791335534, -3.6452530249812534, 0.9698096184916685, 4.302945119033316, 3.250583637319505, 3.6629697409499093},
    {5.0252915868070795, -2.0932863497763767, -2.4540007872610157, 2.035298843961244, 1.3575583408760354, 2.686293577009854, -1.7630834417626549, 3.0915068515001205, 0.37334225465145143, 3.654747296607362, -0.4613266120275032, -2.8024649070920837, -0.4719528045013188, 4.16340850294221, 3.7030160417104616, 3.766130917183224},
    {5.091773234650234, -2.67480297252792, -3.0372104978682577, 2.310506607440524, 1.3003466745402106, 2.3578027999789306, -2.6184294286163756, 3.209271227517576, 0.3447406434771962, 3.6034225959498314, -0.38127062581415105, -3.230818330370554, -0.36713060043734463, 4.285212402695409, 3.6765625814264515, 3.826849368895539},
    {4.9364385160832445, -3.3368160726369904, -3.8487164882381624, 2.960937910167051, 2.30806075195913, 3.2626535842785525, -2.596987949479407, 3.6671477558892627, -0.3624926048262266, 3.8770863973242693, -0.014055942421243748, -4.021408453445372, 0.05223248463965227, 4.342267501005, 2.944180914975386, 3.974565814212282},
    {5.305206618012549, -3.103746388860992, -3.4942471798650887, 2.913917768251948, 2.384427955103922, 2.7921756901318746, -2.5879922824668267, 3.813136840383085, -0.24603429340992697, 3.3961208788165838, 0.5270938117652623, -3.8320562377289824, 0.42609251647304847, 4.651832743519576, 3.3983099158476926, 3.79017374568071},
    {5.725675512711953, -3.0783761936363194, -3.299889656688603, 3.1488746880717944, 2.54558060686541, 3.5278422741014994, -2.1724476607006356, 4.257356426022842, -0.3348274130387766, 3.9940540981681845, 0.6073495782983493, -3.3184384679806214, 0.4727576190550251, 4.624161888985587, 3.925518053284836, 4.317964360130422},
    {5.743757829325918, -2.8841913038140676, -3.243607820681988, 3.3435281534831938, 2.2664877838414954, 3.6583689189118025, -2.411923069693694, 4.22083304190025, 0.08571993235256528, 4.194620168445154, 0.4299557246892179, -3.147752983465299, 0.4029291298460867, 4.817366651648938, 4.181142484937396, 4.408391420423714},
    {6.107793512260565, -1.9320153111602536, -2.6136654582394683, 3.53683445564862, 2.4782515456663963, 3.713212504545826, -1.5753314078729794, 4.6539116627810015, 0.7896014738093262, 4.105853569148824, 0.23232933813116546, -2.9855074007545177, 0.22539418760225371, 4.991686613221215, 4.2209758520974034, 4.606274991705453},
    {5.409036258136185, -3.142247819943492, -3.705715975930876, 3.4722502529199835, 2.009202927857336, 2.760290947216703, -2.746779944298297, 4.0625554622612, -0.46079754406941786, 3.549298825434103, 0.34276509713226677, -3.573916801118285, 0.24816114475042425, 4.524680202079593, 3.669319579463267, 3.9377625666187694},
    {5.747994058216516, -3.5125801042159925, -3.698046872880001, 3.174651302322576, 2.391093324574862, 3.1548685793218043, -2.787070914106796, 3.925985689335473, -0.31822326990256866, 4.013982697604731, 0.1286191223154692, -3.7701210757396297, 0.565629614216749, 4.871186645027693, 3.9616649669666253, 4.195413394233266},
    {5.279969962680545, -3.6151753680499876, -3.9708907238252236, 3.138681568168384, 2.577569031972859, 2.8181181895668046, -2.3862897260253333, 4.114622782706704, -0.7901507144016057, 3.680891418860919, 0.355245573478035, -3.913948964619736, 0.29344968554089623, 4.5008475038084095, 3.4745048387718427, 3.921473269930236},
    {-0.1883877105402991, -2.00601711568113, -1.6292853694990548, 2.780029082682805, 2.8676420301365773, 2.0580219354532643, 0.21562506572198545, 1.6538497633980338, -1.8909141368883615, -2.342151338548268, 3.081720071021718, -2.1859640033102643, 3.448383176352448, -1.534037561514628, -2.690012354670581, -2.2670180561999773},
    {-3.6403559259793523, -3.4973917346236147, -3.9462133857355233, -0.2513143017445644, 0.27994531315486104, -0.1572175593578009, -4.464440638681684, -0.4049558814188071, -4.762505812734282, -4.0528684373137365, 1.1215423357456433, -3.577764158168564, 0.04030495370558199, -4.549319995263282, -3.861326786220777, -4.419750105759359},
    {-1.5774369424708006, -1.968975891561167, -2.2260676357658955, 0.6930519310998464, 1.221547853972892, -0.4213650767094224, -1.9002488938991886, -0.24168550230573693, -2.7516323687961006, -3.7864212702007034, 1.150515253734925, -0.8912197351884644, 1.6543656119431043, -3.4008990935693437, -2.073316065457974, -2.881091906915246},
    {-1.0123297406410425, -2.8264077579688016, -3.1573870473755226, 1.7151498617181002, 2.0301606761685687, 0.7786125747235939, -1.183133847113751, 1.1839217260852726, -1.9299831636013578, -2.251593680503752, 1.4376848486227085, -2.3154564559151702, 2.1279116180058857, -1.7279106999542877, -2.3827443071634726, -1.9306717959935735},
    {-2.7662087610438943, -3.5775975469606247, -3.6777804554122313, -1.9368868865535054, -1.1836163123016463, -3.245596221584257, -4.262593955897616, -2.3090163300589643, -3.4041846764122123, -3.104972742125732, -1.246170746613429, -2.8007974145246983, -1.0975623341811813, -3.080278687283628, -2.0583498732787073, -3.1528709157428274},
    {-3.582457998792755, -3.106963354546746, -3.3061283613239567, -2.8804221233848843, -2.415191145609111, -2.6801812007916492, -3.6754667594523087, -3.04872761284631, -2.6035623197731645, -3.579845553417166, -2.1276044175476274, -2.6232173627811766, -2.2505066844970107, -3.9099249018793865, -3.414591167071659, -3.5525563462858103},
    {-3.1108831492283966, -3.9921928628739223, -4.050845035672004, -3.040477979040495, -2.657307995278818, -2.590846142224423, -4.253360756579819, -3.067986699453607, -3.5043072412118312, -3.846160759465477, -2.881160366868156, -3.5758554120632313, -2.090290003916604, -3.696673729848026, -3.1320844356180633, -3.8864623709414152},
    {-3.601642961921836, -4.540079648740118, -4.738117619611471, -1.588030514490801, -1.5069024869595165, -1.9907668379128152, -4.349637275298046, -1.8589250478817316, -3.64935148909809, -4.07276022367205, -1.6903178719845657, -3.633564426939339, -1.9197845616287819, -4.087156462348391, -4.315223362316457, -4.075239186068131},
    {-2.610332356151243, -3.5293529713538727, -4.202929576345755, -2.5347770541303603, -2.149773236401604, -2.8567983897427185, -4.160785697617928, -2.576283856845935, -3.231046630708196, -3.1263701763613527, -2.374299932537714, -3.192455975277786, -2.023246104692427, -3.308202046896554, -2.306686686454062, -3.1590382697696358},
    {-3.4274687343710655, -3.8684758777695127, -4.047505140452167, -2.42276149270371, -2.1684908605480904, -3.660433678148061, -4.524265666907498, -2.785183650989755, -3.9070037295751785, -4.515988723719291, -1.6543864151423338, -2.409376662610749, -1.4049733875608112, -4.351455634270832, -2.697830092620147, -3.9953808650045817},
    {-3.7638499920419166, -4.379149029806183, -4.4594879838789625, -0.15828614971945526, 0.42590900203253385, -0.9296508425891381, -3.59039108462786, -0.9326159510750521, -4.475711619967264, -4.350421174012571, 0.10069238545932101, -4.010242849592155, 1.0922576955872567, -4.248065578442543, -3.9112696167342635, -4.246479590533775},
    {-3.690870587622397, -4.489974130170607, -4.390913277368068, -1.750697790185718, -1.0380895178648748, -2.3223177989815573, -4.207444773362092, -2.289864816635155, -4.611798911487321, -4.900474449335223, -0.8197093257649735, -3.119912916411038, -0.09129898181041025, -4.757024714097937, -4.089927152555539, -4.652908936508742},
    {-2.9904821848329863, -3.188808970336109, -3.3319233399580424, -2.249907858950571, -2.1168533842558284, -2.5546142802469216, -3.466186808723034, -2.4958340366939566, -3.3228239338780616, -3.9224155767551254, -2.109765486324629, -2.3432578504375643, -1.4568599219737686, -3.8237088774208554, -3.34816545621407, -3.5104249628235653},
    {-4.432010498913652, -4.3475137838798785, -4.154306067058016, -2.356058359605964, -2.150301502861277, -3.124320718217758, -4.936684056821917, -2.9109313361595173, -4.445709207398282, -5.597876971173184, -1.7130115926162814, -2.961226275761111, -1.3127742620046507, -5.5393202414587535, -4.406741310719225, -4.9924152212480735},
    {-3.639979129494345, -4.016161443131087, -4.200558876219396, -1.5438647959995968, -1.523425693333101, -2.928146586179929, -4.831500854294754, -2.436993222782317, -4.3965698906486885, -4.96473034225883, -0.5842215244919429, -2.4960259183119087, 0.10764749796466994, -5.259894123687848, -3.221206112260958, -4.931723331170798},
    {-3.3142223577249235, -4.776909113183344, -4.570758569945206, -1.7078022244470543, -1.3974088723546334, -2.37272690211872, -5.003254353666036, -2.1397716983474546, -4.693281605724494, -4.850673717502305, -0.9529836904414347, -3.552565858313414, -0.6135897873029396, -4.551573540987518, -3.3487916536726345, -4.7132380867422246},
    {-3.9905986293623115, -5.299310767061095, -4.836148070354984, -1.769747614490227, -0.518312926727999, -2.3642433258287276, -4.946987553467134, -2.0155018842921, -5.0017054713414275, -5.282065807465821, -0.06831138553765491, -4.169993371201128, -0.11989140064596293, -4.892240637465596, -3.9936041214472824, -5.294659622574643},
    {-3.7298824229485095, -5.4557303958609245, -5.164213369248756, -0.7968311051947443, -0.24801321253230377, -1.8127119655657735, -5.252582156427613, -1.311352618376076, -5.094796822143698, -5.432726524114867, 0.6017597044191608, -3.702586024833967, 0.969274294732772, -5.238793277637595, -3.3419088465487836, -5.074436230694816},
    {-4.428751299720857, -5.793018604827947, -5.7304126271148395, 0.07808045314829047, 0.9252331871420335, -1.0735941200999886, -5.418594036066165, -0.36653785610452744, -6.0204125345574955, -5.456982148336841, 1.4980782340129208, -4.459769974192563, 1.472419904509848, -5.123960732530881, -4.480639279594911, -5.381388428068874},
    {-5.100664440585784, -5.976859526982686, -6.301937165498802, -0.4222638835034035, 0.24105323528851558, -1.343237288338906, -5.764569842043126, -0.7499617487980306, -5.974016453303433, -6.197596852023254, 0.6095427548441221, -4.844814255308924, 0.7713873362080038, -5.735717849954311, -5.256397864707942, -5.755864704200951},
    {-3.295071008876265, -4.666334091167389, -4.062466423983098, -1.1719691382179798, -0.3602957429157149, -2.0194965763038963, -5.204775747631989, -2.0392088882159864, -5.017079850267416, -5.318119485921936, 0.7451192829042568, -3.520295095639669, 0.8408087307108802, -4.910331332343126, -3.5385047215630085, -4.931109699367581},
    {-4.259434004150296, -6.026236530579272, -5.518162740501925, 1.6582525742161014, 2.3192385758125997, -1.3871503438104356, -6.459543645594365, 0.37665806283966113, -6.743543300597844, -6.90500862288317, 3.445091387942436, -4.326264128662967, 3.9036304396482886, -6.719774832801564, -4.908454313410038, -6.739806077652572},
    {-4.430148593249065, -6.2143258435739295, -6.19343918992859, 3.8503743647725863, 4.297677515003502, 1.6325376866340777, -5.840673715673858, 2.9047884552490855, -7.033222402532169, -6.982914461351858, 5.663980927577023, -4.8879819545354, 5.452134203205371, -6.369062785253267, -5.415507832955709, -6.771426344106993},
    {-4.856739636029668, -6.675254400084558, -6.5860524951404535, 1.5794579941810216, 2.6506036065107303, -0.8106346888275369, -6.401449098991425, 0.2790211413281058, -6.983343870542604, -7.172722309977437, 3.9458295054349626, -5.249819698140858, 4.149061945711251, -6.671218630067032, -5.593408569626528, -6.809478810924978},
    {-5.025198380968649, -6.5701982551864075, -6.316641178674269, -0.7705610299893689, 0.12682214560499985, -2.3043756375637816, -6.506659886170873, -1.5995923721579421, -6.64538565194833, -6.967932923242326, 1.0191973685517262, -5.147799266748225, 1.8864163797910907, -6.760295342533082, -5.3176873464007715, -6.834304505202163},
    {-4.6156495838530684, -6.277131258028803, -6.328724983843973, 2.9222135021136397, 3.621024628885618, 0.8298454133265688, -5.609819732017129, 1.9424102558050687, -6.821172698320696, -6.593432722068755, 4.150744651580693, -5.349659504642655, 4.257246013691014, -6.591903329759344, -5.619605714772914, -6.595818361536262},
    {-5.466550535575702, -6.793417423940294, -6.702002151593992, 2.311810110134143, 2.95819568740223, -0.05613099912882499, -6.2184612839182, 0.35988737342416566, -7.229253682565111, -7.394501806645422, 4.362885613886824, -4.990243845380445, 4.513496793032237, -7.057183747851248, -6.076534377396205, -7.142771139492445},
    {-5.4455859514329, -6.486514344253896, -6.33933053656092, 1.9510343983338345, 2.4900441998505363, 0.25440425923893506, -5.934701044316987, 0.8803963963593979, -7.008570441065104, -7.296725580159386, 4.0499294235165895, -4.5282745144638294, 4.316066661885088, -6.819729948874056, -5.668744438100385, -6.907909331845719},
    {-5.525702609806572, -6.803232389451567, -6.811928829381095, 2.720004064659819, 3.1415427893053063, 0.3725613759566008, -6.049720016439774, 1.1283879965726156, -7.161916882592645, -7.146198320854728, 4.727258313818414, -5.669560516749437, 4.57385482799372, -6.9639874969946165, -6.150054743289928, -7.120942149961637},
    {-4.633825525841985, -6.789829016267237, -5.901513114037318, 2.5582960143178655, 3.44104288645678, 0.9745053362140839, -5.916923232311597, 1.559458278292637, -7.066513198939284, -7.087466940189004, 5.376823589639198, -4.591387907639627, 5.284495660674248, -6.774429128264668, -6.078662903095389, -6.8027986687388875}
};

static const float b1[16] = {8.475386088927811, 8.482705778867938, 8.359031400745184, 8.144890427898899, 7.484283737731405, 8.04341607048028, 8.390635454153394, 8.366006285015585, 7.727163804336305, 8.318474893329626, 8.393708427953632, 7.918575195502705, 8.544998099827163, 8.368285778020681, 8.265688431182495, 8.235875966625859};

static const float w2[16][12] = {
    {-5.842230593367651, -5.524906002240668, -5.546732349206827, -6.208488217861496, -5.398263687647371, -5.339660905236544, -5.8776084922812935, -5.769922609765015, -5.472555049069913, -5.922838707831899, -5.726927372664245, -5.957229930596333},
    {-5.694062509260831, -5.531055120358366, -6.12774751154402, -5.383267681414421, -5.880488437301752, -6.007840623925389, -6.506135997304687, -6.2246096351308635, -5.58614072203394, -5.586639455194779, -6.387432393342574, -5.005127938196564},
    {-6.22350233821995, -5.8071530131535685, -5.630661106190812, -5.930588990562271, -6.114887467852476, -5.071211329009691, -6.1109942145807175, -5.744662057152574, -6.187360157341009, -5.885339909510916, -5.383094041347074, -5.971621109278046},
    {-4.8608880849721485, -6.093543486552334, -5.310540670914264, -5.805337386734847, -5.772712488262976, -6.192018424847665, -4.5216418984494355, -4.801934639771442, -4.9137790911924375, -5.63985473095627, -4.408497505870788, -5.813000764801223},
    {-5.45886839858283, -4.452995751602438, -5.465397287701908, -5.015446526933482, -4.823443379586304, -5.1198706167133645, -4.609424937454936, -5.162585833869461, -5.435820856497244, -4.643401990026615, -5.315867780501866, -5.439498126601292},
    {-5.31265260268201, -5.5163165221235095, -4.747353479169704, -5.15899955059097, -5.287731664287189, -5.112190253194655, -5.35738831360374, -5.71346136154426, -5.971917763591702, -5.288396541277463, -5.044055480060872, -5.184960630830653},
    {-5.4583898802575606, -5.689883658064165, -5.528068899802373, -5.624489778831691, -5.179431339873343, -5.776741706031953, -5.538462388333811, -5.552294921520718, -5.456867435680259, -5.333081820343928, -5.717642788273103, -5.864901208277509},
    {-5.366486186300027, -4.847739543304577, -5.281532060793202, -5.07044336521584, -5.211023327923855, -4.844825862187782, -5.962554144188324, -5.215058841941396, -4.862329062575296, -4.822205188733036, -6.08752604974579, -4.618986945292718},
    {-5.296997067905192, -5.689763924193339, -5.431266716087566, -5.776689388800754, -5.287200764303411, -5.750057261853235, -5.152922277782791, -5.372815431708385, -5.408090207303466, -5.33459369913545, -5.424689328970752, -6.162286211114623},
    {-5.941880557126104, -5.9126274743663005, -5.227661025671807, -5.885985686976994, -5.434927784158605, -5.524246690141378, -5.907291315275962, -5.670205733905819, -6.005481970772634, -6.117989900410792, -6.605861167810543, -4.941291488711342},
    {-5.7250565118631656, -5.135142265375719, -4.8503332763209075, -5.2541726048439585, -5.811747430940084, -5.0565289689744155, -5.637092554787738, -5.537582261363803, -5.117275569122338, -6.178986397032524, -5.4647621373175, -5.379464198843914},
    {-5.668965587424458, -5.961375125894694, -5.708856138188891, -6.064762161769279, -5.881595834782651, -6.108344974605749, -4.993963673822814, -5.484520790136067, -5.800819912934534, -6.090268410439338, -5.605304984308497, -5.8801475688068345},
    {-5.016062017555304, -5.602600682190358, -6.115182158069581, -5.4106299030274885, -5.035946437867829, -5.333536944834504, -5.6670513222932355, -5.32732005367127, -5.490839169376295, -5.25555289448684, -5.360713969355022, -5.265017311275398},
    {-5.439344953103133, -6.19901971424639, -6.337184826431866, -5.818074434154335, -5.560143203043822, -5.254344009444815, -5.58021795719722, -5.298312736335296, -6.300274300590532, -5.6625436432944065, -5.196102456852332, -5.585614473217221},
    {-5.942902540935027, -5.166130331777534, -5.661256493167158, -5.840488264582815, -6.210485184836221, -5.807502064729506, -5.69708372268059, -5.496044905797823, -5.250907421319539, -5.30216163192213, -5.780069289037171, -5.39613559465781},
    {-5.408910037439387, -5.659095437185224, -5.716865002521953, -4.478072913897833, -5.929779266415771, -6.447090264896152, -5.415836875946254, -6.215344711453506, -5.4837607145744975, -5.600551825274165, -5.13188384060075, -6.283485235288228}
};

static const float b2[12] = {-5.223272794211792, -5.653461948656769, -4.354648927509736, -5.184428857083452, -5.232023779086287, -4.927117563650254, -4.495872661262781, -6.126746054227239, -4.513726314029448, -5.038765198181876, -5.353575994160348, -4.878982788840542};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
