#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.1413285318650428, -0.6914262112725216, 1.0195575920420612, -0.019054913472005577, -2.8684792694311874, 0.7752843675785023, 0.41996225794455305, 0.30416889250388, 0.5818885750403958, 0.7662610612240079, 0.6803610903761648, -2.2601249670209382, -2.7484768458383644, -3.4846922570783647, -1.1098464859161155, -0.6378053341976908},
    {-0.2388287017363169, -1.6006258821424793, 0.046995291351375645, -2.422384240169982, -1.6065333822548293, -0.5327693038133634, -1.9713230671516007, -0.7161465235754424, -0.3231093125733865, -0.646671619236457, -1.4998414354128216, 0.7128150804807132, 1.8896238567450128, 0.6608363611999133, -1.6186158944475508, -2.037335123975286},
    {-0.019872744100992813, 4.181595873031642, -0.8025527729680275, 2.8770721477915027, 3.800483098650278, 0.510675703669669, 0.9344970952877314, 3.865550922467861, 0.9228602242303167, 1.3668938252069844, 0.36034105261558286, 0.04822989481824259, 0.8193232186552483, 1.9594193767109274, -0.13356946774881695, -2.6808738743548357},
    {0.44333615061882536, 2.9078008955669237, -0.7077737339152201, 2.5048981689875522, 0.0012791060731127822, -1.3039964540467508, 1.346255831195767, 0.6316166208466265, -0.2613234415271883, -1.0874607450812057, 0.08917311096966285, -2.2893268820911152, -1.1256455711169029, 0.9573591760320895, 2.712707038563397, -0.14177560811865966},
    {1.256426609843701, 0.8719366109869633, -2.2023458259556867, 1.6534643328733793, 3.0985743026410737, 1.9757731461751293, 3.961673002738718, 2.606859268811412, 0.9611054203723821, -1.1058664843989392, 0.8164667354765114, 1.084073447640005, 0.9793719643718954, 3.169956756546812, 2.802196662559688, 0.5947593518155145},
    {-0.9721575624862826, 3.7792009052063102, -0.24314974011068974, 2.46473950719795, 3.800089914158667, 3.532918943797289, 4.199677513206339, 2.7747334394164964, 1.2372805944931309, 3.037091885684711, 1.2095435280795295, 1.0252829747000243, 1.0393833316979446, 2.7550498902639795, 3.2537250660138204, 0.4585330548743823},
    {-0.23087214739711343, 3.231207858553923, -0.842353284437935, 2.0987915173812146, 4.033521761682439, 3.0639496972746474, 4.427016471511762, 2.0728184621211554, 1.7209923499885258, 2.8111189136368586, 1.6595909108212261, -0.7510044481608067, 2.301169673943218, 3.8706235050494113, 5.04006622425855, 0.4418841324438548},
    {0.3544616605776545, -0.3881278173428494, 0.067511768217784, -1.2292715231159823, 1.9591759403109161, 1.7402072339450572, 2.3546931522525, 1.1852299470753422, 0.3060071750450343, -1.033572501301929, 1.348598612598313, -0.2732037323821213, 0.7551474142143191, 2.6754222004321884, 1.4965414456925015, -1.4781233185946576},
    {-0.6580503275649002, 2.038024034540341, 1.1929147837445924, -1.310844988001746, 1.452634902751103, -0.5422252619532297, 2.7787653033625306, 1.4081372344658212, -0.11339975544073426, 1.025031128727386, 1.1329241817872153, 0.707906228815206, 0.5229440234358058, 1.3845154076686812, 0.6094844676674577, -0.9506426255055674},
    {-0.8051742377441622, -0.9296931754934488, 1.0751121549219893, -2.4935490859454137, -3.579290457438918, -0.6665218498038896, -1.9817917114424386, -2.135047268702567, 1.606301436767394, 0.3595853957360532, -0.7999063037855821, -0.7739365292079902, 1.6557480366276514, -0.02396092951662771, -0.34418384700641697, -0.27542747550818264},
    {0.9430949523955146, -1.0213889299834504, 1.7448157397956328, 0.5302755512301817, -1.3463651645042798, 0.21894416681062465, -0.4396270086655098, -0.39011022255597266, -0.4398181664044593, 0.9208119020366718, 0.9859256684551153, -0.6169771330430663, 1.6763045760264277, 0.4802473357050726, 1.6280261319651783, -0.02194598480182252},
    {-0.49508881072977795, 2.042879884542833, 0.13172535833247417, 0.032793994912960825, -1.1394753186824738, -1.748997395219421, -0.06556624837189397, -0.8051995977628645, 0.45399579023000847, -0.8468268308861883, -0.3192637714228035, -0.467500922167949, 0.10220322698562175, -2.282819371324414, -0.7119088777452409, 0.2429333771025663},
    {0.6144992831157645, 0.7904553942149941, 0.5669493292502318, -0.10854116230331873, 1.5746762575616513, 1.8297867635721565, -0.6325958079434477, -0.19827506350740398, 0.7191128131033385, 1.8996978405564735, 0.9909618178601168, -0.29805256300287164, 3.4144630341341187, 0.48435384316585073, -0.7129397425212138, -1.0008630349341587},
    {2.0896490285289167, 0.1664968244777767, 2.0943085633285823, 2.463402739964001, 1.2981287408111608, 1.1494890222874692, 1.1026812773256425, 0.3492882503238781, -0.20885602484959156, 3.4168850444104746, 1.0139567459607843, -1.194733154136053, 2.69016484853022, 1.2821798311398687, 3.7666956476738838, 0.7740612152446111},
    {0.9845964119597388, 1.87530622461255, 1.9573309215940269, 3.0484486626298257, 3.503124909160771, 2.231101676408209, 2.0216094719533886, 1.0293123493077942, -2.5657698914808402, 2.584737649563259, 0.9065860521422975, -2.18904052505069, -0.5281575341331132, -0.133779683822485, 2.3726631876665074, 1.6081243150489022},
    {-1.4369057166080776, -0.20120096438476986, 0.4460060044993175, -1.6399959926352847, 1.5200067831689505, -0.5025660201082514, 0.8067620212528689, -1.0553310282408985, -2.4718326406154896, 1.045198984952218, -0.2599059594322236, 0.5592814807090646, 1.6458220231741827, -0.16677850990209633, 0.29163977283901776, 0.5954731096172989},
    {0.3934571307341767, 1.7559629068031908, 1.9871566918088062, 2.6847338614181457, 1.8554541873535697, 0.3700129527414353, 1.8798788518397627, 0.2746912687129189, -0.9822690605588181, 2.8543645660229835, 1.4439233423340745, -1.135182312896139, 1.2550162024241474, 1.0299968215283208, 3.2157805903493664, 0.6602697987159988},
    {-0.6675453007378206, 0.08052754410279354, 1.237689656848169, 2.285969286046815, 0.9437407240509177, 1.1861354449268309, 2.0091635784288884, 0.44273208492919974, 0.5961274387406539, 2.2413071469228063, -0.12297316032865767, 0.6962690727268313, 0.1313882066610314, 1.3075897291499017, 2.794812253965539, 2.075218425733915},
    {-1.0938244210532246, 0.934939689528448, -1.496680147832935, -1.1288366892026713, 1.3546459430120574, -1.2699778049360217, 2.1175317073011874, 0.19065496490974979, -2.018232085284632, -1.5843581688013018, 1.5424401038125983, -0.20363636418965217, -0.33826894032663224, -1.2330553211413662, 2.4244501194261026, 0.40919425469986154},
    {0.18745356116293277, 0.8846717797454541, 0.33292217020356085, -0.45235383552275676, -0.6465333018769975, -0.29527413579923106, -1.0027496170049002, -0.5184929691169218, 0.21390743592851177, -1.2204267357636707, 1.4571757264407545, -0.12276325435072907, 0.32029474676889474, 1.3078897043862705, 2.1690629366054908, 0.015408050772237789},
    {-0.26711139306257153, 0.5556958638244849, 0.002057051728573197, 1.6805131828559405, 0.17986202317463093, -0.3625344044078372, 1.163093594641556, -0.1739916812982631, -1.1506109217096225, -0.9480751113365882, 1.9834949662935661, 0.22715761383373556, -1.4602859768302732, -1.2894114559328007, 1.4188251924458357, 1.0530060019247367},
    {0.6766832290152541, -2.19084229106537, -0.9786634855245719, 0.19332517088060414, -1.4224422388160107, -0.6314428205241926, -1.78788356310457, -1.5138089531395515, -1.5502690088653321, -1.8949569038448448, -0.40041236313992273, -0.9277524554295145, 1.8862468558795433, 0.3393813431134064, 0.9840454634511141, 0.6016139734332113},
    {0.04443137838028051, -1.7804614437449515, -0.6278960859542334, 1.025113746254376, 0.6486983036186827, -0.39250454879426266, -1.2176830613148448, -1.1223487134792163, -1.2383036267145402, -0.7389154855043596, 0.526632740222574, 0.3419837003735699, 0.36069897026440617, -1.6929403148892217, 1.005880332814165, -0.3461482413641535},
    {0.09665184624423306, -2.019819446229907, 0.5969259272389675, 0.9783876477172243, -2.0180401125443312, -1.259736376502104, -3.769899251800079, -1.3720335860541246, 1.1476065689998685, -1.7087965235806628, 0.5642747105219836, -0.7146569677705247, 0.06480139155901642, -1.7890024764718275, -0.13664776889683847, -2.0241886321969473},
    {1.8541357450229228, 0.33676534512934764, 1.1253688302129854, 3.951231907590151, -0.9651916896109665, -0.8611896289677629, -1.510982043790161, 1.388591326638254, 2.183999833158835, 0.5061614538593271, 0.9611335124940413, -0.7052040977189923, -0.04364272698764178, 0.1460794358384327, 1.0304061691060802, -1.0686931801092026},
    {0.7008954065584334, -0.5995730697611381, 0.8712165457273507, -0.12053859462788798, -2.089860141221636, -1.7260931376962991, -2.3835247337413485, -2.40933231042945, 1.4817147735244738, -2.5481775599756067, -0.308021058147991, -0.6135259274137561, -0.3517428728055373, -2.967905274884434, 0.5968415919343216, -0.24250840418157527},
    {2.3426039912097654, -1.7971084019236525, 0.026076963628254752, -0.5571348646973977, -3.96944270029959, -2.737936553958806, -3.340006747878813, -3.9254622550384983, -1.4030031591729248, -1.665289668198694, -1.5592657171038946, 0.5787499138504784, 0.22346340131402898, -2.420585706681407, 0.18541720189855426, -0.024708928995916396},
    {0.004975565315637279, 0.7252507874305094, -0.8229932691994176, 0.6607722906890261, 1.4357441353468239, 0.8842984740381656, -1.1764820959983835, -0.764488514456, -0.29853876511347704, -0.612722178641725, 0.10970810961526484, -0.0738217845139121, 0.18040397708050085, 0.7486959523167238, 0.22132245785282523, -0.7539661884355646},
    {2.031333850352821, -0.16941030865071233, -0.9749282864383755, 1.974312790582156, -2.0550953050027814, 0.03478561419678204, -1.9406302228543764, -0.17066049659775548, 0.0904852788337584, -2.080687752265035, 1.5530847336034455, -1.090152964727265, 1.2449690281280958, 0.06593459704464452, 1.4052216347995632, 0.18828356664558776},
    {1.3616295596039936, 0.8586806446284277, -1.3792723267009421, 0.6246550094562769, 1.3317813511267866, 0.30991676845161714, 0.6779178712384775, 0.8729671560128005, -2.251989889555273, -1.547834415522655, 1.1369660483885282, 0.5672335888074255, 0.2572495967417002, 1.0059585043346215, 1.730197186752362, 1.5060257522486353},
    {2.0753509283480223, -0.6601726014884094, 1.9934131204704721, 1.9040850280911905, -3.3966696853522462, 0.3474042920358808, -3.485229795505999, -2.416409994792656, 2.0357873795835806, 1.1008080921393708, 1.7429914486336038, -3.002261126630832, -1.31527449398113, -1.113859200592322, -1.5702668108861206, 0.39051400932925506},
    {2.4720033755255435, -0.5305195359705441, 1.763446649314966, 2.023699365835065, -1.316473819855793, 1.1778142166136378, -0.40894880474093687, -1.3247694833597083, 1.8725950540470617, 1.260210815604908, 0.42210567837178176, -2.304928776858799, 0.7378925828252049, 0.21338760417959782, -1.4429965313438278, 0.5327504270349053},
    {1.0263235352404831, -0.47281708661807276, 0.1432417057090693, 1.0619841861795951, -1.4882418945093696, 1.3508268203653973, -0.7667159872943703, 1.5683512487113922, 1.6375197374666135, 1.0361532810159517, 0.9531765204379676, 0.2109709517551786, -0.32917505662391955, 1.4660874696501511, -0.7242799317453356, 0.12738042947902825},
    {1.8044160831473164, 0.2597227581995051, 1.1094520372709413, 2.0034289541695176, -1.372128335693916, -0.23319224535293612, 0.4198260724596443, 0.19395020045723058, 1.1497804895015924, 1.5089512818878348, 2.3545192654162017, -0.5995543755424031, -0.3666422043260106, -0.13639167310380892, -2.2761525308204096, 0.44202836746114527},
    {1.5346432320374197, 0.7723627022597441, 0.027995896776093966, -0.48264865705257975, 0.7868151392716262, 0.9624105878232277, -1.1720468040281122, 0.1587401132207166, 1.7834811684521275, 0.6987583251121074, 0.6119886037337297, 0.46177628795989445, -1.8328093097729676, 0.8280195311579147, -1.8743704345996737, -1.203803567850922},
    {0.35497170111425674, 0.7847210779057576, 2.0425448133661295, 1.1023558514789467, 0.4439207049267822, 0.6279250958815834, -0.7027892833753417, 1.5971518312580784, 0.7970280946790526, 0.31290430716857376, -0.7782946936157626, 0.5480181453779145, -0.6755008842695289, 1.826682042458035, -1.0509854286572045, -0.5641162244880366},
    {0.3872374582298813, -0.09850615426167052, -0.7052260178449092, 0.6281111396565366, 0.08436318312283261, 0.15852148226081508, -1.1999594529186435, -0.4845532830328688, 0.5847470758836326, 0.17302439067406103, 0.4118903081985446, -1.3714488636330386, -0.4493324627848256, -1.0640094543317544, -1.337749190777094, 1.1305431900601117},
    {-0.33222342220684836, -0.680316380653275, 1.6306154449443009, 0.7776072824554351, -1.0045992491503462, -0.5765719822661097, 0.7215587682165446, 0.47162082503921393, -1.227674164369929, 1.9104063872956887, 1.606853300315936, 0.15676377828453403, -1.458009824426311, -0.47688339591162643, -0.942036201352536, -0.8347299056477695},
    {1.2056265206961314, -0.8692328213181054, -0.022391924311458433, -0.9114812385095787, 0.6717258571057108, 1.073403601081331, -0.5139609659504383, -0.42564852759220684, 0.8331918963629409, 0.7004942089945475, 0.7718264893284611, -0.20427255244375345, -1.9327942385170305, -0.209214757193073, 0.39505267092004154, -1.126208219407207},
    {0.9707034721494564, -1.2313087240799385, -1.8090805189808525, -1.3885230508013051, 0.5859335891044555, 1.5579198283854485, 0.970742474973041, 0.7763011876424328, 0.010901402807705653, -0.4328128542340799, -0.8541520661801579, -0.9798261359872128, -1.3137315934337832, 1.6213449769625798, -0.6590573982451533, 1.2883313243273404},
    {-0.7061230929193762, 0.8054342641971458, 0.33263795276804736, 0.1342706578939811, -0.47196563246351475, 0.5006630994481795, -0.11954133533104191, -0.4730842574998125, 0.40709244080954626, -0.6489570079630629, -1.080682526730176, 0.5922132518732999, -0.728210276117779, -0.409964367763824, -0.4298863712305084, -1.553848609597738},
    {0.12224926158404327, -0.4406245393368794, 1.9127185471934984, 1.2575472506394074, -0.5821151483006806, 0.6521722449412137, 0.41599027289530016, -0.36049637791337186, 1.081015788192078, 1.5496322712585564, 1.4996569346953645, -0.47704174816508604, 0.07878057294422786, -0.957221510876082, -0.36734603802190635, 0.24678784815859775},
    {-0.14783265233508275, 0.5304647447970439, -0.398711380638376, 0.35629216543773135, 0.397336019644129, 0.15714446248533429, -0.660878537640599, 2.0596576570063054, -0.578070287819904, -0.9684359304864919, -0.9963891535651681, -0.8310857476653949, -0.2350523099906675, 1.1781227135304664, -0.6873307969036381, -0.364755617206112},
    {0.9089941263841563, -0.7608483091706225, -0.43344648805311387, -1.2808951699566495, -0.4067366940357223, -1.1332264275332573, -1.0718532085503407, 0.44382619320662786, -1.251875793552225, -0.8002491391909211, -2.950180720026357, -0.13530562979702337, 1.1553341905230088, 0.056924043551125326, -1.1178879109198845, 1.0472457779620197},
    {0.6201296059524553, -0.6594848758012848, 1.6346050266885324, 1.1510627314596558, -0.2271799700893864, -0.5671868148524816, 0.06326993289753281, 0.5121822781595553, 0.013851251220713123, 1.4998805402774995, -0.7159608609681436, 0.8026303680757458, -1.1232314134197932, 1.108370104323969, 1.141545086066922, 0.5988502469889884},
    {-1.1619832471830176, 0.18711036394284014, 0.3360071950786072, 0.8654330253914425, -0.9550595285720697, -0.9203735117513591, 0.11331334156631405, 0.7881931885302057, -1.4610198898152504, -1.2674921504484589, -0.21374440297668945, 1.37668405707658, 0.35599975728350697, 0.8154033188741172, 1.2063527783231707, -0.04951702198212107},
    {-1.0075928615029979, -0.7730625938226915, -1.5314678016009289, -1.165453229670052, 0.5905099960164449, 0.569354000334066, 0.20312342359689411, 0.3666761670962851, 0.6935321818476706, -1.1248531586503199, -2.1540909109002784, -1.37088424443797, 0.7655966169068231, -0.11140276994359884, -1.3052876935157103, 0.2845441925955223},
    {-0.5456801871456225, 0.4018104941114217, -0.5544444876089217, 1.3627121278413865, -0.7823344076612616, -0.32444604855257764, -1.7035202281164812, -1.2573582543410913, 0.8000359756662334, -0.0009780618731956886, -0.13412883316108504, 0.14796977749764217, 0.2070266412035305, -0.6908876171476814, -0.9376122738751436, -2.28984047832908},
    {-0.09890511398567446, -0.0071948139414348454, 0.6107402191299544, 0.44416664723612026, -0.7031831847557489, -1.6067888858807302, 0.9949860049649153, 2.109365695202637, 0.33378385393039567, 1.60864006798734, -0.6957651721165553, 0.07909332072078767, 0.6247232724264401, 0.9457461451529942, 0.7041350658251512, -0.8929701166592441},
    {-0.9439798048850679, -0.6659513951254802, 0.34154888683665147, 0.2536239023918379, -0.2547451041991612, -1.0014081671094335, -0.7161420511231098, 0.49777049607734647, -0.31759903535587236, 0.9349416887575731, -1.8391133752086275, 0.9332343944447378, -1.5862052244409208, 0.09834042139890561, -0.6298051039014791, -1.2881663630460318},
    {0.4319585042760035, 1.664013199511262, -1.7324030834479676, -0.44785545931910975, 0.8902989494556086, 0.8766050323111985, 0.41352010488974517, 0.31038093598715844, 0.19019616813372162, -0.8404791207405371, 0.13724707610128373, 0.1225474160031479, 1.1495452225210765, -0.39730898653675645, 0.47604434045366784, -0.7360388255963554},
    {-0.54774783800747, 1.818876777334078, 0.7303109909784392, 2.3119769508286416, 0.10184428199971401, 0.013592851434322173, 0.48795315046581145, 2.2919163491286545, 1.0471802800552132, 0.8657989197551668, 0.6123873837663475, -0.8295203962620383, 1.6413708073570694, 1.107337863309406, 0.7651119116956565, 0.3703288029945456},
    {0.4055781317081977, 0.9099795011985281, -0.10419360414001158, 0.29057902443391875, 1.095928401496255, -0.18157455911590614, 0.11265858592824968, 0.2164753857883043, 1.1742507701420468, 1.1146508691946033, -0.7614784322808889, -0.5347332795242787, 0.5598910768727097, -0.7514492073099583, 0.4524563654491737, -0.4266350646593929},
    {-0.9132149746683215, -1.257357635436625, -0.7528261568507312, 0.45072480318064556, -1.663311289626097, -2.393883672758241, -0.829751355906271, -0.42804704007661776, -0.4809704698032669, -0.16773858942400868, -0.33002457311229744, -0.5014132420177628, -1.595621179531074, -1.3041254137810316, -1.696405787158409, 0.007104941585308982},
    {-0.43429129272818806, 0.9536278837975086, -1.0101769631588675, 1.265272389870138, 1.9951653606364674, -0.5907502989138775, 0.1925162074663169, 1.0921261766086525, -1.410047778410111, -1.1055411477340498, -1.0470928888729072, 0.1909470925747906, 0.5447187369687224, 0.12672662514758842, 1.5638858154158939, 1.6373669552078722},
    {0.11770285303450664, -1.3418378712317902, 0.24175910317144217, 0.9523449455151355, -0.533507445849383, -0.07040196646695476, 0.6621407862413518, -0.48053322777878943, 1.8341670573147468, 1.4005935276792645, -1.1282906864650726, 0.39542772207092247, 0.034582087240466734, 1.0447859001700843, 0.20238626182339478, 1.1411600355082967},
    {0.4487542203667055, 1.1766243305266049, -0.33175233342652055, 0.1511997366830776, -0.22524912532295163, -1.9942206919678898, -1.7315427173661484, -0.5075448224170841, 0.03737774009440448, -0.7700755124612048, 1.3906515950016378, -1.2806731335765056, -0.32055300209603305, -1.6031466232009899, 0.26545357206753484, 1.7407361130392789},
    {-0.5932492801317292, 1.0297719960142369, -1.179619889080422, 0.011533892678009973, 1.3958222020538218, 1.738071147385984, 0.020395396879393804, -0.05078928921165499, -1.3844140079459488, -0.3576465430010073, -1.9105501023633857, -0.08903037726824739, -0.6869981709211964, 1.3493766887498002, 0.6152014038636316, -0.6495655617670343},
    {0.20453595221957757, 1.1919349236591468, -0.14746286414502674, 0.281589926065127, 0.9165334842824311, 1.1573283547239508, -0.3529347655376225, 2.7240844573993264, -0.125631862140395, 0.13985641195365617, 0.2504415477868958, -0.9631204535292914, -0.05729307727467861, 2.0100238408512103, 0.29561045156045546, 0.5538832324982446},
    {0.2347010424174539, 0.20988541413419293, 1.6658478831551768, 1.029071920812516, 1.6890611970309455, 0.21837407488405677, 1.1860271820002866, 0.3743828771642979, 0.05769102936354413, 0.7846480270926636, 1.1415491789947307, 1.0683454948777855, -0.35609120031528874, -0.598252670582199, 1.0902484368004994, 1.1718323759930747},
    {-1.1219800361181589, -0.6828059054044542, -0.1038387093091409, -0.8229996469329591, 0.1839926839372551, -0.18574583279165396, -0.3083232745300408, 1.0250963297750209, -1.7179707087204075, -0.8866489638651072, -1.8570440464420572, 0.8845067366460181, 0.057731685807712325, 0.7130218865198881, -0.08556576383942967, -0.41810775318144283},
    {1.4274294044736742, -0.735179142732235, -1.3424986885934724, -0.44120220783586356, -0.10159014688350487, -0.6552356084745551, 0.060894675933120285, 0.15563656867790282, 1.6911612684490052, 1.223130009299055, 0.09925302393238122, -0.8917449366001573, -0.13075485186524116, 0.235673871429643, 0.17329802294036267, -0.1777691614926349},
    {-0.8445942703450192, -1.888202837227024, -0.5206446244513185, 0.6612057810833253, -0.15826623999050443, 0.0027723952233894606, -0.727206536934808, 0.3179695679812865, 0.6571862273207375, 0.483328422646555, -0.8569233525165276, -1.7382307845064353, -0.6406596706569304, -0.6006631028429554, -1.169156620015934, 0.4414642491091398},
    {-0.858069961753184, -0.16917149341666826, -1.0961545934503631, 0.02705115828770986, 0.4863795607291839, -0.8469304789636437, -0.7901462534634683, 1.2771194001736657, -0.7256191759612529, -0.6634239676636593, 0.1609529468703744, -1.1934641056636464, -1.0005792724257718, -0.35392029853328744, -0.3796752624083154, 0.15074059527227662},
    {0.16441370410617076, 0.2828715013385187, -0.2041455719585654, 0.17194723958368058, 0.2602087137844757, 0.15892336890897119, -0.5424153655089532, 0.8490588684020162, -1.0249020858118363, -1.099863893396759, -1.5652908910290997, 0.49081511612730294, 0.7312075367708523, 0.023863683557181728, -0.39146564851651877, -0.7002370493588972},
    {0.6391320831371581, 0.6411815737477857, 1.7323274108258717, 1.4595333672579591, -0.762347797811952, 0.2794455576754357, -0.7289532829343202, 0.25029295377486654, -0.335473179201255, 0.46426317751285656, 0.5243254654826391, 1.6525633244688256, -0.6580230552369573, 1.321803006382764, 0.45089413698141617, 0.48464465772351295},
    {-0.7722701758333672, 0.4827008941749042, 0.9326161509388009, 0.4461270757826791, -1.4517630792769638, -1.2351391370431382, 0.8250193003622464, -0.7079707695082421, -0.6060516402976309, 0.6519578091343297, 1.397304006416254, 1.2283446612019702, 1.3688673027546052, -0.4600104981706106, 1.768037574415764, -0.1352465042357421},
    {-0.3959677792851086, 1.3750814486319969, 1.3276260642711095, 0.49992683859927806, 0.22868355551538166, -0.8513326142734555, 1.1308135631351866, -1.0625263399668683, 0.15690897698692233, 0.15584674288191094, 1.4164736501388315, 1.0068654374557182, 0.17169511086353106, -2.004056360691704, 1.3547902661513695, 0.26209063441302427},
    {0.7241683213112967, 0.6339308091358781, -0.5858018488550907, 0.018014462950020443, 0.3361275233370314, -0.06894522744927975, -1.129021525237468, -1.064760324973395, 0.21240291882434517, 0.7315849159936306, 1.3984718648826386, -0.7050292826206824, -1.2721047339372218, -0.9249410588030619, -1.38658471486718, -1.1033677484211408},
    {0.8659853713863829, -0.9359435112086167, -0.928387574689139, -0.12050162613751204, 2.0382985624964833, 1.707191981407074, 2.139451872861209, 1.6278268023831395, 0.8104819973663272, 0.5137515833133002, -1.28334679829268, -1.0219946086475178, 1.9694041936077982, 1.390527560334328, 0.061515785195463274, 1.2852185981349453},
    {-1.0774902976826592, 1.3090831908429417, 0.4485563560444791, 1.5553012888559439, 0.27488758799975804, 1.3671215074025251, 1.0769032260318843, 0.6935394272276212, -0.9832836274691381, -1.134756020136027, 1.4480695488852906, 0.017820577714724933, 0.04144511681895507, 1.9324898797164822, 0.5161283557608449, 0.31884689387902426},
    {-1.0018421021765571, 0.7562989456280879, -0.8697992146213923, 1.2390338825164267, -0.37940960108786725, 1.3095909849481957, 0.7443408262326154, -0.6563695930536183, 0.1486024404206257, -0.721616077680347, 1.3609730103084992, -0.09291049856195314, -1.112169944011636, 1.4349974150049407, -0.5213997883206223, -0.772423888681764},
    {1.2717682916646005, 1.2177976948885105, -1.1261740470277641, -0.9905217367771356, -0.0011384573164457835, 0.09258146906911631, 0.32437998806427415, -0.6277340786276941, 0.29804583220828146, 0.03172317124292611, 1.157176225805638, -0.39154409950498537, -0.3805839071385534, 0.7014055664321284, -0.019317768454486642, 1.1670736601300415},
    {0.8039477499918467, -1.335484117833709, -0.4398333554985144, -1.1218756644053183, -0.9412569699045251, -1.082668978827355, 0.4975254024015635, -1.6135483740174195, 1.0224842703757056, 1.0757799539037751, -1.5034561018594208, 1.310507416109237, 0.12131234712317063, -1.763057765888175, -0.5155186742925467, -0.245274896440717},
    {0.829722492000142, -0.6596739541514226, 0.5628443914490372, -1.0196094119931434, -0.4073821236774637, 0.3182511864614095, 0.06326578161109538, -0.7779684498775633, -0.4679949008788954, -0.028449514089966495, -1.919009153659087, 1.3460135512220135, 1.2378262336519819, 0.591227520561219, 1.3626771346336566, -0.8176887282889598},
    {-1.0099728183040257, 1.0574627156057341, -0.12745328423571486, 0.5087827842840722, 1.1120216286424138, 0.9948679937088304, 0.2837639708035378, -0.2676479476452382, -1.6114783025168735, -0.1513813205241836, -1.5930393120660582, 1.0479363484689244, -0.25572204066593884, 1.3630748459240372, -0.10375541323267577, 0.21523326521469838},
    {-0.2610686044973662, -1.5590949809552261, -0.15298311553472585, 1.0590799326492184, -0.8689866504331982, -1.0369573416253437, 0.5261936600381595, -0.7257500123296551, 0.7642934973645023, 0.7716419570619925, 1.0746488365888276, -0.030921681583757268, -1.1060826307099574, -0.9552574800372995, -1.1193128290919294, 0.366402700316792},
    {0.30542587855704817, 1.1937582374025173, -0.7376315358558846, -0.3982226876878264, -0.5077315628452316, -0.3415272461521118, 0.21956125735450877, -0.7944222079397377, 0.15525871380117584, -0.2684396432121098, 1.2085855519800583, -0.5728324966915479, -0.9995510387501318, -0.02710768493809656, 0.6957877646858657, 1.7998787720703986},
    {0.17614948489246596, 0.5405765146384317, -0.6153150141161413, -0.3597930788065069, -1.0785563535954532, -0.1929949875022411, 0.8611846544428904, -0.767185529465487, -1.084697464077888, -1.0243848460225002, 1.2507516055382806, 0.43354960541666643, -0.7813094117092221, 0.23002575840801862, -0.2121245684914555, -0.21441047098982485},
    {0.2671853283441125, -0.5311632529670509, -0.04418753791053911, 1.0884163289567863, 0.12952342879079246, 0.29584981264293897, 0.8046247140613894, 0.3259431885206504, -0.8522450833612913, 1.2682089528026725, -0.36019257898697243, 0.2183124847988007, -1.1239563035324895, 1.0025358617088984, -0.8856468920404977, 0.617239759203207},
    {0.8746221748133878, -0.8586992039492747, 0.0008700340908229121, -1.1717290468312056, 0.33881990824450336, 0.6913978885770776, 0.8067817571472387, -1.528676966815787, 0.8020052036189317, -0.6443560402090116, -0.15840394762443333, -0.889128936961966, 0.5949943814281531, -0.5257582950432115, 0.3875634261694024, 0.6821998382679457},
    {-0.41992339483421093, -0.7236691779823176, 1.7732248117857066, 1.5194748205044053, 0.3934379927327917, 1.1144437083386465, 0.4266863201214752, -0.029105516383254863, 0.3233376012842599, 0.6151319548372378, 0.6232173896987248, 0.8803181320977925, 0.5818323007293981, -0.418878979742087, 0.2319771716313508, -1.205468180929531},
    {-0.532905249803172, -0.6049311003706714, -0.18051763878126895, 2.008112152681634, 0.4758910874298923, 0.7752076671829357, -0.8152168707801805, -1.1531322286943992, 0.6887676638009842, -0.8423206703145034, -1.913100585330518, 0.22593168289225302, -0.6824433393252787, 0.672065052466817, -1.5060176224858643, -0.4588783257590735},
    {-0.36136839502248874, -0.9559080026325638, 0.42108489464645227, 0.5021718596344114, -1.387378614630496, -2.040500375319469, -1.1178696597078979, 0.39295119878180385, -0.43439713539375957, -0.1077444314891199, -0.6247893017746111, 0.5849316263304211, 0.6384208418732092, -0.6196553947230851, 0.3587804274986391, -0.557050616849076},
    {0.44826973993203906, 0.7473106636914416, 1.485467755268575, -0.5801754306066713, -0.7421973597267885, 0.832351131181426, -0.5940704125707694, 2.050850923171383, -0.6102311173030561, -0.1393050504022827, -1.3956185006068558, -0.5725239542385892, 1.2371027818843807, 2.060901958521587, 0.1302421231136375, -1.1609684873102741},
    {1.0383144523559855, -2.0428559391353422, -1.7665752530187695, -1.2066633091793735, 0.5530777579902891, -0.5678953964590823, 1.1114328971414307, 1.0143056003351978, 1.1274621858568967, 0.913692298544984, -0.5658100382911689, -1.0015722968074412, 0.7696954666578624, -0.6109054717337301, -0.03221295135611928, 0.10264865549941014},
    {0.1682257108499626, 0.7459057966264573, -0.5622692106198078, 0.09154422598583549, 0.05590922024688333, 0.20018170270661495, -0.6544952751669757, -1.0520622909063084, -0.8919886376028129, -1.8845197016146331, 0.22454219054795208, -0.46943181894563446, 0.8898728421001364, -0.19169870511077855, -0.6104919139961691, -0.1114248473973317},
    {0.2164648119609672, 1.6464650981941062, -1.8277306766647547, -1.9439451636025922, -0.5458106155550755, 0.6223364583782868, -0.6002979880200696, -1.1449438148236795, -0.042422834048441715, 0.2739555421144057, 0.8956516015075264, -0.00028762316435496685, -0.6293293010261793, -0.4132594973960513, 0.8185430094666662, 0.22003847374670119},
    {0.5465759884165864, -0.6384996794040781, 1.7410841069619862, 0.9946075675052486, -0.8118897631541201, -0.8679817134367838, -0.3529880193072134, 0.6486918617689836, -0.5963618142013382, 0.6454870152941884, 0.5145854579497634, 1.5112608209295861, -0.518966842329043, -0.43414297501917554, 0.4744850019688005, -0.05407023922964624},
    {-1.3269718822994863, -1.0171520228846649, 0.706278734002121, 1.1195953574778994, -0.466843927487029, 0.4911640167760148, 0.491243145979129, -0.8541311470432921, 0.24736521389743096, 1.1432954908761326, -0.8795364881415869, 0.3317044757661593, -0.7310422336359685, -0.3234831872082986, -0.7311397248345046, -0.6445641193058753},
    {2.0975664164876724, -1.2624324113719272, 1.3745554066198122, 1.271419082671896, -3.3151661387697238, 1.2063802413606213, -2.756818629062675, -3.4802927800297754, 2.00656311426786, -0.4980299522475863, 1.558836718136117, -1.5061156774828213, -2.576259822967475, 1.5719323095118867, -2.478105794858458, 1.4948687681494697},
    {1.8486552996543, -0.5356673968536126, 2.146476361677258, -0.44716645212437955, -0.8505495328850584, -0.9701306564302425, -1.5563939461262928, -2.882183091104405, 1.7735379456558487, -0.8174580519905088, 0.7143551945769068, -2.336768887122722, 0.22648897278660365, 0.9976393825705565, -0.4194764462914874, -0.4037666857490931},
    {2.2778409700952444, 0.15199353759156578, -0.42207086645867864, 0.37850061979776345, -0.6232085187219157, 0.23314662268660738, -0.1315161051881132, -0.17943365847016743, 1.3837981952013856, 0.3008766549159107, 1.8358077323300164, -0.8047463801222107, -0.21779485554593844, 1.132775905791748, -0.8696847343433278, 0.7330983062337934},
    {1.0169969594220278, 0.27742045813629657, 1.7660393306242563, 1.9766959725200948, -1.004255485187016, 1.3833620484191438, -0.7164507283696236, -1.1656091800836823, 1.6631017606108873, 1.0367468292206234, 1.8580869012961632, -0.10322295993121045, -0.5275347375303416, 0.39320045706325535, -2.377237804813027, 0.09628683916307014},
    {0.43832588030834674, 0.9096040286760478, 0.5368599749997123, -0.2288265098943671, -0.1674666522325691, -0.8638132739759283, -1.224354854492525, -0.2797896870314202, 1.4142389683767116, 1.0647072379502172, -0.2756556828741253, 0.45019251836673574, -1.5573022497050466, 0.4396993153259862, -1.7641552899925144, -1.1620152948213678},
    {-0.25342401702867523, -0.2001105786238436, 1.5796420461566723, 1.0716385776190747, 0.25478900734906046, 0.6660402937825641, -1.2947696544378178, 1.6497513558035297, 1.2811473778789457, 2.1324789475880253, -0.24732814548589477, -0.5604173741867006, -1.3261000123512696, 1.528366365071914, -0.4706071134888636, -0.2756038634209921},
    {1.804161241481863, -0.6139245933584933, -0.10531875281575777, 2.000309840916437, 0.9025047830098524, -0.005058104730797553, -0.5603195309888589, 1.2460297562734237, 0.3688617826131109, -0.20194552124406068, -0.36339342873758596, -1.6807215872813461, 1.7563550368407068, 0.23089582084839477, -1.608806110348839, 1.1015120902336724},
    {-0.7872435160735584, -0.96515253568861, 1.2770069448320613, 0.1504966535547847, -0.2535285060329094, 0.40103071140393004, 0.834182104700562, 1.1090420111369244, -0.04837538421098634, 0.6096895883308691, 1.8107456323852635, -0.15629760343366117, -2.331561679390415, 0.6092174199043194, -0.24506576604209426, -0.8193338008244269},
    {0.8848122971528726, -1.0262303092131086, 1.937310974220969, -0.6564015195651737, 0.3332220782215672, 0.46535414920115914, -0.8639594788421153, 1.6448713559948611, -0.27170407284612985, 1.58828965001884, 1.2423471148357517, -0.7128301773444488, -1.9236680982121523, 1.5161538765119986, -0.22386886292439417, 0.38423571715703136},
    {1.3617368024564571, -0.5220581536620528, -0.9527758597027834, -1.5354552873025524, 0.24113744553710786, 1.3073824798541638, 0.4190803925076665, 0.21656222884023724, -0.09513945402805578, -0.331451423789251, -0.5623065699050325, 0.0728902754579815, -0.020804315422326903, 0.4911016213296431, 0.5860540959083991, 0.5379970092242495},
    {-0.9680345442709368, 0.7442038084676897, -0.40031194905852846, -1.553529921635301, -1.5052431074388046, 0.16827392288251697, 0.04883459701076985, -0.9220380665331712, 0.08107982668710971, -0.5454331141959065, 0.9816271397713668, 0.32795049873949617, -1.0027900813765709, -0.021906151246509506, 0.2985493176116804, -1.512569371316363},
    {-0.3097161022330886, 0.46423797458430976, 1.7999945112237126, 0.9362211862233779, 0.7042641870500709, 0.6262015155122568, -0.5769402528489624, 0.5521546604007844, 0.4034335013992331, 0.044097121571978294, 0.05854596785873131, 0.9425055571499974, -0.7232193075404016, 1.2099960769276075, 0.5159191432081581, 0.9864612830519349},
    {0.060140394911010524, 0.0785643890890196, 0.13594302732497615, 0.676619525677174, -1.0126029953892002, -0.662860086474116, 1.0424498967387816, 1.6917768988633197, 0.8094800011443379, 0.9289060411492881, 1.459080714567399, -1.441126779313381, 0.8320767640817279, -0.3526914655126943, 0.5253441252413934, 0.3919924136674889},
    {0.4837201887490473, -0.30557508400408023, -1.0713100918208391, -0.1928563207949453, -1.4614606019389396, -1.432902960948559, -0.1557436519672184, -1.0166099308975594, -0.7558955779285744, -0.3961494002715032, -1.6272079119848204, 0.365552646182577, 1.119550625562034, -1.41525218012213, 0.21607646231838545, 0.8862719555825577},
    {-0.6780582296521052, -2.0044386880610836, 0.09478485175616817, -0.4106989359231542, -1.7367115128760875, -1.5034701719984598, -1.914376524652349, -0.6681784114995629, -0.5626256122187949, 0.3249254235879378, 0.36788887309529844, 0.237952013660183, -2.315100532585075, -1.2927901729204714, -1.429125220918289, -0.983431018828755},
    {-0.3240220018069263, -0.26951757335563337, 1.6152654195195641, 0.966067853987657, -1.2373384651257924, 0.2327112639513023, -0.6400192721662196, 0.8683523064452477, -0.8010134127002067, -0.5797788553652778, -1.5026944354313283, 1.7719607478825588, 1.313588449439086, 1.7411062010923493, 1.6433613990984801, -0.0562716816915081},
    {-0.03348183282625951, -1.3788999262625545, -1.821835476798219, -1.5118824814270913, -0.5840858370077662, 0.5614951452169967, -1.6149477075361436, 0.9106434314110387, 0.3664089126154218, -2.022482906526755, -2.3124740301849367, -2.2223952852783366, -0.9237822382255065, 1.2727705784848875, -1.6906166289378493, -1.499309115231972},
    {-0.9113172497389944, -0.189142286547192, 0.45980085713511754, 0.3859026892253769, -1.2216210545140267, -2.107952911958127, -0.9762886878955455, -1.5798164452186574, -0.9970418869328685, -0.6753287294557574, -0.18879435030848102, -0.1496154161553816, -0.619223808153924, -1.8647278311818185, -1.9238294279653654, -0.580311761554689},
    {-0.8729511689552811, -0.577679620566039, 2.5823524040073385, 0.3009189821804286, -1.6418861728462788, -2.105948875253362, -1.596142222778487, 1.2729176184483533, -0.43282490659656636, 1.7072591509554724, 0.629283190157899, 0.9509032565283131, -1.3355255977599831, 0.8122647911209664, -0.4580590119156008, -0.45634252084223503},
    {-0.30255607203820534, -0.9958888326177285, 1.4667166857553284, 1.334342556992473, -0.2809390025259733, -0.23752133003382903, -1.3191677980680365, -0.5830542770518344, -0.018572686163699843, 0.7759459300093959, -1.3041347402075703, 0.47343510347043777, 0.2793766130219528, -0.5061929901690027, -2.117904650685166, -0.635469249673471},
    {-0.7036805654925096, 0.12276755944425342, -0.39428864810028974, 0.1269726262497867, 0.7049978657760436, -0.06538571596306295, 0.3166829803823279, -0.2944277465362607, 1.0347010436575563, -0.5171355280802233, 0.21778986786679114, -0.5081778421589649, 0.8060531030504616, -0.5534095286382836, 0.06924284940746007, -0.7912148901458229},
    {0.12667068730663994, -0.3049445194332808, 2.316192232698987, 1.306779653502954, 0.2510100501581559, 0.342343386165998, 0.7076899182135107, -0.39776946224434717, 1.5256046886791093, 1.0273890471248184, 1.512336817893872, 0.4131169688895205, 0.29049345085449796, -0.6407067582174266, -0.6124351374953324, 0.5964437938673577},
    {1.0159313274884092, -0.43765099332179547, -0.14297597658972336, -0.16425731513570538, 0.21580798730522618, 1.151561814847478, 0.60031348366458, -1.0564147192631366, 1.4827340844732193, 0.371014762767976, -0.7789782528222199, 0.43360328938523685, 0.36371999141680306, 0.41647553625225786, -0.01987445245206673, 1.2598550012441228},
    {0.19533924595607494, -0.6742989427310349, 1.1185788366613525, -0.07020584127318469, -0.45527249596054076, -1.6388626511394566, 0.4682726384920796, 0.7056353691342412, 1.1823903344061633, 1.9321055162550869, 0.5468034862375263, 0.6324665403125688, -0.3367111128640028, -0.5740088694745813, -0.2692051803254015, -0.12739871679648582},
    {-2.6254613093565915, -0.3840644346031387, 0.08328639643353584, 1.4406679043016863, -0.3537934734233986, -0.45858593390943553, 0.17728478991362842, 1.1893858789425733, -2.447395452971278, -1.6628767231436894, -1.9805424080989014, -1.2076804085720514, -0.3688070284168971, 1.2099877096042944, -0.9782938914800214, 0.59766571952789},
    {0.45087213595744713, -0.46349980506913124, -0.22455896299455172, 0.5763074965506971, -1.026428001497368, -0.3635604602856755, -0.5272894578392343, 0.26070945409571317, 0.9708562889254093, 0.013007672643370535, -1.296775021414395, 0.9685575310150174, -0.3289631225887357, 0.25358927583679175, -0.6517507533034466, -0.12566357537808434},
    {1.458764413049511, 1.4930397834877829, 1.2608061605174408, 0.5439939301062005, -0.8169575330091751, -2.367012474764704, -2.1648903001098616, -0.8506426732335536, 0.11081989988244474, -1.3125190714820993, 0.6853609940725622, -0.1586034159592968, 1.07649066620534, -1.843114434087047, -0.04829538073257085, -0.14538818670100642},
    {-1.9627666904236183, -0.2958975245408068, -1.4394938913162796, 0.05399876934115683, -0.17715082646232508, 0.22607282719215246, 0.5852178594554424, 0.017646929031317295, -0.9826575260811652, -1.9180764454797299, -1.8122825806960934, 0.8275972518268911, 0.09335072662884997, 0.13590242653778054, 0.7301963604735343, -1.0835335930632373},
    {0.4766179581317366, 0.26285837144896784, 0.07352496347937887, -0.4636149092552238, 0.7829452303946351, 0.5664733899712003, -1.8523891458460426, 1.44029554694846, -0.33700831658655156, -1.0820357070836726, -0.8755112566451049, -1.5185777836575345, -0.24100381058207015, 0.8561920261660173, -0.139347688275393, -0.45509416268126335},
    {-1.4331348257808052, 0.3115710601774288, 1.8539196202215265, 0.7211638467645637, 0.8657973396273636, -0.6715095073168799, -0.6078139643368976, -1.2137444091632112, 0.32346389156384237, 0.9968569026115561, 0.26503542553351184, 1.510591963376451, 0.2116241680651385, -1.580101684976987, -0.5136879785685844, -0.7325014321714107}
};

static const float b1[16] = {4.653190426520363, 5.339367321301241, 5.397130119658585, 5.601045577823814, 5.348041847613656, 4.993605249130149, 5.345669558208733, 5.26188530074075, 5.34340017099533, 5.201272894607873, 5.34560716924143, 4.416149172312158, 5.543923931436773, 5.7485837439787275, 5.5225423841026196, 3.532611262129746};

static const float w2[16][12] = {
    {-3.3551816573692883, -1.8116502972965598, -1.4924454284584363, -2.323685041220769, -2.9283992438309188, -2.0146502434013644, -1.920353116803703, -2.193563017102889, -1.0682195532850491, -1.8948359863827153, -2.1934526102060947, -2.5825200377349193},
    {-2.6413534792945255, -2.9329434896226148, -2.627383124777062, -3.5926952787276427, -2.6417577497504277, -1.8138746690450551, -2.1066980165385547, -2.395365806955149, -3.2463285590095596, -1.7743189376714832, -2.265197827195344, -1.5352917400295039},
    {-2.846229968218658, -1.842172504531443, -2.8871952375928265, -3.038072768357937, -2.701414926268197, -1.5050687141117962, -2.001882181539067, -1.9995097587315973, -1.7848143534378575, -2.9373798218693334, -2.040272839218439, -2.1441482371000213},
    {-2.8832781095500826, -2.6577802633876373, -1.7687058486468954, -2.848879721092638, -2.9502699618087114, -3.1754956358600017, -2.5539691429577513, -3.4932323091658852, -2.220447765622055, -2.1990256205740955, -2.7417209086473644, -2.628325520297302},
    {-2.9136210585866262, -3.3800241199383256, -3.4409852716043887, -2.9226447379658773, -2.1307089726264676, -2.125676504526045, -2.485836390598607, -2.8314150032621597, -2.1294679166736126, -2.7277520579735337, -2.8303387544731864, -3.5821366016666154},
    {-2.214558577831473, -1.966026284828582, -2.1159245983345145, -2.816047845313331, -2.5752677207604404, -3.3112013852314766, -2.930536670970836, -1.7166716548522372, -3.258247200727613, -1.9480610964365423, -2.3378675320007734, -1.9584983685246062},
    {-2.978765511853069, -2.427079725858015, -2.5908182344358064, -2.2238220595256815, -2.6807323837875567, -1.7779905427700544, -1.5737758156882748, -2.093710948057769, -2.69201894621073, -2.248060853280655, -3.232355470734043, -2.4094459512420303},
    {-2.925105124638767, -2.7675867462420496, -2.2981552463506567, -2.6563612216451946, -2.2558793020087116, -3.4335771182543127, -2.470172920731313, -1.8128818185160989, -3.534926039180942, -2.5067789223120447, -2.9785389825933537, -1.7825605481814206},
    {-2.9091542128449177, -2.5182584267254935, -2.924615187099459, -2.2763631207032113, -2.3817620252618474, -2.5859770962410185, -2.0832215641095315, -2.940936969459963, -2.996451209552561, -3.4453384975663672, -1.3531302914113483, -1.5733858009024932},
    {-1.37835173379473, -2.6401061001364927, -2.449698791287708, -2.9868773189618785, -2.372124777445035, -2.412879967072167, -2.897626246672039, -2.533747198110816, -3.168653657914296, -1.5943334033235605, -3.6626630882241256, -2.9200641532137666},
    {-2.1250248518428863, -2.432485081309779, -2.7420743945997494, -1.737392519899312, -1.9684298018947675, -2.75401023873167, -2.7784475502747887, -2.5279877835712266, -2.457444943298341, -2.7441705572874637, -2.976021827729283, -3.106309393475566},
    {-2.0602433352869753, -2.796920223184383, -2.356678947237078, -1.153882791038527, -1.3363725616370576, -2.635408055568977, -2.350264877528079, -1.1556137544962308, -3.4475528175178902, -2.149730465574578, -1.5251907443720598, -1.6987644380397044},
    {-1.4207857935148351, -2.2285762633345874, -3.2484734897461367, -1.25336149642911, -1.991207876846494, -2.544022144424831, -3.3314137655848155, -2.621958801812844, -2.1633285475206088, -2.3576541311007624, -2.9255271283475324, -2.846580170196022},
    {-2.437292730372338, -2.445894225818297, -3.2369834358690537, -1.8982563477381535, -2.6650938710889687, -1.7784618287405, -2.74150062799207, -3.9180894786552893, -2.1908005644270476, -3.3933598632539383, -2.2069242891264085, -3.508405328060601},
    {-2.725547870854464, -1.9506466470533474, -1.8739834281393475, -3.767747120572606, -3.115390027019922, -3.154674198880833, -2.566188545401305, -4.238741605222581, -2.0213217671042254, -3.0269228174251523, -2.5932584468686075, -2.707981231782671},
    {-1.2436881231679537, -1.9416370849752327, -1.7697696245391306, -2.859551343317508, -1.6858719823798092, -1.6496540151902503, -2.1590007111733818, -0.6992288929204774, -3.1508120826089874, -2.0743784209701945, -1.2024177777948752, -1.573235423030693}
};

static const float b2[12] = {-2.766176882375108, -3.1367939361757027, -2.8637510104481576, -2.519548791609551, -2.817865018187668, -2.9883939757068876, -3.059262804953346, -1.7174107248548443, -2.2982571407588046, -2.555505314418521, -2.298930951638744, -2.4783385204574895};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
