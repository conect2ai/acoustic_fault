#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.6132206874544669, -0.8203490655309998, -0.629012386925908, -0.5476407877215919, -0.5691050378394303, -0.7816759086918195, -0.7700181677436537, -0.6220121702273935, -0.21242940679033345, 0.08836626239780232, 0.5003696504911358, 0.7162106280127502, -0.45799907902153375, -0.537630690768311, 0.21415974042983577, 0.053463589604331056, -0.1277381361380471, 0.06094423343885513, -0.44712629778953034, -0.3409095631801788, -0.4979751730054007, -0.6291390317723712, -0.9805671523460515, -0.7225452819012997, -0.058137681227160315, -0.36159133849255165, 0.18273841530410306, -0.9413971723010851, -0.9311386262693103, -0.608216253239877, 0.1231793022528843, -0.2272120865492742, -0.7009320846485628, -0.9138134298093585, -0.5302420697081204, -0.9666843803839604, -0.7409030642490123, -0.018978880438846324, -0.5590946593213395, -0.7711380410948747, 0.07211153823276242, 0.007102945163718193, -0.4305391666767416, -0.6587159573020646, -0.487895385285972, -0.32665079597433877, -0.7104019778140968, -0.609182219353093, -0.48137439890279193, -0.1947186851840875, -0.9220338925308555, -0.33352849368097487, -0.20687563630766856, -0.7285755548922854, -0.5543204543763413, -0.24028668100217598, -0.08329766130463105, -0.3916685149292127, -0.20243413174477562, -0.4606612328044369, -0.4991950717380895, -0.7446019732467374, -0.23587369737426944, 0.13544892846444861},
    {0.8227492793768021, 1.249812636240149, 0.4939239732428737, 0.7505129752644096, -0.6539559523249199, 0.7279270120229393, -0.392362632721763, -0.22589166875139244, -0.13799189248110394, 0.003763931924479885, -0.7737379112357643, -0.7459130965470703, 0.05821186707224329, -0.5783482401266382, 0.15168770490424346, 0.4429219851910118, -0.7349052128954888, -0.26038444952593903, 0.9873918050951963, -0.32253336772081026, -0.5856379115586592, 0.07211357773058151, 0.7436829225014986, 0.8823427134561668, -0.25850411341947227, 0.595943374980471, -0.24716406440914487, 0.3773153327174588, -0.35173770108157876, -0.08428077045662995, -0.42785310144481786, 0.13624568602471504, 0.14575603104205875, 0.5697894711132121, -0.15659871535064354, 0.4330274672882728, 0.8853641358364434, -0.15800011887549453, -0.3850753799471719, -0.003208668565236025, -0.9143195803240511, -0.3403320094301341, -0.08734842483764084, -0.06829111174345942, 0.6244905451314346, -0.4070473355601074, 0.916893086869563, 0.23429386594794913, 0.11182224718636635, -0.4278281039831163, 0.5585754146203865, -0.7192172119714779, 0.41966718779373946, 0.5608258519222301, 0.28966463380565305, 0.4824564340613415, -0.02593810093655858, 0.2959333815966533, -0.4071908935301898, 0.0441721407672381, 0.7516157838401731, 0.23177326906343487, -0.7325122530347888, -0.7127954226106638},
    {0.25446029952300453, 0.169941544624489, 0.4723729258507954, 0.7740523839336947, 0.45572966962822853, 0.7667660369274719, 0.7500105689839384, -0.08797061263547756, 0.39093553059168745, -0.04357790524808944, 0.7259905033173993, 0.368002231772272, -0.012189410077427366, 0.7498850352472999, -0.5714469437082942, 0.19346180710639957, 0.23288562531769189, 0.3966532590463487, 0.308939187089323, 0.19818676747340017, 0.21125090397688875, 0.5036920291566285, 0.7479803493208665, 0.06023684819573259, 0.6968543573870544, 0.2730418672347116, 0.38946910910231525, 0.45837089823801264, 0.3639782055953991, 0.5016925736531723, 0.3496465586591868, 0.09338734494232204, 0.32395526754713916, 0.3331562932742714, 0.6928447062741536, 0.24223644898274463, 0.5982937193265309, 0.6870270671083327, 0.8337460941369859, 0.718479021216677, 0.8574244926506124, 0.22129306102612098, 0.923194346171678, 0.6629583794366039, 0.5963766155355863, 0.7907323328899013, 0.44307685638862887, 0.6814424826679474, 0.6119712110395122, 0.2989898220741236, 0.27019282848573783, 0.6237317338636282, -0.4150043745569075, 0.21630658326207353, 0.2893456395886729, 0.5148274964378698, 0.4262307859190175, -0.16984323657730033, 1.0257602749964365, 0.4339371608842341, 0.3433010258876754, 0.5795640472540561, 0.33986134919385735, 0.4019522580499557},
    {0.011643270023480324, -0.15820999752454032, 0.47607763714729456, 0.2503044244033034, 0.7204663455198069, -0.4839450433175426, 0.7480323110257876, 0.3690382071503908, 0.1615514522134809, 0.032861348025743545, 0.9958051025852919, 0.8431977849661828, 0.5356023601372151, 0.8308673086738013, 0.3771479639164133, 0.36793087566577415, 0.8397409658754307, 0.8709137730509842, 0.43766708150867195, 0.19199879755917865, 0.5878010229481678, 0.6033254086094176, 0.1233587854816423, -0.5593032332388236, 0.6932004016103733, -0.3628234099036624, 0.873853969762924, -0.7275756402233474, 0.3606686487663894, 0.2689266683767297, 0.43141749503689103, -0.8563876848478981, -0.15234531719501346, -0.5084395843660617, 0.7918252525968872, 0.7180463325056076, -0.12282111698613876, 0.940454800198965, 0.8906942449084616, 0.13029482685282898, 0.7819160569906372, 0.6274204770636843, 1.0254877375620095, 0.5714246167102636, 0.06481933088935433, 0.6382920198202303, -0.03249203813013578, 0.6380285162064853, 0.21036769267295072, 0.4866542566113248, -0.3375753874156561, 0.9901317552023723, 0.5252356814337066, -0.3902464847865503, -0.40861627036695397, -0.3223392003317942, 0.5481503945929894, -0.5192679159742571, 1.1293277846282719, -0.06692537124813273, -0.2893523080924497, 0.14221011454840002, 1.0924827998037787, 0.6398660554388321},
    {-0.13104470773393428, -0.14608685334180516, 0.6170856123402262, -0.3844295458861179, 1.0135072047845262, 0.6174622250316557, 0.7303514034631423, 0.6212446989088249, 0.06358120527850131, -0.6026986347352884, -0.15220506789432262, 0.12728614080779316, 0.07815016227582805, 0.6172893826693714, -0.5180074856210343, -0.669436159598092, 0.5324385863808506, 0.3196600251668955, 0.06579694250232554, 0.25403565775977505, 0.26432494872798395, 0.6738668618401119, 0.6114028188224868, -0.6220325334236033, 0.31592230148087036, 0.04746156530495759, 0.20620191209212038, 0.31369682784174463, 0.8150039146311939, 0.09398854608456761, -0.37397371893645903, -0.14521485393311132, 0.25180379956953286, 0.12278638402609972, -0.00558049189799346, 0.14739414262168737, 0.5607444462931699, 0.1477896368963964, 0.7845329710428716, 0.39942090597872804, 0.4316946547982182, 0.02473613519764873, 0.5706396312723316, 0.4229975082237572, -0.24196040071289723, 0.5032933179872552, 0.42676589568450296, 0.6451782396815358, 0.16285714215146904, 0.10506372426399613, 0.43102912712861713, 0.5180217398867145, -0.6010939613178474, 0.046429230495728196, 0.32216930163446506, -0.023479338958930715, -0.16748547809923428, -0.1281722856192907, 0.34135724884898805, 0.29566538434846645, 0.1871821919302181, 0.5058027839794669, 0.1047608745017929, 0.2196845469018776},
    {-0.6958592899589475, -0.049772916810232576, 0.4602335533565415, 0.23341477082349688, 1.0421426071859805, 0.6849033448373396, 0.5888896604933448, 1.143407867078104, 0.9071833685890064, -0.2818465207811593, -0.38593588818356445, -0.1405874329374863, -0.18978345109581157, 0.4012259187065489, -0.6177586891919927, -0.03433728910403559, 0.6380487640650365, 0.9627341552027168, -0.6246457487236585, 1.1371747353417045, 1.016483241700078, 0.6552656814888533, 0.6313450828520961, 0.2460293738642818, 0.8055989457449749, 0.3222465975885306, -0.1832451623451242, 0.8045885750915419, 1.029654259750129, 0.665957730994012, 0.25188631540897816, -0.1805077725525538, 0.6131878753106474, 0.5802863811590124, 0.2958439351158002, 0.22756986054384953, 0.6445589478839225, 0.6244097583947298, 0.92534908468837, 0.8599157464298957, 0.6439575509889784, 0.5869104596646864, 0.7154394348866915, -0.057657957542038014, -0.4760245053170821, 0.7895219428777878, 0.6201329616288833, -0.39527179480864544, 0.533268593621713, 0.1330170335600178, 0.4843290078448963, 0.9904601131552654, -0.5853428880330703, -0.000822258149447562, 0.6751239220924842, 0.32082273253991883, -0.39269955003650725, -0.06998059639565399, -0.022562501969800502, 0.22720675628637482, 0.5225641643140075, 0.06791476622935778, 0.7278994436993254, -0.014953886918987663},
    {-0.48821281969020786, 0.20635125381565173, 0.5322192649687545, 0.47653496425833364, 0.878139260058243, 0.6857324526842036, 0.4821998307314227, 0.7454748156686827, 0.6363327592078836, 0.37215620226340984, -0.3506589770918231, -0.20128264154870062, 0.20638711854814934, 0.3280329743603873, -0.59515348150517, 0.37923858383522846, 0.6226709881221273, 0.6421448954668003, -0.47436773013185335, 1.0834262974638436, 0.7863349549923387, 0.9048288855026321, 0.5313024572202176, 0.05363386999802127, 0.333424415395431, 0.11327269995983655, -0.08771463923480907, 0.714068213231872, 0.7149647048904254, 0.6202060083619709, 0.7595789558586555, 0.14113941355549797, 0.7192789402677179, 0.4439289566595489, 0.8276243745487101, 0.6173933022846008, 0.8977877428007456, 0.6739666999341354, 0.9338379166067959, 0.6363631377203288, 0.6842662787781345, 0.6556090603774251, 0.8525676449352186, 0.09533083424563195, -0.3156394194842886, 1.0406101880571212, 0.5129461595538566, -0.22849837538088577, 0.6158370057873032, 0.532276194632742, 0.5295676204664491, 0.7772036210094104, -0.7365762301259111, -0.11511322598709436, 0.25442506559218403, 0.18878701962916078, -0.24640043860761413, -0.014243082574983792, 0.2735784295495416, 0.33550125751842996, 0.3675404866242279, 0.2856556394103076, 0.9039928167466346, 0.21961484833651462},
    {0.6013755872617662, 0.728784003805005, 0.45828800885188475, -0.17168344191252824, 0.4128648780700591, 0.5115616756078909, 0.38622338520351834, 0.3987820826859475, 0.24345320092897427, -0.16533506531570183, -0.009466955547290882, -0.1762548846364405, 0.1697340001323582, -0.40452619403587553, -0.025480286512087568, 0.3470760799848608, -0.06223304171213817, 0.05367803547198262, 0.30165149572034156, 0.33063340039079414, 0.3055666307163459, 0.16231192380706774, 0.5795759147942832, 0.5239534508160753, 0.13476497860853676, -0.3869730415165906, 0.4801299889556259, 0.3405751298310799, 0.4032533599093953, 0.45446604500810517, 0.05748551374598625, 0.4682208126014503, 0.06983072377313601, 0.22384007771614944, -0.26529815751323343, 0.23689298670193246, 0.46960740789815714, 0.5748315777265982, -0.13762511731401514, 0.1252950816495278, 0.38816523354041393, 0.32591993835509614, -0.04461266142430533, 0.3492689903756531, 0.12260035549772326, -0.22113444445559685, 0.8833195667084894, 0.060577517971370946, 0.25848648088249915, 0.003689048417943533, 0.5130107758986728, 0.02710901511916272, -0.31230230248862273, 0.26249535539328966, 0.2059315692589843, 0.14270979790932004, -0.3035977677384031, -0.04789936326675762, 0.5533449540430502, 0.29968504006484886, -0.05360318746953241, 0.16979021287351687, 0.1943867798341023, -0.28745838753520203},
    {0.2503747519391078, 0.8221607017598849, 0.4670138836276776, 0.22359405469271967, 0.4682648399361815, 0.48142271664662944, 0.01998185412131456, 0.18228731444904026, 0.31913726321106767, -0.5361108060756528, -0.14175247528348625, -0.29946171510465935, 0.1325659643984171, -0.3345167562635441, -0.13381866459226702, 0.38198559304421414, 0.02349556611017917, 0.2867449787015416, 0.4044388957907218, 0.04432236338499153, 0.539009376857271, -0.04885980621118814, 0.51927230716549, 0.17800201365101748, 0.4298033481363798, 0.6286891812468519, -0.0032130930124845717, 0.3927849742931015, 0.3156942933522229, 0.5536889826246684, -0.21782916304948988, 0.08673048804815382, 0.4762801022238044, 0.6469659632553065, 0.1862805877304325, 0.39974623649388114, 0.47493623808954066, 0.08364505416079576, 0.3988189975250716, 0.19141810259565403, 0.16751875716504033, -0.33596730250596213, 0.2533682562999605, 0.6649808059337002, 0.3212029664132735, 0.007433482151878034, 0.8272341035330774, -0.22266138341652916, 0.5424551718641275, -0.47633808181793674, 0.5211586263488508, 0.03556505588870807, -0.010465044117863975, 0.6766055583913775, 0.7854670562521884, 0.5612777894420788, -0.4320905853514522, 0.6367853538675035, 0.19962951709356044, 0.5361299801443057, 0.3206356600551571, 0.5602089470178744, 0.09618935875918237, 0.13952358757716568},
    {0.523403360924974, 0.5740261056210179, -0.2108009687379074, 0.4747249380199201, -0.6248729584892858, 0.26559851232975146, -0.6608212633650781, 0.2994926841120803, -0.11989700685953505, 0.3292818229584317, -0.46304989120437284, -0.9279573775013769, 0.09719560961155485, -0.8055176548384795, -0.1502443128033066, 0.10794487722295987, -0.42725402344214797, -0.39881213284475, 0.6443929558916442, -0.20431964354321389, -1.1363125816351185, -0.28518654472015253, 0.4386179250708857, 0.7903391136289427, -0.9279243577283416, 0.4282697615927091, -0.44614639875756557, 0.23209808681654154, -0.4117034086584319, -0.2615819463896617, -0.25344079429505745, 0.11490906467017713, 0.5802829022218503, 0.3654594279855716, -0.5766852615469839, 0.6222531224435904, 0.506743205863932, -0.5478865682242243, -0.7574510808574585, -0.03711522739802206, -0.7751128405197053, -0.4348242048255979, -0.756575388756137, 0.08068998699383552, 0.70829654645368, -0.828390819127591, 0.6127650659009157, -0.0524250862100371, -0.26025603759857624, -0.3313171493941539, 0.681026903466814, -0.6737934541600502, -0.24981579166794565, 0.7593648640645481, -0.05899265704181441, 0.0653376899026749, 0.028874900261106843, 0.3220559202808478, -1.0379401727945765, -0.12231741476019788, 0.40385633961300993, -0.2685155937239845, -0.6433334385563898, -1.0492501387716497},
    {0.2089847533928764, 0.14229931562321788, -0.09352851488310587, 0.38696578671130744, -0.24424099719939285, 0.46116956230194023, -0.12127427049742018, 0.430294609766233, -0.3306044769762574, 0.1460491106853206, -0.09407970011913919, -0.8411611442909686, 0.47061663281977273, -0.25898423002973675, 0.17994637193496713, -0.23363258357415204, -0.19011634254505203, -0.2758803911234882, -0.243663971717161, -0.05945693626521979, 0.006934259205053531, -0.18216678901071048, 0.15345194326578773, 0.4032342797877352, -0.09954171419006153, 0.12342036571269065, -0.5840745377525984, 0.38858369358223566, 0.37563867619849206, 0.16963675844622958, 0.026543518936297358, -0.6753984843074722, 0.2798618581601774, 0.2712494977081102, -0.24891198657115587, 0.5342337808753245, 0.2823446419298566, -0.34120337691093233, 0.09958331757284845, -0.04700945356584038, -0.14140983554216732, -0.1446540214839028, -0.16698639393448927, 0.24899113369117712, 0.6991984383596257, 0.015450232452941515, 0.23625832841576647, -0.30556640294555804, -0.5049784755874809, -0.05497098000689701, 0.4105842768590207, -0.17972720318549426, -0.15452519906071646, 0.2624009292788551, 0.1539472839999445, 0.10953196371289257, 0.2130894400592691, -0.01997224040195981, -0.45702450260405464, -0.48236609471918845, 0.5628725913101588, -0.4877537040977976, -0.13358574813086613, -0.3553795917285073},
    {0.2727540529407386, 0.6577214529126556, -0.31196552185140225, 0.6506816086758008, -0.3768963010362481, 0.0878118122507482, -0.16109322666065332, -0.49186796333136173, -0.2105992274401222, 0.16469119562272272, 0.1338129403581898, 0.08199189957802257, -0.1137911562555541, 0.29329040596412587, 0.5086904305856355, 0.5764140320890393, -0.10080204778179429, 0.3342225621491427, 0.694607794189585, -0.22078225664260773, -0.2642720790389724, 0.38871522090616856, 0.9607083268809654, 0.20678544880031938, -0.10316371753278371, 0.4233689534720166, 0.3218812083081809, -0.48345271267245504, -0.586615110125082, 0.3829566596067654, 0.25041500234306197, 0.5948427890458675, -0.24131996072317907, -0.3521215954651228, 0.6429611481452523, 0.7438179891480886, 0.11711812762264659, 0.2641915864615726, 0.03260729618073183, 0.18286417807104327, 0.32674052981273194, 0.49657114892226933, 0.20772065827776623, 0.18513340594565322, 0.3881548253163373, 0.4775511219385888, 0.02540557021220058, 0.4840346545355562, 0.5530452227464786, 0.48240358964196867, 0.2233469069527613, -0.025780372703139005, 0.5228157836887614, 0.779597233803543, -0.7181451951884389, 0.03690421867392972, 0.3236786297301885, -0.05647181734653633, 0.20137487845225324, 0.034708650721095545, 0.31556316737545625, 0.18168434746195117, 0.4318965256694989, 0.2003934066355293},
    {0.21303529015944914, 0.31139351805653337, 0.0072964649489253965, 0.8080668929953455, -0.4674784688984903, 0.9181335297181222, -0.5293038355569879, -0.17486954505059962, 0.49226987671605693, -0.15086265465588702, -0.7376221267221537, -0.30248108904612203, -0.19945201664897597, -0.5206220950937979, -0.5690008369708994, 0.22886044709290257, -0.4476349154790851, -0.017888274905734528, -0.6101107746735034, 0.4208109948419556, -0.0032115376007197695, 0.20084611891667548, 0.6740931687637136, 0.6058731154702516, -0.05033130459338127, 0.7402074168231733, -0.7906585444272912, 0.9778449725606568, -0.03622832712951799, 0.833869140798016, 0.10559455978816848, 0.9298586507364359, 0.8802742058935011, 0.6019548733287888, 0.053426956210104515, 0.24517790882300491, 0.6559069621058295, -0.7878866776046659, -0.6725147990297511, 0.4027071487967857, -0.4468661872902619, -0.630681913390044, -0.2533963068733768, -0.5313778114299186, 0.5635759378050769, -0.3137087776612384, 0.2985849078321829, -0.5678646531771034, 0.03114474462984049, -0.5229234448466269, 0.320343308222434, -0.1706665191373996, -0.36153907768884813, 0.8287147878918731, 0.6181567476411075, 0.8584078137440639, -0.5745158181761886, 0.7767602673080393, -0.8305338386705525, 0.2858284476043703, 0.5355874596715695, 0.17043006834158964, -0.10600806600939759, -0.6117784860080686},
    {-0.07733925276835993, 0.7601432540960307, -0.3124042525691665, 0.46505934044015146, 0.8286933986728192, -0.10014357476626197, 0.8571613163301784, 0.5485112635272089, 0.5190246498766689, 0.3607259384722581, 0.3358177068391794, 0.5565101223380828, 0.5870743998116839, 0.7794204612201882, 0.45486777398436357, 0.5871945177475255, 0.5513201448720801, 0.7252174024947337, -0.35682983033564647, 0.7667882298594277, 0.657972464810045, 0.40812265611114684, -0.19048697802565795, 0.18870288806512076, 0.22744439690424118, 0.33219300279672387, 0.2288179275754265, -0.3152384155769028, 0.6845772745192301, 0.5618858458554001, 1.0095641847713077, 0.0688704668297932, -0.10953417412355261, -0.4911019561156489, 0.779130708445198, 0.7917198689881263, 0.2984200212782729, 0.6536127231069773, 0.8777250710696373, 0.45793704912518185, 0.7208630195179566, 0.774332134291733, 0.603319700373424, 0.5825946411625369, 0.6928507148637982, 0.59497876157533, -0.3022555357199599, 0.7018380469062205, 0.36660741154101956, 0.7191799299062498, 0.2955974462996608, 0.8364650110679063, 0.5380970043672844, -0.13275180656507482, -0.09999046828248305, -0.07145955001324146, 0.865881586217234, -0.24054945932938673, 0.5381180361748923, 0.3419885725084959, 0.5276643682053768, -0.02768665068805554, 0.889835773837525, 0.9069956141627684},
    {-0.8655927884999376, -0.17341763791569081, -0.5312828554131682, -0.5964720166033921, 0.707789759111636, -0.4115121544423639, 0.8397522232728006, 0.2256107200500279, 0.8189588011665303, -0.1487663352763498, 0.17130031503895493, 0.927401636677245, -0.029177222157719403, 0.9540629523610262, 0.13454855743832156, 0.7707799227810861, 0.6184371151670418, 0.8129112118133851, -0.8883794983432727, 1.1043537316567769, 1.2440781138136892, 0.12856663413222558, -0.5735211948777748, -0.7858254273445301, 0.8671739910647832, -0.3543738530331239, 0.27501768984724634, -0.6959086448738931, 0.8325254590930153, 0.6474209274895413, 0.9688083765960198, -0.2101587775355604, -0.19567530827016627, -0.3105866932516083, 0.8127660032061725, 0.019099321538182088, -0.43702330696202996, 0.6466183677369827, 0.9747617900825643, -0.5194084465125576, 0.9026951936481931, 0.8271723198382457, 0.440956502717009, 0.18961123603795804, -0.5101599819620268, 0.785264108946082, -0.8355709150439196, -0.32272513053337454, 0.15872226946123244, 0.7596335492725265, -0.5518981126577082, 1.0849198862205929, 0.6110411338527189, -0.6038059186792202, -0.5063455686300401, -0.37655183683149485, 0.20308414682915385, -0.21061693845938825, 0.42213197767099203, 0.16897665524593095, -0.08378107072076098, -0.5031716061582263, 1.0964531787727734, 0.7744306931766319},
    {-0.48886854635337257, -0.15412515647355973, -0.43679681893163963, -0.09865750075631959, 0.050270264980870595, 0.46409729079373085, 0.0446719770401274, -0.07448675411373913, 0.8586148644920982, -0.26200977287980304, -0.7718491969865909, -0.13080909975180202, -0.6749371301183199, -0.3908062801343251, -0.15373095104575227, 0.6423527540101991, 0.28591143719584033, 0.16668933068270034, -0.7207445140589, 0.813382212017753, 0.5603051069606582, -0.13732801243139928, 0.24527723661449247, 0.14828091148822714, 0.3081328235913148, 0.7336312123315905, -0.34843623153932884, 0.1247650446402923, 0.6610093710756865, 0.5929161787475618, 0.2651372196152103, 0.2601368992848841, 0.3038640553363465, 0.07672990131337235, 0.46764633811418393, -0.08466332106905844, 0.2017838951236226, -0.0888482030922278, 0.08173192955010193, -0.06382040218597046, -0.49697965983774084, -0.21788125935225694, 0.04626257379793697, -0.2740190663140314, -0.033548679661569124, 0.027201300655965023, -0.1986073519320328, -0.05813847467315198, 0.3366308332431374, 0.14522748556772397, 0.16973156057755032, 0.4545044758808706, 0.00481423326018201, 0.161163129520123, 0.03514893043262533, 0.27753982435543023, -0.44006678854276204, 0.48030935125587243, -0.5502265713695188, 0.5209737046111738, 0.47991357354642566, 0.3930204598382013, 0.5603481494051643, 0.5748922548987428},
    {-0.33037128309001973, 0.32971691412043513, -0.18451226068562773, 0.24191853171352598, 1.0102272228233646, -0.21137381520940945, 0.7048574965759535, 0.6976935164195242, 0.718647811979908, 0.5149746904034479, 0.03871477038768303, 0.6412868357262721, 0.2589888022300237, 0.6495874054937729, 0.46312777732386495, 1.0640850184700525, 0.7028176591628712, 0.5608013466578063, -0.8085613516445209, 0.6559314028583297, 0.972413355579647, 0.40206086131331636, -0.5847400485868596, -0.5217667596275725, 0.5019810568957542, -0.06833357861428907, 0.9482835781894119, -0.35077427567562347, 0.5732449116424342, 0.7047626629281076, 1.0516212926199013, -0.16123403834564293, -0.4008344112866553, -0.08471907189881754, 0.963914396008275, 0.5938344842548678, -0.24429256548405323, 0.5560229034529149, 1.0022779844426006, 0.04304177046129767, 1.2713917756209454, 1.0273513639763483, 0.7957040845869435, 0.2587471229271898, 0.23930805113345402, 0.6994796022401696, 0.25198317362794254, 0.146194503921394, 0.07679022375142938, 0.6471734567351998, 0.0340302709131538, 1.1646158274096508, 0.45555725822023757, -0.26005477213058814, -0.545402513242707, -0.34112818298073183, 0.348947677922846, -0.39919440500634223, 0.7330712939906001, -0.09188327609405092, 0.39025542503550764, -0.5495277203468087, 0.7752629305110803, 0.5805692851714288},
    {-0.512385091631516, 0.4381572840087479, -0.390984248848341, 0.13576233847741073, 0.3257327940246507, 0.2980227002923487, 0.3548810844270697, 0.5384959058108453, 0.6516981832818657, 0.06261116254766984, 0.08748830053527822, 0.4217499651865126, -0.17547539887440258, 0.34098195976355133, 0.35824489449633773, 0.6523354648602567, 0.78955627784629, 0.42077546465843824, -0.6620421379346161, 0.8010583955864322, 0.607333830039575, 0.40156189720873936, 0.007869576091667416, 0.1771471398487513, 0.43964386510874087, 0.34092679408630006, 0.30196296794616106, 0.4189153952979789, 0.5307548628427469, 0.7065118903210124, 0.8496047022284767, 0.16102504844949306, 0.20330584095072252, 0.06052393121040099, 0.5477713733689745, 0.6163800678211968, 0.3241681757793245, 0.06558888269526715, 0.7109117302917084, 0.1502540529094034, 0.5040829866338247, 0.5879703508076999, 0.6829606076552232, 0.2153837136022374, 0.3274879783867034, 0.3614303844492108, 0.09166661875326573, -0.44589751392599697, 0.7333421830955571, 0.5723668708632337, 0.4092735616974271, 0.6747924025542398, -0.30285473132816315, 0.2597549534097875, 0.014557369797053825, 0.1363670743474932, -0.14077572931381735, 0.15489639690555515, 0.011148922354232623, 0.6952936335214636, 0.2880321413274327, -0.27607304134949107, 0.694998080287517, 0.5966332675375268},
    {-0.0348477661965881, 0.14620503776643892, -0.4171405007751199, -0.16964805827712623, 0.5264528102418552, 0.042995205786597435, 0.877683671110874, -0.7051250921522093, -0.13376649782564842, -0.12031350825259692, 0.1741702675938587, 0.2900582724760786, -0.30419056198375355, 0.40644164557318546, 0.2570895657295524, 0.8578762706960688, 0.16252352914592677, 0.3984959275490825, 0.09375811827793835, 0.2713579297733763, 0.38474947969112905, 0.5231217534956589, 0.09947628772311448, -0.2641584246337004, 0.021970421509976298, -0.20422609224437932, 0.34317289070800727, -0.5501054162696818, 0.09090640566905221, 0.34015122568951, 0.42751923898884836, 0.4151939932364605, -0.5652778786842954, -0.2663921634605457, 0.7563600215073072, 0.17357841562859608, -0.17613950180347893, 0.3325211678561149, 0.10096649063526283, 0.4889136996290682, 0.6920318099186697, 0.29667172414695175, 0.5694559980978805, -0.5612935826689925, -0.3080155412567298, 0.36807739752017166, 0.144471692941682, 0.06840192702261341, 0.5238554643429219, 0.39659289044276547, -0.39494884313617284, 0.609136604348898, 0.05214228910807642, -0.045036412000714954, -0.09608940809709919, -0.3496131000836964, -0.4359704037997211, -0.3569786201870465, 0.3362729078014523, 0.12235416429420129, -0.12688195290590862, 0.1130394513215234, 0.737400508317, 0.34245130916231176},
    {0.7362876969328859, 0.3381195118680931, -0.04219918206264041, 0.09086644522615793, -0.5630077085169342, -0.3602249832582981, 0.644964914165189, -0.7587234324368142, -0.7038547602573902, 0.5394332205447053, 0.2683957728022314, 0.34163131058783736, 0.371510595014233, 0.6560968548292433, 0.289950156037125, 0.70823166418851, 0.6846544331705434, -0.542547595302011, 0.2393464098959028, -0.47835146984971316, -0.19882874647174634, 0.5551532457117432, -0.5746811188538018, -0.10427693834764731, 0.2388760361829563, -0.620215112983537, 0.5696578808753814, -0.17772819870083034, 0.03537859723595417, -0.11461084562675852, 0.5671864511659893, -0.14459072287338542, -0.3572038614302217, -0.20255137890459596, 0.46935866561101736, 0.6261082492935864, -0.273309132638309, 0.5096418403287761, -0.07775267313258011, -0.5651481199989504, 0.6055031723427818, 0.48927598272990314, 0.28189480838067077, 0.21588281546115315, 0.5744321219371903, 0.668714882148195, 0.190906172226632, 0.48988733032262705, -0.19482270255843204, -0.06971997255297317, -0.3122797226219731, 0.6176919728280663, 0.3529848226400317, -0.6055775586243776, -0.5082805519816168, -0.27259634012077844, 0.5613373496276247, -0.6641578416583023, 0.7205486124709093, -0.8264168837578257, -0.5204411669898992, -0.8369616782905345, 0.734413803559678, 0.44732248008733455},
    {-0.18265810967806406, 0.04341966032412343, -0.177038809849139, -0.1894179845415737, -0.09128791688856899, -0.7950464472279292, 0.8224666968585715, -0.712726508631667, -0.23582494550965238, 0.0370286532313214, 0.46791772880246923, 0.9469523696034841, 0.06802609093040914, 0.8658473904883913, 0.515675635792761, 0.08000590196288619, 0.60097090256309, 0.09709082393283557, 0.13191120283931448, -0.09616131102579768, 0.384834616484915, -0.11947789818277958, -0.8013673215969356, -0.686659166081423, 0.14428555133924714, -0.8413816264461652, 0.6861175041057316, -0.5273056714373809, 0.46088392553372887, 0.3400132572996379, 0.7093842805471536, -0.3876526946463806, -0.3087774600961165, -0.8718586279154615, 0.6321540209052678, -0.004371803459615157, -0.9292222102290807, 0.8250093277720468, 0.3976215227200972, -0.4196879407876841, 1.1612853977256765, 1.0043928374333082, 0.32771556350524883, 0.14011256571031505, -0.7600325863386106, 0.37822891713094736, -0.44545982791060323, 0.4655450012620917, -0.5829515198587505, 0.8409850768724899, -0.7217289624559091, 0.5261795750509823, 0.3239797538049683, -0.6022424594451825, -0.6726121006279024, -0.6245288471786521, 0.12369704751165532, -0.6814120855254535, 0.6643911174035687, -0.46435952071345815, -0.47211033933088287, -0.7122014292475314, 0.6728894203092975, 0.9710686225783838},
    {0.19680247462722406, 0.2310553360719343, -0.07390470603943386, -0.5888123764729561, 0.28437165746722665, -0.7147939971854599, 0.39704514922770245, 0.243607428111174, -0.13266472903593787, 0.885416387002286, 0.3750860487557172, 0.30382046729970835, 0.7320607293423316, 0.46339232740552594, 0.7128991286510993, 0.3876491316844289, 0.4462443108105057, -0.15649656087348643, 0.23076086405533633, -0.30933555574466937, 0.09364373990649906, 0.1252462898395511, -0.7261505311321436, -0.7376953391155673, -0.2317220483020385, -0.6502605328995552, 0.5209445339693356, -0.48479393136844345, 0.4760311321955477, 0.012785911880893558, 0.7180827316469204, -0.6511805277949763, -0.6598102193821654, -0.4860232186017139, 0.45468378726219016, 0.3621655390458011, -0.5102151902061184, 0.7874489303061191, 0.07112304961292869, -0.47803434115946414, 0.6350671677870371, 1.0060328058866308, 0.3690031105453379, 0.22534028977463585, 0.41769031122547984, 0.2558218005233036, -0.3496143512969012, 0.4905072681234833, 0.020508898990963732, 0.7719241170994918, -0.6227392641728487, 0.9926620455266619, 0.8132081171476774, -0.797532112331518, -0.5116479843402812, -0.9994749550659537, 0.45495774468188194, -0.789721185546629, 0.6730610044285852, -0.7279069183329643, -0.24644657967013253, -0.6848850475163883, 0.5769666550418218, 0.6757006008028874},
    {0.21227231962246537, -0.07080441746351146, -0.43019143279172656, -0.20702902769095513, -0.42782465853178614, -0.5998353337278257, 0.6952854048756877, -0.5897397551581273, -0.311292575704648, 0.45282737224854575, 0.7647281093072972, 0.6276837701544741, 0.645535314871662, 0.6636388130664026, 0.8643723515588401, 0.32676161402177994, 0.8059514811765519, -0.16636714028234661, 0.025617648154458807, -0.48081053112245054, -0.33750484272052306, -0.10223428769372714, -0.7163791230078557, -0.6166124720920769, -0.16565484148798615, -1.0668131923099309, 0.7694778206189189, -0.4311902503035464, -0.14006192999731537, -0.24412794266432034, 0.6014627807640708, -0.2265107445364598, -0.5407466345716007, -0.7788432176877161, 0.8612675160094743, -0.09370824832845083, -0.8714864087198666, 0.6357725328586628, -0.21110258755809616, -0.38001620328042335, 0.4861013587042187, 0.9651141222005764, -0.0373224719645616, 0.5788044289318878, 0.015371469247162926, 0.3074607759337653, -0.4104540104791472, 0.6131065583513312, 0.2308895630618713, 0.6950977154588518, -0.8926406655778575, 0.47340044919670354, 0.7587045805122202, -0.7687853494489265, -1.0072504312115858, -0.46813701312067246, 0.8765555452292044, -0.5772858940132165, 0.8483292645083382, -0.6888594469414179, -0.3283387853736732, -0.47895879594371843, 0.4134676381949993, 0.6148764213239816},
    {0.6560252462995865, -0.1676171366614018, 0.10567560427125339, -0.4808493918433265, -0.7850955633717844, -0.5285329977277582, 0.038647271655650725, 0.0581648103309698, -0.7980952081740137, 0.7410756662016457, 0.3390325993726117, 0.3432742476469144, 0.5186376426456166, 0.11858895633087112, 0.6875505214492019, -0.10974296240411767, 0.15054902728063294, -0.5061700194332485, 0.4227516136679887, -0.8512533173905465, -0.8508331392223917, -0.040807719748218056, -0.2815315056182163, -0.03061515213193281, -0.8559082289459071, -0.9925095543630246, 0.8991808839282821, -0.5688952608144788, -0.5002628074061927, -0.7343633240137344, 0.24811504808259724, -0.7836168852284808, -1.1576548672571447, -0.5492574002965882, -0.3345579421622377, -0.0575806072828794, -0.7129750091867005, 0.08039965864037193, -0.5832636882459985, -0.38850073337812974, 0.17335008228055912, 0.6332560782941793, -0.9467276408819867, 0.38726891869359514, 0.05776573374973149, 0.18888641335672243, -0.07798993887762157, 1.2208784110725626, -0.2174208541405911, 0.8774856432364072, -0.3871399705036831, -0.4140839679311161, 0.7142531000004748, -0.6000746161526594, -0.7878097020702975, -0.6766206680193161, 0.8915595156351891, -0.46247527073386696, 0.5413122059324268, -0.5637248605445635, -0.3758497212974401, -0.5176745426871032, -0.35550844855639974, 0.2785424869507925},
    {0.6504209335223553, 0.000456936908223843, 0.5426956780743146, -0.2500945108972181, -0.09938878344656578, -0.39327315065226387, 0.5588728999758877, 0.3568540306427417, -0.4278902769054053, 0.6584236652260119, 0.9778202815951497, 0.6247457257513725, 0.8360643942243888, 0.6131071832434536, 0.824776353135215, -0.052868639210339054, 0.15282196000446657, 0.1205520286440543, 0.7575016549837993, -0.35788584873933293, -0.4128672619339993, -0.03934951413375181, -0.06709969432208962, -0.33435844973873774, -0.4237690115316906, -0.5612668407068624, 0.7578715067945627, -0.6062424290954223, 0.022645487648582294, -0.11867962245693851, 0.6352425058164733, -0.19763524511482045, -0.551752613971359, -0.7289904611323111, 0.5203893809494039, 0.4605671619748452, -0.31682440532550404, 0.5427393182336205, 0.28856332304147425, -0.4126259428978047, 0.8193757810229368, 0.8235044028207434, 0.6034859282641056, 0.4442534789199543, 0.5254688870638801, 0.6297753601476241, 0.0007859282407995974, 0.9511390612090626, -0.11579017392634927, 0.2905897142168593, -0.3219302237570395, 0.4381691834569855, 0.6502341887133352, -0.49893512610159657, -0.5690379360140324, -0.4110614940611248, 0.5909834506333012, -0.38102252909211454, 0.7671730898497406, -0.7192458296365993, -0.45694770522384287, -0.7507080213773901, 0.5789815661380934, 0.8094952964495264},
    {0.8618309619781201, -0.27029421818973187, -0.30379863483685177, -0.13835745995147938, -0.5847922398877425, -0.5836181435781855, 0.02816311010339643, -0.34967588906171515, -0.7895141330526875, 0.5531616619251696, 0.8069200432945141, 0.44436703566273766, 1.0029754485943507, 0.3704129956639454, 1.014227508388538, -0.21264658187721916, -0.5418757511850776, -0.19734146668391278, 0.917050937692024, -0.8760928350528332, -0.6548347712573473, -0.1529565475088235, -0.6646401857538285, -0.35691373262387055, -0.6595859018025853, -1.0067908690157683, 0.9641852443813722, -1.0506765039666373, -0.8666936931472435, -0.7555922268115149, -0.059296775161393304, -0.23599344027926122, -0.665507900106293, -0.8735227337713537, 0.09740934562008449, 0.37601746631752325, -0.841524049692248, 0.3486013141103309, -0.3605832338828214, -0.5345371567528419, 0.5446041244715414, 0.5723242634816706, -0.033160038696011106, 0.41001003511041706, -0.20666854248945238, 0.37456072594162343, -0.28720733249479363, 0.8174689266532496, -0.2565486955936768, 0.333014617370607, -0.6876095252300397, -0.40428997507917236, 0.7473338496988584, -0.6457174483540635, -1.0348284368800373, -0.4539149104312973, 0.2646624985567563, -0.45942587988868516, 0.9655408221242209, -0.771600378154711, -0.889041584904757, -0.6757541264239323, -0.11929288285120919, 0.4419554599574589},
    {0.10470812912180406, -0.5697489469165484, -0.5654841367408865, -1.0384061679139784, -0.6587930147603268, -0.8119789764159913, -0.011742453841296083, -0.24225357514328957, -0.7444818995458284, 0.591479227801175, 0.760909332772995, 0.5926533584584485, 0.9380772248059206, 0.5835749890812052, 0.6631983924533836, -0.06132931396640013, 0.13813196340509531, -0.4240573191375476, 0.793635647632506, -1.0906426366607644, -0.8600957414891597, -0.7199622548293952, -1.0797111800416828, -0.8177263409664045, -0.47469683749729513, -0.9647548998292101, 0.7537176759255841, -0.7380484416681067, -0.5610515460371333, -0.43005107139066145, 0.25943287676389987, -0.5702778872450334, -0.7503192901538357, -0.6435334539555396, 0.40796384454196266, 0.06115778533209438, -0.869340271999597, 0.2460761013262401, -0.5859988271792586, -0.8577075601342731, 0.5759215606150382, 0.5793103524143339, -0.46977730362522424, 0.5451271292225975, -0.1868017921306569, 0.28162650265774103, -0.8090735832172397, 0.4959843175274148, -0.7662283855993908, 0.6635074902371659, -0.6971330827293216, -0.21954702510195137, 0.8493966589488012, -0.7901500845931579, -0.9193283277270722, -0.8672794963645941, 0.6678561608011849, -0.5550590555218133, 0.7095209090322755, -0.845809008876897, -0.5833993434198421, -0.7790144156356821, -0.014166571415531017, 0.30165395744157886},
    {0.8075213072628965, -0.717999635133644, -0.008843945943017795, -0.3595320449157307, -0.39584798718372954, 0.06265705457685422, 0.31330220174568646, 0.015368341847787704, -0.2768069037876211, 0.5383671411470611, 0.38924483258702075, -0.12128528839783559, 0.4714244998547389, 0.4341613074403952, 0.37619909962108794, -0.43750885599559997, -0.03464783482533644, -0.44750779744564734, 0.6070598838258762, -0.7528418550605049, -0.5272638404093611, -0.1288967493732759, -0.243667437645229, -0.10983141030566802, -0.3313130703751878, -0.8793076468001021, 0.3125956277291721, -0.14192637155388965, -0.22561743206989152, -0.35615420645576973, -0.3289437883951549, -0.25828257188773834, 0.09314494930091995, -0.24923477224348894, 0.12341503144001113, 0.30613096769792153, -0.4001766826175613, 0.08372910349042076, -0.4094704889837806, 0.03732665552072913, 0.2419718249591714, -0.028293109295399792, -0.1569131259372931, 0.3552820898306467, -0.14319396721275093, 0.3335993961144156, 0.09502935400874861, 0.6288212941141464, -0.38902520476674024, 0.2704245366471493, -0.10349685109076881, -0.7774128024579555, 0.635008115289192, -0.1532330682531073, -0.0685908988621125, -0.21908574837986464, 0.36154203894270903, 0.0662845738048375, 0.541766948410246, -0.47741296197335636, -0.2826804592500023, -0.42388170465964836, -0.1111200028030792, 0.3435008924739529},
    {0.060562546664162706, -0.08770392831335544, -0.29562429813061614, -0.5582941077965359, -0.17299510922234973, -0.6735262627329773, 0.29491984180360065, -0.018046839876814713, -0.48459991221590015, 0.9626710007044171, 0.39028838265498944, 0.521094780784198, 0.6058001756871854, 0.7961900376082672, 0.8276360092165829, 0.07896698066067191, 0.1826210247339314, -0.09906182403156401, 0.46030081121858174, -0.5159122980250462, -0.1514957513316424, 0.029429126172857794, -0.7802829374369668, -0.642021469851454, -0.31317993727593924, -0.9780061636512523, 0.8357304748075312, -0.7905931398432927, -0.2795976041630228, -0.5086149674082783, 0.9397396658963884, -0.4905995924931697, -0.5208640135025535, -1.1896789014139062, 0.6119645099437325, 0.3711475181613236, -0.7235774421784844, 0.7128725309237075, -0.06002503684183561, -0.5237224619487719, 0.38147026215961083, 0.8457929385950169, 0.2575341460862797, 0.8842189264513262, 0.0005290536090970463, 0.7364254656538258, -0.5718677199229839, 0.7499000884502125, -0.20297378733399926, 0.6809571901037053, -0.41323565430283205, 0.3837749386402449, 0.877877748502866, -0.9489505983583139, -1.0157774272028393, -0.9278379754311327, 0.6889707760404428, -0.9884248504958877, 0.7238635767370633, -0.3817633759325699, -0.3379000315099702, -0.7550222769451619, 0.346115751221115, 0.5392421567942208},
    {0.4980476947431992, 0.048717807921643846, -0.12884421956656075, -0.6950555016780956, 0.2790449460634643, -0.7094951455682534, 0.30322413311646385, 0.23851022958336188, -0.40221155688501276, 0.4102211330585812, 0.10003873041308121, 0.6268606513640708, 0.600285375460017, 0.6210167639081708, 0.8010299525509429, -0.03782118346953164, 0.4401316896852756, 0.016702464630717857, -0.17565294166499282, -0.2382206031917957, -0.3297262693188449, 0.14837005352508525, -0.11143464791018518, -0.34568217890466013, 0.2787698277095416, -0.3351787228966325, 0.4788259931900017, -0.5434032457748255, -0.22422508514247103, -0.30012274850375925, -0.14497121942402, -0.2248114246744425, -0.6306260073824809, -0.5680915242975741, 0.5151113617922438, 0.35192692776879847, -0.47019445541053273, -0.004185458206065833, -0.022780383744196057, -0.1711701358567005, 0.709035132321272, 0.2632904712508395, 0.4266499282615934, 0.6268723456048287, -0.23979221553608795, 0.6366047674389692, -0.2727745751801311, 0.37238434167315554, -0.11549000850873735, 0.31163811614838566, -0.01059706516187461, 0.11691542446618208, 0.3356880627323638, -0.4884579340941043, -0.5475102199524391, -0.9736045385514045, 0.5855050725546502, -0.34407316541653976, 0.2983356802407278, -0.49722324962245595, 0.38245319069053985, -0.5283229942713212, 0.3436570384145042, 0.38444934619889065},
    {-0.3936936305710277, -0.6942327710185159, -0.7051548113336258, -0.7686859113272284, -0.3514448319845981, -0.5625301653833651, -0.8173946596777987, -0.369765073338154, -0.27199294623345427, -0.11579867012705174, 0.14139801324611748, 0.5197921603601684, -0.4714940831335147, -0.48364166763621896, 0.37058311726703114, -0.10195522751203656, 0.06437423984903384, 0.271341215613597, -0.481246599771185, -0.16210961657984307, -0.08076348464944248, -0.9281869904453347, -0.6353942375250491, -0.17434956788236988, 0.14423594835223671, -0.5390148057050352, 0.4573501066012257, -0.9126864352943896, -0.7760826614232257, -0.6425569304703151, 0.1663795629464494, -0.6764126309473701, -0.6621653419907736, -0.9433732571928514, -0.5051280226006338, -0.5585147588345704, -1.2596859318266869, -0.16651720011180407, -1.147297406275197, -0.9197615669921047, -0.12884199031739654, 0.029704486519317723, -0.32223411937496554, -0.4050945569300592, -0.06700504468395496, -0.8871747983250298, -0.6461607739928714, -1.0471437741458676, -1.1354303127459289, -0.5762857595641118, -0.8278008878209034, -0.22395938620306655, -0.2931069974283349, -0.6273508731138799, -0.5357611622005322, -0.33395844898120197, -0.4918675274162437, -0.9023884401343506, -0.10252627245343446, -0.574694274958596, -0.49399859631953763, -0.8964348845645425, -0.8134340308013254, 0.4144979775024637},
    {0.31480296266541175, -0.08004590685094783, -0.5189987606126867, -0.28932113553570254, -0.329361784687279, -0.7614847758468432, 0.0700065997517354, -0.6763801374289151, -0.30849316610129374, 0.5910938300483827, 0.879923196814506, 0.9298646490641113, 0.2539058643599289, -0.08265309007616242, 0.641573649402516, 0.7622135356319796, 0.34073270745817236, 0.1938064066442325, 0.6357948946665313, -0.15793328519709032, -0.2551644351936248, -0.34073305769466344, -0.2833094248372584, -0.08645296061929603, 0.31449551316768304, -0.39942524030511417, 0.6838686801615687, -0.8991253369653811, -0.9598329220686692, -0.2577226672974361, 0.6348633313598628, -0.5997994499632471, -0.4794329988764329, -0.7633020172425309, 0.27153564481455716, 0.011517669050395161, -0.8112456485063784, 0.22110400646504563, -0.5340364572932346, -1.187558241586103, 0.7865233510296992, 0.695933084730857, 0.11171567782844698, 0.49701588643356176, 0.6030149934699996, 0.1638577596785941, -0.2599782183839282, 0.23658160678694554, -0.8263111630207276, -0.15252896073020988, -0.99044513041909, 0.23890110611656132, 0.36439760442219404, -0.3854486248841938, -0.9293768621180517, -0.34050061504215623, 0.24659360193790836, -0.5408507313142258, 0.6367485250424801, -0.38851566972060386, -0.27194576194419817, -0.7400128320570971, -0.19350482838640437, 0.4445608113031166},
    {-0.07615426019706291, -0.661462149558559, -0.42120028438872836, 0.025791460108865807, -0.21335261536518454, -0.026744350243996417, -0.6384691740395619, -0.20382850381730108, -0.19009610164700583, 0.32604065049870323, 0.5704972082669603, 0.5205600002570079, -0.5436030952320543, -0.38362816389798177, 0.39066915874982805, -0.4189361826302924, -0.06342619831788501, 0.41559908917560473, -0.05974991497909511, 0.34239325995517894, 0.14451110637631698, -0.3090302462920956, 0.021748229497243962, 0.2667757688006863, -0.014888324313692615, -0.20524066072366104, 0.6044974108386153, -0.39566017571487494, -0.6687993684072566, -0.25695501359486916, 0.23893118168120345, 0.36414585202786165, 0.25103709951374137, -0.7327333268570103, -0.22051965288459396, -0.49128638258024726, -0.4089207567880255, 0.11183444425336898, -0.5460003470676934, -0.24641173390254936, 0.33754023592845533, -0.38524807830229846, -0.546233977211485, -0.3253726073492091, -0.01600454145780216, -0.3167496178520167, -0.5090028404344011, -0.5485804166579799, -0.07461806957644801, -0.682388912518295, -0.6636148783621205, 0.0903952810737025, -0.7363898246034369, -0.32295630539691034, 0.14679704524104337, 0.06754261578511543, -0.37665635920319174, -0.2382062878009646, -0.29729076525855513, -0.29412778696595643, 0.13548028670731013, -0.2063541170076069, -0.5320862300439703, 0.2801935255526663},
    {0.23754856953653292, -0.5990566964049377, -0.29672700086905407, 0.21408968628874542, -0.02449635888615681, -0.19477494382826424, -0.3950148500168571, -0.08247458878284264, 0.28733940084321946, 0.5916952403788758, 0.3580376303074715, 0.5516390798108465, -0.8304766467480872, -0.2114981341728783, 0.09945189079526376, -0.3249547837161906, 0.15676560579073898, 0.04733718663406778, -0.25644759845834697, 0.006019815591312057, 0.04431224678672361, -0.38285735777249175, -0.22974080332262214, 0.46388202734853895, -0.3711636063432492, 0.13866469004613952, 0.20703770708923916, -0.84113689923511, -0.8844827269272582, -0.44598284353788414, 0.24173280381989937, 0.8157587572945064, 0.33277716082364617, -0.860534710905512, -0.36770763763233116, -0.574050178388633, -0.33703655114197534, 0.24008009007564654, -0.5448223811898442, -0.1191141065103111, -0.1842149747120761, -0.2065667666375157, -0.020069644275450806, -0.012344895521737504, -0.07598957954406285, -0.525798307651773, -0.5637918504912693, -0.4085058734126449, 0.005529061574371798, -0.4873277647826976, 0.017363992050023196, -0.43661457767454714, -0.5686599344472357, -0.0047567883153299805, -0.3703686187172466, 0.0018079826059148503, 0.29383864208999627, -0.17324096018813495, -0.5703259003403119, 0.22796362095417538, 0.1694345060007135, -0.7708820173303882, -0.43817073606102724, 0.12469691044828483},
    {0.49411052551708506, -0.5727620217059962, -0.043973244020550944, -0.5388614514037304, 0.1678038191117562, -0.19248401005123705, 0.036842204422245846, -0.5149134425795542, -0.0438799085107173, 0.5885488316405697, 0.5619490716924762, 0.5555516194165941, 0.07634834941133342, -0.30618085832380665, 0.4037442304349419, 0.2613308181451934, 0.2751367229223569, 0.5366970151280323, 0.8300634119994992, -0.17437444419626738, 0.36093411203180364, -0.3434533813634984, -0.12221587067568632, 0.3026998566273249, 0.2814308167660302, -0.33925141920726704, -0.30832996651613853, -0.31762493768674216, -0.6299644369057286, -0.2746033474506139, 0.5106347900268955, -0.09842252669131994, -0.05936125971883299, -0.350801214846163, -0.37818298360820074, -0.3247551135205678, -0.3001801500152987, -0.055945014767110904, 0.14427431749283268, -0.6301964667708505, -0.22168994196075678, -0.15270758734655077, -0.0558618936310649, -0.0475907404501083, 0.23967151653126284, -0.16835024089504796, -0.02970100368108363, -0.1744124277723194, -0.16280167849080082, -0.47036626343249804, -0.37834821149115866, 0.17892094827817046, -0.2114090654419732, -0.07528622983446744, -0.17528021274057703, 0.1334772451693664, -0.2737361373494888, -0.2681147566768064, 0.35047903624296645, -0.17962869135606863, 0.4679764715931077, -0.2587368559616582, -0.0018989481005894664, 0.22545351210432762},
    {0.22577997102198283, -0.45637400136363004, -0.09984772984373981, 0.26236279590389616, 0.10676260368432511, -0.1091155057324384, -0.34627616021190644, -0.18499398593354804, -0.07601278293362425, -0.24632332049566116, 0.5337717990947886, -0.03656263366428938, -0.46419716134654443, -0.5954117499770115, 0.7163988216684354, 0.33711271497547257, -0.23898167769923806, 0.26860410960632036, 0.29290255122040243, 0.1584447665719883, 0.11363992834235707, -0.6585505256376888, -0.34293688381443393, 0.16018734946929036, -0.06770635049291922, 0.23790807826976215, 0.350714746474023, -0.40383954304418457, -0.735373670630339, -0.32942708662338427, 0.24735253718259426, 0.12911743738697254, -0.21844490210254558, -0.06797814344829303, -0.04134811213494263, -0.27216241552508014, -0.28510600505163164, 0.17874414595065136, -0.08145918894313356, -0.4056318606154049, -0.1636619563581334, 0.16730387449932804, -0.08595130759951256, 0.1542547992865817, 0.28078397113956377, 0.301300614725971, -0.21435582077313017, -0.06975390346535192, -0.7483538086349438, -0.712292968973021, -0.3417515710141447, -0.04990990196960078, -0.43611627152005566, -0.46992290824983307, 0.094311244585644, 0.5652979952051225, -0.33595216848216775, -0.42590478747726973, 0.3286924717560244, -0.038404630662308425, 0.09036536563046679, -0.6170180492201676, 0.027010276682266944, 0.2848296298359686},
    {0.09101137923917924, -0.7994833727674608, -0.7776373836767734, -0.04293765728317879, -0.6608157703676967, -0.06587512360485673, -0.8278628499394789, -0.10331741210095474, -0.0328995432237515, 0.28104993026688097, 0.4163785599385852, 0.23018749559471655, -0.24863333307889807, -0.10517787561463517, 0.21696677067160147, -0.2536251886928416, 0.5248629870788333, -0.26003843398465765, 0.5862777375697371, 0.33843920991269655, -0.2215672093034666, -0.19215099219796428, 0.1278317474896879, 0.6545915353961542, -0.17212276803361515, 0.2498119592953412, 0.5783789420887478, -0.2165325264235146, -0.6764653436037282, -0.394251941988683, 0.2822052569049516, 0.5689472939713069, 0.16545560786926758, -0.2581954003289943, 0.36661879557826166, -0.2970077440326238, -0.15292063038142067, 0.3411292260992688, -0.5521285821692412, -0.43218088751763245, -0.12404887028831518, -0.4247840592226533, 0.0645041695318959, -0.39547013221482374, -0.25186835732426266, 0.10379984390723303, -0.4690694358181971, 0.4113240578096116, -0.3457195700985071, -0.5190475392273344, -0.8127413330515777, -0.16202928010276602, -0.950458742997268, -0.3232540376311991, -0.07931125046704347, 0.331445611724528, -0.20074776413831058, -0.4940704214323592, -0.13762943382052556, 0.16281613065264183, 0.566563430842436, -0.4286796615017112, -0.09248837399740291, 0.002201621290819863},
    {-0.7765742651454958, 0.0251426961538559, -0.4624875791328889, -0.36391766738221853, 0.24404356027657315, -0.45546792503666156, -0.06145869900482111, 0.12235841718945631, 0.023757952619617977, -0.022464463777193987, 0.743009446340853, 0.17486217393623316, -0.3431615023397042, 0.01787450130805959, 0.7953036014028606, 0.37535594129433136, -0.3868270358687207, 0.2066692936644721, -0.08977698028489349, 0.26368065531719004, 0.3537287069462506, 0.32257392321797285, -0.14294744472372886, 0.00434279557609436, 0.33812818955044854, 0.3777504854232359, 0.036699166957869817, 0.027947864706421348, 0.10969108422242058, 0.13090132118262918, 0.5155627692798677, -0.005517364141238829, -0.5608320892811287, -0.44316932031861284, 0.2977924813144685, -0.17801626387510772, -0.0999887984976924, -0.009664564824182853, 0.02287807633845947, 0.31129359094466047, -0.06343427502254756, 0.12931874227710746, -0.425525493184904, 0.5474361878777076, -0.06872871007287536, 0.6326022407878275, -0.07688223422371346, 0.6178041816977441, 0.4247340674278298, 0.849439114902664, -0.31096465991282707, 0.22692025186616996, -0.26685733840647413, -0.695446195462592, -0.34154497178557286, -0.20698936442065607, -0.13154829309039354, 0.1289817798858518, -0.1256643152422877, 0.18888060212961197, 0.04605760279659322, -0.6987878808694351, 0.1600638773398984, 0.8344011874030212},
    {0.164118305174365, -0.5222131449964669, -0.15774925620117103, -0.1389719778367238, 0.04095797909080704, -0.49907366162032757, 0.06532642038541285, -0.3942793421353674, -0.03080118317047542, 0.06173849420356797, 0.336296111393032, 0.2595609745960531, -0.09099953636304868, -0.2722666723820608, 0.9533373218395331, 0.3422887617870792, -0.21835498614585624, 0.13450632907600119, 0.49463561387434957, 0.30776710697391807, 0.7421857213913888, -0.23037644599766063, -0.3713071933641613, 0.010713180404017506, 0.06292417221163842, -0.15724261677709278, 0.05356401550160074, -0.26157970904706257, 0.05307532330230458, 0.08304483548941144, 0.6101636330504387, -0.17577864458974893, -0.48821332703994313, -0.5241122721963023, 0.2696171798676894, -0.5316511233243664, -0.3240385853848172, 0.5133496636149568, -0.053390281711836685, -0.19448627352795225, 0.3279568210293743, -0.11570975321999191, 0.551224430943919, 0.2495551841026641, -0.14153546264364406, -0.026571947313928534, -0.11191778021915694, 0.5672433841596733, -0.17479281695394083, -0.003305468885534239, -0.021721654505663723, 0.5030693220318969, -0.052976963180957674, -0.45250482314534657, 0.16897216821942332, 0.2544981458649305, 0.05466191545529445, -0.07806862377708057, 0.4323025882335962, -0.33839513168931423, 0.16628449266067982, -0.11703179703963287, 0.4841446912760697, 0.3224431167599378},
    {0.6878956861324771, -0.25990496077029923, 0.10404174370946258, -0.5190583387914471, -0.38255312126927815, -0.40212492826405966, -0.3099303477379328, 0.0030485878788208682, 0.34095779324437214, 0.05576804942512469, -0.16995664082820838, 0.3821797418183748, -0.22213414447494786, -0.4061949224080454, 0.024079691171972367, 0.45241127141891563, -0.013586858063408626, -0.9356393568492005, 0.436438818488005, -0.08894394273345635, 0.08360134181188549, -0.199453476170521, -0.04229665679440749, -0.15202988692166333, 0.5450302841065221, 0.2837101578848633, 0.18279613512657267, -0.47117862631875723, -0.2062923200446241, 0.36865660394148886, 0.2936305639086103, -0.155590910556101, -0.41451227143421027, -0.28229219261668465, 0.5131220120136007, -0.1808044187073289, 0.2691913039992634, 0.5529835772329923, -0.0948157072833822, -0.21494953821582533, -0.2033909845717741, -0.4100698448297303, 0.3149929439890692, 0.008798478420636961, 0.29482366449250375, -0.39059499613878096, -0.027595057302478087, 0.3462453059748526, -0.29969071010043963, -0.23674410185057362, -0.14962740978338082, 0.1842812685681384, -0.1327238298215122, -0.4902258605925763, -0.12073015277643485, -0.25994847089265727, -0.12206870381928935, -0.0737607482388431, 0.38577893501253435, 0.015775541863273318, 0.49883983401968274, 0.06624086569216658, -0.20440008040012425, -0.0959498767763559},
    {0.06963279963447873, 0.43049617367317705, -0.1251383591517267, 0.3900227640099856, 0.13301790774978534, -0.2372184040148725, -0.29236489893014106, -0.3262512569054971, 0.35242572867655886, 0.07523640451161542, 0.14441152674343688, 0.5047214078338804, -0.43848106686654525, -0.4161151468219472, -0.07910930012322767, -0.22958096424904054, -0.2565036913274699, 0.23352409249996767, -0.022905775529340082, 0.05835389391675826, 0.06977770049398031, -0.1155089047210109, -0.012713743609014071, 0.38790098703693976, 0.2564838299311172, 0.5355340423952442, -0.20882649209509713, -0.49865449842330534, 0.0011347075564457035, 0.5971412948887597, -0.38156256992446774, 0.3023830703132937, 0.7445061016103538, 0.08491264990831979, -0.007823209466675404, 0.3559379190791533, 0.11334942293470239, -0.2971970731465724, -0.3059611006966556, 0.2134248448712811, 0.4630742100294533, -0.18462320688607786, 0.11443633647494376, 0.2867327969874013, 0.39187667123808856, -0.2738875268371969, -0.3091385598181316, 0.24867654102191, 0.34782677033718823, 0.1882415202479035, 0.09145657186146576, -0.2849856111893585, -0.3684393876137159, -0.15284010694807643, 0.201522908503248, 0.23580530842183256, 0.6984042276264386, 0.24280811667003319, -0.10989508931278553, 0.381236663608564, -0.24878297109006337, 0.3869699503926648, 0.07919065046638729, 0.28508728735106076},
    {0.770342657271612, 0.4427180859756442, -0.10040672799351852, 0.35583564827995007, -0.6293330225538575, -0.06901542945000806, -0.4620943311729853, -0.44383296564648517, 0.21402113469816575, -0.25463725898928313, 0.3388124299572202, -0.18848375336111203, -0.3278061539305607, -0.30906112794406454, 0.5228586968992068, 0.3605368844877955, -0.42439719244519036, 0.46551936517512077, 0.21261686059566498, -0.13440865890540168, 0.08229172396429268, -0.5880133317678968, -0.14055506375483257, 0.07920981427062554, -0.19402031922687454, -0.48413213970362096, -0.37202763506358105, -0.322320064308051, -0.27877977922027086, -0.140772709456272, 0.296772571211761, 0.29920032291093945, 0.048182455977499816, -0.588742678018858, 0.20154537901226666, 0.1822878656649262, -0.34322597318311887, 0.28382794327013205, -0.5555257705525315, -0.08226257426015474, 0.029091925152260993, 0.20690268292457825, -0.4053939470170833, 0.6787549373132891, 0.34259138274289613, -0.17913555028356076, -0.36589460631125753, -0.32494468934336906, 0.20041802095056524, -0.2904023275839973, -0.12091831436319572, -0.3812363138360472, -0.08801138671207097, 0.44612008906024325, -0.06357107855841654, -0.40174295499474266, 0.31503589431759144, 0.4455184639843626, 0.11034675686809403, -0.8281354798914994, 0.5060902627191338, -0.10948718201887478, -0.15458042760284585, -0.06230620159828735},
    {-0.3815422877853172, 0.27014405369874583, 0.018980695468820682, -0.01570501838190334, 0.250959254760888, -0.4062438294268415, 0.09669005501243091, 0.3490385837682165, 0.4594696061147251, 0.24010448548002122, 0.4129393214636444, 0.38933297092248914, 0.039117456725906725, 0.3330989651584907, 0.9145781042841453, -0.08270686320808313, 0.3553107408878353, 0.12760554942320373, 0.19037793340334974, 0.474303455312899, 0.1300985867852071, 0.3814796113034306, -0.014133272497822456, -0.2684672997274674, -0.5361590773997511, 0.1240823592614385, 0.6700945473513155, -0.1927217992831226, 0.3939828431952763, -0.7029543017916126, -0.13961642657467838, 0.07517840776643255, -0.1501731482191157, -0.4731717691728051, -0.5106207681366985, 0.8125947359659323, -0.22628793280465875, 0.6086325387632465, 0.1956137974561684, -0.26293709583553876, 0.3923689706938123, 0.26730037635520154, 0.4355074733561975, 0.492533776557004, -0.39909601148612733, -0.03522177654283121, -0.5105692235586754, 0.3322257447552633, 0.217765910263393, -0.08674368520035172, 0.16839742340550812, -0.03603114553806715, -0.044547248073238156, -0.034818470427324555, 0.20002364732767666, -0.2860959325118866, 0.2507319927879181, 0.20522879449169104, 0.3730785243313434, 0.36113293629570736, 0.17444865297341886, -0.6470040793183388, 0.21678516705862302, 0.6399642291029717},
    {-0.12603167882074112, 0.3056453818868608, -0.47329514493763253, -0.12213451402775317, 0.08720198818274644, -0.024725827053489736, 0.02810573479238107, -0.2565305891204645, -0.39658892962647563, 0.38859774179622253, 0.1519073651743099, 0.4478316368966657, -0.07874777755417911, 0.009065027954218357, 0.3383908852065677, 0.08944688257934198, 0.5428341735649083, 0.5761000719450841, 0.004721528977957005, -0.31728685523814054, -0.43816570520637765, -0.2955534049928552, -0.13907917569755537, 0.15849968464070693, -0.3192503699842187, -0.008321442645374115, -0.207338108278984, -0.19707365006012273, -0.1625653255288228, -0.7736398010427713, -0.0242193125285424, 0.2698910917987535, -0.12948636357516263, -0.15873065439050293, 0.07745623674441453, 0.020706698402314337, -0.2809668233497713, 0.057205549157355075, -0.11696883208781655, -0.37108465909725746, 0.19711511882966673, 0.49383359762908113, -0.32876549853083176, -0.6409900307609998, 0.1747179008082703, -0.01754777678501753, -0.18734514895103244, 0.5895015844815716, 0.11026017375050155, -0.17164126235159075, -0.2669061981217085, -0.09618272711139529, 0.13538550198803975, 0.07539225116390208, 0.04181399063964302, -0.18216567141888476, 0.09733527228585014, 0.0582213036818511, -0.5079027525609275, 0.025352163126465824, 0.2803556688682463, -0.07139374888807168, -0.005736406550962467, 0.6033065845510701},
    {0.43841800477020715, 0.338192885679354, 0.4280140732714425, 0.18516216805981936, 0.25877411665044636, 0.07312763592516167, 0.2537536541258273, 0.17625094037453742, 0.06606783440697866, 0.2285028771135577, 0.672634370180761, 0.14545422139731168, -0.4275971481288883, -0.30351739203334144, 0.07703716629365759, -0.0741077382697223, 0.04494265942919613, -0.38948842060135075, 0.4085152895813275, -0.12043934248327057, -0.3563713155691588, 0.1972983120119923, -0.2615904729021053, -0.02434378982030233, -0.3739575158032456, -0.37126427585190885, -0.08249856064913173, 0.30386267894842633, 0.17374571455254828, 0.31685216327988097, 0.2918567467374024, 0.7673433627173029, 0.21234602309995282, -0.416293942157256, -0.0669460446605048, -0.18904182672596836, 0.19394411556166158, 0.6532115736484806, 0.3751473114677295, -0.3116096055889787, 0.11890755049341245, 0.4706362415992816, 0.13634951706353043, -0.6325650361773318, 0.2621849279411197, 0.22436133767821304, 0.4886432617676598, 0.38927498083436335, 0.13325587336445646, -0.06765032199611767, 0.6023901446248927, -0.2624501333983146, -0.09344806279077993, 0.3102675211237751, -0.25911136464109535, 0.2732606817069108, -0.01294175079769602, -0.12476682309359724, 0.23069949827696176, 0.16586981058890668, 0.27621812619465325, 0.38643793423180095, 0.07070953370982376, -0.10045816234075523},
    {0.38313006492988105, 0.3584610229927236, -0.2977246495117287, 0.017703923109878672, -0.5059082655666904, -0.35567998957884156, -0.0412813799099552, -0.023600749062718644, -0.388627546801013, 0.6881444281414982, 0.2546019135804058, 0.3357904372718057, 0.15557227396427545, -0.18391288533582237, 0.14523391972929606, 0.12079033157236874, -0.1311031782292477, -0.4445614493644838, 0.24286168611027156, -0.48792534802886306, 0.07728170174115741, -0.007632825857357369, -0.3108370064749984, 0.11382650318109436, 0.021261476541659087, 0.10455940332711279, 0.5073545428906847, -0.4789009605402452, -0.3998787484699148, -0.842852435812872, -0.0376831334499817, -0.22913015580757057, -0.3615427657524223, -0.294661329032122, -0.15944280566935884, 0.38028285109021126, -0.5377638281847645, -0.05252298756747211, 0.13265010540761604, -0.5680480124291639, 0.031618771577345224, 0.025762502033023552, 0.07669010829212103, 0.0087738775419104, 0.48584936756029506, 0.30304606551184604, 0.35426057439172076, 0.5252739029300932, 0.4684088854638874, 0.3659777998319054, 0.5046093958695808, -0.2556582225981345, 0.1449137855997955, -0.32736603954332805, 0.040198669775759546, -0.4864032408444993, 0.6538884744140112, -0.5652623553308949, -0.07772010283626277, -0.580308943335275, -0.2290417587153269, -0.394962915530369, -0.571635181237525, 0.5195385420146151},
    {0.1270411947261847, 0.3278706106890798, -0.2942632454261716, 0.5910510961707398, -0.3764269484401418, -0.08576486950117686, 0.024309630443440613, 0.13012133631282405, -0.010331672444342159, -0.16899768317485872, 0.35748403028487724, -0.1618511554868736, 0.2357423080501721, -0.04169520171131541, 0.3563547226480661, 0.32992815719253615, -0.6306543561071319, -0.05391254194706329, -0.2138549067369936, -0.2655141563162557, -0.28131308804335414, 0.3318861382967579, -0.10743705200970254, 0.2731785735441338, 0.24037046743819393, -0.036878037235768414, 0.0042691992673881286, 0.26185402390558804, -0.2936498489140199, 0.11326217587872887, -0.15395751992087334, -0.015119771755835901, -0.24829487331393701, -0.2529500184239861, 0.4870746666596451, 0.09600298489356796, 0.22589660777644321, 0.20993420152312767, 0.3528121919909805, 0.1822584827329427, 0.19733923243144583, 0.6247591887386118, -0.23492388895496213, 0.11023837113853563, 0.1644504689806685, 0.04743384666583767, -0.22438543961274118, 0.314349232591605, -0.033542493066102734, 0.15128462520036154, -0.35888120579976646, -0.454841500216409, 0.5020440100419086, 0.27146962634600474, 0.45765422018940344, -0.11079764118890915, 0.3839347514221694, -0.09221168448329269, 0.14618729527452773, 0.35272997482843704, 0.17664777079085642, 0.050242786792110854, 0.12475197691114318, 0.05587560416664066},
    {0.5062883876687204, -0.005943838750766955, 0.38277900213516963, 0.7269083515964873, -0.26251861035168855, 0.06070326071340386, 0.05339857369387455, 0.2746720873353271, -0.20011513071842277, 0.18331668981959212, 0.43091530001134215, 0.35794923239814225, -0.3392599327618121, -0.23113273833489326, -0.3090932423762096, -0.10952530614535916, -0.5406435061885532, 0.01597803716027383, 0.02958771023262685, 0.02723811507685859, 0.2598786632944531, 0.31441091090278495, 0.20837177777181648, 0.2647538624729562, -0.12603004896854994, 0.43519839779430763, 0.2031485356694401, 0.30376581340508174, 0.009726233738607575, -0.008065353596110443, -0.3307529249851744, 0.23110849272338524, 0.0674358160824494, -0.2179553443733891, 0.4610680587925945, -0.24282414803469277, -0.06590910311131577, 0.428196480493027, -0.18821584054493085, -0.28848147928451895, -0.2610455559872251, -0.32196480474478917, -0.34423176374896447, 0.12308922269800235, 0.1090074104700539, 0.18874493342150905, -0.42512755208959613, -0.41320806958908174, -0.007279496812228434, 0.2978245408013584, 0.3151878942723295, 0.0952896137210452, -0.26630593055693763, -0.21530894678585322, 0.04260056349430642, 0.46165923627165667, 0.46275780727282206, -0.28122310177709026, 0.16151346340845166, -0.08678262398128307, -0.41688844703976174, 0.17051511766223493, 0.411781318369026, -0.43905137665469945},
    {0.1364756352412722, 0.42477415998288776, -0.10171543682560656, 0.22693926299176367, 0.11007465701015692, -0.41023462155434964, -0.14223118687723144, 0.6532643981227395, 0.6742059384354135, -0.1856542055843283, 0.20113713516158088, -0.2896839794276565, -0.1796421535141344, 0.045527970500236103, -0.1771003171765693, -0.1039584307268534, -0.3290092442248003, 0.3705825827036154, 0.1333988317803731, 0.39662027874165545, -0.07546263367137251, 0.33041285555345473, 0.6524480726891546, -0.09423902147808884, 0.643339214102671, 0.45111160706638237, -0.10708415145670636, 0.3893528897289929, -0.08485998038877912, -0.4249611852431894, 0.20787397045261602, 0.36622639004904584, 0.19659475711156404, -0.16470985186923756, -0.3629986223175434, -0.005517645722505683, 0.8297851423788454, 0.027295751889191398, 0.4062583118438012, 0.31619711687190405, -0.3518196817898835, -0.5074501377252145, -0.022808428973484177, -0.6030717362330302, 0.4022593562913955, -0.11474078111450932, -0.15636591326647006, -0.022052445267004513, 0.47585610544300816, -0.20783175570451226, 0.46177879114615555, 0.2120651999581458, 0.14666345971773934, 0.4654738899407782, 0.0709321075514049, 0.19908519406404732, 0.9966145608658592, -0.040318279981079355, -0.39632474470305873, 0.370941981106585, 0.434047081305726, 0.4649889692971546, 0.13122425212177294, 0.11696827193585535},
    {0.216445430350833, 0.30501353243602675, -0.14761022441359067, 0.08582695701604143, -0.6799747572372725, -0.061222528836545644, -0.004837574417338609, -0.3739956491030108, 0.2666476975559334, -0.2822443667305458, 0.2835019981648539, 0.3851708398205323, -0.2776163497061093, -0.2263042494517102, 0.05527190508311649, 0.1027971973304919, -0.14230838014426167, 0.10412014898095533, 0.24476852377571717, -0.062349077661681025, 0.15377147552254966, 0.6857031963761709, 0.10019004212857865, -0.3541273848173342, 0.25901609804246006, 0.030509470804563954, -0.21479785265924126, 0.0847854876165003, -0.39625328583484687, -0.21795155082200976, -0.5565682089374832, 0.5072514310230505, -0.08525482947273283, -0.016800716367687242, 0.3659627764454699, -0.10442366065729142, -0.02958155430697035, 0.18978680651448218, 0.14013832652077146, 0.007320053032906884, -0.10716925397019177, 0.14626449469428274, 0.06305215988910862, -0.11487845651543858, 0.44228908111675785, 0.5414819086620918, -0.08740406021364934, -0.34462582157195976, 0.0940647753967746, -0.32555900795063, -0.20623208393386813, -0.375705730596406, -0.6521688616704248, 0.24358808826163447, 0.07838463225668474, -0.0026636354839466732, -0.0012976243092303425, -0.015928165319267072, -0.24445887599596222, 0.2624655036358256, 0.41425992470845613, -0.19042792187985325, 0.007959656571586829, -0.41136450580784256},
    {0.06158501507632787, 0.329753205853702, -0.03645209974624649, -0.06594516953477361, -0.3483491538947281, 0.06344926630218213, -0.2522433581667084, -0.4373224882614783, 0.3783142217872786, -0.10374759777559037, 0.7036020400757486, 0.8030816732390106, -0.23867995697382738, 0.02365469706996834, -0.15135878057731963, 0.38582287201156007, 0.008939281913472522, 0.3057828902179774, 0.13355544786125978, 0.30127051080087325, -0.11919567501849943, -0.15652520744533807, 0.11356484927448232, 0.7812935490300543, -0.055090363141830655, 0.29774685607702595, 0.3277827371739553, -0.3711486074850961, -0.08736851875041378, 0.29199709934885504, 0.2082852332244727, 0.260724191827015, 0.73732860270947, -0.10823040962347637, 0.13651438790485299, -0.33334900009652685, 0.2595407920672325, 0.4464483278904637, 0.07761805356413531, 0.35539436636848626, -0.13218691136839408, 0.21858106914114042, 0.07622363025754618, 0.07124323189725076, 0.22898102281044552, 0.16993965585919152, -0.3342641834706665, 0.010315982691521505, 0.008698221497030038, 0.1301876174545201, 0.7488562716800682, -0.19416722485417187, 0.008298990331666155, 0.010125011014251048, 0.08131370672951542, 0.34330545026240433, 0.5150252483009947, -0.08420081673383736, -0.03901506039920837, -0.10796446111286206, -0.12804650029405262, 0.3582314794957744, 0.6922015801062773, 0.18111432299472335},
    {0.5090004787348267, 0.5901077097377303, -0.36367050203497003, 0.08372334527908779, 0.06271759724901185, 0.03586306555092406, -0.10884162644394703, -0.14741670541624013, 0.2512445957102414, 0.3838798963566738, -0.3720573302250298, -0.3016349794646386, -0.2406438191577252, -0.12941353597031827, 0.3530348166214386, 0.09193238380647113, -0.04524594464949602, 0.5995254631264009, 0.8160688765699985, 0.05684635840211371, 0.5102488559259798, 0.0916067836487166, 0.32674565165559705, -0.42269043793908834, 0.061741483929740715, 0.42329039635588533, -0.47850254173033946, -0.09394626355498609, 0.38170648582118855, 0.5346864980016874, -0.12532727388300763, -0.3262548227277742, 0.7740012236843515, 0.10889471381747085, 0.16346262618100663, 0.02119445544036331, -0.18353832157458203, 0.542536206374137, -0.19646629616405906, 0.009465472367785437, 0.14382438560868052, -0.5975145947470332, -0.04798200589701292, 0.1335750732895581, 0.19397614159955795, 0.38951079591821913, 0.4116537786248445, 0.1564844062251826, -0.11359362242967375, 0.31149341989316853, 0.6413534243896113, -0.04398847250883041, -0.021770627241028663, -0.09250658663482425, -0.5867257692578758, 0.36715204169999666, -0.171124899905568, -0.3364466373731169, 0.19804265510387267, -0.3312457942500139, 0.17830722188050072, -0.42891792542715046, 0.4956529298687744, -0.6585603427311838},
    {0.01670843664320851, 0.09031459507036622, -0.3672411280421267, -0.27062316458743646, -0.2960692344809288, -0.027847770688699796, 0.04448435487088533, 0.3497490767063177, 0.31280536748465176, 0.08466005817180405, 0.6436163699976912, 0.21479086739491893, -0.6679915291506799, -0.16389419403676422, 0.24474487627697902, -0.0989671632454947, -0.10061200158033878, 0.5687117881952278, -0.02460667481224033, 0.22250556450502385, 0.1381140793142565, 0.20400606054726572, 0.7024412096472558, 0.6878764569187462, 0.1654264239461567, 0.1741636853255032, 0.1738359494731014, -0.2976961912925743, 0.14536279826934556, -0.07264472126575292, -0.11466461045008339, 0.4561590222841267, -0.04549687083774968, -0.036732593409206156, 0.012845556941138451, 0.3645349703081222, -0.2814050693006555, -0.11270313728799149, -0.2025301337805174, -0.1024049579387219, 0.541423224761471, -0.5934883459490314, 0.36404208198958693, 0.3435153289399619, 0.3173299611042888, 0.228766268154634, -0.34558501815403175, -0.34037395997101216, -0.4907494678783385, -0.5379576100685577, 0.028695021503720674, -0.1620309605125333, -0.5238079318663406, 0.0038659975792570086, 0.1139931867537564, -0.27257496842756623, 0.11822724704482712, -0.22387061740767464, -0.4723007015809667, 0.671362218871472, 0.3220673778858369, -0.22458420498669765, -0.5123947204819879, 0.33028721940187383},
    {-0.0357283077201997, 0.40000877238170546, 0.030001835072647476, 0.06851560171775654, 0.14207495144859572, 0.08159349662422913, -0.2796437959807803, 0.21869454979717434, 0.30053599207070875, 0.6372251866172619, -0.016803329949651356, -0.23252056824301154, 0.10161932904888486, -0.3290163592102021, -0.2674963138714442, -0.009970495617337595, 0.06625658515583059, -0.2787007177529543, 0.07539409527866806, 0.2875200049150169, -0.2190387495246793, -0.03173025606617959, 0.03192596326528478, 0.8136271826224608, -0.8116577513289779, -0.091869430064346, 0.5644131611559434, -0.8162655668492885, 0.16485607281780723, 0.1639468656555538, 0.33205786749800803, 0.5521263083655432, -0.042387128173266946, -0.07329063039569148, 0.08728902877760115, -0.646537934678887, -0.24042560058520557, 0.17280467772319014, 0.04818066733047835, 0.3335482782064509, -0.13752374409208068, -0.08861330160897694, 0.16776100937451452, -0.28809262864910273, 0.027580155929795302, -0.19607421122378166, -0.0983139742933334, -0.06003263516424904, 0.5173669991369918, 0.3718323321852898, 0.29233496054369174, -0.27451048828202596, -0.13201131351460624, 0.10500782215900709, -0.15452684101437517, -0.4515551328790549, 0.4251166906442101, 0.2187624761817483, 0.2709917759836333, 0.05901912531223664, 0.7452596719936856, -0.3889723992151794, -0.11800823818042148, 0.1073636767809417},
    {0.07360494459408089, -0.799113703875776, -0.43821987769706444, -0.4851947982788026, 0.18182703497892172, -0.4161510773732054, 0.09574234770474788, 0.04779527595276955, -0.07336821787048499, 0.05783514645246317, 0.27245090970307306, 0.034717093137858236, 0.3125067270846049, -0.006593120197293998, 0.18126997260636288, 0.1029408131331592, 0.34631905475094915, 0.24556080474703276, -0.15688090477042477, -0.07202880565355536, 0.5353743782153496, -0.3800956486064529, -0.19375091797763827, 0.3014147927846327, 0.3437399294088039, -0.4605522042475859, 0.5085813658449942, -0.5590804974834319, -0.15743027806999094, 0.0948420072991473, -0.0709166156262419, 0.12822630084291403, -0.007580700596346442, -1.0280073480151004, 0.17352884504882138, -0.35410729633116395, -0.19164619399186342, 0.7041731849600144, 0.4255413375520891, -0.1056856642229967, 0.5503146517559441, 0.5250812609334288, 0.42759136945866866, -0.07466437016093833, -0.34589181844535277, 0.44526013381354024, 0.04993555013190612, 0.23959837074858586, 0.09088855461226793, 0.45226662142351964, -0.19865754217216022, 0.11094614936575538, 0.30705562540509757, -0.44227965154480847, 0.02119203000548489, -0.17655776503225165, 0.07092364673794482, 0.47222434103381533, 0.4522574815761425, -0.04665333455083504, 0.43748781458933433, -0.11287742312402498, 0.1556818050241018, 0.07832321731092064},
    {0.27201071496784685, 0.06147861084921043, -0.4449397408965515, 0.2306871686396521, 0.03372756678366557, -0.45533656127438504, -0.02137678818641283, 0.601709483007454, -0.2823763048215249, -0.2507868923701793, 0.3638093229703645, -0.08004147808854979, 0.36127970927020137, -0.0736387481592818, 0.10799796692694717, 0.5730601456072946, -0.3120487180259697, -0.34631917199891005, 0.05951527044689731, -0.2624001055857115, 0.12032979853916552, 0.017296154557967958, 0.2686345507964161, 0.19800053293513686, -0.013338585272974894, 0.267124316692282, -0.17908117367919318, 0.037489897903026335, -0.09063914545353265, -0.27894753884020856, -0.2796023812073382, 0.0704439389735935, -0.09512847599758249, 0.22204308842069112, 0.21889384591762442, -0.49683916802874883, -0.27316641677961806, -0.03292918296112073, 0.15280153461422613, 0.04555612003657877, -0.15680855606628713, 0.3015561483348265, 0.12455753111913083, 0.3022154932341051, 0.07824523079683823, 0.15356609259824736, -0.03980706199523482, 0.19076758445464845, -0.6517556373377921, -0.21883193174125593, 0.1825010918903161, -0.196559675722244, -0.24694552966954547, 0.24597379931058788, -0.014084220068711786, -0.65820063923258, -0.5256897441755454, -0.3616924325636204, -0.12131245731711361, -0.19611521591059802, -0.3504508160509722, 0.36386184937005633, -0.26050240192457086, 0.5739781835416551},
    {0.1759890951805663, -0.0278018268005921, -0.4710931895226146, -0.08561714837636565, 0.08504475457741084, -0.12539958044168578, 0.16409494460502444, 0.5750139351364362, 0.2933554687137127, 0.6040623365558005, 0.18207437874207066, 0.6801813342249096, -0.014636229755242708, -0.03964258760207932, 0.08115020458190683, 0.3750603309930296, -0.3045408166511002, 0.3954857484845667, 0.12398090627271194, 0.3085833810476243, 0.38151125629090193, -0.39143493755961123, -0.6246251750145912, 0.45022373881913474, 0.5204882726694333, -0.14296358909117676, 0.6744512911434142, -0.49367280488509524, -0.07687276589140635, 0.093027030090687, 0.20286373291154391, -0.16616608625709448, 0.6768301618881912, 0.10039338987273418, 0.553072140410773, -0.1511025979496, -0.4471616880072691, -0.255657566441827, 0.06327212958962487, -0.3875237973766937, 0.7661949930361808, 0.2339813261951129, 0.7401130039814917, 0.32567418488209804, 0.36220885564284655, 0.5359256446186305, -0.43017057691870564, 0.05718311141149175, 0.05250560730835778, 0.2040990950536402, 0.4118993733143176, 0.44691448791591426, 0.4390588771818116, -0.6137441523903638, -0.33912809540147587, -0.3502590764433359, 0.2747932301766533, -0.454530470919794, 0.24002759198848045, -0.05995311871895118, -0.2898212938729765, -0.3734328124417958, 0.3814905040691588, -0.2080654187135661},
    {0.11509266652712291, 0.5255184437440544, 0.07872354355277243, 0.19536739690597285, -0.5007942409445657, -0.11440634853982094, 0.024610651821599105, -0.13263308830593534, -0.1309409115137445, 0.357064885793581, 0.30916726642832204, 0.3318843117799246, 0.20912877472266783, 0.21613774235744498, 0.28456427450331023, 0.30881510636814946, 0.3040480050743195, -0.31407377549057564, -0.2695516304667546, 0.5014097633159824, -0.05208945473512733, 0.7430608458115017, -0.023357803749426795, 0.6503726684234561, 0.02158799299792766, -0.14580972678784432, 0.12057770728362685, -0.154746926657484, -0.08110040647283207, -0.1056900439013806, 0.016575269602606982, 0.5034474029655631, 0.0787758474794138, 0.11118111480815014, 0.2505026863319131, -0.033564138354794416, -0.0723024407475439, 0.12399802107436864, 0.3289957431672091, -0.46214587792479656, 0.48838959217764083, 0.8252856992792101, 0.2950756792690554, 0.20150565110913565, -0.357951422832014, 0.43574273629518795, -0.43630642262437613, 0.7445258124935916, 0.5298630710185374, 0.33157321163320763, -0.32585200695839023, -0.0751225695588411, 0.04104557860675579, -0.4719767703797218, -0.23607340243438965, -0.17041514479133962, 0.6719045276428702, 0.1968202458225257, 0.15584570834325512, -0.21177787085318725, -0.2666302493937861, -0.4704062836711437, 0.3375746311142597, 0.4821089396005199},
    {-0.13883348742239607, 0.5264227351728795, -0.249188106466481, -0.43599773876941816, -0.30599277648051876, -0.6655647455064907, 0.0722181155381519, -0.24505374495374668, -0.435772318373872, 0.37505146365602443, -0.30393279488168473, -0.04911699287840287, -0.18725067334830187, -0.31160443853795544, -0.22464957903667504, 0.6014920755402595, 0.24122878006782272, 0.2258846697092172, 0.13979022674260239, 0.09624176913072884, 0.2098050861010937, 0.23800093648088785, 0.10870809464075036, 0.09397743876464039, 0.17765967400673835, 0.27361089459244253, 0.5022817271300521, -0.48387676200706725, -0.27035740922314827, -0.06540121928066744, 0.5923835526625986, 0.2220846234877661, -0.14813870218556807, -0.4240527752863687, 0.36259041261792485, -0.21777574142499756, -0.39503217743764807, 0.23908452963116616, 0.2605681997723133, -0.20188070406343678, 0.5341255758884254, 0.6441674006198845, 1.0700616746624627, 0.8072967166908103, -0.11132927643239961, 0.20980538453608705, 0.11922238225755699, 0.03600461157735416, -0.33434587398993276, -0.5835211302708989, -0.04903880075533025, -0.4758228787410542, 0.19963607278292816, -0.3474775507767209, -0.5752347612471685, -0.2654111180937072, 0.17713763295129778, -0.19990682272497984, 0.7684184957443696, 0.07104417454087839, -0.37237388877028155, -0.4824015942805196, -0.01244239042667644, 0.3295151314138078},
    {0.5230101651506919, 0.4241078143769287, -0.29405826649571715, -0.08645681922594746, 0.06949649927343789, -0.05162230838934984, -0.14911637756686502, 0.09397791720789053, -0.0030317208250581276, 0.41965871033062274, -0.03845003797125829, 0.4450585905306505, -0.4206117108998513, 0.5331415812550413, 0.383521064279835, -0.19534731149490048, -0.033586772127404414, -0.33902168956793854, 0.43314288842061544, -0.27155943787821174, 0.4513206010930386, -0.32206698404503453, 0.16726066795327763, -0.2183097111753151, 0.1556165150880585, -0.5668898693148345, 0.7417385498049613, 0.0019922061417640548, 0.008820773571405592, -0.06543769366848196, 0.21028280031770033, -0.23712531944451037, -0.428625777627629, -0.3547979764832313, -0.14337734606368682, 0.23384556715935417, -0.46965678989851684, 0.41576040208023873, 0.1601744209284514, -0.2360572680121262, 0.2844079831818187, -0.17684177324848654, 0.22560404046609975, -0.4159924301928847, 0.012329476136317494, 0.7167980351961831, -0.6455831690003623, 0.7454144053508461, -0.19803382543696096, -0.2085033945011643, 0.06659513813126641, 0.569511075487103, 0.7932272491251808, -0.34815535715906476, -0.22258029681070748, -0.3450132645961011, 0.4023267060644364, -0.3676023842419063, 0.18223186329099123, -0.11337166418788097, 0.26462631786166874, -0.18272947070591924, 0.2904935452889633, 0.4172094423509007},
    {-0.0823442156608256, 0.2420026865871332, -0.060586901077930265, 0.2167138664845481, -0.06935357281777223, 0.07631343415994005, 0.38966786793240954, 0.18260640275510925, -0.5849399755009448, -0.13656506760328055, -0.37805237820708143, -0.215816759797054, -0.3199700304899815, -0.47632787155767853, 0.11651835869134383, 0.03938335574760968, -0.3244290439318124, -0.2758351423586687, 0.11847732882474744, -0.2597476615369362, -0.12105931062883211, 0.6309261226215489, 0.10791627774975335, 0.03048360886963796, -0.06915603481689074, 0.04751877804907627, -0.0596693005292781, 0.0740572486622441, -0.38303756106693554, 0.1269237189570975, 0.1896570994120413, -0.09623240998109474, 0.41386424374644265, 0.09118917695385119, -0.18885508494076336, -0.33298245283410854, 0.2476581240606936, 0.08338262316788701, -0.23860613894114827, -0.06315118255922082, 0.3448419045312129, -0.10897014502176944, -0.15669475639000385, 0.09763006665630915, 0.1481437489673261, 0.3659954812837517, -0.07534982028593465, 0.30450175226981435, -0.08460693868488313, -0.3620853746572457, -0.08659426278935706, -0.1969723424185039, 0.33132924030286925, 0.42975806556573126, -0.7200789352356617, -0.05295881324116493, -0.3577884646672556, -0.3585133201089211, 0.3057892547909784, -0.25046966267350795, 0.04695017201010075, 0.03318987895964217, 0.39224634126080293, -0.47096923449130895},
    {-0.5819565309818535, 0.035195112762561244, 0.48444754054202094, -0.16274190570800884, -0.023841531186465457, 0.2222505425603723, 0.01655222045510407, -0.250667400225531, 0.22476794145161047, -0.38336760122951935, 0.14540475754933146, -0.126243135295378, -0.37770389375597174, -0.1258467414549275, 0.06130740359345871, 0.2512630913650877, 0.015966288361587016, 0.11197666030529345, -0.17070968072597276, -0.129672727914002, -0.10905587471803709, -0.2489810397459674, 0.3744046783860602, 0.1536742981520635, 0.5267721531808521, -0.31896564933915783, 0.012271614290377195, 0.0801610487761651, -0.25076803541364817, -0.09306139144195104, -0.1450518571740002, -0.28333279737720046, 0.031066587811873634, -0.16517044000719977, -0.18275532298956776, -0.21677086646539112, 0.31484046690666395, -0.009282525037218162, 0.025177303537793787, 0.040322745446003436, -0.10140214904202766, 0.24559083210019042, 0.5466260508223155, -0.289969471636525, 0.12094286130819754, -0.19993040348955035, 0.4553654045173008, -0.034341176177169086, -0.23150673816717862, -0.20164800492234786, 0.1502639411932616, -0.17727130220212997, 0.1282159673390057, -0.46166617876158905, 0.13244078465100298, -0.010233457311114774, -0.43597952942968776, -0.07481980590928247, -0.0031516065075281856, -0.5027646813779281, -0.1462782656913664, 0.11728114686022013, -0.09131848766340621, 0.1028555552535462},
    {0.10304298892009182, 0.01855763835116687, 0.10878946510372552, -0.059985998132354446, -0.23424745239454878, -0.020945530136701494, -0.014923547205832655, 0.11214132039230136, -0.03532599822830742, -0.09166199563286723, -0.05300884208916013, -0.09629303568102822, -0.38002526059045644, 0.0743355841036261, -0.2030808419684153, -0.4026530831661261, -0.19567996042015717, 0.0765177724981414, 0.6647270648464314, 0.26146473238369805, -0.22600474400859527, -0.3369579116699957, 0.3888776096655946, 0.14875325282004556, -0.09720596883373132, -0.3124400165630316, 0.03078228062254136, -0.02704046688891451, 0.007980162609358715, 0.04367039271427829, -0.17424164117516278, -0.2909664877674854, 0.23580327096612574, -0.1373678202854358, 0.06041954335379664, -0.15336615646134086, -0.050960334189662074, 0.27414030746536266, 0.10727262426510896, 0.522719756389489, -0.03784466102705125, -0.20549618738575925, 0.0627105799111332, 0.10195080066690825, -0.08094885876355486, -0.3721699209249591, 0.2009573741057494, -0.19460013244673166, -0.07368322894354815, 0.4402711013180931, -0.03574461254787328, 0.33713565453810557, 0.08446450582075433, -0.21482588565898683, 0.14423914141354713, 0.15872332876963505, 0.07602494606735073, 0.46708340943199816, 0.12614553976923648, 0.16493548787698184, -0.1884621820425091, 0.2587799761125394, -0.023436269454815754, -0.17395484202999414},
    {0.13986787442925114, 0.0940603874928352, -0.17276880504544434, -0.18732959325115422, -0.4528620069844649, -0.10630069932084833, -0.017134012321138134, -0.02668251048558232, 0.3624634568795157, 0.01821080633766282, -0.013996960329814723, -0.004763254598986908, -0.02536201317660757, 0.18830336586881477, 0.06135093884871443, -0.3222077682230905, -0.2866841390812077, 0.15775974767810463, -0.06286229873928607, 0.030896381269743835, -0.06729672269934427, 0.2801957395201467, 0.08560430990612077, -0.10550574088665522, 0.13193903116613576, -0.2093864981288449, -0.024016109641639655, -0.20129041488745295, 0.10066459586348739, -0.011941025806173516, 0.007949945888648596, -0.16183580774128573, -0.28808301595518704, -0.11722453092946564, -0.004630863385544839, 0.5003671752632345, -0.4693850059731038, 0.06373662685412061, 0.10370904363359322, -0.08938115591521953, 0.2776134292733683, -0.1310476363461965, -0.06720123576643428, -0.0061435290555454545, -0.42423608719571326, -0.11242096706957068, -0.35814824835289616, -0.4135860075859943, 0.008879316722724271, -0.021910117829540023, -0.22734477885941431, 0.22281706384579747, 0.31901880606373817, -0.37517634288573143, 0.4697786408370459, 0.25981096962576034, 0.50052091168448, 0.014729987320491961, 0.03826680704563553, 0.33645955950349565, -0.5818239126040105, -0.047731420132323336, 0.07640934009679477, 0.11774065618934673},
    {0.39971162308050373, -0.5771622356922215, -0.38089361226770896, 0.30404492378882336, 0.09255819622747484, -0.36271156682790323, 0.5161390653728337, 0.10584353748924341, 0.16675493069948105, 0.19781630032976566, 0.10529343899228812, -0.03544103220502485, 0.4480427616258593, -0.10285850932510075, 0.2752269987133767, 0.09212768307148947, 0.24412645442588, -0.3902186023188836, -0.2856941321769004, -0.01634568887558151, 0.2750884578157064, 0.06410035973109743, -0.32241483572262536, 0.12692544639377557, -0.24140882060855065, -0.11946215834033139, 0.029976940114992617, -0.0842384917188753, 0.27690390098899526, -0.08041762389327943, -0.1401112897658806, 0.1532088840624839, -0.18749595855274465, -0.07053981585696974, 0.147814767510128, 0.1062753525372131, -0.24564569599786532, 0.3391171324621555, -0.02355271579097176, -0.16277022685792716, 0.06667051509044382, 0.08800135111643863, -0.5304062415869418, -0.3019836453122455, -0.09951896952192847, 0.0375851433416344, -0.1371914353666876, 0.1738360206488695, 0.3442114842498162, -0.08292871980909469, -0.11827505045028155, -0.12240850158001669, -0.148744703803033, 0.015425525071438843, 0.2978216259364622, 0.3013581470948682, 0.07224856794265266, -0.4226891065397621, 0.003078883155032362, 0.18154347223739456, -0.3735293641445223, -0.3863150945618393, -0.1892328943567624, -0.12188856684470474},
    {0.4742129364445258, -0.2066180492478902, -0.3950430566315339, 0.07403795566178968, 0.28535198219694197, -0.4290738104723839, 0.1840329223760659, -0.23161738064074344, -0.10759880680324671, -0.037616162159736455, 0.1353162752711269, 0.23618210125221395, 0.13864141658018006, 0.17797441205717676, 0.15147766156536413, -0.07715618614014054, 0.5474959802868133, -0.28911422493021965, -0.22326746600166517, 0.5360136028145743, 0.29745177383387766, 0.04814576418144547, -0.14086580202015236, 0.42409082463209424, -0.2787211493943152, 0.27435001839746564, 0.5224503406389407, 0.47770914110148455, 0.4236454373949888, -0.007571903812306303, -0.13318294290008123, -0.29245736235018793, 0.003156714103604869, 0.13241282793919745, -0.200067764319848, 0.05369918640258197, -0.19484756958643795, -0.05792614964667699, -0.1717308968340769, -0.10569841976685936, 0.049755574234016275, -0.2615325696465569, -0.0029866532802724738, 0.05857956245231633, 0.30191637359093526, 0.20205068825521702, 0.06508144090140855, 0.09211143309076744, 0.22210689920339766, 0.11841747573323844, -0.03334076203740255, 0.10137471231022248, -0.0743208331439204, 0.07136740673433564, 0.4498682901875017, -0.20510258265330328, 0.1279320634565615, 0.24094222882694655, 0.05366616825816454, -0.42261889989126444, 0.11104954895652076, -0.19571470793491136, 0.09582013711248816, 0.15102607033547463},
    {-0.08532603530677868, 0.032855597338464694, -0.19209453036719681, -0.4452032778757871, 0.463754372402642, -0.1451450335754897, -0.03156154604427412, 0.1112841878072306, -0.3489286242521409, -0.02513140201553593, 0.17806797696474985, 0.678968624431407, 0.5164994924902703, -0.1785881653682977, 0.17482220575720353, 0.13037334609800053, 0.370486110223606, -0.2624685294751287, -0.4694874400517532, 0.35315236620700796, -0.1306983775212464, -0.17075129161722077, 0.4330856043251807, 0.38610085263086147, 0.2067362356134663, 0.06079623459882142, 0.36493119667258284, 0.6534381336150066, -0.1455771721636523, 0.05337155278760391, -0.10963516377799129, -0.33353759456941817, 0.3763896074170525, 0.3449461114492439, 0.10691587587155153, 0.15661102967770504, -0.10412308474608559, -0.27599908174550875, 0.19854100220211612, 0.15233745661234968, 0.008141471640920469, -0.1876576941843505, -0.18389679238595238, 0.29526908412106856, 0.24683242209193154, 0.2669122423819904, 0.3500804147745029, -0.04898332233039465, 0.521123065360465, 0.547176716338711, 0.5458164315109396, 0.061990881321690366, -0.19747747890989015, 0.12221580049682078, -0.045646332500284076, -0.23099212893809462, 0.09428693170294895, 0.6307088240210008, -0.2728266598300178, 0.16180428201116742, 0.3851207743314212, -0.010952832714488178, -0.2081651385282084, 0.18457231433313076},
    {-0.13758934048607044, -0.048674561828690094, -0.555708814028902, -0.32901240168294954, 0.2509229492202374, -0.22597961079458492, 0.03291014620052107, -0.07488554819333823, -0.6719769163784953, 0.07572279697744566, -0.15256570955565255, -0.1486899910318129, 0.1457419828400834, -0.3022529440759629, 0.06379633966652633, -0.2867970166753674, 0.5804095191158916, 0.1467016600734238, -0.07892720724344503, -0.09551845207776535, -0.44846144439824603, 0.17653621186295007, 0.1387130489559433, -0.07713299345904936, 0.5834086581965053, 0.14807653646683405, 0.19897780895281636, -0.5046548891008616, 0.045157345569127455, -0.16726794694008443, -0.1094125571597179, 0.20548775933329505, -0.010310503990684419, -0.028264681816784848, -0.1662056652567746, 0.18101562945074948, -0.11043053097294946, -0.24243536933058007, -0.4308280440876476, -0.19766895445013016, -0.38236295749966126, -0.2298917627718963, -0.4540825749147184, 0.08017236825765503, -0.05495829701465707, -0.23565965815841605, 0.34235566764866104, -0.09743374510357106, -0.0578961536607249, -0.24733831697642558, 0.2695428319984334, 0.02720593102146889, -0.5698959814843223, -0.3646180444166141, -0.05920579295557142, 0.3071050572889933, -0.26591048798219963, 0.4888553915735925, -0.030730825256029874, 0.25092650718100035, -0.05356106033982966, -0.12043469610113457, -0.31617497518378723, -0.1845743608545644},
    {-0.18812233627705863, -0.2761117801250787, -0.35854187255760206, 0.0013807972295756315, -0.3134107193015163, -0.5603205655156549, -0.0830445416458728, 0.46092476796589904, 0.17318486289137242, 0.23610705333391727, 0.04224489613581895, -0.006231141043180627, -0.321511909756443, -0.38213734251016535, -0.13662678221786378, -0.31880258643665293, 0.7665846559875837, 0.12325590453589098, 0.25764046416868797, -0.32869195071538576, 0.055610149292215916, 0.08230455713954228, -0.4912291631354277, 0.13567224405562128, 0.3524108025731934, -0.416817799441736, 0.1341415956426653, -0.0574277353426827, -0.30173738125956656, 0.0963486110442522, 0.19583395642278908, 0.07587869856843862, -0.25460404498915307, 0.33643377671627384, 0.2645502809247386, 0.44713306085594834, -0.2071338416394885, -0.329591934332498, -0.30236407123586057, -0.33258009907144576, -0.14289295047087802, -0.0011322411384264383, -0.07571073642003359, -0.11774472679036099, -0.21982945761307, -0.03700098418040648, -0.5026923823412552, -0.052755795359355394, -0.3293470725452043, -0.38801257077038903, -0.11037248906696845, -0.3666265104536271, -0.031028932210630997, -0.2797547256032502, -0.09432480633726775, -0.05896944894291149, 0.18570677490192003, 0.2195066910776525, -0.13985369260172073, 0.07832944690082384, -0.27347718884454597, -0.10013872269014953, -0.134721065358464, 0.396481005500036},
    {-0.2559007395724892, -0.2492159748286073, 0.18556634487097687, -0.24872153267234093, -0.2860941897783195, 0.4739404513829654, 0.10193274677888786, 0.36291989281197157, 0.537033510879478, 0.03607642053006919, -0.6671964109068942, -0.3576698113655462, 0.13360181766979834, 0.2690190352771284, -0.04584621580876021, 0.010243665238294427, -0.18061011236381586, 0.35563452692898456, 0.4492415353102743, -0.08471756677824556, 0.0862640860897539, -0.026383001357355863, -0.20448042227336868, 0.21174808171605206, -0.20273376149655306, -0.047172399406933824, 0.04229804307113749, -0.36034149328613724, -0.13718030545235982, 0.05085706986650673, -0.36102408060604113, -0.40233991144922643, -0.32308320956110376, 0.4061384834285716, -0.04691862945230061, 0.08936638546448841, -0.002140244060309916, 0.1524709664061252, -0.2486089317452045, -0.0008125680052579807, 0.12405966483326697, -0.5354166860337886, 0.04470303996594463, -0.06681995255722636, -0.27885580594214365, 0.0004995653687982789, -0.16379693825503316, 0.11699425541798965, -0.08305431776407078, 0.053816323785986116, -0.1634516999684861, -0.302911066510307, 0.24422947625128483, -0.29809215555473545, -0.3938524386766327, 0.09347395455719597, -0.2558055313278234, -0.04426530043940279, -0.5831821917766835, 0.3024865955285761, -0.10986973665007956, -0.05198960423814347, 0.36146687394382215, 0.154866631268325},
    {-0.028209520492041448, -0.3552184912118266, 0.4641037993485549, -0.3283076808646278, -0.17222437561786552, 0.09423340013450676, 0.03148706837202024, 0.4132265151077024, 0.8099118991756032, 0.18075875356754023, -0.4814617611928071, 0.030337117097201625, 0.5341418084377589, -0.039839503545088494, 0.03240337462696002, 0.17129521750893859, -0.09159898755807544, 0.2969218755765151, 0.3363451628169691, 0.050929968943367536, -0.02353390231884082, -0.10391436821263243, -0.008823829027116325, -0.4569274591732941, -0.2663587445361101, 0.26558788297700187, -0.022962039157017777, -0.28442359362944125, 0.0003137293933953292, -0.13465979745483, 0.1977538956595541, 0.056562349514792665, 0.14159984483562055, 0.1767687662895929, -0.2992790584818137, -0.047284374396053167, 0.4887477754880672, 0.004221308168803559, 0.06694212550249548, 0.2586924898868923, -0.33418815257307294, -0.2576683764106507, 0.21486561968999046, -0.36794464053823384, -0.01254456315197189, 0.10672419803173089, -0.03791762754267292, 0.22061262973313817, -0.19257551692171915, 0.145338015894866, -0.169627389924252, 0.11199883864058627, 0.3348185319992087, 0.028796828637013463, -0.0635769211413673, -0.20770196191660054, -0.2145684944969047, 0.46624526223847707, -0.24952059977673158, -0.08519645419581207, -0.23949632742698052, 0.17244972505158648, -0.23842033084607053, 0.17530971792759223},
    {-0.11487658901805742, -0.759418501226857, 0.4480135545026718, 0.41962457149907556, 0.05001557387417962, 0.07368109246309935, 0.19017291939021302, -0.1466578291691854, 0.03304531568798451, 0.05293072095760484, 0.5027349022997911, 0.12699827808913683, -0.022877210752961036, 0.22763669344001117, 0.41993478448576493, -0.18906560721860582, 0.5968610337912365, 0.026732788805620026, 0.08974969092934794, 0.40532374960431566, -0.3817291196385765, -0.2633889828828561, -0.03983350143786524, 0.06988609585851022, -0.13382554766592278, -0.14215258946136167, 0.2887728950045143, 0.0896969785061226, -0.22043283762889954, 0.06529800673641702, -0.16946370669787583, 0.21889513156975018, 0.4482226538119689, -0.2046137471882851, -0.35778013323813634, 0.24185742271899008, -0.08290829159463713, 0.08147804247248985, 0.38079366179352103, -0.08775840254316772, -0.06812421655321539, 0.5395579261249627, 0.07765753635564504, 0.26174094086997257, 0.001996101170384167, 0.02624124821016124, 0.2648707991882852, 0.2965208648356008, -0.3411511187457907, 0.1838470620590861, -0.1616661882840411, -0.19810812160992586, -0.000121580524657966, -0.3209286471953588, 0.04214103211666561, -0.09309408336666339, -0.10017481994561846, 0.09988236729301588, -0.021921250200159035, -0.6291222569992335, -0.1887592172347905, 0.505360993057845, 0.054039887460071656, 0.2539238749866104},
    {-0.42857041450323585, 0.07692559477611184, 0.3542921686718911, 0.11613630371014252, -0.030725602322339778, -0.28890118426631173, -0.13589762180848936, -0.2770185335560726, -0.16429294962079785, 0.035653904111968594, 0.22463433152011586, 0.2155303994763481, 0.002950718812615178, -0.02045367985070382, 0.47972148782261104, 0.49569175060757537, 0.41238708989578404, 0.19917392723848312, -0.1379735636435829, 0.012941290789877526, 0.13955531142857655, -0.03060655026977437, -0.3076946354190777, -0.11134325839573572, 0.59902535710116, 0.22922491469242057, -0.014195424655050254, -0.030980431389464668, -0.14144028672407524, 0.014031529222417983, -0.14157396375335762, 0.26517261775786405, -0.21957793529579783, 0.16292721713940012, 0.4706755912921663, -0.02726925551967727, 0.22321716654315668, 0.00042129173623747036, 0.19585351838435044, 0.17921610296261473, 0.05785977859949344, 0.5397128190917964, 0.4054175621913183, 0.5772948353718835, 0.03384941767433073, 0.09708771379696844, -0.11466035856596907, 0.1875617633790066, -0.21739159251922596, 0.6178933669418306, 0.10389167963902436, -0.27696933414071245, 0.2642010566837866, 0.0593554218379462, 0.23849887669092149, 0.08414025601994153, -0.45142135937468225, -0.4467232560417921, 0.3577920351326262, 0.006551229850317007, -0.09979045382365476, 0.0752745975169153, 0.1568368930668295, 0.270559179561804},
    {0.2849281835636295, 0.21296880990214823, -0.516810640754572, 0.21883341126375735, -0.04021795681196632, -0.12125384626787318, 0.029331991248012643, 0.26091519343189595, -0.22462072958456544, 0.1265639812743017, -0.11733845848438336, 0.3084760554505035, -0.18461550543891692, 0.0041589317250349525, 0.14352562374635025, -0.10814374998261837, 0.18674538866638932, -0.698576556504728, 0.24053148103242472, -0.16038654515095152, 0.1581531291371488, 0.08706263233977483, 0.05324608841374261, 0.029253359936205686, -0.3161713489574064, -0.07025394091982272, -0.6619280586869569, 0.07698173891867767, 0.13712527413405806, -0.1971277033379538, 0.4294590803679945, 0.19332019545769394, -0.3956356343923708, -0.31926021888675754, -0.14984715435720342, -0.2633199093253126, -0.18866591588773024, -0.135232923163171, 0.020034902843470013, 0.08725846333221349, -0.1937895796051165, 0.042245085893080216, 0.2502129669685952, -0.310394285461248, -0.05848599967018296, -0.06475004243392565, -0.32263366818162553, -0.34373004698564885, 0.594460214699695, 0.19311951047336068, 0.27142568469769957, 0.0878653498263629, 0.4700402377301306, 0.007906401678062029, 0.11781261415579244, -0.2250462155861539, -0.3604312214723125, -0.24346273064223792, -0.39524654352195393, 0.24218840493648486, 0.24716038091321235, -0.6775717621638315, -0.65910005138781, -0.2903145807176373},
    {-0.14327646674598518, 0.28006373134683055, -0.12023879670923884, 0.15574178733298388, 0.24626718850953838, -0.37326662593461296, -0.08917966335272835, 0.45905254342814444, 0.14823259161843286, -0.2657465151077359, 0.3930364269870397, 0.7125065440865945, -0.41769322335027986, 0.12238469949441655, -0.004419315230782548, -0.35086585264797737, -0.3634124808363771, -0.33075499165365935, -0.5069473637174289, 0.011743205618678781, 0.2566762322955432, 0.1717424405312604, 0.02149939832629052, 0.1791114199935179, -0.03408655272803807, -0.41835303816501257, -0.07952343737610415, 0.2418119238825661, 0.021870223808270525, 0.032864899112987005, 0.05821341427030975, 0.6453520114922362, 0.2506461270723518, -0.24467042734110905, -0.05118356106214298, -0.35816270290092317, 0.4413260242043141, 0.3040368719176499, 0.025044612226522274, 0.09094956710752221, -0.23036814380699105, -0.026390260430220535, 0.14031820074800397, -0.6249049177847231, -0.07805647933098327, -0.17252855223653069, 0.3211850120905145, -0.07707885747047817, -0.011236583886220626, 0.2650717382291859, 0.223553103663018, -0.09794878702212423, -0.7096383996475324, -0.10397438414611956, -0.4459174275471072, 0.1277277149458627, -0.4263869014553599, 0.15536807784755213, -0.1353870260121043, -0.008373725808283319, 0.09196355923062068, -0.09040761783740081, 0.10813353666188921, -0.11553804632664144},
    {0.09746707394070502, 0.03677311535107704, 0.06075443628025454, -0.34587052417356845, -0.19321569105151462, 0.026076794690781963, 0.04312276728369726, 0.293381119965392, 0.6228374189970526, 0.16870159856492248, 0.21929208158388497, -0.2264356455273507, -0.07046523695532529, -0.03350799315416749, -0.32542726692112584, 0.27077347043903927, 0.44912138067053303, 0.265725726529197, -0.11246143828318521, -0.10814924017466038, -0.05505047743745569, -0.026432076249409076, -0.25155703144007946, -0.08165320522499336, 0.3863342570491716, -0.11859675382192886, 0.056714595131448865, 0.25480368588552194, -0.24370908331697608, 0.09704149880493193, 0.08548039841071024, 0.30642270406833966, 0.04271264744261779, 0.2901114222770216, 0.940956157446324, 0.020396283699262673, 0.20187414764966796, 0.4984065453994387, 0.30924062637769234, -0.2178614269719525, 0.07944419826529943, -0.2429409853418267, -0.04871575151104942, -0.5580112129992683, 0.2299756588446091, -0.10199939460252314, -0.3309198001662692, 0.03925867877797624, 0.03132235922357451, -0.08250337554170269, -0.08395229556660541, 0.027925865816937012, -0.8373520769488506, 0.6705587079265759, 0.05410440533705302, 0.5014977620734773, -0.22985892286575915, 0.31983915791005024, 0.05623490523840502, 0.42151967158903014, -0.24890571524888566, -0.0003319239725493648, -0.25703023023635513, 0.07281503218121443},
    {0.20846898475986703, -0.16752087667624435, -0.012374095349833143, 0.025331901555950675, 0.3147366756244163, -0.039482926305407756, -0.04912402239697847, -0.21024109532210222, -0.24279626598193535, 0.07253725572492938, 0.07137691681438937, -0.2792517043282363, 0.00030579999751631596, -0.3454131576070964, -0.0531324624236835, -0.28276218926810937, -0.4282239987088987, -0.13045873281049625, 0.03249204846907925, -0.1316178906577949, -0.34463802965322515, 0.2248968620506538, -0.3216816886008688, 0.1519843826723245, 0.10518172062657838, -0.16436017760470836, -0.04800682710415468, -0.4898342494469049, 0.277526382414887, 0.2956536987542041, -0.021070507635858517, 0.034486489120586855, -0.5632360629683275, 0.3589307977860844, 0.027787938661859506, -0.016827707770100397, -0.007923861326878173, 0.10228661500640598, -0.2846326292614614, -0.2693100218992093, -0.28572940685626474, 0.20933283698836896, -0.22023170133212205, -0.15599240407126203, -0.38500629691045446, -0.13596625147992594, 0.46384344315981285, -0.012683251369709747, 0.3967770177074381, -0.10632678305726165, -0.34441610355401253, 0.204133283606312, -0.6343087200125748, 0.239215870358691, -0.061027230599890146, -0.433666681759934, 0.004384443201242534, -0.37094266628080164, 0.13763002371169553, 0.5133159118541863, -0.1466547669499206, 0.15498048960628766, 0.16815148197816618, 0.14903406353426654},
    {0.1854237076734215, 0.13623711606950614, 0.19713799725891681, -0.22148702271101747, -0.0667411039151638, 0.10436291276921422, -0.20465415813725463, 0.028207029845643217, 0.30566400838807906, -0.009002593276685525, 0.01965609566914862, -0.4339889095049421, 0.3104637840013384, -0.5858077202357888, 0.2843950310650258, -0.16523434919863553, 0.3035660031122646, -0.2618415527766048, -0.5339058729851864, -0.06002034701223261, -0.19583524996653287, -0.6205791104171412, -0.19193636946459053, 0.2003148919345086, -0.20320247761875096, 0.009168907124984615, -0.16928050375475706, -0.38252755582594183, 0.2554339946941802, 0.13416498624834255, 0.32058381105691475, -0.013467833165767199, 0.21110506836290813, 0.0925263487081425, -0.34381001592560856, -0.1813391553206985, -0.24232471643148792, -0.1796255196473191, -0.1490559355029555, -0.15439403929144171, 0.1511513478316787, 0.030911760099652113, 0.2704802637778481, 0.5665641395201662, 0.08073372482339229, -0.06813095324457012, 0.19650053687095653, 0.17731965955697185, 0.1919132196480333, 0.3447705388843945, 0.08414150708306528, 0.10283116791429923, 0.1062780805853388, 0.21133036931853802, 0.49173969541292345, -0.24934518455279325, 0.09229826488110839, -0.24590787476513865, -0.5312796903565107, -0.3526804447984583, -0.044846586789089045, -0.09544692369013069, -0.2079131319971961, 0.44219316933894776},
    {0.0030154381263237493, 0.3023090490720019, -0.1101999752082132, -0.012016314905152202, 0.04947932536733895, 0.15273726126338485, -0.0018014631973498525, 0.14839853505804018, 0.5530877773467934, 0.07352393279541407, 0.3844295034442361, -0.058442420682568684, 0.37435861717936114, 0.15099896464571377, -0.24239019554988167, 0.29483313942060635, -0.028465146528959068, 0.2917553768864374, 0.00789211492161598, 0.5088876792609199, 0.20513460273305473, -0.5141720519565938, -0.02978003726891376, -0.24087825743514513, -0.4223409842899466, 0.6595126750083877, 0.24012667776766844, 0.3687852938335728, 0.16271403091118317, 0.17370431827589788, 0.14083596167044668, -0.3790951372673948, 0.4748938736230467, 0.36993447834118715, 0.05774968056032401, -0.6870025136792203, 0.10363317687025426, 0.19922350013153517, -0.6195752873850626, 0.4134989928283562, -0.13580096684942053, -0.37187866650393364, -0.22034897598735798, 0.36363709985444764, 0.19565391296594845, 0.5446080790452854, -0.17393555396918303, 0.09201214075715301, 0.0898934557660387, 0.11047072918923265, -0.009301509967599143, 0.07536958321450686, 0.30085894422967946, -0.08156210941546255, 0.20756079682427414, 0.06750119419647022, -0.5550848213649654, -0.05533622913133056, 0.13537964056267882, 0.1674175465655224, 0.16119508969401017, -0.032852084270164644, 0.5146287975820423, 0.28915794161640984},
    {0.20695838401423103, 0.282915008646575, -0.2309149747937436, -0.023850970848359045, -0.3021186613887379, -0.3122055492845793, -0.3407513590601354, -0.03043110900200064, -0.5226750954291225, -0.39699013758752794, -0.45318924038802155, 0.15256460347273124, -0.1580800991062615, 0.7905973488853111, 0.3699199047696329, 0.4682167590046275, 0.1813652055909143, -0.14697885754326157, -0.19614228947768766, -0.06340039509030802, 0.09576769929090487, 0.3782529747925422, 0.4113044428720996, -0.8724637619345069, 0.02099091014327332, 0.26192499548394416, 0.11547106381193692, 0.14771226963758552, -0.1452594603191782, -0.5120477158851757, -0.2704482963850445, -0.2097333538915767, -0.33470334885704317, -0.10614682712794217, 0.023761605724444315, -0.3117891533986505, -0.43705376019862124, 0.23703980199830857, -0.3725116220650672, -0.03837994651509951, -0.23750055347536098, -0.12912297494927416, -0.38448103221788904, -0.07711269886999704, -0.22803658917133193, -0.027940857131375788, -0.2807073728198982, -0.04029742854059341, 0.28605235813957813, 0.13869588138779496, -0.43003331894942204, -0.27311430887881105, 0.07266445491041382, -0.4755688381990242, -0.7168420963706347, -0.21255266765572456, 0.2397796184456948, -0.21964168822799823, -0.19471742692354665, 0.04856083627223485, -0.09970823983691775, -0.3002837880349499, 0.2273723483113455, -0.060506939776991495},
    {-0.11547993318609269, -0.30574407647154805, 0.3355144366178839, -0.2900329639854708, -0.20256570141339647, -0.4242371164482266, -0.1859589664302826, -0.312652431091396, -0.047380214881529284, 0.4852738227009601, -0.4310635017659153, -0.34492632687245484, -0.28240365041547816, 0.03239773610106089, 0.3649557745067797, -0.2937999381231687, -0.4173616571780404, 0.10862527523763452, 0.33789599060125686, -0.12443094098724587, 0.19120172302235527, 0.4011097211694407, 0.03858333085243674, 0.4954822633363592, -0.07805955806233542, -0.24352970749909172, 0.007121656342241642, -0.4579734233903333, -0.08419193185187432, -0.024948417380915938, -0.017000994182439, 0.4194539046455361, 0.037249360590161054, 0.10277203105984166, -0.0037963358145462495, 0.020732941902358894, -0.508343882707223, -0.04587033043602446, 0.023393048096212597, -0.33658009101152553, -0.3918235619511076, -0.17190356218706562, -0.01963143666526738, 0.2346859891464127, -0.22330360771439867, 0.12665503521522362, 0.11076727954791701, -0.14415066171852364, -0.5935307595511965, -0.4603404722066677, 0.09660390464760577, 0.4853213357566862, -0.13074161515369934, -0.0284603018561805, -0.1058898030452833, 0.210489531419177, 0.24954385669395154, 0.6417977410832929, -0.06203088561555047, -0.1568180631815025, 0.47184630434301006, 0.3184447420465503, 0.14072561709988257, -0.3374488892691865},
    {0.48187368629864286, -0.32463353622351004, -0.3832721688408228, -0.5943933569496217, 0.19258502880029615, 0.21189945136438734, -0.02623607494744606, -0.40076177088123366, 0.03675161108729101, 0.15234119321932632, -0.017551615429531566, -0.2950511357953195, -0.17259101042968214, 0.04510260199445699, -0.09953598746035673, -0.35665786527089366, -0.5262743776088178, -0.09236061213585887, -0.26637910044045515, -0.13648753237576947, -0.26807524860972815, 0.03846338292776552, 0.041047644325771064, -0.09311058628396238, 0.169578918419997, 0.2567410607312525, -0.006559694499776341, 0.10081155565965667, -0.36895515946437113, 0.40109204055633824, -0.27229913627355984, 0.253509579456586, 0.6063340905718688, 0.3038288466506729, -0.4874910849144075, 0.2539081937421349, 0.20743469372586906, 0.15192519371799082, -0.05525836321470644, 0.2577853050629018, -0.3436040857755875, 0.3799057837865906, -0.6011722569232818, 0.26423762150708047, -0.027827152205199088, 0.006492890545146234, -0.5433292616317767, 0.15396529345142393, -0.15576343440310395, 0.018875232270831942, -0.09738287723438747, -0.18161522032742586, -0.010418879919180385, 0.012605959791346077, 0.05414245104620125, -0.39346144213457035, 0.21796919000031148, 0.17194228536278608, 0.2536148104027274, -0.07740561513701387, 0.5892616469009558, 0.18062821303743196, -0.22817863314922568, 0.046118570838349054},
    {0.10193919973795589, 0.13985245571884145, -0.1647390316953564, 0.13524142841652895, -0.2975321203321113, 0.036008405970319915, 0.01133938470313277, 0.4066405290148994, 0.0673820657695583, 0.47695974784795275, -0.15625923358061453, -0.23479991601869138, -0.23224292608753788, 0.3650454147021789, -0.699406840420333, -0.3839551111738896, 0.4557563818910335, -0.23543453563031333, -0.2216934029139887, -0.13284250227260455, 0.09610928683566104, 0.5535058040650135, -0.07171434612093362, -0.04683515077337795, 0.08077096943307337, 0.18745458326978645, -0.4638607818863867, 0.18756378172026142, -0.03943730481861884, 0.05746198892957668, -0.5986033734165112, 0.09829038315204619, -0.1492657147423772, -0.46187159575615333, -0.03984769982378555, 0.16942291916879007, 0.018162077707274214, -0.3518234510367866, -0.023284066037817876, -0.28068160571712936, -0.13358970763929257, -0.20681005670484015, -0.05062755841783421, 0.17779031601830475, 0.05864113069757949, -0.5452544812944532, -0.15419264617051215, 0.05992763465368825, 0.047238230404975545, -0.02943064468602772, -0.3284987415077473, -0.05122254679044015, 0.23651205894377653, 0.4682000192165468, -0.24901208091780203, -0.06610540747388667, -0.2868818316220016, -0.6803113321824383, -0.1273837064074264, -0.5243648702775979, 0.06468009359425668, 0.028575924943328557, -0.4573622295622165, 0.06713476264248971},
    {-0.31588695287474244, -0.24888174977601768, -0.24545169430507002, 0.06337340680656844, -0.15536017598621496, -0.2082905267050997, 0.1434955599059388, -0.26775185566438603, -0.04695528974310983, 0.28152050308353127, -0.12166007556892294, -0.08158141460134767, 0.044522578643638636, -0.025135484975403917, 0.110098741383025, -0.15085596386941913, 0.08452375801207196, -0.6174930840828057, 0.45446021762893357, -0.12487657027903042, 0.27479815496502347, -0.3070741887205763, -0.12081205661059871, 0.01848096064306866, -0.39175070926127414, -0.2225200074605148, 0.15629936122309274, 0.11080947107707854, 0.3022093487133768, 0.2491772392408414, -0.5065356962696591, -0.17237430715621782, 0.11846137714495757, 0.04348759214078941, -0.0007721038695005747, 0.15913070034833665, -0.13868672923574205, -0.1467184204679521, 0.23495404590371924, -0.15986959953339758, -0.05785975005887307, 0.1149151883315368, 0.2175490806085003, -0.2481684876715857, 0.11206347879844895, -0.23216017972193892, 0.11765718975582971, 0.11999350616438552, -0.015526275302589444, -0.12303761044578668, 0.4503015775939312, -0.024473921829705234, -0.3576790576009551, 0.4227175831331896, -0.03702438717310303, -0.030835833618157546, -0.03227582874046641, -0.1711976850189872, -0.3979276579095084, -0.5135203950036576, 0.1535413109334759, -0.12454637503618024, -0.06465027467732314, -0.1517864142296737},
    {-0.5703929882531016, 0.26685298758095793, -0.12356503999392646, 0.4572908203519072, 0.4733843296036218, -0.02797071392158934, 0.5073208036295731, -0.2361938426668797, -0.15057351183969336, -0.37063439693777217, 0.29450716270240057, 0.11507648989989096, 0.5250689320418355, -0.28749061864307224, -0.41109672676847925, -0.13053098589089263, -0.07770898018896863, -0.09137933989486978, -0.43099990386719805, -0.25906128917611126, 0.13212468164110566, 0.26306935149418764, -0.6853742306894381, -0.14319995690126316, -0.29402203670012594, -0.3151476356161577, 0.18728949602475767, 0.26984793321703404, 0.12828178507163246, -0.14591458746811656, 0.037484423206209615, 0.18569911862146146, 0.19281882998925318, -0.010923268012072308, -0.6190120030649772, 0.01023696738918717, -0.12308190921107502, 0.017488955507165078, 0.0879348967010306, 0.14728873697720893, 0.47810069739052036, -0.013859758272909408, -0.46870415520523034, 0.012694954539738129, -0.217571712468347, 0.5011000763772006, -0.1081956013511122, 0.4281126132088474, -0.028229512687160147, -0.1619173266596973, -0.10420885724040257, -0.07622200518207024, 0.2574154735638295, -0.21327734730873127, -0.15714194676616886, 0.02595750590653418, -0.4507936678947325, 0.23800913865686363, 0.32654018468030466, -0.398421475621047, -0.23784991524667043, -0.4645840365432197, 0.028311873084981738, 0.2133643656054284},
    {0.4287145204466806, -0.3331590477549511, -0.09764867409669814, 0.2920812507209813, 0.11235489804022127, -0.3050593785059591, -0.08894432174263779, -0.07367784286650222, 0.011444799292249331, -0.3331184443214932, -0.42560827467728113, 0.039517102114345545, 0.05311598325390883, -0.03278257236667573, 0.14423388824827968, 0.20651404544341104, 0.09483755068866388, 0.29035516075551704, 0.32300733902147977, 0.03650473823397983, 0.3900770685059949, 0.1774667201672576, 0.10500809276004242, 0.4873107696925323, 0.05172963118574419, 0.1353097167493632, 0.17314618485604247, -0.24812154226684685, -0.03168403151689265, 0.11254120082666298, -0.27327598803722986, 0.2716231055485375, -0.3339174566565919, 0.0198109600444083, 0.08574223095029967, -0.11456091362536724, -0.26055430427975174, -0.5466953784713176, 0.3231497503307666, -0.010582906318556306, 0.1238490888730557, -0.09594708731294459, -0.28120868040736724, 0.23993720006253055, 0.07096545022383344, -0.23608308607260955, -0.250854134275523, 0.3081277565638937, -0.17218835303046068, -0.06939384284576905, -0.17957772808524683, 0.12733125073877335, -0.1752660253443533, -0.23544333883352644, 0.3626104500008448, -0.26989835299595455, -0.46813400315935544, 0.16829360025702625, -0.10481511058362183, 0.07927101759487276, 0.3267088438405993, 0.010432605076645033, -0.06206744787856612, 0.31837900177081},
    {-0.07809912240077636, 0.05191719477607264, 0.36039076712326434, 0.1737198779916889, -0.3324844617874843, -0.35080869933220643, 0.11662795473529096, -0.22184624839706846, -0.20736077229987687, -0.601827265569351, -0.37995412916275567, 0.3721223581821262, -0.1954486043201976, -0.08354668254676574, 0.17914288979214446, 0.30229785843021434, -0.33896214681163306, 0.3331394634865423, 0.20669910819905415, 0.025466926332122993, -0.0763409875740391, -0.23001999631250258, 0.09212961678636881, 0.02496986773796551, -0.03326939727803559, 0.13022993855121967, 0.0679288829343924, -0.24852697729786902, 0.11241436567035998, -0.3712422273377643, -0.38432858111957, -0.38991867983933876, -0.21596161375651007, 0.12330569220379733, 0.013927364506717091, -0.5079163826432692, 0.2672094923546463, 0.0733826177636088, 0.31444893077395153, -0.29221863795780306, 0.043972526044591155, -0.04642200178985206, -0.04340577048522024, 0.32439744248855373, 0.090716625420488, 0.4132655867214385, 0.22259883770761785, 0.5525017151018643, -0.5150054362822888, -0.29601415636847495, -0.28026949913593296, 0.4081085667110454, -0.09120016119000238, 0.26327369402683914, -0.3720017672596626, -0.026885400760353794, 0.1854519041287439, 0.2826396912066676, 0.25469867167910315, 0.13021509155052613, -0.27857691362032183, -0.12947848650197924, 0.3258232307491805, 0.1356078836735179},
    {-0.25877183843108137, 0.39203766983408267, -0.10032287496139067, 0.39285645904400224, 0.17772382230462383, 0.27407780387999914, -0.018587559172746283, -0.21832194493109386, -0.004005654579022155, -0.10710610431600928, -0.21700304101824103, 0.4384170542511717, 0.08996518380699377, 0.3851745943467325, -0.3397341236725666, 0.2158767531070949, 0.17817340650517516, 0.05589477436650261, -0.008407764750007048, 0.036743266813141905, -0.09572620364474635, 0.22348260717270935, -0.4383315296893485, -0.08035467236848286, 0.11384283181294408, -0.09822661641445474, 0.29752964583746744, 0.00991310284062823, 0.14026782183518519, -0.13759536578752193, 0.047557411878224536, -0.5096686712030359, 0.24806605223034897, -0.2462020419986175, 0.3159751399481327, -0.6044688889115417, 0.47425434662905147, 0.13349754953465223, -0.046632399468153396, -0.35967255794748315, 0.04714376079447106, 0.1162236018517336, -0.12865633730257178, -0.327451805506504, 0.38372881841086137, -0.29890211849186044, 0.11761069624910199, 0.046911662842913045, 0.32063816534319683, -0.04943295868326912, -0.297617092351225, 0.22041993589910708, 0.04497425381944953, -0.3208622728502083, -0.37821746784326055, -0.10039683745184441, 0.11898843060643398, -0.010182806306625002, 0.16990108701908463, 0.24836782600393312, 0.07216071702864614, 0.19816180838526679, 0.054815470992398675, -0.26067959800306056},
    {0.0833864297771449, 0.17170867781848376, -0.37399616549956444, -0.30811717837190217, -0.2660648446818435, -0.3707486192628226, -0.586547103660614, 0.14746108947839245, -0.23316467768298813, 0.007109465605111506, 0.5444847979157155, 0.3177212050432219, 0.3046858483612656, -0.08416083276043744, -0.5990344148651846, -0.2622643621751324, 0.32866145720082973, -0.548992748561407, 0.14296774322331599, -0.09492497886935186, -0.33027551988362064, 0.06399459480857757, 0.11486803657322799, -0.39299768366278587, -0.1318903375341505, 0.00923929168938262, -0.23077177739147225, -0.02736510792287368, 0.1641775911336528, 0.18719018726468714, 0.0041920867589083565, -0.43441079406469624, -0.10644913529169438, -0.15887085524220257, -0.2142850230688924, -0.06545560837191298, 0.02535818238417294, -0.383693036670565, 0.36427440391556504, -0.027809872706731215, 0.18236035399463188, 0.45169085539410986, -0.1789200246224231, -0.21200341213220453, 0.04292156038405808, -0.0678354475436295, -0.19038955595630447, 0.0714454433069678, -0.15671028544807625, -0.2159271178746767, 0.3828712403603405, 0.1106409493208264, 0.49741246487862956, -0.08247120981471127, -0.10439076546777758, -0.038239131665202514, 0.5023981040923118, -0.20595769034575798, -0.062394173464482075, 0.06925764819466812, -0.20990607492966876, -0.004339908024078848, -0.097851788375504, -0.2768083033438502},
    {0.2710885860085263, -0.06623041033322352, -0.13208099011204183, 0.041152089048194875, 0.29542779708776457, -0.11736889983783355, -0.49927842425155355, -0.2435372541430648, 0.4779146706321777, -0.287514391225973, 0.6418866398969378, -0.06884294437203194, 0.23814785035565286, -0.025692215325053152, -0.14104386435044478, 0.0047601869352912095, -0.36937335620534334, 0.5336219568208982, -0.05716673296113778, 0.493991477489771, 0.4825431504766577, -0.4045559764205329, -0.0380398592266609, -0.42876481004437816, -0.33815338408982343, 0.293194901701286, 0.27824642005857886, 0.010244086605780515, 0.11798395369606324, 0.0781644655776147, 0.26924925362966073, 0.22480334161869286, -0.08079057267853618, -0.11215867778049363, -0.5189709015814394, 0.10678678376832945, -0.10755956039668076, -0.22960127108158424, 0.22624365131519616, 0.023795740080185097, -0.13930000824627656, 0.290676457878586, 0.022144551196957758, -0.047464959466150515, -0.14998881212907836, 0.10461296281373182, 0.14536312089250114, -0.19920775760805431, 0.2107541356639252, -0.12277806616215217, 0.5263592618572513, -0.3277924896062189, -0.6365920252616305, 0.026767116835015703, -0.012146150719247548, -0.345853178527305, -0.15710456021648195, -0.3002971953453123, -0.03885286124218116, -0.016434559656504377, -0.28895276245069446, -0.23475431480355494, 0.11900358248668007, 0.3876104402053222},
    {-0.18898788079672604, -0.4230157676455323, -0.5440436417478786, -0.4941360104861598, -0.5575565178580811, -0.5980980577123397, -0.555368279289004, -0.3743668632654694, -0.5188400469465493, 0.1335351836754472, 0.6275319482124809, 0.46812502943822354, -0.28814435728993076, -0.2643330529314283, 0.22745019930193608, 0.1739805647168872, 0.20178079317954756, 0.19743687083498077, -0.19989101189576108, 0.023590467149768656, -0.2768516165077158, -0.7884692283174878, -0.8073336034372621, -0.13675227701070633, 0.2696830174012639, -0.7356190551032374, 0.5864815241839331, -1.0889776164192233, -0.8257014528912873, -0.7499151617935946, 0.28999628718933207, -0.5548500931087245, -0.548690442755169, -0.9182914873492627, -0.40784326216084227, -0.3913485896907112, -0.8709662243831424, -0.029650698559373967, -0.900062570384617, -1.348671227498955, 0.22766273654046812, 0.17906925603540833, -0.17673272686894073, -0.2531129500487257, 0.3114732383405238, -0.7710551985243428, -0.24251640047247472, -0.6768039866086736, -1.0850427612184468, -0.3007316387858913, -0.7926542140984723, -0.05188335832064788, -0.14882072631211476, -0.5478758475560814, -0.4351999847099018, -0.22449493184788724, -0.18663644621387634, -0.9126554257984979, -0.0011110591188977876, -0.6152056705837338, -0.36043566128777305, -1.1358754277092755, -0.7519995703410032, 0.12434582766343026},
    {0.27622676434174803, -0.33442994931897224, -0.7454169141465455, -0.18153032278625153, -0.4898529213603196, -1.0257388255681343, -0.0059298748212411045, -0.4039192100678954, -0.4229410558207521, 0.6030325635854175, 0.5495800884876791, 0.8550908245128789, 0.4170942388566677, 0.09831563368602751, 0.5308131119969917, 0.8733593458097394, 0.28044221068007685, -0.23972608987170405, 0.7284103071009044, -0.16787570007782932, -0.3682953768709928, -0.42663392179707177, -0.689536817184652, -0.20719087125192034, 0.11326094105506929, -0.5858546659322246, 0.71960824515597, -0.838995427108299, -1.1133790268628114, -0.5217010093824586, 0.2311775328432093, -0.5911988299420057, -0.6198196933087893, -0.8556004952756336, 0.061918742549860115, 0.04235441821009592, -1.0506359243421761, 0.5131200759128168, -0.6912228211045558, -1.196862559215586, 0.5297450836749933, 0.7646379758879361, 0.06405765910532195, 0.39866375227379686, 0.5606284033742825, 0.5328015821612517, -0.23640520427337203, 0.24752951232823928, -0.9826834796797135, 0.1983044152854392, -0.7750880810762516, 0.4247958147983786, 0.6764774037814428, -0.3074190585030328, -0.7479565853479193, -0.700258091867677, 0.5294122830066895, -0.6719768943893563, 0.5918018231493227, -0.8147448185334082, -0.3683626549860114, -0.8550829642065292, -0.40661660415403983, 0.12949636364045172},
    {0.2021980571544584, -0.517634384550745, -0.36146814297884483, -0.2666924672746137, -0.6445487254550655, -0.10008673387561255, -0.528484238243417, -0.17258580060553158, -0.13349188784735797, 0.6826064684401353, 0.5368663555470431, 0.41318064654345704, -0.4810867468475417, -0.5801130494241661, 0.5764812133991093, -0.3603377470677058, -0.2664129911559667, 0.328067209679532, -0.13752008090805545, 0.021869312697798977, -0.18982557285459303, -0.5567862500857987, 0.0033476086670421257, 0.34216050216378313, -0.05660882941088641, -0.47858199656162315, 0.4771816196024583, -0.31492168142648114, -0.7334172059129632, -0.5807880101035868, 0.20764527143974473, 0.10659924079922241, 0.24091024175183434, -0.5322620550742457, -0.47085097042272034, -0.28252529581136226, -0.39008479160100806, -0.3328341044289488, -0.25793391492121204, -0.4217599080416229, 0.04473106931618598, -0.313111038155116, -0.9387017389579349, -0.02878544384272794, -0.13680872208107822, -0.4903796651033558, -0.25471685222632523, 0.08391457323940994, -0.09134857239486936, -0.15674375305090843, -0.4192873509259086, -0.08943329057749819, -0.7228405289139112, -0.6053861311512485, -0.139042950008504, 0.08072641224814739, -0.021336568350738952, -0.29547499615740486, -0.00456376826301638, -0.18913994750910648, -0.23589300635046717, -0.5088261011834664, -0.41736251010672937, 0.27101730540378444},
    {0.41420830348648957, -0.3497115236734823, -0.4567389342365895, -0.009705076923721677, 0.07386549473293087, -0.3117720903625209, -0.3208653395782489, 0.05017614236656577, 0.021769248094725715, 0.4731959687928886, 0.19976817712135148, 0.8526936023017164, -0.15343051518015657, -0.243221614381092, 0.719311243026367, -0.38886933680544084, 0.04426116787351444, 0.22263235454495675, -0.1151171965494167, 0.20841998022927763, -0.046025673455848265, -0.31003968208309335, -0.10199590036098433, 0.7182002346384693, -0.39718590869918213, -0.29003003418491324, 0.38263001195930646, -0.01648086838981864, -0.5780097967798375, -0.5234667494751277, 0.16182765002501218, 0.28876651692952765, -0.0013221313467732996, -0.6612588803933088, -0.10766443180005693, -0.41596777159015813, -0.6119219814262864, 0.17249910238515845, -0.5114015508886922, -0.26202378809473126, -0.07864301293669598, -0.236165735377727, 0.030311909884131013, 0.029462427225471682, -0.20893071924746728, -0.36373562326684805, -0.5764060587187866, -0.2855957881818086, -0.10616170619269451, -0.5866868749109513, 0.34411632809905623, -0.3662185634308922, -0.611010754304046, 0.0016946562410945704, -0.1687112373447254, 0.005288552373042141, -0.0462748654742273, -0.08132883769178753, -0.4556765562683194, 0.1611627064325051, 0.3891865564291914, -0.5808293118815654, -0.6161068993543666, 0.1497408694246872},
    {0.17316263764213508, -0.1553755290233238, -0.1618767055583054, -0.42757388710518024, 0.1363277800580168, 0.01845576563468731, 0.029230334229120105, -0.6228518420604907, 0.1962962763785675, 0.5877417381607718, 0.5124574460335715, 0.38829038539074967, 0.43854292677054424, -0.2884958229676905, 0.3496492244349734, 0.19195134072963024, 0.4043425030218994, 0.24363617080414426, 0.6215103879425022, -0.1341415706760342, -0.21513087643266995, 0.0038292501948911464, -0.2767852769225661, 0.24201446752678574, -0.03185515399090826, -0.054602950223751445, -0.13433684625733333, -0.24812762961138884, -0.6442762644520111, -0.17326217376398018, 0.4088994775338898, 0.20578219332892228, 0.20416366659901153, 0.1624753652958734, -0.1943225973943326, -0.2132918495469645, -0.41764108675869044, 0.07112962539658522, 0.04596169145053617, -0.5726417725661229, -0.12923449026605, -0.28324725071781043, -0.2453592997246839, -0.13186430479838407, -0.11714883991872609, -0.16937451291605737, -0.2229548354995894, -0.013431647466581553, 0.0732632626721127, -0.3135453402894798, -0.260745781190911, 0.38080114032698187, 0.21537156697771018, 0.035454212693790066, 0.16157801716839773, -0.1325279019245193, -0.5085141354405226, -0.20864374010833753, 0.23115444452617678, -0.43165383277940433, -0.07108222209109843, -0.4519737809445449, -0.039808560258017864, 0.1443054536933912},
    {-0.01371755866010007, 0.025686375381493647, -0.24039468688302376, 0.18888583258091543, -0.21093005613215993, -0.30652372487078156, -0.273176634847035, -0.1773763425219283, -0.3021050126697306, -0.2333829229072677, 0.4021302600524315, -0.036692817370408554, -0.7764809498482828, -0.6965704744352471, 0.31831064822030153, 0.47688118915121863, -0.1669313909408982, 0.14182414801599935, 0.18413158787504333, 0.3294353831779866, -0.28883455265760327, -0.7379813835279084, -0.35163522913044115, 0.18891418257919632, 0.022912760597131238, -0.186667868056488, -0.24234905096368375, -0.3635914371167894, -0.7360009679138555, -0.4795447813206123, 0.17618671094660737, 0.03197562993399002, -0.5336744518532773, -0.10812192390190087, 0.04236001981110012, -0.058595429869201514, -0.3497011104100553, 0.04136634265426337, -0.012496686681921242, -0.17630271467591008, -0.25906419644661055, 0.1480416622166127, -0.06230992026020227, -0.11073576229094853, 0.16480100669060962, -0.01938883026687648, -0.11887447328637073, 0.2133782820854527, -0.83546236482227, -0.5867288983116976, -0.5464203576515193, -0.16877679770235116, -0.21224397515740148, -0.24766492969684395, -0.10366954636745394, 0.4716975109161802, -0.5733450539193495, -0.654972736245221, 0.22698203747656517, -0.1939980394479766, 0.720477561071379, -0.4789713162928184, 0.15825893469605792, 0.03253613752259293},
    {-0.1789580700351153, -0.7905568946042619, -0.8046415305260639, -0.21000316705656996, -0.41808015691636213, -0.20637222189019114, -0.3350143480491627, 0.05963203761661092, 0.3517786099128253, 0.42086430915586254, 0.3389026874238577, 0.1956444188099884, -0.2067681199064395, -0.23047496728602068, 0.2710498771913922, 0.07957255863720084, 0.2563565064560302, 0.006550768588388665, 0.35161304427327855, 0.4733662001457809, -0.4246423043444483, -0.4150670047632589, -0.029096619357670904, 0.47360451365627626, -0.09828384429769335, 0.030385979978780838, 0.24238940648159216, 0.012630671706447907, -0.6562569851218323, -0.3970437031220321, 0.4513474505577502, 0.5281838547366562, 0.28045608532619404, -0.47378707601328685, -0.18307200054486988, 0.07717774386782983, -0.2800555291086203, 0.4576373114519271, -0.4425868135258621, -0.39280629847353055, 0.19701475850166764, -0.05576484792314838, -0.09990017332083537, -0.03090476427147196, -0.19438259805040034, 0.09126599265443641, -0.5131906209453242, 1.053903712099031, -0.46377108778647946, -0.3076923616157357, -0.6074777964826803, 0.18147202396021708, -0.7205032968287476, 0.00485801813605185, 0.24187580990387716, 0.04164695286829302, -0.2716722576625338, -0.7057668532217385, 0.1522821084198428, 0.05924478794288078, 0.539849158384881, -0.42383746774844905, -0.1606791660209122, 0.03902316499595863},
    {-0.5246109236992234, 0.1320249083434124, -0.3864753490901168, 0.06469373435117508, 0.05803724214250498, -0.3325320391658405, 0.6742166684892178, 0.4673637547490595, -0.00065945591234005, -0.40743378149676424, 0.3833180298677375, -0.04528723185088326, -0.3942335117896096, 0.20197603186763563, 0.576523337269202, 0.7714649922056974, -0.11200601006390959, 0.15722645207340066, -0.0964202632683023, 0.5322059049960889, 0.03937556584489433, 0.5829600546140954, -0.32848122198887186, -0.14784298216192387, 0.11677117334064445, 0.21899209917024146, -0.428754008030533, -0.18956688931038881, -0.09804981621367716, -0.024705138260249806, 0.19324680116154266, 0.4873631814446923, -0.6841100094464703, -0.5624434532419138, 0.5382124689344765, -0.37466369927331283, -0.29919205203290034, 0.1189134677682032, 0.05232290769337263, 0.0432579897547296, -0.30581881014920337, 0.44324278787190924, -0.22838384154327224, 0.09023952259514767, -0.09977217380892414, 0.21097017983497526, 0.3332291519899779, 0.5002098938962598, 0.35913289353800965, 0.5284549778009224, -0.4514604717051466, 0.7279682224918824, 0.10068723443266187, -0.3439707031565775, -0.14097871133083298, -0.3137139295830723, -0.029573129223087233, -0.11317379458144447, -0.0279563524473485, 0.2632260272838961, 0.4512770687547473, -0.4031090271334336, 0.2250736865961377, 0.43852609591696234},
    {-0.0316352397542872, -0.35220987436182866, 0.018397551241987702, 0.06707562098932347, -0.09939411738719559, -1.059490426319296, -0.3445997495952762, -0.40702707557205203, -0.2322291601551866, -0.33981344759484416, 0.44299401348629397, 0.2954310527392153, -0.14583132567629192, -0.24746309290392318, 0.9514345968573347, 0.016405885034973533, 0.08563333547778147, 0.10515243118650443, 0.41122760437795713, -0.09229551988621754, 0.4215362519013329, -0.33093054522903403, -0.24754153954116037, 0.09934712607458342, 0.5918865732848513, -0.3654077273106371, 0.5120403743750429, -0.16876119991818866, 0.059358117471335, 0.034783745454634245, 0.5297629867474718, -0.24190023605459693, -0.4436145236438887, -0.6235577083824134, 0.20377736706969096, -0.5085400327576671, -0.5177269898274438, 0.15569408876233334, -0.19557246027614741, -0.6927836689489393, 0.20354377400932883, 0.3285003442277822, 0.3441605661892094, 0.15544342160939567, 0.11055682548800394, 0.32576655292746737, 0.2386833773092123, 0.18963663414423326, 0.05719412854673837, 0.2584641398400664, -0.37588493447001226, 0.19517572031464728, 0.36612710433312595, -0.5854462409888707, -0.12702739741346047, 0.4571623168684181, -0.05267183144135309, -0.3929260421028377, 0.15982492139189078, -0.270704769247245, 0.1762072874121305, -0.4822396452979327, 0.20137437023883983, 0.08151589615556658},
    {0.6376413102336091, -0.015501606233297894, -0.2142902504626822, -0.32057084375987, -0.1804767240450055, -0.09378321037335517, -0.23921692479850207, -0.4890060479644154, 0.5290605743024902, -0.2092968274217644, -0.2695104177280782, 0.12413462909653347, -0.43278316753489476, -0.3692683271659198, 0.1116183066415261, 0.3537782155470031, 0.14325597249513877, -0.7917968283820247, -0.05724289470507999, 0.3784960372500045, 0.24127377145305787, -0.4499449002715266, 0.0839870827911676, -0.07008625574724002, 0.26235911700213554, -0.018739931380400476, 0.1493023464849669, -0.19016417499712907, -0.28845255745201215, -0.05555883064365522, 0.3338139468320323, -0.046523778808424544, -0.3736982797449666, -0.3089106532279932, 0.28279799990832494, 0.07039903004152653, 0.19347613827170834, 0.0512732284181026, -0.16715007121928319, -0.12293783968951791, -0.26544734832285355, -0.3911509816191813, -0.09176250809617446, -0.12934774885508418, 0.36902407824085337, -0.3574309404259326, -0.10456692719437037, -0.1921489239671608, -0.05676137769354749, -0.3729701816240215, -0.2916153983401368, 0.05526863965211324, -0.39272634652858873, -0.28581182330960914, -0.3282148745769785, -0.17650145930619562, 0.020458059611886556, 0.003536600077150889, 0.07246825673047315, 0.29245050317944465, 0.8485023065989508, 0.006152449889760124, -0.3878312139889933, -0.528600237033944},
    {0.4439914611000138, 0.1346218198342765, -0.5807190167088456, 0.4185304703289293, -0.4740960243736621, -0.47886929915081744, -0.6409215445212026, -0.1992339217022449, 0.34591607334615276, -0.2566107122001322, 0.2285492552459127, 0.062087657038471536, -0.34030526390890364, -0.2698768762376367, 0.1266810082350632, -0.3412904257365441, -0.12214253654407492, 0.3541114272707592, -0.23607869237392864, -0.1979684328937951, 0.282857719797223, -0.11286806022235712, -0.4795387506850145, 0.3381708074740045, -0.13621887042839115, 0.18417501042800535, -0.08433934592519832, -0.5713593397185073, -0.28375172205070437, 0.2308921758447952, -0.2921618974921406, 0.08850975639106308, -0.029545143296233468, -0.18789280440874864, 0.03284383510783777, 0.3407274203482633, -0.0924375176471925, -0.0755823894115264, -0.2862637810174166, -0.016214174724969097, 0.0934318369897451, -0.22660694612548907, 0.005206989237738213, 0.13797502722103827, 0.1424976509768154, 0.06586771412710409, -0.18309155215622136, 0.07557907569808253, -0.5066012562886315, -0.06475952301942607, -0.11801699433489776, -0.23604581198200728, -0.5494063851915786, -0.1660637478900627, -0.23842313375280996, -0.3697964349867619, 0.675202231677428, -0.2975784619455801, -0.12778416668183804, 0.06517296485607521, -0.5814315465091092, 0.02546007576831267, -0.09186557418119691, -0.12170254090677964},
    {0.7020531380466444, 0.2583920491726947, -0.3950598350860995, 0.17375261800620317, -0.34352888060301673, 0.1045372359803876, -0.5903241483991766, -0.3346961263795217, 0.10001283066728373, -0.09996972920615826, -0.05008764190377141, 0.1588419453614265, 0.0778594457260209, -0.050385605184092117, 0.457627737329889, 0.40552033275308924, -0.26262879239559445, 0.1943260725065336, -0.06638858515742684, -0.0021798740728326527, 0.047323385013157894, -0.48450899822702653, -0.015096686110169857, -0.2931962789142859, -0.2878767472161814, -0.3298611172141438, -0.04847496398754889, -0.3585566121747621, 0.06299648162197251, -0.43352051716877565, 0.15989407047855475, 0.38493936459922645, 0.029630539151462253, -0.7559328667013111, 0.02680106921429621, 0.5873403929526313, 0.11925329128278704, 0.5204365088931195, -0.45947839155960263, -0.23865391680475875, 0.42251466141845395, 0.2475464554916613, -0.2121905460473579, 0.3907185004364667, 0.2890865575931808, -0.08261864407939144, -0.33135239468173233, -0.5075232374502999, 0.011519635303288008, -0.11757316187030713, -0.454878105725284, -0.00638706720766634, 0.018528036743251472, 0.03076660458594287, 0.08161757370078065, -0.4684678908499255, 0.18615646949495343, 0.30479202384702997, 0.2070141487528796, -0.8917907289281403, 0.5166800558955458, -0.37249456574223566, 0.3452374352838696, -0.04933148615720157},
    {0.08578959962218484, -0.00011266809238606421, -0.4248824389702133, -0.00014027382491016007, 0.08628828584945272, -0.3913458830032979, 0.1567569713315693, 0.22466474678439735, 0.28296237512874856, -0.5125721398017252, 0.520574887389742, 0.513180554523806, -0.5575227951998796, 0.14587427951963158, 0.5619714784355297, -0.06199487172039309, 0.39077460742413506, -0.34734585685590647, 0.30941991423571974, 0.004594367505108546, 0.1620282397851514, -0.2159004091650141, 0.21625104871526094, -0.21425293077568233, -0.6202603971175419, 0.05691025584176396, 0.49919399640669565, 0.03379521658804374, 0.04592815043455601, -0.10307659714769712, -0.11803401093261254, 0.08252773945501031, -0.4061613904672867, -0.08119006446996434, -0.565376030268283, 0.6825134669865139, -0.2939447022259371, 0.011867542646435714, -0.32778042377221156, -0.2942482875903848, -0.08840457637945935, -0.2035344917214714, 0.16952754630573258, 0.5209231969270136, 0.3025179008895151, -0.5622979305601218, -0.6252982811507751, 0.2714440264964526, -0.37065304272523164, 0.011406712316033402, -0.013925591917624096, 0.11759798940751467, -0.16941108491330858, -0.14234529986435132, -0.15672277141734023, -0.593615868034193, 0.14779756876639052, -0.09806359082528233, 0.39431108619704247, 0.15377254564090742, -0.0782388825629283, -0.47283579494932587, 0.21338000542838104, -0.22959079982514502},
    {0.039944387715628735, 0.09032265126582789, -0.3763802564577579, 0.1410498111044506, -0.014352424837888613, -0.16341367320858582, -0.36605301713727323, -0.3410475372427801, -0.00830911950896715, 0.06976910389032291, 0.2889506615727127, 0.2274089473115494, -0.24239256093118214, 0.27700913940803445, 0.22356473513286376, 0.3016388005988855, 0.3890906629186001, -0.2540574133702022, 0.13434542981770534, 0.0015257136776932374, -0.26873451446584984, -0.4561405153538354, 0.08998559541330761, 0.09918972041268703, 0.04791922774896432, -0.24016594118788162, 0.03153218731040258, -0.08823570531734377, 0.15798718016182373, -0.924928688169597, 0.060279888406455, -0.13274253221656515, -0.18981486521237148, -0.35753985083577455, -0.040138910653564695, -0.038295175375218045, -0.1921425435306353, 0.004069795744224535, -0.13213746892170852, -0.4311045885369787, 0.37684273622790976, 0.2381114002998478, -0.4574288052032588, -0.5734559793422741, 0.4199892177011877, 0.0805052372889673, -0.049422612176394744, 0.3020001901598338, 0.32458876666943803, -0.47513832471178097, 0.05701055171734489, -0.11610288603110867, 0.10807531364696427, -0.09704832192719902, 0.35182762243408877, -0.024903309120866985, 0.044081309556525554, 0.15647921482865051, -0.5314353899045954, -0.006434831203564824, 0.28677222306902267, 0.019571614251729475, -0.24674208381764942, 0.31570300545204694},
    {0.17110326727931113, -0.4008380297532735, 0.10823203982178241, 0.23177252781473132, -0.24159948553782876, -0.33650267954463786, 0.200176968109005, 0.26476085972699714, 0.04423418313883532, 0.10361270980898087, 0.4392234216731071, -0.18285240285056203, -0.09884768571486761, -0.021132805979242695, -0.06568158529679506, 0.019915474705892347, 0.5543267552072919, -0.1762560550224039, -0.2440063050268055, 0.021898800232450253, -0.28008834846189584, -0.020530661001735943, -0.5817852535136482, -0.15035577160398714, -0.23443904138980304, -0.347710633810703, 0.22776196016639588, 0.20321211693880975, -0.2664865480855509, 0.10463103120153977, 0.3161038699174241, 0.5907350567775249, -0.23394451744457392, -0.10348724763968048, 0.35147949278016727, -0.5266627063357217, -0.14195772827820313, 0.3069844338870858, 0.5350622897780357, -0.608153334340578, -0.19987078527940055, 0.5290849940692232, -0.3463412294128712, -0.7005623178310931, 0.4175349036684159, 0.013643208822338212, 0.7342070119400342, -0.12285098968976083, 0.45911323084951006, 0.2874371029672983, 0.2359223169489815, -0.014734303643052464, -0.26651151184365574, -0.17183655207464243, -0.0539249582927728, 0.6113710220669748, -0.005610379559263208, -0.21826686187950725, 0.5516985788091, -0.44866279319272745, 0.33048141714539564, 0.014630631385406113, 0.14483486114734112, -0.324025940567704},
    {0.06317647848813016, -0.16136262012592478, -0.4989167890281058, -0.39040817518213855, -0.45234095999166685, -0.658756279391697, -0.4488425074224893, -0.04864477240659287, -0.6707427030491897, 0.5283509909085072, 0.45947086921812197, 0.08383575953675693, -0.4700872784771185, -0.39333044011913176, -0.4237762877420961, 0.17871778732047827, -0.24846420980400685, -0.3429137477907646, -0.16883781453943247, -0.6940647179653586, 0.09405499572205336, 0.06642202030463996, -0.13528347144712188, -0.6618208049960262, 0.6955134201053705, -0.35519530483156997, 0.12649298722511687, -0.43504368131958193, -0.41344161768029813, -0.5837946604899104, 0.3717976190419052, -0.23865287965276402, -0.5847579888744655, -0.3967662597160954, 0.0701306922016952, 0.5208812667000984, -0.41708616502097495, 0.27501521171709703, 0.2530635552748336, -0.9054218172533786, -0.020258151134769645, -0.06588197103765872, 0.09336798818981006, 0.12786018952974812, 0.1534165977379523, 0.21189595063800437, 0.2760405781439466, 0.12171571356669753, 0.009576723768276207, 0.4610329015439417, 0.20888877974680137, -0.33183229560925553, -0.3352222597904517, -0.5533113911587987, -0.21385059994139888, -0.5722286189329873, 0.4802704997943281, -0.4650695378454549, -0.3695538325729164, -0.8803019158653553, 0.1754668018822906, -0.398685440613699, -0.7048237672367006, 0.19513781722354645},
    {-0.3109117374934642, 0.16645357931594282, -0.641146586925422, 0.5690612451182075, -0.2849287186986409, -0.26658309490687343, -0.18661596322295573, 0.02428233515363729, -0.24180153446999836, -0.0023293539607050157, -0.03808343161250503, -0.2524450567224002, 0.28477639831854507, 0.18046153148506988, 0.1672634472360601, 0.3868698773736503, -0.009231103041179524, -0.436763575628759, 0.27052920427485283, -0.25881432698138396, -0.8106510430889701, 0.37198219748216643, -0.38796490718047366, -0.07305814546188463, 0.3744478553711734, -0.5665456422152304, 0.12641342152647128, -0.16552439161231236, -0.7712902812541436, -0.3729504930784906, -0.2926078949748409, -0.3378286008525594, -0.19538357151620084, 0.07852459242180466, 0.40427247043109354, -0.06919139790149134, -0.32754591388935117, 0.30516635301151984, 0.03203681006408232, -0.36683070807990786, -0.04879842214118782, 0.2688669397993809, -0.27654830931084035, -0.40603618876520153, 0.2571877875265381, -0.1944494139752437, -0.30168645506042335, 0.2263578040955784, -0.7147741318934643, 0.09758787839317477, 0.07399323653917285, -0.33598126334751205, 0.7163247607026528, -0.20171166429807733, -0.24577613343299382, -0.23071260209165584, 0.7602881097902441, -0.1550730244248167, -0.16830820683143566, 0.18497128417823644, 0.20794185290133171, -0.009493533594212095, -0.051841501148581735, 0.02109453007709719},
    {0.528237096662136, -0.09522463402274442, -0.02202620737784252, 0.4344668918093336, -0.6988481455073312, -0.5228908552185138, 0.042974700649031965, -0.24197642454377075, -0.4741850562317894, -0.17312170579970199, -0.3030050791515142, -0.38022166920013856, -0.38824397700436014, -0.2639156258316673, -0.4426110081587244, 0.07037366579246354, -0.2819670299000043, -0.19917216765355122, 0.15765555633359357, -0.384086433692065, -0.015081531318427242, -0.09192894727329472, -0.18992875817440366, 0.15924305113841566, -0.6916625838512004, 0.14265916717487448, -0.11816795852539073, 0.09636460477306816, -0.27547022952347483, -0.16096867253739372, -0.3404341071908666, 0.33257570432018024, 0.010575416565834488, -0.11548687910939712, 0.2816875984514935, 0.06747700874306448, 0.09430588648793861, 0.1611775123890918, -0.292454658054981, -0.23279184808055875, -0.3912918139939206, -0.5577240047797292, -0.8461572711495359, 0.358809179154034, 0.04420405996271789, 0.4068291756218395, -0.18513223086992237, 0.05889756647398378, -0.09641149248047885, 0.057824914759379654, 0.15066549679236546, 0.380450237598286, -0.06932683742584712, 0.4558234991231982, 0.07662010977209961, 0.2664541862296602, 0.7029128870437181, -0.4742577741993335, 0.13125082083117057, -0.25431764419611175, -0.32343522445901945, 0.0864473874915531, 0.40924670417055264, -1.0160218305030022},
    {0.15705270753765, 0.6170209859602269, -0.5111263106480324, 0.037498998014020464, 0.08426092470323712, -0.7417962856905144, -0.2121178244968477, 0.32498728463460297, 0.5369205987864848, -0.6214407920515961, -0.10005636520766256, -0.22005986076688136, -0.3585931893047723, -0.33893549440506304, -0.09506438672893225, 0.06379859896221617, -0.44275410271984794, 0.47995725617401674, -0.3209247549143465, 0.03671895528365461, 0.46801973098990635, 0.1775803946067746, 0.16348710244075954, -0.3747194022780459, 0.4831133855427458, 0.4207533921242644, 0.07870565953956651, 0.28862112816586466, -0.18493365748516555, -0.2437160869564918, 0.24475058472852887, -0.11834739772889705, -0.1807310178195653, -0.13192190355101313, -0.2001793318020317, 0.09665050151980403, 0.2779097702597638, -0.13438748307549353, -0.035222388009828076, 0.33928813637885924, -0.4364145550746337, -0.2294213477792873, -0.13135059839667332, -0.5714098164120965, 0.4187397370913708, -0.25174912051608056, -0.24937120244657765, 0.4836294333040747, 0.3136710579959033, -0.07459390010149805, 0.2932761076180235, 0.14429253303951622, 0.3047725213447288, 0.43671218849789106, -0.1795522983352777, -0.023790032179930188, 0.15709233964521832, -0.31514291134853406, 0.15574004620274282, 0.2221303232643938, 0.36548148873161845, 0.31791973449995986, 0.05314349640343315, 0.16090434515376822},
    {0.1923330405804513, -0.10337032024901971, -0.13931778933554875, 0.02020723576670712, -0.6285623042126274, -0.16584920527450206, -0.07533074884356449, -0.619490267938437, 0.08468019689784628, -0.5125309037394056, 0.4243153708688484, 0.17166568526146456, -0.08365530442265874, -0.21722612836778588, -0.41819557492651893, -0.19268011634608842, 0.17547517273393895, -0.05659579517654557, 0.34323756513754416, -0.1133442203684146, -0.3025651490634718, 0.17609020488866317, -0.08753758615182222, 0.24241871742597496, -0.11515102966676106, -0.4006387249063618, -0.5181753616988464, -0.14775919636751844, -0.713130922336091, -0.4556293138883433, -0.40771265738432844, 0.17833790659109017, -0.04095648311812748, 0.06943448699357879, 0.3300806385186462, -0.22717646947885806, 0.007106343527915818, 0.030902528988163168, 0.2641254318210373, -0.30352817245023433, -0.28526546020138405, 0.11717893646026707, -0.4775751145967013, 0.353916946499041, 0.08234306391783767, 0.24418813107483908, -0.22557813946202837, -0.5588561917523783, -0.5106544834789183, -0.49241472362292327, -0.7103407918173802, -0.4828446148726007, -0.07261131661685795, 0.24296175965120168, -0.37721938338439004, -0.5165689803510071, 0.2090566533177572, -0.43496258004186594, 0.24803109836484788, -0.10900673548915164, 0.0825121586243122, 0.059005840086752505, -0.21328979634123643, -0.35132743494203206},
    {0.15052341584684825, -0.07281935077265704, -0.6457921030637467, -0.19037342439651883, -0.4126044893464919, 0.012620636869859926, -0.4067372268716679, -0.5807469077732786, 0.04781632417934172, -0.24848885563543707, 0.591978722078437, 0.13516467797848689, -0.022512908420373748, -0.0679389129363177, -0.08434936134636835, -0.25002726635175027, -0.27750422492791715, 0.13816287312989867, 0.5925526007234925, -0.19022221412610527, -0.4487240520193586, -0.023724563812453532, -0.1384521010311829, 0.23172684442315286, -0.32967984368411396, 0.057477483726662865, 0.4249591019004536, -0.5754300057025296, -0.11846624735556026, 0.12637475975261522, -0.24747342482601942, -0.28717286258549723, 0.1565727792471289, -0.19807260744843877, -0.23917581863639267, -0.13522002228832944, -0.10234829931510507, 0.11641029666156603, -0.13749559660531796, 0.1784699686176799, -0.18794258340100395, -0.4188621533079995, -0.3440540119485622, -0.09692754783041954, 0.2921730843017887, 0.05651622479123177, -0.2700892823581282, 0.21611370648360453, -0.035119206107094215, -0.03519261403443527, 0.5214440411681498, -0.9345222105945946, -0.002397879489602095, 0.09728133608439743, -0.5885866519502524, 0.1721209297593596, 0.2588726299865506, -0.18973531482967307, -0.14576023466487253, 0.030850832368501575, -0.5080986680965848, -0.22605087465729132, -0.05424301456467666, 0.328871125800927},
    {0.27688582381879406, 0.9588395419232106, -0.3564464078261066, 0.11822568503951991, 0.02832238191731362, 0.044569710052535225, -0.3832557816305803, 0.08578603281357298, 0.11343352107501121, 0.12419285611280542, -0.3307034144288534, 0.15114484359377559, -0.4879363731742989, -0.03509334092041885, 0.46663357564629554, -0.00088190747194789, 0.3042564627260103, 0.5402329078549367, 0.743751815914255, 0.24949301555250258, 0.41988803844501305, 0.0773157140576533, 0.41207701913611516, -0.2223443897544366, 0.2312511162792768, 0.6934835438398633, 0.05771359712454603, -0.023458348137120274, 0.3690310135485308, 0.05012307769892527, -0.11158847541838425, -0.26452444783777807, 0.21559271927896517, -0.2798059650646778, 0.12539266078696668, 0.21892221154211572, -0.3152657829298129, 0.10305224959138093, -0.7436791921308545, -0.32899141520314007, 0.12538313849138613, -0.3540211966942051, -0.034461734944264154, 0.10259460800467925, 0.2757754813873284, 0.27240751033308525, 0.42168100174833173, -0.15102851200348752, -0.014841026746568772, 0.06436886597468536, 0.31846642254034085, -0.42059573617791657, 0.00419448004579064, 0.1726084429369397, -0.7566038968696459, 0.3818720116756759, 0.11590060607778714, -0.0036484709387288087, 0.2338258698749868, -0.12071975459520243, 0.2933448688452775, -0.516214439795376, 0.39451751709826294, -0.7956257677809987},
    {-0.07978029384973856, -0.12999586604070582, -0.6535993640983575, -0.08153325695599892, -0.20380144958169058, -0.21854147283750686, -0.05105431785757733, 0.03285554598093647, 0.2125985047641031, -0.029637923672568754, 0.3367705051156535, 0.13837886120858825, -0.1421836550667591, -0.41233108062484086, -0.23419649184169095, -0.24167177083063818, 0.40601210851656294, 0.36815202154147997, 0.05756567962976543, 0.14024137149628157, -0.19054282989658938, 0.40375969841389475, 0.20684174448046266, 0.5478757022826833, -0.36252036075753635, -0.013284094208689888, 0.1709014833824049, -0.20393093425895, -0.2517639229824597, -0.2503617390794845, 0.04672416453669513, 0.24394242962195287, -0.20299727089357392, -0.8034844477474714, -0.2990909862872979, 0.29333478882272246, -0.13287490609002123, -0.11086180926302018, 0.022401570236339007, -0.20128805720096898, 0.017844977950642306, -0.2726874407373446, -0.06581280642104884, 0.10040787712452333, 0.24425900011248255, 0.18910835003191778, -0.548917420984452, -0.6454328612695168, -0.10985910033858737, -0.6226808690140927, -0.03277581714348137, -0.5711134249483203, 0.1718573210798564, 0.15401019332902274, -0.0881291619288236, -0.2857059010203645, -0.2735568721306997, -0.15109957207239125, -0.047132119647968526, 0.071048439624029, 0.20480666601325598, 0.16646722186228502, -0.47882238666853255, 0.19536633997622357},
    {0.012917831114769844, 0.41308698702373087, 0.00769037617533545, -0.19429091927392486, 0.0392755792717877, 0.2510457952840078, -0.22190830193903643, 0.07799839185260779, 0.09391293396079742, 0.6516466669648673, 0.07521530697535328, -0.17245204842875655, -0.3452235640094612, -0.25509262092276686, -0.3524273183962174, 0.030948477144003526, 0.19822376000166067, -0.454558539736935, 0.22421249824765735, -0.16667013776333583, -0.1370147766164506, -0.2998699056919721, -0.006571556198872231, 0.06651345690749375, -0.48921837573914523, -0.47163539296073054, 0.3768744934168668, -0.624122314243161, 0.06357529127869238, 0.23138056744749586, 0.11838715705132928, 0.12339760879082792, -0.02348680549542949, 0.05949388464158474, -0.3802177018596854, -0.37396316505026733, -0.1493105296330305, -0.3071520805555396, -0.16127385573348427, 0.23703697173035526, -0.10012932953294955, -0.5772600174982273, 0.06852354553397985, -0.5277786480827266, 0.47540484634240676, -0.28895220638797225, 0.01932634690913684, 0.16229479170569144, 0.44779344468614346, 0.3209628876731209, 0.14375857729270458, -0.425688972627388, -0.3083350645614448, -0.15923445802625077, -0.5179674863656106, -0.5823058328701737, 0.6129232204339218, 0.4426617055317728, 0.11609488116874256, -0.5528492557238252, 0.3086926122046505, -0.2231316762854005, -0.27659243259583133, 0.3451090142128903},
    {0.400896175468328, -0.4080136618858186, -0.6887378519639338, -0.5349279706749729, -0.5255944757593776, -0.3530838567426612, 0.12336827442982239, -0.21603712408869633, -0.11543656812607506, -0.17038241596108114, -0.03602774097399943, -0.12324500134512395, -0.1392988856827565, 0.06079525970393302, -0.4431037542341321, -0.18731502264617014, 0.23113295414596335, -0.21840856705280284, -0.2913635655428888, -0.02782170078140221, 0.16067802730078318, -0.48197070312077506, -0.5536954566679543, 0.2359921778087644, -0.1533515211049823, -0.3637331300598876, 0.38375560808237547, -0.4131425914064149, -0.3378265756488683, 0.4735245403535178, -0.1849213531296553, 0.0006178384817773798, 0.10246841962340057, -0.494590500837333, 0.2193494151462177, -0.12790149663971148, -0.3853105292987585, 0.6318472293700285, 0.43791049836197954, -0.07195825826905183, 0.6779676886113432, 0.17044501413282193, -0.27694455725432415, -0.10770856222103886, -0.34742759196339235, 0.2927094292740722, 0.07809994242230196, 0.11933732426581695, 0.3484487293190262, 0.5919573837431056, -0.22398157800687576, 0.4150433373473963, 0.19713666943817001, -0.3484128147260285, -0.028786580447425533, -0.11304553093902704, 0.20196951185975587, 0.3121100553022544, 0.15547445536583307, 0.028267378712311143, 0.07447065277525436, -0.11912259228313765, -0.4200666845931299, 0.16019371260457646},
    {0.21020932806282278, 0.08121850479213444, -0.4363256010212547, -0.06715186760953654, -0.03237851170396677, -0.21636031167897157, -0.3128718771997336, 0.5908429466993917, -0.4871384422387685, -0.006751086679279711, 0.21729121107883873, -0.10517805201556044, 0.2968757274237917, -0.38300447306280494, 0.04467499857061426, 0.1420273345054585, 0.23375232381939262, -0.5766606778339182, -0.21426750706635272, -0.16045482070536393, 0.43711673874276136, 0.08074413184452271, 0.35293074948462017, 0.08641323974504032, 0.07857498331832093, -0.05833981819731119, -0.06438044553363291, 0.1744272907785377, -0.35407986745433195, -0.16336622160002007, -0.5570337823164353, -0.22446361461429695, -0.46246188753230605, 0.09534789599585963, 0.10930630785534991, -0.8837998366766576, -0.28112563807319213, -0.043171557702290045, 0.2499730261075505, 0.06275506544163535, -0.18022079445100375, 0.31010243514410163, -0.21465360032457934, 0.669715644608279, 0.39399573757711953, -0.059407461573100444, -0.22878251891693382, 0.37229570527503286, -0.11599842912393453, 0.08792356843438123, 0.2051807588518739, -0.3566744226352278, -0.28514393719964704, 0.15706942728726184, 0.13048354073150215, -0.6291523695127961, -0.15208545371487547, -0.40476937575097754, -0.34870981654097777, 0.08243748773269993, -0.43295409577212796, 0.12924338018182857, -0.43372617645503203, 0.14759553558367086},
    {-0.14847712269105448, 0.01669381821340819, -0.11073282044833987, -0.29446170106921027, 0.007220038486102769, -0.28482680285266365, 0.13173659031060928, 0.3170593002250032, 0.012957941733042787, 0.6132316665597811, 0.21011962042359664, 0.4432489526713766, -0.023995872205484586, -0.13888514870600088, 0.45969903620161784, 0.5377044851942286, -0.12787311871936768, 0.326081496232088, -0.03729597826644841, -0.00593591106113446, -0.5361940698874714, -0.2843924838056291, -0.5250523464911665, 0.30005934681821184, 0.3373237551660118, -0.10534293654829423, 0.4739334618784442, -0.6320565215800259, -0.46099275515184956, -0.04756263136061548, 0.3879687459757564, -0.10973416632732068, -0.11033777405085768, -0.041566371717973644, 0.39210413099553043, -0.34324534223262293, -0.36373657330047354, -0.4019376716689567, 0.25192760454772384, -0.4765878815253941, 0.49720671982245657, 0.16702385967821493, 0.646031443707243, 0.2861791622485093, 0.10778791328377031, 0.3953091247423335, -0.5610825481131392, -0.130145504567906, -0.17813810501297705, 0.3957539163182231, -0.3195174627824893, 0.3334877905863537, 0.6097751593674728, -0.31384976377260837, -0.4015079236887572, -0.1700059375346, -0.14993645008815581, -0.6331462915928251, 0.24288709882749404, 0.2293047586839553, -0.7712115209952219, -0.28618033844218094, 0.07695171657104766, -0.22103398297225105},
    {0.26103542697438376, 0.39682009036091737, -0.1031442987882069, 0.2492912066532184, -0.4072928328316385, -0.02667549253779473, -0.16384799089584443, -0.4174131391546574, -0.10237219423315426, 0.2659751600985141, 0.5964496986264018, 0.37120761083987613, -0.12277638171294455, 0.24262622794301056, -0.21994030043467272, 0.24209696222949684, -0.047312198455143395, -0.557520042983835, 0.15030952658783434, -0.27608723540445346, -0.3472044523262825, 0.26257877107381217, -0.18961423955020276, 0.38878582272468887, 0.13867015916807343, -0.2678187182244602, 0.2062382299494596, -0.4558325061116369, -0.450062421120811, -0.1236537766823019, -0.023537494442255048, 0.5479754474073131, -0.25867458540181015, 0.1766569259662604, 0.3440806166877621, -0.17680259373147003, 0.1423108951872373, 0.11191178003658774, -0.10982421831212304, -0.721472920821676, 0.5422298721614437, 0.44343752195283326, -0.07013074264098218, 0.03509263217842437, -0.3312234049420361, 0.17818403835003435, -0.3412595327553983, 0.6631914047023737, 0.5740212069620091, 0.30599235380660705, -0.2120580609468322, -0.4453187259527998, 0.002377385490087536, -0.33161366152721017, -0.22946657329138911, -0.20949078614613548, 0.8001719074672109, -0.0024333636924202488, 0.26070933604082613, -0.6684442716419193, -0.15372314554427904, -0.4800839421381277, 0.029676271354967993, 0.4225094655104124},
    {0.33641701989012807, 0.8416479239859143, -0.34816123509235447, -0.4572215845378107, -0.42913447226597523, -0.6181961563551269, 0.30202315409761904, -0.4365996247557781, -0.24707696418873482, 0.736249370334206, 0.04779720230192053, 0.41279002605176934, -0.22082836439019238, -0.5121334736910581, -0.15031034263228618, 0.5140306350494078, 0.1686025853036547, 0.25505268688563665, -0.07485703771966191, 0.04414361338953914, -0.16001019774287162, 0.3465415508278642, 0.670224238311921, 0.15843091992133018, 0.18160843901138082, 0.32464863451456655, -0.027135236063853582, -0.7301380271553473, -0.6194552026862318, -0.1754191971310822, 0.016057724419727037, -0.35987838856599325, -0.5540398989363258, -0.3527002556081858, 0.36261719452619445, -0.21867583136456992, -0.8262673662661634, 0.32593186908340044, 0.3076629430115034, -0.04270033717486796, 0.5388970407811418, 0.4635036972652387, 0.7153290535109625, 0.3583898595442937, 0.2919665911222149, -0.15175521147962404, 0.1500846669936699, -0.14496025019418746, -0.15571371836963382, -0.3449097948864778, -0.2027574064504723, -0.058303121609418446, -0.11537250736042677, -0.5299290664974807, -0.7524069974905692, -0.3424001953828968, -0.053798580908987426, -0.29380066830984686, 0.5173874878084652, 0.00424688487855928, -0.29255636229630877, -0.5040718417646477, 0.39142887878120597, -0.08874636839928808},
    {0.7200101039993535, 0.569244607117637, -0.5357731023031141, 0.22308286909618727, 0.09840661332404245, -0.3638922770476325, -0.21401722132963316, -0.07527572500670511, 0.09379879595885635, 0.009229291635082439, -0.1631212959741757, 0.3848136065281386, -0.13039431853549618, 0.34199386251306424, 0.36991349162998427, 0.14299241728961934, -0.06513158748608212, -0.3768590708351974, 0.6343009117474089, -0.1594519864922999, 0.26060022044365166, -0.45914508567705864, 0.29122017031281194, 0.16743476721308886, 0.4432213829734524, -0.3216676832586357, 0.48671270072197853, 0.17206805748659554, -0.10203706444002542, -0.23174197704148852, 0.12181526794333607, -0.027363513262701325, -0.5494179143510597, 0.48407090822914856, -0.2678743762593069, 0.2095299524819984, -0.447985141041961, -0.06754671055077703, -0.09668344585990858, -0.2775204096731446, 0.4220212810295857, -0.04158125389400959, 0.22151278172022956, -0.41665898816533303, -0.02086652791538806, 0.4321133224548903, -0.7760147952903361, 0.9885308857041302, -0.0924666194078937, -0.2679097284837377, 0.14947673545301926, 0.39916369133721924, 0.20586954998945847, -0.21309091110780437, 0.12483474127135946, -0.1572235816689444, 0.14247592355296798, -0.08706505776290863, -0.1033684689901553, -0.4887300209789417, 0.1461722149765314, 0.24607594143438805, 0.16166958147647234, 0.009276690441383352}
};

static const float b1[64] = {1.1663208445554127, 1.2245853514615352, 0.9580942445235838, 1.1064795483237382, 1.1409047708738604, 1.1250097587574082, 1.021260152614197, 1.0359717279705323, 1.1408460986708728, 1.128922933376549, 1.0950032525263305, 1.1544101708909924, 1.0579408209468475, 0.921704856602724, 1.1621918471390318, 1.0909746452625277, 1.1299984736593336, 1.135464932896445, 1.2114719754497025, 1.1228508749274302, 1.1114033377174588, 1.0945970868237473, 1.1755038617675795, 1.1939868617369043, 1.1311718721933979, 1.1647103922641076, 1.0730592191401822, 1.1740164315523, 1.1733725560008248, 0.9380878390191247, 1.178718423076852, 1.0559485161878504, 1.167150094086627, 1.0931569546196451, 1.1592235073749442, 1.1618559497044683, 1.1605571440948506, 1.0583331958894486, 1.1365324179883831, 1.14421349704856, 1.1603320992062547, 1.149326784300594, 1.1230976403059094, 1.1447267349326413, 0.8048351906501041, 1.08261080224986, 1.1339427000284628, 1.168201530138841, 1.1280100702386646, 0.9570898818936772, 1.0284349526359757, 1.1126275842535513, 1.1870176097889764, 1.0579251357717814, 1.159988220460634, 1.1109631740354289, 1.0901196069197203, 1.1436860944913372, 1.1087538764791989, 1.149967931435466, 1.1039954750905803, 1.0748127751299623, 1.0381727045104563, 1.0765248019359697};

static const float w2[64][32] = {
    {1.2110470011337762, 0.871622743702272, 1.1715984925782783, 0.5479563099277395, 1.0489763601872573, 1.0373720697492055, 0.8677409291322609, 1.0627726206272792, 0.8458006326019032, 0.4200876005659282, 0.6592499272742843, 0.939373961640961, -0.06663962821196305, 1.0890966924157288, 0.5216551387706315, 0.4969842000176358, 1.0632311883823005, 0.05098535199795347, 1.1455119837159276, 1.0552380569383957, 1.1307129150419621, 0.5358813743769985, 0.7688689051201987, 0.9598540325561995, 0.8824054589840696, 1.2207850488973377, 1.1239764831608379, 0.05569705402309837, 1.0732817841562388, 0.050685970404147344, 1.0790891482223004, 0.5845007965009774},
    {0.7806450995863716, 1.0103167669973858, 1.2494703752198715, 0.544485033757543, 0.8691934694338418, 0.9206063186235488, 0.6094111979406525, 1.0191854616505696, 0.7968367666114957, 0.5359933164018266, 1.4303414704785908, 1.0456486054411867, -0.013378268234345582, 1.128264585896133, 0.19460741605545367, 0.44828501049695507, 0.7409674645651997, -0.017078617484039868, 0.9921220378074168, 0.9824491611348072, 0.8638465257301136, 0.6534426509842239, 1.1005671954168879, 1.0590484285094006, 0.4495056204220102, 1.0182874491044254, 0.963462673239315, -0.18614135721647992, 1.1832386201927818, -0.1293196947336416, 0.5213913239636745, 1.0338360858214133},
    {1.1260792595949654, 1.1216046490556155, 1.0239491006894403, 0.5088860553329547, 1.0692447333959418, 0.8672956345529219, 1.1082386036697771, 0.7436728495109308, 0.7380943705677491, 0.8743909223844257, 0.762010576325244, 0.8800510430308875, 0.02761941968215763, 1.0188745262018781, 0.4376815755040432, 0.49982907736094834, 0.7358466947500202, 0.15593475624660857, 0.8238086423120985, 0.8128627453373884, 1.0713629155036462, 0.5760150661071486, 0.8576446810635695, 0.8160862419509946, 0.2908568319462432, 0.6882644986153131, 0.762098844800522, 0.0708470673535628, 1.0348913608377455, 0.05969139545183406, 1.2038846497952191, 0.699532612633937},
    {1.182006164926216, 0.7616806332942471, 1.2409783154381817, 0.5953578220279685, 1.1380815128477528, 0.6472306537249094, 0.8058457267948776, 1.234069241537804, 0.9687235176919989, 0.8869169552719036, 1.0619522070103165, 1.007748895708104, -0.19250484178355048, 0.9597289872130587, 0.4980677948343676, 0.452087195145466, 0.8597356096605424, 0.11556688003483934, 1.1197457698307316, 1.1238127455563929, 1.0173410226935906, 0.8016814702363215, 0.5637452631963136, 0.7263487576777268, 0.601029907935997, 1.061654913582148, 0.8187320412746693, -0.04631983390711359, 0.884088698216673, -0.0757935518920984, 1.0667706799264902, 0.9776957508263766},
    {0.7399403819092812, 1.1759413901089333, 1.2163097233207507, 0.6290139887390658, 0.9995499752190925, 0.7727392237602969, 0.5499298309066022, 1.034410604553492, 0.5984513036304363, 0.2987569655815087, 1.0541320538161225, 0.9705274155926155, -0.025918662998663012, 0.945519844075016, 0.12332523723637445, 0.35100163399297807, 0.749325036104351, 0.15305011741502386, 0.678756793623929, 0.8256112673559678, 1.0358758609990708, 0.5749450056913107, 0.8063294767055386, 0.48893533474748396, 0.5313408228741932, 0.8672778390593632, 1.1834920788895233, -0.14422775361465248, 1.0885317384961337, -0.19708727754665967, 1.040614602751918, 0.8323311132632796},
    {1.1904751319645763, 0.9065332841637576, 1.2404730655540979, 0.39426884556339836, 1.2157068715012571, 0.7884431346525588, 0.6374296536923915, 1.067337659475254, 0.5635610816601965, 0.971841714467013, 1.5739990188283628, 0.9867994315441962, -0.03353693082816525, 0.8263757439629427, 0.004963579347072896, 0.4864273803953654, 0.7666623254150743, 0.026066897885200245, 0.8315531024496773, 0.9449461775122161, 1.0171486321151653, 0.3786537728770393, 1.0151685665698162, 0.6613784740810904, 0.6290793623064019, 1.3263124899677243, 0.599481703410807, -0.035135477456656496, 0.9905009249452642, -0.06317764606564814, 0.8651117427061215, 0.5513494751126766},
    {1.2658190071081956, 1.0296553264445856, 1.0325732983498297, 0.6798343782262644, 1.301724945749503, 0.7509505419150876, 0.6775527591018011, 1.021488548082824, 0.5926553647116403, 0.8636235559638229, 0.6311907233255467, 1.122024942685322, -0.10620695894487445, 0.9042889046291823, -0.21423035780564567, 0.5620439229859939, 0.671468183427843, -0.11807672621281397, 0.6517843659421555, 1.214053478178497, 0.7665235714534678, 0.5966736339571475, 0.9590881950363398, 0.7704141867797898, 0.6637959389623822, 0.924226181432941, 0.5798568547002929, -0.43730066835431125, 0.9494586051684907, 0.16669038555663618, 0.8285531707037681, 0.6913891273232685},
    {0.9480271593010057, 0.860061457874145, 0.7427770693994409, 0.593593627959655, 1.2586870275642978, 0.4872724401836283, 0.6074832044993136, 1.1152062287220563, 0.6503537082204509, 0.4138395400339036, 1.1765857964423476, 1.016372552333764, 0.027005713296667545, 1.3125323714678723, 0.08869747180445359, 0.7435518267396357, 0.8236524400039557, -0.09365164129215854, 1.13633228279331, 1.1250082172146967, 0.9961746800530575, 1.0400887760453241, 0.6624207118109393, 0.6273964660320123, 0.4383190438401461, 1.0028816671370477, 0.9688150900079304, 0.019712975122530695, 0.3522523414303562, -0.21222234207336188, 1.024344479663723, 0.8628820067134648},
    {0.9077712487612598, 0.8821134313774656, 0.7771398304321944, 0.5934230525782311, 1.1053904791320888, 0.8527244927135098, 0.8989749884657976, 1.0956315500280087, 0.8460105771977581, 0.5498372424179726, 1.2393860367109484, 1.1211612757756084, 0.36478166997387595, 1.280832582629765, -0.24763833911740177, 0.48245120375511563, 1.0472206865128655, 0.03984826614832981, 0.9068904830317907, 0.6909784644198486, 0.8202444455707274, 0.509464193347643, 0.6315639615563498, 0.6199882912121233, 0.24749616838849023, 0.913375214390918, 0.8222355038449052, -0.06531102223946013, 0.6872021435126173, -0.004312357587141791, 1.2774798104881013, 0.8986977911001444},
    {0.8059009534407513, 0.8120371137204604, 1.0437621568953415, 0.3576710302274119, 1.2707574745029422, 0.9952257345188767, 0.9766808784518266, 1.1096528414689832, 0.8399944325391376, 0.6475102148359551, 0.8655922051313721, 1.0074056826680424, -0.48102386847418016, 0.9683896395897483, 0.4279749884020097, 0.9200289181258569, 1.001806451279764, -0.13616787850339196, 0.9684080161198232, 1.149087464103006, 0.9432066029113813, 0.8989706378794862, 0.9160206511908541, 0.5179482366424524, 0.4927084930765325, 1.1904291568610825, 1.045488764906602, -0.007591100978403087, 0.8914081730993423, -0.45250798491733163, 1.0504461178004576, 0.7166042889443649},
    {0.8414996750324771, 0.8809047635510969, 1.2256320110418721, 0.8057060622803468, 0.8648745475213084, 0.7290787202502386, 0.6468707325142585, 1.0279605493694057, 0.8357622120025158, 1.1092518204988235, 1.2405115219608354, 1.1656484783876329, -0.5264474011438978, 1.1383213316583907, 0.25514541575792316, 0.5643443393724284, 1.0117766486355417, -0.04491482025002583, 0.6553354118498624, 1.0100457905071383, 1.2130604819227344, 0.9672021095560431, 1.2483488743851212, 1.114631231657018, 0.5543872401185154, 1.0327226485758436, 1.095099682266438, -0.08089662731416816, 0.7539707972280469, -0.0760037456204465, 0.8615889087012384, 0.49962301613631227},
    {0.9906920606385963, 1.0237485752153297, 0.6266368831197463, 0.7992204986866888, 0.8632441166965692, 1.2955214624479463, 0.8906186298761054, 0.9293914332273602, 0.7072627544206395, 0.6384273298374494, 1.5260539103830009, 1.1619050252477654, -0.24666760010868088, 1.1461749980329927, 0.22548167711429723, 0.3820855674916349, 0.6187162544052831, -0.1584165530907519, 1.134771578375596, 1.1249318823511296, 0.9119018448339001, 0.4772914192625683, 1.2990979312194486, 0.7425291453545858, 0.6859103271017275, 1.146637599822441, 0.8940065883331507, -0.02421302441944217, 1.0661096980417437, 0.1878152998183355, 0.9430440354416173, 0.7358401781742184},
    {0.9361181027398788, 0.716416388434242, 1.0374500135199647, 0.484197649796793, 1.3771901805745266, 0.7153321387135714, 0.7151331112839922, 1.1252678526563422, 1.005247766173229, 0.8028001874050583, 1.0250782234469107, 0.8723887599655504, 0.39188340474494726, 1.1787849746863672, 0.23972693188777006, 0.47776338361335297, 0.7476372722741992, -0.15934505198450513, 1.0768912616472996, 1.5188040319003842, 0.7527552297041318, 0.8421082068446809, 0.8177041718464461, 0.7358240841238156, 0.764787855259604, 1.0059919233746306, 1.0173871418265463, -0.222163661415528, 0.6910252561283862, -0.4058927886383112, 0.999738979532759, 0.3633086282297839},
    {1.040478337188768, 0.9647931047557774, 0.8651365857189302, 0.9683280843252948, 1.2124565556868947, 0.9240337669951267, 0.9739576073803872, 0.9027977146719741, 0.6875317850276158, 0.6304787174681724, 0.8751785817402589, 0.9979730986143764, -0.019006476359272235, 0.8072081539108631, 0.21516673057318528, 0.18733195855446633, 0.8996043224443865, -0.011693735472046354, 0.8016557706888088, 0.7869464562482631, 1.0564781211354937, 0.9938860371625651, 1.043470928743508, 0.9326470051667568, 0.1761279297983408, 0.8831133175346554, 0.8302956579219398, -0.12760272596433317, 0.6062820826308345, 0.40912335399235894, 1.1319677322731074, 1.2371631824393872},
    {0.8245431232688424, 0.6983629912108906, 0.8753732856410105, 0.6852263398065643, 1.2056579515963977, 1.286055898977372, 0.8691490425545245, 0.9150977379629182, 1.1568962171409376, 0.8185853810836284, 1.0513192682890395, 0.9921834702087533, -0.2200301179924186, 0.9461652671114038, 0.27124678520866424, 0.5849582705301534, 0.9166916312565084, -0.20038103876231886, 1.047421683833498, 0.9898978369187631, 1.2084211812311791, 0.7377862968111927, 1.1850277898297163, 0.5281012941610207, 0.6258827184560698, 1.169152418516044, 0.9708496117466628, -0.20462212480362957, 0.8896142828281522, -0.17902221961339335, 0.8636726893749019, 0.7120971885531123},
    {0.6806660890714417, 1.0284980519914104, 0.9090708692978321, 0.8374436451553015, 1.1210772995305942, 0.9031226970371544, 0.5861970420967937, 0.7678964218399278, 0.9302476169317274, 0.8108777758187314, 1.1161005497473955, 0.995174317350709, 0.14630546240345238, 1.2399903931839893, 0.16866159769712888, 0.5579707127909248, 0.8011273165296883, 0.34686711716742213, 0.9978203067616396, 0.9690523561268166, 1.1200121963380891, 0.596431913033195, 1.2917000930610438, 0.5646808363304276, 0.06612599037898147, 0.957618928510927, 0.7176912112327498, -0.21136746893186292, 0.8737756560443188, 0.19095569967198128, 0.9238805948127837, 0.9340002309628547},
    {1.1606690944713223, 0.8513609610075519, 1.02455792127379, 0.8155134203797036, 1.0095439601748994, 1.106244266680603, 0.5947620433712547, 1.0842366266531016, 0.5377980215646251, 0.5992163580353622, 0.9922921478891296, 1.1181925759967728, -0.07920093189974486, 1.0590349118491011, 0.3526932670318035, 0.5766729319695947, 0.8066662947314927, -0.13528075137566783, 1.2016006138980528, 1.0625963183303146, 1.3940218941369005, 0.5148166048866867, 1.0579958114869934, 1.252291536062128, 0.4944613991682873, 1.276673813953522, 1.041453362864115, -0.08943805485176538, 0.9682051222794901, -0.004529638815528399, 0.8994899354747766, 0.8629575828914438},
    {1.048699910658792, 1.049369063131786, 0.5696672954412922, 0.6318095776158816, 1.034104352601817, 0.9286926801012263, 0.5895195360189013, 1.084590805865579, 1.0048588112134123, 0.46906690857089606, 0.9558135429727498, 1.2281716896145105, -0.16070356517817844, 0.9676610633662447, 0.41748466472945456, 0.7196004156592027, 1.0200189865293385, 0.18109879926849945, 1.227551421936426, 0.824613208926136, 1.2644970020570394, 0.5652150754428564, 0.7806737684637762, 0.7576312908411512, 0.3529958948417939, 1.1423794612604852, 0.6109501571829699, -0.2359369657715207, 0.9427686415517356, -0.03302241372393323, 0.7893714282456905, 0.9982867844530767},
    {1.061109133681771, 1.0518199051611339, 1.1330010697842818, 0.8116457011575567, 1.224324988136662, 0.6333161439979043, 0.7742072622865409, 1.031172791765725, 0.7764646269570742, 0.8694601016286145, 1.077731901240809, 0.8730446159382669, -0.0656284232484234, 1.1746793114616716, 0.06992855249919198, 0.6238709583300117, 0.7006083751514153, -0.07980047632673211, 1.045157880584363, 1.1201365022523784, 1.124456513910938, 0.7182743119743247, 1.2522446013496462, 0.9190743190139418, 0.5011487987429422, 1.061492465923182, 1.1371782774716048, 0.09707001947695651, 0.9146467321948406, 0.024296598571958254, 1.1537543451954417, 1.0756891494171412},
    {0.9430375040277126, 1.2609926443099606, 0.9440583031483119, 0.934715539013181, 0.6402021001168582, 1.099501400832382, 0.8186080969657542, 0.982325011216007, 1.055250766426487, 0.6181570712997003, 1.0561310710460625, 1.065028388719334, -0.20313610196596382, 1.4024192265880981, 0.5306583590278239, 0.5678899085896741, 0.8972661967816596, -0.1307311552951845, 0.7704068436581109, 1.0770246170234508, 1.024177977545241, 0.7884882370295367, 0.8599130150561577, 0.9709944451345393, 0.4601068008648174, 0.8022401503575589, 0.4219884901542021, -0.02821084874874129, 1.249771024195244, -0.20229207081709824, 1.2380927355494642, 0.9617202076522118},
    {1.0043106210858304, 0.9779564323947398, 0.9378385953920673, 0.8087211702806582, 1.0533751961568871, 1.231843215291024, 0.8461991203028428, 1.1464780229900569, 0.6221776032012923, 0.8836305963090245, 0.9715864465298226, 0.7653648092532389, -0.03525408399726693, 0.9660889780793299, 0.12160212640512669, 0.609630440181706, 0.800965093475234, 0.17285657639532226, 1.012629729403461, 1.1145487188790295, 1.2392803672728698, 0.5134005080707952, 0.5772014735766607, 1.1069082524904423, 0.3532224189913049, 1.065670798205586, 0.5343699693647949, -0.07151805399503353, 1.192873919870012, -0.19802774283118293, 1.1328346582749476, 0.9928472532082119},
    {1.1669914193180604, 0.6842167198967737, 1.039023071558554, 0.7748304859656903, 0.8601380153957472, 1.068589536519015, 0.6604063413364742, 1.1524244429224277, 0.9019409426165954, 0.6655943553996414, 0.8312028309049987, 1.0865910136210548, -0.2569225541435747, 1.267709183194801, 0.29718762446471064, 0.26681558248280357, 0.9336220122866034, -0.28125832008507884, 1.232535338986175, 0.8154316347544972, 1.3967228292525213, 0.5533133102983351, 0.9842182808085922, 0.6096873268676242, 0.61887189554866, 1.0527614758831154, 0.9195190013473062, 0.22369175888467943, 0.5435012566283417, 0.02959227450068405, 0.9893350069987402, 1.008088823886959},
    {1.0436135940407993, 0.9454080693296922, 0.9506954316325603, 0.4976049433814045, 0.9816246417854665, 0.7163803947214381, 0.3290909388610574, 1.2185409012630934, 0.6251782134234227, 0.7241219903537114, 0.7783272885865422, 0.9395312588173153, 0.09938851546475198, 1.2901145539491572, 0.005269646747417495, 0.5732455452097927, 0.9612537988854029, -0.15143706570799778, 1.138588595889269, 1.0396008101326664, 1.1237429882247407, 0.8580611674254224, 1.2238036938309533, 0.8634022451797386, 0.3910056412661021, 0.9122761842222381, 1.0453239076410032, -0.2942724414560439, 1.101946500589695, -0.0962409901492745, 0.941315325462769, 0.7693051221372569},
    {1.1650317444555738, 0.8185302840598575, 0.9415598158337438, 0.8188632517836497, 0.7919098377295078, 1.2073310293081296, 0.653415945118409, 1.3444515741596466, 0.955751182839203, 0.5939248640962509, 1.0576455594350282, 1.0038097167791509, -0.1783580622925069, 0.9219804711766828, 0.21378561058354606, 0.4375931096009156, 1.199800301385225, 0.036940805421279976, 1.0807395732997331, 1.0314347242105855, 1.2566316473236088, 0.4793042297465876, 1.0719528786502686, 1.0681174126211133, 0.6617132051268495, 0.59415593545, 0.8524484031938975, 0.01010233881231583, 0.9676038235430569, 0.07302289608331954, 1.1196944192404932, 0.9812464431569932},
    {0.8084739490585008, 1.0364962665427642, 0.9480798248616993, 0.6348652964593896, 0.8298063764398431, 1.0012991843136776, 0.6422063240751643, 1.090748768137477, 0.8001188008516419, 0.8195970021827487, 1.072645299109903, 0.8902047354720066, -0.3639701928749566, 1.199120982015721, 0.29032747112710755, 0.7896011068222087, 1.0397334768767108, -0.3052109381670205, 0.9163698150971578, 0.7397405872765485, 0.9069595246338079, 0.4293915926407166, 0.8643490952389853, 0.604578997314685, 0.3858843950555898, 0.9324848841262557, 1.0190635347688561, -0.1582377798960815, 1.312178363822267, 0.09233595780905744, 0.8777880697289352, 0.8767083090885025},
    {0.9822384370441101, 1.0892929137168041, 0.812444891749889, 0.7915220530492416, 1.0808410582205268, 1.3025525983131236, 0.6614932974884349, 1.1771703829085987, 0.9474111941026095, 0.396961464245148, 1.0608984886978183, 0.9199043622526142, 0.07042285649813604, 1.255438929737701, 0.3117791686685833, 0.5549381488672819, 1.1630103049062064, -0.165154340753791, 1.1022358266996422, 1.1548360220995328, 0.8593964754847556, 0.5287236233317629, 0.8511845071824696, 0.9750497222322214, 0.5356156391330484, 1.2583418349551723, 1.1049151044500884, -0.0007678814554217532, 1.2437286555391907, -0.34489406173769255, 0.9715425817741995, 0.7891680405908887},
    {0.9077036957773807, 0.9141595665051121, 0.8672903337216541, 0.8751883780306537, 0.44468178604564085, 1.215984918623962, 0.9459539034546509, 0.7191232275719467, 0.7398228423446265, 0.9133119010615602, 1.224459401812726, 1.2070991998708882, -0.44794701038673757, 1.1137747646852667, 0.25208102330193394, 0.5487896942315804, 0.9426348117832252, 0.21504582969703365, 1.0914094322393533, 0.7538740317847105, 1.1029584988115122, 0.7714654053733685, 0.888295784192879, 0.9078040314417787, 0.4582986524521213, 1.1324360498761923, 1.2026714198756394, -0.08115574875350379, 0.6101765653599719, -0.2603602677814414, 0.916607248213506, 0.945157906195942},
    {1.220672858919252, 0.6901529954161589, 0.6963706410435089, 0.8178434137015732, 1.0763240138336985, 1.143696700315433, 0.6636388050286794, 1.027387669436735, 0.9826864844017055, 0.42439329425725836, 1.1368245065856037, 1.2367809620661607, -0.19374527609376727, 0.977330244766198, 0.2207983889220567, 0.6569844351441002, 1.0921896159501228, -0.05974246765729434, 1.1725072456794172, 1.0713614698179748, 0.9453276254337918, 0.6143134558386615, 1.3456585701010193, 0.9740980948129452, 0.32138707721811616, 1.1095438965878932, 0.9495314471881227, 0.0944792437445909, 0.8674516623164306, -0.09795031229256164, 1.0173188076938695, 0.8156523862417333},
    {1.260579665835478, 1.1758394732157245, 0.8272565533558002, 0.7270797546391551, 0.9275440101579163, 1.2398021131398793, 1.1491885536834818, 1.3354377848118681, 0.8446689724624012, 0.7513896871452441, 0.9627024494808825, 1.0376328890717088, -0.10620549314045587, 1.0618059035815572, -0.19545977649201726, 0.5408027180980344, 1.213133511323508, -0.05099819992652115, 1.0463807520242718, 0.9810799945488559, 0.97111946339358, 0.686628143649544, 1.3994126161524796, 0.8706800823157317, 0.473469043175603, 0.7895127140929595, 0.8314220040572065, -0.28232119165622516, 0.9749087942121345, 0.02764842280336444, 0.6096634146061374, 0.8308050790271924},
    {0.7097752974675193, 0.7239600195636322, 0.8025225709826059, 0.5860059982413354, 1.120544288574185, 1.2744481437468276, 0.5832671999469048, 1.061568225136633, 0.9004479472053158, 0.5225036649659476, 1.314605611022207, 0.8331540175441619, 0.15383888584042205, 0.783422315214474, 0.5490692732513408, 0.8026771394359333, 0.8403323696139786, -0.09125153676481099, 1.0866276265348689, 0.9303795833406633, 0.7344044438846676, 0.6961725336706455, 0.8623223273883647, 0.913824914493534, 0.26510092366312826, 0.7657070281610373, 0.5706183377246122, 0.007842148805626701, 0.7738590749880564, -0.024573689200576388, 1.0138514317513672, 0.8052734508522391},
    {0.8487904465736394, 0.7425238562544595, 0.753477553034578, 0.7522310973350579, 0.8280566808041706, 1.3980658566488697, 1.0181673264006674, 1.0812072476483163, 0.9173225075809432, 0.9785321921245459, 0.9361287656182921, 1.058922933615215, 0.016060921825584818, 0.8182587163203129, -0.0915122223851247, 0.40285228618798763, 1.11041383622571, -0.18835986998179644, 0.9821465731551628, 1.28267757216127, 1.08948301122584, 0.6176130762037385, 0.8928039116157134, 0.8763434187416582, 0.362453293761205, 1.1126190230535387, 1.0854424943356402, 0.07553822817059348, 0.665106850927276, -0.2664395476837946, 1.0545641736140638, 0.8024304332340977},
    {1.0487344612942242, 1.0639550655912637, 0.695696067271618, 1.29808457500257, 1.106087087512939, 1.1265165482019321, 0.5767718641571071, 1.2636935193009806, 0.8308332085376724, 0.8891721104180084, 0.8667728132280544, 1.2050809942418512, 0.29693387045230296, 0.8884075481658973, 0.44130683151694916, 0.7085986188754445, 1.0080687321046624, -0.15819431858822727, 1.0075940044810932, 0.8599044021772934, 0.6929068639514131, 0.41885814198384747, 0.6757695177345262, 0.8130048214773838, 0.6794795657549644, 1.066331456098227, 0.6615025197429247, -0.13168431225211338, 1.1327213202367183, -0.025737726571788806, 0.9111351610292534, 0.7907340158769298},
    {0.8821065724813099, 1.000162168702972, 1.2649043875025734, 0.7883729794870684, 0.6946589786159486, 0.9670134640827668, 0.6129408115681563, 1.1136136085755943, 0.9185039073860715, 0.4236670351732944, 1.2358728672804005, 0.9647493469142987, -0.19022973098593593, 0.9637556712638652, 0.12799193604442324, 0.44043284821137335, 1.090603000021625, -0.35067456526377594, 1.4533322851027357, 0.9070034540679273, 0.9350035014492356, 0.5315537253415219, 0.8030999532430073, 0.9431878876739415, 0.2767815259834905, 1.0820683423668842, 0.8646941832076428, 0.13263913402532698, 0.9588478511692945, 0.11163842739587955, 0.9666902387133571, 0.9439243374643898},
    {1.0018676994950166, 0.7693555902248108, 1.2380675937639165, 0.8659157001073914, 1.3259659247603828, 1.105328450344664, 1.0421728301916686, 0.9095104891763828, 0.6134522680275786, 0.9058097354025781, 0.9411086148622189, 0.9518650373921296, -0.11418314909054322, 1.0180738257729476, 0.4811906273715766, 0.6850335665781181, 0.8609565484874359, -0.08405996754870212, 1.0010344233578146, 1.2711357857287167, 0.8136952252254734, 0.9562796873495241, 0.918657708516385, 0.8689945139609127, 0.7462375282868301, 1.0455327581657559, 0.908825800911004, -0.11258259489442915, 1.0294302644527424, -0.1087770945946512, 1.0553856212388424, 0.8742040987492912},
    {1.038513689945263, 1.0237555018151323, 1.173240424945098, 0.9365679495896371, 0.988122968470723, 1.0804808377427018, 0.526871093240201, 1.019238618149993, 0.5844381793265999, 0.7222607850242165, 0.6049796342457399, 1.0314134481486952, -0.019015588127203432, 0.6815940525090776, -0.13105554110825385, 0.3479318380984056, 1.0080040720168757, 0.06983009237196663, 1.0233245522502032, 1.1916232224425836, 0.8743803873291728, 0.8177897025254772, 1.0233289773201946, 0.7036741958159791, 0.2932687755116982, 1.0221327373973266, 0.8299184781008283, -0.187515250485127, 1.101236094826994, -0.06708239550541652, 1.0503195573906114, 0.6777863083342915},
    {1.3835474220307424, 1.011945985978944, 1.0374301379821687, 0.6261550189906115, 0.8605724251359699, 1.528053311536118, 0.7347818745917646, 1.0803985850553512, 0.8824255461556592, 0.5423625330068579, 1.0857181331723733, 0.998633326955972, -0.07042987740259568, 1.0856627537289167, 0.2693837921747842, 0.5361712023820282, 0.8372975260256864, 0.044332625535492984, 1.0298397749419, 1.0932039814520316, 1.0402182516645673, 0.7452942693121024, 0.966686050936013, 0.7473241791909127, 0.5845087931195896, 0.897670760051748, 1.0738950620126795, -0.07674488866020676, 0.6136275118160149, -0.19705728102629863, 1.4939922071761045, 1.012671458144647},
    {0.8922871261623683, 0.9119265311485905, 1.0593291651842616, 0.5829902413802157, 0.7340570873095662, 1.348548684276921, 0.5750372767957017, 0.9636067901788968, 0.6764859116588233, 1.0168307240097978, 1.0775766372646176, 1.1031840104857933, -0.007605952442271838, 1.1750259957459608, -0.06942619385638088, 0.7369555129082626, 0.9203798891418337, -0.12913531583745158, 0.86345604564234, 1.0296191810840007, 1.4409495184984964, 0.9232993455044645, 0.9511069501348332, 1.0470356688492715, 0.5677715767985408, 1.2106377744428616, 0.8951403621894976, 0.009680266556677955, 0.9741065779014797, -0.045118163725009784, 1.0671278510360258, 0.7035756886367908},
    {1.1866356144096977, 1.1642429142221755, 0.8045323120849377, 0.6326261311606645, 0.8771452145067687, 0.926464005935766, 0.6136868882110611, 1.0523846348900932, 0.607398194558543, 0.9815745250039012, 1.130535694986148, 1.0261618984499636, -0.17838000541614546, 0.521423401381392, 0.3294604852122241, 0.6326779313477452, 1.0596406899023805, -0.4688096018417976, 0.9936112634541464, 0.7591556331728433, 0.9026156648832485, 0.3915930854884045, 0.7555611934793497, 1.2270445640244096, 0.5172122950273518, 0.6906039563444012, 0.9151613631552779, -0.2608499450359086, 0.7941841029221627, 0.03655055187504508, 1.395640164262374, 0.7792176806309092},
    {1.192297040125731, 1.2394538396079313, 0.8237642007341329, 0.6017070459343442, 1.3016030889851211, 0.44971599266256856, 0.6210943097765025, 0.6307759835571379, 0.6837645290024965, 0.8562099686387404, 1.1192752183720087, 1.313539398151474, -0.18946283075851725, 0.881574741518928, 0.26506452166410766, 0.6868330980048368, 0.6098753059409389, 0.2520030262933645, 0.7884822214158448, 1.0549271430362042, 1.0679662617164851, 0.45503795568295746, 0.8801886223314487, 0.7559794594658453, 0.3220689480049711, 1.2914585916294556, 1.0735379354534194, -0.04000595490835038, 1.0633855154689125, 0.07406220787153582, 1.3842527647120921, 0.6887773347420009},
    {1.278682026092744, 1.1397211557585247, 1.278600829176186, 0.4287497109633457, 0.7300102771062589, 1.0040135113330075, 0.6022792436583702, 1.0221163873808212, 0.9030825698238103, 0.9289335116279723, 0.9519315404457205, 1.40222916420673, -0.2835065766694581, 0.934068831276882, 0.45071031310957577, 0.5693559631708828, 0.7973984762878452, -0.0380287800608552, 0.8687170854541131, 0.8946588673748344, 0.8795421270237463, 0.5004911132300034, 1.0373102924191064, 1.076649438259981, 0.2758191337021651, 0.9848623934156514, 0.8782493060987114, -0.12076174907390613, 1.0899375043195898, 0.04836211911597909, 1.2491315403343008, 0.8626805763506206},
    {1.306247451309427, 1.3320861134640096, 0.9673695962601703, 0.7356356276211959, 1.004851509919928, 0.98837956339111, 0.6764299667539957, 0.8618321001023661, 0.7641119784658709, 0.8142702122771295, 1.2261159219365665, 1.1601427660204127, 0.09464389840636551, 0.9801963102461366, 0.3567726947265999, 0.5276809709681186, 0.6802434010021822, 0.09489307053020354, 1.2152459026650353, 1.4250747343001242, 0.8598531407046246, 0.6524986584650185, 1.005407294176679, 0.5580745241162991, 0.40437477242444747, 0.6843494490988162, 0.8570284316001247, -0.08811028612061834, 0.7800558032504529, -0.1869647374709781, 1.248422797407799, 0.7187286510065098},
    {0.6630800928442825, 1.1985151949413289, 0.7833149769089481, 0.7668967004403797, 0.7950719387923737, 1.1795950515303615, 0.7566514343486905, 1.0029845101496204, 0.6864358690945208, 0.48665754034309056, 1.0781272413450322, 1.3662974932120326, 0.217415119330814, 1.1868602629949458, -0.10458189554447336, 0.6031575453234126, 0.5462646780939192, -0.47926714917571905, 0.9009863258814107, 1.1706577276606613, 1.1682176016132668, 0.46440623133591913, 0.9205610866684832, 0.798414536200264, 0.22012639813951845, 0.868978140455116, 0.5820030717877488, 0.1428039205524035, 0.7852508429778317, -0.12104839598586278, 1.1446390641257436, 0.5579823553853148},
    {1.5273750048577437, 0.8757712996859808, 1.105329675095371, 0.798194154221948, 0.7503057144635378, 0.800188752619247, 0.8391995685248754, 0.9922964163645174, 0.7213525790771996, 0.6377385806984341, 0.9799709613752047, 0.8786522589151342, 0.05063829651397545, 0.8950111274543306, 0.539148779966746, 0.6464685249656376, 0.9206795897676514, -0.14925820221189318, 1.151471498183934, 1.0053169389753494, 1.0880129184338385, 0.8730347385797951, 0.8941043411317409, 0.9479981672053114, 0.3550100062449882, 0.8581815655332014, 0.6198662991856039, -0.03222525350054384, 0.8966471668721859, -0.13393169066270416, 1.1815143189281598, 1.0090272649895662},
    {1.1036098284547313, 0.9912865169349363, 1.004311060521914, 0.5564570924713418, 1.0859167000920142, 0.49344709468084286, 0.8629171568203154, 1.0780819821408199, 0.630753342435269, 0.8554414007501342, 0.9853719849666803, 0.9758452737486096, -0.10492717972777507, 0.8764970057934324, -0.11981611594099545, 0.5930809478106697, 0.9624954454977867, -0.3891668228783894, 1.0707221444478265, 0.9119610482765196, 0.8418769691361461, 0.6042240930485046, 0.8984032725642076, 0.677037932357465, 0.5879799615913622, 1.2138224259620278, 0.8626510465474674, 0.058305028082168614, 0.6822733987882842, 0.048332192598988195, 1.3295422263027226, 0.6181385472544945},
    {0.6163148382005548, 1.2249262447348677, 1.0876206921886793, 0.348817424958445, 0.8531716327145495, 0.7036864025089191, 0.7571745403048835, 1.0742763558710076, 0.5811229172727324, 0.7723525569445475, 0.686935097369358, 1.0580293027109373, 0.046389121816941534, 0.9316616689721048, 0.7079808365816226, 0.7989779955816956, 0.9572448503441474, -0.09539366244252322, 0.8738664298704245, 1.079781910616863, 0.9341560952108773, 0.6202520019724672, 0.98831048717862, 0.7886936840781006, 0.5058567352148313, 0.5992873110740063, 0.8789563756658141, -0.33596695719343933, 0.7516896805140622, 0.13614431605538554, 0.82346878546252, 0.919164829250984},
    {1.1676990778353717, 0.9345553065867052, 0.8574001784666406, 1.0822995478111108, 0.801770752983156, 1.2816061647858137, 0.7792794853833984, 0.9199060833354686, 0.9164683478248403, 0.9745232741192965, 0.7491498084510435, 0.6669499944614568, -0.22519253613498982, 0.9284238225090152, 0.2712974335304832, 0.7070461178525005, 0.7102937127235733, -0.36946852558112425, 1.1277138627509753, 0.9406614017677861, 0.988325967858188, 0.8152374453229133, 0.8884473347420356, 0.8998947555611599, 0.4809769816659798, 1.0963721073201156, 1.3024173337562561, -0.1293080539165148, 0.7076963261787423, -0.5397905567329171, 0.8415496330543547, 0.7784236978566708},
    {1.2014290328567117, 0.983027057102334, 1.2464976027332682, 0.6243768064604976, 0.9207189038168705, 1.0875170588309917, 0.7638505242676533, 0.9894703771900072, 0.8610499671905012, 0.4240279051410932, 0.9474162021055074, 1.2465980025892005, -0.3395001767919193, 0.7338617807936085, 0.6015180240600371, 0.8116268346527696, 1.1537951136647553, -0.11754757678767686, 1.1671682274871906, 0.8967590800442422, 1.1413818756468905, 0.5433949559645197, 1.1796566567669768, 0.809505300437599, 0.5480481467312547, 1.1147032423174885, 0.6954691627084939, -0.010460408987710244, 0.8541513484618732, 0.01369812427938364, 0.7841007553594246, 0.6788157488132782},
    {1.0908428218782256, 0.9560002460641341, 1.020267482862399, 0.6755850171061589, 0.9345279641150184, 1.0055677394902602, 0.8269351225336539, 0.8945753613574632, 1.086235322302931, 0.6676220932173375, 0.9913338089209726, 0.8016103435361622, 0.20693345527689272, 1.0230837219238795, 0.2302723153845885, 0.6246503317735042, 0.9955666324893365, -0.031141214991877164, 1.1666453253896216, 1.0414145741338612, 1.2988661160030466, 0.8142453284321769, 1.1454373743882478, 1.1079350535730932, 0.32150811588351963, 1.1370461114026178, 0.8091452182929322, -0.31384223765336217, 1.0126118162814284, -0.0025249593318453626, 1.2800677809541683, 0.7371731651737211},
    {1.2498992609048958, 0.9389121019708639, 1.0756330968609331, 0.853077273085095, 0.9282421956486211, 1.0352595633131463, 0.6344447107367677, 1.0917204093031148, 0.6006854308890153, 0.5910695148885942, 1.1632161629002196, 1.111699291907833, -0.18268294206674351, 0.8241449473195634, 0.04144539011893711, 0.45169222943148485, 1.0473060908221943, -0.09176793318394329, 0.9319411479674706, 0.807931868145104, 1.0544866651937734, 0.6249736653434316, 0.9523555406278152, 0.9121707005658432, 0.37250522172128697, 1.0834042981760095, 0.770401705539689, -0.05612329979537888, 1.060391929968372, -0.48758839007523846, 1.0209553463163525, 0.8192471788053874},
    {0.8272273167574475, 0.9769936436125587, 0.7573593510296142, 0.8453310644233706, 0.7948968939871056, 1.1407008801991603, 0.6407269277343766, 0.7408501903423416, 0.6439925549273025, 0.6984111815287156, 0.8767279987709814, 0.9782726624079275, -0.03850555940690303, 1.1119279792607801, 0.3401314403701483, 0.44104308142526183, 0.7784430641531854, 0.10359403258966673, 0.6770208856284811, 1.0490130359022223, 0.8040607092419735, 0.49455478568190325, 0.9551537042003361, 0.7385938755776856, 0.4165844519663582, 1.0502769687452918, 0.9097943012586204, -0.43791384727050836, 0.8822911735182394, 0.04080136530266953, 1.0101662408025571, 0.8065792482776675},
    {0.70538528614617, 0.7762011324171122, 0.9671666077223052, 0.8506412812221148, 0.8084343053569794, 1.3048762724177962, 0.977089648908491, 1.3725156764998154, 0.619903806773116, 0.771289922915865, 1.0892915653040571, 0.9029985940147821, 0.1367314920347154, 1.0836033859290122, 0.16673473380152845, 0.28885551905250695, 0.7953654545650877, -0.4087647461541052, 1.1122725800935924, 1.045669059699996, 0.7239956643051795, 0.7328674893725846, 0.928218702214353, 0.7792252653172353, 0.29499361747574354, 0.669612380283163, 0.9666065068627365, -0.13289727758741451, 0.7019908225219028, -0.11943790087691733, 0.9422312439999067, 0.7865617727234037},
    {0.7448174585115019, 1.1999954430322928, 0.9280899485002689, 0.2731494025137718, 0.8959384465277275, 1.317629252061191, 0.7344212394182219, 1.2283870083956192, 0.7511791416884638, 0.5756337021196777, 0.8404910544235384, 1.1547081732063567, -0.07010450242246961, 0.8583545073560461, -0.07236470731738139, 0.4562235624952192, 0.8850303926780634, 0.09278755095677498, 0.9449645364126827, 1.0205826585714075, 1.3036543268788496, 0.2466192851458925, 1.0447281048231627, 1.0648867616838655, 0.42750052937168254, 1.353158368800461, 0.798532862092884, 0.22165463088411572, 1.0641148785648407, 0.05237225860708279, 0.8748162470730835, 0.5088231727780936},
    {1.1822227804846248, 0.7790922370905972, 0.9606239358830693, 0.6321003156222816, 1.0352428813904284, 1.1224692015009248, 0.612216485030166, 0.9344368512704185, 0.5489491449621313, 0.40037847230484347, 0.9891671123397293, 0.796756786639733, -0.10794327790455438, 1.3729922441261737, 0.6070605617720737, 0.43921819516883204, 0.9704875696320701, 0.022483160130962843, 0.6184307500217857, 1.2659913017217412, 1.0033678966710586, 0.7156123562518885, 0.7398049475099396, 0.9731117426002793, 0.4403925569602937, 1.0015359886246447, 0.6835346689828933, -0.06820156141572875, 1.0055372305455474, -0.09266635830029352, 1.2126908884460885, 0.7805498272941827},
    {0.8268844556002267, 1.0710196369458782, 0.9549770521811627, 1.0718498152440823, 1.0892633606258304, 1.0074350627432935, 0.9487896730810097, 0.7879348656437755, 0.6816571646807609, 0.6092966783127078, 0.9371342558283924, 0.8845510646730808, -0.19953783336163153, 0.9869888521802239, 0.2864825416359646, 0.8994528218549088, 0.9689660903530365, -0.005030787854609843, 0.9461374109147682, 1.1791017275987914, 0.9553121901369693, 0.855870320608931, 0.6795002871573781, 0.9745975252123554, 0.43819244472481056, 1.0064020555906823, 0.9774489308614727, 0.057094947309359385, 1.1684181637412248, 0.24525035147595833, 1.1320803908128116, 0.8604555437438125},
    {0.8987637183626478, 0.7983189130176768, 0.7010990657463942, 0.8960158235321465, 1.0151669487763366, 1.294695442487191, 0.7135485257776604, 1.2513899808645323, 0.6317307364364078, 0.5437304302203322, 0.9841227413813948, 1.1007247267243123, -0.03219784422543479, 1.0311714933198894, 0.3846336215330379, 0.7274087894508857, 0.9506811568349501, -0.033372916537733305, 0.9001882452871828, 1.0450804227000754, 1.1243583939887942, 0.7679407892837662, 1.2418507507274563, 0.8127282964580544, 0.08239859115728505, 0.8392557608622497, 1.100397433324389, -0.10012498682668868, 1.1373903062286854, -0.1415069970867096, 0.7834238813569259, 0.5704127942046054},
    {0.8503462429889078, 0.9001418377653644, 0.9011859394487926, 0.7071030596578342, 0.9929854900705424, 1.1586159614659313, 0.7428504115757397, 1.186682000245395, 0.9363127779228944, 0.6479211845486362, 1.0557025083046312, 0.8226753401352697, -0.3971424213649589, 1.0125082934032048, 0.5025543107672754, 0.44189957995945384, 0.6664146555806973, 0.031008821763168534, 1.0042862166613788, 1.2934860876175915, 0.7819557577335853, 0.8184469837536171, 1.056126467431903, 0.7892474597955432, 0.7318916743411338, 0.8405699738779548, 0.915773051350976, 0.08269607766948306, 1.0774175628225744, -0.14599190051914923, 1.0343087723711262, 0.8841120914491173},
    {1.0323825266962803, 1.1747752239458178, 0.9323975849969272, 0.5839524828265724, 0.9177049840730053, 0.9901176051078271, 0.4670311510774652, 1.0786138293855678, 0.8400522719321653, 0.5081685129203014, 0.9878327810963075, 0.9192572392188629, 0.14814858824115332, 1.1072121655258564, 0.3321624703940423, 0.5186954757281069, 0.9255938817609379, 0.018801320959701936, 1.2449296669347611, 1.0277786719355724, 1.159172826087356, 0.9434492572826682, 0.9869376254470533, 0.6862832460626095, 0.5455103280166983, 1.0231141096693959, 0.92655261555625, -0.22681129318591592, 0.8309522646943938, -0.12288390811062241, 0.893468112556006, 0.61421959504276},
    {0.7544530188130096, 0.7623214799243886, 0.7385201246362931, 0.9810589988453541, 1.0738554216745693, 1.0334072263562475, 0.9035005324897579, 1.1343112222048533, 0.7824225962979809, 0.7811479303468519, 1.2751731406758322, 0.8596565842399989, -0.21792051853897032, 1.1617455091141557, 0.3315994606979622, 0.4762901071784233, 0.6147815218835212, -0.015872257148094798, 0.9158284154942422, 1.0438876772553016, 1.0520920586288205, 0.8219104811493156, 0.86013355054278, 0.7104101047706607, 0.7341902288846751, 1.1645561939914757, 1.1470003046902786, -0.13546824665930196, 1.1621774177448696, -0.2005361251177903, 1.0404218599396189, 0.8727777454814264},
    {1.1361369244587936, 0.8188369633776584, 1.0775060258687899, 0.7877575758305313, 0.9243563616992627, 1.1427205132769522, 0.9104867672241915, 0.4682904450901687, 0.8188394971058764, 0.7681571508233056, 0.9004311015055413, 0.991463911862813, 0.04386572228274063, 0.7591955080426545, 0.4885426692988928, 0.5815278534926561, 0.49006357133468703, -0.0664915147185997, 0.9023944212270872, 1.099497289218644, 1.0360741076556201, 0.5783005742136925, 1.0669809406033053, 0.8615220038030685, 0.3895972297544709, 0.9057871634160013, 1.056411000180208, 0.018068489510613125, 0.7525433496328117, 0.07093248579095539, 1.1040024387303151, 0.6000747206314312},
    {0.7734094072907604, 1.0766293946247665, 0.8749203071977829, 0.8245855621699338, 0.860478435609315, 0.9487212269993115, 0.45645670285973955, 1.1172866604141483, 0.6766780088087, 0.768483159297982, 0.9114259367639347, 0.8455136121200473, -0.02513104294209027, 1.4553650213748022, 0.1663294368429445, 0.7005132869677063, 0.8680706976143949, -0.3964298472919804, 1.0103994724407934, 0.8206036084726642, 1.0406218130966898, 0.2954732770326426, 1.0554813483967282, 0.748609306168851, 0.12209118720953614, 1.4279033497025213, 0.5509891799397232, 0.004938180763534359, 0.7894792766791077, -0.14066378296823118, 0.7338903250683156, 0.6986188037354959},
    {1.1428272516119031, 0.6647133380980179, 1.0821352685117305, 0.7373695017048815, 0.7778134507892205, 0.8277809068098391, 0.7409405963789654, 1.1319367159625024, 0.8073381917562765, 0.6192834606706397, 0.7961878717440182, 1.440897151981439, -0.037045545261514295, 1.1865813783336576, 0.2908728737889212, 0.5948960347840854, 1.1170038259867274, -0.14970155218130574, 0.9814676586154384, 1.0108624544307077, 0.9196524373263161, 1.070661466517793, 0.9808179541677203, 0.6085052563245632, 0.3186966133344873, 0.8893862709643083, 1.0051075281098372, -0.109101392286051, 0.9616658538917258, -0.20929923194601738, 1.06191591829159, 0.9306803511043233},
    {0.6745934628849567, 0.6456772937034089, 0.9506255988881467, 0.9944726037255768, 0.8090194044935342, 0.6975370785737781, 1.0773719511751572, 1.0283743018575775, 0.7435289207239937, 0.7465786312794931, 1.0488988997841242, 1.0585672252679401, 0.15844898912952204, 1.4329451256906152, 0.18118606612217364, 0.7102360958203658, 0.960160582021445, 0.029645876279188122, 1.2232166197537144, 0.9539110760820699, 0.8928562554594137, 0.8619594798043546, 1.156077625455161, 0.5411019352351081, 0.5356136782157844, 0.9272268399969646, 0.917530339919989, -0.05954470627641989, 0.9111182160962986, -0.2358522202183607, 1.1881328370731385, 0.646253337571073},
    {0.8778078124506075, 1.0040271431394527, 0.8486925959097699, 0.46611451041357843, 1.0382302322580463, 1.0585281203393393, 0.9577326482865429, 1.0241770958104885, 0.5246032654051005, 0.984371213372846, 1.0467520452739842, 1.2288457268269186, -0.07012913593126383, 1.074753116434999, 0.49892872216401135, 0.8395593964365725, 0.7477699152265251, -0.21512190822931296, 0.8640207413041989, 0.8694597324472839, 1.1375185842793827, 0.9711058513089723, 1.0539813112116838, 0.7918324711938982, 0.5968591208583903, 0.9705503080645433, 0.9452804778406053, 0.0974658680849256, 0.8348541798734163, -0.17622767558713961, 1.2292724574434248, 0.7962878627425071},
    {0.5481694136158495, 0.6269341658440549, 1.1008043138583268, 0.8007115283694255, 0.775781560282649, 1.0599472080283683, 0.6256874359960933, 0.9160946934960771, 0.8759710175985101, 0.9791662539324525, 1.0937691151050684, 0.8253884875067821, -0.4282118848654569, 0.9540381299829243, 0.4927455690214784, 0.40261396404700533, 1.1625627666818168, -0.29838449583505033, 0.9177786820794299, 1.216035416301927, 1.0609105680702624, 0.61340122857248, 1.1703362687232899, 1.0746682483238184, 0.5945930281320484, 1.0578649134066125, 0.9566716781727068, 0.010122281908580943, 0.8540725233762817, 0.0945692593081448, 1.163136380231429, 0.9637195881067876}
};

static const float b2[32] = {0.9249901484485668, 0.9947152017355898, 0.9368563994456217, 0.6454035302269502, 1.0821482227201555, 0.9738631551368617, 0.7149986661082668, 0.9967545010782273, 0.7855644499126148, 0.676183576615299, 0.9897440371484592, 1.103911078152689, -0.06230038401075713, 1.056884404005588, 0.23159602014855385, 0.6109393160875836, 0.918976543206125, -0.07786250099767188, 0.9326120130594485, 0.9495471799074263, 0.9604026264719376, 0.616774448386293, 0.9392442938340924, 0.7649043847673885, 0.5176123555410294, 0.9419153160509856, 0.9047829441431962, -0.08764596924686187, 0.8634588032231592, -0.11270535454829642, 0.9822900865292702, 0.8065480557758254};

static const float w3[32][16] = {
    {0.009128107544037983, -0.29481440085931526, 1.3861905638624208, 0.9283802185991741, 1.2016769978582513, 0.030173086585564567, -0.15187940775251543, -0.22112540523882102, -0.013539316194139683, 0.933557603870375, 1.1681279903227229, -0.1819414949723193, -0.29168633965260016, -0.5405087178572366, 1.2497421180102553, 0.15552351190417438},
    {-0.8593986917219902, -0.1819487770413407, 1.0134356834456513, 1.2880196894557152, 0.6733135584011071, 0.1498420042015372, 0.15714428589872298, -0.25882438493567006, -0.02264474275448066, 1.2947658039473693, 1.266182836202852, -0.21424187709929696, -0.30810947199344646, 0.015803348995975398, 0.9380461478053533, -0.09962811575602547},
    {-0.14670740559939113, 0.049967222030400237, 1.1376308261355383, 0.9672562968888224, 1.3997328875032922, 0.3701718057923167, 0.07863014508410367, 0.0048055330536324456, 0.10027277732603423, 0.9399765482571224, 1.392979103317468, 0.0036556243706551187, -0.40908150839485163, -0.12690919314921723, 1.1057444101250984, -0.3589476212766119},
    {-0.3717898265378046, 0.06658498733248776, 0.9567607353544602, 0.8280718456366482, 0.7344259337749712, -0.05073367024271273, 0.2531721334132178, 0.10939264717790878, -0.22622422304111936, 0.6053255293930548, 0.4151794282285725, -0.11442098129619603, 0.18444980242279088, 0.24006626780734588, 1.0967575019435134, -0.15374710963043722},
    {0.023744380845199822, -0.02952155382659115, 1.2420946208110657, 1.3234092231962917, 0.6942339364543592, -0.2348463519427406, -0.32731950280688044, 0.45362399348273147, 0.036842453311363606, 0.969428270155299, 1.1795509694496087, -0.34440848134701063, 0.10587101336026332, -0.023002132726341783, 1.2658980274900142, 0.08014330650187215},
    {-0.23943308844792777, -0.3842397304177559, 1.2711128014317172, 1.0117169504906367, 0.6025591019064065, 0.12587707291942268, 0.15885907140790814, -0.48146493901965765, -0.24711597075828073, 1.38749491623002, 0.9115193553510467, 0.25573992660470185, -0.5332620862626061, -0.3606870498516904, 0.9631410163117523, -0.5614111234986461},
    {0.1409867633754957, -0.15816217868843946, 1.0237537067433349, 1.1077662138902504, 0.38162104551472875, -0.11182746604849934, -0.3307612817784178, -0.27906610982027397, -0.0010794639620538395, 0.9585263320977647, 0.7805356338552146, -0.13427341548193378, -0.10403803739066551, 0.4173783419638699, 0.7346512855446995, 0.075942111743849},
    {-0.4023411496994816, -0.3999306006877249, 1.57059068525955, 1.1600776347060204, 0.8221585850750929, 0.057874460046424846, -0.03685757363358535, 0.1235413045387122, -0.27224926840302593, 1.0609118914716837, 1.1530248482700112, 0.04654586556778794, 0.001894587759565662, -0.11853780499507952, 1.0004981157841122, -0.245153406128826},
    {-0.4447721543506239, 0.23927737811286307, 0.7319468177022589, 1.440399494511974, 1.088561343280916, 0.3255605249456996, 0.1873747594641465, -0.22468772843032092, 0.4995328534008353, 1.241073039629677, 0.7903765941879728, -0.23440936368350493, 0.1758715738722863, 0.23601205441626377, 0.900664346620588, -0.45111965856800595},
    {0.12348098744127076, 0.21340390914560337, 0.6511279195850923, 0.940436747189116, 0.8609617773335143, -0.04375868078787888, -0.2017656176990507, 0.01693480157235783, -0.3382309799980532, 0.6794157856409129, 0.898088173628302, -0.06723680348877568, -0.36449824017266247, 0.0835229097273661, 1.0249365684986103, 0.16218319631286676},
    {-0.002001045056434913, -0.2580849845078115, 1.5166734508492725, 1.0820559487175692, 0.6781986400873284, -0.13208943718222516, -0.4349997684052067, -0.19012430675896633, -0.29267649307865035, 1.0431661908391023, 0.9686481816401665, -0.20253767599773964, -0.10625907783228751, -0.0709442542119417, 1.0250088182884407, 0.2952790648993447},
    {0.18306177423632006, -0.1994519210455674, 1.392953406995278, 1.1276552526666233, 1.0554756934889706, -0.07448576286343941, -0.17967390279487225, 0.3457452902313113, 0.11111763725022307, 1.422964830345494, 1.2356440385893173, 0.42045542293519145, 0.19148951765249758, 0.0636622142435119, 1.0174442336684146, -0.3296186107337133},
    {-0.379461685927755, -0.222173348132617, -0.04932154336847382, 0.18948166890686666, 0.47336606385892743, 0.2601602567258213, -0.16604023980993798, 0.2808595008984562, -0.19453109145150738, 0.2989691620611212, -0.507365795728634, -0.3526560353297079, 0.46022188552008503, -0.3964802961029262, -0.4470400968238572, 0.31653163134993445},
    {0.287015577026534, -0.377839036704657, 1.49578107367153, 0.9784472320009056, 0.7608593448361702, -0.18629509973706268, -0.07654619640467576, -0.3768845731896978, 0.4135041864538382, 0.9638954550945639, 0.9886832503599541, -0.12327207413982241, -0.2498251304995375, 0.302200989064341, 1.2668164455802908, -0.1497291170917958},
    {0.4431810385687143, -0.34157500716620864, 0.30277715404750094, 0.37905114543297824, 0.47361151037191734, -0.1172120589215107, 0.3611498717760973, -0.0510368666705758, 0.40044831871481484, 0.16279300605976085, 0.6051406264247338, 0.33463063473622384, 0.22697090801897482, -0.08572428628505815, 0.5631021353364932, -0.08285312097198719},
    {0.2245702403441833, 0.23047072446833625, 0.7998463570656623, 0.8184989901598263, 0.5865735922594981, 0.28582523104243335, -0.28710021989660783, -0.1875351979811576, 0.3398786745228824, 0.9825289173499413, 0.6853985983112724, -0.3126744405851356, -0.21431895700981612, -0.08466358925834166, 0.6081847346841981, 0.01605227822987539},
    {-0.017275261269310487, -0.2714703264546615, 1.253784498605659, 0.820746172428492, 1.1111363900764417, 0.2603060106375175, -0.09497210345289622, 0.24513306596223958, -0.24591338395734075, 0.9874721303663634, 1.0446618843395292, 0.02628184663595331, -0.0443913207194181, 0.2629417587896195, 1.1295133945418263, 0.01833724189866916},
    {0.0066875083616168614, 0.348502343800428, 0.02936911361021655, 0.23560911999844006, 0.41067052793821907, -0.06615514760360765, -0.3505831167090944, 0.3066777531639939, -0.02932602621743861, -0.2217514310613185, -0.11840281606338554, -0.02735071428388771, 0.48468008267632096, -0.10786537512216905, -0.47409300393737125, -0.05274230512627742},
    {-0.11899501138595589, 0.15421442003693545, 1.3626989946977905, 1.30944570750338, 0.8197357389917017, 0.3845751883949767, 0.0609749720716899, -0.1736979155969162, 0.38544671493377586, 0.8562305958224341, 1.3653319734546137, -0.31147151498680054, 0.4310285503500889, 0.0816482077573405, 1.4548993433781767, 0.04535345664660517},
    {-0.6014890117178167, 0.1077180694152318, 1.2996177997987077, 1.4162852412147782, 0.936200066576659, -0.48362488060969877, 0.24295139208300048, -0.2463330571039681, -0.13997756683237453, 1.442480632449821, 0.7913617733165842, 0.15915308056317867, 0.2367435835062353, 0.19474469071961467, 1.1803840826820873, 0.08519268645382984},
    {0.13719203320083798, -0.14838823670641496, 1.379624477443666, 0.9340954474326003, 0.9325273440826864, 0.3696763121385673, -0.24203751023437123, 0.10055894557589938, -0.36974975366583057, 1.0548810302718328, 1.5644987115153561, -0.22530359251659376, -0.10144009374126889, -0.08135110098568024, 1.0255289416913078, -0.48224404428999335},
    {-0.1667560810406942, 0.2176156213721208, 0.5048771462806522, 1.0269922593125753, 0.7796617710887681, -0.06315948295452, -0.026989179645086587, 0.26886092521916943, -0.22860237781706305, 1.1242514251291493, 0.7836469826450337, 0.4904340882706673, -0.4658914351065638, 0.2150485304707972, 0.9002001240896352, 0.2818380669354037},
    {-0.16155970777569728, -0.36429146809569546, 1.3311853859801759, 0.7005788673417584, 1.191626211658277, -0.21569177737838227, 0.3413828070747761, 0.021599786574906393, -0.12330587563689892, 1.1968290415045062, 0.8190629526387712, 0.12027581116472169, 0.042245365778949516, -0.36432425415878456, 0.8365874369390908, 0.022862113627807948},
    {-0.06706002754969596, -0.18953981880674745, 0.7580633155853332, 0.7804521432331599, 0.5677086598468879, 0.002776775521132021, -0.15480763790616672, -0.38183656428126744, -0.812157407772006, 1.0301280674188917, 1.2369875427864385, -0.11412375657017886, 0.05157894564114466, -0.325029220130949, 0.9811281709561154, -0.22909817759979875},
    {-0.1402093730481658, -0.044532583675508476, 0.6044714160423702, 0.5418048181898122, 1.0771961267844188, -0.2023264157929262, 0.20422636678454487, 0.09806162093591175, 0.09848569046495147, 0.8505958898522706, 0.16678109489633938, -0.10254990026005618, -0.054445725811575904, 0.43283817168361066, 0.8825504862197883, 0.37807152087328894},
    {0.7168900726070525, 0.15657795245156536, 1.3749796766945226, 1.4607367754530614, 0.9308968794258898, -0.4479703883146811, -0.12776363668263552, -0.39319113369195197, -0.45291689970088955, 0.661619855801374, 1.3723527653283112, -0.4784522896196562, 0.10600902187618824, 0.15192964588741092, 1.1034107283119743, 0.4212366589584119},
    {-0.327725541917671, -0.48755826240884925, 1.0853963958751591, 1.2418489724919326, 0.9765782459503788, -0.3421280338094033, -0.5390571732315049, -0.3570818815927935, -0.193409507263754, 1.0208568869025973, 1.5691177919614787, 0.357094805770201, 0.11809812737089072, 0.28940814374392293, 0.8949856095586896, -0.5795609872884459},
    {-0.4427654816309267, -0.0951100666982917, -0.04909774651360736, -0.15070041545805127, 0.28384094091568707, -0.08053215898563755, 0.19732141380788806, -0.4878069981477786, 0.10409386993704048, 0.06936197450829153, -0.3517128837418159, -0.023807942048257417, -0.6586441330489787, 0.11544415121477535, 0.050817489985955144, 0.2205827754133632},
    {-0.28333685556343907, 0.09950911374819653, 1.41518081771692, 1.115184783151815, 0.21074782763616348, -0.2129910654196946, -0.40408246217282223, -0.03416656438869732, -0.3396428193175608, 0.8272040043334472, 0.6274704606828774, 0.12612875720775796, -0.2918079305684655, -0.5446151040662761, 0.948101849209036, -0.13853279564453844},
    {0.2606180096301122, 0.009233786659957019, -0.1210111018053375, -0.3428705552578098, -0.15132906507126412, 0.008179462842150882, -0.35431084907577826, 0.1669551676772271, 0.023137654935724096, -0.031608332824100485, -0.15846595466826144, 0.1151351236412624, 0.043535719218261396, -0.5197825799182235, 0.0840618150278945, 0.5050590574785817},
    {-0.021498301193852043, -0.40159030169782495, 1.250260080390394, 1.3733945071798797, 0.719574009747378, -0.006562307184331796, 0.06297502770239777, -0.29316905985630637, -0.3238125964052195, 0.8922410604261765, 1.072616487708484, -0.27911142573561665, -0.2759773617896464, -0.20506415365307795, 1.405689041849707, -0.24321883887146784},
    {-0.3242816089235342, 0.2653184874154598, 0.7511252347841555, 1.2839502619724288, 1.0547627160050728, -0.12478940896863774, -0.22821385441699782, 0.23419511193936368, 0.023966476054999877, 1.112442917817566, 0.7782149015503292, -0.39255221308084914, -0.004164045669622395, -0.16761579916907401, 0.9235360043485018, 0.1823607118990492}
};

static const float b3[16] = {-0.04325708585511561, -0.029638574374895404, 0.6698733739895516, 0.753173660583784, 0.7020619014596691, -0.054194525096081324, -0.026050705392135436, -0.008926088289831309, -0.013655759275221108, 0.8486260147489002, 0.7430873626672907, -0.01278644129395721, -0.011295733822351562, -0.04061691215180513, 0.8073574679921705, -0.033175604797205};

static const float w4[16][12] = {
    {0.10806006052477266, 0.5212733825998342, 0.4744980845330792, -0.1376120382478056, 0.093666074487278, -0.7123657460160703, -0.6476098444069174, 0.3792515086288487, 0.06490192370212113, 0.17718969927159092, -0.11986295546792676, -0.18071178719765896},
    {-0.1979400755925189, 0.2995046759514912, 0.4049570241190152, -0.3549025306362733, -0.09282455076059366, 0.7934814630630641, 0.3504027744390764, 0.32765939102266833, 0.40643203386986543, 0.1609200702698493, -0.13776081702540738, -0.6945150300597576},
    {-1.383926056128386, -0.9177403304416493, -1.1019576026953921, -0.6953656473405652, -0.8796375213258221, -1.1541951187976978, -0.927302578557092, -0.6329717555385552, -1.1807907555834978, -0.7640668813250856, -1.1174895879607656, -1.006132215815682},
    {-0.8191454650080342, -0.4390722381633522, -1.0264028557311464, -1.233943014366131, -1.5599498202406652, -0.7165111132082123, -1.1444084712292115, -0.6372942769540224, -0.3121742438258145, -1.0965214382241448, -1.0409424018603555, -0.5764894141100821},
    {-1.1180928927357827, -0.8497522336822122, -0.6814020233240575, -0.8692909311644624, -0.7253790971193826, -0.4965104368140064, -0.9129517334140856, -0.9437562140795687, -1.012446905657937, -1.3497503511753843, -0.5526685452404446, -1.332530369527447},
    {0.26998344620227355, 0.1880667855301024, -0.19295138164632256, 0.03166722403234643, 0.06560193071984759, -0.09493380023055238, -0.3973571343042609, 0.1982640256892551, 0.029599121862802967, -0.12979738292908485, 0.37136862586417335, 0.251780625839193},
    {-0.0539532448740177, 0.05947592751182412, -0.4670982084766148, -0.26459773094996897, -0.0997694058580063, 0.038981932933799285, -0.34107881302275894, -0.17424928145302498, -0.629850365001585, 0.28222936704739193, 0.27428424965643183, -0.28191237984353223},
    {0.18511581165926178, 0.16903134276807485, -0.0005262793138799975, -0.3436356489691103, 0.17693767382027775, 0.1707728318365892, 0.49624398681670384, -0.07997786190291736, -0.37423366189623586, -0.4160443444093839, -0.06699663383103799, 0.4084811873219878},
    {0.21193601794632186, -0.2674483409831242, -0.22757780798283822, -0.042979482712239565, 0.3911880328387957, 0.08637004228003901, 0.16822299744982802, 0.03309351597361411, -0.2740928744591634, 0.2889869252121977, 0.3605347921601587, 0.23052618834210883},
    {-0.07088059139433102, -0.5783724380970053, -0.7692904180724216, -0.6813494566408548, -0.9770306276783204, -1.1247519074397672, -1.2610135134625833, -1.2382063872891402, -1.1132786481242547, -1.0251539073329161, -1.086420201567734, -1.4208534801009023},
    {-0.8435717305379473, -1.4080211151790336, -1.2769513236301873, -0.8319533896516255, -1.0512019885235857, -1.117486875126656, 0.04502366706024245, -1.250913582787174, -0.6583203301852885, -0.8205706163910146, -0.844177213616005, -0.1594575161670348},
    {0.10980990148882928, 0.06545959088253221, -0.6418906346112705, 0.18935134858953212, 0.09602723982393778, 0.5310923757178027, -0.5247279308775938, 0.11171094816674623, 0.08063732728322516, 0.01497724918992593, 0.08932796634954875, 0.14511832617793807},
    {0.6330042652222054, -0.2439189531768392, 0.1319860460253787, 0.4697393192722863, 0.002086854431471925, -0.38748569533827026, 0.22184561646477738, -0.23176642743769732, 0.554565171477928, -0.0772666822925725, 0.6756014017735649, 0.24274665983185104},
    {0.1543340297242639, 0.15911654247828386, 0.8004402137877212, -0.4049904376624645, 0.11555244897694546, 0.11122024505153837, 0.17053530327920152, 0.058744543338828344, -0.14436743963783646, 0.020088580520575817, 0.535636131552415, 0.2683022566561049},
    {-1.3477751180808422, -1.4150519144342892, -0.6764228122173285, -1.286292754416151, -0.31153038013363743, -0.8981246613371859, -1.3922822681435436, -0.9847102942381789, -1.3345112649250692, -0.65500601445968, -0.8531238859842403, -1.1678046218517701},
    {0.3342124963845815, -0.86994398476563, 0.21599423145072125, 0.21616895519594068, -0.5496490845752674, 0.3965509765135232, -0.41474021221518703, 0.5095757322138923, 0.013643952819123083, 0.6009850296561189, 0.3864296789344075, 0.35757412539258554}
};

static const float b4[12] = {-0.3674225317592665, -0.34055270680124033, -0.32362075903090465, -0.28288136510044676, -0.35819329453432047, -0.3269159694093949, -0.30244885626095613, -0.2507335688088014, -0.2401219568998709, -0.2271591342671594, -0.3431662118479904, -0.2081606581845597};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
