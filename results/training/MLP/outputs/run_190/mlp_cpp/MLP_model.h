#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-2.245130437218669, 5.130469669784405, 1.4944772653907905, -2.1943283870290777, 3.0498482345353093, 5.764954966164792, 3.509641301607041, -1.1331251025439382, -0.02884359846943315, 0.9619922865400576, 4.488032615541234, -3.5412575619833264, 0.13619515212451505, 5.188714101928383, 5.718030061405824, 0.3075643262681167},
    {-2.6345523424020048, 4.536239849316077, 0.651995593563373, -0.9065888372489022, 1.8312907720323324, 4.552397926931445, 0.00876316306530148, -1.2738156235375286, -0.2593293448365968, -1.5073266949238728, 3.6261934377127956, -1.248599013966707, -2.1914081839247395, 3.1502023906602017, 3.379368805776448, 1.2718330417468862},
    {-5.702625338307426, 4.074113283339199, -4.388533215680954, -3.4618503726700576, -2.355217889634133, 3.9800886761095735, -2.9924606080959992, -3.957896494430188, -3.755251718709647, -4.946359930460792, 3.041341009241235, -4.728787358511238, -4.303337813190385, 3.7762013934320757, 3.5716156594133786, -2.4103425732726023},
    {-5.8454899508808085, 5.515994109679103, -2.7274566598624155, -3.5009218247464498, -1.3698801320949523, 5.372362648153454, -1.399691658831795, -3.6329242383357556, -3.7291486702792547, -4.258330567928007, 5.114080910455353, -5.7543654940121876, -3.369311044017251, 5.733911166252695, 5.222503277501526, -1.6759503603859671},
    {-5.570838664208157, 4.782280700823199, -2.5426994818174147, -4.424727579859326, -1.971911691918182, 4.280155045882017, -2.6141112764773147, -3.9589846525966124, -4.875553962460403, -5.334841432001985, 4.685549478036669, -5.300344251839655, -3.906638147478002, 5.569995239896433, 3.6283567626640583, -2.9558144419730783},
    {-4.368708975606428, 4.341763170017209, -2.356235000711244, -4.312723392990977, -1.5218900844041976, 3.6539682366588635, -2.734265739740538, -3.0119506411059493, -4.177837190061619, -4.54205874590097, 3.5358892867482896, -3.6792283166387123, -3.988718834791502, 4.687743899540598, 2.7556872718421803, -2.35009240142931},
    {-3.5429021309223296, 4.473686283468621, -1.4769728161896616, -3.869900263910647, -0.40174274682376826, 4.048114272539427, -2.0157753509348293, -1.9210046584312734, -2.398964620604674, -3.824018776863217, 3.2620923179328907, -1.581188916570675, -3.1663707035523436, 4.481554790733639, 2.425001212463167, -1.0164361978906573},
    {-4.619146606302803, 5.1378747049234805, -1.1463710392915725, -4.33856261634099, 0.21388486156653422, 4.646843907797558, -0.7280024365014814, -1.591100337591945, -3.051593744350726, -3.2435830154664633, 4.690035656733543, -4.201359722607832, -3.805761222129927, 5.458112669732013, 4.387969338532307, -1.0629946156326366},
    {-5.592487268544063, 5.101317085823763, -0.9760924002857501, -4.271038034077813, -0.027336129672802276, 4.999849473028727, -0.27367986021828067, -2.102896233030584, -3.6877494767020704, -3.377875566450028, 5.206831257136881, -5.182221993757853, -3.5809181824672125, 5.508889345932526, 4.800616334267046, -1.2434784600490902},
    {-5.676489001408911, 5.662523514838092, 0.16391662963608356, -3.1222832031551646, 1.0300873400801103, 5.733181622027035, 0.07664941673980795, -1.4513980607881074, -2.901176192703643, -3.8862045685296747, 5.905226592595358, -4.884572503401873, -3.264667572326759, 5.312562357827432, 5.467697705592114, 0.6185517220286552},
    {-4.295966151303265, 5.4481851349006485, 1.2865699393859307, -2.0857198134582107, 1.558300656788969, 6.0543955568072745, 0.7739387887790645, -0.6596415820087357, -2.5534099084893205, -3.3606010514635796, 6.010954842534323, -4.066561521394708, -2.720222517891942, 5.0718549889386795, 5.163726729425897, 1.0531188728911012},
    {-5.270867143020586, 5.236494953440167, -0.06850646422104799, -2.620623344521354, -0.047395106382676556, 5.38859721370616, -0.2571206321368658, -0.010141412192298036, -3.3067132716720877, -4.442775481869905, 5.92584439353192, -5.505045972091186, -2.9846549566922542, 4.636404374232216, 4.937564313741589, -0.07888110969249408},
    {-5.785956216777622, 5.448640442765025, -1.162966727982762, -3.093506831345039, -0.8154003560625126, 5.370314778173752, -0.7857601825824746, -0.7716522220234928, -3.47606291832137, -4.776905543583669, 5.858721354305225, -5.876487747940097, -3.6001189440210988, 4.831775725906791, 5.1804336137527, -0.6708074499248845},
    {-5.63943773183999, 5.508900310149672, -2.017691517379262, -3.6548074410586753, -0.9726641952613, 5.1760363262668925, -1.699431561883403, -0.30783052858518445, -2.954128632827123, -5.261097906906645, 5.864691715692018, -5.784258751463302, -3.8340850339934396, 4.851865213392181, 5.332026416333547, -1.027400847532517},
    {-5.39594385081767, 5.547550948548394, -2.3483909019074583, -4.0276938008505585, -0.018127504548390693, 5.136294286655665, -1.7406729262592755, -0.13969935918156082, -2.8852721707042237, -4.3955955200841705, 5.491557450839922, -5.526646784527674, -3.956989825142555, 4.97715884853383, 4.770513344341294, -0.8437104015484176},
    {-6.259375009409148, 5.426420315610764, -3.087970052854192, -4.393904335388204, -1.0598726996325742, 4.5290687938529395, -2.640295372721822, -2.1352533495808728, -3.183903154587236, -4.981020791893549, 5.262599605853508, -5.35034099266323, -4.8307505912457795, 4.874622991157086, 4.681616086880911, -0.6598020830320741},
    {-6.450980508462206, 5.254660409023029, -3.490973695819583, -4.637634433302373, -1.5321157510281291, 4.630824494005435, -3.0360579000320955, -2.899953105269746, -3.7780085147708538, -4.99786775621977, 5.376278615058556, -5.688751082111688, -5.06586038717152, 5.56309050388619, 5.07408657766061, -2.1635124027287382},
    {-6.165674571741362, 5.333490390910082, -3.8421457416997673, -4.690653173673461, -1.8435064870530524, 5.026099655597344, -2.6168726227434, -2.1508500191136406, -3.825351199004653, -5.181577090012047, 5.406609761591274, -6.219084386757319, -4.744348688593052, 5.346193706472151, 5.535695250313581, -3.0700106013602753},
    {-5.913395584099934, 5.727666285767684, -3.2740202163448813, -4.224474754119973, -1.6237703776440686, 5.423231821152675, -2.2614519652810143, -0.5584011969397443, -3.3886003161491076, -5.1833484517032264, 5.72972234753235, -5.741019740852447, -3.6260739845942034, 5.472875673696835, 5.753694705436271, -2.502045028052365},
    {-5.918110535426501, 5.897418868855943, -2.5438441668650347, -3.877185379419191, -1.1181165315573616, 5.641249010874286, -2.3490184786854127, -0.5246618343579834, -3.472745326582632, -5.260338616527465, 5.760044122021714, -5.495968243603662, -2.8282326744489827, 5.5917095925769535, 5.596789355811641, -1.3505327928204667},
    {-6.344465029482776, 5.651957196304805, -1.9884080536167836, -3.3309244187584697, -1.0655042453649315, 5.2652558263454745, -2.4986530799076103, -1.1859004717326, -3.330067861078588, -5.314108648433526, 5.91246830590879, -5.759607386139309, -3.5074573866264833, 5.163807140136927, 5.655853118559695, -0.8503220519836789},
    {-6.367880656468816, 5.952006518867392, -2.0433811012904055, -3.425645748017228, -0.33552438536148876, 5.654620986573776, -1.0547581632431546, -1.5756652420511539, -3.4782811819526565, -4.7047511877257016, 5.772157821659385, -5.929582923812726, -3.3544656380734827, 5.770347366994233, 5.974521078734239, -1.1631722393598813},
    {-5.8934931665615915, 5.840097321716807, -2.009387666561029, -3.260954197143532, 0.3802629399313263, 5.901720434972013, -0.20543101297845334, -1.221820721876374, -3.0674288053378453, -3.7305642201069262, 5.721059652004599, -5.687394348046922, -3.1929724581034256, 5.800174288230009, 6.035048829735605, -1.6034868209932815},
    {-5.9226540067574, 5.456646581269207, -1.9393958577582948, -4.017098759315295, -0.6415866114837915, 5.30140757250017, -1.3241725306009873, -1.750165064098921, -3.4946744036104214, -4.395600964679679, 5.706111976692769, -5.991561005137459, -3.9700807675335414, 5.392930287376918, 5.778894077191414, -1.3314217495873395},
    {-5.815498902711816, 5.39504950083942, -1.6011162136712052, -3.3665468158415255, -1.1380508831981255, 4.724430031753578, -1.8232595263006397, -2.6844044300684593, -3.8342569019548183, -4.128236102847702, 5.3682731372022845, -5.398117802345286, -3.9000450499076535, 4.74784359529007, 5.1854093123667395, -0.8470912362671661},
    {-5.411589795327598, 5.762422520090175, -1.723588694371575, -2.5558452015483017, -1.145270501185856, 5.203743992377936, -1.3509667814567343, -1.0137394511558235, -3.1032626395280345, -3.777713784343633, 5.82872896900775, -5.339817593068339, -3.202386109088427, 5.118555618824478, 5.546118318287149, -0.7971617460195949},
    {-5.689175562444111, 5.7980436572852305, -2.5010422409599253, -3.153814530110415, -1.2668935007395035, 5.145930746185239, -1.595672123298732, -2.2803337074912076, -3.7238952673584818, -4.261648098943309, 5.737884175060835, -5.413687509349041, -4.257621838610826, 5.070466822576473, 5.452509833512342, -0.8067141485150875},
    {-6.023154146169379, 5.260045592352134, -3.0754070200769053, -3.796189518183719, -2.115209766117471, 5.197230983142713, -2.8646964069999417, -2.6116278395190795, -4.060111928091032, -5.002766321141105, 5.017119029839927, -5.687357363413278, -4.1551094360423635, 4.810438791982663, 4.852110978601162, -1.5065683518652355},
    {-5.44413518685377, 5.151171661331122, -2.704212035450467, -3.35841236701764, -1.6887128267784437, 4.764529985333486, -2.7086668569676218, -1.5970749645799476, -3.2268196573723773, -4.571839066572677, 4.690881338277371, -5.2952789117139565, -4.0095904420496975, 3.9812912266671234, 4.664576328441171, -1.0893132664840721},
    {-6.22533487876174, 4.791992713680976, -2.2750960890066154, -3.3419238139997263, -2.2692819912905016, 4.1689686941855415, -3.0870457497179027, -3.0280445472622977, -3.848429450007497, -5.039587164647304, 4.709856449909079, -5.935779792600189, -4.59899550464109, 3.9159055901309734, 4.558504216249552, -1.6421565596177141},
    {0.38713046255908373, 1.7270527749504074, -0.14425118288995326, 2.2642143598915228, -1.5132365449508065, 1.6098839505770248, -0.38261600782607863, 1.4299530843047794, 1.0833448824390628, -1.5824612719349804, 1.5466148975848315, 1.3892794208193064, 1.4736488402123917, -1.0928645720634507, 1.831480201261455, 2.0085285221294757},
    {-2.312526997645661, 1.579060625595153, -1.657309002773221, -3.179949793616298, 0.11285023486433035, 2.5596981262923704, -0.0521556055379564, -2.88356435584012, -2.9628610306835914, -1.1972832407299394, 0.2800932569199656, -2.947161641722097, -2.7187088716943837, 0.9735247823931394, 0.7484584032565332, -1.7971304547002078},
    {-2.118948307110659, -1.1198943636892218, -3.308890688513969, -2.5779262524322295, -3.0520001552131317, -1.0406407593241684, -2.589779365231973, -2.2063851565661605, -2.4835052445738635, -3.232247970916403, -0.021737944946645375, -2.5564946136517515, -1.8109360358871442, -0.08971838963884338, 0.1287057327965275, -3.1715216621736206},
    {-1.6768582370517142, 0.664649290165656, -1.1961691152904685, -2.2300397914353005, -1.4411969289339603, 1.6186503431846302, -1.4128720876347556, -1.525548472270249, -1.9331141675685708, -1.6389068244250704, 1.7150076834844354, -2.175990995038419, -1.8703548586600711, 1.0425320826090614, 1.0986521754334426, -2.031396998865226},
    {-2.2101395690010204, 0.38668256461453626, -2.8878235515636455, -1.5155454833559237, -2.7569078332380075, 1.3604159398511804, -2.3204800729550317, -2.573067168287345, -2.60545430442489, -3.0172539465713637, 1.2268480675166429, -2.018839541086407, -2.090332923280857, 0.8047022754936511, 0.6178502663015214, -2.1635509704459923},
    {-1.639607790632347, 0.6150685874879007, -2.156084123680256, -2.4421101725184076, -2.109631131591586, 1.5406531210457726, -1.4629630981603123, -1.9672526264790866, -1.8364446088306037, -1.8201408149152798, 1.0030692859303751, -2.1186076183469407, -2.3336404770073256, 0.9875996228036218, 0.9725037501884001, -2.077569075006334},
    {-0.9936167299277084, 0.05031890659928826, -2.1343601134795884, -1.8960394071451925, -2.160921434664308, 0.8893813122239183, -1.7093009776500607, -2.270518235480093, -1.9932894523601303, -2.1094474469289883, 0.47598305889244913, -1.255773163052245, -1.9970411199653706, -0.06474575990622426, 0.2344001346466556, -2.1031187323947735},
    {-2.3921262734884334, 0.9123892075432053, -2.3778935753887516, -2.401914365183107, -2.0493634872631974, 1.467420334282827, -1.9160753626294664, -2.495622971075318, -2.659703005546469, -1.5944114770137965, 0.9787983785926221, -2.7604876429152734, -2.5619765867773765, 1.2499015230321162, 1.2309572979848544, -2.4859394662607346},
    {-2.8729611636550474, 1.4846828410659234, -3.4179925518241956, -3.14633683198813, -2.608364563460678, 1.9300811383897751, -1.9207289438468658, -3.1467995595995433, -2.9613233576265645, -3.1273491837589575, 1.8681198893680526, -3.365593207176212, -2.572994634799316, 1.412214647931489, 1.3121200873343033, -2.9896327175583495},
    {-2.651105923884655, 2.413291124961636, -2.8610611895441966, -2.4078061928907157, -2.2601609608494937, 2.4613465987070158, -2.1642000883385637, -2.3320876541044435, -1.9573752026179658, -3.120229695306524, 2.2761167445132453, -2.5950109429646004, -2.018131939888888, 2.0037381734371893, 2.217547622001666, -1.5741020431468047},
    {-1.3706200590770232, 0.626784158338303, -2.8224793999903293, -1.6333171459123308, -3.3270123493795567, 1.0992195801388667, -2.713347820865362, -2.5731963869858174, -1.755177417073478, -2.7220185422068326, 0.8170539475923566, -1.6982829285621877, -1.0695938957657318, 0.44661912503037265, 0.4765322268820367, -2.2106591502195645},
    {-2.2349291025358102, 1.2029157655653782, -2.550284256108744, -2.8594596889009827, -2.9330373852912293, 1.6855386442188334, -2.624248502558383, -2.1995351220447716, -2.4976729854559148, -2.872356873688931, 1.6205826337297904, -2.4084689167490465, -1.6947782747533238, 1.2858956929329202, 1.321957851530537, -2.5397368663943776},
    {-2.083730094315779, 1.1705949157671964, -3.5305439941667704, -1.9961020637770566, -3.603677586608119, 0.9019453787655713, -3.013045685642774, -2.85033178088117, -1.8590359545957365, -2.9129584454090427, 1.1755101371723296, -2.6983312852406223, -1.1540651176675034, 0.7724033558626059, 0.5981597241650086, -2.6087318210277837},
    {-2.3968147654727376, 0.8347773610842717, -3.8932832868548632, -2.5274536636368508, -3.9360802568812914, 0.8118856641064015, -3.2684244204956423, -2.67467843946122, -1.7924707498101227, -3.3947366089906796, 1.0091968296375617, -2.064175054830589, -1.2027072326202954, 0.48045705622111645, 0.5853938951173477, -2.9827200190349985},
    {-2.5166674623123204, 1.0446642389365142, -3.1855241320080014, -2.742562523173813, -2.7756588410644896, 1.3913090947240585, -1.943578252100766, -2.692311964708841, -1.8952805821693004, -2.9313429863048843, 1.18721831283926, -2.6366871552264843, -1.2019008582554729, 1.088671785399338, 1.2335519464523395, -2.7915367450713755},
    {-3.4292528456328624, 1.0262116497247367, -3.27705924475871, -3.3918437416109364, -3.3014583651789753, 1.1861675557133506, -1.7416967527235372, -3.09382384082753, -2.9552876985541756, -2.8296628514988567, 0.9362276861374496, -3.100661223401184, -2.372946404588997, 0.7586183226534934, 0.9643639974659743, -3.813772899019569},
    {-2.540578722112932, 0.515368373170205, -3.997785593178909, -3.2890845694143476, -3.097677239017237, 0.8139053405110472, -2.195468453206921, -3.371142795301572, -2.0933274874002996, -2.669060910041371, 0.9401880518665955, -2.297710300774231, -1.9852385935858472, 0.4803413502040738, 0.5966950237521669, -3.6722461063935636},
    {-3.04795101823991, 0.7883399608290695, -4.069995337535496, -3.067823770071507, -2.843262491949229, 1.3624264838626972, -2.434621747670838, -2.7423236550557313, -2.186353466470401, -2.9959670405768732, 0.9728510989858515, -3.225228185745489, -2.2547975401816838, 0.6776675660798338, 0.9710300600020527, -3.329347925953548},
    {-1.904066363924243, 0.10185889402305547, -4.07098146263864, -2.488509002411954, -3.561018544534941, 0.17376315071122142, -2.5122658799238384, -2.658609012733132, -1.877089184939943, -2.7865033284715595, 0.46735097957337984, -2.021341517796904, -1.9545505671531465, 0.195404043510682, -0.16274004402974343, -3.129227572254049},
    {-1.607523358494097, 1.2129422238878595, -4.3445885080189655, -2.2581766819865603, -3.6344481905025, 1.3844629689059624, -2.8130846241347913, -2.218863317476066, -1.0536367587751807, -3.4779474886201, 1.2411367737714747, -2.03092258004848, -0.6785334996714123, -0.01726105471095903, 0.5913599004767768, -2.0870629374155834},
    {-2.2852814334934872, 0.9439146500649218, -4.095702934557091, -1.8034361407925856, -4.297318135542284, 0.7734017379910043, -3.279913134347792, -2.8899135483933627, -1.6265103910541812, -3.8276269428671537, 1.1161160940908157, -2.1460356285685247, -1.6222548957902045, 0.08432409257046296, -0.5086203766987037, -2.7733650509990255},
    {-2.797054172733595, 1.3419827161131326, -5.034171333675322, -3.5444116083372554, -4.715333857610053, 1.5603672743916823, -3.0381528606873576, -3.911423261924974, -3.0294468564438035, -4.305295582935935, 0.9492665529043702, -2.9859123137500134, -2.29757756381954, 0.9411840976223265, 0.751398985134546, -3.944417632074677},
    {0.15497620932093545, 0.9880844595807863, -4.544742969877866, -2.896250815276784, -3.8646816218138245, 1.0465731791633728, -1.4258559993651243, -3.1905567495400606, -1.633923689205987, -2.5849970459517984, 0.29431384266479527, -0.35471556094030604, -1.106971626899107, 1.0223745964764133, 0.4719498051084894, -3.2300952522914224},
    {0.41922554969477216, 0.7587843621818782, -3.616728383399977, -1.6368329228527634, -2.8896470217659447, 0.7185689226525147, -1.9213079696692446, -1.753732339125703, -0.6450113672574614, -2.2410123746732076, 0.6913799078444202, -0.17464321704748928, -0.6218153742203417, 0.5871846589467236, 0.21960214088510308, -2.035672656115843},
    {-1.131394147850842, 0.20568358715829305, -4.460222084823384, -1.9630916982337032, -3.4836765889937324, 0.34522586793890286, -2.9248207529337407, -2.1017595924158528, -1.6427923934255455, -2.7951850032593697, 0.5165598718800593, -1.8016399242711696, -1.4051104717384788, -0.6854710604059131, -0.1468125289822568, -2.76672065961935},
    {0.8014809779452772, -0.2248548344879459, -4.143634522599685, -1.2356734576022688, -4.359350241551708, -0.007898423957899699, -1.5879756462464705, -1.5644869425874506, -1.0299422673191119, -1.3162735964843697, 0.03756471009839537, 0.15678005929126398, -0.19323990708181665, 0.06547187368157031, -0.02034399970244622, -2.5759740906604485},
    {0.23337788833313025, 0.9264305049074267, -3.590644214718605, -1.7782864988695093, -3.4259218804821687, 0.646089673214346, -1.8421687663045365, -2.4613958398894438, -1.6368958484486562, -1.1331929456682237, 0.4273564796653107, 0.4503915558229687, -0.8187379762344239, 0.2890612608422852, 0.41328848803502755, -2.1347945219683253},
    {-0.40593218669596215, 0.330016762141831, -4.602501744886077, -2.5211451412757633, -4.493973147024425, 0.12380213397564684, -2.1524350819237896, -2.9635505928659254, -2.4191029136382345, -1.237666015270785, 0.006593830254639954, -0.6078034260701801, -1.5044013324562366, -0.2502477810953278, 0.2767845453721326, -3.1976282710715562},
    {-0.7683066948886526, 0.34508356445983357, -4.533671677452184, -2.814217360543067, -3.7773825098744345, -0.03393063164185356, -2.0958935901865785, -2.440034962140001, -2.2493434793992853, -1.4114651815526185, 0.2661256161251041, -0.5275987250955547, -1.6203596208019295, -0.44030453719622376, 0.5441373630661069, -3.1695472273376226},
    {-1.0970486577288308, 0.4094352451613091, -3.9348976046719355, -3.04207313835698, -3.430785446703885, 0.7772203853623153, -1.7558443361676448, -3.5211567670518327, -1.6191012417425286, -0.8793873304393404, 0.13360636909386314, -0.49718196975967643, -1.4313574117686416, 0.002791745933391911, 0.9336504251627067, -3.398887762758488},
    {0.26568434482571424, -1.8804356622298943, 2.314404034117773, -1.8504997219900186, 2.3537292199321573, -0.7891963520024715, 2.630306409218535, -1.8988594228846727, -2.155680986306203, 1.8606746216170393, -1.176294454533405, 1.3040659264593535, -2.505706712044833, -0.18929500044057102, -0.45016082964722154, -2.1653133534679965},
    {0.10702765702764659, -0.6306169939849605, 1.8636664937498992, -2.2237425869610234, 1.9508595718646193, 0.3821254055686746, 2.6238675353225727, -1.9119780724734508, -2.0573417445146434, 0.8933949307419807, -0.12366541913548042, 0.6291750274907913, -2.451781398664457, 0.9962258095922567, 0.9661372024359771, -1.8380884336805476},
    {0.08033035789411513, -1.4683175127311408, 2.964266696822044, -2.382045959987992, 3.7343889469997356, -0.4614002203449573, 4.122061895033406, -3.0805490075196342, -2.783171581653978, 1.8912465751198724, -1.4054614991043028, 0.35459177102178274, -3.183181127084393, 0.6802682358214754, 0.5637385723997764, -3.234393569686352},
    {0.5868045948505233, 0.19103512607885628, 3.3024633713120575, -2.1322399386891506, 4.090184043290417, 1.19903758399124, 4.464247914240235, -2.35277017603447, -2.2522578314501, 2.1313128404933233, 0.6133266565552663, 0.9394127427772615, -2.5143384626995564, 1.8795970454924469, 1.7566538144113066, -2.117548741722483},
    {0.5736950779106861, 0.029446613065465217, 3.328009647501391, -1.6591865807609198, 3.473387805187133, 0.45695711694477675, 3.8006501516944415, -1.725430696335656, -1.8683000817004507, 1.9376433345139543, 0.07434706477403817, 1.0023384790495797, -2.4676558316057817, 0.8318831824833686, 0.9962995946735904, -1.7665286741635675},
    {-0.2119375198573799, -1.0961431741339065, 2.499336639853407, -2.9702331797492674, 3.2464027169237686, -0.49114706383938544, 3.978764258625644, -3.360949457609879, -3.1284396857594046, 1.400369425377526, -0.834536947705163, 0.4465565400340754, -3.3971338886409415, 0.7348984220414863, 0.46581508847403746, -3.212858832904385},
    {-0.1346519614720334, -0.17014458633768045, 2.690482080147497, -3.4117109229031324, 3.488755823013713, 0.6353374818124229, 3.5308606976904007, -3.6399870246637667, -3.4242531028562357, 1.4524044175524036, -0.15216982632970144, 0.5694811594616296, -3.9363512967996503, 1.2334579106243895, 0.9723756357903957, -3.540779566658187},
    {-0.93865417839326, -1.0203068129116741, 2.6885724030314466, -3.5227551031247386, 3.4739444948690044, -0.09750551031988505, 3.584580908726673, -3.5460220772103717, -3.850444182084791, 0.839438601454039, -0.9172868008083298, -0.309973571652232, -4.126077691992744, 0.284119686236487, 0.4650458425566624, -3.771798198250383},
    {0.4651166171130397, -1.109035379377966, 3.759195641894457, -3.105860560249993, 4.250688649442369, -0.35455016676552514, 4.558029850347814, -3.1185965921853316, -3.2681267450552585, 2.64306187375854, -1.1749195735057443, 1.2880312468401862, -3.733003715710256, 0.7209926852133602, 0.325869995152739, -3.377955292573649},
    {-0.020349104277834287, -0.45712998357238743, 3.3965953362611936, -2.282979203697728, 3.616361988014111, 0.30457942112359476, 4.703929758873982, -2.5560358416516182, -2.8903723319347536, 2.753858009205744, -0.4107022306711065, 0.9640377132241056, -3.1294232769034176, 1.4900777317920126, 1.424040952705626, -2.800732770083607},
    {-0.11696503391172408, -0.30050699387318647, 2.9364688459963753, -2.6093575913043314, 3.822412301212215, 0.6899786363694116, 4.745032173693962, -2.210367338856581, -2.887715602317066, 2.051411305760248, -0.01447689854956205, 0.29609361715584226, -3.3643343301996125, 1.690378985029196, 1.3550638612798744, -2.664627547955474},
    {-0.41101852664434596, 0.056116867414558624, 3.337563738243297, -3.0518261299419516, 4.243273429438169, 1.0386616499353227, 4.9466570857837615, -2.7466158592905523, -3.17319645228013, 1.9503069705243972, 0.25530664999432495, 0.49647511957802215, -3.937156618243889, 1.8565733184694475, 1.8602525012321856, -2.78415387431657},
    {-0.9276709105596211, -1.205577182006127, 2.7897486930534243, -3.4140248289647626, 3.6930137988147913, 0.281881953522426, 4.271533454822169, -3.4439706860451444, -3.902995907171003, 1.9755118327894063, -0.5571360860891093, 0.20895802139902525, -4.43119805627352, 1.063243439901513, 1.1119145401675778, -3.818552908324361},
    {-1.2547924733949747, -1.9204486572944348, 2.1887110161379377, -3.773892049857617, 2.8512602444554633, -0.3324783443381332, 3.770444192294808, -3.9139000858223647, -3.7821279688967775, 1.0777897695816314, -1.4502850758003556, -0.36599529870925174, -4.016840348125778, 0.09337173184642603, 0.1679790038360277, -3.861525041498747},
    {-0.9401662941160631, -1.7629926780289185, 2.619694066667114, -3.3089086910764225, 2.7975320390598064, -0.2637678403654414, 3.4042457096774275, -3.445683354830264, -3.2974323490944535, 1.497356175082331, -0.9768121654437315, 0.030466306870477553, -3.583185588827359, 0.5091391189419336, 0.654433323341299, -3.4683680461577184},
    {-0.680208603028143, -1.49674155206544, 2.9054267877177753, -3.039874333166628, 3.3834080366375043, -0.2560687915965794, 3.904856203946892, -3.099517422934858, -3.620961765368476, 1.821985546552296, -1.3176773579646854, 0.15403613337433225, -3.8850333065377414, 0.6915183672199852, 0.35700543180364713, -3.3355814236805017},
    {-0.2782199194027458, -1.18158440049339, 3.8144259957909457, -3.285669786378075, 4.510304905976959, 0.009004991386587382, 4.744477175545743, -3.1978856234041535, -3.5825361199809524, 2.7710821093290976, -1.2479519087476811, 0.26357451959834777, -4.1714907133206545, 1.0547994905684102, 0.9869292781843317, -3.600626531066079},
    {-0.004194442624264323, -1.5844097681338356, 3.6847433734160795, -3.5100771826807335, 4.348984437687416, -0.11098915522418795, 4.6633822335539215, -3.233318530420847, -2.858881398412184, 2.1685496111982165, -1.1375176793923922, 0.7642542459371653, -3.821460524451005, 0.6455793986866597, 0.38731079244526095, -3.3827855692619506},
    {-0.4237829019325754, -2.1046705693560295, 3.742114986716277, -3.4718966924683308, 4.00621826064754, -0.5192561475568827, 4.7024848746962595, -3.5678645915700726, -3.6958960231234674, 1.9258305565077203, -1.5868648969179164, 0.3431865568846295, -4.222283068008752, 0.1575153093303222, -0.05508072378750877, -3.9591213581742486},
    {-0.11764959668675926, -1.7149736432121434, 4.252609855599979, -3.3053197948216355, 4.50914066861231, -0.16993867389678852, 5.095495763367394, -3.377616424443936, -3.2133888684475913, 2.4279517691045336, -1.2037196784943753, 0.5505458580168509, -3.7609024880444695, 1.0433612402078025, 0.8619125561777011, -3.56324431206574},
    {-0.11521976690016468, -1.876281404419126, 3.892174915115885, -3.103697881739313, 4.617809173561829, 0.1458762431019638, 4.821699554222351, -3.268748229011654, -3.3091218537062406, 2.6706921794745013, -1.1192021632719562, 0.4339031413799106, -3.7949243414490317, 1.4524689146834453, 1.2797590613205687, -3.375073660805816},
    {-1.152962678849862, -2.069634321415276, 3.839416494394232, -3.8591672536456936, 4.57645966223222, -0.1807571368569455, 5.091969397013106, -3.820723307033192, -4.078081933316788, 2.0175365054373247, -1.6921244161971545, -0.20623576197378998, -4.460237805285762, 1.135418377080186, 1.0055850751282294, -3.89407148589759},
    {-1.1579537768354302, -2.5883547017935324, 3.647439437651307, -4.2140195628396135, 4.2653546697267615, -0.4826050242661359, 4.9362694981929245, -4.15744433625012, -4.1176561308872035, 2.1038423292888893, -1.835698170017325, -0.27173272488918887, -4.525998729717057, 0.9071291735442063, 0.5474037292946571, -4.120472401057898},
    {-1.1741696773642203, -1.7754606629274858, 4.24686423322897, -3.5709838233820195, 4.367952685179919, 0.10274432200592444, 5.117867340544435, -3.606852797104448, -3.7960800936567387, 1.9750692485094155, -0.8411904304099095, -0.18317790978996384, -4.4752607524175465, 1.386208416319497, 1.1382646587155227, -3.913233823116691},
    {-0.7215288619866431, -0.985812131070401, 4.300688526217615, -3.7183889444274056, 4.735364417508151, 0.8775837953550949, 5.066128604936305, -3.570932880843611, -3.8615803117887326, 2.1683447617463893, -0.4352400734695751, 0.17296316048007587, -4.435535186120149, 1.8560246634263813, 1.5272897049413394, -3.831289066101185},
    {-1.1812073386812585, -1.8434055117713144, 3.86915883820756, -4.163554425820012, 4.628000897146307, -0.022982163375035492, 4.779126581357763, -4.137145298059809, -4.257706900028243, 2.1992564829540004, -1.395545598394625, -0.37610111221547143, -4.6104592905780954, 0.9453435463027637, 0.5615049230638424, -4.251878944579276},
    {-0.8614241717208799, -1.9595198214122773, 4.417873953069644, -3.992827117018528, 5.038297280630269, 0.2904191761607202, 5.19106033591135, -3.7227947407681934, -3.994671187130268, 2.341948782095187, -1.195169778152672, -0.18382664317873226, -4.548714149971697, 1.7107452364176128, 1.1149704846039243, -3.859684824913804},
    {-0.6451073516437069, -1.3010648152915794, 4.103388766766889, -3.5696912424027794, 4.819858634571451, 0.9641982979489164, 5.195481108147412, -3.3718546169900585, -4.035152184493416, 2.0756955337813556, -0.6690887303077379, 0.09139243164374891, -4.308876959576958, 1.9483181501695555, 1.3533406225830054, -3.7478982106097565},
    {-0.7579862989050378, -1.094254397921499, 3.6555915902792084, -3.8686646969795007, 4.29383422203257, 0.8569749898011317, 4.734744194188733, -3.643841613614928, -3.997447655585983, 1.8451594995866856, -0.6476932513478376, -0.26691081789861726, -4.079527477292916, 1.7556864257510696, 1.53263981178761, -3.862487233677428},
    {-1.1020643778491679, -1.9252634580988737, 4.148939994442676, -3.5821171316632814, 4.602415416205884, 0.3343488367245263, 4.848894469926715, -3.715177531631485, -4.085622737428948, 2.2161902224856718, -1.4945108532404454, -0.03752739257530457, -4.333558614617565, 1.3060522649156405, 0.9524713272844598, -3.910138476081841},
    {2.25747925908062, 1.3928485271044249, 0.8778143583849105, 2.973639229828502, -0.06220645292765064, 0.6736807490040649, 1.4503530394583646, 2.4402848598202347, 2.3090242957212657, 1.8276012409896236, 1.7242713340857028, 2.460025175897313, 3.084305642466133, 0.8039301219353658, 1.4062304231861489, 2.466278707216259},
    {0.4227935893926134, 0.148425632695257, -1.3312478465704483, -1.1326072621157952, 0.01366202156258708, 0.13152304235816034, 0.19964056919620618, -0.33544044343071006, -0.768254996370252, -0.83417708679584, 0.4411046831647054, -0.8082834791226294, -1.4128927851096826, 0.5390442660555983, -0.8759195957471911, -1.6359417358514428},
    {-0.3113662293606623, 0.5820011316872765, -1.4222786989074032, -0.5189626561121148, -2.386704619097794, 0.5998108844086043, -1.3996377066320698, -0.6385156495976715, 0.3842448309053965, -1.2082449874631727, 0.8191441790557326, -0.7446049894331509, -0.06922669709323057, 0.4246344537037388, 1.0183168654767802, -0.22221059719561254},
    {-0.846020445297219, 0.6555948778734285, -1.5767444415081378, -0.7885355811781587, -1.7554473266974444, 1.2246861025403895, -0.6789703576776378, -0.114894983299234, -0.2821285099207602, -0.6272146620167879, 1.0991906333265316, -1.1773495856899094, -0.11047157372609548, 0.8703055249746561, 1.2093645627734713, -0.470999235340979},
    {-2.0157278091945785, 0.30799757010864526, -2.980705890679475, -2.1101124902908164, -2.5836929168329306, 0.7353117665485152, -2.025159853232109, -2.1827448536841785, -2.171938235981532, -2.16989572076571, 0.2648480623903116, -1.650508242647154, -2.0274418068983064, 0.9122655308778994, 0.41814426356202705, -1.9161180867149767},
    {-1.0635050888569988, 0.8451620526106356, -1.8505191431170545, -1.4183149530548198, -1.6560859130272472, 1.3497252894281666, -1.3292979898207646, -1.3484074092331677, -1.2482918489918386, -1.0347135189244248, 1.3268486267488286, -1.0508073501992217, -1.09114852708032, 1.1202228239842698, 1.144102683531944, -1.1858568524418303},
    {0.5638126870223886, 0.4941408883668434, -0.5370424801476159, -0.638067050071252, -0.7111178618436647, 0.8651236501569927, -0.2803524242024678, -1.1556398742876781, -1.2991856560338304, -0.3605918211018306, 0.7727966191245879, 0.1410375958076723, -0.9931726280972615, 0.25526569078432126, 0.5002308933283096, -0.6258590445524037},
    {-0.967803133123256, 1.2774428456987992, -1.021857028275564, -1.1789466736424823, -0.2587128571564621, 1.3540432309706667, -0.9194028738427529, -0.7659320343124404, -0.9275599384100773, -0.47803820403799424, 1.472722958644194, -1.0901702829285096, -1.1517572788065262, 1.1621409040495836, 1.380296652590059, -1.1110239230593801},
    {-2.1777767139988504, 0.9784621554550336, -2.2661440327329263, -2.3865571536975416, -1.7224843518226223, 1.4831107902749407, -0.9393400190125053, -2.450427897664509, -2.720963087252466, -2.3786125092717825, 1.4309368776883231, -1.948630953663651, -2.5858464107053374, 1.2311712841129672, 1.0064769901011903, -2.257427196541044},
    {-1.3273702897314998, 2.154346939412058, -1.7809179354381819, -1.4703132360256337, -1.4701072328507256, 1.9423387088588235, -0.8793241280310257, -1.0233573550965753, -1.5775464055835438, -1.9833480483911587, 2.463224699476142, -1.224005632981802, -1.1011110962982238, 1.877759280337543, 2.059661868644849, -0.9900551261762672},
    {0.985745448698652, 0.2804852142586013, -1.983365946974295, -0.7687698375529488, -2.6654073769334525, 0.3243587735818447, -1.9143446529282324, -1.0940414168151522, -0.5555990501679636, -1.1518727863631377, 0.20849995950123826, 0.4699645340854813, -0.23064454046559668, 0.3636886063940523, 0.04457535252863243, -1.5273276585054658},
    {-1.2375860599842243, 0.7500834689268037, -2.9723555246529703, -1.8960952187393663, -2.949681656056801, 0.9490781426684403, -2.805255727083809, -2.1832170752648445, -1.5598574857124017, -1.9922734039931393, 0.7913545147324426, -0.5934576691986962, -1.1697929574563122, 0.388660037133333, 0.8888339268942282, -2.308498002732581},
    {-0.06211892076237382, 1.3091235625982316, -2.0461921347933245, -0.16153124580371991, -2.1380713253717425, 1.3464186966436413, -1.7300768714069794, -0.9952800605383206, 0.058345986662016174, -1.7452508817620174, 1.3947347784089128, -0.04169935092719112, 0.011060169727470143, 1.1649631203273205, 1.175963194601536, -0.6412785958819278},
    {-0.5044813591725841, 0.9240750610408703, -3.185727432693709, -1.1892362497342333, -3.419741101245628, 0.6084399714365535, -2.95311972078602, -1.3862468467282978, -0.7500278253013899, -2.118315158658979, 0.916605260459109, -0.4825508503699311, -0.21468730366207298, 0.28808952588165604, 0.2812903458542499, -1.9166444143759762},
    {-1.1217112146829338, 0.6848492759369966, -3.06366865672923, -2.1635832378774373, -2.923881660070202, 0.47496802154148404, -1.9162161683056413, -2.0389281976713054, -1.6589638417269903, -2.1392428639124392, 0.5975684764347613, -1.1956433306069607, -1.0440421800000128, 1.046633790864622, 0.8000241176596667, -2.510365824018964},
    {-1.5466150124299562, 0.6071000422873478, -1.78505155106778, -2.6517624340912587, -1.7992830775873208, 0.710729382081202, -0.9192902845571159, -2.5575082049722315, -1.8393439390743962, -1.1710572444260192, 0.7288462406327859, -0.9044712658084687, -1.6617619326442978, 0.9555918275931549, 0.8099880210160921, -2.72152985871523},
    {-0.06531949375311899, 0.23489935749435167, -2.156564443248062, -1.4116348353517865, -1.9095510104871032, 0.31746991076148817, -1.1035704821093075, -1.998888159284952, -0.4723485796848038, -1.1747884768365158, 0.5927904566611886, 0.4628685866929146, -0.16858910741950203, 0.1309474402761305, -0.1515170896204726, -1.8746871461172507},
    {0.10521717712444591, -0.15771145407945855, -3.2282393558939697, -1.9978756393648063, -2.8775802700514115, -0.22734026082999684, -1.404536383742358, -2.7823905492925523, -0.7166300696705253, -1.9101025524021433, -0.1103871702357898, -0.40430315012628987, -0.4319031616882686, 0.29107018101679005, 0.047179851372399176, -2.978679422478532},
    {-0.08795673908120229, -0.7996294322429557, -2.8895098447457377, -1.9367304223661719, -2.8114476495401814, -0.32179694161591055, -1.3164974761873125, -2.211243077144408, -1.601490050058105, -1.84045015986719, -0.37545771399863537, -0.22117176107020656, -1.2170178374983225, 0.23563071794849574, -0.15508198975565196, -2.9333274941671332},
    {-0.6500017406207498, -0.5952907694824747, -3.224114573274457, -2.4420377118324077, -2.700163474304638, -0.13895171311621035, -1.8914045830585071, -3.194646767238041, -2.1872530623137494, -1.5849354567229101, -0.241759834793646, -0.07287643425937589, -1.5061781775473355, -0.4948825813344019, -0.22894464040542162, -2.9523523441073336},
    {0.24663716996612509, -0.6395478577631659, -2.9185734316247838, -2.320257312390012, -2.8128644952105075, -0.06535319360669474, -1.301624776247107, -3.378164939295858, -1.5302488788285982, -1.2247232113712598, 0.08221096766341998, 0.9641251104764581, -0.9111930951189534, 0.44598993828267736, -0.11674432920653587, -3.6601988189683268},
    {0.6229673636873374, -1.2200399760571032, -3.8138643246278883, -3.0614233644872972, -3.933547514139894, -1.4623165597665755, -1.7292642150577886, -3.345434919227546, -0.89666927017886, -2.1452942217730717, -1.534728584721221, 0.22416138977231162, -0.7994553100367866, -0.06316296629759785, -0.9673623398287332, -3.4835427695541874},
    {2.505978740402743, -0.5460565565619585, -2.530062105606671, -1.0567057198228924, -2.6702250122425735, -0.9467083958400475, 0.7212841468018774, -1.20220441414126, 1.0786304909492375, -0.04783799116887559, -1.067433067205409, 2.008696540337056, 1.2015919724654505, 0.7265432008779281, 0.08046952893855774, -1.5439045197589334},
    {1.1526199293087696, -0.5676136889240824, -2.8273560623001672, -0.8796424912205738, -2.7035506956273734, -0.5816653829876791, -1.4288945231888297, -1.8371245809480112, -0.1195304091635344, -1.0386648484339984, -0.4279572888376418, 0.9308214388923209, 0.10292583838697063, 0.27745075915064293, 0.03466253180771819, -2.191516863236885},
    {0.06093390277200994, -0.8122755231537993, -3.146173835525846, -2.34934448984889, -3.0162085873714264, -0.8828886501038108, -1.8217186669982262, -3.4823612127537715, -1.868952847204101, -1.8302410441405332, -0.6296323685522756, -0.18614572427306925, -0.8574955430122476, -0.7511806562597305, -0.6216964634119421, -3.707977199298419},
    {2.252126716808227, -0.5197415067250021, -1.6032884756741292, -0.8044184920279648, -2.376207528270931, -0.26536783208432746, 0.8494928448861574, -1.1376755858517633, 0.13598064779364516, 0.10517646559041821, -0.09076410169751592, 2.1598945076283815, 0.8012113174115694, 1.0712548608671442, 0.3811314593964276, -1.790312031290066},
    {2.0650525192927365, -0.10622651084598811, -3.1163371227438863, -0.9979925802677747, -3.0267481024482628, -0.33465076046946457, -0.8238138307819209, -1.353450267150914, -0.3746256829977683, -0.20146106178834974, -0.4263460454033895, 2.4636731962221363, 0.05144956739629898, -0.026512349892158275, 0.2180179176452256, -1.6914583339869713},
    {1.4517188792515792, -0.8725867823183612, -3.7592762930985066, -1.7834127309896755, -3.5513220289889107, -1.3035990353189864, -1.0554649883294658, -2.442924465328743, -1.3123720310897296, -0.03525254219241575, -1.0355376659202948, 1.5839862973142387, -0.19457568103394693, -0.571193476595448, -0.12179950505149349, -2.9079331828235233},
    {1.016498320068796, -0.8917920168577232, -3.506425416825202, -2.7044308403782558, -3.309348346620857, -0.9759161239242716, -0.8364074640659837, -2.7299560020289175, -1.270962066878478, -0.6284520911571596, -1.055870538537038, 1.2724449093867145, -1.0256574777864804, -0.14833711016015969, -0.547910772577961, -3.520059461804594},
    {1.3638466544438406, -0.6870614792992146, -2.867879139463659, -1.9241014176260076, -2.632917063940434, -1.0677771654871457, -0.49929834325976424, -2.1447941937429285, 0.6577176922147949, 0.45651270099066954, -0.8835615126857314, 2.5614294735270886, 0.462889531493459, -0.35322590718678637, 0.1293298635235884, -2.1915348113245328}
};

static const float b1[16] = {6.764168869108774, 7.060382427962415, 6.986462344889878, 6.527497303685409, 6.745839141864662, 6.6446905816586685, 6.909425845472453, 6.771525211675415, 6.594837257283285, 6.677748138906174, 6.723050547890998, 6.871508509565463, 6.620373227198003, 7.038716022889023, 6.9550680861980085, 6.842084826935207};

static const float w2[16][12] = {
    {-2.306905411305649, -2.1473731599085557, -2.768423206778815, -2.4667907417214527, -2.567509023451764, -2.9007333995981077, -2.9050807910031753, -2.572538973159954, -3.1950616778211254, -2.767874186777568, -2.819884225993316, -2.7659744498433603},
    {-3.1685422611434415, -3.3874124795176335, -3.6894454846979916, -3.8652431225976067, -3.98149160172594, -3.4503321842478254, -3.197735094410895, -3.083453390795544, -2.7987332999035877, -3.467778177289846, -3.5858295069334063, -3.0239688271442544},
    {-2.6815375809419937, -2.8237116319744437, -3.031516066074137, -2.608958932377474, -2.730417795324672, -2.859334063382335, -2.792876757374831, -2.578848613855208, -2.769009867803158, -2.0792225659283683, -2.5314545498392342, -2.7951303446770885},
    {-3.0349821345800874, -3.1648308947130457, -2.247769121823562, -2.9098278639853166, -2.4097724160538156, -3.3449816748769696, -3.0154280104428453, -2.296312910355594, -3.420014853687602, -1.9912215211262403, -2.9392608450610287, -2.3571225887400553},
    {-2.435447447017145, -2.8728640138679378, -2.266810662605531, -2.2205823389568824, -2.6602537860039157, -2.588853951212561, -2.5345475160667377, -2.6530791270739713, -2.93052863277918, -3.1179542122013872, -2.8196941052642623, -2.605185887942437},
    {-3.1428483326313024, -2.956241343714744, -3.3654300524057352, -2.924769790169689, -3.3267356494338074, -2.824993045476772, -2.59385480252792, -3.5876501468407964, -3.9058290346494284, -2.671540369670899, -3.5487488788948345, -2.343963329065782},
    {-2.9492259016653044, -2.3311043574749686, -2.646200301894869, -3.1262596313319415, -2.687999378552779, -2.621203127287508, -2.636122467677741, -2.735172747819228, -2.4874490440209645, -2.5139632820024205, -2.582598582570368, -2.5844240457463505},
    {-2.2489073615155277, -2.3494341954264883, -2.061923364517779, -2.5941179746021223, -3.4154647070951514, -3.1359710990031022, -3.064304861318361, -3.237918372813185, -3.0330932667347343, -3.3182535153558366, -2.3671091588721542, -3.6243786119741164},
    {-3.380872587583923, -2.2114576616298076, -3.01377848512168, -2.7221862735074613, -3.1999604198656817, -1.8408938493737652, -2.1932998013358254, -2.901286690916098, -2.2148989125998853, -3.4336558471741307, -2.7214462626318934, -2.883638900244088},
    {-2.2179207955558238, -2.281407224886925, -2.2782438934028213, -2.752952877603959, -2.180148410188081, -2.2047543064450026, -2.288574908408701, -2.5107338881208983, -2.450525090166044, -2.5194088759867723, -2.8371366863441914, -2.241109010663178},
    {-3.430184587263534, -3.2062371922065114, -2.8076754664872037, -2.8120764538972396, -2.6285485361591903, -3.3710865264532734, -3.6952819447939924, -3.1616258938093407, -3.842713652921879, -3.2836521551747593, -3.044224690402226, -3.9077286638932733},
    {-3.081639854615943, -3.3441304634505045, -3.0681648202329033, -2.4051145778378498, -2.9600893822037926, -2.6032406864266466, -3.146822772006849, -2.9175215811517234, -2.290085566684448, -3.0564023793628246, -2.1374255675729863, -2.907565544174872},
    {-2.324370363359649, -2.975917874605606, -2.9206116500116464, -3.153307287266599, -2.7178014755879984, -2.9459299595847988, -2.9170482383209175, -2.946999850760331, -2.5399784776236376, -2.492556097205686, -2.972379401609045, -2.6401638903667584},
    {-3.455445323824435, -3.261847386554595, -3.193447911211192, -3.591773124133516, -3.471435973455176, -3.194599852321972, -3.4893037898660486, -2.492817907861233, -2.510592272982968, -3.409984108888655, -3.6258947627457503, -2.8827305174846978},
    {-3.0337868243714747, -3.045455915996013, -3.045168315782304, -3.271365929711401, -2.888218064431504, -3.1450174894971568, -2.9733661202973316, -3.618019701731785, -2.898224905326537, -3.1135289089581617, -2.2137196261495875, -3.7932487920873297},
    {-3.2477581992898834, -3.4700652775187395, -3.7339095235414117, -2.906877056601919, -2.379797451641726, -2.7751504088732144, -2.864479433154591, -2.865862035180408, -2.94137553215632, -2.7865643475142488, -3.21772195969955, -2.582796974594217}
};

static const float b2[12] = {-3.141322079785148, -4.021223806737335, -1.3003720660509466, -2.6553109967367265, -2.641304810892732, -2.3029549674041534, -2.0715427102005286, -2.657690574343399, -1.618653321775121, -2.722619399817854, -2.3452641636507874, -2.6387504831849182};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
