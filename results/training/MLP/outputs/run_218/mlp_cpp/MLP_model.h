#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {1.025348088921427, 1.3546663421122866, -1.047119780389081, -0.5727515223907409, 0.31273687396860733, 0.6869924347980745, 0.11039987181768283, -0.5985024238488741, -0.5315961595254651, -0.6332518846432155, -0.8017189321723229, 1.0048205753858792, 0.34741785077981413, 0.7113953492327584, 0.1866112793897591, -0.6086453232710725, -1.1785853623707865, -0.2275373375191247, -0.3703058069818166, -0.25830561542698377, 0.6453966119968401, 0.6985171575187138, 0.3919844425068647, 0.9933711178031474, 0.9913172536005197, -0.8831141431276912, -0.40047350165294326, -1.2721237018176792, 0.6420645036962102, -0.680897598782015, -0.7705182950665073, -0.3886887122173466, 0.9105525459007546, 1.139606340612615, 0.3559258687911612, 1.503134090783209, -0.15934278494451815, -0.7305925931571052, -0.830475222123275, -0.5366647072124001, -0.7616615977062663, -0.5968006149613174, -0.554008588977915, -0.08036113849947427, -0.25551159229469633, 0.14270565940527977, 0.16264986239507975, -0.6316791913234312, -0.47535077014127436, 0.36396158949378055, 0.8267756548677111, 0.05378517140424209, 1.187795993649037, 0.06764063815160684, 0.2561542380096175, 0.9896300839175457, 0.8856552861989849, -0.6139226221901655, 1.03678800298701, 0.2417907819406067, 0.9301798262651313, -0.43783545302673793, 0.6924154665176647, 0.9144393415116575},
    {0.37094704812328794, -0.5472142938647395, -1.0335573960636841, 0.5747644251172691, -1.1473556664648772, -0.8821985261448991, -0.18312188904909, -0.9225148372273708, -0.7772440732906662, 0.7398120085159818, -0.3007393206412933, 0.08562075940572186, 0.2010352506740008, 1.4072498327175007, -0.36437861375825975, 0.4799578819166353, -0.5078608594977386, -0.6245557705407471, -0.9848607756910975, 1.2725687773030439, -1.0242670793131647, 0.2983920008040218, 0.812713313039807, -0.5778987963980218, 0.12352282644772891, 0.18496271644262716, -0.46751335625462254, -0.40173067773718896, 1.21093337962132, -0.6352288405426968, 0.4712481100033463, 0.9308004906529481, -1.4943175797947175, 1.079898268042754, 0.2051821917249731, -0.04486582251949082, -0.8036441135824908, -0.8559440083690729, 0.8741147286978818, 0.994071148941854, -1.5354312323774377, 0.8784114035933288, -0.5487065624932035, -0.30036647678551903, 1.3353918305056907, 0.19782751072135182, -0.5314942369519224, -0.5652086533384704, 0.32915514873299, -0.3286056155167155, 0.9098665191291245, -0.016432582083612285, -0.5008227823920521, -0.25777196810722536, -0.5560232763483411, -1.0796827107386473, -0.046336402181604924, 0.4402309064742021, 0.5517781549266818, -1.236287971222889, 0.27999510669927513, 0.06172383703627514, 0.9342195170451609, -0.2653277148414354},
    {1.7847475589996777, 0.5427544640245711, -0.14180888594647242, -0.37502979567810596, -1.4068315288086297, -1.0921234703829703, -0.3444784155853723, -0.910527088050712, 0.8941334213668838, -0.4338149335520675, -0.7295981571118159, -0.7169987998254677, 1.6511465588745748, 1.8076154847612538, 0.33237882874894475, -0.8052669474873114, -1.2031029207620656, -1.2003429082837809, 0.3214090275580742, 0.6862290132916096, -0.9382815104638631, 1.067984454134867, -1.068305654597043, 0.2767895200945417, 0.454000107292457, 0.6278073665593886, 0.12601393188924676, -0.2588049103007625, 1.6306704376657348, -0.6200563894983031, 0.7380035349388944, 0.2311605187525482, -1.3771771579725707, -0.2567796673597917, 0.23620279928952218, 0.9336283231164013, -0.045520267943566575, -1.4039236100230044, 1.2493602437449016, 0.9594601779145644, -1.0133419632825267, 0.03506023897239574, -1.272778558243789, -0.04966397216366556, 0.16613118451327744, -1.5011703030742205, -0.5955627219906634, 0.030767850520714, 0.8253567961091534, 0.6293271486909349, -0.09220389773969778, -0.8392407740550902, -0.015597598986592288, -1.07131533260147, -0.02177990673478656, -0.46091498916386175, -1.3639043347391664, 0.9017902889407658, 0.12593835617014842, 0.0986572077197567, -0.7173393047595464, 0.41961531594049883, 0.34592811541373275, -0.08101272708411152},
    {0.852018562692206, -0.9928087438578603, -0.31305310233406997, -0.886063031430011, -0.4572459579448068, 0.44189915859135304, 0.40673719789415136, -0.7401431245212506, -0.2730221601210599, -0.524644638170939, 0.41134402297713124, -0.9945059528007784, 1.1674416135486838, 1.232148015805294, 0.26511068467891297, -1.053054600804668, -1.031287205264484, 0.1640694757325871, -1.388439655650751, 0.4797638276666747, -1.3291651537932914, 0.5321824298070572, -0.07288081715038276, 1.1099732034150782, -1.0972238863823, -0.0061531041828133395, 0.5688954824265128, -0.5680756148933311, 0.981923739604553, 0.36590885493815156, 0.6429371630548762, 0.4324198889733914, 0.0799716342889848, -0.4290915271768002, 0.19477231616754792, -0.38855120330899945, 0.43204179354315025, -0.9282552198642178, -0.30939369965964925, -0.14931866933205698, 0.09593664852338972, 0.5489548148931721, -0.8338275593167663, -0.8757391243429058, 0.7644369128703884, -1.4386712101704349, -0.8531209865295518, -0.08597794708491688, 0.03871128149061588, -0.08060937667926331, 0.7671656144750688, -0.8312836128896091, -0.3091215578588864, -0.80631305570211, -0.42440463123019945, -0.8253389188388552, -1.6916181335367113, 0.37926352189277124, 0.4148866548595206, -1.3149462124970086, 0.7161737430555073, 0.165819190493346, 0.7529442247688138, -0.6943151152597952},
    {0.2347347558850111, 0.2590122737990157, 0.9108551801475756, 0.05698658365391064, -1.0111196119999764, 0.6785735001335407, -0.5093331678224061, -1.7730628813963998, 0.1483890967148925, -0.9244420082937377, 0.3240157042010951, -0.31383148710813974, 1.1067192679294062, 1.3486353692939157, -0.7510183028143709, -1.5997021657086838, -0.6066394958525979, -1.2168837897942397, -0.16972344725636035, 0.5009731381986985, -1.4100583497884824, 0.613968854812584, 0.452073258861781, 1.1174348220515382, -0.9953193846092722, 0.7426834384413876, 0.9035484544822153, -1.4116647068836503, 0.32983121461696874, 1.078901901491468, -0.8035153916634359, -1.136628070025041, -1.9490596548953527, 0.24470607090902682, 1.093274567236217, 0.012599110244837338, 0.6009959910862079, -0.3910964339970818, -0.9203206204082274, 0.7548466094405684, -0.9936523409763522, -0.931062389808957, 0.012614669543734962, -0.6756418012441598, 0.08518395052643028, -1.6008578566720988, -0.6483996263060294, -0.39331438384529427, -0.05476820550684225, -0.26386959956376727, -0.38727151734181875, -0.6138597483144277, -0.8332822026094768, -1.4223676186248495, -1.1961029435688089, -1.6298221557506112, -1.6555956501013651, 0.7347283643511913, 1.609300458965531, -0.7115871377854934, 1.094671983515707, 0.47964401684315416, 0.9243116832692513, -0.2998558410952527},
    {0.5479254798993364, -1.1692784092851427, 0.08766569160726653, -0.6743348351006349, -0.6057334277272408, 0.4964257497789598, -1.565343443465609, 0.01496361771924261, 1.2261787174589753, -0.4263428609237044, -0.8497048288250633, -0.8856415212348103, 0.6975444638182177, 1.1854891808382797, -0.07972777941669647, -1.1200191929714995, -1.722434146236751, -0.22357991656429038, -0.601361861329496, 1.28864467351603, -0.5686883901735048, -0.5438507050377496, -0.8481128838179449, 1.4132081641835115, -1.0044277880415677, 0.09015600965367546, -0.2291948228085247, -1.410451431107088, 1.2769854863000496, -0.5776092871339271, 0.4966623167712173, 0.5318751720746373, -0.4659493308971728, 0.11647173731966141, 0.08722852674460958, 0.7814479066847378, -0.21044393036346626, -0.01960789164647452, -0.20247524873297681, 0.2704490442633584, -1.4305976680046164, -0.9100969411252255, -0.7320904429322753, -0.607139954191447, 1.107827626023795, -1.3310876834796106, 0.6557140878673391, -0.528692365954235, -0.2778053512080804, -0.5412973476429256, 1.2661200246983564, 0.8027785752513161, 0.39129518495951787, -1.6269984470185237, -1.4706432886455205, -0.4350648772903078, -1.8023414456248907, 0.993876954636086, 1.0909385696516782, -0.7002069765008441, 1.0101829523633048, -0.8262574354349648, 0.7737508770602336, -1.0440882976401789},
    {0.12071954506524685, 0.08551280752633152, 0.29030548412320223, -0.7465524846802836, -0.18091631619081366, 0.38679901812474793, -1.221948844484075, -0.6925286260387231, 1.0168156257992989, -0.45588062842118504, -1.3781228020965204, -1.1054484836143326, 0.5975281866676063, -0.21305097988870383, 0.5194232927918898, -1.1250993555476396, -1.1803273128171452, -1.576717155440455, -1.120160274959293, 1.115017016818174, -1.2620601252267183, -0.218129070454487, -1.070208521382449, 1.417546720239525, -1.5694916862225792, -0.46215330925979825, 0.8916986669903103, -1.1261366346912423, 0.3912745850779123, -0.33960122377607393, -0.791200418399255, -1.2574707464662502, -1.6209811882936178, 0.9792207193375176, 0.8113833708205678, 0.46725861208366787, -0.6522096582243938, 0.545382275326773, -0.6025554535900295, 0.9244394777887258, -0.9918272829838478, -0.37352343294295354, -0.6714225688650551, -1.4997796974035584, 0.4605816424786154, -0.4183667504090392, -0.9121889110363547, 0.7080849957945369, -0.7306141795957168, 0.033916145709985406, 0.19650667488330678, -0.7546822134208745, 0.2808195964737614, -1.572524492375942, -0.25970446247868345, -0.23802079157857858, -1.5161508157618842, -0.6553751848597047, 1.0483607752611652, -1.0108388968119641, -0.585748760108475, -1.022789897466622, 0.8632066633467659, -1.6532614299421375},
    {-0.31122305938005423, -1.0959293465305102, -0.317763564930138, -1.3283838234846341, -1.5127307350890082, 0.6586185158078923, -1.4917815014339, -1.4215936902229158, -0.19247474586931146, 0.06371648552564474, -1.5137956621172943, 0.6818383196322151, 0.8925434136799013, -0.6354858008669445, 0.7451243985373095, -0.6999910052689334, -0.15142932568510328, 0.1839196577339388, -1.7375660309301675, 1.2732404101477155, 0.15276678241684652, -0.16645266691303467, -0.9758531953581017, 1.2365316927077967, -1.097366882269525, 0.457137086802978, -0.4358992972675146, -1.7769472982974994, 0.33255392977762666, -0.7246960335819455, -0.9383096515041429, -0.891295057369799, -1.5986885290527595, -0.8299804686773076, -0.05179064123384261, 0.7117198622610659, 1.0050315163940962, -0.5267840085814637, 0.877584973337102, 0.3039737435054079, -1.3486949226595133, -0.8016078698308448, -0.9022370037167279, -1.286142325388667, 0.41390686443982116, -1.9123158413094652, -0.7841616718437392, -0.43967787354903026, 0.41760421180389634, -0.8380770270344968, -0.03833726585209232, 0.8399817911429313, 0.6280285937932222, -0.2848445211858284, -0.5465113421672898, -0.5831605033168796, -0.6049186179554844, 0.19924449505792444, 0.24596273822531758, -1.8976568289560323, 0.03473938471576342, 0.5489997820407813, 0.7149529055166582, -0.6209893239494254},
    {1.0927182987257873, 0.35801758746327556, -0.7336661432848777, -0.7384326860799932, -0.46402305736599714, 0.808329495903299, -0.5273230870590504, -0.49520366653954134, 0.2004159430688128, -0.8099598988883088, -1.114619133932558, -0.7531501513561365, 0.441842990687661, 0.34544932318081156, -0.6566797897536287, -0.7675285215232751, -1.0777030367695366, -0.9605663575415624, -0.30273179361220043, 0.34960841254942654, -0.28035315351919765, 1.32313488907809, 0.058186205650733167, 0.3182873946851699, -1.3271314630398277, -0.835180801884076, 0.25936280275118856, -0.44897140066097824, 1.0430279288836064, 1.0101946533152577, -0.4901769877430218, 0.2594097069745846, -1.8950725755067588, 0.325363628713087, -0.04529178280127312, 0.36093170609446595, 1.0239539936494162, -0.7865773931714405, -0.7148389090620029, -0.5646045101964998, -1.620737389554879, 0.14588585288942532, -0.8894542942194659, -1.8960887676395453, -0.37918929582991734, -0.8452792242275606, -0.12753046230453577, -1.1887414233966374, 0.17445930161959233, -1.1050090029383177, 0.9515937131887692, -0.3067926185645069, -0.9934902684321504, 0.23162690246543516, 0.600446446812214, -1.4243042661265382, -0.49648995393534395, 0.45360344021147897, -0.3635951507419612, -1.8920354965059372, 0.997627440749662, 0.8878314931952234, 0.31747535616135153, -1.412610106712812},
    {1.5214292671330287, 0.603638363523788, -0.7994927349690049, -0.5221561902749614, -0.5222486986092377, -0.7702304609860269, -0.3349015939434262, -1.7757470760338985, 0.7848333772422291, -0.8015882449047738, -0.5008341109634822, 0.41985989019044834, -0.11051753331888145, 1.406373280517861, 0.10650076672005945, -0.8957443195916542, -1.1495148251509908, -0.30954588154286516, -0.5291895847514748, -0.26543412831850116, -0.3747309587830284, 0.810157345598274, -0.7004517177034902, -0.3245330245157227, 0.18724320432373828, -0.08471744911963827, 0.10639357973769746, -0.19912591369233773, 0.6004045064883763, -0.08127950640505735, -1.0182285954906012, 0.47069132984483997, 0.06484464321807129, -0.1913645820199741, -0.6403523207041935, 0.6304490436259866, 0.4040691089282906, -1.4659486918881666, -0.1557862845389895, 0.7677143213141028, -0.5875829151808953, -0.27007102125223836, 0.18457830620367968, -1.4987853862036944, 0.4450341304742733, -0.5256814494305905, 0.2466243998779601, -1.3171857867462171, 0.675581617900112, -1.2998796294051593, 0.39213008019563, 0.1397376983980358, 0.7247069188733892, -0.11635024083877141, 0.26879033623672993, -1.5225382318265805, -0.23345642745572395, -0.8975233333147641, -0.3512503670540583, -1.0788874800968227, -0.7095866478304416, -0.027748903228316385, -0.37493250528513433, -0.13314092590203566},
    {1.4278457233282498, 0.17235766643272904, 0.36679394103048135, -0.8054448983267912, -1.2641938542642885, 0.20003728019433953, -0.5161946937386833, -0.690058646838749, -0.617737348466989, -0.008124874406906485, 0.5334914367126884, 0.9457720660451818, 0.8766160027881768, -0.3741391115807021, 0.7120582557290959, -1.1055732675763168, -0.4617853604857798, -1.2002680917391395, -0.910464549562813, 0.17902890326242055, -0.41991515818312114, 1.1810891267458745, -1.0999359650977913, 1.0484598975521342, -1.4991816791161328, 0.3519268617420477, 0.4909348655367804, -1.26085562560716, 0.32287045751596055, -0.461096408247655, 0.26167175021629385, -0.7994745900922132, -0.42713883411412085, 0.17274174013093158, 0.6631570261684224, 0.7502905466048481, 0.2206123287206864, -1.1398013435608507, -0.26128287546345336, 0.8038518877768609, -0.2059966977270005, 0.35560989056056774, -0.2609809175538156, -0.07408164867342171, -0.4838555360367507, -0.16617196702747575, 1.0749045796399863, -0.37886413651552026, 0.2972296189650031, 0.6554103860385825, 1.1358111180216466, 0.6387631724238647, 1.018584342445472, -0.6988962924981769, -0.9157458205536151, -1.4405531758687902, -1.0934591442182637, 0.09966350757165358, 0.40462424514060985, -1.2656046302688173, -0.7153266617987051, 0.6887285766846857, 0.9359511043068555, -1.3651585492661948},
    {0.21611447089007907, -0.8156585116563232, 0.814489286939767, -1.280926412177815, -0.7926931181440424, -0.7804709361701204, -0.8421556522530766, -1.2891520789102517, -0.8127676029659633, 0.047302906442061636, -0.9378176800877781, -0.45998510360379397, 0.5178171368785646, 1.1482641209060016, 0.6442603207683588, -0.9648413361643248, 0.27205522279864225, -1.6615805191710153, 0.2444962475208401, 0.20570774606467693, -0.8906658331589513, -0.18788362174171364, -0.9179264834186365, 1.3213943808404063, -0.44273541087848056, 0.7110751808126824, -1.0778120255768133, -1.0315836967197638, 1.2540740243977273, -0.5659752042553103, -1.5778492067755958, -1.0301741807455194, -1.7329028952405223, -0.6212984219853475, -0.537994926202275, -0.33004428195521174, 0.5026673598575984, -0.912034514511973, -1.0080128707093736, 0.8465267622070148, -1.110832265204225, -0.39351172745277657, -0.2535687491559221, -0.6981313780140309, 1.0631652065130694, -1.4711604308654918, -0.9480974656700601, -1.339031467553218, 0.05082714242716343, -0.5450279350059355, 0.1688359362408562, 1.006528990513009, 0.8162084956928426, 0.11093869400686522, -0.9213546407514315, -0.5683135047782567, -0.5982424632482909, 0.15704794761980748, 0.9252391644753546, -1.546685885583499, 0.25499269732711327, -0.07391968786250377, 0.5973100999693955, -1.7130774513561213},
    {-0.5678343242157531, -0.2689628937043878, -0.1403880287192144, -1.5697593055623293, -1.0110315250759885, -0.07586045119229895, -0.06337977246418419, -1.6056819779122746, -0.47456229783426757, -0.6151782472170733, 0.44453371000067937, 0.14248799080075825, 0.5012188638052896, -0.3668040460231426, 0.11609366532092091, -1.371999018968605, -0.7314912321120028, -0.7638142894259283, -0.32231718097681133, -0.0325955804018843, -1.4734454241435555, 0.7492961850784202, -0.01300356131545359, 0.09199354263550245, -1.7344593380301034, -0.8154480268206189, 0.5324863135564826, -1.4810142196142273, 0.542141111817295, -0.5025665417085295, -0.05647458887260749, 0.1694578015838054, -0.7855242685071272, 0.335106939325401, 0.7266775263196016, 0.05312665806546823, -0.7055325598577464, -0.8114993937855778, -0.6726754553382427, 0.38831318627556544, -0.9675792805989633, 0.8361388855324383, -1.039813023896432, 0.06272761125699601, 1.077523157001264, -1.928804425083925, -0.6217966056541009, -0.9270849478759692, 0.7141826478426883, -0.5716153133818328, -0.15591544935961146, -0.11675064354154627, -0.8338186246282654, -1.300349019146323, 0.04382831446351832, -1.3139051199165337, -0.7059075329391359, 0.6020666893795129, 1.2905244165196148, -1.5314681679529938, 0.7881008787555939, 1.0445424426454135, 0.682803838338599, -1.0656933143514555},
    {-0.30612311449305035, -0.3066711945320526, 0.8601107214094592, -1.573263362657764, -1.3378551856742409, -0.6969173565621992, -1.4085258812421644, -0.40556555159453433, 0.4356155812073654, -0.5668523438475328, -0.02993110800482509, -0.010395250236493231, -0.5206532412706775, 0.2989332707737815, 0.9711964348718853, 0.35737570787889505, -0.2457793151124833, -1.1547037197266985, -1.0015082877100585, 1.4284631626299427, -0.5462922322385602, -0.07458440292135261, 0.1526765274133218, -0.21960695829576823, -0.8705773162370619, 0.2510426830998408, 0.38417749876261187, -0.4987678237009829, 0.081749519581493, 0.5417352845915817, -0.5093932891907005, 0.6847085654687755, -1.9783592338077312, -0.1556955323646509, -0.02903464580641306, -0.7593417781462278, 0.42139179800467125, -0.8496859109953688, 0.32653472621515406, 0.5153876751310111, -0.519907752518099, -0.3293680956463184, -0.7784965542146159, -0.43142317001428365, 0.10378123448376123, 0.003977652077479346, -0.983278024667075, -0.5604491147852468, 0.31711762015212264, 0.5051933162913433, 0.620593622807404, 0.42220495963328836, 0.7278958256500675, -1.499174911945252, 0.6032098506639614, -0.36740281688671905, -1.6808541982180398, -0.5340529744394034, 1.3110308805915618, -1.4785671452813534, 0.21445074452856078, -0.6434879893511732, 0.18812297627538382, -1.73789620413331},
    {0.704764883438844, -0.07414458809775352, -0.9521841963578392, -1.4616799909401916, -1.1936976992714816, -1.1014538243539829, 0.30547125553879606, -1.695506969110681, -0.5420900938525239, -0.32041100180141247, 0.44789233544209767, 0.25109032605470877, -0.4563815548458905, 1.252208768824666, 0.013757008195171356, 0.011560705500749382, -0.7378480669540024, -0.9674568487687267, -0.20936235928203228, 1.147722346970655, 0.05709647893614128, 0.9129687760772378, -0.5383329712568258, -0.23070371227106798, -1.585957970067179, -0.8671187413517731, -0.32733744978326074, -1.8994009276117836, -0.15623115661793124, -0.517037650422964, -1.1024526166153135, 0.8908513183037995, -0.7511040058042576, -0.5834627716481061, 0.3845524468656404, -0.7683525173841699, 0.754226112320591, -0.7940902582075609, 0.6506753472566821, 1.1405942861405889, -0.0194752122469507, -0.9526876009542651, -1.0134076253984121, -1.5641387996679463, -0.08016557312661597, -1.8306557128148282, 0.39460216970424855, -0.5282011056230096, 1.1329552342980755, -0.3354848921345317, 0.6323420742371205, 0.43752518752104635, -0.9771548744568737, -1.6543338924081197, 0.05883052754724091, -1.6190677437192051, 0.16949518607974928, 0.9782859076356147, 0.10812156137950252, -1.6770773175763904, 1.1728699574724817, -0.007699750070038878, -0.0938406411769703, -0.11505128990287615},
    {0.02759371913082719, 0.7984741323791956, 0.7994845289412784, -1.2706713564811132, -1.7444679701355756, 0.7706533352901268, -0.7948433001027916, -0.699387895829427, -0.4697989072749256, -0.6434257930118145, -0.9890552733567642, -1.1772822564248078, 0.06273862726650864, 0.2659697953723223, 0.03830871561622893, -0.41157681239833876, -0.5391634011630737, -0.9137004340593746, -0.029800713933164188, 0.6099655129288892, -0.4148410743071407, 1.04857713693166, -1.1943251029718522, 0.6068952070021365, -1.5393115419346413, -0.9060836328489935, 0.8223521043713136, -1.1709169055117128, 0.5973175296710789, -0.49135381489238833, -1.3407273248207743, -0.5550078427450374, -1.9060579450758324, -0.07796933736010592, 1.109020879314599, 0.01738421499653133, 0.40185321946224856, 0.2613966523607398, 0.8154975915757022, 0.3677936861709087, -1.741485808203798, 0.2681072103314379, -1.06027450307406, -1.0096212305472043, 0.8032199510228206, -1.4216823894931496, 0.17988775527085357, 0.4302062783022561, -0.20783752653095727, -0.38209761260367864, 1.1948249150286254, 0.4839753868407622, 0.7083066856893043, -1.036378946929115, -1.104064841730882, -0.38502512353187657, -1.2940049163073577, 0.7447378211387135, 0.38940648663191657, -0.8497473832284339, 0.8624428860277815, 0.6611181896542156, 0.5397820945555881, -1.551328602183147},
    {1.4538111072853337, 0.38763659649358834, -0.11445636174276018, 0.16375867055817245, -0.6443392626759294, -0.11461971097381983, 0.08442338079611292, -1.426741984754715, 0.9749844482348282, -0.648172566294768, -0.20572975265010057, -0.7069122191092295, 1.3843574449514782, 0.8874924167136666, 0.14404796963376076, -0.8452043477374825, -0.9825279255780831, -0.11568325733948323, -1.2822690648571768, 0.9638907420856888, -1.6111574968261653, 0.8792907527617242, -0.6467270492703492, -0.308361202823367, -1.2959674144215243, 0.06358440225628159, -0.6069211878864413, -0.47750015640821974, 0.6911157062631529, 1.0775702926141664, -0.12209933758507888, 0.7819086419446344, -1.9666062877232022, -0.470428630522433, -0.36686692285911154, 0.4330434428386022, 0.19219628188141602, -0.18218864580845795, 0.8899632638588478, 0.03365220918217019, -1.69542446984456, 0.9087184201670117, -0.526028567331828, -1.868809839065574, 0.07247676388190803, -0.913417232079433, -0.1660731236784596, -0.19821593307971175, 0.5511794265161039, 0.04002955635469778, -0.27410802871076834, -0.6165239921720344, -0.602244947982483, -1.6187367223713498, -0.5130544942662935, -1.8543643656762656, -0.4609450011890263, 1.0158299563538633, 0.14000555715688456, -0.6096994115325505, -0.8376572217876266, -0.6693732439620371, 0.6559392566587527, -0.07440311004031966},
    {-0.21463899083143545, 1.117125293946907, -0.6601934080202843, -0.4730205832385521, -0.8525319858007235, 0.7318083293221855, -0.837345525054497, 0.07565863163315613, 0.3275708209620289, -0.795900137875366, -0.1067752077501081, -0.8247076221099031, 0.9260515559808641, 0.5220192037133613, -0.3418921723132772, 0.1527945400764348, -0.7356778477917781, -0.478535979699085, -0.5441476325006418, 1.4854260016104468, -0.257249610119592, 1.1278088887211606, 0.23056108162492614, 0.5376805312448241, -0.6271913327772226, -0.6897970096939074, -0.22049238737121837, -0.4145136271966274, 1.3322053305230446, 1.0479223231110422, -0.9261664875999528, 0.14637415849478042, -0.8580866505490783, 0.6215162611324411, 0.1665963987817149, 0.9374520648295247, 0.4744861219052759, -0.27500012629496623, 0.11749399538581097, -0.12777256340118032, -8.83552890544153e-05, -0.4172072422357703, -0.2775061022164313, 0.10794635435626584, 0.2902968282948523, -1.038145012211996, -0.9593557762778441, -0.23843249710192518, 0.18813180598942011, -0.5246792431914188, 1.1883042903291205, -0.164458299378954, -0.7319222714688778, -0.9164599542712001, 0.6496984910342819, -0.8264199602966483, -0.5955629681935675, 0.5056535496696167, 1.294618355887105, -0.5530581552208502, 1.1162860391809621, -0.4817581511978912, -0.46534134320153825, 0.285250476105182},
    {0.9474902886209171, -0.6046418280770648, 0.944067099072453, -1.4862691451652124, -1.587071044275875, 0.4035909573648744, 0.33542732667361097, -1.4339863164354576, -0.18939000147383078, -0.4688604690311816, -0.9542869979199103, -0.010212464520371644, -0.37328348502190173, 0.38961223871145273, 0.2464887218402703, -0.5075962354022633, 0.17856451408025434, -0.7958985832608813, -1.6062897544843266, 0.05628670849263725, -1.4004997923762346, -0.0962221446574219, -0.5319628871179832, 0.5781864493097222, -1.6251458997797377, -0.40271117528653577, -0.03003846591161215, -1.5732402360448117, -0.3778163203722924, -0.10356492770833978, -0.253465728780033, -0.5779487831827442, -0.5142498616350607, 0.16458213480211217, 0.9284324840722677, -0.2687311362349983, -0.39238939297241254, -1.2890243146661313, 0.1355232934783184, 0.3839313618961109, -0.7235453867592642, -0.4291856160677177, 0.5080962379951118, -0.33770203091103934, 0.8197861550583899, -0.4924625695407052, -0.06475209379955703, -0.9723301860509863, 1.2130385766760299, -1.229836556399976, -0.4706147104061525, -0.7085577396881835, -0.2288826096723658, -1.1155445523179348, -0.6471190024495671, -0.02868752742705177, -1.4848010875025608, -0.4296773389001352, 0.4224844829772834, -0.596687826194987, 0.23696271804823904, 0.05459218179414029, 0.8644681761081482, 0.3459385749890834},
    {0.837545396367571, 0.9558964317529244, -1.0480369402377796, 0.180609785867623, -0.9480258917180575, -0.8956357292227547, -0.08115926200354444, -0.6013583388405123, -0.1829288008733341, -0.8877579746912674, -0.28882683032702605, -0.6269606955677998, 0.782977590530132, -0.24855376908731977, -0.6547367898390103, -0.8658292583701014, -0.12215842329175719, -1.2552692442878308, -0.7400830084376421, -0.17332679618478056, -0.4499894022998187, 1.4544841686914347, -0.7276599509124639, 1.4175833040749468, 0.14842261149308672, 0.8068371314695177, 0.7953550717768585, -2.0062355636014475, 0.15643163137213928, 0.5909821059993204, -1.3731926286823235, -0.7982451007609715, -1.2155748516253198, 0.006465040905982481, -0.6385233444719981, -0.29500833448605285, 0.6932225634276955, -0.8114644403730971, 0.5377032332615732, 0.3562344847678005, -1.6431566737846703, -0.5248453869741713, -0.309818035858115, -1.3682593697561178, 0.07826900462780213, -0.5694010446299351, -0.5042700399393105, -0.7753152684800618, 0.4115397968158037, -0.8101324038639636, 1.0451003872228044, 0.9415522798229755, 0.5490193282598799, -0.017530279329799232, 0.057592228786901865, -1.7149126832943449, -0.8193255516227499, -0.8540132608347974, 1.2667225686046513, -0.5704894799262386, -0.5118335124181473, -0.0638123900219812, 1.1976982337040636, -0.24207621762122006},
    {1.0614036104273368, -0.9239204774582206, 0.6631439005566396, -0.8124805527071808, -0.6514622717697882, 0.08818728367274027, -1.5022185348429298, -1.8930064333519616, 1.2435490009344419, -0.5242962594038679, 0.3205627664977345, -1.0930934166756754, -0.15778519060818383, 1.0901703062121668, -0.4207336800554667, 0.28814185966139416, -0.5393982184869386, -1.028653882546639, 0.029751092764536836, 1.1087918786490325, -0.5073964370818157, 1.324291050478378, 0.3054059939479389, 1.533565436183928, -1.4132725183229276, 0.6003975461224406, -0.20031412443615415, -1.9790785460935865, 1.314365472999236, 0.13739999464128447, -0.24567524587706, -0.19910899734063492, -1.7121288658412672, 0.9253348609238006, -0.631677956153447, -0.7523240032577071, 0.05033890364466562, -1.0016863266107412, 1.1585100484593776, 0.7970180381880024, -1.6719882255450056, 0.32676726594114686, -0.11155868479176209, -1.4177708636407635, 0.38326901197130026, -0.23487809382632346, 0.08004270996904882, -0.6977743126664216, 1.0153744217153777, -0.5790481174055588, 0.8703725231688522, -0.14868097801543254, 0.6572670191642556, 0.014602556407817721, -0.010634221873609264, -1.191018255635406, -0.4956960126011552, 0.22275047290850825, 0.6444065581450507, -1.4282282593763935, 0.11603371005941959, 0.5060378170859002, -0.4097813602252818, -0.9089331738117447},
    {0.9143074075567846, -0.43876429030667297, 0.03611905112957475, -1.184154268430175, -1.0271544021613133, 0.419572527181672, -0.5579363064785566, -1.732224502338227, 0.4141158470592529, -0.6006310182376656, -0.868364439819216, 0.13773848919301002, -0.13724710958931946, 0.10619812945585574, -0.47543723578216, -1.250694955634656, 0.08311201816667622, -0.6907898002616683, 0.20043000531123253, 1.4284465257364647, 0.32019349995732355, 0.6014069662493815, 0.357734513565106, 1.0679136482427407, -1.2245025555314728, -0.3826346482858225, -0.26990892165035946, -1.4849493106901681, 1.242459132592984, 0.9590728022898325, -0.9303378421509303, -0.10383340971012568, -0.6794697249975978, -0.13012518699481396, 0.5814529438336775, -0.7310269453854572, 0.08659773397300799, -0.7189043281275078, 0.10997942070900202, -0.30998300297849746, -0.033679281563998825, -0.3170789121008414, -0.03577919019765715, -0.18339112756866846, 0.27691797286694186, -0.5093513112181755, 1.0463977001912292, -0.5449803794073036, 1.1822522560092605, -0.659808425912138, -0.08882735427904419, 0.9875430392357589, -0.6830344295010181, -1.2902421234659045, -1.1342808867226644, 0.18803528352018212, -0.8751499334339623, 1.2515526179306693, 0.34528384582036853, 0.11662110528572354, 0.9885321941327241, 0.09754887065840565, 0.6222628408989915, 0.31891157437754253},
    {0.8445275952063299, -0.012824241978793933, 0.5895537407388394, -0.19164505246317373, -1.1200841226881342, -0.7027720244034455, -0.7218861755578082, -1.4356329326015238, 1.2656666783985107, 0.8342301379867036, 0.09488148836436486, -0.17057503048936973, 0.07398100141678579, 0.11294953698460433, 1.0527163111266693, 0.6725072965185706, 0.25098333730006, -0.08262501974915125, -0.18802122019820894, 1.2842201071750738, 0.10794763606278919, 0.9578113810075662, -0.40846190517891673, 0.5857451482006046, -0.6964571233074834, -0.5942771500295676, -0.4690774489707241, -1.0960401768441355, 0.7746200402348711, 0.576193100448993, -0.857988997214624, 0.34247103616724134, 0.28403941693035306, 0.034124094024914786, 1.0374179462965591, 0.303417625687308, 0.8188970178101067, -1.0899951858817651, -0.45862543092750124, 1.2191432825021826, -0.9661956804920665, 1.0095052965002242, 0.3002200438083599, -0.9789557557379615, -0.14824877524867383, -1.1687430449965763, 1.0644818300598102, -0.03454434041891324, 0.41057271705560977, -0.47046978297751785, -0.25445019198537916, 0.29431122044901165, 0.9342950129527097, 0.07980880328302244, 0.30891965409844124, -0.47421822751772824, -0.5990578997765368, -0.4218349666364468, 1.7571469289529602, -0.687892478943343, 0.05809842379757404, 0.104242746750438, 1.2138509509794304, -0.11320954698809103},
    {0.8426624061185469, 0.5190954917134807, -0.947525252079656, -0.8224634313715363, 0.10127093342195984, -0.8996967624470694, 0.2888259906913515, 0.0023792389559776817, -0.3868015650318939, -0.9232298988971902, -0.6573868253099154, -0.9882032252049152, 0.38177413492121476, 1.4586602434182736, 1.0572067948059085, 0.31633973692178474, -0.5655564491372985, 0.18278503011993363, -0.34219000988561826, 0.6144685973338133, -1.494551061181344, 1.6427083274871093, 0.5808459207993325, 0.14375305883241046, -0.5225075217966796, 0.5850858671380605, 0.7697786407543057, -0.3130725774122383, -0.08364584291740154, 0.3569084767261023, -0.7218442418308999, -0.4938832226143271, -1.0384298437215165, -0.118835054626856, -0.6237351213980946, 0.17823616708382012, 0.9113332676649396, -1.388546014761147, 0.7052646004397591, 0.4167375418009504, -1.595567452068773, -0.4046010926941045, -0.0423084831591612, -1.604026524299049, 1.2465720380144683, 0.010631846632052164, -0.8668072665203013, 0.3052031343111272, -0.3653292903093766, -0.18676828338727827, -0.08499557463217203, 0.5863713068982086, 0.013393484450606216, -0.9453057725087344, 0.2891279097641061, -1.5370932226578575, -0.3680906851403256, 1.0664282951570307, 1.1292060855701067, -1.359777698273972, 0.7495084980406419, 1.0185998694270508, 0.9441699825788568, 0.19861940788585708},
    {1.3238793279866936, 0.49318944080134675, -0.9417389517136733, 0.12708474391906188, -1.7485352284909075, -0.6994007080993523, -1.4711091246580488, 0.011378592742621181, 0.3881523667300809, 0.5494609753473915, 0.27474682323126226, 0.11420363461777097, 1.5004269556822027, 1.4891728052778326, 0.2930327901351921, -0.602646649154588, 0.24184402221016083, -1.245337233963035, -0.2756160623089318, 1.4400931681812874, -0.9906111448245166, 0.6556231021449767, -0.5215766786076683, 1.1117515365978854, -0.6553968586565341, -0.1014832307524801, -0.03364970063595898, -1.0503047562195449, 1.4633856550919344, 0.5053071449885529, -0.7171305827041199, 0.898112571956494, -0.6667512023585884, -0.04735813839781715, 0.9012432051332065, 0.4753034367418149, 0.03057393204128328, 0.29455696710451973, -0.8191509034064252, 0.41764130341689665, -0.21785921840277597, 0.6041565728908983, -0.27001797199659816, -1.5974453518199252, -0.03556799911534768, -1.1177155440018238, 0.21223855101225172, -0.41222390919267127, -0.6792294278040517, -1.2419443949554037, 1.0582832756518024, -0.43900747569035764, 0.23931687134754812, -0.6268200261376802, -1.136917414277263, -1.4305202849256864, -1.0110317484460303, 0.8143696809641872, 0.5430248320803229, -0.15751165934001765, -0.14417641669007755, 0.8779049148933786, 0.5305956564038736, 0.4058316712082005},
    {1.5557856487822408, -0.6368882923824535, -0.6974954545418647, 0.40513812401504373, -0.04884573987399255, 0.007837117920776716, -1.178200734477096, -1.7328857741247106, 0.25951820265283826, -0.7888488585764646, -0.010868754331306033, 0.8456878551962955, 0.9694835222866779, 0.5079542721070753, 0.8838624085087494, 0.34652583056946995, 0.4294892056176853, -1.4109497791057843, 0.0022524154895936194, 1.012030304963412, -0.46959416771224777, 0.3907243195197422, 0.5081203539009421, -0.2053026061606968, -0.08594734806610106, -0.45127186949233566, -1.0271638156689316, -1.1491518509837266, -0.017729757101842467, 0.8607935323951578, -0.6503408637707363, 0.3630441141986753, -0.43996483322576485, -0.5583480476646906, 1.263551001555889, -0.8190478984055857, 0.6206820914062712, -1.0792604238570975, -0.3545448142669393, 0.20056126933083687, -0.4419985461764482, 0.10867894414458275, 0.2711089421715589, -0.371798857036313, 1.4144462868140886, -1.6989011188609002, -0.6008817797953799, -1.2788261398975702, 0.2876911822323104, -0.667001401053769, 1.2377835329897255, 0.6985342194142693, -0.6599148698807917, -0.9133186126660428, -1.2228656095239543, -0.6833021396221527, -1.0913995181035643, -0.360736378942461, 1.377168084426215, -1.3907778108171296, 0.1863864182068308, -0.3514248670401869, -0.2270225415565908, 0.43380149989960115},
    {1.0442502896387527, -0.4585335532159065, 0.7857511089837211, -1.3041710892079825, -1.4257660190198642, -1.1831166356353728, -0.0599772894672593, -1.735471948301598, 1.0479518530123708, 0.5397160805158943, -0.08140087576191338, -0.46549850196675485, 0.5340512433889312, 1.3459397171552374, -0.5548512317805889, -0.34774748563107655, -0.6379132791211477, -0.14247222972157386, -1.4205350009144417, 0.6887891509085525, -0.0009090080770515252, 0.5504249912969965, -0.2285215769202264, 0.8986187528253538, 0.27470504741404295, 0.4746859817687029, -1.067344977326693, -1.0518446432186106, 0.04924831542632133, -0.051800936755611836, -0.7513709531730364, -0.660982985482417, -1.5463738635283653, -0.3957879726210479, 0.9865615031773594, -0.3707280631510728, 0.3230237720866993, -0.40887820992720136, -0.1562192552831254, 0.2433715040438204, -1.6507544295073346, -0.3451272993644843, -0.08958492530187771, 0.03169333815527343, 0.7446548118479871, -1.5758226187317197, 0.43831522489480956, -0.3355903560126321, 0.5288058792444238, 0.29256303092251373, -0.41906241190799903, 0.4630994437129563, -0.8798306843178691, -0.10133151201526903, -1.160431013770526, -1.3610795659926307, -0.8701966994549436, 1.1927929630622787, 1.0960060441325146, -1.245751168385678, 0.14255692807267306, -0.33868410272266464, 0.6666662340222103, -0.4656688254927065},
    {1.1710308724073217, 0.2949053193641591, -0.2568888884188633, -0.336156338319158, -0.5812228166829927, -1.1466281799210716, -1.062355774302307, -0.20056056854263013, 0.4313867164434081, 0.6845827857528982, -0.4783863202393741, 0.3407126420749294, 0.5697639020535514, -0.08201644996525265, -0.5395617024386478, 0.22727119939874138, -0.7530048149703013, -1.1596352127846576, -0.9991091644197682, 1.254648410019769, -0.3129467379923713, 1.4500483264504134, -0.9766523517351375, 0.9340342028448058, -0.7838665629050453, -0.1847143671624277, -0.6890059871461703, -1.8710282136474767, 1.327649121996006, 1.047212236402286, 0.282050560873715, -0.6456906387428712, -1.1710954175192632, -0.5176861573022659, 0.43265423985282, -0.4807067870357153, 1.0399553656040785, -1.461605968312075, 1.10582907937399, -0.0671545401979541, -1.3464397623779756, 0.7733171097476872, -1.3094407531731564, -1.6770284655053584, 0.8737408629505428, -1.198651690183784, -0.32389222266221734, 0.5923376878227761, -0.022347584460778287, 0.03984444396653349, 1.476851266129977, -0.37137657410058966, 0.2747929563974958, -0.2095742431707734, -0.34426976262184267, -1.4867545890237257, -1.262151495864743, 0.3159891956443258, 1.3038339267558383, -0.9574800452099014, 0.6946596860934384, 0.3196681473203332, 0.7400542168583156, -0.9172349247931225},
    {0.7751783724483181, -0.9314611635986466, -0.460973505744685, -0.23378179788528547, -1.7178982402638232, -1.1120943708506916, -0.5222051013473197, -0.8323081978396983, -0.3843206247026858, 0.523239744042015, 0.6967439615557317, 0.432153123390712, 0.9966586670217702, 1.4791544300640673, 0.976530943603187, 0.07535729785085718, -1.0263954036420626, 0.3673574352905671, 0.0880755705226261, 0.020095344148744823, -0.3385052253913587, 1.6818522512605463, -0.821465548549939, 1.091660370352773, -0.19830733565108172, 0.5460897459281079, -0.56078466455236, -1.8046120450785428, -0.23583416613175853, -0.05349196400934993, 0.5704832552008801, 0.5255455630378415, -1.5270090181487497, 0.5325683991395268, 0.851578202465862, -0.5137163132396396, 0.2453433034645282, -1.4232318651106706, 0.7764387944651906, 0.5700674692764299, -0.30817220323596806, 0.8460431633855927, -0.6499410932698677, -0.21032638011276233, 0.9612993936922339, -0.9968041221828299, 0.6834657632401394, 0.5004342694400125, 0.8195629234110388, 0.7380234200104284, 1.1255202706641605, 0.3899040968700869, 0.8624066268725941, -0.11634341676098299, -0.10352565160156171, -1.559215625230901, -0.2902907438871445, -0.671300937849038, 1.268932732843898, -1.6894032108376558, -0.10022761588811353, 0.7833197265414129, -0.11847620104509697, -1.3892050427627596},
    {1.3838631724271662, -0.753575489290952, 0.7807270170211381, -1.0762950502955906, -0.8002921203813299, -1.1707677442864994, 0.25898650105108884, -0.3362211050201656, 0.37354420954296685, -0.9347254825571155, 0.23114016973904283, 0.544225631227498, -0.2514252683267216, 1.479889683800548, 0.2131292780434882, -0.8926702847710495, -1.1880498692078787, -0.7781496638179135, 0.20254592962949158, -0.2389092404470737, -1.1511440333426373, 0.9406030326033201, 0.7764668412943254, 1.1552803595067032, -1.5365477984791875, -0.10501476890537771, -1.2389276153980275, -1.9045540270088015, 1.3291739108434468, 1.0624090617086155, -0.6114766287334802, 0.5774861523554413, -1.3240684910157317, -0.16815149155979622, 0.8826112705284874, -0.28843633821786757, 0.4028149146285506, -0.24603839935323596, -0.6436776971839807, 0.42811763196888786, -0.914386780534427, -0.42268077611282867, -1.347549580780714, -0.08143292529607504, 0.9818615080811678, -1.1072005222928398, -0.11943180024113167, -1.2656177818951615, 0.06390082074464175, 0.5849283732103756, -0.4470836080670706, 0.2139930133306184, -0.21070659520969467, -0.5107732099188002, -0.022117107790506445, -1.099072725390798, 0.14417067018704116, -0.2680988756930143, 0.5171391645962589, -1.5327918955072393, 0.1232693249566237, -0.219494121687667, 1.007906312814265, -1.3023003728955715},
    {-0.36423323364126425, 0.5341011114247989, -0.5263349452665074, 0.07590045275145559, 0.5943970126335267, -0.44585175360320034, -0.7890635553639102, -0.5701737301827372, 0.7937689640856445, -0.2726715658792491, -1.3435903252503067, 0.49624420103513295, 0.7761158660601727, 0.30795348767480846, 0.7692953992472614, 0.7210162082943181, 0.7159523977643739, -1.0613281335571396, 1.2553137639776153, -0.11454898332203509, -0.120263949067266, -0.7486089758628964, 0.44282310421419185, 0.9121049808986389, 0.43817957694135823, 0.32768617383323, -1.0191085158681763, 0.31240377846205947, -0.07514216379767641, 0.5641604599111568, -0.8038404246929344, -0.7725052848268931, -1.0274160326765, 0.14448301154043483, -0.12153325481304576, -0.8994762090460516, -1.4074170258957568, -0.8817697176824241, 0.3035580694633847, -0.7280954372469151, 1.1706223842086407, 0.8747880764726004, 0.021013566613426307, 1.121692013352286, -0.6873965274974689, 1.1300079079735523, 0.3420247850251713, -0.08801930643426754, 0.278688794415471, -0.6131597013863108, -0.13205254314358333, -0.05281647055603473, -0.6706922397889241, -0.23231935038147508, -0.9553678036773781, -0.6674362381315716, -0.10289744166329758, -1.4121655210001254, -1.2761735942674988, 1.0406559962531599, 0.19822217064222863, -0.23726980464378564, -1.1304222886773083, -0.5182147635549116},
    {-0.3094433776061488, 1.3818021592627185, -0.7616499425325544, 0.33770218434559396, -0.8536246738673243, -0.8048124546933689, -0.7676620355183732, -0.5016284923854646, 0.40086337998708843, -0.897327969614298, -0.7366538031711619, 0.7658443917852285, 1.5109920903022265, -0.21376407925143442, -0.12157172001423222, 0.7648540387781988, -1.1693183397134443, 1.1182091544039514, 0.6158562974167564, 0.7212469167539738, 0.2733511080287494, 0.5961717950469804, -0.3447129420746036, 0.6832072679980765, -0.2018197412350551, 0.6207362894054488, -1.0413580211640996, 0.28401646609432774, 0.8373231922193753, 0.10757155343756725, 0.9478475656821839, 0.32709606800145247, 0.4864536843834386, -0.06304509735685557, 0.6032356792481042, 1.265001724640832, 0.8313092211169437, 0.29131399775213895, -0.7966822717976021, 1.2705053763501224, 0.5601222267557817, -0.7726443799214904, -1.4485550218552685, 0.32564729172152046, -0.15438560929775835, -0.6069765495266923, -0.08632571715620484, 0.8049066084220514, 0.3308261891159263, 0.8350837834831669, 0.1855678718579159, 0.12047093839331811, 0.8572258738958856, 0.9750142392258485, 0.02580049866635389, 0.887750485866896, -1.0845680341462691, 0.0749175748690193, -0.6680366221650682, -0.7304399975509489, 0.4143327900649801, -0.9669090555115669, 0.005430577976729787, -0.744814994351632},
    {0.11288211436249147, 0.5471290609625828, 0.08240624743851008, -0.299362498234566, -0.18861019816142388, -0.25869011892298766, -0.744817949904371, -0.40897071657410355, -0.5095392068260619, -0.3561061204122771, -0.1727433050289191, -0.35473587777447363, 0.8013414100442955, -1.0536939834761343, -0.7974577597812077, -1.027606118637774, -0.5340118322524051, -1.0693913936627357, -1.5055733001256522, -0.506322740774286, -0.1799365886409358, -0.05112622052624652, -1.6232629591494199, 0.889342080446161, -0.41728406232958654, -0.4076008714233471, -0.49882198861495025, -0.28480316626200575, 0.6995809374388368, 0.7034207709197204, -0.5982328837506629, -0.7950769901441945, 0.5192301887848837, 0.6780241742239642, 0.143242452430262, 0.6265308785837205, -0.20358033039058612, -0.17096606197104072, 0.23763099972667648, -0.11728575221682011, 0.9390956041632614, 0.49550612356270335, 0.7383747242281881, 0.3043061468879831, -0.2029766748854415, -0.007391436762385443, -0.01786385668144494, -0.9893637683278401, 1.1942567718637398, -0.41627097000906643, -0.6993620409663386, 0.7202388627931073, -1.095956985255628, -1.2696822024061927, 0.9175275822418945, -0.9603565235435352, -0.24975377404059187, -1.199313916022935, 0.16168057221901125, 0.8212058080877871, -0.8644009210110843, -0.01525430849942313, -0.7357255709853061, -1.1588878445914093},
    {-0.7729015148472416, 0.3525245296158087, -0.00533503083786015, -0.25070050777244535, 1.023094921094037, -0.0022926184344551916, 0.6604870740623766, -0.30968655972823106, -1.0752942996282109, 0.49243855964643823, 0.6305074467450607, 0.24253032085651513, -0.45646399958416733, -0.20690663014284585, 0.557380444293675, -1.0017477437073778, -0.5790725612568459, 0.017779784360637856, -1.4222281925867655, 0.44490893376324897, 0.005952833877329024, -0.32189787581159357, -1.0006605978029157, 0.17833829420767092, 0.6095762251267413, 0.1389429475567561, -0.9281174668021605, -0.20912576988275605, 0.20756503549308494, 0.25249336539362, 0.37722537249806665, 0.5154775873580192, -0.9320854075159427, -0.20451017605497998, -0.4799952689210766, 0.4768233083121837, -0.05820932402236414, -0.39869863569495967, -1.1077613632868117, -0.462623804592604, -0.22900740349135046, 0.22919057063865023, -0.493793885906525, -1.0284434556534487, -1.1990896911521267, 0.0233135043749199, 0.18653029413784564, 0.6074632804729974, -0.6591405621474627, -0.5956662462995567, -0.07296004846578398, 0.7910060818946971, 0.8152233791364358, -0.7933912762953125, 0.2094087541271512, 0.09637297892854436, 0.4846738851314272, -0.7787368255199699, -0.188017494592396, -0.9051166597685798, -1.1126846521538238, 0.21808152377477077, -0.5496572021263401, 0.004063301981991584},
    {0.0976455342314191, 0.552009971654732, 0.533190671511877, -0.5405280181013653, -1.160637320333443, 0.007201002233768386, -0.6182972794831563, -1.1575949599117379, 0.8291896721605173, -0.42233731680104786, -1.0675757684321832, 0.8954977956402977, -0.5439501495249537, -0.2943476417404292, -0.384155432409343, 0.12962521615487038, -1.195853947120569, -0.36611497176727653, -0.030976951261784076, -0.3587157145394445, -1.6192722352787534, 0.46363606421458203, -1.5929372544006863, -0.21653633471754158, -1.3372379709376203, -0.22621811694386038, -0.24313435713113507, -1.5019515142195254, 0.20358925554615093, 0.634980072711235, -0.4041768806238887, -0.5065671915387675, 0.36074236874402016, 0.7402432092583566, -0.2355927591427422, -0.14028559479983457, -0.829158948053551, -0.5068516937837392, -0.6739382932170219, -0.3171083471211541, -1.0272262477878318, -0.44257978356050093, -0.7577418897329319, -0.9107577636253922, 0.5084681768288963, 0.29591367420101605, 0.41748788230379996, -0.7233021754126008, -0.6255303721139184, -0.11183457428013514, -0.6536670018494818, 0.2970549122903756, 0.12269116241125427, -1.4132835339838545, -0.00923493791109631, -0.4611397436331894, 0.005830806946416739, -1.1239965755805088, 1.00654097429953, -1.199592012088702, -0.2436283630978509, -0.023917266392003252, 0.14110878457458, -0.646459901182304},
    {-0.9035055796543655, -1.007962069684971, -0.7405514776346097, -0.7867296454670996, -0.19357909622121908, -0.3483638357491836, -0.04321790607531188, -0.6941297280127956, 0.5971302592971568, -0.8159533826803214, -1.326834201330984, -0.35551859368534694, -0.09839658618659056, 0.16495249140619805, 0.07294268201728607, 0.7184657881456809, 0.2269147216182324, 0.3470415872162091, -0.33518810178478925, 0.7565175085581392, -1.467962360998214, 0.9613333901239708, -1.0526168008106092, -0.9040628468051763, 0.47396115513891657, 0.8633419735141031, 0.4454294343386493, -0.08259276261766856, -0.5026133471060645, 0.7856223197864912, -0.4646124408728732, -1.366802604649562, -0.5238302428108657, -0.2971147598475615, 0.8524621847624511, 0.45605885900614285, -0.05703570245797175, 0.18198801252080188, 0.2785788151961932, -0.509131852730958, 0.6641325446280792, 0.11275461198442126, -1.3559135979143626, -1.1614107724048546, 0.26016397762754107, -1.154462208744988, 0.3226902054207921, -0.6381259535505789, 0.7269422428414762, -0.26954756791648543, 0.4906696664172833, -0.04617698063738141, -0.32879106623804033, -1.0844831524958147, -1.4857983131017658, 0.38674275205164804, -1.078774621579216, -0.000754769425380664, 0.3378235360281666, -1.308817294388569, -1.2105720299551452, -1.4818974357111454, -0.4155035795868922, -0.8971690946098642},
    {0.8990483854085887, -0.9653780379265247, 0.199915319564657, -1.4571023355202157, 0.7000625360374677, 0.17765367979577384, 0.29890331028506717, -0.5324336370348727, -0.24035658989292297, 0.6509169732938361, 0.06951510422542913, -0.6507870772464281, -0.24651844049794192, -0.09292753892851319, -0.13774842025112502, -0.3602603125562846, 0.1231175181253114, -0.814720623821792, -0.9238153968503772, -0.34798838298741525, -0.6935237046341078, 0.17684467166613713, -1.6834733541324973, 1.0928665937641058, -0.61997102374603, 0.024873748523114657, 0.6759655127043858, 0.2633773385985553, -0.8848784157798903, 0.508174697615816, -1.3537252358008327, -0.6641515365047593, -0.11456530304813349, -0.509457406133596, 0.14474204754882072, 1.113043098818921, 0.40330794755442184, -0.17985182143172687, 0.2689028176483827, 0.35965799754493877, -0.697799420392199, 0.7744735618390949, -0.8588974039096128, -1.1576884226299335, 0.07046951051475865, 0.31221592204981535, 0.03358999439850911, -0.16350717552166788, -0.6211214434238856, 0.5541387825093369, -0.6930031355546862, -1.162350511966158, 0.3232861742801199, -0.2667942516013138, -0.4999034595134864, 0.025504924163287045, -0.7874319765940465, -0.25244051576802146, 0.08539983305674016, -0.4339262087611701, 0.8853853163702474, -1.3661332635084715, 0.3788102234364492, -0.5561150082526716},
    {-0.15555460493193152, -0.03545695871802223, 0.055527855095469106, -1.355779275527441, 0.9022781067621842, 0.12946848275003162, 0.7315794576543102, 0.30010017427527974, -0.3233456838793705, -1.2365780035649874, -0.8633912500690897, -0.8524357729690907, 1.0846131406906805, 0.33683812863855656, 0.22362840768955372, 0.1150566635726235, -0.8780039538773317, -0.21513705146089282, -0.1751594001196384, -0.44302375859409054, 0.4313537367556127, 0.81632798252378, -1.1521754949771508, 0.2773294354172686, -0.83259937651216, 0.7666167591601788, 0.18814658333259607, -0.20442415580458814, -0.002205478378585175, 0.35164879807863886, 0.4024371459816241, -0.8779026800800604, -0.9932047070625629, -0.9634877528703214, 0.5772369843475864, 0.5414414053822828, -0.024837404488145243, 0.2469796548744717, 0.7452876777559581, 0.41366497257102214, -0.2477910601850793, 0.786919542378619, -1.2093896290181552, -1.3646700013298543, -0.27233087565086533, -0.5951728111207478, 0.6972342218357169, -0.26783469016290423, -0.3138787130092808, -0.6646288839812348, -0.21772325314551533, -0.6468753144401801, -0.8388215517600851, 0.8569010944793926, -0.8551008447768541, -0.999694319717853, -0.7950746038446683, -0.5351389931686935, 0.7834917635739553, -0.7355146523728755, 0.7561633472853282, -0.29547633245256444, -0.2829600132631061, -0.0713470092467068},
    {-0.01908331179148254, -0.27090013949451985, -0.7307163941205201, -1.1194858833471764, -0.8396849294451849, -0.6005096201653133, -0.4318487206112073, -0.003362113112019047, -0.17191588378380077, -0.38007707945478164, -0.6462393610031444, 0.21374720387936955, 0.14320675046768838, -1.2954000765304308, -1.0817221663700294, -1.114609141859274, -1.0332898202682543, -1.1340168278726692, -0.7415194659642692, 0.9598271310452744, 0.5227510887346906, 0.41759290682513855, -0.7243714414989147, 1.0766915377149906, 0.6060850966484213, 0.27446215945409397, -0.5435980864421658, -0.7345214572702312, -0.7509851356312925, -0.580827647305071, -0.2038796768009356, -1.373700069711906, -0.09695661574974127, -0.3258536166222443, -0.546156568647565, -0.2519126546710305, 0.27245428645025965, -0.5142306028350029, -0.7955865965264066, 1.0421986478291114, -1.1710553366948564, -0.7900312003589391, 0.015413159717437905, 0.3174149630937825, -0.7231136085230556, -1.0796980316628773, -0.8701434758678535, 0.824870031387902, -0.4980842864026323, -1.1687760343403353, -0.8636019853384287, -0.7821681056856652, 0.25194292634499876, 0.37873537390034073, -0.013733161655624817, 0.008871588673267733, -0.5504514286852987, -0.3652179780327872, 0.6603841786894907, -1.1420115284555472, -0.35292340961455426, -0.07994733720672732, -0.18335428671795134, -1.190947971361976},
    {0.3062923495099988, 0.7205675264489827, -1.5249500192193342, -0.7813427898621366, -0.3191385511975661, -0.27375094999271027, -1.1580654895050644, 0.4477741670355264, 0.4316725378690022, -0.7295112062013424, -0.9185483120827878, -0.5278191818994692, -0.36048935165723417, -0.45702010682336075, -0.11516100792537683, -0.25785241114194607, -0.8500567685255636, 0.29039858534289015, -1.4647019326602684, 0.020346726632068813, -0.5869650330897087, -0.8601326371643377, -1.4692328755968396, 0.9747280117937708, -0.11054130867296559, -0.23429105197399114, 0.47321982154123005, -1.0345568728611787, 0.9213364281882703, -0.07876060767042127, 0.17363397510708622, -0.30849635504567363, 0.32107278800921185, -0.5057168673071598, 0.7394907400608556, -0.07616134921486908, -0.33550999760969324, -1.3411798205600436, -0.7679606191031441, -0.08273209282622597, -1.3608847544699874, 0.7578225006515646, -0.2640767451525335, -0.6393579000551485, -0.1906469046647851, -0.2177611603346385, 0.43898749577109175, -0.6908225271277991, 0.032827270970696834, -0.920872709379548, 0.5554474775943261, -0.2256036982598244, -0.10716939990193067, -1.114456539359237, -0.41579211983386455, -0.03638216500442679, -0.56158551508553, -0.9895408433528089, 0.2988174929726832, -0.5702372910499637, -0.0003617593888314559, 0.4695008576504376, -0.33855379439580724, 0.3880628276352752},
    {-0.5536241943779133, -0.5269421488088738, -1.245856900235155, -0.01574153917223988, -0.4384137584504855, 0.7041979195464136, 0.3497386936482372, -0.07990645904787523, -0.2367931610959056, 0.7369015120781655, -1.2977782838636014, -0.135869385040528, -0.15992322016332639, -1.3404062031735835, -1.3552226948625685, -0.3666867421958364, -1.0799153434262516, -0.8331416037748528, -1.184134756471264, 0.5897510688265193, -0.8241971770019275, 0.2588754262595505, 0.34805398231921775, -0.9583867294334469, -0.4849342265909284, -0.6878504227423281, 0.17272066905653347, 0.4444311701651936, -0.671771840172025, -0.7961240189362362, -1.1312705388942048, -0.15663734288179687, 0.8233566333586981, -0.7791118607874226, 0.3525863502839431, -1.2082078843871717, 0.6959432661906958, -1.1136073551841186, 0.5509244892567436, 0.5365355614690077, -0.9270014493816247, 0.8572292707569527, -0.7647050120750948, 0.060073088289977476, -0.7260048730655371, -1.0078965104372188, 0.13989972193080472, -0.5401917039921945, -0.6858252198620102, 0.25930945567844604, -0.8379180716559633, 0.5163896822487375, -0.9437769300581448, -0.9664346021580987, -1.3119560880351813, -1.1247761260223739, -1.3255022229877713, -1.2973932904747687, -0.4389494169512632, 0.48347957485076626, -0.9393438349733111, 0.16119115643203963, 0.7318086710630157, -1.6142802316810974},
    {-0.37093062959859513, 0.7015923687936498, 0.26454322511820727, -1.4694605020142157, -1.2766913774170663, 0.2792800726795652, 0.6956454968133854, 0.43956783454340675, 0.40943014586179166, -1.0296798155562406, 0.07078326239515594, 0.28602051902463677, 1.098821392985542, -0.574604333857767, -0.08300137375876462, -0.8429450802372521, -1.2229589503581124, 0.08961370313259807, -0.8536724434020038, -0.27739434609719343, 0.5685529577009601, 0.5552772728293214, 0.4630111599909717, 0.12321524816923791, -0.06819380841775971, -0.8216494448218331, -1.2314506625177202, 0.42828552762449357, -1.068839911974879, -1.0042603916052808, -0.9327337569791343, -0.8691255948405766, 0.3736716562719423, -0.48923169168389047, -0.025933723892166062, -1.0670530601906836, -1.024807522019455, -0.9652033183681245, 0.035322765567347994, -0.9438012168428345, -1.2442467580792227, -0.9170135746816215, 0.49161629065038787, -1.5188045506688193, -0.5362634894704439, -0.7550157087184277, -0.725782818888926, -1.2726073709213637, -0.023766089338377157, -0.8446145156285576, 0.45193791626939595, 0.3156203867013927, -0.5916659466610643, -1.4942815661353874, 0.31525257775633087, -1.339602126081777, -0.02293929581276499, 0.14507085907347614, -0.8166678801405018, -0.1866672610505019, -0.37936238038476117, -0.3747504813460885, -0.9036003128679815, -0.7061054656126765},
    {0.40664314189577616, 0.8452101771512095, -0.6101692583990669, -0.6542457032692228, -0.5411504807300782, 0.3327573531133785, 0.2819299559337875, -0.3660634412866485, 0.388101434506841, -1.331905968063135, -0.20556242655527046, 0.08514107188970797, 0.650149679683565, -1.0471531490981119, -0.480461168320411, -1.5253790028847967, -1.4593523340384102, 0.12111382136916325, -0.9181012876358375, 0.9072238864854217, -1.546865639714763, 0.4443469470181455, -0.1626961010714094, 0.5274792220783381, -1.5456703395231757, 0.11825587866187433, -0.3333746623666973, 0.5705845458779689, 0.5308349449782895, -0.3207010971112172, -0.5830436862506334, 0.15610265699294024, 0.3375062599520455, 0.5845876688188869, -0.6696555020230782, -0.5767652220244701, -0.1928190079055707, -0.701381057699473, -0.8495835563535612, -0.4812492140364591, 0.5708212930875666, 0.10023084177504399, -1.5636312150930443, -0.4931448539347562, -1.2187821043835079, 0.42232186527471416, 0.12091609683353886, 0.7422748144627896, 0.12194609813301419, 0.20093986880243953, 1.0196791920380228, 0.13125606677076398, 0.16059646066428165, -1.338571069055677, -0.653304298569735, -0.9481434102068189, -0.5538991424081717, -0.8077746695863628, -0.5074316240675977, -0.8843191948774254, -0.712655045199688, 0.38937504902692205, 0.5971707989194375, -1.042213691517886},
    {-0.978190974002809, 0.6180872974810617, -0.5146697701683, -0.40292483543752894, -0.4955350659440138, 0.2673600849884366, 0.40563453755510953, 0.008789902037386384, 0.2740178494015124, -0.9877823556586857, 0.36803731795611433, -1.003039304716155, 0.5258991549233897, -0.619896326347932, -1.137985202790505, 0.18970660897553407, -0.5809473689285544, -0.5629865977032419, -1.5724920123211155, -0.6425795123960584, -0.7504954610886363, -0.9240212058975614, -1.5164463073691263, 0.1024633094564631, -1.4417472164044385, -0.9297640190239281, -0.28417050729170845, -0.8901306935359679, -0.6198509354416009, 0.742836702042808, -0.16468239155893782, -1.016381793620361, -1.3005864359151502, 0.9910924363284641, -0.23139724701642211, 0.6179332489253399, 0.5804254150893587, -0.1680486672028585, 0.08172309902302584, -0.9460950404845251, 0.1699207421415281, -0.9984743758927374, -1.1600511363889783, -1.2057881364006942, -1.1225629845337943, -1.3231345944478188, 0.7659274267639837, -0.053098466061635194, -0.7307656281700532, 0.20641126725260145, -0.823880819617435, 0.49009158357086396, -1.1178175654120535, -0.4767691820536988, -0.9412341711254929, 0.326759071253405, -0.625762726653148, -0.5505316120147432, -0.8178643568590813, -0.52369247788578, -0.5157462801989857, -0.9404862642675349, -1.0728238453753847, -0.598383614827142},
    {-0.26298917195456734, -0.4021157935020302, -0.7083427851763757, -0.922607051262686, 0.12806441298049437, 0.11574888262604173, 0.6940288249740898, -0.9763355271835092, 1.1018744520102604, -0.02572453094520105, 0.1524308400042124, 0.6799103947470974, -0.706689342855692, -0.03585162845116054, 0.43759524835690794, -0.9664072510375744, -1.0273346716462506, -1.362777575084102, 0.2684119627979333, -0.6629183737056701, 0.36819103892911936, -1.1767659961130272, 0.20194387419438942, 0.29702840780181666, -0.9776035654802796, -0.8315182188320916, -1.0814881091522446, -1.330912670546205, -0.6023631903087999, -0.8524816182471008, -1.1954936231128064, -0.9756550534511275, -0.3942918388567824, -0.7818688003357992, -0.5570306961470023, 0.6268501994396104, -0.961156047932004, -1.3124043382978952, -0.6356969083499292, -0.3862773878902459, -0.17740206294517408, -0.6920269786903527, -0.5048167341067679, 0.04903125991397976, -0.9058443522202161, -0.6189530566001517, 0.29425829242787294, -0.05405240634939386, -0.022118024293371192, -1.0035948628890614, 0.9333093473820145, -1.007855491414556, -0.34183954958086366, -1.3259915221455918, 0.07416599669035878, -1.323149272055345, -0.6172185768463635, -0.652308768826634, -0.5282990008402088, -0.41172893052967335, 0.5579912011727276, 0.11622743709183522, -1.2882531705938969, -1.4262558271027492},
    {-0.414529490777592, -0.19512546598313082, -1.5389170199752535, -1.2434702709840302, 0.18813987289313594, -1.3739566520035011, 0.9283220174134976, -0.7377900094990764, 1.0098310700190711, 0.2018944069545301, -0.7027248678019319, -0.25763456609474394, 0.9265406902864167, -1.1395237240904956, 0.12349253968964803, -0.694392897554639, -0.7984379856107163, -0.07790331579378432, -0.4342015859474706, -0.06540505790725124, -1.3483310348951547, 0.04297604127961641, -0.1555038691463201, 0.6537759845762996, -1.5284449043823298, -0.20879027219283508, -1.5120247254198287, -0.9842219089569297, -1.0914206576176038, -0.5421190718197776, 0.07752538734310109, -0.00475289551590548, -0.6724626635177305, 0.8654115719918395, 0.9010858239525296, 0.4819938531464042, -0.447740151401684, -0.6811364391930095, -0.42709304796871517, -0.09412597569467576, -1.0625303222069713, 0.9289029398617962, -1.192790273062092, -1.4727768663539347, 0.7150566651674558, -0.36318064091626545, -0.20726342408947915, 0.49403271666421994, -0.1418824228352134, -0.9016337592929853, -0.43596758687504084, 0.6064894545904115, -1.058665342368826, 0.15484616657409028, 0.13113397853666187, -0.16948139044374172, 0.37252440661161706, -1.4758167988494253, 0.4972683201931798, -1.0810631700491347, -1.0258004152546525, -0.3599141898509711, -0.9229891201825807, -1.4271850820120873},
    {-0.7916818149671723, -0.8553300658418537, -1.0374896879428954, -0.6336300116005603, -0.7601817116068593, -0.040501457735205484, 1.065215896950877, -1.2757306816603906, 0.4239804491503185, 0.518062389962445, -0.008811261934265584, 0.09633212569753224, 0.5418157831467288, 0.6681661044584157, 0.6599974200277273, -1.4420205575892149, -1.2197076419179167, -1.4259222542170629, -0.08863990857414719, 0.1314419423318387, -0.2458405449607736, -0.5181200876648926, 0.21173215821178507, 0.2525384224152594, -0.6717289491987877, -0.2123740853113146, -1.4955007495030066, 0.1820603192386905, -0.21662962666912589, -0.3402125718078389, -0.9525692552157229, -1.0202000717025541, -0.4873455549392753, -0.9696316586960718, -0.5697882786290892, -0.9434147219044771, -1.0677770906918311, -0.8393006446783688, -0.8580285439240248, 0.6979916126518497, 0.8905496074169812, 0.43095956218348475, 0.6944178852244959, -0.7632202932478056, 0.7371503118426289, -1.1073125943340696, -0.6704702896615334, 0.3278584345333511, 0.41147649856581026, -0.9723742793075975, -0.9502295821598739, 0.7353848652068576, -0.7474578397012125, -0.4459229482715613, -0.8623009749981146, 0.22032338126040688, -0.8496507796178823, 0.4342178668470455, -0.8450171896980784, -0.815536847015526, 0.22184297869489752, -0.3594512509114996, -1.2083078774819802, -0.7140973175021537},
    {-0.7214005328978988, 0.006302312224517385, 0.7701646163595308, 0.5611150524340305, 0.5570980414012057, -0.9821050349139494, 1.0541358559729697, -0.6806475470324906, -0.8700441323002411, 0.6907345740941482, -0.8312637407480498, -0.22363209393070724, 0.007730307598429693, 0.90228351847048, -0.6682529202410379, -0.35004614612126883, -1.265454224665449, -0.1667830024196135, -0.09599089609139529, -0.4381763004022206, -1.4696377049185465, 0.20523154017834905, -0.6235674231873027, -0.5782457808705447, -0.1329911711310064, 0.04005292560008723, -0.8696962960775481, 0.237834562235664, -0.709931353186929, 0.16608777503685312, -0.5597523915495873, -0.016914088220219465, -0.18994842569198758, 0.8404238197281219, 0.2801259487477258, -0.06212004029062777, -1.0854925679422456, -1.1784735940640476, -0.03240672151888593, 0.7558525848703921, -0.6271180647701214, -0.6921435643229678, 0.8776991014411001, -0.5063071104635994, -0.08140138466235869, 0.1945228175303412, -0.9339579206425791, 0.4507892824868958, 0.40619012765151835, -0.07984085721301713, -0.4611000321797001, 0.8182088774162471, 0.633528277109461, -0.8818682983634156, -0.08692673276399525, 0.1482729997057574, -0.3572691357422368, -0.22570211248960179, -0.680270131199421, 0.17273865583168835, -0.6543620505472402, 0.07083263150352662, -1.380822432941726, -0.28051276431530714},
    {-1.054738349812537, 0.351364476720536, -0.8310194675273773, -0.696054275748862, -1.0812863949010907, -0.22408587985717546, 0.9384244889823409, -0.4962489369090872, 0.8871483632024867, 0.004666841917136106, -0.1992253169433201, -0.5559554279262487, -0.16626708950222907, 0.7999005177230479, 0.3278458992171492, 0.019304115450894145, 0.3071721682582457, -1.0483678481058727, -0.6094110510768354, -0.5748781815938542, -1.2883371735006979, -0.3885712156488231, -0.1524164933107123, -0.2118241076063693, -0.04395648681972596, -1.3798377924854086, 0.16574766157115672, -0.5024905124658627, -0.3517634169734606, 0.5716119834186643, -1.1360227012399624, 0.012773044938473555, -0.08193624627933332, -0.041562294402044855, 0.6240087143800511, -0.6065872330455038, 0.03966716033970777, 0.17060049549523928, -0.8384942589596224, -0.13575113587980403, 0.022295823030852945, -0.8360562704114981, -0.9149056648247224, -0.2568509746024921, 0.2762905091397025, 0.32736620237467784, 0.6612392142565602, -0.7745796657082599, 0.8431204243468056, -0.07357035501012993, 0.06119736024964518, -1.182018942344693, -0.8484810027549818, -1.3072387182450704, -0.35456880960199716, -0.6236703519677927, -0.397549376448473, -1.3568879434914627, -0.9909785558067165, -1.1015332087163268, -0.807194877356202, -0.9244565713971414, -1.1036516218890555, -0.7693119768986585},
    {0.6328975761934352, -1.0982402123213282, -0.6746400321735991, -1.2608448576175628, -0.4580914265169679, 0.08515663329233894, 0.8149652213130192, 0.7087923356154505, -0.34513778796551303, 0.28370206812359183, -1.6509114044972493, -0.43775533986998605, 0.18108457550650292, -0.5014416711053636, -1.1020776889632484, -0.39053943893273874, -0.931112086716747, -1.09782520001979, -1.7360055061771262, -0.4873351690713472, -0.904694334764085, 0.005031485264488944, -1.688003966371457, -0.12633762543927882, -1.032954191573237, -1.3226778617194475, -0.09017488721265002, 0.6634408234907483, -0.4694843629885282, -0.732366324959578, -0.5789096205673364, -1.656880152481069, -0.7002191397419004, -0.6780257860013333, -0.7492692038608995, 0.404964883661089, -0.12936663220389888, -1.0096497152470414, -0.6602281610153602, 0.2889068513483951, -0.956144036900702, -1.0102098044614942, -0.055743895008536666, 0.021944961147532856, -0.17848856610028585, -0.41126919367157405, -0.6718465263997139, -0.11708941932092948, -0.8528263398499225, -0.8991837782081741, 0.07910351532625007, -0.15868680314009231, -1.139057259855401, -1.2503371427267713, -0.9291705517476645, 0.1738726976810716, -1.2793111532796664, 0.03913948788066913, -0.36753149392797296, 0.13978660306747293, 0.8392125894935678, -1.4881278808084033, -0.9516935511264432, -1.127900365755169},
    {-0.44190815937568684, -1.2365645618939076, -0.45416864539577895, -0.6361074484165439, -0.2523435439865889, -0.1879392805917867, -1.034700062937702, 0.513638117122708, 0.8348986141424424, 0.2524014105200343, -1.4323352244691756, -0.27638747178610606, 0.5757114504836774, 0.3221847472199437, -0.9099755266013853, -1.3382185257587784, 0.05031452298100048, -1.0978826154317938, 0.042986683434066864, 0.3228113812730868, -0.5156349622206854, 0.0026165055456695858, -1.5640773262064496, 0.37113730092482033, -0.7830206618098932, -1.0633955775516015, 0.08038622715266537, -0.6215493363840261, -0.2528815414159672, 0.8698387769515429, -1.2884355085808465, -0.16469428484183857, -0.5900796798785312, -7.600008701206364e-05, 0.7875616788740402, 0.7068722376320752, -0.5211979890559122, 0.5643018218917331, -0.3782351066328044, -0.6917476900548054, -0.8930518180015244, 0.05971145817533953, -1.3600212204984476, -0.4112864405869002, -0.5708179761912184, -1.715337549859185, -0.45347721376662836, -0.5635264531856008, -0.26537004873638664, -0.8746632944284248, -0.3973636655597266, -0.24322457957973853, -0.06759295965493624, -0.1417834641057904, 0.30471229852657217, -1.345620296815428, -0.09216617815659287, -0.04472620856407367, 0.19608330018871617, -1.415473989287241, 0.03327372745006469, -0.14917172266290032, -0.7507802760808151, -0.4963031008611934},
    {-0.2608816054346244, -0.8995730207770626, -0.27601013636392785, -1.3555605770432537, 0.22016406187070042, 0.06355456967194069, -0.7396131409578105, 0.3886004862088661, 0.9174282441060396, 0.06592008557038437, -0.6914026549787805, 0.2132429447303803, -0.34675322096405226, -0.9393281653561287, -1.0830843247146553, 0.04678434795943108, -1.5300435650994437, -0.4844291386893142, -0.274365657252502, 0.06669238243621903, -0.42482039302318997, -0.8629613094825849, -0.9837108756566447, -0.4367888276038115, -0.12837962966507907, -0.9160331766978878, -0.4548372830075059, -0.31545331195848314, 0.9385262103006076, -0.03095319792941315, 0.5633371863948846, 0.2474124751199546, 0.5065504499267657, -0.35702487824567725, 0.21507277001132885, 0.5230017509088707, 0.3096000120769553, -0.44483152810156285, 0.5941764728381158, 0.8048737220872904, 0.07254842066520037, -0.9655620299477713, 0.17160233290263782, 0.5341950829275308, 0.8768745046995987, -0.6422125446177372, 0.28358203447748187, -0.872725188937314, -0.09234642717982242, 0.8093081838450186, 0.7764550610443826, -0.9284013383615078, 0.26189908346545177, -0.4471105300530622, -1.4007930636493697, 0.694457266494108, -1.530319910130897, -0.00545600057976734, 1.1556480220738679, -1.3802155606002764, -0.18860849035803054, -1.4453086056274966, 0.04806407040227609, -0.1681646385474912},
    {-0.46381863253818734, 0.6092922947699982, -1.5890013086955124, -0.7347704454063467, 0.5680628588627803, -0.5334808083635713, 0.5452672613883158, 0.2376731318965107, 0.31605807161886745, 0.9091764147914148, -1.3146262109051225, 1.21267481756506, 0.981894051039568, -0.2833226097311038, 0.8982177427235426, 0.5138946343530361, -0.7594256431844183, -0.830553930138607, -0.23070957040208742, 0.85302937585245, -1.2662926351478454, -0.6076555091645995, -1.1693111463443726, 1.0336092096288647, -0.13530833600367612, -0.9244382888696532, -0.8540300270949979, -0.6872709805227097, -0.046132233218755286, 0.9986338227097157, 0.5450472729905649, -1.1275538921458381, -0.8546520387947414, 0.8714430435670109, 0.23766996177613633, 1.2785993723915154, -0.9446165000549609, -1.1007451887561777, -0.9526781667814669, 0.9976402194121468, 0.8491578567468467, -0.07812255878098971, 0.04434247342439906, -0.6065444826822063, 1.155197385586565, 0.16066696560082233, -1.0280463615807762, -0.38770452345952494, 1.279369923617086, -0.5900166754786988, 1.0405915269413115, -1.608826972641875, -0.5170468233429869, -1.08970193733111, -0.7234391164424243, 0.8320831278070205, -0.7487763670282961, -0.2324319876687555, 0.6645098687367699, 0.6330954963327405, 0.8838373211023115, -1.3592955040395283, 0.020860774682190216, 0.6030304443830605},
    {0.44786391825232713, -0.03719209499038602, 0.2928920126273313, -1.0974776695761033, 0.46356822985999957, -1.630338435572111, 0.9331927797287891, 0.5690219414958299, 0.3155237449742643, -0.18992306303810852, -0.02789050367289622, 0.41615996515961046, -0.26262929517257366, -0.817529351150134, -1.2092688669205858, -0.39025689509433176, -1.980208506323015, 0.1721402288189271, -1.595168421307972, 0.5242273335630719, -0.29877049590433435, 0.6071212334839037, -1.504373837783059, 1.1143749796336069, -0.5404898161415396, -0.8149311020536022, -1.5151097302666798, -0.9852686004322857, 0.1667800548322072, -0.8467895716591346, 0.048173118032675336, -0.6642067594606414, -0.4680951596826921, 0.5108498929558201, -0.2527289150241763, 0.7555023744365558, 0.36062901122136165, -0.7806025425092669, -0.8631422822272473, -0.500434747895681, -0.8738960686160628, -0.4295819698701352, -1.3900814687240433, -1.5932980040398654, -0.8263553486332942, 0.1443428163136515, 0.5828277882246604, -0.8935698452154636, 0.41804646672901313, -0.21003623024580534, -0.23972257321224247, 0.34424220922337845, 0.11360474040756863, -0.2829758382611799, -1.4709033345714817, 0.4845450060570601, -0.6312115919428675, -0.834838226344406, 0.32808521850219974, -0.30485800975370464, -0.945994641971112, -0.7767926812788732, -0.840225324869324, 0.5190969757730161},
    {0.8768445325642231, -0.907561910805466, -1.1257204353962775, -0.8649837033117236, 0.08443891711610374, -1.5303638896561806, -0.4535544902292645, -0.262747985812442, -0.22201893673064813, -1.1659622424026947, -1.7378629326924537, 0.6354235636614652, 1.0305177210816687, 0.6698804913962474, -0.9015333896934151, -1.1617741396454415, -0.36951343808946713, -1.1709463930293649, -0.731857692405658, 0.6523321742769576, 0.126963724006548, -0.3475718299980736, -1.4849953536997262, 0.14295211948118577, 0.40810628775773666, -0.03734491008809022, -0.5369028772914772, -1.2348103708073261, 0.8812473036199115, 0.7133257186575944, -0.8713633753198528, -0.8181437586301092, -1.2157615599816607, 1.0491690690842055, 0.707423745451293, -0.6682116164096114, 0.30517281203973556, -0.7373974845017265, -0.44404293425441016, 0.47746330469777604, 0.7592652437335415, 0.5925222657641609, -0.015091650556979912, -0.4923505248417008, -0.764720921314711, -0.2917092821427808, -0.8980790341300673, -0.6441870582328316, -0.38746142120759225, -0.001726190494620274, 0.8522804641167296, -1.0625691857334363, -0.2580047990314118, -1.1283547272155685, -1.6428415173206394, -1.3557675659611175, -1.5310901479231325, -0.08682810086209132, -0.4335673071249117, 0.46860669262351884, 0.9195378289001914, -1.1100343488760565, 0.09709303834299837, 0.5863608664858105},
    {0.33544726567267125, 0.2177684600312163, -1.7030630584537896, -0.6938123154361343, -1.1149489626876603, -1.4312712280615432, 0.5721629295444735, 0.39255858249713477, 1.0599561696814057, -0.06086288488078994, -1.6423836868814872, 0.1503933811842105, 0.9054361741040781, -0.21572993943694535, 0.08934289992637388, -0.663578118492822, -0.8366539153577274, 0.2315955950506803, -1.6734695908589075, 0.034271655676203064, 0.024884425690266384, 0.5752006436726056, -0.0844213593607934, -0.745855409460672, 0.5539880710821956, -0.5845317099154532, -1.3088241992999254, 0.5148401727606997, -0.1576260802169954, -0.015258226724610703, -1.2302984069860212, -1.0407184593050938, -0.7681368036652956, -0.6588840976293232, 0.5303110082439277, -0.18389948031687187, 0.26265002638757345, -0.7088096068364669, -1.6903839015725703, 0.1952792778004044, 0.991688855805416, 0.21373716305906734, -0.07283019338461845, 0.16472679030317622, 0.7670438108828636, -0.6521316884531174, -0.35650873417856044, -0.34889839526466254, -0.12107957020632137, -0.6446597913116202, 0.050657681697730314, -0.14366234483632273, 0.3104998876019901, -0.32293116887893497, 0.10530079120149134, 0.6511435971699885, -0.43244723702836413, -0.3932469666108451, 1.0186084148769488, 0.7642669617136284, -1.063504533862817, -0.43708210838202743, -1.1580492859951401, 0.7245006681476375},
    {-0.20889910494154096, -0.45029014802352707, -1.4572857802015193, -1.478110990292598, -1.1485008626984943, -0.7784984702010992, -0.11465343945357402, 0.7307893589610959, 0.39740296121238783, -0.34671618767572016, -1.1439840044757608, 0.7192894847573773, 0.15680370826032497, 0.7355552241306955, -0.17745042825012586, 0.01464937754386418, -1.910692362810789, -0.8100780433851394, -1.225357635736654, -0.2148689315472841, -0.07748236082998967, 0.3765214207745982, 0.2962838985581214, 0.3017063757391063, -0.7658119901076195, -1.2226317005059388, -0.7996833160612843, -0.5968331774954544, 1.1023450363704388, 0.4894222507702904, -1.0411509635719087, -1.4552966758531183, 0.09719500568580187, -0.24167987005423805, -0.024438385409494733, -0.43194159698506546, 0.41456740536734643, 0.36956106000296796, -0.04848303985593681, 0.5502705955322037, 0.274742737093525, -0.0621711732511677, 0.17232194349054572, -0.8144213326847667, -0.2616683198378916, -0.3519905337483413, -0.3023747196703188, -0.6270317693858267, 1.0344594069796202, -0.6756553082687067, -0.5127478883978949, -0.9687316118746393, 0.1902072719724738, -0.8287021152291429, -1.5398393572530347, -1.0037858593306688, 0.4661401287007911, -0.5986076805421116, 0.7954446986223446, 0.6433412259630019, -0.24295963632817508, -0.48858258693110596, -1.1432025363924458, -1.2004017406311516},
    {-0.11057027960353134, -0.21503996249326351, -0.3956555138501065, -1.0551390942604797, -0.5327540152016805, -0.1301858948693594, -0.12877639245987776, -0.8923703032439487, 0.2769274297502168, -0.4501117665443293, -0.8142889008919172, 0.4226490575665087, -0.008059595524475917, -1.0943340307669212, -0.9920986304127449, -1.3920354501814596, -1.7760165566153778, -1.0222403063805157, 0.13371215226547367, -0.3160236272404388, 0.459008456391613, 0.8327007983139912, 0.039696410772089886, 0.1311421126001925, -0.537432790253265, -0.26367760865669393, -0.08774903672470884, -0.49360821890907264, 0.3320396865153013, 0.9917897012030619, -1.260454473271922, 0.12800097367476193, -1.6043897397701459, 0.9245447186571462, 0.22844189365206818, -0.8102060396258433, -1.1650746380910222, -1.016677243764312, -0.991979761694069, 0.529645915125382, 0.4109521561100473, 0.18963944542571992, -0.16697502031406725, -1.707076095567299, -0.5361053995738272, 0.4393297247490074, 0.9036056667436971, -0.5796267773862427, 0.9096334633269638, -0.31257426460520044, -0.13228070103432663, -0.16156018884594037, -0.991216045118695, -0.8203622910013363, -0.9695104273024923, -0.7911393839013001, 0.5286811259606244, -0.6109815777515016, 0.5510210300826998, 0.3711101022987669, -0.22567733260893452, -1.537406442816863, -0.18203494954902363, -0.42016794888063536},
    {0.03725997488645284, 0.9847748036208153, -1.4700799928061206, 0.2078534697288487, -1.2482400693102185, -0.8378293350663574, -0.44069148862028645, -0.9756564875544067, -0.009553510637378113, 0.5562303534206028, -0.23439701981468203, -0.5276244657789476, -0.09835470832222241, 0.4008917279752566, 0.380565465642088, -1.1206119465378768, -0.8126295701466496, -0.9265918824970732, -0.7493407146841918, 0.4584896329813954, -1.1303970294349195, 0.9396913824542618, -1.2325333175512394, 0.8354788359565578, 0.2704210588878929, -0.9365225606960503, -0.85276090746204, -0.5940632244370893, 0.5565205479058841, 0.48915632679794085, -0.7056463399223949, -0.3898161740513129, -1.0497952437994933, 0.7903604284157825, 0.7352658953730423, 0.04942040767679016, 0.12267455761573727, 0.277125163913271, -1.0389332339220863, 0.44553645342533044, 0.667166239963521, 0.8026630063955704, -0.7591813059954723, -0.6111303538066427, -0.1458173185815102, -0.18829020400122384, 0.6817763709923453, -1.2607733884061036, 0.6820689878380313, 0.29993910149910774, -0.10109340347683039, -0.1456105585011299, 0.09812752880431985, -0.5426448031608447, -0.22906400910703295, -1.2972954771959466, -1.0649473779600098, -0.5595466431511811, -0.7724046020594507, -1.171270345305162, -0.49547673711821355, -0.017240747283482565, -0.7300082650033402, -0.14504052810207704},
    {0.19849534865017304, -0.2655652483439174, 0.10265303030264152, -0.15504419253261478, -0.013605494127883314, -1.3833358300668477, -0.3187582470996027, 0.553586837045269, -0.016257938733400083, -0.89747738657864, -0.5562309478092615, 1.002626032245666, 0.42982931259575935, -0.16172252798700484, -0.5961149699479968, -0.18217312657547666, -1.9841845145563113, 0.421865537953643, 0.10974154604461829, -0.7623110173622982, -1.3656800641482274, -0.19677614847812214, -0.7692383414817351, -0.08532824482825274, -0.1678802939125998, -0.15898401479814603, -1.209491631851344, 0.02922769475196455, 0.6966133707654147, -0.5266616213644244, -0.3134969133648666, -1.050114652566154, -1.5038237212365828, 0.08967549783794858, 0.5381016645543247, 0.33216314892274884, 0.11476834145086061, -1.0969570710864995, -0.7844804531114162, -0.8156353730055544, -0.3435748570781509, -0.3729599135281638, -0.13411558034567356, -0.9586990729981069, -0.06848172588117199, 0.5191223571105396, -0.08116838824873346, 0.42789451801924744, 0.7822658949821212, 0.474985550291178, 0.9554369919900031, -0.8913338704150308, -0.7906661782734316, -1.2414230235750152, -0.7935404242792481, 0.587393068088626, 0.3268818093259853, -1.3491766362537416, 0.2151915059628538, -0.2095592992413179, -0.002834314759806957, -0.5240993275812532, -0.9935078929144643, -0.15683418618484615},
    {-0.17852976682479302, -0.20994204948639472, -1.0579017512973945, -1.0885904633386505, -0.12963436293576783, 0.679528394266989, 0.607249574114504, 1.008447482835442, -0.15516752351859134, 0.983987312451871, 0.5047330149024748, -0.9767071708174113, 0.7901742400670634, -0.7968740956587806, 0.17778349357865647, -0.5219261581457365, -0.4482250913764253, 0.8553777704353631, -0.262784269820882, -0.8218926040152047, 0.31677022480816946, -0.7606073261795376, 0.5383797742013932, 0.44347857275801, 0.6996707488521619, -0.6858393339224428, -0.8440298448303745, 0.5816881584848556, 1.0030484464907654, -0.4030712776209603, -1.0357192766019867, 0.07034677598247109, -0.6433363629545782, -0.67374151794467, -0.20021755294185858, 0.4602513434472515, -0.792499929657687, 0.3671346358622054, 0.9697192895278532, -0.7819254639903888, 0.3285601515265005, -0.016199458342447744, 0.9615999571227087, -0.2013820026170388, 0.9889840564129095, 0.5794929391345656, -0.6720876166870586, -1.2835127762935967, -0.03774860604414871, -0.8790287165702296, 0.3473944429127179, -1.2030511583941772, -0.7231339937287087, -0.5382294781047036, -0.15079867001745856, -0.5245193979370788, 0.8802203564375838, -0.13479543059479188, -1.2358919583462336, -0.13751455680456348, -0.06139930622773406, 0.5253708405580689, 0.3109884728031817, 0.7249361790316299},
    {1.0247840040783829, -0.620617277443556, -0.9317579039527963, 0.18013691723528585, -0.7806764932429294, -1.0203679555547374, 1.1737146496228705, 1.1403711135648926, -0.8849435331294735, 0.24871273697584664, -0.5643011268320205, 0.4653126620623504, -0.7699895674441791, -0.20204609205240023, -0.7585466859232848, 0.4222909226689515, -0.4812807864829404, -0.06359932853562925, 0.7612037800392348, -0.9510358985829869, 0.9795053553659171, 0.12390667700113767, -1.3133682697940545, 0.1895096600598911, -0.5710320022453316, 1.1964175052453883, -0.2605831675454175, 1.0723429895161531, 0.6996294562389994, 0.15131646790292283, 0.6368412112561649, -0.8699581617168, 0.00040708228246334255, -0.3725922769318225, 0.5383408185479635, -0.27393167127266266, -0.7545582305748764, 0.6695757600390164, 0.2651046577548772, -1.2189306895986156, 0.8932776652653964, 0.6567620695300437, -0.4674996977402671, 0.3344964974754578, -0.5067561230715295, -0.4558232318773861, 0.3623768026397999, 0.33700242678946224, -1.0459263940360541, -0.8017122975720913, 0.6675653379910825, 0.14491152733095336, -0.7813489312968167, 0.5365257515316295, -0.6131821907128805, 0.8362144328997864, 0.7350672753034372, -0.6496336214582551, 0.9010615295142702, -0.0676159270442769, -1.0591656015458975, -0.9509891941813244, -1.0948126205689643, -1.1653305884790517},
    {1.1001498576444153, 0.2811401780568378, -1.1882500673187046, -0.07204110362457204, -0.9977318396906482, -0.9980085142001022, -0.5048234171469976, 0.5616118753692666, -1.1722434683322687, 1.2806237618771907, -0.3625826175174967, 0.45704359201480493, 0.47346133580021815, -0.4519822796378304, 0.6393376072277002, -0.20535421173539148, 1.1526267938006862, -0.18991826396039987, 0.3407217716164334, -0.1595133997615024, -0.024389884851477847, 1.2183703038853193, -0.7969385058951116, -0.3654449568567424, 1.0372912111179742, 1.0535966961666974, -0.33063357602106563, 0.5484622715806439, -0.15269263444425546, -0.7295902442998227, -0.15186087632934406, 0.34026835689560386, 0.9923815321669219, -1.3302157662850251, -0.7475435576555893, 0.39577655981567433, -1.0654737423971474, -0.05451603099800849, -0.7817918050905732, -1.2729843207922016, 0.4937747930436755, -0.6814183153734289, -0.8160146088188197, 0.7097863483936333, 0.7757248542984612, -1.0922730351506011, -0.007211273519480935, -0.15905437675988496, 0.511671060383921, -0.8769655408912546, 0.7105988821298815, -1.0901388880716425, 0.19213601900866686, 0.28322695501800793, -0.7626034157676351, 0.7828958086208238, -1.220440746158319, 0.7608266837448792, 0.595547174069339, -0.09355814861447369, -1.2503301968468974, 0.19615038272856325, -0.8373073959947456, -0.9565721115468971},
    {-0.3506934482845234, -0.9968755847974846, -1.011100548488381, -0.8557938667758272, 0.05759304028608497, 0.15501542340467098, 0.5173565508532023, 0.0997621574630914, -1.0229816537970406, 0.5782803111809198, 0.6187923919614474, 0.8731816656686233, -0.1629288641479042, 0.9966599016880184, 1.3146385350552419, -0.4575528137500427, 0.07832540081676538, 0.33055535186672, -0.4578685234109429, 1.0921680465766475, -0.18036983371706725, 0.5526673352110956, -0.184013238460869, 0.7929999280927243, 0.961478239454463, 1.3353888691883329, 0.7521675331031535, -0.38826835780896635, -0.222974640284435, 1.1555205169132208, -0.8809171430492256, -1.1958089386964796, -0.41563603818910433, -0.6930864106097628, 0.3771345990893989, -1.3748768003794223, -1.5398365977756485, 1.0286766406898253, -0.9388755179762743, -0.24710386685270977, 0.9470092917747208, -0.575935980639916, 0.6070778206206201, -0.673846001541798, 1.3832875162109013, -0.37262035655074754, 0.40410295006381514, -1.3363096410385367, 0.45002159484968435, -0.9644267580148006, 0.12043330630443029, 0.5864675965884654, 0.6681729875178523, -0.812735131709186, -0.006930042723778106, 0.973978108080659, -0.6778725250927267, 1.0783733023026534, 0.21458291112045555, 0.11729999041951167, 0.02639791518284809, -0.7107421363376863, -0.41360941518506256, -0.9213346571330582},
    {1.077947791574894, -1.340070775921257, -1.4128084826468184, -0.1993767756198726, -1.0586041571969358, -0.7816665229491555, 0.8232490364126657, 0.29558165642569073, -0.44740390571074873, 0.4244341592786435, -0.6477036303647333, 1.3046925367938151, -0.1868299862967978, -0.5706175499511399, 0.8073878369797717, -0.0514873598363121, -0.3686399044926058, 0.7750499273305133, 1.1133648523159418, 0.3464832068263474, -0.4314037951109176, -0.5540632794601037, 0.7447872178628413, -0.821104331594177, 0.8468649896693626, 0.4174029787778446, 0.6984025550643896, 0.6319962715181273, -0.08985942530640478, -0.7505599382182102, -1.304687113077971, -0.6445877607393451, 0.3711143821703698, 0.3916554041856163, 0.7236110705464227, -0.5067394456214616, -1.5071244191576023, 0.8596746423667434, 0.6689968971097385, 0.05377058065078007, 0.760022655644028, 0.26892103800911865, 1.020828431184196, -0.5830681032944675, -0.5253090489891585, -0.9787192011727935, 0.06430751334688642, -0.6418613807811059, -0.48805265303923545, -1.3692966922329892, -0.5466906679950468, -0.726466387001132, -1.256468157840098, -0.14662303569491825, -0.5011237981328883, 0.22450612994106822, -0.4351306563473137, 0.07087644055441907, -0.8453440764442269, -0.5158542932656932, 0.37760329188288133, -0.25025451195924986, 0.11194486449321793, 0.11963973679119543},
    {0.3086554303998886, -0.6123714651041638, -1.3516671939652005, -1.0367478542100652, -1.0711318154470337, -0.4039963449865333, 0.5658559951691814, -0.7067486070510796, 0.049518640147136375, 1.32579131372887, -0.7236265036695212, 1.1783844886406831, 0.9202192360550201, -0.25583257792322733, 0.3519404645804428, 0.5454491883799087, 0.7893532143116334, -0.7262114992438715, 0.25004212809749865, 1.1388154917944933, -0.9015018076222683, 1.1745714199199533, -0.42963320421115087, -0.0010124045641377996, 1.357455535550312, 1.373009635246491, -0.2608169946399249, 0.9168014609944912, 0.389020459407545, -0.5015968389934704, -0.5727993142604867, -0.7172383149061934, 0.12279654124209212, -0.243242498411094, 0.024859499704494505, -1.460633439093805, 0.5394336060935888, -1.0405832298139468, 0.15289602740666827, -0.28497249091423715, 0.56764895565808, -1.200692195867489, 0.5064804396540228, -0.46916298950264923, 1.4585747707488832, 0.3035976906371141, -0.7988016296293443, -0.07966943489177886, 0.20173350411266155, -0.9494308666435077, 0.9420209306772301, 0.6607559046209656, -0.8097246311043212, -0.4725224350232258, 0.26576490984985723, 0.31456101213887605, -0.36767488644182766, 1.185209086783353, 1.0122638639888255, -0.07923915964694216, -1.0990852482226825, -0.2047333564452425, -0.6135724014271403, 0.04934288665280517},
    {0.8146460356225145, -0.856512747317462, -0.8318628600735476, -1.2398365312473913, -0.0957463950275784, 0.9159245184260543, 0.23451469410359707, 0.05099399485626147, -0.36990414721553994, 1.4913279924104907, -1.0272819391500445, 0.7407418496766089, 0.39160172319749115, 0.005748642479247327, 0.1708112922186705, 0.4046762047953616, -0.4543612708748772, 0.019089072693901647, -0.016872281563325313, -0.8042325860408789, 0.9557429825570006, 1.3074606767136618, 0.7311177503808627, -0.6032920752987222, 0.7658261773725792, 0.9711842547292409, 0.39287709639228474, 0.2287299895580605, 0.8331766222803281, 0.8250475691476886, 0.47389406995126576, 0.5601646917621529, -1.0503641651093765, -1.3740401701365275, 0.27649635459505806, -0.44620635542060894, -1.2644021494871909, -0.505039990312455, 0.19937526571232458, 0.16196358875145228, -0.4834762107219438, 0.18120278997509925, -0.5177480868367162, 0.5170170501454885, 0.7110749333313455, 0.1147618940439552, 0.11979791029049601, -0.34290331953019604, -1.0638165926295455, -1.0517420847410162, 0.2989275708586952, -0.17460761220776602, 0.6651065147091575, -0.6838095823980095, -0.6453403957797267, 0.7776459846981132, -0.7337225093605056, 0.8679677097778049, -0.23284489571982597, -0.2334479062527059, -0.9054048989419474, -1.022448483120122, -0.7661018116793789, -0.6098061357618674},
    {0.6129962289147163, 0.14139885702998847, -1.4568319014538862, -0.23435156406587418, -1.0616824225050594, -0.048916948490927765, 0.11481924941484142, 0.7378455131720372, 0.2260503311360239, 0.983006458807389, -0.38646689878291823, -0.7194458334201679, -0.14781306887482448, 0.7069365880117575, 1.3600249781471292, -0.20542628604712893, 0.9101683645730785, 0.1695101350976846, 0.09304065725799443, -0.3651786599676119, -0.07089879141147469, -0.4096846724340195, -1.3076198687787421, -0.6654788297521288, -0.11126065670154156, 1.1628198216200634, 0.8196551716965603, -0.5599134065012956, -0.3717540732074048, 0.9080044299717246, 0.6632037785669956, -0.35079627959082066, 0.31606325991102474, -0.33640704070865296, 0.8097880376209171, -0.8879792635685535, -1.281081495361159, -1.14479900030789, -0.11554676154594225, -1.377297232544188, 0.18074519068436692, -0.7758345448598009, -0.7392952314966074, 1.1218199001302962, 0.7064827641282244, 1.1281285985422793, -0.4188117529430389, 0.6091839995726331, -0.5359098242597617, 0.1587824138048361, 0.7137933988573727, -0.6416106066771907, -0.8063465513896412, -0.7193593419169216, 0.6200164286328135, -0.5305697911279702, -0.18080736099727285, -0.4380581719155212, 0.6610432014494307, -0.6831760807081916, -1.126337657933264, -1.0169263672152065, -0.03405733856470516, 0.856389891488816},
    {0.7271087496653973, -0.8091422573900906, -0.08495060283072162, -0.8301850221387594, -0.1177176977574353, 0.1552392983850423, 0.5911557396019612, -0.02435039971918867, 0.23550895673762096, 1.2641851147491596, 0.6327355718345727, -0.40841417171048633, -0.16494842980994984, -0.5928775034952429, 1.485568307347794, -0.3871616296868367, 1.1849854731464666, -0.9951088868892959, -0.39629667716845823, 0.73173941042082, 0.022857031381377662, -0.5666961421531717, -0.6358647003129316, -0.39998230049630545, 1.5115228473543223, 1.4357683198607285, -0.9171254417848833, 1.0741586239131722, -0.008478815711102964, 0.15056173525915165, -0.4228833633351582, -0.8688679316585143, -0.7964902602136781, -1.4732243655024222, -0.8211439178378226, -0.7657867456934931, -0.4543520804494771, -0.7924274247864856, 0.8915923628456905, -0.8042835825828922, 1.0595512394546138, -0.48571635923929923, 1.0635829503299814, -0.6714185752358242, 0.7028604845038184, 0.5763747515808446, 0.6676148297239461, 0.10178608716782749, -0.47773130548551235, -0.9384176800552522, -0.8903096823594887, -1.0689056730988633, 0.14446952575310948, -0.67292900532878, -1.0188922294502036, 0.7636431860781137, 0.5678412301510459, 0.11377017589805609, -0.260146837834348, -1.3226888927125369, -0.5466263826374197, -0.7079750519751665, 0.6405364068781404, -0.7069640837829102},
    {-0.6710337009247737, -0.04353831854909879, -1.0709648844336321, -1.3419921529663446, -0.5135858483579372, -1.199742412739235, -0.5306714885022868, 0.8806866979908005, -0.17177390258412364, 0.44791058899206243, 0.5468100754226964, -0.5765253611308815, 0.628617699625001, -1.0202451040636595, 1.556238431056808, 0.9168509272347161, 0.47885061260254586, -0.44917638527640313, -0.10092242141299451, -0.8234693261189883, 0.8623222677493709, 0.2810665704074948, 0.3957122999512246, -0.9505284306845962, 1.3105133292992368, 0.8997654503181322, 1.0013139492760175, -0.36779959368166376, 0.7873940944026919, 0.7699208526648035, -1.1934344596657949, -1.2090607175912385, 0.9028462058485138, -0.23041257575240384, 0.3085056752846951, -1.2841749843878354, -0.8552980720548407, 0.5747966441018563, -0.14354967271516716, 0.6978341007544889, 0.9930099473486753, -0.7567843145568081, -0.06993652001450741, 0.6700886894440466, -0.447559813003852, -0.46935051473810246, 0.0518683442920403, -1.0554343034229332, -0.35505798902422175, -1.3008056479990813, -0.9129469018031245, -0.7583754636564002, -0.344984809214379, 0.3746343545034918, 0.3198859881660837, 0.5304097283526208, 0.9623156124830029, 0.6390370974831953, -0.47822410789751846, -1.1845632386102551, -0.7725387077033027, 0.5537803335366968, -0.8102755362640269, -0.94767978538826},
    {-0.4274965186327487, -0.006382917201585916, -0.5012220872351313, 0.006011908461269294, 0.5808513542373577, 0.2970087959667284, 1.3926029171508263, 0.6646906416709101, 0.41717637164785487, -0.32317541936162447, 1.1450138615872831, 0.5443524947131652, -0.8509248443129688, 0.773790772393919, 1.2522271196987325, 0.7269566616880695, 0.5718096687365496, 0.1017328997183999, 0.8779619055476193, -0.17962093448159794, 0.7509910220943338, 0.42383337938508797, -0.28350456414725916, -0.4922368584463874, 0.27370024969418455, -0.07654544685954535, 1.0383713370863314, -0.8656602742264541, 0.6674162922158072, 0.527022677304152, -1.245784571189056, -0.2957562515389647, -0.52642919359501, -1.050247954566005, -0.499062868404137, 0.15876573372804456, -0.2474883144553518, 0.1110341321838359, -0.5719354894416221, 0.21641592984245842, 0.5431026434945617, -0.38233792534974265, 0.2143783590310899, -0.8225703689904259, 0.5020733182151754, -0.08063281869271158, -0.2906849395008758, -0.02646309161015536, 1.0383454086957942, 0.5062003574926027, -0.8051531233285931, 0.5944287944384805, -1.2043115194382368, -1.1186895743930003, 0.09571685855720438, -0.5241006681675717, 0.14598188324596337, 0.19261024228993015, -0.7039784740497619, -1.3994724398948493, -0.13477962831622892, -0.7542316022583886, 0.3797607638004664, -0.8305683029202843},
    {-0.12221385089165247, -0.5006735809884922, -0.14996829364882658, -0.7281656625477327, -0.28998770809712293, 0.011320441959371043, 0.6497747036161274, 0.26831346584493115, 0.47007926837720787, 0.4403082382266233, 0.23208168293360446, 0.9120020232607647, 0.8966416294576743, 0.48525528361362075, 1.5235574298140613, -1.1691530833067354, 0.6070921024599548, -0.08107181368897602, 0.49039427257565293, 0.8978215365136356, -0.32677677620323076, 0.3004798154422691, 0.25746301332596355, 0.35453308933755323, -0.25604676375494095, 0.7377920531689087, 0.006233023255284807, -0.21956053616342755, 1.014606695720196, 0.8897829826383322, -0.9096194222947197, 0.6234741797567535, 0.06413552591968866, 0.735521000130394, -0.7881807975602024, -0.05385602093112614, -1.0025887278944166, 0.5531242288564286, -0.0027344742861073004, -0.5114405209752425, -0.20281135041141893, 0.8411470691517934, 0.05504791516730376, -0.6974385348538555, 1.408713432875175, 0.7196948102037128, 0.811600600881047, -0.2853451652137856, 0.584466669652031, 0.5943885700629173, -0.3365059135188626, -0.2678069971997003, -1.2857904391214574, 0.5640255970910453, 0.919649041591097, 0.0799626643197714, -0.09761625212622134, 0.6481235305123055, -0.6063499844911812, -0.5821308767986733, -1.0709033928445177, -0.2299903965898351, -0.6055104356883884, 0.6768244920227547},
    {0.5786947292864651, -1.0703142487662853, 0.3295412571575561, -0.23305012935174751, -0.9011168937904875, 0.4940248080788132, -0.34732178837868455, 0.8290708073929005, -0.004684092506361507, 1.4575736599860927, 0.7505098335060257, -1.0492436679753818, -0.8682985191666258, -1.0170947267269774, 1.3245968608286525, -1.2219488592971597, -0.7950057801124272, 0.2988392617257681, -0.6343736380303907, 0.7487267845558938, 1.3718930190498455, -0.7369211918882971, 0.08602135837337138, 0.5874145666022175, 0.8792954462945478, -0.08604719444034192, 0.4756038037524568, -0.1341797904093681, -0.2535179863994135, -0.9046846409701926, -0.31916397126702023, -0.9274702787934144, -0.9254831879083572, -0.7224345056127555, -0.7343809173703194, -0.71980055838901, -0.8205368145017476, -0.4762388967544241, -0.9406700687030536, -0.06751843759722732, 0.6622850981948781, -0.14755500544185912, 0.2763025088352132, 0.5485164953375772, 1.6835066938044967, -0.1837076631414589, -0.8893549031168557, -0.38562394708101244, 0.17957572798025936, -1.141400061833398, 0.5014585216618274, -0.14538128814230813, -0.6155122304703536, 0.13814781204024343, 1.2336066650672612, 1.0040504682037872, -0.8259074606136361, 0.9323544065315796, -0.7782148676037612, -0.48758008178578827, -0.40453580106031867, 0.32130326092176886, -0.6836721057284522, 0.2716314267607497},
    {-0.8328404591657289, -1.0353028348478288, 0.012675499380746464, -1.4517347185455494, 0.7898369355214311, 0.01432579433550238, -0.19868895976999995, -1.0281647496073882, 0.5135950326744937, 0.8397120950238203, 1.0606335941864349, -0.9823931723298142, -0.37677733044579675, 0.7926979194705128, 0.4024279225078896, -0.18458765537867383, 0.4313843298021998, -0.12407839859527525, 1.0449748496507298, -0.42548256791924005, 0.58582206535131, 0.7310467967168192, -1.128530028918585, -0.16896404008719243, 1.2007168701821582, 0.675001985415854, -1.2741697049507483, -0.5032878913191697, -0.0932663656198989, -0.5541065004289437, -1.3258188501629438, -0.3443443761854813, 0.02462606135646045, 0.6301863419827087, 0.2874877798792863, -0.6825552098732753, 0.36290232236325193, 0.02877006278833336, -0.8017743149453629, -0.4369134010954648, 0.9095909077073006, 0.4207767283806191, -0.1489497451765714, 0.47777531850295707, 0.9065518712994487, 0.43004723274328266, 0.553218821346603, -0.5714669578519433, 0.2760457187414464, -0.28342412017249735, -0.8217948985380205, -0.9178367770152815, -0.5513226186759735, -0.24818073662350962, 1.314509801893855, -0.842231982032217, -0.7324045308433801, 1.142402209631659, 0.44427554737784636, -0.4789476958121913, -0.3837453606487311, 0.6921099088278545, -1.2263892439832538, 0.9237179343664574},
    {0.9068200790277788, -0.9218027076315299, -1.311036414894678, -1.3037728198230016, 0.061100346639780256, 0.5869788332240945, 0.45149829822222964, 0.12170236017508695, 0.8827052931130964, 1.2755196624011382, -0.7715389478358617, 0.9868184575205425, -0.24760452833198626, 0.6758980362093723, -0.2838341683109503, -0.06327963021897441, 0.3335496051691683, -0.06448837873332088, -0.8151165729810004, -0.16102264154684579, 0.6336412732545733, 0.5508843140290436, -1.1892321042845593, -0.7672603174325663, 0.141981748213341, -0.7696578083983847, -0.1807053081940433, -0.2949141649464357, 1.2250074115515683, -0.4853202651280954, -0.6590671529698199, -1.086730359722978, -0.948405769723854, -1.3139096081991548, -0.8641704702437365, -0.9166708090184409, 0.5167051274360599, 0.5160548749382382, 0.48779151582491587, -0.35253159545151636, 0.26005323812107933, 0.8008094900093078, 0.1530216793532296, 0.9050457327440943, 0.9236489857839504, 0.49405517930660026, -0.12660326439180794, -0.863201608091892, 0.6215147931938163, -1.3417802521928166, -0.09504492544753808, -1.0540109221568568, -1.1599810476718897, -0.25326382938421155, 1.058143681813357, 1.0208168775851745, 0.5465980019820619, -0.7407975137268519, -0.5416865076874622, -0.6247256577155343, -0.31549268144416986, -1.0843723933529807, -1.4185625309962149, 0.5445059595823991},
    {0.4725885931938021, 0.5064735672124298, -1.376889382931381, 0.6045798345093154, -0.7378951427119423, -1.1423404340878685, 0.5273848016064628, 0.4884924059149909, 0.3929695343097666, 0.15368051333809576, 0.24339369943854466, 0.4913202310931276, -0.3568955875212576, 0.23094014505056246, 1.0691532113651063, -0.0870129244010709, -0.3515170301670789, -0.7763837127450886, -0.39294729842842735, 0.9436212585233237, -0.02553900842582222, 0.04627460550835429, -0.4123697943363844, -1.1552145336134272, -0.22788700722002544, -0.038973646121591786, -0.10687512259816115, -0.2355272694151379, 0.6054307511785512, 0.6605109157565449, -0.5699848304990779, -0.9467770355118762, 0.01030900162181086, -0.3291112355373444, 0.11437330277319314, 0.7311930018358451, -1.0451075502741618, -0.5402612413701424, 0.09959463818939544, -0.19294744857076201, 0.7241666136653491, -0.9967488202476502, 0.4196519635108834, 1.2525572015356656, 0.10999881602423181, -0.8746823959533568, 0.6916500494460627, 0.34950747707515123, -0.8546457573322258, -0.559378842302797, 0.4010352755088905, -0.9518406968506294, 0.37322356353251074, 0.3958748531542671, -0.522766938718323, 0.6165080008202135, -1.1526891391342042, -0.5774643177485974, -0.35157334550597885, -0.8907896610849589, -0.5282564713949066, -0.9626489961250175, -1.2000299738014593, 1.0765579818632631},
    {0.4063402470617723, -1.4639084783454779, 0.3421206589906408, -1.053320100723085, 0.5401297659131257, -0.13613504696443599, 0.4774901546860869, -0.5464161828832805, 0.2902022593947691, -0.4465940873610228, -0.7069529390112729, 0.3410472596704984, -0.752223990961828, 0.18789158429231484, -0.19436421406539875, -1.1090672363450087, 0.9945138368975629, 0.6622183660511592, -0.3863952403197424, -0.5646750259585039, 0.49779013589243415, 0.9096466988424778, -0.07728962551157777, 0.9692875389507654, -0.3660764074123191, 0.5452994241367622, -1.2297108340090916, 0.3590886132380245, 0.687882787033609, 0.8956452027209253, 0.610397998692849, -0.955404697179171, 0.32437024818772886, 0.2592489227860995, 0.23976654789708265, -0.018815849144119667, -0.44811475971098574, -0.6333915102251279, 1.058110755208596, 0.6426465128718796, 0.5582363445014645, -0.49029967420082254, 0.17822454792538558, 0.7589729003585844, 1.089463662828217, 1.119658419953974, 0.773360956609349, -0.7534748353268108, -0.31196583474578043, -1.0568235630899874, -0.003392197989649391, -1.30311624506597, -0.7522812525452609, -0.5590233322981305, 0.43146020641495064, -0.5965407158251154, -0.4630420994149593, 0.5611962417314765, 0.5809293162184114, 0.2719073005654186, -0.8354831062056539, -0.8595821203173845, -0.8070510256428884, -0.20316447957194092},
    {-0.8315188888617492, -0.18210773645845474, -1.0625081664249385, 0.5654786256711899, -0.20098435514617963, -1.266443581320229, 1.0371585167073365, -0.7041227465353734, 1.2057539777806063, 1.565581844694175, -0.22171023976032775, -0.27946519029367706, -0.2784108401862197, 0.05393299601379686, -0.4776817017067103, -1.2371868857551422, 1.2597500692121522, 0.70372698050082, -0.9924546935639538, 0.7574787622292927, 0.9583609724429393, 0.3248759896125505, -1.228101862087207, 0.8042683009647693, -0.2173958159186878, 1.3972949794633873, 0.2624592812100891, 0.27494308634937165, 0.3024469418367643, 0.10854208763036755, 0.5020338901699604, 0.04953272196383716, 0.7685918525545402, -1.3924652304534317, 0.9317764511266677, -1.1912184711276472, -0.7341213165988242, -0.1103986369781326, 0.5331084189321399, -1.3331870177752632, -0.6277585243508153, -1.0445559219573328, -0.11317132738502353, -0.6960835840812977, 0.893476819689356, 0.7734098677080743, -0.2738236869449442, -1.1092397314595388, 0.954720725472043, -1.354777430974252, 0.6471567177705787, 0.24743974623299092, 0.32191955143349227, -1.2590429930428495, -0.49530182483751284, 0.022356886761154982, -0.45993388341769736, 0.9543195814928345, -0.7504497292304104, -0.2220193558391881, -0.04473423439665981, -1.2615557954076426, -0.9337931809052917, 0.12353262886794872},
    {-0.09115640074141634, -1.293605304973197, -0.38717627797186005, -0.7863552793373905, -0.8203820176871816, -0.41503146422121, 0.3133918353575195, -1.1683795824129766, 0.8465049123645743, 1.5986937571406616, 0.7216418087762572, 0.6040707808578057, -0.4872801644031804, -0.6558380481308118, 0.6933522478060941, -0.375280226408203, -0.7286878292557882, -0.7844979480885328, -0.3891745186893406, -0.2783008493746165, -0.2931689444976669, 1.2581545548020028, -0.027924253570210944, -1.0169807140298595, -0.01817703378986194, 0.1712675919291629, -1.048398114184524, -0.7523795636057433, -0.19455924340258998, 0.11969304336242251, 0.015476213937920216, -0.38469554834263087, -0.7324885880442558, -1.2427777195818082, 0.2935220322910181, -0.058158354680334985, -1.4066655856843513, -0.24616903617044505, 0.6419640451235952, -0.2717782822712028, 0.597987276646397, -0.0926780492944744, 1.3876638670779162, 1.0193528885859533, 0.7435109074220391, -0.8394683898231676, -0.28239619423238793, 0.10061388461031559, 0.6473200169056378, -0.4601597782248154, 0.20065450913891272, 0.5668559366603707, -1.1105960363509801, 0.7113468023518992, 0.7200119687578707, 0.27777062104786326, -1.1388574825142164, 1.3859023719588572, -0.09055994477149198, -0.6100976579914016, -1.16068399999242, -1.3114201601132522, -0.9888682700989628, 0.36789016671522556},
    {0.17200169290803904, 0.24504844143527643, 0.08082880180936813, -1.235556792184533, 0.2485658026879069, -0.5306748017629717, -0.4407331462370825, -0.9785783308195353, 0.5704236779673549, 1.5658602776321286, -0.4928253061389943, -0.5091647661745247, -0.8454588666188044, -0.9571675230543046, -0.0011634443552024994, 0.3493656607833789, -0.0992421843193174, 0.9616076179450513, -0.3816290738418039, 1.1280894369292809, 0.16761450319360452, -0.3418112399022053, -1.2881649540184739, -0.6110732308110788, 1.1531844506593765, -0.3903912234573746, -1.2573877658855663, 0.9422265054774435, 1.157704404353897, 0.14274350615518114, -1.3743876144589728, -0.5230083251018066, -0.3360664862940514, -0.08440169624652709, 0.7249934212433198, -0.9978860955449445, 0.3506524503351792, 0.915774324583831, 0.8419809748279092, -1.0737351987010648, -0.2501510313101395, -0.800225280400083, -0.6806144138527978, 1.1702457378423936, 0.3303023101897918, 0.9354514341546206, -0.4411652155610992, -1.3745979224676137, 0.30271004274348734, -0.9629092431716612, 0.6137502716610491, -0.1744910372104438, -1.01489888944705, -0.5649353820626419, -0.934666264621801, 0.15842533131344444, -1.0416661484499685, 1.538348142615963, 0.28848557781143636, -0.8254645409881868, -0.3860438284973031, -0.9561057711319618, -1.3702429748599965, 0.6899531643785858},
    {0.937478115113589, -0.8988499736618892, -0.13889763652412454, -0.6452596483588461, -0.8238033848580208, -0.7495776889158775, 1.2155243195809322, -0.23461985678137515, 0.9351295912273778, 1.4982524097045635, -0.2981057783232301, -0.2477310662010181, -0.1599983023587217, -0.25148774832855375, 1.0954886447033472, -0.2126187503549403, 0.552027960520593, 0.31882620579119647, -0.21310554441206175, -0.19441677256569945, 0.1252964108353586, -0.7133609428519222, -0.6707608071302952, 0.32975135533107114, 1.043449694283988, 0.13702475871440983, -1.4276605470052561, 0.4044342920368915, 1.0725649333263334, 0.3739209164396299, -0.9910965568104441, -1.2448636127420283, 0.7592092220973421, -0.9982608949817953, 0.7893359095264436, -1.0676759222108245, -0.5414787669830557, 0.09640580961061856, 0.24123208511176097, -0.3015373147691499, 0.36148844722821943, -0.6697597099213022, -0.850361659342659, -0.6176045601478556, 0.568088606374964, 0.2703370863801564, -0.43750834539843547, -0.8007492940792496, 1.0204643188736018, -0.6163625600635133, 0.5175441506440803, -1.3608489088598574, -0.8424507899924597, -0.8626416303240384, 0.34488400022419824, -0.45911039682071625, 0.38591761836704, 0.6710732919400485, -0.8888604829122775, -1.2977204375376796, -0.6469654868994366, 0.5573067272670406, 0.5928810670737803, 1.0285864299550802},
    {0.22872871915327198, -0.5292597008675816, -0.0049941405569165435, -1.4457036495733733, 0.6150705737853758, 1.008720420358797, -0.1625450553394088, 0.06595258206998117, 0.31745898602723654, 0.1104741567838512, 1.1782332179258515, -1.043503805554229, 0.6031000948019851, 0.7417740409403206, 1.2667691134302437, 0.4603951844371983, -0.47101063435151025, -0.9483833889655459, -0.14185702568987318, 0.5260721106798516, 0.4523798215878404, -0.06329521941467824, -1.033133798381488, -0.4086112800719768, -0.14346085889414004, 0.5958923889405323, -1.2228702858517486, -0.4830268949822394, -0.1632118990005634, -0.5717230409411623, 0.6932296358879558, 0.24513670035666085, 0.8905774711801053, 0.12204497643279182, 0.08225618109458163, -1.1452179591539071, -0.8532816175429427, 0.8071813520871046, 1.156219697159068, -1.2344025296744472, 0.6303216423390441, 0.5623067058408033, -0.17083919991882476, 0.7075319873047685, 0.09312800162776853, -0.7081760367375881, 0.17423393036126944, -1.3098495941309796, 0.7642363699637967, -0.15895112228460231, -0.09189941887964734, -0.7284466213614573, -0.6087123787761995, -1.2134407629949442, 1.1470361512950775, 0.12671861657174235, -0.5980967245329686, 0.404721160434866, 0.2608196621834608, 0.14018044133208343, -0.2681647041387352, -1.1708573902754842, -0.6644017743182782, 0.31881435583121936},
    {-0.15954048741252586, -0.0004971773791236022, -0.7163649642369225, -0.5142054109875618, 0.4003061226961788, 1.0114749949850825, 1.464296170745303, -0.9696473577261926, 0.6732439557895672, 0.6625171573591975, 1.1079620387602145, -0.9300541574815243, -0.02816819181110134, -0.21875832250567123, 1.174475565866026, 0.7833525246533064, 1.1305867590715093, -0.06479700978660177, 0.23360085094964397, 1.112481586447837, 1.0948603340748053, -0.7782884806160468, -1.3690269972742366, 0.2951545449081515, -0.48807500149395916, 1.4158662325100508, -0.15211737507358652, 0.7911184721201424, 0.4895214204656198, 0.8972298892270987, -0.0412013287031392, -1.2760126310241484, -0.5799039494957349, 0.511731778589069, 0.8259854510738028, -0.6734310645899668, -0.5478898084094087, -0.5236772433327923, 1.4838412796662817, -0.9048773262476623, 1.2928778491079924, 0.10822769914989455, 0.019074342787171877, 0.4359852607062606, 1.6305286341434833, 0.6824011036889467, -1.0097932893800803, 0.5023223278321489, -0.3315118880308719, -1.5433167819568776, -0.5814314222265367, -1.383521081101799, -1.0095082739692702, -0.5851008414323814, 0.5188360398652594, 0.3336085980657256, 0.33783177885534993, 1.1785388227412865, -1.021868536601726, 0.4388144937275121, -0.70579941877791, -0.030804799766183548, -0.6029065830157985, 0.7399674906908762},
    {-0.38519219419521084, -1.4813451639325845, 0.32903824739221516, -0.07351555043957071, 0.2581496199492664, -0.025513309427737364, 0.6497412132594576, -0.1157185168175947, -0.7362655384391479, 1.775275358173722, -0.270402384244161, -0.7273319010159661, 0.15271147812588104, -0.3961825292334974, 1.3950334870863295, 0.8191373196296041, 1.0270710903594673, 1.0991063710423659, 1.059676418161131, 0.4420069178808009, 0.8950027972748169, 0.36705776527983075, -0.3300671380219861, 0.8515911123199603, 1.2540381030859824, -0.08955261301264672, -1.1785534410779082, 0.9043321393827797, -0.704263410311157, 0.8562094005095614, -0.42676476288847753, -0.039641367851528234, 0.8814179741234822, -0.8958525129128047, -0.7245266493750725, 0.5133921125952574, -0.04382876349926177, -0.508585699021603, 1.037674906394475, -1.2474834736438472, -0.2899774256203927, 0.15823037047302804, 0.6888648169803205, -0.10856520530932597, 0.10417706745548526, 0.05816102013862318, 0.7006788847881177, -1.1187347290367775, 0.6573589092376394, -1.1933476120332898, -0.4054239965880489, -1.4859128498559817, -0.957276049261358, -1.16593223301591, -0.8674907730018501, -0.6322108020931734, -0.23584758146887871, 0.5031314784144424, -0.4378360695738402, 0.35188530657082595, -0.08930583961277196, 0.2622199323154475, 0.08152469660054606, -0.6962239097019635},
    {-0.35340316496184393, -0.6787466030894372, -0.1677915248349897, -1.496951546150463, -0.3411366493630939, 0.9556869496963509, 0.15083928880390185, -0.8636170125540742, -1.0441859689933142, 1.482291504029656, 0.35338953833081327, 0.10049823614413145, 0.5597313532266247, 0.0932883412403422, -0.46835316551565, 0.6423168505168261, -0.6984304193706757, 1.1091828916122235, 0.9187235678495025, 0.4152488157085264, 1.3901527598601793, -0.06412237160071643, -0.7191824022469732, 1.0124718219811966, 1.4681631753131035, -0.2679756737837465, -0.7218496392807178, 0.7160174436659333, -0.3956388422053917, -0.15809866563097968, -1.3822286887980626, -0.7226930815865599, 0.5890813183961147, 0.24105934927899877, 0.2990613957544329, -0.34843311831639745, -1.1837110153149384, -0.9366358322369506, 1.1654156903434618, -1.5462756187809685, 0.21105342862229615, 0.060704071106050854, 0.3916354665659434, -0.4514259393531953, 1.573042694587546, 0.2559455014530734, 0.6106784090035057, -0.6979955168755918, 0.47849818366797287, 0.20484283216464624, 0.7864207936427876, -0.34805200015036475, -0.2524176053166195, -0.6512603092882987, -0.25265485242071967, 1.1975332935889258, 0.36430357845516365, 0.8694856440017588, -0.41082857367379355, 0.17157912699027256, 0.6081286281157395, -0.7083639545463724, -0.9503514986757007, 0.7795302168833572},
    {0.6113034644744194, -1.6439329685425177, -1.2282016023418727, 0.03483290873422133, 0.03920214045110597, -0.5920656830265721, -0.007302633465730672, -0.9473213480874162, 0.2211673978358098, 0.07464071408785335, 0.020506601943425858, 0.07988606744212512, -0.10001487294950949, -0.043795302733738224, -0.4636083154216634, 0.5033640069205426, -0.4463954404185539, 0.6995199578758647, -0.43579975637054086, 1.1843551647486552, 0.12945893581325466, 0.8848997519653707, -1.0626592417265595, -0.875845121415767, 1.4599863488589013, 1.179851708583094, 0.013578196927297963, 0.2891293245591877, 1.2275941991031838, 1.2004596260810012, -1.1201428019161188, -1.432333545661561, 0.9408400592084049, -1.2703497376753832, -0.7124112617267198, 0.18277396371376517, -1.5950643618654607, -0.41800670401589135, 1.1840087594506106, -1.0645841547861379, 0.48966244461017294, -1.2321121556773222, -0.285768047791435, 1.0066672108458259, -0.069672880492679, -0.36419368908898914, -0.4228941521282396, -0.452068554071437, -0.859519732370309, -1.4699817698799966, -1.0988214289454574, -0.8420734404505389, -0.6644615274043725, -0.6806192954763315, -0.13258648273740853, 0.28423523097329767, 0.22829427898266874, 0.6982331587404522, -1.0378007789236416, -0.5599011894021347, 0.11563001634972221, -0.35469528017630125, 0.5847529247239736, -0.11057169429421622},
    {0.4956680603710331, -0.4175784750615173, -0.5619896225161747, -1.260278333100866, -0.016477669906948055, 0.5537039231868183, -0.19536911881367308, -0.7636631767812107, -0.41666492690028994, 0.2921569505886261, 1.1338283927687447, 0.03768438202025673, -0.7504026469190651, -0.7714533962515455, 1.2067817826198852, -1.0290763055694607, 0.22200903918573575, 0.01203935701865427, -0.6137523371058701, 1.088845479678914, 0.6103920765714935, -0.5285236476481523, -0.08731451365910013, -0.571091245395146, -0.23345333681340152, 1.5287114549533483, 0.6913580911710691, 0.5021056556093193, 0.13499208416537983, 1.011726672355489, -1.3174640858374402, -0.6297326592092015, -0.2066008155804688, -1.232044380154075, -0.8975717945137991, -0.6317447700340125, -0.135339968730245, 0.3578041516089654, 0.1739885908606143, 0.11542850709012335, 0.7275583786097527, -1.1964719497102765, 1.472120960238939, 1.0785694909892427, -0.26739263040810385, -0.64171055715719, -0.7042031665682232, -0.8622386564977396, -0.758246387057765, -0.4775801556210986, -0.17768007686155135, -0.8424460903617716, 0.2242161124604701, -1.10846063718187, -0.06198803934370524, -0.26822143743462734, -0.21799893309667895, 1.4332131320120374, 0.23947792374781832, -0.5654650502345779, 0.4049980838795807, -1.1089742950436836, 0.1384081114720389, 1.2754968795062351},
    {1.006863528219398, -0.3059685963776762, 0.05111332409947673, 0.23223537966436497, 0.6714629628164489, 0.5621465251885462, 1.2800556080177257, -0.9165672546903506, 0.6510158185160841, 1.357488664977613, 1.0762167792330553, -0.17241392479770215, -0.23068646993924002, -0.4225734924958184, 0.5314952810446972, -0.821216249588438, -0.3176330468698808, 0.16817838642925395, 0.5693359291770272, 0.9427022264178462, 0.3829661111573416, 0.7895995089530159, -0.6563506352660217, -0.03648151199691866, 0.36481192366762505, 0.061720711612124154, -0.7528301251004167, -0.08903390309852353, 0.9935107652562537, 1.036101436305098, 0.24854924120741556, -1.1846181622947711, 1.0083499102906055, 0.19383151396347895, -0.8145860461637291, -1.356049928238869, -1.4276419612537703, 0.14819206347743297, -0.6391345508587888, -0.6302520424561769, 1.2124316263141688, 0.381840141176475, 1.1548231697763538, 1.033758607718437, 0.4433714087781523, 0.09339801976454352, 0.5367634671946673, -0.6676046440203931, 0.8575430890786312, -1.5406327591725362, -0.29025381719712035, 0.026954015320854476, -0.783271623780869, 0.028624452633081436, 1.0795053606780016, 0.5420283876488159, -0.6427873578638781, 0.07547404411669706, -0.05251569445373721, 0.4416363565961188, -0.6626355569714835, -0.15665658337888355, -1.0345267099344237, 0.4015496449526568},
    {1.1220285350086432, 0.22087125839949676, -0.6788125564475895, -0.9016686088739659, -0.8862991830444917, -0.2640599980298459, 0.9826725887886139, 0.631050470719452, 1.0620156048008755, 0.7385481333848557, 0.8019384181643546, -0.06115507337981089, 0.45066097168121677, -0.2397473738681852, 0.7658559958648552, -0.9895917513230064, -0.7418752768947325, 0.6877665227709323, -0.18551407767276817, 0.7231460248572862, -0.045382809497542635, -0.3091659922556435, -0.09927111827945657, -1.1260643695447825, 1.4285674438593678, 0.08373173352466637, -0.622527469802157, -0.9269127367974713, 0.7776756266749748, -0.2984807877790131, 0.7094511372331181, -1.2166647573108662, 0.9885013953756798, -0.3583705763448242, -0.4052087948274676, -1.1095779820123581, -1.5447781750790432, 0.37025886564068045, 0.7330615095204094, -0.9324340624203762, -0.03757590310011083, -0.44637846838041323, 0.8701926301507847, -0.3805642078834328, 0.33186997005428287, 1.2452526086475335, -0.9896331996531228, -1.5206260065306028, -0.5125945923405002, -1.2332147083486147, -0.8802006586873198, -0.7341134390921958, -1.5612259170039462, -0.6515631108858567, -0.8325755673692358, 0.6937023656274744, -0.14726812920413213, 0.1867766060975683, 0.6650261970975481, -0.7871325262953696, -0.8375814486891369, 0.4864922303749518, -1.012089585559144, 0.07420351595471501},
    {0.8931794500473158, -0.04271551614821941, -0.6151972757876829, -0.16026158099117438, 0.27104377354458753, -0.5972271954236734, 0.9950359891853061, -0.25348990697498647, 1.092523561257627, 1.52333689060937, -0.07133840316588695, -0.2201477886234174, -0.9957655105170716, -0.2606942327628848, 0.759470798741901, 0.6025193870056631, 0.2380154723897121, -0.2889056122694528, 0.0507670964993407, 1.37266129712251, 1.3183254380958662, 0.5901440874875052, 0.3097663421738484, 0.6275846159876122, 0.9027495703321126, 1.0069923576974924, 0.4707461895407074, -0.45793884522646394, 0.6458241059192714, 0.24039149002065044, -1.4446962267679522, -0.5022571947937918, 0.3902629552955572, -0.5768717833033512, 0.02192405864834273, -0.6184486491399632, -1.6009248165252705, 0.17847994504001094, -0.6451229215193514, 0.15146633505669124, 0.5435953632433798, 0.5820763446686633, 1.3247378254003555, 0.48516120310045235, 0.6256173014320812, 0.4561560705198419, -1.1192523130335539, -1.5092678844192737, -0.9209441179179656, 0.07145677095351573, -0.6919694810864306, -0.6529776040195929, -1.5719680398967313, 0.16082093205036826, 0.845346107045757, -0.10390719267847337, -0.01346397607188657, 0.26821360262449245, -1.1261664444168455, 0.04042348325136806, 0.2379250773417245, -1.4687893967392815, -1.0862548238164338, 0.3194717947361801},
    {-0.07223414707593634, -0.1349150229838188, -1.4704228643815713, 0.7198517239485477, 0.9822020119157288, 0.3775845452175704, 0.010094578690628913, -0.3926480856453281, -0.6885961548724572, 0.342441292192633, -0.444886943064005, -0.42412740325559045, -0.17586274797046655, -0.8005155774190931, -0.5715230840007249, -1.0457092473295706, -0.46900494671480725, -1.1599831928362256, 1.2724580930872416, -1.2912472834545372, 0.11828840329425383, 0.4618015616008894, 0.7947083455036309, 0.8009323040929075, 0.7532704189519386, -0.5763454298149255, 0.6783873946568083, 1.2382589574400682, -0.573813795468748, 0.2610226538063265, -0.7416439861756856, 0.10065454848183056, -0.8406186054186593, 0.5894212954976442, 0.3942799874920459, -1.0999189740743247, -0.9979990493839341, -1.0523847737416931, 0.4408302237296244, -0.06237572366166845, 0.12891482571230814, -0.5318484537851778, -0.4885946591683265, 0.4365691821866294, -1.2232273036130155, 0.9264861105005541, -0.875485037007419, 0.6580441804188404, 0.33037489185063496, -0.723161383149463, -1.0074821772274138, 0.8255461138449299, -0.7701646810955827, -0.26234939881297714, 0.7779022249777207, -0.8609285511265186, -0.8293888102320567, -0.9217731402842242, -0.8438341026134485, 0.05069789261965359, 0.9213785745494633, -0.48535090528115, -0.21894561827561296, 0.39147100499963583},
    {0.0594770122254943, 1.293406880494968, 0.19807618424941054, 0.0221855704604219, -0.13643330902662998, 1.1188201733529646, 1.2125552148551952, 0.4353773120494738, 0.8949177224333235, -0.10785142419696589, -0.1289841480303036, 0.7654333527873364, 1.2488305977700436, 0.0525410259594113, -0.6199009116690705, 0.05340710189428479, -0.14854788144592546, 0.15898654389172134, -1.1396817802168366, 0.9310274819159691, 0.6508517449560342, -0.4159728991001559, -0.8803378832151281, 0.737546301054531, -0.9084327962136072, 0.6916269020729235, -0.47536954697555023, 1.2582863238899895, -0.3802815079043651, 1.3402522320639958, -0.2507436476257824, 0.22858951005567157, 0.1819998478800434, -0.4591361937872834, 0.39692495353505985, 0.4703409924409729, -0.4962162047272269, -0.5385423033951634, -0.059521656719131046, 0.2649248349794057, -0.8707239430240477, 0.2608633903724006, -0.7942909669134764, 0.6129301147598788, -0.1662881963746758, -0.15524641405538225, 0.686693968429107, 0.7399131074170966, 0.6853032177348907, 0.1928344494983504, 0.09161954086113089, 0.5805565670952568, -0.5237298982254607, -0.3399895337191376, -0.010751733502793383, 0.3441007337288209, 0.1395765714458858, -0.6695638624899929, -0.015917321303948278, -0.5474709904890426, 1.0728371914481643, 0.7611852129519865, -0.5602367612971014, 1.202802330524797},
    {0.39891802187066144, 0.3008762949627375, 0.03505195751342737, -0.8157008450947313, -0.29039324600754457, 0.461785605201639, 0.8633378451022918, 0.9165229032656156, 1.0291916576246745, -0.6522296050619898, -1.4764840110264796, 0.16598360713615415, 0.6741607792708945, 0.45691124120581317, -0.9784177674217468, 0.20899660075723003, -1.2748842159184648, -0.6918922824998534, 0.5154436740634855, -0.41162255587608665, -0.47574951562399703, 0.050784345528658924, -0.22714355901459204, 0.654043674673186, -0.7516904574442386, -0.7527793416092063, -1.2591712020679233, 0.354627991408058, 0.2167289435698272, 0.5480988937582145, -0.10818816500486318, -1.221765350313953, -0.8237080214291105, -0.8356450829929751, 0.49342048118421417, 1.0129402754299741, -0.20423414913487625, -0.37953498062316204, 0.10997047480623302, 0.7137962559098917, 0.12632008916094184, -0.6197872057334384, -0.7521044949693517, -0.9852749495093808, -0.8541936509040006, -1.5302154644956354, -0.8851842949191436, 0.8130306010339001, 0.506658253769971, -0.9034900596278113, -0.32447009947728467, -0.6438662388629361, 0.7982682247844519, -0.02520873453863113, 0.3162048815669076, 0.07206926352281015, 0.1642665513863104, -1.1424584582848756, 0.3682262790843755, 0.7479129036278691, 0.7931595556562637, 0.44336525439963276, -0.3400953089973904, 0.05485462442843043},
    {0.7979433773850991, 0.9638564050931295, -0.6663607478529625, -0.3119378869508611, 0.24634116031856984, -0.9405490624658621, 1.0166270934934465, -0.5198589761009647, 0.619605593339522, -0.37782499260798247, -0.41830631129857526, -0.6856130037528325, 0.09780722899601997, -1.2440067478374228, -0.5008941862228706, -0.18803269299831527, -1.0307818093933327, -0.7017213394233381, 0.3922484816169357, -0.6307235558414729, -0.7792722123098106, -0.35766515607972915, -0.45501719904492016, 0.33156269089008944, 0.055918582596354155, -0.41300638357053837, -0.8860908066784493, 0.6837933800930676, -0.6899279384969079, 0.07314614721584667, -0.5356891770981254, -1.1608605244729362, 0.01573070042274844, 0.6465469220301636, -0.6387467974107929, -0.3899649795113515, 0.6605250106924541, -0.5645147446400027, 0.26819479781824723, -1.1198444717910576, -0.15535404625703736, 0.22445435797821392, 0.46730253878208194, -1.1689834011509974, 0.17885233449835913, -1.2342817161721118, 0.751681032786862, 0.7303284900586888, -1.089899374798954, -1.1003035348181227, 0.7388376071928932, 0.5574641900516966, -0.4393769235529821, 0.2951355291460154, 0.7143185690635625, 0.6671395041844157, 0.31616083900986497, 0.0754264232105479, -0.7357841121518531, 0.022932062964793866, 0.34042913406403996, -0.35149293403424314, -1.210311149406124, -0.420340575801189},
    {0.9849151092948828, 0.8769551416048598, 0.39323102889476164, 0.334249537695527, 0.47482733942867533, -0.8085225686204413, -0.16062956039558027, 0.4283622704681799, 0.3920146927947606, 0.6276485273744323, -0.5531318721948199, 0.8751004368576536, -0.5275405656812078, 0.32543787400558305, 0.08043438718827588, 0.5716729173149099, -0.6022242958261492, 0.09544547246247882, -0.9359918442410604, 0.16651165619519534, -1.0256829475293108, -0.2697022247366551, -1.5076923084545366, -0.7839902436476418, 0.06015593981648767, -1.1344900862628724, -0.8635650055389916, -1.2414231348099904, -1.0305427917292516, 0.811000240817055, 0.12280002809437497, 0.28321864482466247, 0.0870042943955087, -0.8367535532837723, 0.14335765657782534, -0.2429923573542652, 0.3945884041614687, 0.15585056624932733, 0.2243448991844366, -0.6450166973009348, -0.03739416441891216, -0.857180482027195, -0.5319677974670641, -1.386404626474171, -0.44872117473798345, 0.06700957741310726, 0.5767496666524132, -0.3071749922120662, -0.501695060337356, 0.5440069176078625, 0.36266494381774883, -1.0253157278948144, -0.828220812997353, 0.7147610840552889, -1.030330326963863, -0.2388941305935782, -0.4200214012240834, -0.864087927291792, 0.683727376002382, -0.7976811894573803, -0.6270199745807004, 0.4934973090028388, -0.8500193023332203, -0.6445737322313705},
    {0.991253602199262, -0.058275148744217735, -0.9156873087549914, -0.4735990822115799, 0.6304082452454605, -1.2622876267594962, -0.6883277634696665, -0.2438994735492576, 1.165748796553766, 0.9188830098721721, -0.48668662782812017, 0.17102849725595534, -0.5956074376703813, -0.37334740820309076, 0.20990320728695128, 0.7727652058056725, -1.105369601483287, -0.2523309820892269, 0.012403989864920077, -0.67574839121747, -1.217751599406875, 0.21189280783448386, 0.12436398917878522, -0.846197297529387, -0.6071665115312189, -0.09749323047921356, -1.2237152561099012, 0.3084661912928867, 0.15060543405715207, 0.9008756116739154, -0.1874077221272621, 0.4608096758584898, -0.24707462287863236, -0.6925476273160031, -0.28194878551050584, -0.3522416656675492, 0.675914934948774, 0.8974420601904095, -0.6874066346422683, 0.27671371612748596, 0.34468692704451426, 0.7251661511077517, 0.6685388619780046, 0.28106853256698494, -0.9395289711926741, -0.4198466721097818, -0.8934382124340114, 0.029894646106376113, -0.6310352869498118, -1.1407314323696551, -0.9040112242931986, -0.23765106417172308, -1.0957352723989042, -0.9559431784115437, -0.098968178843358, -1.1119825259928104, -0.19756820414992454, -1.191169295729566, 0.3112662810540903, 0.4781140824670924, -0.6647062894448196, -0.8079140099815973, 0.3772000407250254, -1.0474966950587001},
    {0.9851443717886482, -0.1404524914278118, -0.8681298172682956, -0.7841178946550033, 0.8556591957507031, 0.25316080342230396, 0.9649011484127582, -0.8988358911112314, 1.2300940228740866, 0.7334818138969429, -1.2921500996890458, 0.6519794162866424, 0.8145183217180241, -0.23561819244837537, 0.34515412618047364, -0.17235875834962525, -1.0067547809665194, -1.089814722378741, -1.1996354448369522, 0.29482899809027807, -1.4498977002401106, 1.1552915397255368, -0.9477945225143753, -0.1780269000041494, -0.05452872159460427, 0.14047052407224442, 0.023731452756120125, -0.3623335939613448, -0.3425972736853406, -0.6535838933948773, -0.701096013625567, -1.000313536471785, 0.4982565420339869, -0.08084038197797186, 0.2956554503040444, -0.7125714765438786, 0.8655700790180652, 0.4089485009800097, -0.5624733101670899, 0.13087525996573346, 0.36948151234743776, 0.9672674488247238, -0.8817969192176587, -0.7437786301073448, -0.00433212182844471, -1.1910984762015435, -0.45573396801393906, -0.5836316615612088, -0.4425041642573576, 0.3998730587327234, -0.8898540055964904, 0.11275766866187974, -0.41059708000169726, 0.8739543357265166, -1.1997451863355788, -0.27964574640590645, -0.09861739753524526, -0.6971961943482291, -0.1415196674840675, 0.52124555357732, -0.23531008955606403, 0.6065235740514108, -0.21554037327521458, 0.10325030715059444},
    {-0.4893298143651014, 0.6387681364415992, -0.25200209317711636, 0.2239378620931375, 0.37176249199798184, 0.8504110763763386, 0.9497616571106076, 1.0648549901615723, 0.614209578419115, -0.5171931124878903, -0.9461231039716468, -1.1147387895382184, 0.3544642153106451, -0.8716989203343783, 0.6485297703869884, -0.7215762667024935, -1.4646868765271652, 0.10949377329190996, -0.549286833880144, 0.7895223278000894, -0.554972729984961, 0.5080347980605989, -0.7380150301241514, 1.0943253786457716, 0.2955623569827471, 0.4903494296988134, -0.5628022133425211, -0.2721699251703855, 0.3635321428557704, -0.424982710615079, -0.7904162950746738, 0.7389477600901507, -1.275020618987153, 0.46987622862042544, 0.7711394027847295, -0.8546949697840439, -1.0109503237390867, 0.6315210059906656, 0.23048202914773996, 0.15815423515688176, 0.16824204381258462, -0.5519501136597101, -0.9492933912650685, 0.623720931259505, -1.1789439812693443, -0.2865139229141287, 0.34599122978242697, -0.6213960769858771, -0.6536755401315854, -0.12736231759798927, 0.6470334718893921, -1.1166337856831876, 0.02265222240836021, 0.648338301759213, -1.3483463383000216, -0.531822024071101, -0.8850291220904921, 0.5514362751135164, -0.11847448890276203, 0.1339748624396389, 0.5554717752980299, -0.9389713143558337, -0.09123847565604576, -0.642009234886353},
    {-0.07379710562576947, 0.6097907380466775, -0.2609151328871761, -1.0089866717685576, -1.0630459011227458, 0.6699427398616683, 0.175495055244366, 0.1649076889893213, -0.9987909482272197, 0.7978303051684341, -0.6713567855878818, 0.39321427550915866, 1.1356142593964662, -1.3406096047459037, -1.2636420041094336, -1.1152580235794993, -1.5759142551546381, -0.44599298924251934, 0.34461789867353654, 1.1943709567107665, 0.4021001492799689, -0.7287567559594054, -0.08868736769359505, 0.9854171132691928, 0.29361435412904513, -0.8556772832406889, -0.4619589428540086, -1.149712120161574, 0.7307161324058109, -0.6142236259499324, 0.36888780204019167, 0.03111374493542555, -0.495713725350596, 0.10920465899604531, 0.0941222561316629, -0.7411040654994123, 0.583777145537243, -0.6771244025638472, 0.5696451978841485, 0.25627509095400725, -0.5575272272043127, 0.2061082557197802, 0.700199286272902, -1.204309321221885, -0.3529103911683951, -0.19618153783611295, -0.8483932749527615, -0.8507382686326116, -0.804083838696215, -0.006774951549159091, 0.6137237193499959, -0.6269716938701198, -0.37500735033452226, -0.6397482196509026, -0.9951810438353869, -1.0061637004908845, -0.6857058571956227, -0.4745231724056712, -0.19950100236939064, -1.143707496263503, -0.571200551674884, 0.167067239050384, 0.8874866932165015, -1.3679365577263096},
    {-0.638425955574578, 0.41810371652162936, 0.5350843296911437, -0.5432972437776618, -0.09565467256238464, -0.46261365080920924, 0.18773109473591557, -0.3733696352527497, 0.015872437686550014, 0.621395945179577, -0.21826129979724923, 0.13800007416317686, 1.1157219937455274, -1.1372365099385333, -0.9430544765441256, 0.10334794519975596, -1.4286960011830196, 0.3218741880906534, -0.7075881262918571, -0.5645318273507378, 0.09296445883766719, -1.0380667222127955, -1.090811870070773, 1.1373598302300343, -1.0225066351733492, -1.2597291896247083, 0.20149914669398897, -0.31224559107174116, 0.15585488014697324, -0.2747277687562217, 0.27209155915275773, 0.45234665581084643, 0.06783031261610441, -0.21636580814142972, -0.33083595466674187, -1.0702109020654222, -0.5764149982267351, -0.09932549548083158, -0.7452895355327696, 0.5675735473543648, -1.2668167506937273, 0.05802060356022431, -0.8352439249508816, 0.08267673561712102, -0.7820879636836234, -0.45933361780577603, 0.3478862211326093, -0.1232853211664778, -1.0466776567061353, -0.4192942301125701, 0.16528223462117045, 0.5602409429457065, 0.35697439471280584, -0.1819714432409285, -0.33586592240927715, -1.3466589974105174, -0.733230990523756, -0.160742861116926, -0.40287802684548113, -0.5847117065230585, -0.8578444976814252, 0.46394179092868343, -0.1850058412582863, 0.43416107531916953},
    {0.5417636216353627, -0.8276021206783307, -1.1698683240374188, -0.6726229023986563, 0.11831604624464662, 0.21085408289688087, 0.7755182664678274, -0.14786619059395092, 0.5144748976480444, 0.21168398026346877, -1.2942244035667099, 0.616833788746425, -0.6684157905368465, -0.22477725691508604, -0.8614476419306111, -0.317654189284227, -0.21184816823074948, -0.6131294275191146, -0.05138519193237424, -0.786499370737143, 0.10168972328239725, -0.9510621607917262, 0.24385208837696223, -1.1511270199540642, -0.9413455305751728, 0.8794310512869268, 0.6173810189673411, 0.6885558534275105, -0.4849952959320019, -0.0908331171414996, 0.4243782733699478, 0.7133282614177635, 0.5910675739933948, -0.26765317988765935, -0.35334124010292944, -0.9649092004062269, 0.7988430818795176, -0.6248739282459771, 0.8169130326233105, -0.4237399124037139, 0.2815192763249576, 0.6073526459953478, -1.0878902641093386, -0.6690791125257802, 0.3412839602828084, 0.1685531762418422, -1.1314545228783823, -0.4878611426697776, -0.7174851753763622, 0.09721617194492542, -0.7545025783590131, -0.7846734710042085, -0.9142986906837435, 0.6472831043386694, -0.424179636222769, 0.804878067828279, -1.04031237091348, -0.9826632329777034, -0.2285422426516187, 0.7007967480453358, 0.0012827825890254923, 0.15443663498961618, 0.6803254151843603, -1.2665416707773485},
    {0.10244078483324152, 0.6211621404496674, -1.330401181042651, -0.3653301024810846, -0.4312041061033772, -1.3365253952702605, -0.3046791198398844, 0.3215294764756339, -0.21955204018064559, -0.9361108132986661, -0.10137534370444097, 0.7499076760314718, 1.056703454417884, 0.6328708933886947, -0.548045946378879, -1.2139969239604786, -0.76406612730081, -1.4277572368644125, -1.2020201708384306, 0.9675802515943381, 0.18183370812777627, -1.0776004381849784, -0.16371860020886142, -0.20572668116527504, 0.48263329886843453, 0.5170054268339103, -0.12997296820058257, -0.5010037733986163, 0.5673024662289425, -0.40898958560529775, -0.5481029256615982, 0.09816910276453303, -0.9404860018020681, -0.5986946085181629, 0.36706160189645204, -0.8216646372909312, -0.892872695693982, -0.03684195432095804, -1.1758952458257117, -0.47460655069965424, 0.7628966601918673, 0.24794689058529137, -0.8299399566326693, -0.10394358644806348, 0.7280641813874024, -0.05247520620221489, -0.6927588920650531, -0.0553578192117593, -1.086358547000925, 0.4760016780535937, 0.645706168434208, 0.4429444545877522, 0.7678921105691505, -0.02039063688139575, 0.49190939920039883, -1.358872524110419, -0.9037432245101047, -0.4128189662896314, -1.1495587384254968, -0.05383984647171383, 0.8166602035440421, 0.6226991316694162, -0.213795399528655, -1.210853890598116},
    {0.9260576557838678, -1.068540095176813, -0.9798308132482504, 0.0894841115403222, -0.485166112234776, 0.7048523677941245, -0.34891371266955706, 0.5534770661554105, 1.1921763711520257, -0.7489497464892383, -0.06581238773288936, -1.0840710830200346, 0.09161234999751573, -0.3790262853493209, 0.6204287774748417, -1.3822481554473658, -0.7368357536538734, -1.3867189052846978, -1.1079764900143116, 1.0515284895653687, 0.3468748543854791, -0.10236835707182525, -0.7137022282427636, -0.7068752244731387, -0.15791547937010747, 0.8369449396402164, -0.18399686314508226, -0.23730106159697023, 0.41036593648792374, -0.6263949855679164, -1.1855679978654117, -1.1242387297769538, 0.6300453092853181, -0.7614454564150243, 1.2478605944619192, -0.5973052007054973, -0.011731045819525077, -0.720709795133021, -0.23592383648708104, 0.2639119473412576, 0.8405543829097655, 0.21667407194660254, 0.11661155503418753, 0.267320262666331, 0.4117378458446462, 0.6005043974596764, -1.0794888381879946, -0.1820144513717094, 0.2999398698071861, -0.029168133188465433, 0.2223003447475908, -0.4613093369740663, -1.1390251666424998, -0.585531549062089, -1.0860458633126098, 0.4149373855405835, -0.2977751356171375, -1.0855426899304792, -1.0056224028296676, -0.3811151979790301, -0.9081195455829881, -0.09663235897771533, -0.5168365619246899, -0.1465173140466359},
    {-0.7435603173498245, 0.2526277116017609, 0.31668858724698257, 0.017526739892772446, -1.0093301974474187, -0.8830838881650344, -1.0006763583245677, 0.6690977370624932, 0.7678602051026436, -0.5811682808299046, -0.24392964782100046, -1.1464920753885315, 0.9184638940392997, -0.8955282508256918, 0.7416751922782088, -0.7187107318575301, -0.22665676995486983, 0.33514325900440833, 0.5250365431841005, 0.1831321832487895, 0.13830792468580416, -0.8473829152339439, -1.3284164699294538, -0.26158427085728997, -0.3219082719948483, -0.8932904244783, 0.0714595063301691, 0.07029307957349935, 0.6694870249087479, 0.5488748896580073, -0.8902850731769506, -0.4440340487906135, -0.9109124026909402, -0.7982261530836123, 0.9852937602427939, -0.8666660405591464, -0.3211222469020752, 0.5547729357614413, -0.0605334135543417, 0.7959991326914246, 0.818978158676298, 0.43042129544690444, 0.8364285890715696, 0.1644227575316322, -1.2698431186601487, -0.911253198950045, -0.731848836416975, 0.5795316710483048, 0.38106964818465583, -0.674503642437994, -0.2891236555381066, -0.4856368928932412, 0.38570426783634393, -0.8385327602744969, 0.7018175505316129, -1.1782347964004918, -0.17329673487170782, 0.5234234420195316, -0.3029171947973056, 0.027331950904732293, -0.46950866868592284, 0.0716256606869428, 0.6000774296659034, -0.9342463605565539},
    {0.7823747577865819, -0.4974060930441767, -0.2179957397061664, 0.0026870941670578976, -0.5782530467892472, 0.7949484899954777, -0.129418797907568, 0.8739822505149453, 0.34544180964787247, 0.6298267120909605, -0.8635353602514256, 0.9628211094411785, 0.7529498362224302, 0.018119898806157452, 0.00831840605862886, -0.6595628542309164, -0.05608556140860177, 0.1844218760219374, 0.5201260084142947, -0.2218061039084816, 0.7612781039791979, 0.023586031867642823, -0.8316901447919506, -0.911082722984051, -0.6035067249968432, -1.303424424179907, -1.4140642563864707, -0.27517513193656684, -0.47631464648923355, -0.9899638850922601, 0.5457644082430992, -1.264067244713261, -0.6134514610588694, -0.276471663370275, 0.5359945171506282, -0.2611112929946752, 0.25732713027403015, -0.9014424466668041, -0.8754272703556482, 0.24148373656148323, -0.43952704608790116, 0.6579714839286428, -0.014454569033980508, -0.46882227734282594, 0.7812269388415368, -0.5917995438389584, -0.49416275181536184, 0.21475290187184506, -0.9556885537718633, -0.29696250214466874, 0.51861179063984, -0.8304126463529399, -0.3863254644634679, -1.1904369566339723, 0.03774409515250419, 0.6528356102387942, -0.36848052949183113, 0.5046264297510039, 0.21478205367683695, 0.05601366493730252, -0.6418753935145485, 0.5118130069241079, 0.41798092526909103, 0.22971994248929117},
    {0.777964416167896, -0.18191324486310465, 0.6926817728047224, 0.039930323246052356, -0.49966796437996375, -0.5793142092816936, 0.5272624305900696, 0.39269082017352386, 0.9604014690561672, -0.153870431226434, 0.15874440584558455, 0.38054491537429325, -0.6020069188794023, -0.7054747644086423, 0.9774734447432942, -0.678820527653933, -0.835718560250906, -0.18092593181689043, 0.7284738454477708, -0.7808693312378197, -0.14928310871077774, -0.8351153840053173, -0.3993266643788659, -0.8922962543512742, -1.2096421526278884, -0.9373470563481754, -1.0159345187350532, 0.27932921213798306, -0.032053871166503385, -0.6970401946701584, 0.10227576650527126, -1.060021088736967, -0.7152274828350459, 0.20288033742325495, 0.775184890634994, -0.09718336614996945, -1.29375492061311, 0.2667159745650618, -1.107209476421702, 0.9588754881668289, -0.14422593592202432, -0.6619988814421189, 0.17579097500057161, -0.5506975122567596, -1.1608520771823037, -0.6294550211526897, -0.36317082101337195, -0.0051087828750438794, 0.7961356994963646, -1.1631370033130244, -0.08199103083036136, -0.9050427020999603, 0.3752268214960499, -0.9970698571476252, -0.2427572228178687, 0.09967447761962292, -0.8184689928701282, -1.4175798276800704, 0.9262618228968074, -0.4105327678169729, -0.19893993771789661, -0.9622463297004772, -0.21645763328294973, -1.1958323020298443},
    {-0.03801300797224357, -0.002273559001229115, 0.439670865838301, -1.1924371147836597, 0.049950567604575224, -0.37141361884905294, 0.7533734703959256, 0.7449981736365764, -0.27612945080552126, -0.0153733775665267, -0.36500222742189736, 0.9819019054621394, 0.6406858227547628, 0.13466344799765098, 0.4643761856136554, -0.2000780386183642, -0.5231459336163539, -1.1546257072981043, -0.06886910787669673, -0.1782894097300085, -0.49873580942974327, -0.40489751379992206, -1.5489502481546824, 0.4719690859393873, 0.5365454367196162, 0.25277983413284727, 0.2670256789737327, 0.06825052644972326, 0.5786252321707679, -0.6083524495078396, 0.41503860133948395, 0.5053785196754979, -0.7744017379891776, 0.014227249668553245, 0.8080938726104971, 0.11341426211693141, 0.3503324372904571, -0.6004498204023262, 0.45324383754996395, -0.2675454237295002, 0.8024791822661321, 0.20977050743995074, 0.8258014630478423, -0.6556131282780767, 0.5026262373585129, -0.1602741380845006, 0.7805039385349088, -0.9824358219416688, -0.061591656178055204, -0.5556940081266325, -0.544820792829387, -0.5819914790105565, -0.7331418153468081, 0.3495754758070304, 0.3109973706410049, 0.7294434795136695, -0.9499871362102902, -0.48284140990053803, 0.5252943526991645, -1.0366071726232702, -0.3765202526436169, -1.2239741784810172, -0.38392891679203994, -0.06278550271237689},
    {-1.166632220589394, 0.06471719450220814, 0.20949566920213233, -1.1942188308537063, -0.9161542323842113, 0.4931569061141414, 0.6813466787673488, -0.13667788268902295, 0.771542717581897, 0.8815159366353168, -1.0732213121124405, 0.689388458048039, 0.9577458354696912, -0.39372734669645915, -1.0298462340791097, -0.3983353788871635, -1.4656756507930377, 0.5787509012464636, 0.42997229154142425, 0.5544512350742663, -1.4302799192372362, 0.29046413439517155, 0.2941846693456865, 0.7153940943080738, -0.19582063563068072, 0.20091661903760807, -1.439274700055217, -0.9927689789036959, 0.21142712273592018, 0.6830085359827273, -0.1425997471963044, -1.3365993249915573, 0.7362807732272154, 1.0775305005700604, 0.4707482635300623, 0.9875912355599994, -0.06277432657110504, -0.7342576215534824, -1.3749643632784223, -0.3238017905441161, 0.7596975260595472, -0.20496106890842686, 0.872589610729113, 0.5586122161430497, -0.38486350663076707, -0.3045821381035892, -0.797638385367425, 0.07617099031340037, -0.364831720475333, 0.7361183855916871, 0.8801219069778141, -0.8397292224814572, 0.21572165043215516, -1.0445438469407131, -0.29842440228610967, -0.21411461640615853, -0.7910217397256883, -0.8338011641650008, -1.0359996694584903, -0.13965665073308214, 0.4738069824500275, -0.07448027592097275, -0.2653557250077801, -0.29796255614781786},
    {0.3063996567058335, -0.538479979477298, 0.05237599747008528, 0.49719111741711314, 0.19150672846586128, -1.0432659374132198, 1.1911744682309682, 0.6594037323089322, -0.142756461843311, 0.14755732796035792, -1.2909557629829862, -0.7591826128416475, 0.27132686652092586, -1.128216742998987, 0.1732684187211822, -0.1505448527239852, -0.6051492317156667, -1.030838391904966, -1.1149725968648074, -0.8283882449876575, 0.16305325054383155, 0.8356717664394199, -0.6961542415106883, -0.4353793110101687, -0.22882961770739121, 0.3157454212627918, -0.13749195038675005, 0.594671749459903, -1.1684353845014424, 0.8254616789117921, 0.2915687089263728, -1.550188334984484, -0.7076342013664376, 0.6455957434805933, 0.1387069423087885, -0.9637596370929973, 0.6764300515010855, 0.6199026154944102, -1.2024097970962608, -0.21079557269905408, 0.4122930118956611, 0.313917725845426, -0.7580218237438443, -1.1067580188304642, -0.6371060461207908, -0.4191180549096489, 0.10422787769441556, -0.41130155401205526, -0.4228330360341396, -0.9256323317292945, 1.0140858710800356, -0.1371357762145719, -0.9647109918830993, 0.09724563546784706, -0.05975483802292256, -0.4257123221209071, 0.6229496258958753, -0.29591496838355935, 0.2522335809574331, 0.2671708949972988, -0.6261522240447946, -0.4496219965136359, -1.6597622543066246, 0.5632957953954538},
    {-0.6458573676502568, 0.9492681173153514, 0.02968478359737715, -0.1587928296980144, 0.5802112156052875, -0.6176317822512227, 0.06160170532140083, -0.5211373005442653, 0.9083757448827504, -0.37759841713232994, -1.6876500264786338, 0.11144711254429226, 0.6022473012285687, -0.6202789772511977, -0.722841375119639, -0.01311064510364328, -1.56633933108483, -0.8266530544318367, -0.3617651037437547, -0.8433341033518781, -0.40572877277834635, 0.31795201466380896, -0.5055218282184183, 0.7874604119811207, -0.9251930446495275, -1.0629424453958505, -0.6493650468793747, 0.8233999274576193, -1.0188182348133767, -0.34227132303884933, -1.102992097508541, -1.4667557135771727, 0.22747634521159124, -0.25628082520254236, -0.7049062958526828, -0.39979187432830127, -1.031277940283085, -0.1212601030501824, 0.514782280778077, 0.6013047260429842, -0.7180834751128568, -0.05633262082644638, -0.06460311062330984, -0.70957262367756, -1.170244561659505, -0.7259065562433547, 0.830421050885834, -1.1782046833451634, -0.7938257636428396, -0.3321457177389271, -0.22963587955829848, -1.4043955645238593, -0.6613765662766155, -0.7251588992129809, -0.3250013002093407, -0.29892228712324276, 0.7196883303353617, -1.0778332865778415, 0.2852516376846322, 0.28366831747331295, 0.08949795723837467, -1.4661256456850065, 0.07785039358556917, -0.38869109158727055},
    {-0.01644269681600812, 0.8295522195644656, 0.41978278607468017, -0.4750040501435885, 1.1302464331793731, -1.3316955809007047, 0.5425220012867459, -0.9561960701346732, -0.004620925005335452, 0.27748928328302136, -1.4385775387128916, -0.17729500421989244, 0.7212175762770227, -1.1563653565075895, -0.615763437904162, -0.5257250138228187, -0.2314190404959057, 0.4385773616334817, -0.44325325532163173, -0.013742140487909525, 0.841915939033707, 0.943328894830103, -0.9092250795642435, -0.7538018536042735, 0.06733507809620853, 0.25156715388740486, 0.21362330207646885, 0.7922281127105588, -0.11060999297937323, 0.2930932879364364, -0.37661235474463917, -1.1782457337327803, 0.6166456976799463, -0.5822765818629817, 0.029238096511094016, -0.6786879712947996, -0.17310392806327016, -0.5955448025927705, -1.4126304779697951, -0.9725832944913734, 0.273547752952058, 0.735817490549009, 0.25862538567813975, -0.17327397021537166, -0.16005321242074538, -1.3703179046151417, 0.35008858619711286, -1.0051843317117346, 1.0759692123253435, -0.5086139748706772, -0.23024845730909096, -0.1366506133095656, -0.43037654752061494, 0.41745783284331206, 0.6932637155954904, -0.7814340581932975, -0.47913532441851325, -0.8634546139977801, 0.502381904856444, 0.24621604671523104, -0.5357924034325243, -0.5255214146750576, -0.4967820572869905, -1.1424553269129578},
    {0.009885577497984703, -0.9817971291082479, -1.17102980812633, -1.2411085745085277, -0.8923237543527545, -0.7459654435083437, -0.49595957074031605, -0.870648694903774, -0.729503408266519, -0.19702920264995386, -0.1753039670927957, 0.5373262118320858, 1.1884764148916194, -0.46505707751283687, -0.25959845704147416, -0.731046028594109, -1.1023895661887315, -1.1735107120441783, -0.4072985771546659, 0.4771855904892229, -0.7553426232851219, -0.7828169245785744, 0.16353316421568917, -0.7438892652292077, -0.04355704721764368, -1.1029822063342032, -0.5244818760969487, 0.7310318338191101, -0.032894941715329355, -0.12143112674638115, -0.016279908469499563, -0.5393236729261719, -0.27178946410495486, 0.6500137327998944, 1.0607973002554054, -0.6640252819813814, -0.33454090369523737, -1.2996055967375384, 0.34835689809076303, 0.201869589691947, -0.7759650504913518, -0.7369234040377807, 1.0468196947519488, -0.45582791661274435, 0.5242648442233651, -1.2872851747417053, 0.1866344779730531, -0.6353811338198312, 1.1802282554162447, -0.0639281976422226, -0.32454353317112045, -0.91453962200089, -0.8194136534241954, -0.042266613626287745, -0.2751472644827453, 0.7011203293460716, 0.3694990095389456, -0.5108891049481359, -0.7282654947696349, -1.1757271654551662, -0.3416327350468192, -0.3527221329544012, -1.200913929305823, 0.28426003494489155},
    {-1.1819033624857487, -0.3656097381969327, -1.1656226854001648, 0.007646583410023309, 0.12198458256750716, -0.7904709198612963, -0.39399200659296985, 0.9832836071790332, -0.45875551022650357, -0.7657397724689791, -0.521694919995259, 0.9275803652276416, 0.32340658903400077, -0.2570822524489151, 0.7409472353211229, -0.5105839818315543, -0.4996105690262544, -1.467649450598805, 0.6030033738388428, 0.5712084005594966, 0.29546473843605714, -0.6215748904971483, -0.9608510877544485, -0.15778175438765482, 0.041590218975148543, -1.4162203871839385, 0.43044267180737816, -0.4133105645241929, 0.10977682427556797, -0.6740901568387919, -0.6058807022701986, -0.22029102556603622, 0.7669953264316977, -0.7962030591514597, 0.10851746671186076, 1.0390059565375256, -1.266679167092987, 0.26203705809557626, -1.194862279525084, -0.8427307102653183, 0.08510178639678533, 0.5201346616042168, 1.2000990681442412, -1.2102127570845043, -0.05368134050928739, -0.9762397395866356, -0.02273711724317845, -0.30807412643253307, 0.6094433848558092, -1.4305772128086414, 0.9887781670608992, -1.6085402721985114, 0.4413399146052081, 0.7639009582037876, -0.5535900117630471, -0.6162043885929324, -1.1283832607883058, -1.479862187702418, 0.5721389049775026, -0.2937163295527854, -0.48256365249189986, 0.04866522932258119, -1.5742658128062827, -0.7598160096805812},
    {-1.3822070713792047, 0.28173288182430667, 0.4721920415983619, -1.5440666886532437, 0.7675922229526754, -0.7971161435322588, 1.0861272522199956, 1.0192470031807128, -0.4430140787969257, -0.8771660218771411, -0.8317833203816382, 0.14237246085126115, -0.6709097383524506, 0.2889990181572864, 0.2526914981416133, 0.4634388827328912, -0.38832220403978485, -1.1510312370582358, 0.5915722164013079, 0.1293148735633319, 0.7863754034545631, 0.11475656894522897, 0.11696146362034832, 0.7797922730733517, -1.4108291657561347, -0.4953337209766166, -0.8439899103460428, -0.2440466643475916, 0.37925415900526793, -0.8575675666786166, -0.7130252509091863, -0.8662009707129401, 0.41068391290535927, 0.652825520267759, -0.2757468416485609, 0.9546599070401772, -0.5761415112602891, -0.5652803257733022, -0.3847781542675458, -1.0593270763675857, 0.7629939153602756, 0.17788796817540128, -0.45728065375575877, -0.5378909666307836, 0.6151825278493765, -1.3019337931526813, -1.110558219272245, -0.8860004276550059, 0.5310572273146983, -1.1978444917949482, -0.3530543230807095, -1.5431761795842878, -0.18406744693743332, -0.001404595416476074, -0.020442312671137962, 0.7957506964227505, -0.9587216786395335, -0.7419696939129096, 0.3888000088971394, -0.6700274355237685, 0.7789176666431052, -1.100553255189626, -1.8724340644374136, -0.027162003464188896},
    {0.6197085678882202, -0.7493465466303827, -1.0650366204464032, -0.5631001230358706, 0.8421447794809501, -0.11542689116689382, 0.6202828595493429, 0.32777176717618967, 0.7574456101780993, -1.0783452486627179, -1.6553078825440042, 0.41281100184219266, -0.9349354578806428, 0.13688132789265373, -0.6455160875811325, -0.6927174593991594, -1.307743261831909, -1.0156774507581514, 0.5755963155593163, -0.46501095122858166, -0.604288522430095, 0.23356557531650818, -1.6669935936115152, 0.8467794292711482, -0.008481926526639998, -1.0883002287877956, 0.19103526958729608, -0.4220976593911108, 0.8678818970229302, 0.5537013332102014, 0.029360783995734305, -1.084171002192626, -0.9108203097602178, -0.27012383075066204, -0.5828820479261856, -0.043614686556715763, -0.4626849779228865, -0.9713751335336389, -0.2803191759686457, 0.014887470544733484, 1.02686991590916, -0.9323776969400378, -0.32221393834294243, -0.7443688407580314, 0.45484454279478614, -0.9799523088118666, -1.0910805657348437, 0.5563937930879832, -0.31294390395666716, -0.6405853752143772, 0.7800875609576143, -0.5237818052846073, -0.2422458677608966, -0.7351183948220074, -1.3198162393686927, -0.7122087243133787, 0.6042655187737415, -1.5367205262389598, -0.7705453671849554, -0.7980484485085023, -0.9492897048877484, -1.2456127710979372, -1.193138496576546, 0.13851653922598373},
    {-1.213305882879577, 0.9202769857714538, -0.9710582415926319, 0.22353954470853238, -0.00829659809801571, -0.985948846603881, -0.20027644174771214, 0.3662834176245488, 1.0697452757110357, 0.5879334757403574, 0.3479004853352522, -0.272940061805969, -1.057806306483659, 0.36602266716029325, 0.24789743477672235, -0.09284045886762789, -0.957371854409881, 0.08256764998465854, -0.39444000038803284, 0.13329937821692714, 0.7112127258630485, 0.6580461332067092, -0.2496203950485585, -0.013979468194009918, -0.7054285487635974, -1.3421754457459585, -0.8116432865407535, 0.21307516378247823, 0.28638273790864616, 0.8940185536303159, -0.46509503932893553, -1.3128230220319759, -1.3044060090040075, 0.6539157356447847, 1.1597634131219432, 0.39892255267375365, -0.20570584682347642, -0.9679784204303832, -0.8549455591242746, -1.1186598793444498, 0.8860924743097621, 0.24719119522388114, 0.05458668189510838, -0.118415095006091, 0.8461000925567166, -0.4375394342830926, -1.0389462049528593, -0.2869597945656145, 1.1018197174182902, -0.5721389417992124, -0.5031904808462445, -1.392946902212771, -1.087625222760369, 0.08090650049582115, 0.6439237906396593, -0.5387819229464411, -0.4032259174925157, -0.8072204180538112, 0.4713200641551564, 0.20239858631718768, 0.24987142802121878, 0.09376155256977786, -0.704387702871284, 0.9597245908732206},
    {0.4587467947723776, -0.41342440189770674, -1.182519150988969, -0.13173391985019103, -0.47223103076526424, -1.681842300817598, 0.8067817279291205, 0.854125737197739, 0.8457553375262972, -0.40081665371717645, -0.5137435726136713, 0.8997348947517604, -0.6169398772811026, -1.0237287507441617, -0.455419517278522, -0.3124597085221812, -0.6969562062262152, -0.05127193079265353, -0.0280949522450311, 0.9008459811374868, 0.7971982891009929, -0.4351960712373922, -0.4310151673571141, -0.4290165649081279, -0.7124254374628977, 0.0621837600632407, -0.35190909082962823, 0.7699500894754281, -0.5641376005684394, -0.011725162885728689, -0.06952287640484069, -0.444741386393178, 0.017302108063722264, 0.2230922658404663, -0.15379038318853633, -0.2027844408486633, 0.5675934682385563, -0.27650426757557844, -0.8852494691147119, -1.0092079843701418, -0.04145151528338963, 0.723406816144907, -0.96865777060855, 0.18646205142844885, -0.07950501861740095, -0.19148471079978496, -0.3200430557660547, -0.8196375819783314, 1.356428196054888, -0.2429689280400214, -0.8132910336399364, -0.31523982150249424, 0.713318394702134, -0.8456164413013586, -1.3592576627657782, -0.31879667038948944, 0.5134776842607026, -0.32788822903213966, -0.7040822835205296, -0.20794421056760995, 0.30936825312711375, -0.9024649378841021, -1.4193369233760005, 0.35395611914001324},
    {-0.2478986741814459, 0.7141464057261547, -0.4404644557852137, -0.8870463167052856, 0.2312575951780039, -1.7121767829239494, 0.635551272787788, 0.10028345735289812, 0.7317225313519808, -0.9494243760339675, -0.37085948614650727, -0.8672504710495595, -0.14630820328125574, -0.937722347482601, -0.6235950489726156, -1.5508022028669695, -0.38963750758726384, -0.5815052859494677, -1.1115365471617773, -0.03160107946618991, 0.3053343570911885, -0.36049674930909964, 0.29370447645008946, 0.12544861974230204, 0.06213573915856434, -0.2805006679890178, -0.8704734321442844, -1.0727189983860723, -0.6305940834837966, 0.13773569770709904, -0.5588647330516292, -1.5984152768735451, -1.0776526558797, -0.5388412453750488, 0.09949010467232794, 0.5073197364838957, -0.8622224984915863, 0.48312272937404704, -0.2070077934051929, -1.2270542690497677, -0.7074622522479087, -0.6489726537614696, -0.6870309717365386, -1.5351655554883132, 0.2786659007732149, -0.22006481024339045, -0.5340205812755028, -1.0674275711339978, 1.0881010430647422, -0.9749092121589901, 0.6610051709091996, -0.9281364674807687, -0.3220780415299925, 0.42648393053887657, -0.8769326607233251, -0.34468906129047044, 0.44148693115324716, -1.6678907844033009, -1.081917157663895, 0.061913419552591685, -1.03319351474197, -0.4277579154671994, -1.2485277810198716, 0.004899271788516338},
    {-0.6138221713094429, 0.36253014051951543, 0.10865838110947097, -1.1871893172117995, -0.3516274557453931, 0.10699555993332609, -0.11337668156447507, -0.5648107296671306, -0.11089961074581547, -0.5026760119667816, 0.2471634170390891, -0.491468450199188, -0.8534037827164591, -0.4058841746591597, 0.6157427205951668, -1.190739631198562, -1.7257594450101645, 0.06493609837343506, -0.5311965568112883, 0.6061278942431098, -0.8303555045719533, 0.6335907086087723, -0.4222700756125548, 0.2231427236993649, -0.9884936600444332, -0.2397956718679929, -0.7260984147054003, 0.9024489957362958, -0.9765724575292343, 0.7145490317511995, -1.0277670710240903, -1.5508359809126628, -0.6885831355391, -0.36215882870291516, 1.1324553599354186, 0.9525365579095344, -0.5006742256995007, -1.2446620145102196, -1.751272616386445, 0.7173062926097404, 1.105897275152721, 0.23024795250384528, 0.5292270278889777, -1.4045473776629867, -0.42318897747164624, 0.2988464835400836, -0.9240592026231117, -0.7087879100788596, -0.2593226099037221, -0.17715462140646956, 0.9414403326268399, -0.8253284387238655, -0.9035057451476896, 0.12283236635054291, -0.9060241957023825, -0.588335047332977, 0.6072224677555235, -0.06069964609929629, 0.14638514384278833, -0.09011112312292778, 0.3373699981707923, -1.5945153315899094, -0.9720668955289369, 0.45863821431424295},
    {-0.48927589384525483, -0.5974510417560563, -1.2919500898818954, -1.4561110911479522, 0.9746240880509099, -0.9901688616849362, 0.23083043548034374, -0.3055984654468822, -0.15313297083109417, 0.1791017326911362, -0.7542584421351981, -0.19565445896375236, -0.623000594102873, -0.24826959844409918, -0.7980405886819968, -0.8644155796507778, -1.5396546220286467, 0.027308991178387927, -0.317348837746108, -0.5326536720758913, 0.9437704021495144, -0.48468029256549644, -1.5065481061517134, -0.3544250083717718, -0.18807391375223695, -0.4883825433737751, 0.28308431332534373, 0.37173671653450163, 0.7767955555577838, 0.8088379812759239, -1.5484942066184386, -0.8104906057405729, -0.06666564596941338, 0.212864221084178, 0.48791478988478487, 0.23758065966604322, 0.054542888237292524, -1.2176015070766637, -0.955203039724847, -0.46238353572931834, 0.9871075412063084, 0.3376110904027349, 0.6867365020933438, -0.6423675612563947, 0.8426035851746229, 0.7736083686530778, -0.08672796458462755, 0.09652636460311674, 0.1652519271582232, -0.680280544028116, -0.8418355868067594, -0.13431619030541617, -1.116580673077864, -1.2749422386723999, -0.8902161026758363, 0.8372623532233624, 0.11419283362931046, -0.05920254655017539, -0.23399460144798484, -0.8529241325228686, 0.23068806129228756, -1.098368417549488, -1.4244950094491977, -0.8088289373183687}
};

static const float b1[64] = {1.2178627769156807, 1.3717993262924753, 1.512990798754735, 1.400351359342575, 1.1360204204667197, 1.2328635807207868, 1.0792700683988457, 1.2656150586389996, 1.1106884897468325, 1.3854417154307306, 1.248639732704254, 1.2173395427608777, 1.1423302157026458, 1.3039978940528372, 1.121088847578286, 1.174159502693124, 1.506809093472161, 1.1213084369277981, 1.3874829953006733, 1.2267101645094873, 1.2510544114905746, 1.3085103906469044, 1.4344744249048693, 1.037479852382394, 1.285538224729653, 1.261584016744959, 1.3128876026234066, 1.4208807739591138, 1.0455918528646995, 0.9993954052194308, 1.4133054456362113, 1.2371766602945147, 1.3707547706583039, 0.7562039751085876, 0.5114314634832162, 1.1315718089796523, 1.371378428278399, 1.0669701429206193, 1.259689441860833, 1.2309023378148254, 1.2081873792157238, 0.20259260918091, 1.4592958842700912, 1.2238608898393748, 1.4238995565585313, 1.4769102304266177, 0.662491114247908, 0.8395903689798715, 1.1749689907093819, 1.061552095267172, 0.5179648451172371, 1.3198674182044803, 1.0779573775855522, 1.3497059213003753, 1.1227939742733983, 1.158221832154529, 1.3289641132253713, 1.4692319128238065, 1.0693528419567422, 1.2828470715946823, 0.6720167369867698, 1.3273338807759585, 1.4236012128621756, 1.3893959699297482};

static const float w2[64][32] = {
    {0.4012786955732452, 1.366750798122026, 0.16734576837948656, 1.1504179167812467, 1.5872223604285562, 1.6038466186227738, 0.7281265662038491, 0.7211207238611625, 1.8025564898968343, 1.9454088744280231, 0.19228572609196531, 1.3347082814861058, 0.7780106945244234, -0.1546907578728979, 1.6846654678255313, 1.0664340908139083, 0.3266931376727524, 0.6596521976394346, 0.4815268133451456, -0.057588260553664825, -0.12753751451639464, 1.790921000176557, 1.1700736350168641, 0.16932445811874092, 0.04313791419356782, -1.0489985239445097, 0.7739213567711689, 0.6695120135805483, -0.37053973633866427, 0.4077008335991368, 1.8101533997217223, 0.6643022364458518},
    {1.080130042453009, 0.9444927084110039, 1.2687619660407168, 1.4584370132141196, 1.9757717833126418, 1.750891288638604, -0.10865314392663225, 0.9022565803562901, 0.06252912633619985, 1.1421776830024952, 0.207545157975598, 0.5299425386901844, 0.8694351976830461, -0.900800434729618, 0.3559832106667069, 0.6451316201226754, 0.580689093168033, 1.1688793041462258, 0.9997435574054818, -0.9091829724568095, -0.0990444080151361, 1.5051614820661479, 0.06786445735203336, 0.1392072770429742, 0.44453382225706944, 0.24334961610658148, -0.8829816241794493, 0.7780076776407684, -0.5152148653290004, -0.7343272660568354, 0.2882113914495075, 1.50898329549204},
    {1.7392248821132947, 0.9331421669052843, 1.4977768390252617, 1.6659800181805422, 0.9743307592084689, 0.6143914049288366, 0.8037555038438611, 1.4288730033818224, 1.0903695136936966, 1.8994931912257225, -0.809823750169905, 1.3760541663328365, 0.47144745847881464, 0.1180568185571743, 1.65149108744707, 1.4294688602774313, 1.0226541802032212, 0.7929186507719441, 1.6097245695287896, 0.6368353321689164, -0.8416122431273526, 1.8498033778182172, 0.15693622237406304, -0.26450317362983844, 0.5981997621745939, -0.22448648025296808, -1.059362803501809, 2.094942492216952, 1.0769569381274442, 0.22482618326238407, 0.9246702476706997, 0.7064774980453578},
    {0.8471416262762571, 0.6867052935984952, 0.5798863303026047, 1.2622667858023908, 1.6714659138293966, 0.25180260769029206, -0.06875643219080205, 1.7157755134277721, 1.555930723040374, 1.5773339140147185, -0.27329241124009224, 0.7105924407804804, 1.5818439537994957, -0.26020248508605415, 1.245774065694536, 1.9024341517105385, 0.8215780264721864, 1.2474408045734042, 1.1760296011529947, 0.22359752789960846, -0.49041594738452005, 1.5404027024869986, 0.41681991030901566, 0.2992052070351347, 0.8228418628628342, 0.3162175739078319, -0.9179903299866482, 0.3370793473792654, 0.7545258759778436, -0.16072542556746755, 0.51079866630417, 0.359901304858873},
    {0.34561424277204805, 1.487068774291422, 1.9466453411816025, 0.24219074264879475, 0.15618198556770355, 0.4704096692916301, 0.011287137314530451, 1.128817537223597, 0.3760895808076425, 2.011508513457534, 0.2721614778032735, 0.8166340411809652, 0.636803390783273, -0.2842436495333064, 0.40901038361702774, 0.5009029218646371, 1.7934612474542588, 0.34498399755450904, 1.131573301619748, -0.389310564436056, 0.47005065747593805, 0.13742895139050415, -0.22447847257646864, -0.9885078132530515, 1.0339413216384763, -0.21065933259121314, -0.19731206043762087, 0.6568521956238633, 0.44121884458248795, -1.0163718752614814, 1.968177023512602, 1.2978261708398342},
    {1.022439143128213, 0.725996782421437, 0.5087254573747519, 1.5488756708647151, 1.3571168596949583, 0.38495888776909304, -0.02112557358096643, 1.3803632423498289, 0.7161484411261058, 0.7508447594218063, 0.12647483398522097, 0.5373675646112706, 1.8168585679373435, 0.45464558574638847, 0.5788256888869765, 1.602440439168117, 0.9675684908261731, 0.03767314876100903, 0.39112703817815064, -0.7785703124367688, 0.5523337018321585, 0.5784396429833597, -0.09654432132152904, -0.8734345125370737, 0.762506345550437, -0.8556302948675786, -0.04401033149017186, 0.7436433137391658, -0.47745773652663265, -0.9749581213700831, 1.4143409394723325, 0.3749523839389379},
    {0.26025914766921215, 0.8984024285218122, -0.12106819717858676, 1.147055859884525, 1.293143466005218, 0.12080165854350473, -0.48219853014853764, 0.3823696060092472, 1.2432640184036958, 0.23173344632606105, -0.9487979125064808, 1.7509713321075175, 0.12567393202150004, -0.28763155009220515, 1.4206170115505234, 1.943735995940157, 0.7859289114838537, 0.5634063465343434, 0.7900220691338875, 0.753799994678648, -0.2545480437322117, 0.4899217658580493, 1.0280716579799727, 0.22814958875228747, 1.627398800324106, 0.7407084947310323, 0.6691969311191586, 0.8316073346811186, -0.07918134912271559, 0.2677886852969619, 1.504283058285011, 0.6462998881679174},
    {1.118765427775803, 0.37269767776434753, 1.860176516205224, 0.9828914752388183, 0.108526168316703, 0.029488199087353877, -0.5311615486989245, 1.2774438358301214, 1.7664257703822566, 1.9319974579736554, 0.16160894588469898, 0.4575059444180076, 1.0232288123851698, -0.9717754418706395, 1.516892087778772, 1.217326863768783, 1.5955243505191194, 0.45569361833810285, 0.5095487624484305, -0.03489409181736896, -1.0725888804368813, 1.8288596312877963, 0.4146367092463179, 0.342555621803052, 1.4515296415389123, -0.9250547151014876, 0.6087646926715452, 2.0602222400438315, 0.1106714573987452, -0.6297162879476188, 0.39298626671900383, 1.7561530546282649},
    {1.8655534263287987, 1.2324423246152785, -0.05751248107662852, 0.006853820547767646, 1.6019355957707127, 1.548425832061513, 0.5275621700679085, -0.3391008650294522, 0.25719491213149953, 0.41312213797613556, -0.6633030443150782, 0.8344219551274655, 0.38657047925632104, 0.4884790475644334, 0.5773277963282426, 0.25234078695987777, 0.35907980467489353, 1.1268548968556704, 0.9383760935083039, -0.19988174897116884, 0.23392285277433786, 1.4352175247558352, 0.9578073461756067, 0.07994668054024295, 1.0466096842502521, -0.0389100499450439, 0.43541419315308955, 1.3200908921047454, 0.800953973071535, -0.7228931921202304, 1.781716540346472, 1.3484592883788882},
    {1.8568961543670208, 0.5271888008439067, 1.3603021663381007, 0.8696896328682361, 0.9266916423762926, 0.475200799109839, 0.3583412007432849, 0.8943872022862449, 0.493157251765021, 1.4133646419330823, -0.0045542542278902455, 0.9110077822571786, 0.24035750109483855, 0.009193786467961741, 0.8966816076915024, 1.424946805758228, 1.2029041390206228, 0.09341993858224065, 1.819761476226013, -0.24825982141903707, -0.4877527472763011, 0.932468295129454, 1.1255704218755638, 0.2129041044107379, 1.7440283163884793, -0.21327501915930763, -0.08076188579288926, 1.6158192315676574, -0.6526064529711105, -0.7274447186840711, 1.930154141729948, 0.06721594848222362},
    {0.38132513137315166, 1.3915767857498171, 0.948473233182205, 1.0747761984343245, 2.0245397654815216, 0.7877132581038613, -0.2659170307693944, 0.06938696826013932, 0.6551123435938201, 0.9305114432098833, -0.17546832009843466, 1.8296820387653094, 1.5383116659350768, 0.8930493166775819, 1.0361267811236916, 1.9224083852875262, 1.6696229587423923, 0.4789109250866142, 0.5538820881789943, 0.011584930802779355, -0.4694858035469528, 0.9904264597889197, 0.7212876991232341, -0.3580516452702631, 1.9224218928405654, -0.12660075432622125, 0.8164136496450738, 1.608258300167786, 0.6730498317467561, 0.22395912153445083, 0.7932869845614235, 1.0136161382422475},
    {0.6117515391180566, 1.4810936935031647, 0.19288046261248634, 0.2093463783846308, 1.8419852164464017, 1.2188551095363755, -0.4508511109097557, -0.24566264424318676, 1.0492470439509767, 1.8935361276070382, -0.21298304823549027, 0.05116651873669113, 0.15127113602239525, 0.06126995673550688, 0.428066001887114, 0.9795981552034275, 0.21800228975235184, 0.10015339242023204, 1.2574766576990366, 0.7555983285000683, 0.5298813524131085, 0.2655190776126384, 0.24921984784945023, -0.363008976140987, 0.9008644809437504, 0.5050898540205097, 0.6254493736896326, 1.4899857019583869, -0.7563211303705035, -1.0333787563432582, 0.7851112979282463, 0.7226586418838623},
    {0.2057147979995534, 0.77249300880167, 1.290107355322462, 1.741377599573363, -0.03733900795023176, 0.1711287376918757, -0.9499276776458323, 0.9964658669916067, 0.03655429095979662, 1.7022775267687502, -0.7758967868333205, 0.2926001938121223, -0.07400098906300509, 0.7505490825740254, 0.36460444662559377, 0.4947994277102993, 0.5132946110450104, 0.3499538669209867, 0.12409826913718688, -0.6356646456539532, 0.07275541143879327, 1.5806732903776783, 0.517019589235288, -0.9255518357671084, 1.383494674362077, 0.33972847778798887, 0.7960467391864546, 0.36682062412578637, -0.3150384306323002, -0.8634189789022767, 1.3397627362788944, 1.6856978053820122},
    {1.635105913903683, 1.0677780812103304, 1.9519754584008713, 1.1540376943976576, 1.7114927630600534, 0.8392841562697909, -0.34168493876350925, 1.4319082131118384, 0.7719312100277723, 0.3650792097724107, -0.9328194607917798, 0.23974754602843856, 1.288451235267171, -0.5698697297871296, 1.5235476802716874, 0.8648774674109677, 0.9429648173290563, 1.2118107487346044, 0.8058562589712414, -0.7888509369329408, 0.19281098710280917, 0.88599733135409, -0.25966497908952124, -0.22708549798359465, 0.7957849659183382, 0.03666884788403466, 0.7489401720489761, 1.2370028932614583, -0.4192199399141651, 0.3704167575461121, 1.538031809487903, 1.7192302524116403},
    {1.5820207252456724, 1.2930546710853486, 0.9198441350097201, 1.41677213919247, 0.9376112265195476, 0.1709531117877816, 0.5785202505271294, 1.34253750777679, 1.3501146871806562, 1.037446165704774, 0.5705362541810313, 1.0612081991910671, 1.100022347433922, -0.41019777479529396, 1.1379891406362055, 1.018074964569815, 1.690309499225679, 0.6137565261556192, 0.6792813417805298, 0.03348418517646059, -0.3126648740117753, 1.8939952318533657, 0.9749274012251555, -0.73710927120016, 1.1211675669377432, 0.14205785975899896, -0.2619781423300922, 0.959511282258824, 0.3115892030443447, 0.03131370116843083, 1.6039655417465413, 1.4431884920647862},
    {1.3841849202839192, 1.6738966201806358, 1.4976769059229542, 1.5137392770111446, 1.8970753523096417, 0.5681761517038113, 0.4063339729052727, 0.7877726639588946, 0.526987732280678, 1.0987561901864793, 0.046687068431914426, 1.024717545821328, 1.84546210951134, 0.5705646830662021, 1.6728566430890128, 1.5711646091243088, 1.5450630912154433, 0.3835519184453208, 1.5556625978094833, 0.155772091149163, -0.16669333841421255, 1.6302868218552298, 1.4364210101751644, 0.029856156858373797, 1.6995533152360014, 0.4451285684700298, -0.41112588517088366, 0.7944157083759942, 0.1533456031730811, -0.8000152036934866, 0.5258409315105662, 1.6945575347505928},
    {0.8530362975892983, 0.6531752540238438, 0.5666744699008563, 0.44531136275990224, 0.5724771725085455, 0.81726076175414, -0.07059201448372394, 1.0783356344948427, 1.3571473362927202, 2.1847156240890784, -0.9724518596356143, 1.44610782854952, 1.8680891220051261, 0.606480238778749, 1.3724324932100922, 1.0021711839073697, 1.2059212630141427, 0.3430293230459362, 1.535034777736991, -0.18269489870580355, -0.23476737866937414, 0.2909701899422195, -0.15078270215036887, 0.05527361888721276, 1.0890869415213429, -0.21953319687539846, -0.3901595947268786, 2.186694853258261, 0.3970665663608018, -0.7230300758704441, 0.26648348094143604, 1.5502760002563558},
    {1.2301580029589056, 0.15372432929326416, 0.0838442161732672, 0.23560365033093547, 1.2655563202755198, 0.31552851861695225, 0.07166677655038846, 1.04715626720429, 0.9541780478292087, 1.889809315621037, 0.6423909239361645, 1.2122117937992558, 1.0316926546074006, -0.7187768913982563, 0.6915840715315442, 1.4947359014602408, 1.7204826920075318, 0.7048391360740647, 0.8778767448723778, -0.6675190023410265, -0.9102683549746986, 0.20123184499816799, 0.8782471513795902, 0.4207156325148711, 0.35817047579736516, -0.2053688789844199, -0.707124470652059, 0.7024385058001188, 0.7167026219169891, -0.6509054750255092, 1.617666786987787, 1.5217106033008874},
    {0.9062476509318038, 0.6809309408146933, 1.5600897460391627, 0.24642653871909626, 1.8361849685536524, 0.26313425482244157, -0.3802268373069821, 0.518678541082379, 0.05258021577740752, 2.150914415545242, 0.6318111415671233, 0.38581143591433925, 2.024220386945871, -0.3367757431216964, 0.8049291014014935, 0.72850249714247, 1.8019226824309527, -0.08105073920126307, 0.563933398864104, -0.9408152423591878, -0.18366780969495602, 1.8570544425892956, 1.5912645460746933, -0.7087681968332925, 1.4292576510658968, -0.10041944628704245, -0.2892657321483274, 1.1214094933584806, -0.541359564930019, 0.15669593730155437, 1.2164403054460797, 1.0658113367018467},
    {1.3630939108306603, 0.8976339595965748, 1.7060181569389776, 1.2809106348354498, 0.630223701155201, 1.5467605919726652, -0.27478666718316513, 1.454691984932736, 0.7849179493651764, 1.4334620598578585, -0.7851683893157481, 0.6012687890211244, 1.3905441931235303, -0.9773201438855921, 0.23545570184503356, 0.8612181058521086, 1.2937980606549757, 0.7094839848578731, 0.39323162074351026, -0.771041328850079, 0.5585034687888254, 1.5598628136892263, 1.0780592143353513, -0.11263322039563164, 0.9306809127470779, -0.5742783018603758, 0.6850824749675158, 0.871730228418371, 1.0183609805410787, -0.6516180483932626, 0.28932180450205425, 1.5798496411584015},
    {0.36950852529899275, 0.26130168218750705, 0.4213786731137897, 1.057434164038813, 1.7710112047546478, 0.818199402386361, -0.9131929152507153, -0.2878814316218008, 1.4060046887978814, 1.3016316770184448, -0.5312443704577767, 1.7168793785024747, 0.7359609294486271, -0.6749560301522491, 0.9071393986668831, 1.7068541582253534, 1.6093418872874592, 0.6498197299202999, 1.625117326156588, -0.8182980748965385, -0.7986799813424568, 1.0799521523591595, 1.2190186988531844, -0.021064282951588825, 0.5762311012913889, -0.12112385018554916, 0.5224398695768849, 1.035232549240575, 0.14436831284872015, 0.7329071861495569, 0.9543227468356904, 1.6194551166979059},
    {0.0286297121190867, 0.7750368656726858, 1.6998850044378782, 1.3446302082241015, 1.8227967123901734, 1.0799726996575627, 0.5568101403901283, 0.525868436915278, 0.02443832881888456, 1.937601917932663, 0.5474714217385103, 0.36910902736240586, 1.6946462449862059, 0.04831590153604152, 0.932470892725175, 1.2713132217716054, 1.6090953234241097, 0.4228935977778982, 1.2726408329255783, -0.31730465300726723, -0.6151908753792613, 1.7873137512696586, 1.0373513154850313, -0.9206320867764392, 1.2518523811935176, 0.39710417715824364, -0.5934465981046583, 1.7427866794156244, 0.533751483909939, 0.611166706421943, 0.7055827627225655, 0.1759924620700827},
    {0.47477288679281676, 0.480569868390617, 1.2572255866386304, 1.6663527033397618, 1.8950433702933165, 0.7244424500762258, -0.6486528070678811, 0.7524322764655114, 2.0060827968582764, 2.169814944798381, -0.33954658239307406, 0.5406800094461445, 1.333067651445978, -0.6414900762013757, 0.8959163265018477, 2.0589845208433424, 0.10987221024591262, 0.516819405232344, 0.030485940788970243, 0.8061501841683805, -0.1341051059691078, 1.5219069089074029, 1.5541240271386474, 0.08743448155153069, 0.047035083379983106, 0.033184887226623265, 0.7972539007874294, 1.8487194551060517, -0.39729991704978357, 0.7611222002777183, 0.6616985069182044, 0.458028202895745},
    {-0.0616277658078246, 1.2183432073385776, 1.6257208665032632, 1.2440827148253966, 0.590016344123598, 1.5959550675447878, 0.17032256297102083, 0.9823068611058363, 1.1665533429201305, 0.8855110637278238, 0.6702700569190421, 0.0571670697645251, 1.6905163704847102, -0.7721808954684662, 0.3768049586473157, 1.273699170208384, 0.7134475151171462, 0.006978120244392814, 0.14000177711107292, 0.7445923225832692, 0.7427391610662711, 0.6124586852652479, 1.1964731729939704, -0.8677301051777301, 0.7844525776972912, -0.46424607352865754, -0.6808221822502376, 0.021063821288956133, -0.10217152184988028, 0.7360189326612397, 0.7549131379111501, 1.5217330265129025},
    {1.7567002214269116, 0.6599455713535334, 1.0653680259391838, 0.6761216999104104, 1.2004411643637152, 0.1511798969694775, 0.6434494682330995, 0.16680085658394836, 0.8800331417861302, 2.1528574587527793, 0.06629278210827462, 0.8677385328354125, 1.0313841917315594, 0.386108234381114, 1.0848223678519886, 1.6688121033890058, 1.4975864999413793, 1.1974631828014817, 0.08952228817188991, -0.029358993852062008, -0.7450101803094611, 0.6090919599938528, 1.363058051861554, -0.833488971403576, 1.1322041595827321, -0.37219450665764764, 0.7418189692429976, 1.8670215140626447, 0.5402200451366987, -0.6098468743840605, 1.779674674609864, 1.6881485037069903},
    {0.5468585037289253, 1.5002223540985455, 1.792195238341742, 0.40872190789677354, 0.992006133261988, 1.6309733096632941, -1.0284243678149194, 1.2390932979435705, 1.6582082716534952, 1.2081309700879888, -0.22776787686454644, 0.7984767010524402, 0.6372106730886202, -1.021759513850013, 1.091855483087939, 0.4787517040101478, 0.1597869687630015, 0.5029872577347904, 0.30902356997434965, 0.5739784037883077, -0.15269434393460182, 1.3286424760180455, 1.4821804640363851, -0.4026714560788027, 1.423090020474833, 0.7336958218287017, -0.6228340981382688, 0.30839087590949116, -0.33314853181447335, -0.6598730339314719, 1.4644716261062292, 1.1242799561751309},
    {1.9002707314403213, 0.12446382201976347, 0.6857311453247662, 2.063393450473144, 1.5472696822284968, 1.9631393000539252, 0.8097512254402751, 1.5955778515933583, 0.6302774423950707, 1.6871658013110917, -0.5589377829167554, 0.6498790823502602, 1.267168261744918, -0.559864474801835, 0.7253336046293982, 0.7539626839321442, 1.0209696496802927, 1.530605044263485, 1.6373377457920655, 0.8130335760906059, 0.5989062579960099, 0.812715571808684, -0.1506177243079975, -0.7490582768518684, 1.811967912957673, -0.7002272052760344, 0.3842705090705071, 0.3734336374307961, 0.523848126628606, -1.0254273349287477, 0.8011505994712477, -0.04378855524698542},
    {0.0970684471484741, 1.3194003625078596, 1.7526180414232573, 1.2140317561548661, 1.019455715634001, 0.5905596777930676, -0.8167328692692523, 0.98747211542416, 0.4790330383548695, 1.1579174922146453, 0.27798173760493233, 1.841131068656988, 0.9429646338054285, -0.3386313094575652, 1.32015152716876, 0.9991291997063365, 0.5516008352306709, 0.3906842807610895, 1.416545467716341, 0.059249697274170086, -0.09718686077983332, 1.018994622298216, 0.7533371592844651, -0.19108918426142055, 0.25775133519403576, -0.5128476908019465, -0.49950607162213584, 1.4739849456550127, 0.19886436666707902, 0.07158172670943916, 1.6947270061778943, 0.8150298461123663},
    {0.3409477081473421, 1.302657209005437, 0.030503112317592514, 1.2116624695820037, 0.5427252086570264, 1.0571316015222938, 0.05997127323124936, 1.3546398786050708, 1.1473866147737355, 0.29847949682075536, 0.43674729218299235, 0.9887676504781635, 1.5365800324671335, 0.4259765636824383, 1.0739697908688859, 1.440957487507213, 1.4936023270760839, -0.3626252736233634, 0.9081570866980031, -0.15526460418606094, -0.7513954524169695, 1.0491363572887116, 0.6909095150554592, 0.6649833308539411, 0.11155333982908436, -0.4626499063638491, -0.5527416762813194, 0.8353677223765497, -0.30053730204226875, -0.6272361219400524, 1.939090548689515, 0.5359298147112619},
    {2.0258210737148983, 1.4456148027293394, 1.7749785270527714, 0.3408942886826756, 1.9512010998862213, 1.5472821954871425, -0.3707531607509367, 0.5417021735661407, 0.3072688492342868, 0.6385085341503325, 0.6501470877843234, 0.6031996365155357, 0.694111615235941, -0.1048775712177839, 1.5454314358175343, 0.7234443289998386, 1.147938035333868, 0.24458158900129534, 0.15802350163279136, -0.9733344383406999, 0.48094186575624964, 0.6215005425687752, 1.347326418710507, 0.23097528006413143, 0.9409227893033554, -0.3205351477809191, 1.0053874357681516, 0.6603801502917241, 0.0028809017991631505, 0.8023213943260058, 0.3326900273886318, -0.023245124906193224},
    {0.9338869833409634, 0.6428074144458972, 0.8049802826397894, 1.2582533857142673, 1.9758548896312387, 0.9569752256378496, -0.5046815668428696, -0.07368298151449597, 0.9401515385218009, 1.6733252157835852, -0.18388803539339352, 1.6780905754950166, 0.4021300273702646, -0.9418231610000414, 1.883053542579213, 0.34634836851701745, 0.3376776556388292, 0.17548181922097864, 0.7929127234962577, -0.6266744758482051, -0.7584656481294797, 1.2866726308694918, 1.5588708999272762, -0.5627291001416984, 0.534243422167857, -0.2767395798515741, -0.48713098018993184, 1.572264794923671, 0.5899393013428627, -0.03940885798888543, 1.8685378288941787, 1.3059807282252343},
    {0.3505570534118596, 0.7222761532851092, 0.33305155762779715, 1.1426835554563122, 0.9929416838989437, 0.15672218485415187, 0.7076816427571502, 1.1322174362719772, 1.9932772233576115, 0.7535503745015134, -0.8906813772600327, 0.5630114670045742, 1.0694172439007943, -0.17315166627205905, 1.9665974195891225, 0.6439594398952531, 0.30267408513074545, 0.7712319475058219, 0.942134734383633, -0.20139751539726664, -0.28350350070426955, 1.122605549555132, 0.8493217853233693, -0.3739177646776396, 0.13698426367813044, -1.0540552140769432, 0.4331264173101944, 2.1203538530209753, 1.000625732316353, 0.7660552742899382, 0.954020837573938, 1.459362518809013},
    {0.1054623767155562, 0.16590872116060976, 0.911487426404138, 0.14035842362474826, 1.094019328961769, 0.9025837065071615, -0.17388276947439152, 1.4259667406069707, 0.5438890368536665, 1.6877785701176884, 0.4807052117083989, 0.4198619607546092, 0.6633225661857364, -0.32181771664642717, 0.9373120408823827, 1.577063685173063, 1.180114633758988, 0.08155904716532571, -0.05022534041223334, -0.9724485430671186, -0.5009387640092517, 0.8899778398317706, 0.49018910902694934, -0.4831981089615634, 1.4945108928757926, 0.49054412400128317, 0.14892756094657472, 2.132055304156416, -0.48573969568425845, 0.1262295193689588, 1.1405329863070555, 1.040636044532017},
    {0.822957289824398, 0.41900035750242026, 0.44826149070784754, 1.8108469771208988, 0.6159738286626101, 0.8624089831201822, -0.08911918793779364, 1.5038871816172363, 1.7685255738577028, 0.2805802116880001, 0.24339818759970902, 1.2888252136264855, 0.5019902847757454, 0.541966330666191, 0.7697963511255488, 0.23395221337393265, -0.09754756358948015, 1.5364855517099807, 1.5616101456514186, -1.0393548006216926, -0.9204020560093286, 1.3797187923827932, 0.30664423295710913, 0.798785531379151, 0.5262237906448465, -1.0345956532219651, 0.08853407161967954, 0.7879700261796713, 0.525744513613909, 0.5562881549458624, 0.41406822000688803, 0.8933628912210035},
    {0.95671005912881, 0.48598462837181566, 1.5855820837156376, 0.22029021788486763, -0.034166303455500785, 0.39124427563617237, 0.4507998344284602, 0.08853425661295267, 0.47556056891690984, 1.387109453753955, 0.4982842329027462, 0.05280438241714715, -0.014554280875809561, 0.22827568055791986, 0.6835988333674937, 1.6445250460589027, 1.3253764995592963, 0.3702683279437449, 1.1555037640197112, 0.24928884372705015, -0.911965059933075, 0.38482334968436344, 1.214878049883535, -0.27371305598041173, 0.5743678610138953, -0.5075695727086028, 0.2613430534317122, 0.1338415534315785, 0.057355870044173, 0.15181730263389945, 0.4098478852376366, 0.8935289192104761},
    {1.8524778610824606, 0.1514554792487403, 0.22299556022719244, 1.8811697009022819, 0.40995875093697637, 0.8118496137112202, -0.33789905724321345, 0.03574656195934482, 1.5434328261806873, 0.6876559285100713, 0.15014346515581103, 1.115167212967578, 1.4748671357545275, -0.5823106151162368, 1.9334259808812946, 1.8469519741989182, 1.1034956726917522, 1.1794205905258637, 1.2310183899072422, -0.9686780515625777, 0.8082957559538811, 0.8274211116681934, 0.05616266631521134, 0.5339715669579287, -0.12137863731268084, -0.19145161207333994, 0.030157551765071507, 0.10558425866565455, -0.5540606246747012, 0.02144760920269344, 0.7535163326560541, 1.7848972862439396},
    {1.6028061554727597, 0.4947145192109905, 1.0866719741890778, 0.7478402559623385, 1.8140800622165116, 0.221708180560705, -0.6175641737125815, -0.025739434177117777, 2.0004389674438463, 0.64653186895325, -0.2663209831048584, 1.8445750530849583, 0.8240530935642542, -1.0501453708081627, 1.7356133858072187, 1.9083015622540382, 1.2628623531247054, 1.3155457959477035, 0.5779510508663107, 0.061625676151324, 0.5611473252219062, 1.893914413633917, 0.7955755488922758, -0.1525106660189794, 1.2472464867443973, -0.15002658306933783, 0.03840703737991199, 1.3092864299860365, 0.2808667978224171, -0.44459688228023375, 0.5000572473317644, 1.637313282228374},
    {0.27009510186759866, 1.0941544972359931, 1.7038074178008347, 1.6618116787148431, 0.8512637893650739, 0.8363114274621497, -0.05372396091426375, 1.0365163890852795, 1.535006913508301, 0.193682060124388, -0.2110117281276605, 0.004315107780418367, 1.130137787549375, 0.07742645045082971, 1.7869441891136943, 0.8047694998682787, 0.3746938223794467, -0.1310936134712758, 0.23975460533677953, -0.9633048077626929, -0.5197415148078188, 0.16409841430294628, 1.2779094116773724, 0.1441627827049528, 1.159135555019001, 0.3691199070890531, 0.28651436225308774, 1.008445418060601, 0.009779889118173056, -0.21693337574234503, 1.2351286301813431, 1.4644722900874185},
    {0.7997198055418075, 1.8956988322731447, 0.4096949503237785, 0.7140279207023642, 2.053395313396297, 1.7690272281945485, -1.0673099771207357, 1.2111540465256867, 1.9065997580189855, 1.3079001037833793, 0.3900950607948759, 0.24651380872823223, 0.3795178535617659, 0.27469987440320187, 2.1291195116665698, 1.068852669931934, 0.4001053010240125, 0.49359484621129585, 0.1785135545362293, 0.8806126787583538, -0.7159185329347417, 0.9576571095015652, 0.7213281039426169, 0.6217826890400665, 1.721515842699181, -0.981370209738143, 0.8643122998676906, 0.8380184863668052, -0.04894163819289798, 0.5870502703546323, 0.9433777582809902, 1.3004525082969498},
    {0.7219125469513288, 1.1332687072672412, 0.24143948020323375, 0.96661019370728, 1.8332235680823128, 1.4447806652640764, -0.5994984721491567, 0.02237185045286228, 1.5229785717661954, 0.9349347440337195, 0.5114885404249571, 0.8653030136760904, 0.8679599398514182, 0.26531533379061145, 0.8778532946272178, 0.5863163071265971, 1.5829292690865884, 0.4512627408756883, 1.2585441421626842, -0.15960138424078602, -0.516131259417969, 0.45880945810523693, 0.4104830742117941, 0.8425051937751691, 1.43618134991643, -1.0307804962488278, -0.42695210972023373, 0.8258721410309315, 1.1139024402544746, -1.006305887029473, 1.1999510536610551, 0.3977542939666667},
    {1.335674467955629, 1.3471279440387913, 1.4344571553151397, 0.5151820006862058, 1.015759333472613, 1.2025099123657765, -0.8768536852526998, 1.5942388569931638, 1.7711726715071476, 1.7293250613449107, -0.5279515993340624, 0.08070867022581124, 1.4700776964217919, -0.6122640280221935, 1.251338899559619, 0.971919311043455, 0.5627695127859053, 0.4249981695306683, 1.1110866905919226, -0.4311178975334494, -0.4999034413120301, 1.3731226275945796, -0.2278112834499049, 0.6135929952184255, 0.7322480328218627, -0.3324759420693648, 0.6870623514587696, 0.2057179545743593, 0.5144387865390915, -0.26917750154832243, 0.17159478867456468, 1.227809034740481},
    {0.4312867474793828, 0.2964677035806955, 1.1287485285615764, 0.3073300833925945, 0.002299477113286645, 0.024831348976662528, -1.1139370016722685, 1.2381233030444472, 0.1448581581560504, 0.2233891093367558, 0.8323485244221964, 0.6657547364406647, 0.8237059122727507, -0.6222121198772114, 0.014005782418514716, 0.27987665042804044, 1.0398759671670106, 0.32912565063890176, 0.5640623652339188, -0.4060681361682032, 0.8213468718789226, 0.5502801734979916, 1.003051521544525, -0.4369686621609897, 0.08028509607095194, -0.9164700452626809, 0.8863932408430061, 1.483492130509969, 0.5874435054788224, 0.2700790726343655, 0.6201558468632836, 0.7829629965681243},
    {1.6165245538587363, 0.9297545526702884, 0.3698512130678039, 1.1113023246371734, 0.33736444383128755, 0.9002412016649488, -0.2901942416882707, 0.9571606304689008, 0.2459584428300783, 2.0626359644718923, -0.8746307744653578, 0.4812181484697579, 1.690848815716287, -0.3378418948465163, 0.6992800553760088, 1.3655143761937845, -0.032625134276260286, -0.034341569032102406, 0.41365680038670793, -0.9097162365321825, -0.6874029758537392, 0.11455185981537355, 1.1276105707145703, -0.39174928496185535, 1.3040718479259108, 0.4849308787256485, -0.36182201918032336, 1.8697141157643535, 0.49663059069966226, 0.39482932812008587, 0.6113848733364198, 0.3385218076275732},
    {1.2078409986610894, 0.8113636032365628, 1.5730452195073656, 0.31753033861989655, 1.4672953550411312, 0.984356743404361, 0.10208844962261368, 1.2003589278887317, 1.8844548205091871, 0.8298071512986761, 0.6761249719130252, 1.1137303826023477, 0.1553082050067609, -0.50643979949498, 1.595193760523482, 2.0400713734704468, 1.1450124652929734, -0.013997924186794432, 0.9293768667807922, -0.1403660026111947, 0.8625844383456395, 1.184122848973777, 1.476691736614915, -0.9720374776524596, 1.439709858813363, 0.42277255878923453, -0.3430068078164404, 1.0256338859718315, 1.053846578595581, 0.8106839084255116, 1.7991868718717685, -0.0583256507526201},
    {0.10323878977827285, 0.21532675615351995, 1.5873214993193758, 1.3488239021235926, 0.35910074007154313, 1.555894523152793, -0.06766160198780753, 1.0700346702493937, 0.32487214398172104, 1.1129976117070182, 0.36462949252422494, 1.1050232408340397, 0.42841558078557934, -0.47987440481799243, 0.9335273888667762, 1.5549389732376881, 0.7148290800233109, 0.5850051079463051, 0.278783501715107, -0.855100689606757, 0.04990687031624962, 0.7090780331652712, 0.10339181107721454, -0.48383175832442915, 1.0258255910511969, 0.02371508114307641, -0.16177982202281418, 2.039802636361695, 0.30721679476983954, -0.318157411821101, 1.8574904649744006, 1.770580148826172},
    {1.6488354444049909, 1.2573514991598145, 1.8279445104271355, 0.6203887912653451, 1.135009703835686, 0.5714283839252254, -1.133474722817617, 0.47686502846097556, 1.1224294380968787, 1.5145925959868811, -0.35069614929029136, 1.8618381396398918, 1.123252293660248, -0.7546028749639913, 1.350684485850581, 1.8121134880663945, 1.284508415187913, 0.11177130484762453, 0.7234007073605231, 0.7788971318043239, 0.15108388967691022, 1.7480744132292152, -0.19626440097463285, -0.5419022242282316, 1.9732091439486659, -0.36537342080426416, 0.3992401587310046, 0.2805534014840193, -0.04653290858434692, -0.2409905376074484, 1.6348392494875208, -0.03292475898887218},
    {0.14728376037079047, 1.2466337212322602, 1.572490617716127, 1.4224039744347599, 0.14308936193585428, 1.0716603916777077, 0.019754300576565523, 0.5715730175879927, 0.8682954317439104, 0.3022435115174999, 0.7144968843661135, 1.3507870294157196, 0.6369628333870025, -0.08599160866376629, 0.808429062734741, 1.0189442873641512, 0.17266242420430428, 0.6133028063718806, 1.6537242369039469, -0.36614505893067506, 0.9867590529186105, 1.7160647077347027, 1.3922119716429728, 0.872766054449014, 0.9892906469633078, -0.1340496379255821, 0.3253205587412653, 0.45496196006342726, 0.13294405552031754, -0.565078226643787, 0.6733798283660846, 0.12503959069430615},
    {1.2090090600431613, 1.3966290295053623, 1.5046787844820302, 0.5733623559767999, 0.2898356219892699, 1.8299142856722663, -0.439496309885144, 1.429740806220368, 0.6737100591969444, 1.04137046824438, -0.5063029179940947, 0.4763696103859866, 0.6172684042075922, 0.20054366050953273, 0.6796963079992425, 1.2132622894911531, 1.6370968564793036, -0.1483234404666562, 0.7155013837853789, -0.11705357932195257, 0.9368184483898808, 1.784445843066185, 1.4862853272452765, -0.3326486586970037, 0.1611784821942136, 0.8112987078231176, 0.6041213691055859, 1.1051602875572644, 0.34832664285047704, 0.4181445428841475, 0.4736489379702298, 0.10623580730701682},
    {1.4018538785451984, 0.9073987457072505, 1.485278865432807, 0.34498054565506386, 0.9060352296295241, 0.5430381551351341, 0.4909951298251676, 0.18447613858870773, 1.3707767999433818, 1.5619816588047861, 0.5917719677583526, 0.796866681980425, 1.0117654941050473, 0.5310440913354137, 1.3083787598693217, 0.4307895288789917, 0.6438269853262956, 0.768274820815432, 0.7970148828067685, 0.7558559695906889, 0.1085336402559221, 0.6459900284557294, 0.842080809055548, 0.6158983660630676, 1.0253566317662621, -0.6737817964896413, 0.23404836528503195, 0.9935063863342294, 0.49062208795229445, -0.7350569975274798, 0.6715801283247573, 1.0746013520784061},
    {0.3011198091698659, 1.255640560840056, 1.4415058939791394, 0.6716314921731714, 0.36457245093392515, 1.5311934542283434, 0.7455112710607097, 0.8052579557121308, 0.43084112610670894, 0.9565882116990143, 0.11557551455829448, 1.6566610698920141, 0.7754314448391731, 0.45264404332686053, 2.1811597333627373, 2.168762563499672, 0.02495266425593691, 0.3200200902089825, 1.528803764327912, 0.6451972501854395, 0.6078322279624148, 0.9495911513835126, 1.2140395611925208, -0.4580031165267606, 1.0732593859095403, 0.8416019632825594, -0.15840096316546473, 1.126760247843756, 0.7977052334975495, -0.30405083675017114, 0.281032152381347, 1.4524914879589816},
    {1.2902527576542697, 1.593240183315542, 0.00035380932634484054, 0.6074545388047569, 0.3024819211570297, 0.885881990346705, -1.0689374795539859, 1.0302533784818628, 1.5615663071292465, 0.2588845562150693, -0.900725077425617, 0.7901050050551601, 0.5106283249792628, -1.0967010550453402, 0.3246511489324585, 0.18703393328535772, -0.006848867377346053, 0.8146463929605481, 1.045007994369939, -0.49972446757403677, 0.5318826422371347, 0.7520770481026484, 0.06919576065587105, -0.5586866958787619, 0.9210230134843144, -0.16999434708257252, 0.5987359747160619, 0.7018638541643134, 0.2572689092589916, 0.4373995282257794, 0.6096118443616423, 1.1517263772469202},
    {0.6736216519286121, 0.36313301329644654, 0.011495335680244757, 1.600942912420353, 1.6903543884608754, 0.2603232219396896, -0.8491808923341266, -0.010335644219099301, 1.0188399341291314, 1.543578831557157, 0.21245905168404142, 1.6676540534237607, 1.9407120824181656, 0.09025442025633071, 0.4222628482168252, 0.8856139609174106, 1.0375281458444214, 1.6866500347084254, 1.0418132023907438, -0.5998555250974509, 0.5845505109995837, 1.950970535551243, 1.217544553119276, 0.0013080274099421133, 1.896407704088869, -0.30309352483975355, -0.4092592384057937, 0.6909299019112821, -0.2740606853834039, 0.8284450246491034, 0.6586326907374686, 0.9402487850930532},
    {0.55911054903565, 1.03911007342596, 1.549403863054074, 1.08090836073858, 0.3138643302925834, 1.8700857988377029, -0.3361681564932026, 1.243767326546246, 1.1033537772709776, 0.9130233485575934, 0.10046127497535275, 0.050441296646939936, 1.4327996129761118, 0.5088930545029081, 1.0863990061443773, 2.0428573689328524, 1.5646185317346712, 0.5358792189849779, 1.7122407533589394, -0.08940593711454818, 0.14908868031680694, 0.14077796310294144, 1.4737944749552512, -0.6310766995564017, 1.551522329921213, -0.5995515065495498, -0.6997237282911116, 1.2781409175085268, -0.12817322115137766, -0.9301817183866089, 0.5477199120458925, 1.6761512259340159},
    {1.86777121621317, 1.7680246525605607, 1.6462073475189383, 0.7837759917958586, 1.8305658998752112, 1.6272104061973842, -0.5796527361209793, 0.732827864791094, 0.5579404987114827, 1.7202597514208757, -0.3203461834806016, 1.8535564003243974, 1.3590110158362658, 0.8735410136839683, 0.6008790093573914, 0.18490846153192836, -0.017768953874136587, 1.4293206510384238, 0.6934951113657245, -0.3593425111379744, -0.26632608614316805, 1.251749704800382, 0.5526861612861697, 0.7328363468060808, 0.20064088763571938, -0.7313779741560219, 0.4586712768467152, 0.28348048980949464, -0.0663524625775797, -0.6011326065019135, 1.5869146555923237, 0.8515813578949194},
    {1.0050304936599095, 1.480872969487632, 0.1789372578539626, 1.7522656878369207, 0.9812527332204856, 0.28922013904576216, -1.1470222341812562, 1.3539763916089478, 0.9515141298796493, 0.27113228557941477, -1.0880108271699123, 0.3115340860847256, 1.809704601423164, -0.09559777687717146, 0.9160189042828485, 1.910905278786396, 1.7820963363552775, 0.7523098418684784, 1.6959165970526502, -0.7679451770862058, 0.5957898151306195, 1.1786252372311496, 1.388448521508787, 0.20599527762370937, 0.9444755187704023, 0.7064598075646213, -0.9953315417456362, 1.35499461057289, 1.1760588305667143, -0.6553331806486973, 0.6289985258553219, 0.345515798096523},
    {0.3692896444945503, -0.11311409771011995, 1.7770878278380182, 1.19446199004326, 1.71006822467434, 1.6955833438973076, 0.09172353125487673, 0.10790798768035163, 1.751506780830788, 0.33564027810615427, -0.36633137612716776, 0.06822042850224218, 0.5188160382882824, -0.5818625971454278, 0.8508094912398091, 0.25519680567411296, 1.6990297637167808, 0.8540980205083621, 1.6778332797014326, 0.9012263605022854, -0.5183614719576238, 1.4713764328590704, 0.49300440617047014, -1.0537751317298312, 0.3260392157122136, 0.38997771584869195, -0.09457031129688177, 1.4332679585572006, -0.5088687460321858, -0.11586532704164769, 1.3855419066556536, 0.7385776115628246},
    {0.7305516715884383, 0.6362619273208099, 1.1566174916069478, 1.2410650497844842, 0.23327915272305808, 1.0481522693923582, 0.7804580248398446, 1.570289669694139, 1.0596873789452954, 0.5193873424314052, -0.46271816795250575, 1.6612630941166053, 1.2007820779928677, -0.8393422343915726, 1.3448385519150878, 1.883619715168118, 0.5350675206613942, 0.8283120219333223, 0.9869098277407948, -0.4417264676327974, 0.5425798301879057, 1.6218622346467033, 0.9103704867302741, 0.5587196539103723, 0.7357370393094532, -0.08019811283892397, -0.3623144089245503, 1.6693953519561264, 1.056093048494368, -0.6856205752443433, 1.8498007040488849, 0.3305676850496336},
    {1.7449548720283068, 0.9008545469886184, 1.3505759308813443, 0.7364723727719402, 1.7188116573144039, 0.6233364977761, 0.49112012392283966, 0.20366308766188557, 0.47120551610962075, 1.8219258292131315, 0.18719684791940838, 1.5875463827497218, 0.47548689124423793, 0.46586188788210003, 1.984674926138532, 0.7093459479823402, 1.3673220114982887, 0.3771297869451769, 0.1404940823781684, 0.370124433699247, -0.7263529516882896, 1.6124539447236645, 0.07585945550954631, 0.7587524095940089, 1.6890953765253995, -1.141486573988664, 0.2254410027525113, 1.923294548525617, 0.7859873031697677, -0.3345286720790741, 1.442374230468387, 1.773503785082311},
    {1.6522151325133487, 0.7880388888055516, 0.30635282855029644, 1.4744687995781542, 1.2489417018925415, 1.2677052143686613, -0.7435887039375588, 0.9332686454388172, 1.3630082148781204, 0.873722711644819, -0.3119686585387852, 0.9022205603606559, 0.7196131871724719, -0.6692775035279455, 0.3859995360682753, 0.3416837717628016, 0.27645144059418975, 0.1971070400681067, 0.1534988475337639, -0.7101374834726121, -0.5594763151164126, 0.205517647479502, 0.6697992457866498, 0.6044869904412364, 1.0582154412986542, 0.29724461712605654, 0.5441364221064265, 0.6512870086414649, -0.4501123281751765, -0.7656074052222195, 0.04137798634551305, 1.4362196598647938},
    {0.7924215314803035, 0.6160584851452058, 1.5020620263451478, 1.2908183389616235, 0.628861176920191, 1.8795701254351636, 0.2949610864800165, 0.6122319117466438, 0.02314972035012707, 0.3136440392929892, -0.4215494677217138, 1.0663464110889078, 1.357478019923044, 0.580329448158923, 1.9810295373889664, 0.31076935094683306, 0.13311101896628436, 1.1443165464334493, 1.8898700926898886, 0.3326948261077695, -0.40606078292741327, 1.7813386944120506, 0.46972116238370515, -0.818244965323626, 0.5253079538451718, -0.42888881882151103, -0.009039518427136867, 1.0795986148444765, -0.042194816205784635, -0.8584537252983645, 1.009689757206811, 0.8597217263195861},
    {0.47877253721407187, 1.468667755466876, 0.36502312203899867, 0.0643962953016157, 0.9902994544579512, 1.2975398931033564, -0.8872393189214106, 0.7044555784714651, 0.5394543640989764, 0.1864324568527465, 0.1952586897381289, 1.2575562579968107, 0.12629798664500874, 0.5719476353683552, 0.35529435182249314, 0.7724004195682661, 0.17002574537963516, -0.10596326355623428, 1.539872057752071, 0.19320503567631658, 0.783049955841292, 0.3113899643275346, 0.7726922624454419, -0.7708867574446073, 1.2264661305801232, 0.5187450827890647, -0.6679218063961017, 0.978674240073961, 0.14995526303775117, -0.5531622730539125, 0.9861956849309744, 1.0552131190024485},
    {0.3490236822253214, 0.6067694306963398, 1.4427475317991678, 1.1105256657958502, 0.47239373081443015, 0.7548177752927274, -0.34711407424992363, 0.20024133016278406, 1.5472772341860386, 0.7194526091580995, -0.7085178391324168, 1.913914069638341, 0.48495319803696874, -0.9438216442858218, 0.22926180559655096, 0.8974151402572015, 1.3392061662425363, 1.4324262052414862, 1.6202152779305576, -0.4985920486627572, -1.012445915960276, 0.43460270580559324, -0.24294141332853442, -0.9620407850373001, 0.7389054360118454, -0.10757058434576416, 0.04857686508626864, 2.0975460620636808, 0.31119269989821874, -0.8879430602092568, 0.7250241726828284, 0.4129627112781856},
    {0.8594789609739715, 1.1092736043744138, 0.9113657040876816, 1.3150116365849829, 1.4070445844100947, 1.0934593701834878, 0.06152842001329452, 0.9703365068187074, 1.3280847595272136, 1.1417414026929038, 0.10914961696596007, 1.3264823083867396, 1.6600527324647527, -1.0401631350513267, 0.32191966833949504, 1.2692218722241329, 1.2274769655248727, 1.0983611629922543, 1.8938534533069302, -0.9340895554686544, -0.6473756650658857, 0.7531000427458298, 0.9151171671259544, -0.6193345718664837, 1.287110936622875, -0.23942255250421968, -0.7232581751718382, 1.594311908401782, -0.1762237129109684, -0.4458956131066854, 1.4172348740488787, 0.09393503255889442},
    {1.6656767461333581, 0.13343317655815254, 1.2447853223724858, 0.9817497943932035, 0.7523084033184138, 0.5126852196120995, 0.06792948242159984, 1.6335180695779294, 0.6607012239730007, 0.33234213120977596, -0.618280385425789, 0.900962324420469, 1.5074683439336674, -0.22204584913722564, 1.6502889432159795, 1.1570641611694912, 1.2959701023970018, 0.6057398163630442, 1.4183960719726159, -0.11007795996439738, -0.828752452804159, 0.7502123585786479, 0.7478759741910069, 0.07199816592862833, 0.4359909506239619, -0.47867737004379823, -0.551290916494822, 2.0172656838777074, 0.3886000467501502, -0.25309747533216925, 0.6799697073423681, 0.09918366189925759}
};

static const float b2[32] = {1.2913588186242844, 1.0559851971446828, 1.1558305824254618, 1.2735791698364338, 1.170112132967653, 1.351343715272771, -0.3115297555397366, 0.8820063129551688, 1.107014212079527, 1.3811752884795, -0.22084551554732565, 1.1850010813497978, 1.2248943677278727, -0.19610614232584017, 1.3016476471460368, 1.4118601543758496, 0.9607305984962546, 0.7749806887642349, 1.0506455380320998, -0.11840842320822564, -0.11516741755534597, 1.18676891399504, 0.697254604971745, -0.2142323726571668, 1.0942783482196095, -0.23175967460233027, -0.055518117905623166, 1.363665596386298, 0.2031239296069054, -0.13115879020923746, 1.28455704452028, 1.000639749797473};

static const float w3[32][16] = {
    {0.31992017702478953, 0.9021835323447609, -0.6566569908564284, 1.50495106003338, 1.472773859458637, 0.5261969647333109, 0.4113458418138951, -0.9210495327450394, 1.0559751549976377, 0.7416367536266645, -0.6783614131695255, -0.13881179875041488, -0.22392614174621647, 2.189768586655103, 0.658276857118027, -0.11379496798095097},
    {-0.7419664322372093, 0.17988342107361832, -0.47983723027609193, 2.197507443384758, 2.0084002105538876, 1.2971991760556587, 0.5162829037260569, -0.9752049288912067, 2.038090793968206, 0.06925499930317576, 0.2907058475084164, -0.4262045320399873, 0.002525314513431715, 0.5542032696292257, -0.3495725671751545, 0.7770646282570709},
    {-0.9565530283762186, -0.7191582133499955, -0.2812785048914394, 1.800114158091698, 0.4655942021727077, 1.060264621304112, 1.4643427285771213, -0.9791136603983849, 0.44814658080215625, -0.22750582800024335, -0.7392794483568187, -0.2724495222517204, -0.8155393820920794, 1.7690441943131023, 0.21026257526218584, 0.2216229757452708},
    {0.15937140565130686, -0.6074126982662633, -0.5931486596174447, 2.1673246098395214, 0.6628431731355805, 0.5791131273076915, 1.837540745043408, 0.23029117464329016, 1.304217526207186, 0.6806268473522683, -0.06045957071287093, -0.7807542577695417, -0.8149384233418501, 2.4377957151126397, 0.4433686463271795, -0.35990911248691737},
    {-0.8275337209466646, 0.5161430000708923, 0.6029541600004505, 2.290119463711276, 1.7722431849201787, 1.4626506031912632, 1.751196921698868, -0.4677072467316815, 2.2457391165333105, 1.4721545609411877, 0.13276572626853697, -0.3666438540080474, 0.12080620001873496, 1.9628958188158163, -0.1984623048568395, 0.7051598064722759},
    {0.3026414730151375, 0.5991241235925785, -0.878648352828092, 1.7249247023161627, 0.8671363052633241, 0.9942563494901062, 1.7084229346850117, -0.2051600724750071, 1.438480873078876, 0.32585481684486234, -0.14620373795087685, -0.6876116624185686, -0.5517613803255419, 2.424739274894006, 0.4216097018886221, -0.05828094375688145},
    {-1.0402983352449862, -0.924187926884981, 0.3770361217897853, 0.35598011232246146, -0.6629326912982987, 0.39111273605745944, -0.16486394667063062, 0.6459051844384339, -0.6141946440455145, 0.9010794904564033, 0.43207710435337743, -0.9649596037424081, -0.34145987613790885, -0.3506650005462791, 0.33584411834301764, 0.6339568523885952},
    {-0.5731624204883289, -0.7873878751161701, 0.4540597729400007, 0.48554867849995953, 0.7503841284244837, 1.707257665828572, 1.0480407766369584, -0.45492431931870214, 1.7084229953139147, 1.4593857209075407, 0.09318349622181611, -0.6078836324423788, -0.0680973045108744, 1.462335024966046, -1.0076202373146323, -0.7585775273568555},
    {-0.3473178248933005, -0.16283292542386327, 0.0539843451412176, 1.9503033648616994, 0.8025751995744401, 2.076389593542566, 1.6537611081430093, -0.9110165812806158, 1.0171652808953837, 1.1352519953054276, -0.19066470422208645, 0.7269703397854704, -0.8058944482685747, 2.345228341616996, 0.11976860645301582, 0.727845010958356},
    {0.786564923239854, -0.49549730368225064, -0.7406839040757575, 1.6491495304931854, 2.2889261683178317, 0.6388541072977921, 1.082118623914735, 0.33306716074087567, 1.6114838918360976, 0.7095114494108847, -0.4656391489042486, 0.7799765574550925, 0.45352828508232645, 2.01316719186601, -1.0469958403103474, -0.9221585917520789},
    {-0.40719675440522546, -0.7044036319918704, -0.12885518479384173, -0.34719360625826784, 0.026060644979206862, -0.007987182113649887, -0.23680338394057635, -0.1998321699457482, 0.6429042792008043, -0.25344437137764847, 0.5738001519995268, 0.30493930736708846, 0.011357083439118435, -0.17560705471101337, -0.014013959716234332, -0.7574799814438684},
    {-0.9633978165974931, -0.5285727506949404, 0.09737929269125532, 1.3908949650795241, 0.9442118274201454, 0.3821492116624825, 1.0278316925108983, 0.5938419035145703, 1.4372014849853285, 0.07777871516071877, 0.6050346451370066, -0.4302589016884879, -0.9002762743432751, 1.2717361890446475, -0.964689863768275, -0.6172727097947052},
    {-0.9022326309174442, -0.03302160625220965, -0.4881653200774284, 2.0627479353176033, 1.5600388714709146, 1.0174425769953426, 1.6888979196592866, -0.22935679007603063, 1.3752113605861467, 0.8118257081083257, 0.3866638914371242, -0.399332339953981, -0.30926687559838856, 1.0075871614290215, -0.8946171746269216, -0.22884364020489498},
    {0.009823816496160853, 0.9429564731175647, -0.06427715436957582, -0.6583987559449489, -0.7777656980758483, -0.35902408116187734, -0.6641423796167147, 0.6296939781476417, 0.6651997926740321, -0.8019396384196665, 0.5056597619596058, 0.8037516147053447, 0.6422709753797051, -0.01986193493400725, -0.1401104413421739, 0.7545996489688404},
    {0.139637575911864, -0.850837848961112, -0.05600148330268856, 0.8787653988539026, 2.162562641952602, 0.9299459751433887, 2.1334911518698787, 0.5380585046011491, 1.1348298358215103, 0.0625597786299582, 0.047783559411682865, 0.006459081859315262, 0.47170718944039014, 2.1233937029013337, -0.7679584120180643, -0.6336315139590044},
    {-0.19888132795766006, 0.7563033593562026, 0.24936107537372357, 1.8096488641689472, 1.28424408542696, 1.7229346192601374, 0.8264987102072052, -0.8230412325053696, 1.4748207090934478, 0.3721401912447774, -1.0493247730871267, 0.3269167341321183, -1.0274210236833363, 1.6688147042324197, -0.6064570629865047, -0.24334438137670547},
    {0.2833845553595591, -0.37151628879921184, 0.4274852685594858, 0.7783820201015688, 1.3749727908570717, 0.5866408156868013, 2.029939843029405, -0.8840691990501791, 1.1917279372457839, 1.0297953810306828, 0.3491773014852789, -0.7368258091498655, 0.019134057168519906, 2.0038397143113977, 0.5867657565483358, 0.6805524669230897},
    {0.8450640980603532, -0.875547810355354, -0.6546532191082912, 0.5987463420135445, 0.8170396197183203, 0.509576361270212, 1.7229953307744064, -0.8493459783868553, 0.5083820435646194, 1.2889053097568213, -0.8458781300842426, -0.3598902548201953, -0.4974210859082681, 1.6957122476685895, -0.4397053216056536, 0.054301657183926},
    {0.29690406976864, 0.8631012742856274, -0.3918777821695208, 1.744070531523451, 2.0616204379409884, 1.447660753875928, 0.948164532382489, 0.36060435487750453, 0.3640958474384477, -0.06352620101338055, -0.676836901371301, 0.81055173007211, 0.735845436362157, 1.7032435043842395, 0.5733070198538731, 0.04238019807593942},
    {-0.5968088177166664, 0.2614166547635216, 0.5352855988003123, -0.08124636263093754, 0.5844021391937937, -0.5308252736474205, -0.8054641300697323, 0.03678656248240694, -0.5330334979528429, 0.49988666537046145, 0.35079687249120484, 0.055359852244980384, -0.9243610547379573, 0.09821627440646193, 0.5933610041679342, -0.8257571666076164},
    {-1.0502088240335408, -0.3995546186123494, -0.9509676702410491, -0.6289948713986243, -0.3479849795106513, 0.2100163971527887, 0.2046543562061644, -0.7903506208320042, 0.7703078446315721, 0.38628906538510477, -0.5705808653367621, -0.48233560378641643, 0.07542085330064127, 0.06622382000977158, 0.007118757139930543, 0.2032364826976526},
    {-0.6544843181081902, 0.2722015171803227, 0.6643974240937526, 1.1231016282584858, 1.9962174456375583, 0.5969510490741977, 1.507173919036384, -0.10595029103807393, 1.6446356984229076, 1.3728498723391769, -0.9909226527295336, 0.8116532187724251, -0.016863819776356603, 1.0317268442668857, 0.41161733240772513, -0.2507891945375953},
    {-0.496902711678298, -0.005863848896458367, -0.31178199958525354, 1.3176138528603172, 0.9833951510299618, 0.8656290066737263, 1.831323454793877, 0.850182874767742, 1.1258136349082328, 1.538887048639883, -0.21139872891678718, 0.8081254433143811, 0.7041828195639294, 0.5629980040181084, -0.786641434280033, 0.37120943196010864},
    {-0.8028376899612105, -0.36382150669225677, -0.46367516340034737, -0.27105809603670594, -0.737981022506592, 0.03635919335613234, -0.360390244904824, 0.7272527048896426, 0.23234213360044836, -0.009891864005209163, -0.7874868999901085, -0.8744417463017505, 0.5449863829308188, -0.10357106963015762, 0.5860133285293994, -0.14909599153121128},
    {-0.2664593146640048, -0.37511847921817804, 0.5919832515064546, 1.9543202480027955, 1.2903807609165927, 1.5905103352149004, 1.9264861130650939, -0.09665173786634719, 0.9404380903470162, 0.4269891506572718, -0.1819773958076989, 0.8750267783431251, -0.8566023752050183, 1.0448645445755964, 0.15874189274997286, -0.24452522875542126},
    {-0.22798789424889723, 0.9055765030677834, -0.37414375910672404, -0.20530639647615734, 0.4097908332538942, -0.8956776180191077, -0.11515283268403174, 0.07133869875388667, -0.8795408186400194, 0.2592463665930821, 0.5286095853146384, 0.051662634285744184, 0.1681338403954352, -0.5990675177768124, -0.7912334749166887, 0.19380968823632866},
    {0.031693565339823926, -0.787462340877598, 0.6903789122518171, -0.046299271270696656, 0.5005533123045045, 0.13049138999759213, 0.3854783274852414, 0.2909211278211936, 1.104374012061378, -0.5147519564193911, -0.008370351079611477, 0.09478195112665957, -0.489683435064773, 0.22918121942705594, -0.4688014986388425, 0.7919398306086304},
    {-0.0772589939521052, -0.923652608542336, -0.4975164029485445, 2.108856012882675, 1.8030047655543502, 1.8960557061149437, 1.696344996182709, -0.6159348914289767, 2.101839528088023, 1.2986706551469342, -0.8005203870981072, -0.21087458101119883, 0.19814718229522602, 2.0317651010932933, -0.8068014486304255, 0.0945717397843854},
    {-0.45621277988742726, 0.7020206786881897, 0.6784752655215129, 1.1297086230181725, 0.1464680122251674, 0.34532788565631656, 0.8246247244715856, 0.1105371185319695, 0.5393895691633479, 0.7541942576706925, 0.018235261581338518, -0.5720785745169831, -0.37770263361471423, -0.03275659613109274, -0.7221931664072908, 0.6146237872605891},
    {0.4038391372143719, -0.004302611037406381, 0.757692906476592, -0.6624235219089546, 0.15382625606835446, 0.5026722000693749, 0.7914864837607368, 0.07603094130381736, 0.35455947909058416, -0.5976200848752072, -0.09039481659703581, -0.6399024937602515, 0.48372724244610765, -0.7723841267289915, 0.6997034863965106, -0.28467762502182165},
    {-0.5312477112161171, -0.780609730780822, -0.6985194959060139, 2.3239456641525513, 1.3494920350656043, 1.8746604262571696, 1.285078887082285, -0.8546523265477426, 1.8836006431235524, -0.06668525025434018, 0.29843797633848584, -0.7128383842107606, 0.5407386448744138, 2.081995307504715, -0.9201976387944149, -0.07878585601953647},
    {0.8571663370680709, -0.5473969119961196, -0.17155040154763332, 1.439166829942664, 1.768249603193918, 1.7863541403025973, 0.475046608479976, -0.6429519766419026, 1.0892811064594041, 0.7980545972705537, 0.37141469984162434, -0.6696666825642266, 0.2731883751431906, 1.8764052567341953, -0.5997388742031313, 0.24772413272736327}
};

static const float b3[16] = {-0.16619468720239786, 0.026159371032338594, -0.1264565248783146, 0.8463552387709796, 1.032714963589325, 0.5251244936000815, 0.6471757574371826, -0.13500867758837581, 0.746818438993277, 0.3786594321675212, -0.18120867254753165, -0.06312960040812138, -0.1462580887194277, 0.8697301672012803, -0.14368444303112152, -0.20186773611794506};

static const float w4[16][12] = {
    {0.4514722868630187, 0.8575397492660916, -0.687714869221529, 0.3962374281561487, 0.6453052240828411, 0.7405561347975976, 0.7195052857098758, -0.6147622911738501, 0.7170105623819196, 0.09799952243452525, 0.5257631666750159, 0.6992532362967268},
    {0.6819790174973772, 0.11012169117435622, -0.8263608247074368, -0.8834459360280799, 0.8347301624062556, -0.5138027541929151, -0.4540978425718715, -0.6873119719067708, -0.03786314805613575, -0.713568991967287, 0.02565435798534909, -0.14733083319639584},
    {0.321845274016841, -0.16042970475844112, 0.08535615975431153, -1.11284396464758, -1.0362016083694452, 0.6423744447457608, 0.41519625818660794, 0.4113654832451091, 0.7429993121833712, -0.7185088228529656, 0.38257366563548895, -0.991984546201475},
    {-1.7645088173046144, -1.2191073885634742, -1.160634860621328, -1.6867421098989002, -1.8505265463740703, -0.6326361470325909, -1.125029388679515, -0.6344400520593952, -1.7229786917971006, -0.2651951482671554, -0.6871400590632447, -1.89735275432444},
    {-1.318245867468759, -0.774948636506264, -1.0613775324609005, -1.5507389803939826, -0.09495176010109106, -1.1355581922997726, -1.6279889859114922, -1.8812038126856405, -0.8972193793620171, -0.8246044526161651, -0.8435207496259821, -0.4857528784562115},
    {-1.1973007014646897, -0.9302382285978302, -1.3243245361851936, -0.9113600445135847, -0.009245273160153814, -0.2713555814244571, -0.40551042877793386, -0.7765725888670099, -1.2532534729118838, -1.732587622863052, -1.0101074865951292, -0.5194164762422318},
    {-1.0359327545190349, -0.8507044544442959, -0.9300485832373445, -0.1658136530674601, -1.0402213299222531, -1.1807905327236514, -1.2379549034832529, -0.723153506592924, -1.7862214155990992, -0.6782509144873907, -0.6242050308334063, -1.697999986636437},
    {0.7233797071155793, -0.7456769286050762, -0.25501889633386454, -0.8152797039457338, -0.7389204794843162, -0.3393485439577318, -0.07436167291148964, 0.4243903430755194, -0.28724174086194537, -0.41608347257503026, 0.00140095585981845, 0.23920974618289317},
    {-0.41680170845757514, -0.7141641558933425, -1.00136757336904, -0.6792208477974734, -1.697560660113191, -1.7068713116353031, 0.001570785986769494, -1.5360865850751046, -0.7543359204990199, -1.779263510084829, -1.5377570015716053, -0.6314505695020557},
    {-0.5959856451241258, -0.9056293363531066, -0.23693725107099634, -1.1324897550546413, -0.15656666163023458, -0.6467058005606008, -0.5281645841770533, -0.05788653613721159, -0.24331709200470408, -0.46225579352812235, -0.9120517386583509, -1.461594893415577},
    {-0.3831977399767499, -0.381325901001749, 0.6955217531249703, 0.5653979296390347, 0.2697271524315183, -0.654979229470284, 0.5945049307501941, 0.5813237370845926, 0.0737138599681588, -0.28320347180052624, 0.45876695779449317, -0.1951436075109622},
    {0.09041357394696482, 0.21793946264004707, 0.07987651721116713, -0.671675615617225, -0.4236624069424461, 0.36664523701554114, -0.6467241763296452, -0.9696783627156833, 0.09176935109987351, -0.2800281671321323, 0.39034147527825636, -0.06040882616807015},
    {-0.006442806220112212, -1.1093404270766782, 0.8973589757132266, -0.9436359493406363, -0.41164231457951556, 0.6559682077384273, 0.4539631136802031, 0.24256965881676118, -0.41093771528820416, 0.13296106660939513, 0.5507580179653809, -0.046750582417453466},
    {-0.6035944438073757, -1.5627990470257274, -1.1296910967664155, -1.034420449937965, -1.4400358650025409, -1.334565779168493, -1.7579710600800564, -1.0907503765139295, -0.2141634574366404, -1.4002196858379818, -1.4993433311734794, -0.6030213127371946},
    {0.037923101265275615, 0.220000040993237, 0.7067524844051251, 0.7495262600970715, -0.33802959231418417, -0.378920203168492, -0.711184813521079, 0.22278925025762086, -0.38199821553189295, 0.3518675722704938, 0.7445006275307956, 0.4496284730406017},
    {0.8662973484438473, 0.4710872473751337, -0.699916831564802, -0.10184909595890768, -0.09930633982824155, 0.8416224911737911, -0.3486152405519397, -0.3588278984838129, 0.6809328361708481, -0.3020185089518946, 0.5426721876714878, 0.34828041897583656}
};

static const float b4[12] = {-0.463668640684439, -0.6100274683222279, -0.46507860912235693, -0.5490185445929915, -0.6264259684641872, -0.4817372563504817, -0.4944235625646712, -0.571506757781096, -0.4539531880672542, -0.5460971936022921, -0.5067795658256724, -0.504779048121224};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
