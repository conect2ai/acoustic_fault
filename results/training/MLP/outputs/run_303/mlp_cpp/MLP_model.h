#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.4144586599180595, 2.153227764543224, 1.6782571983947465, 0.7588279510584335, 2.8169395109172206, 3.570839392997706, 4.444933946997335, 1.4787120160384433, -0.5311678991666907, 6.708436279759041, 1.3995152694661335, 1.4298367894508304, 2.6437582652108134, 0.22960449026929963, 0.6459804560843736, -1.6440954748337364},
    {1.8631094466527434, 0.5458788793415291, 0.2173857735658545, 3.2545003513043977, 2.0888502900004324, 1.9872202732850754, 0.06825392439766613, -0.3990155099584637, -1.2443204687804865, 4.441359472377771, -1.2981617332669828, 0.4770000605537222, 1.7004921578684153, 4.104542452410406, 0.812617273298578, -1.4793886946652437},
    {0.7664810385316995, 3.5257847541914256, -3.970781134510029, -1.6258630807106877, 2.76701502248479, 4.327119128745943, -0.22601369952429337, -1.919792770588906, -4.860132980727682, 3.7515394565554283, -1.3934691980131806, -2.8487380673239304, -1.1100138290861101, 1.626937695089425, -4.085512815256007, -2.6443956964758817},
    {-0.05144961736760937, 3.830162521528766, -3.3552064563389696, -2.8566246683333048, 2.2741945532377827, 2.6593637243550585, 2.8565014296802795, -3.79170695022944, -3.2806247145675895, 3.765218196565121, -1.7790185693473646, -3.3602508396185233, -0.5340118318944586, 2.2844639383493845, 0.23903187797407718, -4.305750851894798},
    {-0.91733774294029, 3.5119377454673986, -2.99172673131411, -0.9179808865282162, 0.8816460754362678, 0.10728522268147007, 1.3287796637736962, -4.936442187948685, -6.647630557651, 3.758907573006083, -0.19686512101925213, -5.604964869730211, -2.5877677972500077, 1.5163398162149342, -1.3907090346467326, -3.2802089269214716},
    {-2.1406750407540263, 1.4990160624416926, -2.586140229879329, -3.241260922426607, -0.17507782875009828, -1.379201409136019, -0.06662126181438498, -3.695082893109625, -7.014281414852639, 1.890598504387802, -1.623406863353942, -4.866194800297717, -2.8246364874859196, -0.02062688729894205, -2.091207102374267, -4.835516677092203},
    {-1.145004095504242, 1.2251057422910854, -2.5774694434863887, -2.0104184920835078, 1.4548316907311643, -0.5960097328633078, -0.41965373119364807, -3.741916936063539, -2.7600821654453167, 3.5514398923839896, -1.3485526525602314, -2.865584154854337, -1.8012905544241897, 0.34327079941096555, -1.2805687590324786, -3.4163068957001053},
    {-1.6735921044308328, -0.7967968247086198, -3.656433014968267, -3.0477608463486003, -0.6690933617605521, -0.08485370155608167, 0.774525375953998, -3.131515702684686, -5.5377321659238525, 1.7156477308056644, -3.690500201415714, -4.599436168490051, -1.771565853399447, -0.3677552854282437, -2.408838801111071, -4.025188333508083},
    {-0.9209007012113348, 0.04844441397662995, -5.904030263955367, -2.7113015196385044, 0.045726142887632354, -1.4195144727183844, 2.1405569724595828, -4.790886484229837, -6.050916122374434, 1.9431428531923296, -4.549958218716996, -4.667161220531551, -2.241902355890578, -2.1551077325370493, -3.9048430195532235, -3.3982020562752604},
    {-1.3840668449434332, 0.9172879709625482, -1.5745455855614745, 0.7500769664678639, -0.5297009685340323, -0.5215868846573146, -0.24320698862447662, -4.741116013520837, -6.524219822599696, 1.2240869259869258, -2.300777573250037, -2.967061996881041, -1.4136068383004379, 1.0178951453679068, -2.460952343875523, -2.9079518467867422},
    {-0.337587038342332, 1.3311348152414846, -3.6653949752474118, 1.1295865740209747, 2.151257167809633, -0.3276392770957278, 2.7183150263582148, -2.2435849928746094, -2.265761357686479, 2.799253199222191, -3.336857291360148, -2.219660829335177, -0.030324621519684916, -0.3998705248275191, -0.6441391354655825, -3.799607171642714},
    {0.40237891514844937, 1.547263986696584, -2.9111145560246996, -0.7779702764109347, 0.5192922503678362, -2.4624061621985436, 0.4600581374569581, -4.538562639683455, -4.337604311956638, 1.2553985937633274, -2.608718827628344, -3.8547781996309447, -2.1466208746374336, -0.27512331042978067, -0.960365132731951, -4.456707332049671},
    {-0.5073856252046602, 0.8913776418842874, -3.344410762160194, -1.9765255549166292, 0.9177051091593998, 0.7071179469637693, 0.24981886986788993, -6.317550307229295, -6.875942078760374, 1.3221504230984231, -1.6305011596906676, -3.0162400883829847, -3.3151036353956487, -0.14652360646329862, -3.864537860019627, -5.523311461715569},
    {0.5218131724275976, -0.18781497396141333, -4.56926113212109, -3.262100316592509, -1.734076920939687, -1.453555331218903, -0.22208143208115005, -4.8210068801094765, -7.540461616865789, 0.1729733705201638, -4.642716358286872, -3.8423015521464077, -3.5974296565091706, -0.6378514754563164, -2.13331340439955, -4.222986029560366},
    {-2.788931152000779, -0.10969986713848448, -4.960717329016353, -3.672629939335387, -0.6185469987001718, 0.5683228664196642, 0.9392733015378335, -3.6559162309689044, -6.588634090648164, 0.4688290062363255, -5.0975014777920356, -4.502615944762423, -3.699584831335828, -0.3778994507855621, -2.370095729157255, -4.982221283326414},
    {-1.8757399134296868, 0.8644639044479437, -5.979621381176235, -4.3988291874640995, -0.9867808878872374, -0.39298631587173183, 0.296282380390878, -6.13788608329316, -6.686893385216521, 1.4330584186716782, -2.9675955720801674, -4.8175552262984365, -3.211443440326183, 0.42504600286360744, -2.0731790076699506, -5.2970902194394975},
    {0.10950834303166465, 2.233098197666372, -3.2084220135789203, -2.6685595054800797, 0.9111030595895661, -0.2389009159091353, -0.4352422339525898, -6.520928358837969, -6.886539965454756, 3.20422207004849, -3.092301267078486, -5.28374882623648, -3.495328254004898, 1.1851541763332387, -1.4458542890130903, -6.197967229953225},
    {1.4987085700810896, -0.8474330750584327, -5.198546071785016, -3.9327870233230064, -1.6901498984054037, 0.701724550441213, 1.7882223195800215, -5.097920214374424, -7.439803009447779, 2.3739803868096025, -3.010521342275537, -5.819272185598383, -4.383491119402694, 1.3362236823971858, -1.2303208831742813, -3.0251633583012874},
    {-0.770164082542085, 0.20539293555166965, -2.851448661035426, -2.2882247804897142, 0.2389036912187475, 2.219032172049645, 1.8713762586767808, -2.928566413448941, -6.854628981662088, 2.406549928463657, -3.128808367581828, -4.374506430091845, -2.0454856833629953, 0.32009855340932436, -1.374733929222126, -3.4065813451241396},
    {1.258512297530635, 2.795036260058812, -3.1147514928503024, -1.4838012826453797, -0.8478851881349042, 0.5461210651138606, 3.6540713134616376, -4.728257153134873, -5.073238549698225, 4.213803145465811, -3.279315618309727, -4.256983607208477, -3.1460995585453895, 0.8369213134130692, -1.4628173145287637, -3.787717689251192},
    {-0.16568049696851794, 0.7902456930118763, -3.6868893292460703, -0.5227525866642573, 1.0630544763794019, 0.6544791012796959, 2.113511091258279, -2.2680324361252104, -3.5937619344922798, 3.682835728525411, -1.8702692140165256, -3.153415875751578, -1.3551783961955592, 0.046828039956593646, -0.5443753088830063, -7.040444971236177},
    {2.1016501336123703, 3.5656832626158708, -2.6558660226337145, -0.4973098156039002, 1.2807307959471599, 2.491594561387144, 2.1272943660272663, -2.3014525235551817, -3.0755406802927387, 5.9989959995838, -1.3918023047567116, -3.7603325479877965, -1.2046007778567378, 1.9031938035087552, -0.298268638362948, -1.8245895036215176},
    {2.134647689829489, 0.5253942605599772, 0.04890133958638084, -1.0836690265089355, 1.4573627132517355, 1.2520631555881048, 2.737125663691351, -1.2354168207538883, -4.512409577163597, 6.515877501551371, -1.772207260693899, -2.5583231812523892, -0.6951513917162625, 1.6032267227431873, -1.8274098015670872, -3.494212819965862},
    {1.3148921255026458, 3.2287078282333086, -3.976788082046585, -2.279473254357953, -0.006389784134201634, 2.1981037300883974, 1.6303850362971954, -3.6738551347760833, -4.933475246159814, 2.840721752724308, -2.2855111964650185, -3.540092207986112, -2.139129958835392, 0.8633375928718552, -3.055849845750957, -3.564505951706626},
    {0.8349426896387049, 1.3836887851795796, -3.788803727577601, -2.733784750305379, -0.4907325989738765, 1.9206747064644378, 3.4490991107740623, -2.3094933224740615, -2.0478043360803326, 5.384135504316998, -2.2587397563124596, -3.018630265229384, -0.23751701520335824, 0.8740962558875682, -4.31799461899542, -3.6883420685831334},
    {-0.0004907608295746163, 0.3127103689291121, -2.080312793083844, -2.1394075885297736, 1.0439315858174913, 1.205136045925181, 1.2760896147014118, -4.15201712873492, -5.256238245100157, 5.545023904593034, -3.0840951045225258, -3.6842262627767464, -2.410362768460561, -0.7190311901430261, 0.1271598236337927, -1.7458204536810544},
    {0.017159711115489962, 1.8027697968659215, -2.7907833852082664, -1.8479230472871992, 1.2240951423690167, 2.0387767178031577, -0.4956975314926674, -4.476347994004577, -4.6847468073346485, 6.113638947257929, -2.280946156157586, -2.1473212859997415, -2.305272828035371, 3.5221414447537116, -2.5775047147620422, -4.153075831242934},
    {0.07321990692844142, 2.7991947593745135, -3.186838479026031, -2.27852744950597, 0.9441704443075072, 3.040977674233367, 3.0142695843564624, -3.5936254087608974, -5.545475339331033, 3.6864975805317717, -2.3229495358103383, -3.6749039910676755, -2.0926199049236685, 1.264567164000686, -0.9692808321774242, -3.4226441557276557},
    {1.107936695607854, 2.1376217217929327, -1.7230744016481419, -1.6758283790017643, 2.8001189561651936, 1.5456879869477662, 0.07423920271448887, -3.5252197843579305, -3.155870441768411, 4.2377474443256835, -0.7421302218752004, -2.954200617930188, -1.510698984804602, 1.4517345870000187, -3.204969231204137, -2.9461082845386604},
    {0.2603705009127978, 2.838470893995692, -0.5357462428756318, 0.9217909365156071, 1.2454672717879778, 1.8421768770746263, 2.4018390224041672, -1.7726747812881762, -3.4538760197971663, 6.038588826054118, -0.8876366739586576, -0.6708920734920137, -1.6256357261759977, 0.8174917094214756, -2.9914698914406195, -2.8398509771355123},
    {2.122473806584115, -2.463952632955172, -0.9874815610753743, -0.32462999063964215, -0.4708358685115681, 1.2729194452279338, 0.7166982027312035, 1.467714176000928, 1.5118239614989115, 0.8482421570362186, -1.0746646691543953, 0.36641832922426887, -2.0943203643566144, -1.1844127143091097, 0.4219505950109725, -1.4926130040578303},
    {-1.759862124103769, -0.27359000650469556, -1.162260506445007, -0.6467409443697187, 1.3743451782928118, -0.7563009510801614, 3.297046618879686, 0.08005332166531218, -2.392276596753844, 1.1011071030993007, -1.1161673609743126, -0.6392900185998808, -0.6247283856194703, 0.5226308761958949, -3.5638926691506154, -3.112920889852061},
    {-2.4379279725572105, -3.847559215628425, -3.4553292462518064, -6.121759190217939, -3.4809466014058885, -6.2791938886297975, 0.8390644970313359, -1.4812174189190777, -5.214882761885706, -1.6935805324861584, -2.5476211210487807, -1.7740108603277924, -4.00253239457639, -3.4409754600353573, -3.4828178670292402, -1.4358433113635785},
    {-0.4603785137673198, -3.5935444758413317, -0.5846884286787722, -1.8839370756771432, -3.664946976542364, -2.6976366611113045, -0.4066310060760701, -1.7212119494965226, 0.26138742303000173, -2.294095373114051, -1.2679949229905003, -0.6463651849641987, -1.706723020560992, -2.986257119611054, -0.45840837403652296, -3.3191933468888957},
    {-3.3123953430119233, -2.1330110763167007, 0.23330297009042242, -3.9051324993809127, -1.4982505866133997, -1.9506482534936593, 1.8948817924820733, -0.38743788608742336, -3.8488764045116652, -1.4246811120710583, -0.6513827316848769, -2.247458688799148, -2.467097982112522, -2.220019739933939, -0.90875149378816, -2.562655288243239},
    {-1.294972451777925, -0.5648457597108512, -2.5959494796988385, -1.9699464905635913, -1.3570234592748087, -0.40649761986506255, -1.5606640498648443, -2.3867576854311374, -2.122100882393456, -0.5464508506016121, -0.6372486409512399, -0.757184089354348, -2.041137594077774, 0.5338812455609669, -2.0926224139415432, -3.553765245268435},
    {-2.2821062130847305, -1.4848025339768085, -1.6986206844077232, -1.2738456651205157, -2.3602791836194075, -2.870738569049365, -1.4528144308658713, 0.10567985165530427, -3.1487914372767123, -2.3406086729629103, 0.015660036788760365, -1.1414317175810575, -2.8684063088464833, -2.092749573769642, -2.639362753588868, -0.9037463591698968},
    {-0.1820059694080152, -2.6320651252461347, -3.0380577580741814, -1.583064060760375, -1.1522970807467745, -3.558798987956507, -0.8604175451632659, -1.2486426583457841, -4.902430400710479, -1.8362502935328933, 0.7272769015825862, -3.2601299471826692, -4.603871774138691, -2.631152624560791, -1.7391373460617998, -3.1155487843676015},
    {-1.298901225291875, -1.5072847889285819, -2.7513849380125626, -3.2005862326513914, -0.4659587601676763, -1.5335506245592887, 0.13159429373450657, -2.8277115880070642, -2.8493115880005884, -3.671426450563791, -2.3976080353093274, -1.8466593173207184, -2.1676624371437896, -1.7126463353017296, -3.272394032539209, -3.7184110917339375},
    {-3.5337858900504684, -1.791576226541102, -1.882815412593213, -3.951575481261501, -0.49115401401258846, 0.7313538079884666, -0.2309263180662734, 0.7870171496384997, -1.319253418709124, -1.546838294947303, 0.3580569453253998, -2.809656669827231, -3.460412579926298, -1.4091482008904173, -4.472630894682128, -2.3118295869874865},
    {-0.6298058445267174, -2.1316520118345412, -1.5259960009955822, -3.627806816483605, -0.8752553570232369, -0.12313551286166463, -1.5470575450226247, -0.23827043351392402, 0.39278787643163604, -1.5312532392530616, 0.6594187751561084, -0.08043638580515217, -2.5722633766709446, -2.5124874711536695, 0.2135158233098988, 1.9930333672199987},
    {-1.5497983912742972, -2.7286252121278918, -2.508502099201386, -2.3951333961560533, -2.418753677568283, 0.06126633160708631, -0.3450950616753044, -3.5262575013484754, -4.430486216480954, -0.48358249164186967, -2.3758895681512557, -1.0217507530375847, -4.33561810374123, -2.1020279088420124, -0.7444788906753685, -1.4732404393836138},
    {-2.1289262286421495, -2.9409733069077166, -2.3685774283303758, -2.1249007658581136, -1.708406345979668, -1.534432425851947, -0.886643644043687, -2.9339902604649253, -3.2753100339007943, -1.8407776410346484, -2.9931766981878596, -2.5096286832470893, -2.978181648613543, -2.7754524859719893, -2.7076177642713755, -3.8314411953896053},
    {-1.2197018101708323, -1.316800860370593, -1.666056678443808, -3.628595621263882, -2.6340837975356792, -1.3113558218894439, 0.24727230906165526, -1.2840960520208842, -2.065906864323504, -0.7474264248853202, -2.4740981310362016, -0.9544358374652735, -4.761767811836015, -0.1412096123627473, -2.8923315931770945, -0.62402949902021},
    {-2.8450165989800227, 0.04053385024184661, -2.9438080465819727, -4.356561606455193, -1.9881556408170145, -2.2975749099903964, 0.0731609436924576, -2.1772963270113115, -4.1154791101329495, -0.8332979269472812, -2.4549004042809504, -1.0291320703573732, -4.237303588868403, -0.8484706188895672, -1.2490892668050766, -2.023312982797713},
    {-2.0524170907420802, -1.9426896050781672, -2.6742908685788565, -3.3489202150857724, -0.23525877756484948, -1.0930235699158926, -1.4166811555492165, -2.6182993732761397, -1.155408750642256, -1.160629082448494, -2.539359821278247, -2.53325496095417, -4.602921792031366, -2.558980526571095, -2.4117969623744115, -1.521678784223197},
    {-2.558026122392721, -1.9956233995035129, -0.8948114746511016, -2.8863225302055318, -2.418279004983363, -2.3610435741307465, -0.6052757980746268, -1.8080833309646718, -2.7284875881948882, -2.508822039358982, -2.5978638381731205, -3.6880453247304783, -4.91124262119285, -2.685737813461113, -2.5686027223485786, -2.5925043729558523},
    {-1.8208210967985998, -2.9560732357412927, -1.726949037261532, -3.7778559395077527, -2.7518998330278106, -2.1546227766487904, -0.21072327194714935, -5.2482837180980155, -5.966618172100346, -3.1193093443051043, -3.6507712353729285, -2.578238630948785, -1.688881147194883, -2.4882143146414455, -3.530751847487522, -4.528155433473571},
    {-3.9750501271263774, -1.8797737214249484, -3.9062044736934554, -4.303620442520312, -4.567609749637638, -1.619477329968199, 0.11812643833054248, -3.8590114430385882, -5.538791474409991, -3.2788638590893546, -4.168585222146254, -4.231033043165669, -4.279755078898022, -1.0294280758905314, -1.6399761253697318, -1.4067890293313847},
    {-4.845251395981064, -2.447876434902511, -3.667248965194409, -3.4065805371367426, -2.0408150393805577, -3.627789723652359, -1.220888180565595, -2.129967496221721, -2.8160094035851633, -1.2281885586252348, -1.237156447371774, -2.0156431723776698, -5.466265876883181, -1.0510094479213123, -3.221747628871116, -1.5695184905187831},
    {-3.8206088692430336, -0.9686146827282108, -1.7960162591722928, -4.116087843947925, -1.8489530521717867, -2.8373162405648173, 0.9021941598923153, -0.8583993142946451, -1.4656595699106123, -2.788168597139134, 0.03718710323682556, 0.2278020001294107, -3.4330332185689008, -3.0648247038667917, -2.5185068155638453, -2.266276570370941},
    {-1.8786895749007382, -1.1668657697413027, -2.0381886538009235, -3.6062218443105625, -0.4398607375145174, 1.6841327042273722, 1.334131367502699, -0.028326625831523695, -3.1005808791097973, -0.3588870443801803, -0.7605272207207169, -2.786674369825448, -4.066360675840523, 0.34232053267466633, -1.5957121296904957, -1.0523763150000074},
    {-1.6746043256334553, -0.4938909860224633, -1.7427304276305648, -4.1729926082166955, 0.588452471261533, 2.94982873137253, 2.5797947601952758, -0.7187572385071833, -1.5411448029931434, 0.41810799691743916, 1.0154355038413827, 0.5906061237473558, -3.7783229211484666, -0.9896205878682155, -1.7988624882420896, -1.9981454214077512},
    {-1.7108954629787785, -2.0841494333547246, -2.1951308650203774, -4.862304671738929, -2.376097679259229, -2.4747359806863614, -0.10909672306229765, -3.069697401656925, -3.1627673246543844, -3.630457436412153, 0.4836120371147606, -2.4586361894115942, -5.926270973290545, -1.938082024808769, -2.597315143500439, -3.2876568743615913},
    {-3.8522661569267136, -1.120750396137701, -4.125865916301705, -3.4047838676399507, -3.9827189622842694, -2.490638896993517, 0.07128199804598882, -4.601424029542616, -6.733737227780917, -2.894019729465161, -1.4157924850791501, -1.5389772036234677, -5.402565905124499, -3.3640901582045313, -1.7932750574383542, -2.5636338533337053},
    {-4.769777353163715, -0.7415187882920103, -3.6278806281930502, -4.467502040790079, 0.0754988617298998, -1.6041705548028218, 1.0029019906249825, -2.6265823369511847, -3.8533992182164716, 1.348564377057019, -0.6567010326811683, -2.0264274005928082, -3.0944156729274663, -1.1999613647751792, -1.9488172934176777, -1.2366782518246695},
    {-4.2422944835026355, -0.6197213386398891, -3.168012799828167, -4.122608343345365, -1.3827160391404307, -0.21529856460236477, 2.6164258880020164, -0.8226947447818386, -2.139016420497371, 2.927952304522236, -2.6733359381679476, -1.3452937633706963, -5.056292670539855, -2.267154907272719, -1.720148721050371, -1.5428534419882327},
    {-4.8477396348759285, -4.505153441508181, -2.044300577489434, -3.864040417934403, -4.543766028962832, -2.7794369418569955, 1.513754038921091, -4.069872148248224, -4.548628577982403, -0.2766049792811224, -3.5186233359604606, -1.2995943801221126, -4.901268685464427, -3.128342583763589, -3.0821434309940807, -4.6688260635403545},
    {-3.1976068975689715, -1.6891008666189502, -2.4494955907487097, -5.970691276056576, -3.1126390863982967, -1.7854649349599196, 0.841251595668136, -1.9654167781053289, -4.073537216410039, -0.8915536010772289, -3.2320303316485015, -1.8791133704968173, -4.991228099898797, -1.945457142152196, -1.244607736454253, -2.2976066343864807},
    {-3.2853262112021473, -1.099770226956265, -1.1019182991064982, -4.069631068738059, -2.711471768974267, 2.890954783677929, 2.6778016901653423, -0.8555094536797422, -3.165500870837012, -0.592920189537474, -1.6174371526363893, -2.5337008849708447, -4.6550016842543185, -0.8699864082105386, -4.039579620546762, -1.773024022529469},
    {1.2618351896156732, 1.9964602000081324, 0.32746599627213774, -0.004546129094695127, 1.770005212399999, -0.3350425155705605, -0.6395488311927703, -0.9574842417357593, -1.6779057208628367, 1.054663599264247, -3.213427118010578, -2.8658261451930507, 1.4405348329646785, 0.7247997236988648, -2.8155355725397113, -4.034751066457855},
    {0.947975742021587, 2.696869136477886, -0.5240657360523573, 0.4256957271952274, 1.1508198467545339, 1.5482892788513438, -1.1415302986532276, -0.47943600959914023, 0.6617664616731107, -0.4850039487436242, -1.7959275729930457, -0.562012761000073, 1.1869433530756979, 2.96873642275699, -1.0118159056280338, -2.5853366037979746},
    {2.0715344008436882, 2.4551298728170745, 0.035385028935555465, 2.8589212479670554, 4.198769137793, 1.2691005984099317, 0.9968922713146323, -2.599427463167595, 1.3174563577953158, 0.4515438738147701, -3.2388832345812726, -1.179935580580787, 0.12140784668354779, 3.4143109468817094, -1.7366867550328597, -2.4505506872140157},
    {0.030518520251135696, 2.9917844092320673, 1.8831106707033096, 0.7522990716524172, 3.781449813391158, 2.4422093760811747, -0.5368202266339196, -0.440742633912527, 0.03752086777557731, 0.9071743339700719, -1.6842783185759795, -1.745350671924641, 1.7983252103445104, 3.5783371595710896, -2.783389570563301, -1.4957059990679074},
    {-1.421814586492557, 6.07604388726902, 1.816483335659503, 2.654690927478129, 4.274405511725965, 0.6018341475809952, -0.054898767798838836, -1.0626009939642094, 0.8550877259009643, 1.7144593997570654, -2.004879922465274, -0.6812569465988648, 2.717711010485876, 5.0773141274088465, -3.0799259567640003, -1.3020083970845693},
    {1.4869089767652461, 2.996158154804683, -0.5444206256023212, 0.1858424020645344, 3.353720039138881, 3.4451977141153867, -0.3011357834710688, -3.9847305622139366, -1.7819454727379096, 0.20287729113213465, -3.095178199952581, -2.9124289246666604, -0.319644741249804, 4.383921556765522, -2.9479235087479725, -2.93744564056997},
    {-2.0454106172816062, 1.9540524857612982, 0.7174945643987728, 0.8184189403236375, 2.763007084761529, 2.1817467896673803, -3.1589857211565624, -2.658431429597235, 0.5345203680742412, 0.9927818096098427, -2.721639822163368, -0.5695001537553781, -1.9175265728773574, 0.9262746994488292, -3.5954624856853945, -4.140095134320305},
    {1.1910045279693144, 4.1235763814359405, 1.2787369633819963, 0.8985001419749967, 3.518536375625133, 0.8885503706178952, -0.5456435240161767, -3.3719194824310383, -0.6877852530994631, 0.950405797070584, -2.206627153785217, -2.072326500157285, 1.9741606075092826, 3.1842480570277605, -5.828361717319419, -1.7200209395704606},
    {-0.23324150650759373, 2.83769632515433, 1.3831186591517333, 2.321225732740066, 3.7132981970407033, 2.1196720394384663, -1.0782787277281372, -1.2455895483958763, 0.3871890737552502, 1.8215987392880066, -2.0925197667732713, -2.4473447270727915, 0.5800669678558884, 2.4619320604972295, -2.6616128669511387, -3.358515626056877},
    {0.50889606167311, 1.2929528057059576, -0.2571911635543819, 2.5516894324665684, 5.225360887023185, 1.1954128268853634, -0.5419712699846664, -3.485341819530821, -0.12584330209412098, 0.6654372412079848, -1.4815568064583846, -1.5023302506008287, -0.3209102086843797, 2.6919679151246756, -5.182946628619171, -2.2112903111693445},
    {0.6661040961670525, 1.5211581567632009, 0.23418317952267428, 1.11043397656966, 3.099710433844494, 1.2389144042017317, -2.7555705040929834, -1.8990361251044474, 0.30188808410166335, 0.5984812698168592, -3.187943146360483, -1.3180430452082104, 0.19823378512468692, 2.4717383637615145, -1.2030175512972243, -1.0924293115762338},
    {1.2312312755274146, 2.700840318692577, 0.2006536696261188, 0.9053507164786283, 3.335990912461773, 1.3055339163087771, 0.20553419148301416, -3.02073676197735, -1.952470043850106, 2.237104750405826, -2.633041397083192, -2.5291381518287506, 1.3487014466721563, 3.076348175603152, -1.4856060030986447, -2.950764322736183},
    {2.413103013199535, 2.998916609405783, 0.192527690986059, 3.193489632328029, 4.2076658700087295, -2.498783800831221, 0.6544871330501667, -2.0652950609480083, -1.5730831554736056, 3.42660387397014, -3.0735978575568006, -1.6694952568488735, 0.9963453383640066, 2.128359026972077, -1.215679347469086, -3.476432107343724},
    {1.3549565330449387, 3.4201656950239716, 1.5268094017949565, 2.3883013855884476, 1.2624841094020673, -1.2959869886054516, 1.0076362686943998, -0.6961964125703403, 0.7173071771959978, -0.07656299026649101, -2.409244863032969, -1.8035156896621491, 2.148287519102263, 1.8121536493415167, -1.6623355163288571, -2.617876002285675},
    {0.21394664546295955, 2.4299061779930446, -0.2098689489201472, 1.9189242985223696, 1.7018760759893852, -1.4952924414115092, -0.21259354608586345, -3.156990519887939, -0.0916012259201644, 1.5613987981281328, -3.241751358753687, -1.4452953277539504, 0.6151589849522477, 3.094995405060502, -1.4021933046075319, -2.6722765744493793},
    {2.112844246736179, 4.043660444620477, -0.29779348163207103, 0.5862896317400995, 3.270300046496966, -1.101262603650498, 0.8912071197244458, -2.6430428477944825, -3.097696280112585, 1.3936306495345803, -3.696876495889578, -2.93319713806447, 0.06990606191309255, 3.748367258967645, -3.7712727277931646, -3.498956777107576},
    {0.2549691965971098, 3.433711269800697, -0.6350120777800123, -0.47353100084500355, 3.2169129652651565, 0.8599887052670572, 0.9736431761816761, -3.3021014136308158, -1.6137461034448028, 3.242026688681977, -2.205781640668786, -3.1123738540590145, 0.006193323100947777, 3.1481237536938838, -4.086796030546606, -3.9496427602777295},
    {0.632013866748353, 4.499950253289185, -0.5715655921518574, -1.8479210202836651, 2.085889514983171, 0.5069837501359877, -1.7393776401480556, -4.036111200763326, -1.4877371187322912, 3.7867376997218805, -3.556539717979457, -1.4034864711874304, -1.1059488089375724, 1.958338162359038, -3.265797884836909, -3.720958028731431},
    {0.5762242546726546, 1.5421320536669851, 0.004367784463414591, 0.8068184130120191, 4.729389610057691, -1.8922998605925145, -1.3408029538184105, -2.97335646357638, -1.8107388690876838, 0.18167722372934628, -4.1798729030531545, -1.0213920376585177, -0.8922511109860469, 3.453058938307427, -3.4670238713726653, -3.37245752009523},
    {1.7535558309185613, 3.186490650171362, -1.0961463378559728, 0.5227170406103657, 2.075082186348578, -0.00384467125959811, -1.1476821475697818, -2.3052484534350244, -1.9902638649765987, 4.157700937947047, -3.2253745120287807, -0.3161445823460704, 0.5488069688754283, 2.7773609915268653, -2.189519744477924, -3.263629474724488},
    {2.305419664171272, 3.4346951726898585, 0.7116746560227963, 1.1141623095010138, 2.4248408592921633, 2.2103585736228277, -2.5242841235641533, -4.352610350763523, -1.3672519287480687, 2.6061164033855833, -3.102041434550665, -1.8897816773946823, -0.11918509642931595, 1.638009172222745, -2.5694147971438617, -2.2650768865773334},
    {0.766931006962644, 2.556637712759514, 0.8062750205774325, 0.24262981691996025, 4.273163743101622, -1.197089677010912, -1.7855521748702483, -1.3838812747742422, -2.095835530518281, 1.0233870583753508, -3.2445161074279, -1.5556772682375337, 1.1034411784550873, 3.071875319397177, -4.12207796097744, -5.039202965888782},
    {2.4910224101868854, 3.2880871042275364, -0.3643627034044925, -0.1814081139128052, 2.8759880831092373, -1.6650106907759523, 0.6396747512608326, -2.551823117579329, -1.7679761641906322, 2.781963920210582, -4.3363882023256055, -0.9072808131614818, -1.4517194319692133, 3.6013382584261184, -2.3488815206356435, -4.575810016398503},
    {-0.5575131303670963, 3.5921530371584085, 1.477312397359173, 0.7662910026191626, 3.5752838498755777, 0.13237434888915145, -3.089222897556373, -4.1784234248912995, 0.1096101089924453, 2.1046425565440376, -2.409804898579237, -0.814517335510343, -1.5199635391433393, 2.874745338274359, -3.8933895872646844, -3.78679761914435},
    {1.4686645801807323, 1.9680930441479547, -0.05329511340883724, -0.47916470393505545, 2.670960783864255, 1.2307236859526423, 0.7059222155240651, -3.202583051639233, -0.1376562149598527, 0.7989501693384833, -3.587900376869394, -3.3361995972861753, -1.4934984425568647, 4.2386183038629754, -1.7705495482311602, -4.285704154693892},
    {1.364485630141703, 3.4364656216911453, -2.005390149404807, 0.24442528348252618, 4.134640937088378, 0.07444041373977836, -1.2649756417469287, -4.876927671265149, -2.005935701771705, 1.9913756656968467, -3.490454660872634, -1.947837415797519, -0.0669890605866338, 3.7591301848933565, -3.029008435014731, -3.684283114421813},
    {-0.07107789469376735, 2.6015290384779988, 0.2865462769724024, -0.7957679110797525, 3.3623416334077696, -1.337158673715187, -1.8322594304326416, -1.7056721118599898, -1.2646705233000923, 1.085958345342445, -5.084135279834677, -3.509561245569276, 0.7672240731907404, 1.2839343223311308, -2.110846959869681, -3.4679013613184355},
    {1.4355608406693325, 1.6436348528041713, 0.6888505703021756, 0.9545443215389902, 3.5346640715005013, 0.20407323239067485, 1.0243778229093894, -2.5521399341377493, -1.197681123109567, 1.3682976138876806, -2.3703019479522967, -1.1284907068274943, -0.037638640765970115, 1.1908046009068909, -3.6420914157839706, -3.010025526465416},
    {-0.48021820957718014, 3.7459216517201774, 0.569810004839242, 0.0625109819676022, 4.435583346683699, 0.2921811322150075, 0.1973560777709894, -4.884228029239562, -0.9558009786666328, 1.3970757786145436, -4.214916830933955, -2.916543893023546, -1.229803467208008, 3.352723593911213, -4.535365281251957, -4.820671519984783},
    {1.690427986132291, 1.398031961048377, 0.3277062668658334, -0.40004331684050676, 2.305440883633271, -0.5070537937859377, -1.2617426744896185, -3.717930624830373, -1.1200761906908263, 2.114376296014816, -1.8679449645825323, -4.373840926402908, 0.5420105180066085, 1.4466094467958273, -2.6944971667363786, -5.008913804661376},
    {-0.3490300101635534, -1.490224453015892, -1.767618556845397, -1.9824619391509188, -2.2482692262329387, -1.9805389608449204, 1.3128179446367059, -0.549843427211987, 0.027520739945772973, 0.12104246358631525, -2.8162865327860263, -0.258845914478497, -1.0282922996060377, -3.4010671274764395, -0.38578947795035784, -1.8747587222297768},
    {-2.402604270569388, -0.39889176235253765, -2.692114267967113, -2.068618638053994, 1.1982133999087141, -4.086537640623615, 1.1997544019478064, -2.293638015305305, -3.323925732904483, 0.38021762728843883, -1.3703783588129987, -1.2923507435757702, -3.2160365404120586, 1.6538070651065215, -2.5009307087996975, -1.2485263081836844},
    {-1.7544217154005082, -2.8995913336914776, -4.127639913762126, -2.01904773338502, -1.0467761081413933, -1.532584114056068, 2.3792477642605627, -0.00778446729585759, -4.256666335871783, -3.3011976094845856, -1.4316186978981058, -0.45174351877992963, -1.2784819135383736, -2.3577227740964855, -1.9412601951845727, -1.6000769544727218},
    {-2.5532817383739883, -1.2353212529110784, 0.3357524931298301, -1.3783725040510932, -1.8487758980536428, -1.1480655217004812, -1.363431637896963, -0.6128112407431168, -2.445503944944549, -2.420592314005391, -0.32425409980790754, -0.22639618388551921, -1.5453680778266319, -4.123795208318508, -2.444687840519369, -0.3429174363670512},
    {-0.6845500151641631, -3.2399062483676193, -1.8506432751845603, -2.7581340024243097, -1.9182325238929254, -0.07496049043797968, 1.0564960149135367, -0.44848791203723415, 0.19087012484675964, -0.19813499456904685, -0.9102758656907647, -1.3112384465279023, -2.319661202639533, -1.688219226086689, 0.3266435777740946, -2.39134642821676},
    {-2.959511969860244, -0.7760318232634621, -0.8941649217487758, -0.4421480768751024, -0.1615125467978354, -1.7665681985210018, -1.7240044997864887, -1.64562538855587, -1.6015799141027938, -1.99072446583409, -1.1509281225426682, -0.9430749945438693, -1.6750800358391782, -1.35468001685121, -2.8479739873938987, -0.6011940192762838},
    {-2.929197252997391, -1.442927317242904, -0.9459036867969094, -0.12144078479018713, -1.2893881582483293, -2.186239395093457, 0.9886837831320612, -1.052875259916876, -1.5908283278996878, -1.0962735462956288, 0.888013986643905, -0.6449883973929071, -1.5568241324894192, -1.9591786055925304, -2.3135686382676663, -0.7671732241234622},
    {1.6077823123691104, -2.4144588960104225, -2.5589093841801622, -1.049281773273493, -2.7967018076427035, -1.7509968349335716, 1.3532068744415549, -2.073453346789504, -1.9464122218610456, -2.1189781848250795, -0.4578666428966068, -1.388663793168149, -3.140387368071108, -2.384513108668051, 0.37561284622747626, -1.2157383216373576},
    {-0.47057616906959093, -2.601978767667537, -3.542367531304364, -1.3134878436902728, 0.3663442985761723, -1.021703910897487, 0.852689986450616, -2.9795712179995397, -3.3887347970225723, -1.3737264015488242, -2.3039122822024485, -1.1676915193463895, -3.1780692805237556, -0.10906365831725524, -3.8423860772826446, -2.9919746669275358},
    {0.14266850349855448, -1.196088414197931, -2.0101949629062, -1.7462881011581648, -0.7412931292124861, 1.05685841055038, 0.4202089112120521, -0.6229801557163799, -3.5302826496711925, 0.5383875563893131, -0.7762538104042667, -0.7648588186970717, -2.337995861909219, -0.7702167542839262, -2.50546131724801, -0.9606680952096861},
    {-2.7125212292739262, -1.3383693710269886, -0.21130164146383748, -1.5398313583319951, -1.9201723147147514, -0.9010169237132516, 0.4882927232073468, -0.06194202826746393, 0.3112983758677733, -0.04417030355549143, 1.0834870809673856, -0.33061461250436197, -3.7592695509330394, -2.0876055502676887, 1.0412817829080865, -0.6474165324771952},
    {-2.353234591273318, -1.5922297740190108, -2.713059411110278, -4.308750283492538, -1.7389411570652251, -0.246429295467287, 0.8210058666190945, -0.5422137490273825, -1.7936682593643436, 0.11882567875107868, -1.3705393005958857, -0.3966708327016464, -4.151733281771819, -2.0189971233010198, 0.4588016201150062, -0.48037638211324235},
    {-1.1686619823093618, -0.590066392166205, -2.9880479998797447, -1.9001325229214476, -0.7359526707991267, -0.16852726799017825, 0.9577562345166702, -1.9750485069327777, -1.179232936554211, -1.213380818501369, 0.8514474198560603, -1.190870073964533, -4.4957258999018705, -0.6823119704812408, -0.5642986039094198, -1.1325457662198384},
    {-1.9438959315911704, -1.725081640565795, -0.9071093259662971, -4.147551226140989, -1.4146755108731826, -0.45427942235386026, 0.07024677009122737, -0.43839229948805497, 0.14863335294367389, -2.3555147272806374, -1.0222023099446182, -1.3917580629645587, -2.5398086192897726, -0.8823364353449124, -2.4225615249219303, -3.175324154055396},
    {-3.1611129767071597, -2.2840244009735153, -2.3636476303477076, -2.83367577811448, -4.43032148348376, -1.3031785320323248, 1.869824697535319, -0.0991327694467262, -2.6662502115398663, -1.9225709787483265, -0.2116167675885709, -1.4336668214536363, -3.372354994460487, -0.9532175790723869, -1.553141358050921, -1.349353550314225},
    {-1.054080545756997, -1.9987453823611876, -0.8864793725862673, -2.2796363177232064, -0.19486300215735378, 1.3434971557100983, 0.13561351161955043, -1.71918422916598, -2.0719419698005526, -0.22768082707302353, -1.8275100812938947, -0.2860277018632871, -3.4738800009277875, 0.1434374107332009, -0.8607045912242497, -1.9710885602186974},
    {-0.4011045601973744, -1.8843878575060002, -0.057041323350835386, -1.5396373289841458, -0.8117017782907084, -2.4286647678517452, -1.1386794055859282, -1.8262292953342651, -2.3298988485686762, -2.9204368369679177, -0.8205396752182677, 0.8895843331603779, -2.63839258636009, -1.4132322999883216, 0.6105974929324209, -2.41186946811888},
    {-4.3786602827507295, -2.7904065138433394, -1.3065331928589476, -3.577655251729627, -1.6941805014157878, -2.8855295119112183, 1.67467056030269, -1.6352197384041642, -2.061060107626236, -2.924412319992502, -0.28564973035221203, -3.2363932269656006, -3.4966903294727953, -1.028979740627816, -2.1350571165239898, -2.310325738690669},
    {-1.1049758739341577, -1.6570888078183106, -2.592962114116609, -1.4018281703106266, -0.8348053305516264, -0.2529748580669172, -0.17723542928693398, -1.2318486783530953, -0.6748641921031665, -1.0817748825248958, -0.6715243993570765, -0.45105247871432647, -3.722322311865662, -2.4480612920665012, -0.6368208443143473, -1.5395593583312095},
    {-2.9130484683966174, -1.9647132754244496, -1.5997634810114238, -1.6836700150336448, -1.2289104935806003, -1.4297113158829775, 0.21934258574815688, -1.5434158037405905, -2.0109899093100982, -1.3406278466222779, -0.24673627344119908, -1.739778712404341, -2.083177243184421, -0.9391671373029571, -1.595232664696744, -1.026132169592603},
    {-5.260250172398407, -1.0274301779028814, -2.286806466971495, -4.014020349703479, -2.638119815229405, -1.6382903604384915, -1.543733647516311, -2.8295535803777834, -0.9301011789637218, -1.2521323414251702, 0.32812587778295493, -1.8826890357305306, -5.870143902400508, -1.707510572484134, -2.891921572890156, 0.0613805234790699},
    {-2.843233325909784, -0.695813153132107, -3.0074548838265422, -6.08751169531849, -1.3990750062294035, 0.8933620972682126, 0.9792311261471842, -1.2877588801389195, -2.254655387075768, 0.1412333207017026, 0.9061113548027101, -0.1895014448288943, -5.0444274565456695, -0.18332734322224978, -0.7025886886999221, -1.8307602209007963},
    {-1.0565777108810108, -1.9486412725704592, -1.7376451576320036, -6.417368395748978, 0.8897356464242573, 0.5284557321831073, 1.6208166067189986, 1.4041203025468516, -0.15305951273757315, -0.1057514988221968, -0.6019412755575003, -0.000736456047911662, -4.473038143584085, -1.331428971707096, 1.3542996777250487, 0.8016473276232018},
    {-3.0810633899535937, -2.5400714903252113, -2.0513659377087237, -4.377979940887852, -1.8978808831945413, 0.8910838383335865, 1.7262778590182206, -0.2811025054061182, -0.22497641421634168, -1.357252373236458, -0.6876009607947635, -1.2579223710325202, -5.322097114352755, -2.0317136184158353, 0.3014119837299941, 0.2362116124762063},
    {-1.3274471135321746, -2.2468579677449334, -1.6665813333035036, -5.367479322758678, -2.018964685600676, -3.654851294683318, 0.46359490324119396, -3.2030480358983517, -2.625789607154873, -1.555039422486307, 0.6421328571650438, -2.4955084549053113, -3.8023620526816493, -2.855776872134592, -0.3811955080034629, -3.7441434149045327},
    {-1.8687347319291725, -2.5173951773009424, -1.8704772512921675, -5.73214630984666, -3.613078332717049, 0.15363362753486012, 2.2112916505370017, 1.3748384609880706, -1.7555183518638966, -0.24462964884512076, -1.3382552757237867, -0.9051229276108225, -4.421953047473409, -1.8388939217900642, 2.814074643483627, -1.3856597893388647},
    {-3.8905533725244954, -0.1189767116843424, -4.011128445520323, -3.3721585080816157, -1.38103013247401, -0.09583476144731455, 1.818609410001036, -1.495778515092612, -0.41659095846064886, 0.024657646522453912, -1.137615977480619, -0.9703795134343348, -5.14573734656726, -1.147056444919456, 0.7007350217729564, -1.257372825374239},
    {-3.0046399675607414, -4.521949940293782, -3.8261095682899957, -4.227556705381227, -3.474835035983034, 1.2902045596697502, 1.8414068642110935, -1.314191531481414, -1.438227486984508, -0.830764376407612, -1.194169097981086, -3.5371181420026443, -6.20232648517538, -3.0894880298488197, -0.9157766128213941, -0.3620827136565991},
    {-2.982830962981336, -3.186650819831436, -3.6579082927193776, -6.678722781836802, -3.3512790852762175, -0.6408424028111582, 3.767722680581798, -2.3181461306214874, -3.3684044461805067, -1.6692822554005224, 0.729115792975689, -2.850631633440064, -4.2361340072210165, -2.8239179736871804, 0.30724806416494743, -2.903042533971279},
    {-4.163602519485292, -2.5312513650780035, -1.965103822675631, -6.127958097243615, -2.5969365517948413, 1.123868849813322, 1.9820620698746088, -2.25732663937094, -3.476893828311036, 0.27147026471948793, -0.1808331654279995, -1.9201512610843963, -4.924033960426694, -3.4424567641030643, 1.153138844847419, -1.3546570446233248}
};

static const float b1[16] = {5.7738875175255995, 6.656649314759147, 6.241304228858664, 6.942662340465196, 6.523949308425622, 6.427847977284536, 5.283983283678158, 6.792628219889885, 6.696825462881711, 6.919912840849752, 5.223504225552425, 5.3799409115288075, 7.013888121232634, 6.100206734104169, 7.2427727815627705, 7.380694335359288};

static const float w2[16][12] = {
    {-2.991324838810787, -3.3635651481419813, -1.9790752397492324, -3.8937167614371915, -4.042524650495374, -4.932399578643164, -2.5862882427380063, -2.826929203679739, -5.007161932706558, -3.6605597200941857, -3.1190366571863604, -4.463138938820455},
    {-2.930638328497525, -4.244687066043283, -3.765936204932839, -6.149729745102653, -3.4960763065686526, -4.782241302877162, -4.324588780816929, -1.9708834614208657, -3.2577610590012878, -3.58193546824562, -2.597524421895796, -5.16165829216798},
    {-1.9982365987552582, -4.328097960596143, -2.6796978990636067, -3.994145445163159, -5.178693303175642, -1.8951136098613142, -2.766629607552228, -4.970025017687449, -3.317682462472132, -3.710905662279452, -4.133734101743992, -3.6623519211069513},
    {-3.2893455884415927, -5.87388292107213, -4.529297540378986, -3.4129614979810703, -3.2682533684351425, -4.17069149002757, -4.060438357024573, -4.624254437100084, -4.469684671619522, -3.079466325490351, -3.673915536967703, -3.36731327963968},
    {-4.830835469479629, -1.4824603535823848, -4.145674427729919, -3.690782914950656, -3.438455887764216, -3.120077966146415, -4.682862884769337, -4.315935006833807, -3.7726517139036044, -4.2620656139159205, -2.951018641557886, -2.439816566003202},
    {-4.351163452980441, -5.001075186396294, -4.083645944269387, -4.086569778305118, -3.957241864155333, -3.5530604381796542, -2.3788879699457786, -3.5638209769062335, -2.839826532722873, -4.639205144066139, -3.035416596255907, -3.8545735925415143},
    {-2.4998603177583933, -1.4682585039167766, -3.4259687096280396, -3.2980376043265793, -2.736301774968886, -2.585874548549425, -2.5036318633311074, -3.342252574282308, -1.4884588703215567, -3.904789783597632, -2.42948949395551, -3.0566423844367905},
    {-2.1653283632229066, -5.496667027263159, -4.417716843642805, -4.214060772117139, -3.573205048065097, -4.369237672178258, -3.5990931333043905, -4.489109938994669, -5.3817357327801885, -2.990089930519062, -2.1037420052063482, -5.2511509271874965},
    {-4.038981378813275, -3.5058326865280964, -4.5813609406987394, -3.3510991001462407, -2.470627590792996, -3.5207273486002797, -4.892763709153114, -3.0585028769679496, -3.8820836153720455, -3.9502114534715282, -3.153169871017639, -3.7134114635622972},
    {-3.661765029319847, -4.1507638059275855, -4.638867171492213, -3.0984160142896537, -4.366863460576424, -3.2595850961431334, -3.674590921499578, -4.159375632548715, -4.174986805801495, -4.0420219891904186, -4.269567780596857, -2.6967087326488963},
    {-4.802667332764532, -3.628228173190343, -3.7039558840717017, -2.555683196290643, -2.5453375170391483, -2.5319556417407014, -3.369775689451985, -2.6029453768822752, -3.635011788781399, -4.154978335857781, -4.878051337828922, -1.7753170759716241},
    {-4.902295720504888, -1.8534843659327078, -4.347986096324267, -3.597816206222629, -2.956524787991695, -3.6372514490119414, -2.275534738819364, -3.16509299410451, -2.3529422506843565, -3.957978556167644, -4.236121404072696, -2.365043935995246},
    {-5.585181239533882, -2.6566943238733285, -4.556306661417823, -3.966627728259734, -3.755383893489319, -4.664061518548801, -4.462383174453325, -3.9841011394811563, -3.337019521681774, -5.335038695193755, -5.204648060669504, -4.40449523797619},
    {-4.17795014228001, -4.785622841167756, -2.6826772084670862, -2.0281851568660447, -4.4562186611783625, -3.371463932312474, -3.394466551675639, -4.403622346206598, -4.086176388203596, -2.2669080493713216, -5.6413132547796785, -4.016755712770265},
    {-5.037414278777823, -4.011273475533518, -3.650783130171682, -4.794318068640366, -4.082521871717885, -3.8755502641488104, -4.911565524400275, -3.7274571662621483, -3.584171800876165, -2.904024826062428, -4.349862770989031, -4.3888429417841675},
    {-2.6913973477838598, -3.4721204734810827, -2.588076264013624, -3.976869047096671, -5.826984102122016, -4.659745920331654, -4.879413179411561, -4.6530944285510785, -3.9170796132877315, -4.2398950432070075, -3.6418541153789956, -4.51058466486654}
};

static const float b2[12] = {-4.768223199555577, -5.059838065782872, -3.466253854659273, -4.325500527311042, -4.606007185284341, -4.509393149486992, -4.193974104644172, -3.85229720842895, -4.576333603357572, -4.500883477857673, -3.9888819159473217, -4.392150391165246};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
