#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.1136885746220016, -0.03215721635786468, -0.26527520924174636, -0.017304140008442714, 0.575287359610686, 0.07515718731004406, -0.24436227249396575, 0.46771434396661654, 0.1468651222629937, 0.0777974134354, 0.31470225556114456, 0.08713498064211367, -0.19712204200074754, -0.2713797454082135, 0.10069808469442806, -0.16858807667657394, -0.14213214443144642, 0.19803208649468723, -0.3072777114132068, 0.32085626200198325, 0.46130886540945104, -0.3531493577334343, 0.17387334384278527, 0.036627836000760486, 0.5749093971602627, -0.21305404513879814, -0.15048076918964023, -0.08330423526915323, 0.029121906541645325, 0.16592318293049, 0.5343570434562077, -0.2666088280002814, 0.26813969085940104, -0.3557111812244418, -0.33333729286078256, -0.3939942341946343, -0.4387986332805912, 0.4955622952258942, 0.6513173990513279, 0.548404958808132, -0.28565277959582563, -0.3035249411479632, -0.055334534483117766, 0.6054883872384429, -0.34991369659032745, -0.37628808472856806, 0.571421306694535, -0.15044646069269013, 0.14649958734775054, -0.2584589206069509, -0.08955049749337676, 0.6512862899276255, -0.43306818668936314, -0.46051969382390096, -0.2977534769461769, -0.1900905919819472, -0.4203054815341294, -0.6268296034015991, -0.2557907979604381, -0.3162864198285291, 0.5651228980831026, -0.11956411624643835, 0.07850532465969244, -0.25404869052753076},
    {-0.7862461985098255, -0.6278107323504136, 0.07704372681632309, -0.2152856627743045, 0.12559205564091397, -0.14634812106444073, -0.5352354252852038, 0.7326440329779966, -0.40853463845119686, 0.6259790406694459, 0.38928616628602825, -0.442447339742593, -0.19613112112196357, -0.2937371980830437, 0.19111404742465618, -0.5021293778159057, -0.6346181199010582, 0.4018120135795352, -0.15269098980197413, -0.3574014545247365, 0.5619886326079485, -0.7452461057957028, -0.05840639321529653, -0.5465865568332465, 0.4276820041626872, -0.09293610975740409, -0.003090677879946256, -0.2562939185962858, 0.4820129523672252, -0.7113396992435271, 0.1334972036581687, -0.5252951583006263, 0.23841186307062917, -0.4696165585844337, -0.6602557815477976, -0.6006349469736323, -0.30916153813928393, 0.42772719733064624, 0.5610096012272626, 0.4846238678803218, 0.199966140787381, -0.5872793727122327, -0.6289414273529864, 0.4410815866637532, -0.17336972736006412, -0.7853490379941731, 0.24133940160488193, -0.18526500708931942, 0.005591097157113095, -0.5175096833484848, -0.6146805079025218, 0.5815788525716161, -0.6592012607905142, -0.5009206871767915, -0.1359034584012506, -0.5702177427337332, -0.6018123131825484, -0.7653051515332434, -0.6130809497372054, -0.530413725226594, 0.6689947902467889, -0.707814961928307, -0.4221635353723272, -0.7410432150729912},
    {-0.6054647333320795, -0.49368807949375093, -0.20044063983479296, -0.4510737047256994, 0.5408681844348491, -0.167536604077743, -0.5310007366680726, 0.6810048556115054, -0.27518966916593174, 0.830589763619896, 0.646387977059084, -0.5612064035486074, -0.3806271649209718, -0.37800285336461875, -0.3124003203008288, -0.48749472638988844, -0.5534910865502988, 0.8292365688022892, -0.2863223789685516, 0.1623773122645675, 0.8302535176397052, -0.6597426440352022, 0.07984836073770514, -0.18837800854998146, 0.7277451288955874, -0.47513918276442857, -0.44070734236182724, -0.5042458547534289, 0.5816511994738509, -0.27059415089803696, 0.5917040627263352, -0.711569034733141, 0.5294389994865166, -0.5112276420037629, -0.34229579024024087, -0.5516999584868455, -0.4949225924846237, 0.4459674129552849, 0.7739514890533997, 0.9050851356424603, -0.2599727671216907, -0.3730196685638325, -0.5054963704476014, 0.82414466385237, -0.16976041818229395, -0.734765500142284, 0.7546649502324116, -0.4397538436220947, 0.7290724887389607, -0.5667082705482784, -0.3123430106497932, 0.8374836098058849, -0.5407457154768684, -0.7281736450358304, -0.31205107328494375, -0.5168685781742715, -0.5193573754839302, -0.6752759762410244, -0.3786404746059306, -0.48090252499684366, 0.6200752092128013, -0.368965704200647, -0.29728167598953514, -0.5677345951147159},
    {-0.6816518344190504, -0.5611950679455893, -0.4155413183277169, -0.52899021748516, 0.6153896167624826, -0.39386564103338245, -0.8109186393145644, 0.74932272491501, -0.4513652475275551, 0.6583555559395322, 0.621255129268618, -0.6332115200967937, -0.3993900726617376, -0.7279889493845307, -0.33112198091430384, -0.7472324936119343, -0.6142284779035565, 0.696603954351462, -0.5686872936538921, 0.0026198678235863555, 0.8043469652947223, -0.6978837457912606, 0.198592014414549, -0.6866318333878062, 0.6974329019725696, -0.6043778887754426, -0.530852871224271, -0.6465779530598659, 0.5983180917664104, -0.2358529100971407, 0.7716091843136162, -0.6529981541479255, 0.5739636843851507, -0.6314268861210737, -0.7121895867194574, -0.7306112470175468, -0.778661672827336, 0.5549725406536089, 0.5704400557583565, 0.5444561586922531, -0.2290090467073378, -0.6695554510804389, -0.3765156669408966, 0.6298093084257967, -0.4730453129323712, -0.6388922362513996, 0.6501074110937993, -0.4492367303321298, 0.7401884253747265, -0.5684078166736568, -0.5047200090983421, 0.8351507822938714, -0.763996087932074, -0.8364590013758033, -0.5176145023443981, -0.589531695706156, -0.620854293203987, -0.8422997404108659, -0.6224160196606836, -0.6379931478279218, 0.6582705547971284, -0.7068321238514517, -0.38849840690992743, -0.8108487153960248},
    {-0.7660109536281178, -0.6975089733893943, -0.2780892349041788, -0.7974466666583271, 0.775479055295421, -0.2023080411395149, -0.7065179683790235, 0.42859141812411966, -0.2859274515938152, 0.4975308455586308, 0.7438117535187462, -0.7404480428095737, -0.5220307269171282, -0.730364722015052, -0.4758116178769304, -0.5756340236824397, -0.7373880817044115, 0.687925877788379, -0.4306164582746093, 0.34866764760354246, 0.7490845446107546, -0.6622485927654029, 0.0553998324695814, -0.6543909486257609, 0.8171697361481959, -0.4064733292212122, -0.49528847514563656, -0.6360541801024663, 0.2950613753876729, -0.520737565923412, 0.4646330424638056, -0.8241643147932424, 0.6319188964783744, -0.6526484195861203, -0.6731012829244215, -0.8029741133589687, -0.7736094246833597, 0.21682385886398703, 0.6480321000431988, 0.4841324692074889, -0.5136535251712909, -0.7751804487982317, -0.5018068651678302, 0.6019898164131354, -0.6058977316339861, -0.5437694544581455, 0.6229875035260872, -0.6507958048098661, 0.685109389154756, -0.808454087030648, -0.5554379394020477, 0.8620936353526111, -0.6006952374165749, -0.8192764293027269, -0.7212704446493616, -0.5593949308254277, -0.6180852840303881, -0.7899055152266586, -0.6324114003019273, -0.5029983354212098, 0.5217885772949279, -0.6596165659771812, -0.5222992761884332, -0.5982574616589668},
    {-0.4557265844511975, -0.6325515908979157, -0.40093776191398944, -0.8618315869854782, 0.5300598499435423, -0.2244917249459282, -0.8715035487201657, 0.2095703728399733, -0.4303601904304017, 0.1950689122767, 0.5375413092785656, -0.5925659064271632, -0.5676265726462466, -0.7629640132524458, -0.6640987023968831, -0.6056333827253313, -0.7138856239067967, 0.6723685513181512, -0.6791893222153944, 0.3853725238166631, 0.3073476330488537, -0.4788002158654729, 0.0006312656446585747, -0.543758724893808, 0.6007564054333306, -0.4510387439458764, -0.3582750898508013, -0.7771344906096307, 0.3306021304165, -0.5712427147365017, 0.7492340304623256, -0.7168787220515517, 0.5579614746324746, -0.44229001058555945, -0.4201677845576721, -0.5423775548413472, -0.8345961355658192, 0.30647198986011726, 0.5427142485920549, 0.46080249866038114, -0.2999359945245539, -0.5578068299913483, -0.5672099028273937, 0.6280864840578698, -0.7148452668063526, -0.5641197803230297, 0.5503272800656192, -0.5935245761134854, 0.7762921248673444, -0.6848187974219201, -0.6532324586055501, 0.5235297380163169, -0.46792090167435696, -0.577866554861759, -0.7217843726373043, -0.819166395662492, -0.7085289595477618, -0.8989456706363669, -0.5750514774112098, -0.6422117498909811, 0.4288009084158368, -0.3308612887639002, -0.6769142014244464, -0.789464498370316},
    {-0.7973956667114899, -0.5970674274249534, -0.5703138632376615, -0.4983738051665602, 0.7948635917692898, -0.41930695603027657, -0.897199462605302, 0.18856952974789365, -0.36226891072146705, 0.14051883324845782, 0.4586841564658547, -0.794591232171536, -0.31029223375438897, -0.7656715921882151, -0.7152584900633852, -0.7913662746369469, -0.45681830470164236, 0.7540198101421838, -0.5368279035358686, 0.29813898621379403, 0.5584757762673793, -0.6887573347083139, -0.2788710561671022, -0.6401269399660712, 0.6384040329761523, -0.712640959639096, -0.5320665046825993, -0.4797341615441893, -0.052877994533754566, -0.5930266274667424, 0.5208677990240469, -0.8733731572148035, 0.5740346927149576, -0.5421651371015188, -0.6716922221053375, -0.7801836094469812, -0.8542505625202902, -0.02336749956911955, 0.4854464010322626, 0.43315947205556815, -0.27964847314583496, -0.5364538605523491, -0.5356680617603712, 0.6941540550989038, -0.4835924223185362, -0.4112780739746834, 0.5561685439378323, -0.6543792504598841, 0.518582897993109, -0.891767326869768, -0.43829472470015246, 0.5935638428527792, -0.4837675644407925, -0.48743922686755925, -0.7710988898709815, -0.7536698443192479, -0.5679122641970179, -0.7961096639741428, -0.7128382634085012, -0.6439365922937424, 0.45264917365009055, -0.3052102139236982, -0.4130345382937937, -0.6485602324350058},
    {-0.6650379691758631, -0.5418667593652985, -0.4063952212647883, -0.6528910577681455, 0.5784435446466666, -0.2567019338494753, -0.7302539827895245, 0.296114017557648, -0.33579452475008054, 0.08280302510631599, 0.5512012498603311, -0.791160314307099, -0.45216136795212364, -0.6146879185201788, -0.42269242445977534, -0.8157316877017129, -0.6482259955423992, 0.4723862861656, -0.6279531696645776, 0.2888447509464782, 0.5272078678928823, -0.784554749604175, -0.10899745709484367, -0.6072315231949331, 0.5668531610115615, -0.4072837344536463, -0.6381107654038293, -0.48731673527851543, 0.2109307328782147, -0.6296106268276713, 0.7029160806099967, -0.562288881154168, 0.38147776664193556, -0.6633054044485641, -0.5587551238378549, -0.7051626519475307, -0.6581306271723742, -0.03395909160648747, 0.513181333601004, 0.5108282241060372, -0.3546325671508554, -0.6075449185385371, -0.5245038117146908, 0.6413309677645113, -0.604803299988081, -0.6535304770267898, 0.632518628361073, -0.8357114727645854, 0.6254444557213148, -0.7789110523499517, -0.5844145613850734, 0.7107000323630758, -0.3806783899067126, -0.8445785293390978, -0.5676626480460314, -0.7523912808496342, -0.6503639209749769, -0.5939337733391317, -0.7656501337999511, -0.5677133079378637, 0.23989078686299248, -0.33885554645604193, -0.7179188001235507, -0.7212685556914704},
    {-0.5971940285970709, -0.4456039249916609, -0.4625810714345281, -0.4610508090544301, 0.29834969120939714, -0.3649363084894883, -0.5326800854190179, 0.5586658958495506, -0.5993894186986687, 0.33233224879960677, 0.6838086968052411, -0.784863235775118, -0.38564291050331123, -0.5999702745201864, -0.4678437410372433, -0.7257249113442157, -0.7027511205186674, 0.7609390743966565, -0.6746208378802481, 0.1099137646205942, 0.3652293245734532, -0.6020932417537707, -0.04580056174248951, -0.7884625879676455, 0.5406408051978708, -0.5813136747897262, -0.5002390637411803, -0.8070116704319801, 0.3847146882938618, -0.7332326791517467, 0.592271564178788, -0.5967132264995022, 0.3860082821550778, -0.7108791631274913, -0.6778240700491602, -0.6497350985647823, -0.757848433420525, 0.16889075929307598, 0.5980847946238643, 0.688880503854555, -0.3581270266926009, -0.487555723355311, -0.7178145183613686, 0.6379775405726418, -0.7279166781516544, -0.7537410252902793, 0.6186595447448774, -0.6676235161323237, 0.5685584839913833, -0.6554561304012553, -0.6122629421614905, 0.8174980189348399, -0.5180391003787859, -0.8322124822868293, -0.4434008496513367, -0.8611687578065756, -0.5613918291621192, -0.5663111116010716, -0.5641754402983176, -0.5445698746091107, 0.4044070117287204, -0.4138957880099828, -0.5807431930509225, -0.8165083547223065},
    {-0.7330056849798308, -0.5483220143498326, -0.37362625761655127, -0.6412854238927961, 0.30891089285862133, -0.5209297354259936, -0.7872190177656954, 0.48620960157533377, -0.586530009746006, 0.5045037254513313, 0.5516335945340053, -0.5927722116142355, -0.3079031739998973, -0.7679773670743706, -0.3472736072807022, -0.7001333594503518, -0.5950106257233073, 0.41447547040288746, -0.47431354930871317, 0.07712902809610678, 0.6090548933238543, -0.8024625425915156, -0.3171039344359398, -0.7762816902035445, 0.39798583603524873, -0.5234403093477498, -0.31212107268920186, -0.7321455114143961, 0.36933661165439874, -0.7968715083189613, 0.6663257516562004, -0.6949265269762694, 0.6433897605793457, -0.5504010754408526, -0.7742441975014382, -0.5941734823198908, -0.5814102313747331, 0.1882036575505601, 0.6993530735073077, 0.6112542493907955, -0.5196014500798791, -0.8144241509459262, -0.529895441958469, 0.3599664661030026, -0.5960902567969308, -0.7816159784583016, 0.5885028850971804, -0.5609857447156008, 0.6013439688779726, -0.6875231198077725, -0.5939097400331289, 0.8388697661459973, -0.4438239661090543, -0.8527634107782545, -0.7391648312812277, -0.8431456796284189, -0.531083257178991, -0.856223074348759, -0.6513119451015994, -0.5967949781348205, 0.6660668278789533, -0.45285561452439194, -0.7064739414950387, -0.776980974984665},
    {-0.6949364104015582, -0.5910560531373144, -0.3547748920724914, -0.4083952829020454, 0.20930290843231109, -0.3502340659471286, -0.6070389257172663, 0.2946400559594329, -0.5796750345712329, 0.31324049171253554, 0.3124188631102145, -0.7957005992640306, -0.530326671549982, -0.4935819308028802, -0.37632774937648833, -0.7172927903912666, -0.6166984006729864, 0.3561712365687037, -0.262345681491499, -0.3405274240985561, 0.25826830330432954, -0.7994891613351103, -0.16854347953436727, -0.7494684158489094, 0.3973124338761496, -0.4706091349097587, -0.24291155930354313, -0.4589197379921194, 0.3696493314102899, -0.5643043306569435, 0.5254099951541322, -0.8826555950036798, 0.3953243102232471, -0.8593202980953037, -0.5605598644862493, -0.6295394997717194, -0.6474474717254223, 0.006361195705448882, 0.6056125884763492, 0.5426957333829149, -0.45342588708095394, -0.7637606517322033, -0.6886260620802008, 0.1619256916946016, -0.5101579089333873, -0.745046307473122, 0.42948857233967663, -0.6982679282106048, 0.012146433653920461, -0.6590130100676463, -0.7717647660352042, 0.37949262140890677, -0.8229099113330258, -0.6042136523354076, -0.5071090043309423, -0.577561171473575, -0.8652954188117304, -0.6654179136920791, -0.5284171425808757, -0.8505891231742045, 0.4160905843166015, -0.7186629962761747, -0.5239348143487147, -0.5954214997177535},
    {-0.6098765210060463, -0.46193483181081907, -0.5838774269597435, -0.6290699301104468, 0.2683996702324368, -0.4113360270271805, -0.7620856768162168, 0.4573541325882237, -0.6952466372145445, 0.30437650937143357, 0.32406724171875323, -0.5363652954475272, -0.4958615185886971, -0.624893798015429, -0.5379824591007544, -0.6048502456096194, -0.7250864800992602, 0.5876728002314597, -0.551772126867618, -0.04668361594200681, 0.18903704102452543, -0.5209122571816655, -0.4393069359105527, -0.5679573729838474, 0.4880035523488086, -0.363568691284194, -0.04065698836500317, -0.7094973891458967, 0.15851007757329752, -0.7655402869843819, 0.40571297620946056, -0.5944749311468742, 0.3308202158956311, -0.8541895809573579, -0.5919963522834679, -0.6900089313722869, -0.480068738631332, 0.2977698504096281, 0.5277208573567499, 0.6040040060206417, -0.5398040585644573, -0.7144902756231467, -0.7168103463568807, 0.38454959134997785, -0.6570758814396438, -0.5520734055251695, 0.14182961679407563, -0.748147082819946, 0.4791111371028442, -0.7795886417369501, -0.6308115667456818, 0.3873185357255692, -0.5837776176669427, -0.7198067538677473, -0.6311442067514821, -0.44694214126552906, -0.8022239658266832, -0.5521826661033943, -0.7011646028223663, -0.6651845441048538, 0.34554191278139257, -0.7176745634976608, -0.713217788796807, -0.7100835078998005},
    {-0.7085842484151771, -0.6044702812195365, -0.5535607727673274, -0.39419749502324897, 0.13291271565647003, -0.7053784829492464, -0.7078401318915678, 0.28648158180245775, -0.6026516388635236, 0.25395009872941626, 0.5593058194418674, -0.6128120629696343, -0.3699413125902493, -0.7739384460556492, -0.24334931622631908, -0.4774061973615066, -0.6779776716209466, 0.3191532155590637, -0.41518636534350417, 0.018346483375008354, 0.1282821241060113, -0.6057683405809754, -0.21742182829843282, -0.4735014670779981, 0.45509035245674895, -0.5298173340772511, -0.10099466578259375, -0.6267151919317977, 0.1291984647360167, -0.7318867544999657, 0.4026096766881938, -0.7978465527394206, 0.5350977803139384, -0.6267642737947324, -0.7143171495305102, -0.5789027610309613, -0.7870585704081517, 0.20889187780066112, 0.6218105017361135, 0.37541914956783984, -0.526870259979665, -0.5188974539819877, -0.5637370802163955, 0.25379376178193386, -0.46803004975848006, -0.7389437478189312, 0.21991087608267823, -0.7346638188596989, 0.1992468129716515, -0.751010434378392, -0.4141995270936455, 0.5570787789105256, -0.5307806682360435, -0.7070019596337629, -0.7446492206565152, -0.575855344678939, -0.6896834765566229, -0.4832948659024434, -0.4808605869347082, -0.4932317886051676, 0.43257617527161574, -0.727397662133971, -0.4912245609723077, -0.8531563735813624},
    {-0.8745346324536897, -0.7753151414838944, -0.6268500763233086, -0.5893172884521208, 0.31285538153340353, -0.6108286458779872, -0.7843630150094929, 0.2630332482355595, -0.5394641267858017, 0.38901030069467424, 0.4282713579811135, -0.5200480144868371, -0.38962726185178215, -0.7641895241063168, -0.49391484049807255, -0.4662877309414336, -0.7780133468476879, 0.3920400270412196, -0.4638169392417065, -0.12897908323974963, 0.2130326034814014, -0.5789805214412154, -0.3158537700997865, -0.8098413096715886, 0.2657675550510858, -0.458818281485378, -0.3363836216491226, -0.6049454191637909, 0.24300219962624595, -0.4298716627456044, 0.4476256982464187, -0.6107742806000985, 0.5790941551845065, -0.5830392099029702, -0.5636615265435866, -0.7938072352170625, -0.7915041734970021, -0.056369834384161314, 0.46051564562434155, 0.6576784404142987, -0.5415261981373057, -0.8016057464772859, -0.6149365660351797, 0.4459294182521595, -0.6041936304509367, -0.5212028326968549, 0.24445673667817377, -0.6425822190267556, 0.276196924450673, -0.6369760493413859, -0.6100570254669299, 0.5498692510582903, -0.5904581403739012, -0.8432972851620955, -0.6992550150346094, -0.6899219011862667, -0.7626714169714607, -0.6234238164498566, -0.7492100375784514, -0.7615533875671282, 0.13745618841818028, -0.5289139614149324, -0.5721282942552974, -0.5439033372645256},
    {-0.6834674175864491, -0.45416258251864594, -0.44537253726997394, -0.4403799902938822, 0.39366129010939016, -0.4826439829782818, -0.6197683714764587, 0.3975073252458045, -0.5437131416792426, 0.40996969547035356, 0.26432693788040595, -0.4206286399599441, -0.29348812862194457, -0.6613017107416314, -0.5299786251414362, -0.7582600548167829, -0.6866208808173088, 0.3621380922334062, -0.36356768578661186, -0.033044239855462426, 0.5313222760655143, -0.8224841893982477, -0.39435699482416986, -0.6775496565243517, 0.3245508694004572, -0.6287837991597467, -0.39347840948242413, -0.6433792779991059, 0.1536181224599937, -0.6241726478511023, 0.4190952894133389, -0.5175410149164048, 0.37479942799664, -0.740963902551744, -0.5212928834743604, -0.6193963459921643, -0.6745828599653098, 0.30832265508511764, 0.4995714740993485, 0.5585582839138733, -0.35668234838153845, -0.5598516225867428, -0.6825088323341729, 0.5897127680373684, -0.6059001095312833, -0.697170587933524, 0.251329604897079, -0.7169742117109846, 0.30308828966737295, -0.5808988771020752, -0.6136597212113185, 0.5627513010294793, -0.47352060474688484, -0.5429672545786988, -0.71951666082956, -0.6654602673161845, -0.7476084747278362, -0.7972098238669112, -0.5734587612330448, -0.7605613626443801, 0.38929006820795176, -0.7099010972197212, -0.7380273099833133, -0.7346963708221418},
    {-0.7896777944366664, -0.557514562620095, -0.37355394463104097, -0.6311777088348606, 0.6898534187338353, -0.6434683522343866, -0.7431865959281662, 0.26194534195992963, -0.5475543539647226, 0.655416258038192, 0.433319007013182, -0.7761712560431835, -0.508310725350087, -0.8148022051642388, -0.4410749232659132, -0.8151557412228118, -0.8108135704945582, 0.7103574363534673, -0.27964733875843856, 0.21703569870073725, 0.5403937467630812, -0.740422243731139, 0.037860940717903295, -0.5536650309029297, 0.5102520009486783, -0.40397358122741805, -0.24755148450214962, -0.6224123403925472, 0.42226886770615385, -0.7307451552380381, 0.48518610121729117, -0.8859605258537627, 0.41272769793415237, -0.7603513574781872, -0.6079527996703107, -0.6074031015369601, -0.6365256748798148, 0.2860899940723125, 0.6542967833717142, 0.44930650277418444, -0.29542708044934346, -0.8469649395993938, -0.49101383451864467, 0.5824934178529365, -0.694260800530323, -0.6404146689595325, 0.4015502023014493, -0.6018102150054002, 0.477219864117827, -0.7615886280656542, -0.6302029521910526, 0.48590604604594434, -0.5925153907013977, -0.9046037259779688, -0.46566672133111026, -0.5532921936862891, -0.8300388042559724, -0.6519922429962818, -0.7949703953821032, -0.8148498621830713, 0.5413967176835359, -0.5627463751783484, -0.6565523157299118, -0.8072309723277612},
    {-0.6015852944777478, -0.6864727378301951, -0.4161294969247845, -0.7494011658347265, 0.8249664279369001, -0.523551733602589, -0.8056362382342217, 0.6275952374875899, -0.5026829031191946, 0.6787885426592897, 0.7955797801129524, -0.6942904918839069, -0.2170086144589566, -0.6264565829340861, -0.36344550818939014, -0.7162574330911468, -0.608747556046889, 0.8005073848013592, -0.27920661293526833, 0.4058057598038511, 0.7702332483882547, -0.6512679435449934, 0.016245458637540573, -0.6624587335901826, 0.7155068361675336, -0.3987633299958865, -0.18044078634521854, -0.6139451244119666, 0.28569284488967855, -0.3903500806330315, 0.5641517490631741, -0.5343478680765015, 0.6977770694639043, -0.6016106677773074, -0.5952542043920224, -0.5261150786892446, -0.5324803132140242, 0.6757878142904561, 0.6822590030880713, 0.8598320277622514, -0.21249410424241058, -0.6226993354516002, -0.3740513460232493, 0.7968629839859281, -0.5454485084017644, -0.5527247583646159, 0.6136792433670218, -0.7175790805725983, 0.648594084855441, -0.790600291433113, -0.3428953196902536, 0.6193401237048795, -0.6747770556435948, -0.6504105386388749, -0.5481521674496922, -0.5058903309239875, -0.7553517447819161, -0.8548927065481982, -0.523185558630675, -0.5898338848772485, 0.7571390851512897, -0.6895261910501812, -0.5431871880991171, -0.848039327475736},
    {-0.7061849506177516, -0.3902298354998957, -0.24153762326584327, -0.6548997785179649, 0.816809839833484, -0.5213832239844455, -0.49070240071045607, 0.6570379962324617, -0.4179491680024885, 0.7734801187449888, 0.706709477521476, -0.3216413359396987, -0.31552538036487454, -0.7006440784178507, -0.32808083941679095, -0.48705283962241047, -0.48733269124436346, 0.7747584025469328, -0.17285034939109759, 0.48075115518995354, 0.739521157203052, -0.6713893882121065, -0.01710955852153762, -0.6331644633926465, 0.8124826347310986, -0.34968866872837767, -0.4585849625786166, -0.3222024193997024, 0.1822767726851037, -0.5424217135898842, 0.5972146412721578, -0.47273171356765675, 0.6510006393952645, -0.6245148723326657, -0.42173781163585394, -0.7090544477620385, -0.5599442671497715, 0.5321673296456855, 0.8831571143596482, 0.6608329509317277, -0.1612234933049622, -0.5000309070641812, -0.38818394548629154, 0.7655691818984249, -0.2496339852482321, -0.40354930012895496, 0.7559231501454531, -0.5236898822326378, 0.7318329977056132, -0.6452820300957411, -0.3640537461650436, 0.693845582656543, -0.5960201063578315, -0.643734332244504, -0.49143485864231407, -0.5024535590159808, -0.7045198606142743, -0.5534624992046326, -0.4041938074973546, -0.6092131953179499, 0.5328835390247448, -0.47430512224336935, -0.3026191323119988, -0.4796367707704465},
    {-0.6025966858895625, -0.32816318539736516, -0.4572643618586112, -0.5752286803667064, 0.5541395704679637, -0.49061681847817024, -0.5315230948639027, 0.45821697250495746, -0.08130935126401716, 0.48662700212990434, 0.4581409976605797, -0.3786866349887271, -0.5187330583558725, -0.6858764008634918, -0.3276141246343852, -0.634252850481611, -0.6734508465627351, 0.6551456569486221, -0.5153763334171666, 0.43981709635219446, 0.5110607527209989, -0.37774442973815603, -0.11202515639566193, -0.3375932627854064, 0.6289081071563627, -0.35642077953643003, -0.5631140719676281, -0.6177023006583152, 0.29996018405889807, -0.47419755398281477, 0.7760250066639204, -0.6707556802567807, 0.7501236747448525, -0.668320996237466, -0.4705503415083508, -0.525952817135066, -0.49572382524856623, 0.3078301948903428, 0.812825337000376, 0.6867850580245141, -0.22848100331655355, -0.575607247366403, -0.5526582201780934, 0.8505887268900972, -0.37609029900046376, -0.3619337177591032, 0.4641538915562594, -0.6651123030022695, 0.6899783399709332, -0.6787343533309048, -0.4630948500324524, 0.8281119659584751, -0.5049515008359545, -0.6124673759319494, -0.6496422341909677, -0.43378298867073456, -0.6454062833738883, -0.5226146538273881, -0.31239836554457806, -0.436799512901823, 0.4103063303950121, -0.5703560543330582, -0.47137817019992434, -0.539138498771679},
    {-0.8266371039599935, -0.4471057378396901, -0.2529127378891747, -0.535340656329963, 0.7075675923024021, -0.49928061661980316, -0.5833913932826065, 0.5633517154472609, -0.46797351434234624, 0.7270963414062767, 0.602369382841306, -0.5275488665899475, -0.4994702304514648, -0.5032458996306332, -0.41991237208201265, -0.731885843930764, -0.7574117815842257, 0.6066048290355064, -0.41457019472597356, 0.3250446152412549, 0.4776245443575761, -0.47415708571585574, 0.06673501074534287, -0.5491691742486767, 0.596614510346146, -0.6437532582114, -0.5098736996461859, -0.5640299860107387, 0.34266583032594516, -0.498667004187986, 0.5341544269124802, -0.516139951908954, 0.8099384057513208, -0.7828604492243092, -0.425162844164883, -0.5357664975004142, -0.7986640078424667, 0.4763862025638241, 0.6615343715291561, 0.5781582037583213, -0.5380319872932732, -0.7457895635019239, -0.6125271462841843, 0.6394285454104327, -0.5200464644823534, -0.509785818668817, 0.4023244849742893, -0.49080758392398516, 0.8300456357260808, -0.8462425414857956, -0.6196104151357077, 0.6774360536270357, -0.7804562446178789, -0.5262000457739398, -0.49884852576363253, -0.7425097389349505, -0.8065279306293465, -0.6518825312071589, -0.4330466249281801, -0.45592384057018337, 0.4420053943209498, -0.6118464985606854, -0.600546172176309, -0.5952035781088353},
    {-0.6227094047319851, -0.6346883292519045, -0.2691947674002611, -0.6848913967873085, 0.7072393791864428, -0.33317075602528917, -0.6939797642617561, 0.6394634730475942, -0.5233691176772314, 0.777567110777878, 0.5307498999029935, -0.563542712928959, -0.3828780956126109, -0.6724223651884262, -0.3931756386015137, -0.509079079703541, -0.7097658814891884, 0.7059213592246584, -0.1709535074460193, -0.0334824977567373, 0.568075093904022, -0.8294178217451873, 0.1463723918367279, -0.46363485763013534, 0.7221483250181447, -0.3237718278202861, -0.3929036397512568, -0.5195739722529086, 0.6297997165913408, -0.6049943074731328, 0.5783961297035507, -0.6601568066565232, 0.7562722463018382, -0.6818767438476127, -0.6198474956776583, -0.7963376937459208, -0.46021970398659573, 0.6369049174727744, 0.614869475632987, 0.6325903926888818, -0.5157698511196501, -0.5624809710403355, -0.7240809443961495, 0.5437487742447823, -0.502516909578899, -0.6596558628006631, 0.584212422217766, -0.6469444242432687, 0.7620364005457901, -0.5216501273650882, -0.31581051813627414, 0.672909093589623, -0.6444362370478732, -0.6828415099351772, -0.5176647717939507, -0.7709499483648199, -0.6068376054175244, -0.730892267667316, -0.6520500836615022, -0.6918663559719831, 0.7602740317440271, -0.7766676011334732, -0.5000210150318027, -0.8076207120220255},
    {-0.6811661748634225, -0.43773596973069173, -0.4659390870997831, -0.44020361763569643, 0.821907013577384, -0.3483156895902728, -0.4726327870708287, 0.6717369975655267, -0.48280735895573645, 0.8230059080968546, 0.6863428197878546, -0.293116871556497, -0.15900087339274818, -0.632121234994467, -0.267056185096999, -0.6389716247658693, -0.7511128202256577, 0.8336932049574841, -0.27497924571079885, 0.2217632082466691, 0.7737194658313448, -0.4581417739954503, 0.09346131922895126, -0.39067733087610346, 0.7600428349237799, -0.38472623211413726, -0.12362180847253604, -0.46233931646136317, 0.40666685647815454, -0.2254397345354133, 0.5219563885925548, -0.5013066770740597, 0.5947360754192267, -0.6352546602535883, -0.7017595287639226, -0.7026180714406594, -0.551776558607751, 0.5718895834587938, 0.8109868555027014, 0.9481760915430235, -0.3503523786599234, -0.5673518104617001, -0.36316062401662175, 0.8670921572675945, -0.37580941187306555, -0.5031238963433887, 0.48521910371489574, -0.5583192962841674, 0.6622641950385287, -0.7236029096522597, -0.27678812529019653, 0.7621336423808976, -0.7272196956807333, -0.6727936101950142, -0.5543397907915858, -0.6364277485150349, -0.5322134614692187, -0.529970433277684, -0.649891193789862, -0.7309219994114737, 0.8501332659011948, -0.714640456595823, -0.5367246178188105, -0.5551860250197482},
    {-0.5106827294013975, -0.522991371826715, -0.42654369668400094, -0.2854449597103496, 0.7450717509746126, -0.27540576839093445, -0.3220479225802092, 0.77680486505649, -0.19888350016211628, 0.7916924895350531, 0.6811202168855595, -0.21043965770700337, -0.35437920565416114, -0.29248387486794775, -0.042398860877723044, -0.5570941827297345, -0.40188118913602133, 0.5560544726044984, -0.05228254126648588, 0.2624426705692138, 0.7913509210114802, -0.5272162492970095, -0.03969540402153312, -0.29999361583249, 0.819822460145192, -0.2712678480111211, -0.33295297085485337, -0.24268978469074798, 0.47434284710742397, -0.08913190768543022, 0.829967550202636, -0.5600783444624283, 0.562193845214076, -0.5528172653848833, -0.6421557937079445, -0.4196136162108226, -0.4601733708199541, 0.6484179842950534, 0.7859060258264992, 0.8324770473060763, -0.3660944992935294, -0.5609799669502199, -0.35306784509166017, 0.8635250957711055, -0.349800361791133, -0.5324099672647511, 0.8119896770551485, -0.3114277462450051, 0.7903730036386802, -0.2967460065477037, -0.3458859685654547, 0.6493454144069183, -0.5325399588408669, -0.691960070696721, -0.4442612372310566, -0.27021499139319916, -0.47546722535310715, -0.643944301003376, -0.4236709624565573, -0.6327617257039626, 0.5724963290953814, -0.437306630499417, -0.4638082333559078, -0.4845682564211894},
    {-0.5373158443116879, -0.6127692743731855, -0.117190018092989, -0.4099255244373493, 0.7194211301482706, -0.47218651403582274, -0.5357153627634491, 0.48503109837689534, -0.5108833082888282, 0.8073395291747544, 0.7650095579598153, -0.6344574636028592, -0.3699336278697065, -0.573930919558573, -0.14904134149391673, -0.5332251353696421, -0.47503175427335864, 0.5518226019134842, -0.27959078576155677, 0.26981190610738426, 0.5013405700087302, -0.6225916223404233, 0.15422682137470228, -0.4267647834506497, 0.8497841842679039, -0.5074666561833031, -0.15667183757021697, -0.548308652633781, 0.5722897679917999, -0.4034372766253964, 0.7242772939668713, -0.634320448700768, 0.6791805253085346, -0.7776609263588989, -0.5240577844721971, -0.7416576509376207, -0.48444399495370444, 0.7498314035456379, 0.8379082833750678, 0.665700785626241, -0.31430669624441576, -0.5747126800185486, -0.3907393002843406, 0.6701247649687505, -0.4132084970987218, -0.44623108619975643, 0.5654058978786028, -0.5280289019532276, 0.6940757418490239, -0.5044820146005051, -0.23344527928004358, 0.7115147253489927, -0.6227362244888852, -0.5387261337276023, -0.2740143469812877, -0.6161836069994877, -0.5252530971039003, -0.679315089086295, -0.6959181556105759, -0.4117767231259889, 0.8439153832881962, -0.6926764460434297, -0.6078852100465809, -0.62756857260763},
    {-0.5739055801613993, -0.7494178991452881, -0.26289432750820235, -0.6131272248545734, 0.5983305069858273, -0.2284945446255955, -0.7370962140919304, 0.7868315759479098, -0.5637715491605279, 0.6556914895292331, 0.7089262523793699, -0.6121263134405774, -0.4911753435586049, -0.6940872680138183, -0.033687807736563366, -0.45804140572543617, -0.8034235484275055, 0.47416360831699894, -0.17709051693347463, 0.20749167034011387, 0.5691264608705252, -0.5343017212153839, 0.00589049126669215, -0.5329553610445931, 0.6158807762323371, -0.22004047858653875, -0.06609642222100649, -0.44958634201517933, 0.6346582344399612, -0.6063747757367592, 0.6484116475531039, -0.5047485604317327, 0.7155947692295436, -0.5866216051725003, -0.5702500047275194, -0.6032465437974837, -0.48627078295793014, 0.5841928678382539, 0.7855581690042169, 0.6922373264399971, -0.47126599615441356, -0.4234422069118913, -0.36755961904083795, 0.3734819050223328, -0.2997796315184765, -0.7991145330384237, 0.32503666452574925, -0.5432845268706644, 0.6312376406683121, -0.6763295249965385, -0.4975776565333939, 0.7057185705844746, -0.8087763669102882, -0.8728071363136968, -0.25330353424622853, -0.6229506931294215, -0.7075716652717442, -0.7498900105101174, -0.7139026354427561, -0.7164372261782201, 0.6452116028798113, -0.5200000084828607, -0.570201456393829, -0.74125470227312},
    {-0.5221067859894569, -0.7161511862390887, -0.28443436675639394, -0.5486843284725899, 0.5418329758720174, -0.3948902815523706, -0.5137590139244624, 0.6930597047850952, -0.1872290406673213, 0.6285247197580058, 0.7556569470591703, -0.6310458781330265, -0.4836671242422863, -0.6991425653764435, -0.24282198989295378, -0.49427826330622976, -0.5689676728430542, 0.8036972318928136, -0.06531232470971518, 0.3956313406644234, 0.49511470468850854, -0.6392969829243038, 0.07997113269048226, -0.4635694581911245, 0.5985002968522474, -0.332627190933611, -0.14569593548617601, -0.2844278718348972, 0.2294568641021339, -0.5857661613270552, 0.6777095105986876, -0.6733346837414795, 0.6614768585288315, -0.6765543501538306, -0.5273978574180869, -0.7251415659850442, -0.5710471179842742, 0.5892015233660427, 0.6488084573544731, 0.9137261348353821, -0.41546544453832374, -0.5169383078922164, -0.5099271048803886, 0.5414520391106424, -0.33112239606351723, -0.6402221950889572, 0.37340023288529645, -0.3991005871313889, 0.5823867858764908, -0.6244105860326951, -0.3364539296949166, 0.7237088156196816, -0.7741735749115988, -0.7320940432457469, -0.30755712029578147, -0.6031274891313676, -0.5886938636812417, -0.7858108501373204, -0.576785096229174, -0.47793223589198686, 0.5171533307801595, -0.7850999520411607, -0.23708978846461623, -0.7456276433954004},
    {-0.5217543586024005, -0.5633038798550248, -0.29189862411284817, -0.3096222248870765, 0.5332743200278132, -0.40510340662214417, -0.4524227288164791, 0.6782487504352616, -0.5293348331555487, 0.7812159700868095, 0.5374195354396596, -0.4618574014034814, -0.23858011570051932, -0.712755387443951, -0.45330049918511645, -0.7263372510393225, -0.5575876912051239, 0.6061794041226716, -0.08957683923261073, 0.2830148391682805, 0.5945110009697581, -0.7426765407074221, -0.04574957130224323, -0.3452655946054061, 0.8471217448008574, -0.44338004489105615, -0.20525771656171973, -0.5961331926771237, 0.29370695917462686, -0.4591835013526212, 0.6322393863310051, -0.6912185831224332, 0.7365020599728375, -0.5252093446683473, -0.6579995040351398, -0.4367133767343865, -0.4939562149456484, 0.5231268088220198, 0.8847377345832805, 0.9655366394044945, -0.4730278767711473, -0.6975550621654487, -0.6600192757055886, 0.5986839365386876, -0.4218692342340825, -0.6869804504619789, 0.7866132621138245, -0.3740791040001033, 0.6176826062616441, -0.6799578384528076, -0.4264524591742833, 0.9154817774399882, -0.5602469701094571, -0.7018318768857402, -0.3473071825528456, -0.5515575130024253, -0.6668991117414659, -0.4801835117537403, -0.4778762154193622, -0.6278276899603774, 0.8360284912849121, -0.7734678718529524, -0.31244457608098575, -0.709558968236292},
    {-0.7805541280364388, -0.46317992964647753, -0.2545600767136735, -0.5019612945893357, 0.7840897345043858, -0.22646900894267927, -0.4444911339209012, 0.5916886126262015, -0.4956525447332121, 0.5859431339895069, 0.7939172751708303, -0.3937758275806381, -0.411077520025192, -0.6808448299396622, -0.3361750662472841, -0.4786027885973609, -0.6486459526456665, 0.7424291110870539, -0.11386653975912324, 0.249284082347719, 0.7898940246963868, -0.6157943294299832, 0.06058321027213898, -0.585829236611484, 0.7328955080870673, -0.4546527833965919, -0.2672023551337994, -0.5107815747637533, 0.6180331271514748, -0.41048279343328803, 0.6767899888451899, -0.5127294191800986, 0.698000876530195, -0.7002905980264869, -0.6133312466356362, -0.5530770834755324, -0.5058826499299544, 0.5211203522058315, 0.5848499864273781, 0.8389352903681918, -0.36685521259508136, -0.5639450366122644, -0.5542489588470167, 0.6287615773515459, -0.46319229495181957, -0.6232869125330561, 0.7328682077178147, -0.4511254464202065, 0.728265940103676, -0.49989572973777613, -0.4739021633620446, 0.8421043646744774, -0.6652248346216862, -0.8232918411972934, -0.428972544409875, -0.7070564885045769, -0.670563567786395, -0.6771354347325217, -0.5116913653556789, -0.6431639339045871, 0.539382128934089, -0.6673720919738407, -0.6055383386803788, -0.849814975326295},
    {-0.8107592212866412, -0.668017702514112, -0.2180033948709423, -0.3308358132686199, 0.44659940420364874, -0.3743728918514652, -0.47318720174089846, 0.6700046473318532, -0.3149088334844768, 0.6702700999286147, 0.5409787340937044, -0.471552549882335, -0.3041273532324786, -0.6106480938406298, -0.1659828782499549, -0.5596249987887243, -0.767946670466688, 0.5054115902169286, -0.4157042321973561, 0.15225863118077984, 0.679541074413828, -0.6925353013059145, -0.15666999006174465, -0.6559747892217617, 0.5903957749565611, -0.5247462004185326, -0.4124383706670793, -0.5395329536475865, 0.5239225183332981, -0.3876033467637296, 0.5172400279381664, -0.8166898100128628, 0.8169803780577608, -0.5950618323788718, -0.7418679854887322, -0.4384258812702375, -0.6414405582147326, 0.6156213288464858, 0.6830796393076785, 0.7888492252071105, -0.162909975981964, -0.7159624147211058, -0.48098658632218505, 0.40446047505659394, -0.5987438103137396, -0.8041357157285097, 0.4052036339962466, -0.6133325447193445, 0.7287398710049872, -0.5446607561257452, -0.4359654923876584, 0.7680202365330702, -0.47273070025585623, -0.8200963719458624, -0.424409866463567, -0.632120705016703, -0.7311303439051773, -0.6714965247193834, -0.6632473949131344, -0.6748253739892763, 0.8141346444398817, -0.8178351847245408, -0.32571416545863285, -0.6297533147363936},
    {-0.7563597908312218, -0.5710129711944236, -0.25602438365574737, -0.3747036953971001, 0.6786959837086679, -0.2514156814924595, -0.4984944194091765, 0.520670800758345, -0.40598384300166546, 0.5412933496213752, 0.7207468726885263, -0.3327488585309916, -0.3886039053549428, -0.4821957640702093, -0.1736343487658922, -0.5438455782277316, -0.5847741390695717, 0.5656226473282452, -0.29385239978650324, 0.0025435207051297637, 0.6757917881102322, -0.5841897447425795, 0.03247814111502979, -0.6270533417398968, 0.5318444828554771, -0.4457049980792032, -0.3719336656166561, -0.4041227224006326, 0.30062918419257545, -0.42693000241027257, 0.4837452578911039, -0.6710250777443003, 0.795623484526552, -0.7988371279168498, -0.7230758075935403, -0.5876372869051133, -0.39809297364340973, 0.5189196492334402, 0.8252509065717247, 0.7530015618903391, -0.18019608785540384, -0.6900453488442805, -0.5099164741368019, 0.3972840311568839, -0.298064024129207, -0.5027378355405738, 0.5681427974720303, -0.35242133061335884, 0.4630160915709396, -0.5006116398122149, -0.5386806763646169, 0.70382694980537, -0.6377199337493556, -0.8739001303839318, -0.4860020436971881, -0.5209620640706695, -0.7395954264199733, -0.6569442702479684, -0.7085801440782343, -0.7092963539839362, 0.5201086761845226, -0.6298328138939687, -0.5318988606974536, -0.6951967581959783},
    {0.1297980155173097, 0.2871654055341204, 0.07686387529248584, -0.3099988254239638, 0.3138725294354382, 0.03442419532193238, 0.28661787774683706, -0.42823512953232246, 0.49561170015438316, -0.3954379682709486, -0.5133920162538183, -0.10086594201923599, -0.00506952327326175, 0.0014713206152874516, -0.20213797317723145, 0.3432249079000937, 0.2768068663644781, -0.20869342237717195, -0.0389699917533855, 0.2496997415830568, -0.6197929409037974, 0.17050637844660357, -0.18754892845198956, 0.2945221332967581, -0.5808184742217459, -0.08907214677931595, -0.007000684561242694, 0.3359851077798613, -0.13639343284110506, -0.19755053980441797, -0.2246441455586385, 0.32482655388289927, -0.18362217424302885, 0.28256950868962305, 0.180561476659745, 0.3450499556938198, 0.1894300283617895, -0.6394465006552464, -0.10078089956129592, -0.1485693216403715, -0.337807419335724, 0.39466300095792456, 0.49281030083660843, -0.36236017803773796, 0.42411690073505365, 0.5426876728782665, -0.2714202592767888, -0.1027320342530794, -0.05534227903781368, 0.14981378714810392, 0.0685785812021664, -0.4072816679161546, 0.4485243637594875, 0.274413866048631, 0.05318801637813343, -0.2230288995596732, 0.45967848971871555, 0.39384750004170044, 0.5161304855131025, 0.18730463315497334, -0.42212593332046366, 0.20430531514534678, 0.2762098062129337, 0.47235051276372475},
    {-0.48158555153758215, -0.4979711160974835, -0.258206322508949, -0.4754277770969302, 0.07811021496383692, -0.2792034614693656, -0.37071046662388163, -0.10991522501254491, -0.2897171432798668, 0.18542559776695366, 0.15479657554325504, -0.32412262870459646, -0.44148025748479786, -0.5942769639165788, -0.5491952829252835, -0.5291761940842317, -0.5479629953831548, 0.05564623981152543, -0.19961844432279863, -0.4052586227769365, -0.24313141696544588, -0.5005107357435081, -0.5088360369279292, -0.3668467518187513, 0.15524548688440576, -0.3595643124465919, -0.4768676492246737, -0.5125091477937224, -0.006440547284699479, -0.5091661706165929, 0.1287777124674396, -0.4447154172626642, -0.2949766333800838, -0.3009855134176177, -0.5903746609307606, -0.5619170773896727, -0.19039541069475507, -0.22773617638392685, 0.05208942354853954, 0.27772630545976623, -0.3657820904785807, -0.13034258363562037, -0.23809804840336168, 0.11186347295063304, -0.5328757384381986, -0.2974763904712305, 0.3182992419197196, -0.4366789637493067, 0.004649058975966372, -0.13700572629770413, -0.5295959140604549, 0.4366868946349029, -0.6422033651506747, -0.6120838080859945, -0.11211881248167004, -0.5659831772362391, -0.5796091995086906, -0.5738542679139594, -0.3257620929960052, -0.4533991927432147, 0.16558995546097793, -0.5350019036265118, -0.19389412277422008, -0.44426570330262044},
    {0.14622799075126683, -0.10860138841630107, -0.502936300479026, -0.4637708440785669, 0.3209590972924581, -0.43355873336109035, -0.3091057186820306, -0.46949672365809986, 0.25915881018271475, -0.5565095330771527, -0.3935308292406232, -0.5760145499079141, -0.558730307896282, -0.26074823503931416, -0.6924415295262979, -0.41432837063194394, -0.2158789572136678, 0.06633826435802082, -0.7307712055479973, 0.223403717762608, -0.4450686136105522, -0.14465152240006374, -0.4222367637896666, 0.021103035766676825, -0.6014196604103443, -0.4437115954051395, -0.5406639509289856, -0.3504984488822842, -0.4539284566035266, -0.1841115030121009, 0.16637158389663798, -0.3035113938109838, 0.05689759369180264, -0.032118224583168944, -0.3192147189047077, 0.00810409467918379, -0.6135015923328213, -0.25644592489900975, -0.33747596668514285, -0.39379009522270086, -0.6642839677971044, -0.2717836500386964, 0.05905812551892953, 0.019626940158689835, -0.5258068930832855, 0.08146306978649297, -0.16335863489414507, -0.42113309991257436, -0.05557386622111892, -0.5856376944912225, -0.38064260429844776, -0.16689411649865168, 0.02660648101113546, -0.1252885579045601, -0.629585149721829, -0.5645103695895157, -0.2711612064162915, -0.2074882770347459, 0.07661292512633457, 0.0004208104802935153, -0.44687685560043866, -0.03383476116481281, -0.04485101168862283, -0.15049452324150422},
    {-0.2153845797414512, -0.2770109220736605, -0.33948192307828, -0.21941708560624995, -0.48750954226604054, -0.5565292112623232, -0.26910125237569205, -0.5699024097250316, -0.09095130795873017, -0.5604596011766959, -0.4721991693666593, -0.16407060532046808, -0.26455031615101987, -0.3481430615604583, -0.509241370657006, -0.23316765083636115, -0.16084609190237883, -0.4132446782992619, -0.5762990004369161, 0.003371770581793976, -0.2592011284109163, -0.27505818937431, -0.4164502434928977, -0.3315862348501452, -0.5153343995768233, -0.5905283628651207, -0.3843964717586198, -0.1396537175001821, -0.6797959240646873, -0.4505570877184938, -0.10969973850978684, -0.48682436524684775, -0.09774953105960833, -0.15445266866868762, -0.3359601584635354, -0.39990177760042145, -0.4939968202061735, -0.2539571345182536, -0.5784111805243188, -0.6296627583436506, -0.5222466506839247, -0.2484169017681126, -0.42354214370102744, -0.07262574476993779, -0.454793430723754, -0.08920903196113496, -0.3046696064247593, -0.4860149042639551, -0.21017890785503843, -0.42391443274066515, -0.21150448826934914, -0.36782924242316944, -0.18048710776902657, -0.30747116541138125, -0.26327924872423136, -0.2836073078242544, -0.1855467606724098, -0.2483318475079718, -0.44320942235953986, -0.03360696942176623, -0.3114455261154158, -0.17016634809775036, -0.2878020448093908, -0.39568167241713115},
    {-0.45823866489549075, -0.5073674240690476, -0.6567109638777042, -0.6690269696355897, -0.3225759645172844, -0.38210021946741496, -0.6585445453715292, -0.38182264999517446, -0.12474147387558161, -0.41745196675916596, -0.09519648229689001, -0.2633933169600993, -0.6830492127745275, -0.5714214226349639, -0.5382352445363887, -0.3897627270813198, -0.6299083052743327, -0.06988683849505535, -0.37151137707078863, -0.36073502517386646, -0.29801413041179137, -0.49517540718064845, -0.17975597320129513, -0.3437575093430971, 0.01872016664430969, -0.6430833463104003, -0.5888816032310622, -0.4909810203587482, -0.5427139924116702, -0.5556335912156138, -0.028538953971153344, -0.5336760154460005, -0.10685483057555924, -0.5371961278008194, -0.6001502090399701, -0.4825482524533153, -0.35471972704661964, -0.17218009724585337, -0.24105925878851842, 0.07451071301786692, -0.31850644743773276, -0.3894808253031826, -0.6975762785776704, -0.19775078914251734, -0.5158761971318452, -0.45621955302241346, -0.0653833266527697, -0.6513542285843941, -0.24212233468177674, -0.5248423711492277, -0.5810698192329656, 0.19437254912223287, -0.4053294714627715, -0.44004962780034057, -0.5184650797808303, -0.39768150441128547, -0.3809847598210249, -0.7043746937332459, -0.44957870099879577, -0.30624151146032774, -0.29213121506710926, -0.2859529234970218, -0.4047288114977732, -0.7324914858217322},
    {-0.6600542043731584, -0.50902319735614, -0.4707534142334014, -0.7315307589163779, -0.256468667175633, -0.2890247000047929, -0.5889213222486371, -0.4399189488728439, -0.23859933372741482, -0.5329806960426924, -0.2119665865368253, -0.577983248651774, -0.5427578790020553, -0.427274686096279, -0.4222053113661742, -0.35263067724314157, -0.40315372578387315, -0.06762969017369627, -0.3920038257016011, 0.09623361794816405, -0.29178356849263853, -0.5017624032702779, -0.6486241529628695, -0.4309716612378927, -0.28394993584896516, -0.728363058914568, -0.5965863567625403, -0.6470294267146481, -0.42594826941731245, -0.33754244296197616, 0.07011228780685692, -0.48201286629151624, -0.09137289718752437, -0.2143150901460669, -0.5111144660767897, -0.45951912139214557, -0.5047108997444247, -0.44694392721164333, -0.25802590589669755, -0.29425162382989084, -0.5147898512113226, -0.5122570760162456, -0.6148317728337245, -0.3540067825242345, -0.645624245932324, -0.2276726514044291, 0.07487414559855164, -0.5604932795135027, -0.3261540578327947, -0.6022821369095475, -0.38463952214049324, 0.051047586537899856, -0.029213693279446073, -0.3082607506387581, -0.3656157750855371, -0.7648627690421539, -0.5157452052279654, -0.4903478535696361, -0.5899561601171024, -0.46892987071281783, -0.3594191658769189, -0.07406115590610343, -0.42151606694719684, -0.36070064423894316},
    {-0.36120130340937723, -0.418608008575428, -0.4370685565549398, -0.4506952409026382, -0.0925736961194458, -0.30753436991233873, -0.4749033601053871, -0.16747886040386056, -0.09046888470649289, -0.6630629798992422, 0.0054002117451167715, -0.3739923592016919, -0.547035018602287, -0.5912145315401646, -0.3999133164100592, -0.5599354964257977, -0.5598250701695432, 0.023054210924605044, -0.5056260478741421, 0.054447807994687555, -0.32666053700122344, -0.5937598452401618, -0.4832076704712422, -0.3992861166091973, -0.2567487960577763, -0.5513407355357488, -0.557525305239854, -0.4826727505769887, -0.39005137051934724, -0.37491677910498966, -0.13215315134204209, -0.5332294768210741, -0.04828987390392108, -0.2548462047652513, -0.3254514594796637, -0.5430626452683482, -0.7185663771146781, -0.30939155702830773, -0.2170717418141604, -0.3938140679165199, -0.2744377780732576, -0.3062068696053359, -0.5938685156069677, -0.2993334955061979, -0.5796564685219506, -0.15483703101409896, -0.06781412446763095, -0.6856593808493592, -0.020112832764708766, -0.4856676820323743, -0.7046876185561473, 0.09811145381985663, -0.1524347577419692, -0.2694159374076514, -0.49993785717428213, -0.5857435722718669, -0.3129092556786358, -0.48096002261369375, -0.4560890155571857, -0.48305629270163175, -0.6243750517694727, -0.018261471517268958, -0.12565459376280788, -0.4876850122047855},
    {-0.581194903406992, -0.16586864643548702, -0.686856549364761, -0.37187962795561896, -0.5176673522505462, -0.504868988399903, -0.42621699041375055, -0.3798314053767499, -0.46028859631944385, -0.48724535197301666, -0.208223166245207, -0.42233510027486004, -0.4625884680906804, -0.40488406997705784, -0.7011160639101647, -0.2543514989832597, -0.5014957409391794, -0.12455119435238923, -0.31225446922940997, -0.19716995260730868, -0.5911314938064757, -0.5810995311897547, -0.36552548343761443, -0.3020458940051063, -0.32380607723736027, -0.5436320771088372, -0.42166332673748824, -0.18601964562132287, -0.39117107497791886, -0.43870149700859074, -0.1558595934390605, -0.40465437437696283, -0.33970545265277824, -0.45300618932339964, -0.1526418972138339, -0.14438322474853577, -0.3603999912495304, -0.3290202070843293, -0.06185096723840335, -0.22506383238697858, -0.21488187783496318, -0.40437711072212845, -0.5030675206250925, -0.24027595912253538, -0.5148430019612449, -0.32020548105221747, -0.19436633758118016, -0.667192737306288, -0.4520596433583658, -0.3728376495656836, -0.21028187172314283, -0.08397648922233614, -0.18071803061361474, -0.19052631005954063, -0.2576484501214893, -0.6753022384005382, -0.1590549560071215, -0.21361903617298397, -0.32999391803895634, -0.3349879925331428, -0.6038744229112454, -0.003556085249626278, -0.07838450436210519, -0.28504891031937785},
    {-0.26094308293874446, -0.3217484868253522, -0.521275778276381, -0.7118812483289018, -0.09331198892144016, -0.3832532070411524, -0.5233300784676811, -0.24585658852960987, -0.43222959998371036, -0.436477562095227, -0.20984722491454366, -0.4515619725609493, -0.37426026675885316, -0.3236532863710282, -0.5365607229776383, -0.30052474969143217, -0.32334188868600466, -0.009353512264540861, -0.5430135383008412, -0.020701945413996056, -0.35059835379028326, -0.4151968280113207, -0.43204330641098065, -0.5610394548102934, -0.3463680858477796, -0.6324685045512826, -0.6437257518141088, -0.2783088641232573, -0.4159885258058008, -0.6696795855753631, -0.17155561094107666, -0.562598622385117, -0.09160621973570182, -0.41348700898846286, -0.5147725867745538, -0.46941312141242014, -0.6797087127676025, -0.40357845483210475, -0.09631727118214853, -0.40587875984457583, -0.3201702542347014, -0.16890506411908932, -0.5773776529501883, -0.3057707141991303, -0.5150406156493552, -0.17566699320704712, 0.09410015489748856, -0.59715123403901, -0.37513218615044813, -0.5280327574147469, -0.23388344508239775, -0.2918777918776599, -0.1842022818963022, -0.35803104724475177, -0.30459489049385435, -0.5009207072589773, -0.4097732787812543, -0.5456669996533976, -0.21043333106497675, -0.213292892686155, -0.5705586837792984, -0.14385728327405758, -0.012695472823230091, -0.48398725587530106},
    {-0.5884320762146117, -0.35461098431258853, -0.4387910036663348, -0.7748315185294737, -0.21619606079080808, -0.4223685521262604, -0.5664806097697983, -0.4070793798594411, -0.07260952869532383, -0.39985727220523754, -0.2509720487768339, -0.3261456604038756, -0.43325622986472784, -0.6383150954531808, -0.47663877133025856, -0.3288207853908229, -0.31029303197348485, 0.18324455399504036, -0.6586321845572026, -0.013281329720097889, -0.16873837164152405, -0.5624626709031945, -0.38903971167734647, -0.3656878017545414, -0.5244586095869531, -0.3927976973740517, -0.6458889143412796, -0.5486050316207365, -0.29749082091731555, -0.6492822850531423, 0.299483330913222, -0.5412151356557541, 0.08551881865637051, -0.4463867576595003, -0.5526591291169691, -0.3735070625972835, -0.41398264467045054, -0.3203820864471695, -0.07591894899784069, -0.45728576430064494, -0.5123440742862149, -0.28461255584075695, -0.4062392421200373, 0.078786027900253, -0.3091801858916827, -0.2765241336285108, 0.13889775860136488, -0.5672084799879769, -0.11942010001493841, -0.7408049346022761, -0.33205594816501127, -0.21595552892926526, -0.13251366555619426, -0.272607329668307, -0.5093885038559007, -0.5216072502347153, -0.21523836165040705, -0.4816397342934107, -0.23196264126927998, -0.5106287559637787, -0.18818036496299514, -0.0007089437333440661, -0.1355494757405113, -0.4129137259995463},
    {-0.557048375166649, -0.5372730433746898, -0.3904091198032662, -0.3555309117639757, -0.05690173852605422, -0.67086559041972, -0.5957669928962867, -0.5200162837310045, -0.4934303721731494, -0.3336818450829386, -0.4001611248462567, -0.28351545155582963, -0.4328446787397283, -0.6079154972729632, -0.5176695194418263, -0.48669979913101724, -0.5259869098274692, -0.28439663205178567, -0.6900664432837282, -0.1490528030023343, -0.5110100087076859, -0.29320973595548366, -0.2790627208863978, -0.5321417115610333, -0.5044917521560351, -0.5379069817782209, -0.3712729899509141, -0.36639906799542726, -0.38715084343264494, -0.6493557402223615, -0.34498196844918283, -0.6348479172727485, -0.34430715583269933, -0.42683333071310386, -0.578712588986696, -0.4177851311027932, -0.2939274079300326, -0.3368397515335298, -0.5324988595712414, -0.4683990916085006, -0.49721181525884117, -0.23412777395659728, -0.39089773591097315, -0.45668664389559427, -0.3031810410374666, -0.6324752349450213, -0.08177359663029377, -0.5268260331085991, -0.20600889716016915, -0.4858720895495257, -0.5407628802889611, -0.3394292876801761, -0.1680975894167058, -0.22512465635538476, -0.6207589942540026, -0.6733032277927009, -0.5576988692178745, -0.5105010927869992, -0.5205818648757109, -0.5386873467900611, -0.25211413792823395, -0.0672647024273501, -0.47510091315206576, -0.5346142208073438},
    {-0.5640936605659537, -0.41637499086243945, -0.4808124178748802, -0.6663371685780882, -0.2137702406868398, -0.4620633723272638, -0.47602195121091656, -0.6414578338390863, -0.3284887817836098, -0.46073294591665687, -0.2537790426800314, -0.2966141606654529, -0.6932360806712614, -0.6506353605604999, -0.7979950462451091, -0.3764417458831195, -0.33919684648889464, 0.027407780324094404, -0.6056494478711991, 0.016102107013032413, -0.37030858407094586, -0.24157999364268823, -0.5265602662036459, -0.36623831487452757, -0.5141743325478381, -0.6472359224764811, -0.4400910293621604, -0.5439384613696413, -0.6584414193257775, -0.5640283698740972, 0.03556343660726237, -0.5926814267721341, 0.039751214554382124, -0.3049551935569963, -0.43289161110698676, -0.3417297656259444, -0.4082638277189588, -0.4560034693993144, -0.18157705968204685, -0.24063056297868335, -0.6605627639399373, -0.2088908938170031, -0.48586345257370844, -0.2647991324308383, -0.580500895529018, -0.27301396828584973, -0.27668648921739364, -0.5579625052687277, -0.22373589267091604, -0.456986292707613, -0.3098571451451197, -0.10077912755597188, 0.006130304371147084, -0.34759902799013415, -0.6396664284403485, -0.679118722908303, -0.3288665294813082, -0.2556087223317452, -0.44101052891844306, -0.3568004000784727, -0.28829184173630074, 0.09607394940287907, -0.34711790998676245, -0.39041088912085187},
    {-0.6785024985839135, -0.21433069801066446, -0.5873949636314807, -0.44285682274659693, -0.18144568448844053, -0.4738783851551284, -0.5948877290202735, -0.6919783982267117, -0.4230185645509928, -0.32651650561781836, -0.36148648191120897, -0.40710948184221324, -0.4321591826470666, -0.439926225290589, -0.5852758408317527, -0.35690599089800684, -0.28767795520661, 0.10016528978860922, -0.4590920897734807, 0.30278559486537704, -0.4382571622778811, -0.43228213988496333, -0.44360182768548273, -0.38313661599090376, -0.48067540732916314, -0.4748612786386338, -0.38401900936331074, -0.57676977597184, -0.6469267486281929, -0.5301173847966855, -0.021286852787060724, -0.6936574422634123, 0.1343002073158603, -0.4556330703067394, -0.3911621184884704, -0.25725833523010283, -0.6632384905733514, -0.49359136293190575, -0.2531295070264778, -0.3883406839095989, -0.37215085971005574, -0.4412602122793478, -0.5327965256272744, -0.3808080179015026, -0.648414861067519, -0.20425590243838784, -0.0012094338192122616, -0.32241995905854315, -0.03802678072831549, -0.5819325635534597, -0.6249365943001425, -0.24909415512854763, -0.19418936868359002, -0.5346900875715361, -0.44087181713547235, -0.4834875885062143, -0.6456406784989057, -0.5360126764652865, -0.5716959154924736, -0.3253391526856643, -0.5692883167331939, -0.0018999528855255302, -0.24429485808000667, -0.2830930576627429},
    {-0.516131759617697, -0.5515845247950872, -0.4672265617419844, -0.6248972548878707, -0.17104438388927493, -0.5110827681813442, -0.673332173588804, -0.7674276028813053, -0.5027012922310075, -0.5808089931999086, -0.3166550033218027, -0.5745679095053904, -0.826709719028558, -0.7171276912439981, -0.5267561172174067, -0.7266232390963732, -0.36116023644294454, -0.2884794106346329, -0.760472955137862, 0.1606963965857464, -0.3273683742553333, -0.40996121040225636, -0.46123483927129183, -0.547683496647036, -0.3626822230109301, -0.5870816641953667, -0.8088524215538753, -0.3700487634006466, -0.4486995764333188, -0.3776455698933553, 0.0013129015361388727, -0.6484917354823481, 0.023504417469640944, -0.43822001572130437, -0.31803986240703075, -0.6096055181218906, -0.45483615307747116, -0.3875046689056007, -0.42737159742326347, -0.5632575611732894, -0.4676404949263276, -0.3132525443769245, -0.5908866449518653, -0.33649060619948234, -0.6234191006878556, -0.46312568662960363, -0.16473037222264494, -0.7166498554346481, -0.041201149394206694, -0.5502928731206305, -0.6071706315919574, -0.10475448504046521, -0.2655010086370521, -0.3734810751741582, -0.6316843756084589, -0.7545096106470626, -0.34107917870607063, -0.45426756697225323, -0.5695095532346169, -0.47097641531883117, -0.4765550532509192, -0.44480181572071265, -0.5258702625662232, -0.6835101074164317},
    {-0.4811029123496701, -0.47268215546617515, -0.7002286341598413, -0.5229405095573649, 0.2834668344579749, -0.4037303194373089, -0.6094170496542485, -0.6571760370239675, -0.20608500106135977, -0.6190185976443604, -0.32518640587914766, -0.6074159906730234, -0.666878012939368, -0.5632165488017622, -0.8029438167476343, -0.6089570812164237, -0.30790854792704386, -0.1782656349251098, -0.7434426742956352, 0.20378926827946875, -0.5416720013684464, -0.5843034498244521, -0.5810177037740549, -0.37899029892846975, -0.5752611164409092, -0.7117568113986406, -0.7710501105853153, -0.36905001025032763, -0.5843307674335251, -0.3893762757903496, 0.10346097235063506, -0.6097947884767654, 0.17756835082994457, -0.32980500615713904, -0.2564733157595889, -0.33793421601900536, -0.617626441544777, -0.5640108660792871, -0.3759866781070571, -0.23516653254739103, -0.6269851723922988, -0.39829496912610335, -0.2717608144462748, -0.1905002435882, -0.6435069099528696, -0.38284794269833156, 0.23423031339452258, -0.6488203102462374, 0.047895534975683746, -0.599289325567394, -0.40083066132363004, -0.1984456306772641, -0.21482253039875757, -0.21001734785769574, -0.6147192865949491, -0.7727625125466053, -0.2582276733272626, -0.353321024996027, -0.6337453011660956, -0.2673716942395768, -0.5958610110677386, 0.13096470916203484, -0.29601797566925486, -0.4681134051306536},
    {-0.18014851507624588, -0.3775541633784569, -0.7166257785319552, -0.624384710136648, 0.06468161724426177, -0.7091292900781393, -0.3468815062710695, -0.36532167917404496, -0.07703910644409649, -0.5947678991429366, -0.24761939961939478, -0.4241224232301825, -0.6150062821344642, -0.7116117148117428, -0.49264215716525506, -0.4482157347859235, -0.04026249649323999, 0.10418341141069899, -0.5066147359554778, -0.03558955203064559, -0.4844171971246102, -0.5027017557189001, -0.34071283324491825, 0.020109226632012606, -0.6204860605505761, -0.61849431689513, -0.5223759362683313, -0.31420680492374886, -0.6772250840185835, -0.20468967148618147, -0.24947467001106113, -0.3862757238132192, -0.032573635259944854, -0.3784107031768185, -0.23877730805673275, -0.21279386142741685, -0.6733232638976183, -0.328243650354821, -0.11206512927124883, -0.28187320010962486, -0.49979705586405526, -0.4125829214253566, -0.25286974478175916, 0.13407895394955593, -0.3851506949203967, -0.2376215226127914, 0.07361117794639803, -0.39234420450846963, -0.25100416830799327, -0.4408198417271271, -0.48825252186701396, -0.09839439489340192, -0.05359169483694231, -0.44033733481548987, -0.4086871751616033, -0.5304099440829713, -0.18539377618755934, -0.3696651267895331, -0.39382300995792907, -0.267444065274855, -0.6342610482941724, 0.13682421628518246, -0.29939883371781006, -0.5023562064171941},
    {-0.4666609780582939, -0.1843015872373506, -0.6182358998111872, -0.5293130673495743, -0.3753794823114158, -0.4387184716302062, -0.6443486494737541, -0.6799369481759463, -0.20198764053677407, -0.5616322524656242, -0.2722431739499879, -0.5479855839555481, -0.6192449474559093, -0.43342766630988294, -0.6668919093759025, -0.5496789386760269, -0.5615662733313654, -0.1960484749841489, -0.6654883106174453, -0.04369664054633348, -0.561452256797491, -0.3847003080671247, -0.7063442829684079, -0.028146483378734006, -0.3323821961401446, -0.4695225430407538, -0.6812133333767105, -0.45093719942384763, -0.4655341335243025, -0.46008394536753716, -0.31068445057648175, -0.6059126894315515, -0.27724978716660614, -0.27143991086086405, -0.3495530858654678, -0.40100395494326985, -0.6356375700675627, -0.5148337722666593, -0.3471834167734593, -0.30267520440946516, -0.7058595468673029, -0.45278472838620865, -0.5487041413063934, -0.015791162188307898, -0.4711247521395196, -0.0888538715582644, -0.06200336486185541, -0.711038900071064, -0.06156232114855447, -0.4092176313839075, -0.44346390737615815, -0.2769425436913802, -0.4703215297014707, -0.25763584335556006, -0.6532224409016135, -0.45024213099184135, -0.44678818479673904, -0.6526979744165777, -0.3698225156435838, -0.27102510011270947, -0.40454447853085, -0.041076195155294634, -0.5336179346040383, -0.6111483900957321},
    {-0.04783522123398174, -0.2609782487869388, -0.5275607188577859, -0.4166700136392831, -0.2579798292286164, -0.4016568006129077, -0.2635115980826545, -0.3992228104519675, -0.14975173696069252, -0.28927661721684383, -0.3402565469378338, -0.24652227314163572, -0.5491290769002531, -0.302668795608374, -0.5942536123745028, -0.5609752572861084, -0.20521496413533302, -0.11857338319467066, -0.515573755518491, 0.16203191254185312, -0.22464972275272063, -0.21389378930394848, -0.45431807154256637, -0.009847995687601566, -0.5695304427577109, -0.623268802871327, -0.6676809428631691, -0.22714740550174445, -0.6212188793218186, -0.41659861167151846, -0.0028293360326716315, -0.38565563404317305, -0.1925844653139583, -0.1400329690467951, -0.5361965506957712, -0.5371797880193558, -0.6096538061900971, -0.31856633433119946, -0.4237856772484661, -0.39304581847069087, -0.6226903553155612, -0.23927325766707555, -0.25365574214875447, -0.10830316808351907, -0.3633476247989447, -0.24708719869813894, 0.02030900132419953, -0.5575590786221257, -0.29326638408154976, -0.4426819363456144, -0.4103021198036764, -0.00717718495064403, 0.003598173587048923, -0.41493497385168115, -0.3199284811335452, -0.5231005189998236, -0.35464596266005644, -0.4773636793440409, -0.08779511607644636, -0.19484443342384028, -0.3045895354918654, -0.09249491898712957, -0.2869105639860997, -0.4338928637135083},
    {-0.3210934045543488, -0.26795560455424405, -0.4453626882993535, -0.7087632554505322, 0.03290036756100887, -0.6788023580291245, -0.6722935504904045, -0.4610044226078482, -0.2238030004105133, -0.5350854098026194, -0.28596514719972094, -0.45013634784408635, -0.47160532802184585, -0.43255655246478647, -0.428852416695457, -0.5941669965669512, -0.2049628175571337, -0.05488385647249745, -0.6894190674496729, 0.06840872390288572, -0.39607723727580735, -0.40201750480345483, -0.48696739728782745, 0.0032633143400166748, -0.7204907762475002, -0.7017718522743462, -0.7183068953459368, -0.5477229401507026, -0.6919435171944295, -0.2633450115073981, -0.343808728846524, -0.29164216597257053, -0.05512594101165404, -0.3917474592801738, -0.2997520127239766, -0.5416543767675918, -0.7046885256911491, -0.48634620170298665, -0.21215167429880877, -0.5736286614433682, -0.43047212769810583, -0.14363124873492722, -0.2755108419468159, -0.14582141574769653, -0.5136368823158267, -0.046087871087427124, -0.15963997482533196, -0.6788952695794651, -0.23461981237772606, -0.3562965817607934, -0.30639655031557467, -0.20992270445038372, -0.2781701704140359, -0.2269138111950116, -0.7127735485258372, -0.618827849629618, -0.3380490260081003, -0.6449135082520164, -0.24357851226216515, -0.3787729420030869, -0.6577944732154394, 0.1106646465858855, -0.16401340142443938, -0.23913406100575835},
    {-0.5918007315077128, -0.33139825314461285, -0.4529221034990774, -0.5377091910551542, -0.17902836575660808, -0.45815466248012215, -0.41970307838669935, -0.5131403853199725, -0.02453605016091441, -0.6368968015810065, -0.5320469681274436, -0.6923463405765784, -0.4753657492777046, -0.48280383218657824, -0.6695784741926198, -0.41787688635125037, -0.5408731843309138, -0.030377909755712834, -0.571672179548925, -0.2082336013290108, -0.48837885822367577, -0.3566788919353082, -0.5344326802487179, -0.22574797539850755, -0.5759777590687831, -0.6393775928138891, -0.6847104067301216, -0.33561120490691687, -0.7751354838423338, -0.47674325434546444, -0.07710394693341899, -0.5269060543012533, -0.3684821797623778, -0.2680322520761089, -0.5510085816134703, -0.5925899847675717, -0.7383599311552991, -0.7014797853680484, -0.4989477661583732, -0.33154491400299607, -0.554665786259688, -0.34011734559233076, -0.5892865600455244, -0.10486187647949671, -0.4330304736226083, -0.21285539078787977, -0.2882172696316551, -0.7415133725326091, -0.1882134374060916, -0.46905328830052856, -0.5725863529837595, -0.3066859464889211, -0.08307944875506292, -0.4914785403453765, -0.7620614317111487, -0.8304761540720241, -0.3391415709763209, -0.6048408210501688, -0.4069307516307851, -0.20263902558805405, -0.6342896499197493, -0.12246711830754771, -0.26975819059478623, -0.41580513537664343},
    {-0.5427525920017545, -0.5836583314079778, -0.7455669603544894, -0.5283518930261332, 0.050912114751472184, -0.6891359376188568, -0.6482230158398343, -0.5496947097113136, -0.26071850008869, -0.5230341823582185, 0.025443482534899843, -0.6148659573326191, -0.5253332426913735, -0.7244246762071561, -0.6896879428926914, -0.5290291423839754, -0.41541876115968784, 0.23646799329113635, -0.4594367780521145, -0.20269452900425983, -0.44897208028464974, -0.6727863964417002, -0.616794317930407, -0.48818882612355385, -0.3557484149093704, -0.4131298237060843, -0.7025762252187399, -0.6165272906219347, -0.7082259994320602, -0.36801072261389306, -0.057327740283871005, -0.74641678869256, 0.03160723053811033, -0.3927118302993851, -0.3138630348238743, -0.5484815439559798, -0.773034555930339, -0.6507452807341179, -0.27526968881875313, -0.25509492560320324, -0.7730909868150664, -0.6292926298143279, -0.320791852551692, 0.01592989976649103, -0.500845188677836, -0.40379759047559105, -0.10069542487358417, -0.685293953781549, -0.06622966579710882, -0.7551548669469847, -0.44243665450464126, 0.22411452152907071, -0.3915996390329573, -0.3369103070806471, -0.7208256748975089, -0.6489588942677538, -0.44857569500950956, -0.6823104300200453, -0.6551967614703769, -0.4117749326954863, -0.3592767958238578, -0.18179555402521655, -0.3615590729476016, -0.44122221291281977},
    {-0.2286476175528574, -0.2392693443834375, -0.5920934303950207, -0.6502536008998837, 0.3988703245935631, -0.2795956034038746, -0.6835662051330816, -0.4444113487453795, -0.05471712252354328, -0.2039275642675138, -0.20139513522385344, -0.5652966717251802, -0.6435698538302593, -0.6404518905314566, -0.6228659315519066, -0.4653438224640336, -0.32712190838096017, 0.26725481358167097, -0.5997932253355768, 0.2503645401466629, -0.021877665201616672, -0.34902114976591037, -0.4732826888895083, -0.01787917591403, 0.08534730299685207, -0.4024506188412625, -0.5079777347238279, -0.5607797901839623, -0.5284126254572875, -0.10842137249424633, 0.3195355046070434, -0.5569243185217304, 0.4493929395416848, -0.19292586568382233, -0.45738121569183254, -0.3484485225565114, -0.5376405984139694, -0.22593531164623362, 0.3666761327007956, -0.11408669239443266, -0.379554304356904, -0.3585143884631965, -0.034155249571456776, 0.5380809726980703, -0.48665041240956214, -0.09314070040291787, 0.42076445201538387, -0.2846213316450954, 0.31048510595512635, -0.3741540602985691, -0.2696069472370249, 0.5849214565591795, 0.0019491746707023282, -0.11984550747814819, -0.5986846228828869, -0.7132403092918989, -0.13471187978398727, -0.4639450106946342, -0.06959408129650962, -0.4438043612990628, -0.18817929410961376, 0.204691227103945, -0.2923282298651306, -0.33634627244580984},
    {0.5834086387569661, 0.39207623797039864, -0.40144474421174353, -0.6688980659996585, 0.5986481512103975, -0.032528026236325815, -0.20570585659080598, -0.38027942720288077, 0.6640501035325234, -0.6450172456664239, -0.4637205302225334, -0.4556475932777571, -0.5539362021922145, -0.24860105434338425, -0.6715900449914796, -0.41924372740420723, 0.29612803938614696, 0.5419668322009609, -0.6147115070933431, 0.576832281482162, -0.05939313076716389, 0.006082396915662791, -0.1801372516827069, 0.5203748174642085, -0.38408631718891184, -0.2315489635891691, -0.5278452148646304, -0.22244922599176092, -0.4810459251073397, 0.18243617938338602, 0.493255475432622, -0.10417063969763389, 0.11854280283269068, 0.32722103081379, -0.20714734961746895, -4.110952769211234e-06, -0.5564766896666746, -0.39119737833121265, 0.16580877831995194, -0.21849530713607665, -0.3572485297469049, 0.027503444982806335, 0.2889086567138709, 0.26566856570536407, -0.3513304133448785, 0.3419593343402898, 0.49973305993807954, -0.286956186253753, 0.5836278843554226, -0.1695020569537749, -0.06657738716909363, 0.4243780232471458, 0.3869350572042191, 0.5826097541888489, -0.49608583634314185, -0.6143187017031937, 0.34137644941092965, -0.36797127038866473, 0.12457480633385895, 0.09911472530815578, -0.42003790441881506, 0.46342373246752777, 0.19838970989908195, 0.10166575055549708},
    {0.3800641527227435, 0.08352035277007341, -0.48350837338807384, -0.7032165521392874, 0.40462389630210427, -0.2803822547701526, -0.4395208965022163, -0.7816490668714691, 0.13565271075877777, -0.5098487338415573, -0.37425834686480397, -0.412933203598073, -0.7095885699140414, -0.35575265933970524, -0.6872099646088734, -0.5244151647038552, 0.18247375222774803, 0.37623818920452207, -0.5047921754899342, 0.4584597105521258, -0.49284491422537324, -0.16795273754042478, -0.6099179837292116, 0.04404541592224546, -0.46773216245338034, -0.3602684603340467, -0.5759457173606133, -0.39389710539932143, -0.7166164579050589, 0.06305820745100706, 0.10574204947304519, -0.1176160435145226, 0.09983629851681827, 0.0038469718909878024, -0.2712421018162643, -0.07541163135581323, -0.7378257259620526, -0.4356084930202236, -0.2916221935694415, -0.38347356190489074, -0.491706677249345, -0.20894451571093667, -0.11541291752413285, 0.2665549619363315, -0.6438322079542386, 0.14698697310079692, 0.34625751778335395, -0.5687743986280229, 0.14042266457378566, -0.39419552242602796, -0.4847820470933895, -0.024533095222214914, 0.26030253274378257, 0.2988676993051607, -0.4020401596682263, -0.5626362107084354, -0.06450586747160227, -0.3366135071125981, -0.2222206050559963, -0.038964945048871664, -0.47499147930892976, 0.36619932958122536, 0.06125698163435641, -0.01999063225311522},
    {-0.21529122742229534, -0.46767808923777554, -0.587893788963104, -0.5852598636925825, -0.09816927655178398, -0.7632201716834099, -0.7238447302047881, -0.6603766738199978, -0.25974735860546155, -0.8151495135776774, -0.44767832513225725, -0.5790093834398149, -0.7491698097282801, -0.684484579113546, -0.6735686612578946, -0.5473681964789543, -0.28407562624815824, -0.13897302894057212, -0.49084402423861134, -0.027959531159672205, -0.39644850944745863, -0.34591627652555906, -0.6695448230215608, -0.36553413850156063, -0.672283745292871, -0.560283419437855, -0.6770482358377505, -0.697369687328576, -0.8439715486463477, -0.3617283991192055, -0.053420025756298034, -0.5151504101875449, -0.2089171395203284, -0.36816060089175534, -0.4807581523689483, -0.5670690241250148, -0.7025842380452311, -0.5517616045156555, -0.2038712033288603, -0.5318350735663837, -0.815499335935203, -0.355251343330095, -0.44647335539162747, -0.23608635913159468, -0.4179107265186669, -0.2165300781806364, 0.05255025529251253, -0.519576517923716, -0.09442149296747583, -0.7333361788657159, -0.6344465332233024, -0.20427095106893878, -0.45274845881937603, -0.43686234855825, -0.6778376404548125, -0.563426843295162, -0.3529715492803581, -0.5249215429889149, -0.5734137274944563, -0.542192179700323, -0.4293685516310403, -0.17464526128882965, -0.3281928204705915, -0.4227692005971729},
    {0.31827898515935843, 0.03550335456355667, -0.5887012721500144, -0.3571063279305512, 0.3942897843770803, -0.5007341074939894, 0.0022857309918758264, -0.6285586450802669, 0.2807400218561462, -0.7036603022579087, -0.41681293748307485, -0.5711713388574293, -0.5669047355369264, -0.2803343096507934, -0.6190793860184924, -0.27833175779611125, 0.37343604047982776, 0.2561162471319042, -0.6867522105566759, 0.41608125177689476, -0.44994388493941323, 0.12208469369682583, -0.5248547364455222, 0.32018118145575347, -0.4117065749407837, -0.33031557036004255, -0.711155377733511, -0.4369012698377529, -0.657685210280487, 0.02161277016808682, 0.11406409666275955, -0.03696507693482545, -0.14130157940842536, 0.25220548306500545, -0.26213757196214343, 0.028216399451961825, -0.4808134246070932, -0.40483937657996355, -0.3018503911431122, -0.6754098692380602, -0.4281181852291489, -0.08404428614296282, 0.33707902138089807, 0.26564063062360876, -0.27506836421582315, 0.4166821871673466, -0.06656608366881864, -0.4293339105016211, 0.3066072873308013, -0.38646266194008044, -0.2746620209488194, -0.111595770505441, 0.1930845074966264, 0.08842502364720906, -0.432281662332274, -0.30985154535847736, 0.1722845365204803, -0.25545015415700445, -0.04947416887212764, -0.053351750493576086, -0.7148426352726166, 0.5085028038516342, 0.03242471131409722, 0.08791286513112449},
    {0.2384394122370204, -0.04718984184357924, -0.6117322907609009, -0.7504656150896304, 0.5638015201497637, -0.2864499268112066, -0.4716190146921372, -0.5849962798060749, 0.16784425637480993, -0.5994444953983461, -0.34694629882078637, -0.3266177191394002, -0.5386073343862169, -0.42895865158724933, -0.7386589518414554, -0.3382030579236766, 0.17934235778383775, 0.11980363334197572, -0.44619787450334236, 0.21084953330554468, -0.2944297624739828, -0.1863110636774589, -0.6128456814533296, 0.1196324863902439, -0.5804234442347961, -0.6710366452778116, -0.54428631204176, -0.47510928007915365, -0.6647836952987247, -0.12257144834376871, -0.11971983877185075, -0.20187490114076986, -0.19037350482264517, 0.03161204278443297, -0.20137096634462398, -0.10627896344701164, -0.5272896136627946, -0.35139788596787275, -0.15470569477611995, -0.21834347706821264, -0.5099950061236425, 0.10180312865976095, 0.1505904320685815, 0.4042829458647291, -0.5016317541935604, 0.28699051313766, 0.08102122036274885, -0.47812867125355507, 0.1379527837699436, -0.18572909878505722, -0.44839460002396375, 0.09140696211261438, 0.3023892986972179, 0.09404038968908517, -0.43384257266947346, -0.5661138115328053, -0.10228389331092613, -0.3075590646430827, 0.1765135308429648, -0.19598510352608745, -0.5229395715917482, 0.5236459783342278, 0.1368756695236898, -0.3142372997341167},
    {-0.1713085906918182, -0.228757680757915, -0.4453966780103194, -0.5442245837604588, 0.4508301282314024, -0.515342469983003, -0.5310294868718283, -0.5363026590732988, 0.29876927053370816, -0.6542715729315924, -0.2810976262302201, -0.6883239139368118, -0.6437744605589746, -0.5931867724724117, -0.7843989209583943, -0.46740093972086305, -0.0359145482731155, 0.2691279604366005, -0.5584453966545148, 0.4084872232172277, -0.5620151125591951, -0.4385968127536377, -0.4034104544368408, -0.11587667972624867, -0.6585155837594818, -0.7276339965003062, -0.5864001408854359, -0.6095636912840038, -0.6434606119207136, -0.35732522918761506, -0.0015798286820883764, -0.3627685537591698, -0.21877278304478126, -0.0708611931951072, -0.307979847178347, -0.20086152681939298, -0.6707545277998316, -0.5154407032400601, -0.4504881466097647, -0.5334004122771298, -0.6486742925622327, -0.3680632996843472, 0.10030207859505869, 0.27621330173558695, -0.5749447429595387, -0.1392318359115043, 0.1754167009159798, -0.7115234746590839, 0.03202032017677186, -0.38018711509337644, -0.5602179651500556, 0.0020103404908399045, -0.1427475071614789, -0.23391663941104254, -0.7079545887555247, -0.5939485661043723, -0.028636493863633695, -0.40567613558580784, -0.048517327512954476, -0.19769996647651636, -0.6596474711018696, 0.2645682631694748, -0.08948594823574367, -0.22806449803658915},
    {0.0755844954212456, 0.05466955236334977, -0.375812287042547, -0.7967272758357761, 0.22951701599981775, -0.6385013255438792, -0.515526169722444, -0.6223824637461377, 0.3852602508967913, -0.5745839364058132, -0.5830780131232474, -0.5029080697126848, -0.5098654520897715, -0.28857493893345, -0.7817740230607746, -0.2185488493883812, 0.12791905028679978, 0.046449780619690524, -0.5383552386972407, 0.20034783518957153, -0.5615739875242356, 0.05608732980505692, -0.5123319355761458, 0.3737634168740153, -0.38215629307685806, -0.3488488091919959, -0.7491508867784937, -0.35944516903563883, -0.6759099576024571, -0.2119999049114361, -0.1351235079749275, -0.24073770281567358, -0.05672059778991498, -0.1182802634290962, -0.32069346158193723, -0.26698957011571756, -0.4336054221392369, -0.5317609902124013, -0.3447885690054647, -0.6845424077167234, -0.434989454910154, 0.011538264689208941, 0.11289945060447745, 0.3591860279102284, -0.23010993407932737, 0.2769729901175574, 0.01830440395264639, -0.5043468466344637, 0.29033389683768823, -0.3761352413567164, -0.47195541270788244, -0.1826786439668242, 0.25663382298421117, 0.126486960282435, -0.4626948501562462, -0.4824939536032793, 0.04821795293931576, -0.33119375044101845, -0.013815545108484055, -0.023701977333499293, -0.40456595912895976, 0.41580620399186546, -0.13374909205030655, -0.06610963161325951},
    {0.35783585897391607, 0.32504327325582805, -0.595527456796514, -0.7462944730282498, 0.626253194557014, -0.32290405869875277, -0.41984134548611646, -0.4862566136548501, 0.4704435347687326, -0.8353204196300933, -0.5250153647990098, -0.5172051148994091, -0.6391134140901573, -0.30108499283263485, -0.5201103396230021, -0.3431809569984915, 0.14642597964134593, 0.335571473654068, -0.5467963792678957, 0.5049530029419214, -0.3358095730079338, -0.0483405850485268, -0.3475118560869661, 0.2945280256038252, -0.5787653247773209, -0.27384923019172847, -0.6094687138321143, -0.571108828076048, -0.571568584294639, -0.05233007923605054, -0.12790704267888303, -0.19205976625879936, 0.13152372518763583, 0.12445325280599143, -0.3341533364862242, 0.027925609745911583, -0.4980709801808284, -0.5409334707573742, -0.3270611657696653, -0.609729914128748, -0.4704267327634885, 0.11702796171212088, 0.48102563664282905, 0.3792802158173928, -0.26231211192861337, 0.5393508419817908, 0.3796572664745015, -0.4758434947321754, 0.2553794925289083, -0.35491831773809684, -0.31008664595783497, -0.21224885082348183, 0.33933402358676873, 0.33149837946285715, -0.4605354088539646, -0.47049488571254827, -0.022424951502989298, -0.39331075255557285, 0.16435657023287256, -0.0003819049894625634, -0.3394027149133895, 0.5785591465461175, -0.08835270921147596, 0.04460545232130792},
    {-0.2563576972068071, -0.051056233644551606, 0.4779347018998374, 0.15283196627203396, 0.3665375048489682, 0.24390923595568018, 0.008710055577466163, 0.4031562217694952, 0.446421084801207, -0.09359073963783575, -0.5667254093262509, 0.24650746930269987, 0.48408894448315215, -0.3843874890529938, 0.20221202478416261, 0.22667451155818766, 0.218159846959894, 0.2849225325147402, -0.33064708163108747, -0.48522301221716396, -0.44837314804945244, 0.12525560915475029, -0.60475796640618, -0.12199142320425861, -0.6102632033607002, -0.6093534122653016, 0.34634365799208616, -0.609953440564664, 0.43627257590448737, -0.36311752735886743, -0.28878349144292725, 0.4433886037064004, -0.4426484809900815, -0.6765506945421158, -0.5787035302959972, -0.38470687328462744, 0.254838742811079, 0.5499444811357594, -0.5882720089424632, -0.1834566973548557, 0.2144970685430618, 0.19958390062705936, 0.11994364531656353, 0.19658209049985848, 0.3417943207977681, -0.11776825656779762, -0.2669824195005916, -0.003358446738625645, -0.4576455505754964, 0.3875421353985205, -0.7105434749412513, -0.3576326960730942, 0.3342095571339705, -0.3371578264938854, 0.396102415512634, -0.08931877406064603, 0.08487623112863295, -0.3449932650407222, 0.19330259375456824, -0.48610990313986513, 0.22240054782253044, 0.07818867698573397, -0.6759896875215596, -0.022607549379327137},
    {0.06123493079866396, 0.31353435469019253, 0.27933351477245716, 0.018725822867990974, 0.11480666149579097, 0.32946978334249244, -0.23926548763700473, 0.06238038770033608, 0.3435416355834744, 0.022693245100247516, -0.19139585668217468, 0.5454997783127995, 0.5042891820194442, -0.19978024541636677, 0.36191030123775225, 0.22839515876078545, -0.0034527171723549898, 0.6988833081540817, -0.24757348660856685, -0.5349351221979166, -0.5872316891087208, 0.3312375337088868, -0.5736949097597118, -0.45295124540693077, -0.2657870602809248, -0.4647997873136973, 0.2191490205954018, -0.3788450925075001, 0.5249747686577952, -0.5036355285324605, -0.22195510907731913, 0.14107273882970986, -0.43910114187157806, -0.30315119185568945, -0.27197338346413547, -0.15683141991871297, 0.42036339704130526, 0.5331019260108348, -0.43626821702027946, -0.2859183272593363, 0.49015491954179174, 0.5143660547861093, 0.3933956679369586, 0.3594900649376527, 0.3100534514680367, -0.02598842947823139, -0.14953825185099034, 0.023741295990767634, -0.2559649566445809, 0.1057396341764757, -0.6049187872496016, -0.18111293852188395, 0.4104855566974271, 0.005685986592329394, 0.3720589952971434, 0.14111205595166837, -0.17146392232958776, -0.11070834228683112, 0.6314624896074821, -0.3719183220379288, 0.2359570817596713, 0.045648828170727004, -0.22158979385876404, -0.1303191726852393},
    {0.24060843692102818, 0.18383819830725423, 0.39556745817180333, 0.05973728811685212, 0.42043995450620064, 0.32291798661009596, -0.233906091700966, 0.41674406227058575, 0.49413250908738615, 0.01086385467722201, -0.44000150429942564, 0.3408523132725184, 0.5562797208318055, -0.436201610671397, 0.21180087957058835, 0.25017416987456365, 0.36133834669788617, 0.6113852931066595, -0.05803666339057987, -0.5724918656404605, -0.6976011165643581, 0.5352305584661305, -0.6542628363994631, -0.4948349004997912, -0.4198133412709307, -0.43727069300193727, 0.3688646869009802, -0.4993919558516003, 0.4667895514990465, -0.18663344869491327, -0.4129409992479616, 0.22801181623362846, -0.35525424195112904, -0.32282589229042746, -0.5650486187654747, -0.2636794390828278, 0.36562892037422207, 0.4702329622793541, -0.44040929389379296, -0.2992428029838593, 0.3475465829258581, 0.4732535194631236, 0.3025251227511608, 0.6914232270303268, 0.670543828594859, -0.3385087568218224, -0.23063377715814842, 0.35054424499708975, -0.5933395950099835, 0.5205957752685904, -0.3733238076596265, -0.1239906568771972, 0.15902848089003865, -0.40630857334598786, 0.5023145957861395, -0.015168717289915045, -0.012979822443831841, -0.16545553816502642, 0.3659415476568678, -0.6176620535094183, 0.26801007019397355, 0.18405400806960118, -0.5403592704144451, -0.14915206305568546},
    {-0.09159313024754275, 0.22322422768143718, 0.4430478775814865, 0.41492890277823885, 0.1707548624592434, 0.5616466818040037, -0.3564991650335146, 0.3384090990617758, 0.5038872329083143, 0.2764517791454646, -0.26974479588162065, 0.4895222354640375, 0.6156613794030145, -0.3532955631700253, 0.0004541900740495442, 0.46983284937845277, 0.4856457849479482, 0.6262848820910686, -0.017391679351320494, -0.40410983648081816, -0.5557643535373081, 0.5038712818503445, -0.5247017872599384, -0.2422109768460605, -0.334127468209409, -0.40161336951643545, 0.42740559050852034, -0.6766962313436106, 0.13547305508946805, -0.050830975658599925, -0.22768249136795732, 0.6427857404494728, -0.5113378940191408, -0.31924247327719535, -0.5502382204102312, -0.1440123920882172, 0.1909314987663642, 0.5173301869420406, -0.5608807393707431, 0.03693547896594721, 0.3270940891673928, 0.3300261578291349, 0.4597089843665639, 0.5846022053969013, 0.5433881470271966, -0.3902270649618077, -0.40678184220879265, 0.1631402636922462, -0.478752721625205, 0.3994003974474746, -0.3870160100719172, -0.2976754422924567, 0.3775961656702382, -0.40453077580885843, 0.16158804755073322, -0.16649432648211257, 0.3769949781196308, -0.21289904540740381, 0.5591846135965806, -0.5952810022946514, 0.09582972923195246, 0.40088973585015714, -0.5356021724968558, -0.27198143271123765},
    {-0.07920753000217758, 0.24508243269632216, 0.5206874847804891, 0.1638495044686072, 0.32443481741963653, 0.22067545355809118, -0.2783868842774993, 0.24558803480410604, 0.6390292120532677, 0.4554692029973868, -0.4666601406049357, 0.5596949381848407, 0.44787720099856115, -0.45137645065138304, 0.16854928688270437, 0.1524623409599111, 0.16813197186325518, 0.35119702383872414, 0.1743493092164434, -0.3751630545587733, -0.3802960181737762, 0.576900543793303, -0.38037159373367907, -0.3269022347006418, -0.3739346985289019, -0.21246774362579143, 0.5598019582852715, -0.5898740640023272, 0.3908873585625985, -0.4531254611603856, -0.23864797033127064, 0.44732919941389115, -0.5345815042778392, -0.42268462582251887, -0.5785430983588425, -0.22641838914524445, 0.21044035068941, 0.3745879988093351, -0.1310158672317982, 0.046559379076648776, 0.5323457851855713, 0.3554691733201505, 0.5405452088356582, 0.45280323823944424, 0.28650708827734445, -0.4148604539111836, -0.4339615567081211, 0.10959505520380154, -0.3937674809379145, 0.15183617499772903, -0.43136543581941333, 0.06715251486240253, 0.5919853290510977, -0.40759474505250876, 0.312115610591202, 0.022121883905336003, 0.14514184830467308, 0.17696899889669504, 0.6407309510967328, -0.31668740122784533, 0.3682624417746615, 0.45874024770613675, -0.6557506305469665, -0.520507196080625},
    {0.34520041397747586, 0.28245094646891217, 0.5997483506887608, 0.1492987130292824, 0.00041927193981439447, 0.2452431435155554, -0.29877724769490155, 0.30122943108660727, 0.49614608403755256, 0.4404729484017837, -0.32575803584005714, 0.5099725020908941, 0.6303071805603649, -0.10509352628923266, 0.2773797891054329, 0.10264324295159584, 0.023560345023718156, 0.3635421133784469, -0.17623548489696292, -0.5491552509441866, -0.48704726549415606, 0.3232488227991224, -0.4724107750923062, -0.22112443328536774, -0.3085931517805796, -0.5155538205217717, 0.32745488074508555, -0.6159080527379841, 0.3166063411991635, -0.4246389224147269, -0.14562003126978473, 0.21712689337518545, -0.6403195876324586, -0.5341716715440121, -0.4405067208021769, -0.44031503588987886, 0.010833159579666728, 0.20765870395252825, -0.14478601490532206, -0.15624462365465874, 0.24914374857296642, 0.20839628424338477, 0.21365094577153917, 0.568832109854409, 0.3793916946219157, -0.35130406925084534, -0.2825482105449141, 0.07813031587349832, -0.31671219389354327, 0.25165579047533615, -0.571114538509151, -0.250474206854211, 0.620694485928373, -0.18393349215104518, 0.3202275713135188, 0.01763104651658651, 0.20229849220436144, -0.15806969358624176, 0.6524713521008547, -0.4711697267020256, 0.5795002821003081, 0.25893806308971656, -0.5373741076125547, -0.4900309175267884},
    {0.35539191016088134, 0.008323229836019252, 0.4284618610228054, 0.25483956409056246, 0.18355082510479037, 0.36397084632349685, -0.2344590634272107, 0.0858441610118498, 0.5636629030507367, -0.06389150189590968, -0.28735481234904936, 0.47412983830414673, 0.4612598905133091, -0.3519144256788977, -0.20794909905193212, 0.1662020475551919, -0.0025807947945929595, 0.24307906290800366, -0.45405568684340364, -0.3378870758421187, -0.4635854621862902, 0.3531781762316389, -0.39693009384958755, -0.5179934862690128, -0.4503447474716543, -0.6655788471264004, 0.20075295252847677, -0.7564712956176387, 0.2462294811726963, -0.5547035063663763, -0.2636092768794231, 0.5716617395886646, -0.5419397996938684, -0.6839482918303297, -0.31417644466371347, -0.5725026550309428, 0.12524781822011016, 0.13972611637275703, -0.4852774812733957, -0.13022424071267935, 0.5405820656672071, 0.5661326816548967, 0.3619887182902541, 0.5320699339502645, 0.26923831875686166, -0.26648295201285077, -0.2943384570149564, -0.022928336471753706, -0.6501085047540003, 0.10441507350617583, -0.7197466208390934, -0.2260162439312419, 0.5102476553208622, -0.3445896949166362, 0.5297378159738597, -0.23877948337695817, 0.12781676951058762, -0.2516957002118299, 0.3276279857494535, -0.6915432395130512, 0.4317495529925395, 0.33410395695494693, -0.6200528291015027, -0.5720108338103581},
    {-0.01560830527431305, 0.2901048936810684, 0.678154588719627, 0.20989041417903614, 0.06598550221361456, 0.22070251392550513, -0.2102843125634411, 0.44303200929830916, 0.5452856726575035, 0.11083809635705845, -0.6174965443054408, 0.4735118471895151, 0.31868768362488115, -0.30230585633602636, -0.17090903868518423, 0.3883741562958585, 0.035978612310246336, 0.22951415402439937, -0.06221301290587454, -0.5687101177379983, -0.6734188778863791, 0.4249598076339694, -0.6663666235799033, -0.3402729975100965, -0.3726616069841652, -0.6081076904710245, 0.5349482518948248, -0.6522214007582487, 0.19367898325175825, -0.64400426379744, -0.5251066954542579, 0.4302361147648121, -0.41330450582517886, -0.7255980257776246, -0.4989892430966979, -0.5652245710558867, 0.2861829225473384, 0.3947986209449825, -0.2304849899749611, -0.3384091572161388, 0.6402902923643672, 0.44163073106414813, 0.6896540679063947, 0.23880348416203642, 0.5803282435278331, -0.4076996160937934, -0.3875696409675997, 0.08311493578147931, -0.5700028304120033, 0.5159403346004201, -0.5334624857248262, -0.552869091939744, 0.2114688193696886, -0.177026250455592, 0.42984693238332555, -0.2453358876529068, 0.24200234375811264, -0.12214959082415162, 0.5466394148132979, -0.7086253911791316, 0.5043801217533275, 0.3079318967805325, -0.6220264490072058, -0.34980534281510894},
    {0.06061139086712911, 0.015633530555529965, 0.4384730264117822, 0.31285877619936514, 0.1960758450517621, 0.3081160636104619, -0.19598840657571445, 0.49317386602707347, 0.6017747403317287, 0.392504116238971, -0.41254738153051124, 0.32872308310323634, 0.285881785990729, -0.2909096567374921, 0.21885349445055424, 0.48713807924216884, 0.459989942447247, 0.6029603777493031, -0.2570023654527192, -0.4525870091109703, -0.4505436885301884, 0.3423187050254517, -0.6580782782199573, -0.4419082635134796, -0.34186240945565005, -0.7146102127517103, 0.3126078367657776, -0.5953439327636582, 0.34510393485111096, -0.3832035982713218, -0.4577023735413529, 0.5036298508070985, -0.448043935695885, -0.6954593269005661, -0.3611626862853135, -0.37777756111698235, 0.2213458278795104, 0.30612581835583685, -0.1992244078594556, -0.2900235035476913, 0.5265273411154768, 0.5524904153889009, 0.5600107035551877, 0.620124917882322, 0.5980841108363931, -0.044503162687334195, -0.5186466366729847, 0.07617510464108038, -0.5578880212093947, 0.3127832130128909, -0.7444738171733956, -0.4209883287126883, 0.5632397602802012, 0.007741034176989375, 0.4202794918023948, -0.2476197160821683, 0.4229767668076499, -0.2303391930741234, 0.7226257023031053, -0.3663485724580791, 0.5434778998812321, 0.36973039261756163, -0.755178447543024, -0.5050686705917121},
    {0.22022454473747613, 0.24086688628517372, 0.5911547805907603, 0.2099710543496144, 0.5272270477562602, 0.4061074859257907, -0.09068741162896968, 0.48322451657382715, 0.7374774396806102, 0.2947323085248882, -0.4795437352939325, 0.22375373251458425, 0.5262880126994227, -0.4564485249372286, 0.17686700054679852, 0.4765690168161918, 0.4892777557145951, 0.6754206323265509, -0.33608146387861143, -0.5922926467071903, -0.45058073784763514, 0.3241252646375702, -0.5097667253282092, -0.3578587304425079, -0.32968666258423457, -0.6305636142297507, 0.28696013525494596, -0.5748042622501408, 0.2816350285627999, -0.18662303307718076, -0.5762765209167116, 0.6116502010782511, -0.3314623663388046, -0.7166614629226976, -0.5463841372722447, -0.3476834751382827, 0.41512649846360616, 0.42677125375994973, -0.2587897178430454, -0.26708105764661505, 0.547905190804048, 0.5901069709032654, 0.646906627548919, 0.6131088288026881, 0.5436286260613166, -0.13427030778570428, -0.45983710873329076, 0.10769928215108951, -0.4510432512714412, 0.3838683390130295, -0.7396505216800932, -0.17418376793209253, 0.6427367273754018, -0.18145553846605314, 0.3661755487842729, 0.1789773247834867, 0.4409320304762619, 0.1258646784041417, 0.7405915281161388, -0.6129990721830132, 0.39686544789408185, 0.3996487903470118, -0.5311189872134692, -0.46937487067217865},
    {0.13629323066939386, 0.36367090023875537, 0.5426923239935582, 0.2135094571942328, 0.5032202338959334, 0.5178312370873529, -0.24996276637495748, 0.22351479178831676, 0.594843931514966, 0.03580338283263356, -0.5722900769763509, 0.17838899064723818, 0.21613749220033326, -0.21934737330007353, -0.07729507240921368, 0.26946180285164284, 0.4705394754326644, 0.5082768588442679, -0.3898931074977249, -0.30438061506233277, -0.3075058042459362, 0.3489017058935386, -0.43130823493033293, -0.32297676578606715, -0.49500893379984134, -0.4123187053894033, 0.36620937763050476, -0.33829208748345835, 0.29742371144882973, -0.22939986155638858, -0.47802411128644184, 0.6644638574448324, -0.46364117287302475, -0.48956030288013574, -0.2970108796388123, -0.13619941184882767, 0.4188880286506372, 0.43725201239602357, -0.4196365615549646, -0.24949025304754, 0.382488325885965, 0.5779189751416701, 0.5161924093162852, 0.3577646093101896, 0.6621687565491132, -0.4413610314068041, -0.40175969868666245, 0.23311697433390696, -0.5099472383976191, 0.180446289949547, -0.6646771199408822, -0.10066898347352578, 0.3861918023182555, -0.20259531571464362, 0.585202988970332, 0.2650696784616696, 0.26383272477885433, -0.17134968906461367, 0.6838319647484248, -0.560883162948926, 0.346970858254893, 0.4119468374507189, -0.33335125991406384, -0.23667756533070228},
    {0.23484704674147697, 0.15931456909164768, 0.37719624315224665, 0.387705107170354, 0.44501981223389464, 0.6769853932316071, -0.38789941600423244, 0.15148698605773459, 0.5990454643821169, 0.40994876241212497, -0.29652984975064084, 0.23273265835350274, 0.31308603341899444, -0.3462599946654526, -0.006522279012194495, 0.3556199370812816, 0.41232400966983734, 0.4641871770552272, -0.16995021076037825, -0.4991048321996695, -0.5628500576773044, 0.34197167182948424, -0.3211183091408105, -0.38514792990526403, -0.515460787169905, -0.5331710500821925, 0.11010818027704113, -0.3619524235921647, 0.3014412854119586, -0.23632444326188065, -0.2714034984063212, 0.682673346310461, -0.6707493692748906, -0.6111980736090046, -0.5197547382806205, -0.18313384019582907, 0.2519109440776697, 0.5854080615961678, -0.438545417249236, -0.40001466009966163, 0.3363643226014053, 0.5298537082565918, 0.6709816380174797, 0.6462161057754963, 0.642421887997405, -0.5157997040646749, -0.33592876381392345, 0.3737138583692388, -0.3074322654112883, 0.4735962356263608, -0.7119109872534446, -0.1603123443926583, 0.5437805294802935, -0.19991921917606725, 0.4370117839345103, 0.20220565269918253, 0.4540289194072203, 0.08686065207908195, 0.6318257489591569, -0.49308255495575376, 0.5204121103601875, 0.15538539539019522, -0.4981412949482622, -0.31282957413785556},
    {0.08150505673346456, 0.2865639613896445, 0.41183253229924244, 0.12492325432556707, 0.3955997569977612, 0.7670841250641067, -0.1632808488994716, 0.449046936462569, 0.683579904762269, 0.2218561605870498, -0.26812708943614055, 0.599571641018296, 0.6733202933235469, -0.47714402803754485, 0.024119576785220944, 0.5048691224670188, 0.08989719240329182, 0.5992453306481768, -0.4277450827069896, -0.41846803580458686, -0.43195950118501825, 0.7511566658329735, -0.7071499226672727, -0.14188676009553672, -0.4593529407000518, -0.6257355360408813, 0.4941091271359115, -0.46711165813863637, 0.3671366621946204, -0.5343346896106267, -0.5415434193277222, 0.6770237796511778, -0.6328829250119093, -0.5228091362233644, -0.46631020320960487, -0.2196885576079346, 0.2192085147294287, 0.27739996472847006, -0.3428313803505039, -0.15244476991524225, 0.5562576585612361, 0.6395928932596138, 0.64980942568629, 0.40622992424331905, 0.5667443208642661, -0.28493542288332924, -0.5321896690333534, 0.4776025238712532, -0.49044181767866446, 0.31709035094471494, -0.5345952554901751, -0.5084040863701719, 0.4352082363674969, -0.1552851851751157, 0.5945835087093276, 0.018477739238613167, 0.47142306372431203, 0.07790747453187448, 0.6601609715193323, -0.42690370184418086, 0.33244595400190424, 0.4080480415496935, -0.7733417608408365, -0.4273843549651084},
    {0.026046551419675427, 0.36706956945553393, 0.5959672681912438, 0.007587168537565735, 0.040524245258573774, 0.6510111269121556, 0.082994923337366, 0.27698882088503873, 0.6356551426735129, 0.0997985905203482, -0.6063669020507784, 0.48732550261934565, 0.4799291179703611, -0.3799736762290486, 0.15305349089509956, 0.6942552047776847, 0.004324587787015043, 0.33003660639660054, -0.31670270989130084, -0.6183010945780462, -0.5389451198543072, 0.6994129047548723, -0.5511316214472824, -0.16477266130015408, -0.2629096981379071, -0.6286242985911629, 0.4649832851745088, -0.47758057523037617, 0.05086329633035765, -0.19074697925780254, -0.5929116494129264, 0.5065683681538967, -0.3559059632206934, -0.6119274250623253, -0.47039814229991456, -0.22743592655669786, 0.28605356960641765, 0.21562318666292626, -0.5622002526770372, -0.007124885261292641, 0.3825791462305596, 0.4068028219378596, 0.5830011075387931, 0.433980204265098, 0.43258901495972013, -0.5142810721451382, -0.5985185369193453, 0.25019394957710334, -0.5685979589126242, 0.5030490444949383, -0.5321261815220701, -0.6257884901041942, 0.3656638072722075, -0.23068921003732723, 0.365474594810396, -0.1896921259681894, 0.2185994618929183, 0.056494426339868065, 0.4598687806586368, -0.5223124024842452, 0.4261417207672792, 0.29903489164497726, -0.6739797999308162, -0.3650002610074229},
    {0.2828502060888853, 0.19768464545145137, 0.3133868452839505, 0.1341661119111401, -0.081754927520262, 0.34214169928052296, -0.13828623465616863, 0.3056635838818296, 0.5746657823450975, -0.17950062277831177, -0.6358929215353035, 0.33696557263691607, 0.4721024547398076, -0.4156322651446897, -0.11895800835189159, 0.5225159582255576, 0.12034083977663171, 0.4340023701688927, -0.1895073279465912, -0.38831684611743755, -0.44514572910035427, 0.4464464071467467, -0.4779003381596994, -0.05905605079230097, -0.5936452966936279, -0.6168402384225263, 0.07496241369167554, -0.6317790464717754, -0.040075333571483386, -0.33368610720758085, -0.5815180274234035, 0.5754079486593677, -0.5970740496018744, -0.48731295704998734, -0.3243373017063738, -0.29462066696108, 0.1243274761239426, 0.31969857313272115, -0.28850342276325475, -0.2880968370995055, 0.5501891438595606, 0.3127557643088641, 0.3231417622277481, 0.26798526339921647, 0.6687640986200948, -0.5529836714881429, -0.6253011960618289, 0.19114136536427948, -0.45933487870835477, 0.4399035080663848, -0.36151955392428453, -0.5864757017396114, 0.5340021219542967, -0.32537720815938465, 0.1408935776026685, -0.056579017621393876, 0.33459618655974027, -0.019110065636276572, 0.5113244900891992, -0.5334239443770016, 0.31125379479871434, 0.5007582503465164, -0.7208833105400341, -0.002793145584878532},
    {0.31602126719558926, 0.08323119421401667, 0.4043480679830793, 0.3733980626707316, 0.2717714080324801, 0.644569766471461, 0.031809084368481795, 0.31982413140650207, 0.36328632526789273, -0.18600382979669716, -0.5710528367925175, 0.512578449546966, 0.37441578519790725, -0.30780298090574776, 0.07775625895263108, 0.41318089151669923, 0.2895313454679821, 0.3004862909306861, -0.2468051466619185, -0.31373719500108627, -0.7334559618386506, 0.6816337347360931, -0.3587562200260907, -0.24263513279517016, -0.34981743019724665, -0.48244075621988247, 0.37788673582428417, -0.6818091423214466, 0.3111699076322387, -0.49611633131162286, -0.5521907276213462, 0.6577516387050052, -0.47939071679055206, -0.695737668732538, -0.3485417147012785, -0.5561835016823063, 0.3011084936635242, 0.6006215843399421, -0.5535558575197355, -0.17271871388656146, 0.455080656682149, 0.43528779893259706, 0.34984886641453616, 0.40326149411225665, 0.45228899510856185, -0.5262800779524471, -0.3107757116774907, 0.24120000513248777, -0.5918448181531398, 0.2820487744565017, -0.7215774987487082, -0.4183967745206932, 0.275770703570527, -0.3789285066717944, 0.37797621794836517, 0.1579507249969794, 0.27745532850152205, -0.2997417988644915, 0.4654174854713111, -0.6539967792727047, 0.5392930484306739, 0.3070143505278792, -0.5557958325680369, -0.2886260471446819},
    {0.19137639292337544, 0.06711742387408504, 0.5794015805592471, 0.4991945600285402, 0.4118299844918061, 0.6657340945563223, -0.11628318440511158, 0.21293054180647292, 0.5232825243837713, 0.3762541296390426, -0.4549448444661933, 0.399239205055089, 0.3811036109170953, -0.5462610785620865, 0.02840067683352152, 0.2223101107959865, 0.4958267687414664, 0.3649214210237951, -0.31414304264502046, -0.6229302994495562, -0.37783797856547047, 0.45927527979642574, -0.3929310608564658, -0.352284293425898, -0.4364959527863629, -0.4824010052511928, 0.18273249522511947, -0.7262824959505343, 0.589691141388782, -0.6144567156716109, -0.29682046400115925, 0.37642547052075426, -0.5696084658428607, -0.7086979397267005, -0.6487750188722686, -0.6339393757872112, 0.5146720565300922, 0.48958407662528675, -0.5128372453715839, 0.14591504383240272, 0.5699769165686962, 0.6189400533888507, 0.5701393500272847, 0.39837875238618464, 0.7132376597095361, -0.19869555120585572, -0.34642910042057856, 0.24857496653375866, -0.4425080723579881, 0.5548060891322381, -0.7011189040630247, -0.4261538237635246, 0.4546276464006182, -0.4799406642518896, 0.6549742260786294, 0.25509055306173045, 0.42672727009796785, 0.11249601554046137, 0.6897971480267331, -0.40627694050285496, 0.44107269785749126, 0.22560734304128027, -0.7486846086424971, -0.4605882117842817},
    {-0.011534539872529132, 0.1593447327477518, 0.5057032139998259, 0.22926513657685796, 0.27170224613515154, 0.44898081762236447, -0.23409201221230294, 0.16199148633056984, 0.4810435981172647, 0.16262677053983832, -0.34548667782011916, 0.39772164566513785, 0.6445941065506554, -0.67156269265075, -0.01155513996137689, 0.34034316921542, 0.12364056838684465, 0.6580031177035514, -0.25388901668028535, -0.49472979793510197, -0.7036816071879001, 0.7261853730905261, -0.4030996363834071, -0.5054390566884422, -0.5090991498830455, -0.776226510816585, 0.05105066538847128, -0.6867249067327946, 0.2593364492559099, -0.5122130773341722, -0.6207131121462772, 0.5521718284590259, -0.602549553422648, -0.3902403883169603, -0.5158170627640835, -0.50712952576273, 0.46514622660947574, 0.5729557627935152, -0.459983123935268, 0.04083788798667183, 0.4809144215361358, 0.5092118392934745, 0.5877137902783492, 0.32829889979798754, 0.7014896785017865, -0.3603147410497012, -0.38708973812254427, 0.13793043800365026, -0.6883393959853541, 0.25084946243059514, -0.530888412462833, -0.22693099734311195, 0.6192597129735306, -0.26425748716319425, 0.3142177983664809, 0.16166653375999182, 0.3243858442409192, 0.047908575534432216, 0.373477613548905, -0.5056093560811437, 0.22190110398067592, 0.3983601026380373, -0.763173207616431, -0.29830403988123677},
    {0.2150948523557878, 0.1019296210997221, 0.6803641135331153, 0.452542763354755, 0.3710690872325424, 0.7089378822255678, -0.19807015208816153, 0.36105321698169196, 0.7420703168354327, -0.046158181476522786, -0.3255636169393482, 0.3023502019376066, 0.5378468632957404, -0.640650714562375, 0.03568431656705664, 0.4873988795599216, 0.3582438050027638, 0.6806265070050995, -0.550536456525117, -0.5980338698257988, -0.6998732431950215, 0.6848909282274194, -0.5161379320561883, -0.2734204687927892, -0.6068492588932874, -0.6924200431944216, 0.335695658045646, -0.6672789912633497, 0.22495590180376523, -0.23528172384879711, -0.4393230011730246, 0.2715990249868785, -0.548357872729812, -0.4919931619350583, -0.46256277566335124, -0.5002481698533813, 0.20306183035804964, 0.45745372782443205, -0.6056701750637283, 0.00999380499783365, 0.4633755367695558, 0.3129852821155178, 0.7575923119622135, 0.6072841077922385, 0.6366786155351051, -0.18718044169792736, -0.300047393533538, 0.38158464859843205, -0.4305523561326127, 0.48471639245498915, -0.6395040818049114, -0.43604128050285407, 0.5785736445397358, -0.11908017647686933, 0.21753322707144837, -0.040544085491640985, 0.2996777495531248, -0.10121152086287502, 0.6654438822450113, -0.279686955000866, 0.41710294985561863, 0.46721113023839117, -0.6789379620878537, -0.32379553514992493},
    {0.19066423402197213, 0.17925213969055476, 0.6035589848909685, 0.4587424999319428, 0.3583162976558162, 0.7320973562339476, 0.09362214692858724, 0.2546644188170947, 0.4064156276292261, 0.2091116566111417, -0.6307623910553086, 0.5141788083166076, 0.41275363507261487, -0.5185274796190734, 0.22974061403280063, 0.5172899770657469, 0.11096253378528552, 0.5043040898587667, -0.2358314343203662, -0.5552041634157998, -0.6249734902980095, 0.6854177557861783, -0.7287416464814798, -0.2973939609319323, -0.522056786541135, -0.732225909566573, 0.374471127172183, -0.5284578686604777, 0.41697276037679076, -0.4404313259154228, -0.21734464540933712, 0.3676593523122393, -0.677448734293084, -0.27716346983285284, -0.32812969476036824, -0.16313218293273368, 0.5786125355763276, 0.5935340722995193, -0.26729883708515073, -0.0015962452680730636, 0.2834611019693591, 0.5376117223031347, 0.4983393233480729, 0.4678251168068787, 0.4726984307723834, 0.016259889561282274, -0.581970410497022, 0.4789075422560439, -0.6421308723625152, 0.5202690283136171, -0.4708339489793801, -0.3159885198840289, 0.3476282878894897, -0.09112861828865644, 0.3947937488631494, 0.3078041696303162, 0.47866532665241257, 0.09373556241742925, 0.529478927509469, -0.31928195663125747, 0.3888341657348826, 0.37465242644689, -0.7479906402460905, -0.19215068325709417},
    {0.0330109384368052, -0.009638019019554628, 0.5500538163215999, 0.545150064983956, 0.5390079150238466, 0.6215387966439238, 0.12987312958803574, 0.5657958596765266, 0.46596958612331424, 0.09707436789592261, -0.42442263743833775, 0.6729153828985462, 0.37800499375328306, -0.3892109273590768, -0.13183594624129855, 0.39251198315901364, 0.09585439073161339, 0.5987259407896156, -0.2727084243109365, -0.5454305980519033, -0.5420982131892187, 0.5966377530154494, -0.4489701144047892, -0.35964474410545455, -0.536447270519677, -0.5090676092647346, 0.4633487340522533, -0.6262240575455771, 0.44347331312774874, -0.14839812506682484, -0.46285397037912596, 0.5058048785120649, -0.528093237626223, -0.3994289151467137, -0.3253533641571728, -0.3946822986637768, 0.5592687436784676, 0.3065008740658439, -0.44469555460287746, 0.03216176828215637, 0.32081932897412985, 0.64485858742284, 0.39853482192326933, 0.5299975373826016, 0.41595409446343895, -0.3291756677270269, -0.48839582184357755, 0.5064063297353067, -0.45355153571688134, 0.47923935993957717, -0.48221552917219895, -0.24534629487720308, 0.4402835935361931, -0.13159004480708272, 0.283149866154896, 0.002190665018753696, 0.2596355954163909, 0.18415694033945107, 0.5683793069696156, -0.4060532545390826, 0.4232950671667784, 0.17770721072803575, -0.5375016472491505, -0.270788867017434},
    {0.11591527181210015, 0.11525774612781592, 0.5110461363755673, 0.3189391276777397, 0.5738639916432475, 0.82690651884664, -0.34785990772304093, 0.4422371840805601, 0.47150825501757465, 0.3049566633068297, -0.6329033000387144, 0.7224203624767347, 0.6749289553374165, -0.6455029489940513, 0.09767096466646961, 0.7133905562138193, 0.1633358099971479, 0.7230238267506313, -0.28045443271158577, -0.3311312714618708, -0.6777006794597076, 0.6532968399058523, -0.6725926145216252, -0.3542573046657186, -0.49980477289239034, -0.6588130873964873, 0.2672693851543184, -0.4364099558846948, 0.39478894725854924, -0.520574939761195, -0.538809383708527, 0.7648136243088219, -0.659604066147654, -0.5031368927492431, -0.4207329201084043, -0.4100604553838329, 0.5519890035754295, 0.5901584799247404, -0.6068687824654548, 0.0867049178712149, 0.3536426564580433, 0.7334597008232872, 0.4729585846549758, 0.7013630287048164, 0.532149287701365, -0.15109033142501596, -0.48086691178395835, 0.5748441508311625, -0.5690801570234655, 0.31323062975594324, -0.7306529548918588, -0.39299229581948975, 0.4543008051347477, -0.1786225560116017, 0.5356299583041072, -0.10880128234719064, 0.518760392248701, -0.023673556972961314, 0.4320866536670477, -0.3135469651721153, 0.5679435130512347, 0.2838518096844563, -0.5337253117813725, 0.058878546511024546},
    {0.10252769364971688, 0.027346360889418473, 0.6713538388046084, 0.45765298923522946, 0.4082724921578666, 0.667358880624742, -0.27374963447122336, 0.40763532426025423, 0.518438708298465, -0.015332529658642402, -0.7786256197341028, 0.628596489896642, 0.6522854933100828, -0.36478147942753353, -0.0908297898869834, 0.6416116607071968, 0.3582428707738876, 0.7421187596497335, -0.405046694073578, -0.443243370390427, -0.7669317832130957, 0.5864843961621891, -0.5958669417351102, -0.05716645490196098, -0.46029222101700273, -0.6113482494041175, 0.11181577370754474, -0.7692844054494079, 0.5222297128491741, -0.2789257812429673, -0.6471279261366367, 0.4401472389596653, -0.5725719991104408, -0.6023340244814405, -0.27632413834476544, -0.3805668251113483, 0.25036045327546086, 0.4976877828116556, -0.4576296439897116, -0.25158793839774185, 0.443959020446482, 0.710427501963345, 0.6289756058428244, 0.36581590199164604, 0.7086176160990931, -0.32410494744038615, -0.47485063550311546, 0.38711635116238907, -0.4401192741256009, 0.580470279181135, -0.5574455773411371, -0.5303536105380602, 0.6271468819964575, -0.0776641292547228, 0.6528096517127965, -0.14591383627050572, 0.43537901264926937, 0.07640495619236258, 0.7566359456528693, -0.6419697476146738, 0.4647410162757835, 0.1102150294529081, -0.583733497290244, 0.007327951846501885},
    {-0.027461645630226683, 0.1228802438682537, 0.7559922384643294, 0.10262972047312673, 0.29367527153837164, 0.6074842138251908, -0.3059377771781092, 0.23355581668233716, 0.7324945426970245, -0.017754089487903996, -0.6036426390568136, 0.4038941544324704, 0.6870685685130619, -0.6392919914082397, -0.23580402423865185, 0.4126429044532029, 0.1915934681223087, 0.4814197757474021, -0.5468800847304721, -0.32558249139165807, -0.7787645771590409, 0.4292317532129318, -0.6629274699174815, -0.42950288108350254, -0.6982734002929913, -0.7675895219320743, 0.37286464107752293, -0.591033167222818, 0.5357706139711249, -0.3122870867572883, -0.509779439370112, 0.45820890286094634, -0.5698564140999121, -0.7103700505951015, -0.5764382908425353, -0.356123086406069, 0.3825601673710546, 0.2799130731136346, -0.7006559773923908, -0.3092153539265548, 0.29822240023338403, 0.6990181789751551, 0.569310022792779, 0.40003847250904256, 0.4602760371704358, -0.5347093981110135, -0.6545861829840574, 0.6375257850320777, -0.7067993382736667, 0.5110024047093686, -0.7053917321937418, -0.6602747327988343, 0.4755785259898963, -0.15445030681570002, 0.4763822268874225, -0.09892945981457531, 0.2191477048860112, -0.23181147170966473, 0.6789136927397197, -0.7330453711300684, 0.40628198161274764, -0.021964951038750218, -0.728013939495471, -0.19696298071363214},
    {-0.1754864351701655, 0.03519412918604681, 0.7191308935743762, 0.2955632841825014, 0.4607583328802903, 0.5769314391381649, -0.4011787620404084, 0.3336013575626969, 0.5926157582701232, 0.11544421177256367, -0.4306761522437148, 0.6651448689582082, 0.39963394411373004, -0.6295975704363431, -0.2465009878642884, 0.6421515364135894, 0.41336305226378045, 0.4222370180489247, -0.1618132833286447, -0.39411027634319556, -0.5401616379984508, 0.4597016186146012, -0.7471752505180176, -0.28084171116786655, -0.3627175711161455, -0.7133705246615618, 0.4095065844056837, -0.5896726796804306, 0.6122836787716627, -0.34763091131921914, -0.3960003481753456, 0.380287669129703, -0.39066575743245585, -0.37931374437654963, -0.5625333403538801, -0.6131591508891279, 0.49301786621637117, 0.43231711613601476, -0.5417064502260682, -0.0478659502698287, 0.6751798008030415, 0.5264964126506141, 0.6374481567076966, 0.7197132161230931, 0.6036675587016349, -0.2831090206232019, -0.38961958452140383, 0.5788713587613552, -0.5579056404226924, 0.6195873236564726, -0.8036614329808948, -0.35383199499837853, 0.2220249584157618, -0.3703517984891817, 0.678375703895329, -0.26741984293778825, 0.36253113740968074, -0.20745644995463378, 0.6874854715826173, -0.4129411042565023, 0.4864065122000093, 0.33097880715650524, -0.6757255554948022, -0.11689416767355204},
    {-0.18349966490951677, 0.31789878701909297, 0.6950265175496331, 0.3788779991160008, 0.2587585608570589, 0.689147786964016, -0.3319349193711695, 0.36806437926737956, 0.7035050486216632, -0.029274480962451985, -0.7695246781765989, 0.6420710519661512, 0.5357788146916403, -0.6398122238897074, 0.025366931190525, 0.5265171192691872, 0.46532670743305454, 0.5660282361163668, -0.4235866274604051, -0.44132908783220487, -0.7874653436151577, 0.765524821652435, -0.8331206277751324, -0.47733792475029607, -0.7145256520461123, -0.5512105795371828, 0.1741593299842985, -0.5585695985748452, 0.41874516312900134, -0.43814569574726964, -0.5908745310741339, 0.7196133689689516, -0.428045120245396, -0.6069226166554399, -0.3637214413884456, -0.30220096730937773, 0.4877749599777426, 0.6770213960056789, -0.7272284552564596, -0.3428820215833146, 0.6522631670761428, 0.5023310033455638, 0.7328098345737, 0.7347618025496213, 0.7123825366367462, -0.37937404322561247, -0.48482426413268853, 0.5444999214267754, -0.625032449298382, 0.6566587898369909, -0.8229785930378475, -0.5763582405793413, 0.45109121152328907, -0.2256736523204033, 0.5009198044007631, -0.021958920528594734, 0.17869408382919483, -0.010218154023516616, 0.7115381315110564, -0.636517209261262, 0.41743777657540215, 0.03647265530923129, -0.8186922964482531, -0.02045070759802224},
    {-0.013179781043712044, 0.3545201724808232, 0.5051976124116748, 0.5341920010975211, 0.28109535664325075, 0.6250395018255078, -0.3171003957819498, 0.4354528136891787, 0.6498625023902026, 0.05457671938863713, -0.4864956783816238, 0.7380209760311162, 0.6385485760704361, -0.39192890361734545, -0.25361235381637076, 0.7343226383865566, 0.5286069399996869, 0.6570781062020574, -0.5534771682850039, -0.33950200868636005, -0.640440472141008, 0.6780154216405297, -0.4878787868470398, -0.28346209606607137, -0.44435319750301916, -0.6222662040023383, 0.42297510058093296, -0.4947698900413154, 0.43964390169743645, -0.47641576981547434, -0.6256770773147601, 0.5489954630677601, -0.6774504255326765, -0.5635745860991344, -0.320223293667356, -0.5427269134998103, 0.5304013823210191, 0.6826093005715307, -0.4414677316100357, -0.26645375134233923, 0.6388497546385348, 0.4685231480717785, 0.5607912371904917, 0.565742610611977, 0.6489944893716704, -0.082448988110305, -0.5970612232607959, 0.6501598075233075, -0.6179578038748704, 0.4890454862140917, -0.6663660187925692, -0.6525094940724528, 0.6325864804459201, -0.34672582721719886, 0.35219578700448917, -0.15623892252344426, 0.2978136196149285, 0.2405181030844997, 0.5278929670559998, -0.6602869708776484, 0.504505113973532, 0.22412865004878482, -0.7743328560397905, -0.12276347346557723},
    {0.20473458561046498, 0.3647314959311707, 0.562433562503967, 0.029121054038587113, 0.20497075090632863, 0.5112714919011698, -0.2535609477556637, 0.5097685866516222, 0.7009013924305353, 0.007379015290036966, -0.6996092120786322, 0.4223214064994575, 0.6649258894768497, -0.39026834367281293, -0.32099680358897, 0.7256260797562848, 0.484892300038839, 0.6919034728790288, -0.3367047929599365, -0.5182667251931498, -0.6435053971284403, 0.7713681010948065, -0.7339092700219223, -0.42716558983802494, -0.4477530913385111, -0.5144618242869821, 0.2910307972866724, -0.5837523385861334, 0.07451090897133354, -0.34418031620476763, -0.6408760912051462, 0.619778120869299, -0.5893533985209876, -0.6774533052044193, -0.4296685722184646, -0.30506457140725085, 0.5829267480975651, 0.2923187134170362, -0.5319476796395928, -0.31285573479814244, 0.6662620783529138, 0.7455300249781632, 0.6061389213944184, 0.5760161806902876, 0.7421884051383146, -0.1905561786104556, -0.40154589378057676, 0.5734947926654909, -0.7085621658891375, 0.4841009576558162, -0.5841620753225716, -0.6129489745777819, 0.4724401528737783, -0.4441666056423565, 0.4525147172002843, 0.0488824126380981, 0.3903395970050995, 0.1549663824708676, 0.6801491722521006, -0.6439398890643895, 0.48196661169982924, 0.20997953829520247, -0.813162552718968, -0.1723175639020455},
    {-0.0885961588581661, 0.20303077599854066, 0.5641673009895413, 0.11554591786310364, 0.4344731772307211, 0.6708602104553903, -0.05069414672205279, 0.4055766010712804, 0.62618605997553, 0.09833812814550343, -0.7280119647405254, 0.5122916013844669, 0.45091839928215716, -0.42532597527925586, 0.041961127169891255, 0.7172235768584841, 0.35100472061985033, 0.5850792262407948, -0.6268598977672092, -0.3146231094557156, -0.7729451550427432, 0.605512121763458, -0.6086629592915422, -0.16200195821943675, -0.5764096750724063, -0.6033857629155437, 0.4648848097704193, -0.7607468622026647, 0.18913711231776237, -0.27122953791046794, -0.5520218862593579, 0.6756291371430342, -0.6502888324429401, -0.584590934851781, -0.4266221625727267, -0.343149854389218, 0.436497716382121, 0.4390819830312902, -0.46945757885793027, -0.14838840990894697, 0.4330272606010994, 0.6479883382042289, 0.5119992916614587, 0.49163370780914517, 0.7673373588964492, -0.1065234025451907, -0.459542141905751, 0.3462245033550868, -0.7371966973999634, 0.5500369582541643, -0.6929057766937949, -0.6781668384142562, 0.3358824069217544, -0.3137719022508821, 0.6576886739030756, -0.057756775149798635, 0.23137133022020148, -0.20713114094921767, 0.5147140161385586, -0.5885468485389809, 0.41616955875170025, 0.032279049909361424, -0.7273957080117348, -0.005937841312024328},
    {0.029868836052682986, 0.00355502932372296, 0.5505731219220679, 0.20060645220338058, 0.4275415915347112, 0.7291054169230259, -0.4269021153159137, 0.58492720628208, 0.5164378553218112, -0.24244278986079276, -0.602909551426667, 0.4540381055531587, 0.5622610816668523, -0.6190897412052703, -0.26226042231735536, 0.705779675834676, 0.27729599718760406, 0.6963848150754274, -0.5672028415896038, -0.6850048120380536, -0.5150022420336077, 0.7343353520762901, -0.6220497868882763, -0.21622047492243132, -0.45002273118961167, -0.7931648922333034, 0.44454939655216036, -0.6189283460854972, 0.29448220771782263, -0.3411658878953437, -0.6206115012356291, 0.6006185864007749, -0.6192620886554583, -0.4023962685241538, -0.6898329983266266, -0.564090169521203, 0.38585455495900195, 0.28729377810858037, -0.5141646239382358, -0.45382995697184425, 0.45371729653941373, 0.6798607994740792, 0.47453949263443035, 0.40477056683197, 0.5999033471329683, -0.29815829819646933, -0.6117506749939041, 0.5738263864595862, -0.7361106791945332, 0.4448427731096725, -0.8445275877036889, -0.5995429465084504, 0.49533497588259046, -0.39357320753017144, 0.448705060371332, -0.15057781574468063, 0.20925927347520587, 0.14142381836527299, 0.6550806340905556, -0.5124820409594204, 0.5685507370752979, 0.0012531617378398869, -0.5803946962398956, 0.05745547588512256},
    {0.5891407312257422, 0.5308591841613918, 0.2135228635788195, -0.27611341288623253, 0.3869372303302943, 0.058765051204615705, 0.422771113823347, -0.7396026475708429, 0.22568057077736345, -0.35700079163089393, -0.26455681410403403, 0.2657774373620871, -0.07406030521739611, 0.16107186611860463, -0.22534993500119116, 0.5192354511885865, 0.3694206804857727, 0.1636486502495685, -0.23130011247967416, 0.1998379614887257, -0.24409328204495606, 0.5214315491017699, -0.09551601050527071, 0.20535578363435547, -0.5765804387821948, -0.016694553313604154, 0.027845350462681003, 0.38280180992336954, -0.4090206719497514, 0.2078354107950911, 0.1647005571819061, 0.4477762507943615, 0.030764622589236176, 0.52281700342015, 0.2651002284843495, 0.5161100806930251, 0.4596077875240684, -0.5444154919777247, 0.0022362709158229507, -0.12938366760995346, -0.35802591617215723, 0.2178086817329731, 0.5622438953849681, -0.20866257846112718, 0.3314129908068461, 0.5282544176375732, -0.17861875016278972, 0.11641560838030267, -0.020678787852559503, 0.10015746306059792, 0.35760903442513453, -0.6162083535321978, 0.4984554591392396, 0.6094291162845354, 0.027784996211636027, 0.06887677827957825, 0.4370762215042014, 0.601943114530791, 0.43360981817193833, 0.6081285257198963, -0.6383616025372825, 0.49600081281576025, 0.47591279506467576, 0.44594590406070606},
    {-0.09784255224235217, -0.06494219228462327, -0.2455826359036937, -0.4629918046175534, 0.4158883964034017, -0.006493654090742683, -0.2316665278584134, -0.1576058903922463, 0.2039267977424994, -0.22649588731022904, -0.21388915685826543, -0.170698182951533, -0.2200680900120017, -0.17596905189529277, -0.22216373879242568, -0.19680419476724076, -0.1315999457238142, 0.224860366504044, -0.06775706752580433, -0.03947532177679731, -0.2679192596100955, -0.03837512426946813, -0.3631320826924474, 0.18528614539916027, 0.04272186652837317, -0.25122246337689974, -0.38644551857486853, -0.10249278227112431, -0.4624321921571223, 0.09160698441268739, 0.23977907273687174, 0.01979225540700307, -0.19462837000162703, 0.15634443532750733, 0.18931616575665533, 0.07028646201835219, -0.37069713864695375, -0.2145342373511158, 0.07244892833768221, 0.15643890277670475, -0.10743363453148887, -0.26609442003618833, -0.028297043941611193, -0.0668195828950444, -0.33321351584463016, -0.13339693746864753, 0.1379833939939799, -0.19276674348116343, 0.10656059974621244, -0.057537918100258406, 0.10158788142230023, 0.3585183025463468, 0.05191378899081897, -0.1105144329252385, -0.4307649141287359, -0.014993858856395108, 0.17003475988294567, -0.09878442313697158, 0.10883180155795692, 0.047758489189398776, -0.0752332844499214, 0.034052451121482266, 0.06431034249606045, -0.05869062114014674},
    {0.04323165883541668, -0.11911893175841011, -0.239291727829195, -0.5135898054743072, 0.3206282027166357, -0.5818454881599711, -0.00803146187829298, -0.6705981162066639, 0.34878625292069154, -0.6726609479787912, -0.21127039638965345, -0.3925954531377917, -0.657678475236629, -0.08535139887018607, -0.5472952038839132, -0.3930782975720535, 0.15352672322483552, -0.20468463287882607, -0.5631351679226752, 0.3706931941138962, -0.5017488027460164, -0.07244993552261668, -0.06588950000254513, 0.2641611703306987, -0.3741412737837465, -0.2479879369437082, -0.5590971775968728, -0.32492775644974486, -0.3356313029709123, -0.25265067901169536, 0.43617505868090634, -0.1718666081106069, 0.005110955071539121, 0.10370283740214489, 0.21062886261789276, 0.15996666942270982, -0.1820846200191353, -0.5103576823065744, 0.022965584065494465, -0.5493273502679831, -0.45850940784066185, -0.4253352456105194, -0.022669730541159283, 0.10605624550210707, -0.4894639162102018, 0.08339239266523885, -0.10697483875718297, -0.3132201567740313, 0.3058265143826038, -0.20371602791328472, -0.18068402356238394, 0.014668227319970901, 0.22877094654774255, 0.1081891962028929, -0.5846768916243733, -0.2794556610640036, -0.1928341349762055, -0.08463915706928621, -0.06690437660142472, 0.0603008718726698, -0.6081832117002217, 0.41675469881867716, -0.088667601281053, -0.17791090466319898},
    {0.2894701353229714, -0.014005545494544464, -0.2477914651483205, -0.3889693356952444, -0.3674867482590789, -0.5954058624697329, -0.22913855050492465, -0.5897654192169635, -0.00410227532527298, -0.3518694448441671, -0.269873292334138, -0.11729443121823746, -0.44515555716593364, -0.39689351572670295, -0.3885852611905057, -0.34872637048130173, -0.14107515229110798, -0.19269459892152427, -0.45533455950173, 0.23857835767291152, -0.4719518456226602, -0.08603163494622833, 0.005999133531756469, -0.17441547750947622, -0.5244002179407126, -0.20789179005843578, -0.4069378433996036, -0.1287925836177132, -0.3374096069611145, -0.3509267976166981, 0.09268888159672889, -0.3081570128624191, -0.16789484787010694, 0.0570734105191466, 0.08093982748580607, -0.29788884274150595, -0.45046862942002847, -0.1703485407414306, -0.3142074976966151, -0.6555775939281676, -0.5980952134947013, -0.06298747151757855, -0.08294001956583649, 0.06157446716542269, -0.4286203232463173, -0.010576053489714072, -0.09391865233358009, -0.2921470130724195, 0.13792115969888735, -0.21143366283902154, -0.02501158532765819, -0.11862465174900559, 0.052911157233366, -0.05714719631264943, -0.45459776272423297, -0.2406782449646503, -0.1688357546732178, -0.2220694411280287, -0.15244347860108418, -0.06311686153811581, -0.3037979348290077, -0.06384353539710584, 0.000961771849723525, -0.3176856723201569},
    {-0.10527023348250034, -0.12049289070257735, -0.5415703907210424, -0.3834983071613705, 0.0818861063837997, -0.3109802784699637, -0.49896522429572693, -0.043632281851286765, 0.28876144045172025, -0.18547188678055615, 0.18011028259488965, -0.3892621902798523, -0.5203576506649186, -0.25742770458682035, -0.5029389523209502, -0.4244829746513211, -0.05375656936401438, 0.3335377570906441, -0.4738121957209509, 0.14567512283021733, 0.03305845077057182, -0.23589344433462317, -0.1366871394272617, -0.39070462473594175, 0.15872957239834706, -0.3042058800428417, -0.28503349745967665, -0.4181101543938982, -0.5009171463730057, -0.21434339870180424, 0.13585507560351798, -0.26688854451011773, -0.09878327752919712, -0.2620897234706844, -0.4535959991659552, -0.3807537673227654, -0.3845391100206706, 0.06856939444570649, -0.23190988570877918, -0.11251139183627862, -0.45204979551484253, -0.31032461321033716, -0.33555397411545484, 0.25826090816337705, -0.29172346039884295, -0.06189718422143862, -0.05052724601156834, -0.4587519602282832, 0.0693748053920166, -0.4864587879659782, -0.5078548885203314, -0.003893684923709929, -0.23257700261281974, -0.20280645417837523, -0.5988407253210465, -0.44814425010165193, -0.4194225512287689, -0.5212466978526342, -0.4596967845207738, -0.21108249519425906, 0.07056581843655131, -0.19297417441914902, -0.30240043952460743, -0.5339183864204451},
    {-0.5001714942533693, -0.23548668615114088, -0.43996380732583773, -0.3648755543360013, -0.07421687388325254, -0.32278459772848117, -0.4202600708909793, -0.1780235761875181, -0.03709067715588426, -0.13549982567433297, 0.06280143752668138, -0.5096706775259057, -0.5277389161621086, -0.348272914913834, -0.5634351761494263, -0.16881578340887815, -0.5273275846675946, 0.21447688268054754, -0.5866595999051097, 0.08532163762478402, -0.14804008868485294, -0.5466596197654694, -0.5346929294821554, -0.4426287111655921, -0.16650751911099743, -0.5881290238256017, -0.6246822676702457, -0.41428969103675267, -0.5310901382532527, -0.11945365397382775, -0.1355412375395281, -0.16686329714578238, -0.26904008415829084, -0.19901817078636935, -0.23580723732256606, -0.2979054192774428, -0.6396900525651553, -0.20660501005158488, -0.032966756054851436, 0.025762086457924535, -0.5416429402925688, -0.12078168972683083, -0.40571227770253865, -0.10171375239390494, -0.4355855022603347, -0.22752997907085556, -0.22238900357544186, -0.25645425031446434, -0.02307331354685861, -0.4118501011349912, -0.5729147381025022, -0.15095770754261864, -0.03085295239224092, -0.34699445961873376, -0.32617289927670795, -0.4194899295820428, -0.493645391969244, -0.44334940168989556, -0.17587108196733453, -0.4481392925645177, -0.4404525804089832, -0.41126716218702714, -0.44934218517082164, -0.16842028339057968},
    {-0.01732832739546281, -0.0890522825008578, -0.5234161489142317, -0.5959818805382436, -0.10214012576673089, -0.2983865465183134, -0.38735418321494275, -0.062235357992145156, -0.03206813853717979, -0.504386189813869, -0.1200890259853959, -0.3240491328678872, -0.45423116402062097, -0.3089721788966901, -0.5139218833951424, -0.3758805262583295, -0.34529232333031107, 0.22971131473114204, -0.3493181480470264, -0.12901871232224377, -0.49464754414137607, -0.3471154097867239, -0.44560337940962347, -0.47062651712215775, -0.19608049156072943, -0.5591956080820637, -0.29563477357819984, -0.11799545269936547, -0.5689420540376567, -0.4024830761906077, -0.038745309692051685, -0.27963354117883793, -0.3642908969924919, -0.02927659972305968, -0.39487417936903657, -0.22916879391973569, -0.3874158478785857, -0.27633660828433415, -0.11489712619877161, -0.2399808117904114, -0.09017855096149917, -0.013697464769213763, -0.5816649737102499, 0.05713014529589877, -0.49285987495942274, 0.150822844099988, -0.2503904728593819, -0.47653146278369773, -0.05667337627233462, -0.28573817400453894, -0.4125605114299402, -0.03679336373601474, 0.008801992781169466, -0.05240517430273394, -0.35157213771338636, -0.5874909788549795, -0.16144537946757584, -0.35473355169368653, -0.16136175588944046, -0.3501222768754431, -0.35764157553365766, 0.16708883487020615, -0.03278160563742519, -0.39524149714849555},
    {-0.02056596350990533, -0.28124028922905264, -0.5712651881825768, -0.4197692656806304, -0.41082332931389404, -0.5760794697553663, -0.3283857660873488, -0.11336730909885397, -0.1280403406610494, -0.49567936729973544, 0.09156950609307865, -0.4519711907470147, -0.6171696943186737, -0.2514045889036973, -0.6943627549514703, -0.20125443411981628, -0.3872312529643217, 0.1303628578159794, -0.3689553564848649, -0.14881665972309788, -0.45553571649768543, -0.07283393586751281, -0.2636710655325629, -0.21141862099699188, -0.24774524988100802, -0.2982986372441623, -0.5517189251001721, -0.10894297463471965, -0.35432476707244376, -0.21332017816491466, -0.24494826907110478, -0.06258406571264741, -0.05295743184425077, -0.3097074538631952, -0.37970205510422816, 0.016740392333857896, -0.47324749920455955, -0.34287168093505077, -0.031483743485822606, -0.0043563314414263865, -0.10656137575742916, -0.3050504330071289, -0.31114170308975286, -0.16049483088936994, -0.5794335475442601, -0.1768669986637937, 0.09235693120244837, -0.4153067716426059, -0.04515141402203397, -0.3207257516527149, -0.1997179961399624, 0.012898366014124698, -0.0018175811737667026, -0.295687302249028, -0.4926716915731902, -0.3943757274595855, 0.1319275411921013, -0.2133864815950063, -0.25874157049775776, -0.22811204623773776, -0.5174176830196783, 0.21721584217308842, 0.07256595849911934, -0.3944043830460514},
    {-0.2089272232442062, -0.21200116258716928, -0.5618809776869015, -0.4945076389880773, -0.07003993065793099, -0.2113279147507123, -0.4464100972975449, -0.505097340969559, -0.3289559983194814, -0.228881716050707, 0.09480811814722902, -0.1824616422480535, -0.3947419748441582, -0.4933342406180089, -0.525177733302675, -0.24746040792217072, -0.45466424269254957, 0.17624698492345664, -0.3239546384098319, -0.09086240794066551, -0.04431131579484169, -0.1691636813573577, -0.20148049617436725, -0.3563398149124797, -0.3765373602434359, -0.4535118084000774, -0.2678499511014824, -0.32969372612037967, -0.3401716229677822, -0.4540219071713289, 0.13473724455988964, -0.43891402677892766, 0.07743280830958532, -0.31432255625020644, -0.06341016168908192, -0.39786235121892327, -0.6614432556199493, -0.23078504334262434, 0.1274226648525181, -0.1698435477020886, -0.2720783935969749, -0.023023401900621996, -0.21295209266389437, -0.08561138628873585, -0.6382025257012633, -0.008408330856065977, 0.04643936811879914, -0.46477737458677504, -0.0611180347031408, -0.4470122646732824, -0.29240493299153575, -0.22622833358230746, -0.04194770156547018, -0.21244838270997526, -0.3075292166256755, -0.28322678166886983, 0.044602487640868424, -0.3516390206616968, -0.39920377497744564, -0.1062736965953846, -0.5425205611230772, 0.0466373269541535, 0.04248296204628372, -0.43956131085304745},
    {-0.1579613063383137, 0.07509659319433848, -0.54214815989498, -0.6776359962653188, -0.04718366937308375, -0.5617767392901754, -0.4021348171778809, -0.582853093000876, 0.13680160428195418, -0.6118474102235693, -0.15718579659903775, -0.3828047888170437, -0.347398653490897, -0.35597953375708885, -0.5727075053822963, -0.17354849325406374, -0.17186068786321326, 0.3620640239198522, -0.5686882473909136, 0.2562455494082727, -0.17124946190195175, -0.14621851657198007, 0.03661955522557989, -0.044633708384505824, -0.4854686378530842, -0.1763767607618161, -0.6158845382705062, -0.4466157973133408, -0.44507829670348514, -0.11249826486829831, 0.3713746213398751, -0.3835551650648813, 0.2980948798581266, -0.21067052261420605, -0.33790041387603525, -0.1911797275217486, -0.43620483141536703, -0.31143651875605155, 0.1881805694066858, -0.20075775329622877, -0.2526892392813054, -0.09156674592022776, -0.16316927543546106, 0.21960420976100256, -0.5144096034409151, 0.23170699818927618, 0.41147342971682416, -0.34738274011638365, 0.20777534538860012, -0.355763406598432, -0.42222596137914553, -0.17067682429585385, -0.03258076660713509, -0.17164286268156734, -0.4428239503727865, -0.5961742207400866, -0.06874026838314007, -0.12897961172602995, -0.045989057017618525, 0.0931171638809374, -0.5538389650840037, 0.3491342902540012, 0.12600018468121538, -0.4734796398039108},
    {-0.2395085944277328, 0.13895733967569082, -0.4767468136834189, -0.5170034279829546, 0.1647122545252145, -0.4519035504530896, -0.19620400540320054, -0.3217743386233673, -0.19567668274140917, -0.2827129634215344, -0.2617449360262597, -0.3255602297075773, -0.4833185026001522, -0.03138033409294254, -0.2458087216411922, -0.21812820950334139, 0.039167528163856505, -0.1188944435455194, -0.20099653471080675, -0.06891356925423563, -0.48879834476506695, -0.1236502248138424, -0.21796722581553044, 0.061877792655043166, -0.503848581940453, -0.3239478367679052, -0.2889912715439828, -0.1958263691743629, -0.5497318766123488, -0.5272449256973035, 0.10310381642047273, -0.1674831235651975, 0.1144618603634867, -0.1864138870677156, -0.2927290348061341, -0.05232349597386511, -0.001994628405328473, -0.5199068743875002, -0.22717213937946754, -0.5031628698792276, -0.14521089905577825, 0.1298446209486702, -0.39260778498852744, -0.12394238835891261, -0.19519875189384556, -0.21541788123483485, 0.06802222688031465, -0.05087276144960775, 0.05238043705087737, -0.43381398089068435, -0.15494876424903384, -0.046686502787829445, 0.23568665203773576, 0.1576204980145032, -0.13693974410983673, -0.5062297223568925, -0.2627155962485523, -0.15727804203547335, -0.2147953241381617, 0.16727839563165353, -0.4848896258418031, -0.06411953079375018, -0.02945162804135518, -0.07749763450886185},
    {0.08310522982055543, 0.08406460408256113, -0.5756917048755351, -0.3519744776763295, 0.1141707748268366, -0.2540132385154611, -0.4790828733147416, -0.6149063117036857, -0.09775189039988057, -0.585173586368977, -0.04850605908859081, -0.25030286469534346, -0.44273259825805794, -0.47328722540037876, -0.5972706545930226, -0.4140729137617022, 0.01949637475707364, 0.001971365916808919, -0.21769458181849694, 0.3094067799802871, -0.16673839464136522, -0.3785363583000311, -0.49324250179648843, 0.02871179982756941, -0.556514933963635, -0.4609648131883324, -0.2792439869658808, -0.412964933628468, -0.41768469908735273, -0.5250986832805298, 0.06347884891514594, -0.07078611468242121, -0.17952974152377307, 0.10016601417440203, -0.17004445734165957, -0.21084057055389066, -0.36973215109282687, -0.3352193959730777, -0.3811287897093885, -0.05316461215999346, -0.4131428613696518, -0.2902939424076268, -0.41814932128548676, 0.12373820841453745, -0.4860216939740089, -0.09021963846949965, -0.18563525845242893, -0.2410105167600226, 0.08286617148965986, -0.3311260029835679, -0.1324862104370343, -0.17188167427225917, 0.3149561025944168, 0.00027962731760973616, -0.23845115853048118, -0.5941628909890637, -0.2559460960909957, -0.07542707531785625, -0.43999531038803186, -0.2574469833972476, -0.2740328089726489, 0.3031477162644129, -0.1184262496114584, -0.07132179899667947},
    {-0.1758009489968682, 0.003680346998706685, -0.25845466920501936, -0.4597969650284308, -0.06170214117913296, -0.33319530327255925, -0.3537248227497912, -0.4249308864518398, -0.25169880386923743, -0.6274239221004334, -0.12836668600502069, -0.3401355075009401, -0.5909577003573965, -0.4651900044338716, -0.6792912622099205, -0.10523945527448376, -0.1793412309436621, 0.13702654138909573, -0.33069012289257765, 0.3836984186248098, -0.28367564923187344, -0.050376375387461085, -0.49575129522447553, -0.016653627336332803, -0.6081403493302197, -0.3849498283763199, -0.5953012599706493, -0.4692163246505254, -0.40638209545454995, -0.3814524092718701, 0.04627017861144316, -0.19020193925557732, 0.18568138963422248, -0.33111295793223205, -0.09254594947065915, -0.3108368837507616, -0.29853410514876466, -0.22880735137678562, -0.38724767956146533, -0.3688272579796756, -0.20829398757778034, -0.274369740799701, -0.26909745359846393, -0.28245130989996575, -0.4025529803625748, 0.07802059458044676, 0.15966557649589633, -0.28662909098424155, -0.2111834740471901, -0.30432697822441546, -0.20979141049934422, -0.21168144841741718, 0.2769689099298483, -0.04391614186827771, -0.17692265123245107, -0.6244082568629081, -0.15876191242359466, -0.06805474264301259, -0.46802478404043163, -0.0813526196075457, -0.6238697492970829, -0.01828876987667043, -0.2234983766408799, -0.24993272164625271},
    {0.07015085852834647, -0.1915027962031022, -0.5335630474036647, -0.5045312457362812, 0.06433335634298493, -0.4572044277542309, -0.46359402856075854, -0.5123625664389369, 0.04822013800029904, -0.41919594501549273, -0.04220735209417118, -0.4060893481540217, -0.6713955942569388, -0.20460845732169278, -0.6819350645788056, -0.16358186525096746, -0.15123307485883966, -0.22031215716953367, -0.5812723394814281, 0.30981544266336536, -0.27577121700408347, -0.2875101358658356, -0.583615604568919, -0.05564639504926797, -0.34760810722741214, -0.2948087123945511, -0.5180780205093474, -0.4258847359485896, -0.5586216665499333, -0.40942076486488566, 0.19737131530491386, -0.3060594971841437, 0.15631739093954836, -0.1528239737933348, 0.0015881270853724716, -0.36019374052806236, -0.21904090185456537, -0.31096898839048337, -0.3231957316582002, -0.2647735333034323, -0.393712248065886, -0.07316038973464363, -0.022877446644664425, -0.33352786756692543, -0.33299729748091156, 0.05680011511414304, 0.09997291242254056, -0.39537041639176046, 0.14457898102640482, -0.13827116159816574, -0.3403059334610052, -0.14810726500998142, 0.06313259203849986, 0.18642696121420071, -0.2484239919079025, -0.5797379362040124, -0.042284206825269115, -0.022449084954549104, -0.35474515620713687, -0.18363276515716523, -0.5054446401187458, -0.04248554014708424, -0.09903640979434608, -0.08544940730361406},
    {0.019249193498307244, 0.08058711268606925, -0.4472400076622917, -0.6128673869203575, 0.4050736532483645, -0.1849302361807987, -0.23577524806007105, -0.3831036488919077, 0.26552454114545226, -0.7408483198251935, 0.11782931702393919, -0.27353744954042125, -0.4464390105834236, -0.2262584329385528, -0.5746729000710076, -0.2633977313245398, 0.30515823043067386, 0.2541614505327827, -0.7264643272904227, 0.26577056984316116, -0.19852947789564607, 0.08989366207611058, -0.4816570326671768, 0.23403371677092144, -0.278781522383365, -0.5018760719330974, -0.36369431828686877, -0.3268668985845922, -0.49700610518220656, -0.0020224086176942498, 0.0697252391243403, -0.2968510692226652, 0.1149592833017637, 0.04271396905467066, -0.24165450046594777, -0.1128896538647458, -0.29270524712418433, -0.14497667695499333, 0.19325353019826413, -0.5014333146416771, -0.4970776483222585, -0.17248164829025828, 0.01918728175229784, 0.1366853351801351, -0.5821176752385141, 0.04615428460095168, 0.29919498940187766, -0.2400687826188039, 0.4802031034116996, -0.19678938799469214, -0.15732341855546247, -0.001771192828765438, 0.3742393159297988, 0.24013967357152136, -0.5252292200699791, -0.7257923313327864, -0.1098820250514632, -0.12603178312316204, 0.01870629449090949, 0.022963056087492047, -0.32057305342135284, 0.3466516948731462, 0.22741973393963272, -0.15037623705254627},
    {0.03221578042144152, 0.16267718493323363, -0.4972326706914291, -0.39841246719403794, 0.2560255700327184, -0.5382625681209926, -0.32849370749921514, -0.6066980972041387, 0.3343644885828492, -0.4465002844969432, -0.15124085820078628, -0.38362024455431504, -0.23979215965101947, -0.2727451838395344, -0.6345484465574752, -0.09631635003258654, 0.29129273926083404, 0.28367142802048356, -0.5507595232098885, 0.17700003143941032, -0.4976102802238605, -0.05238494572228026, -0.4311765774505389, 0.1976992457819886, -0.16547608188580315, -0.3260007782598934, -0.2908247293372992, -0.266464686830037, -0.5806173507114185, -0.030290463628644005, 0.07065514135640955, -0.006877328073314043, -0.15275731368251658, 0.10120816134080396, -0.11562365065123305, -0.05196577145019352, -0.43344434434617246, -0.3264728789833751, 0.10429311386667592, -0.5579066409975239, -0.31977424056940856, -0.05091467529884064, -0.26734179466209157, 0.35883291005159407, -0.4269203644987685, 0.18400633646665304, -0.007962805196389146, -0.43803115828873573, -0.10036078649068637, -0.5239257480759412, -0.44569038801318056, 0.16978553983671243, -0.07042340604936212, -0.09789987899988631, -0.3330601392826962, -0.6734552836983306, 0.13828681343409607, -0.00230993774989661, -0.223121523674926, 0.07839830527361373, -0.5301730028870077, 0.47400699742081154, -0.20364871820075595, -0.2984304572346435},
    {0.2145509082962801, -0.04711089674081851, -0.5100316580938358, -0.4122196650013247, -0.1587516180297116, -0.571090888606292, -0.2439870379466628, -0.38234822849033373, -0.059845394249020245, -0.523209413730765, -0.07846365260432604, -0.4994823930236377, -0.4365892979295885, -0.3835962585871972, -0.6272517088130101, -0.5050603526795925, 0.1085985855215716, 0.008207983283222227, -0.43463507012156494, 0.14158430815474515, -0.0849492820209935, -0.16399511214798157, -0.43085491051646013, 0.31841221977834183, -0.09387131967099457, -0.4110581216719203, -0.2802044358389149, -0.2181083569658315, -0.47204356125062363, -0.021855276196430826, -0.20617572741102475, -0.2407962565984895, -0.1561366937167212, 0.04102993146191102, 0.09398310840699595, 0.03957449952886671, -0.4855750851184333, -0.1394438161780147, -0.33368795402913626, -0.5646900619002645, -0.2915626932685311, -0.11287540315841849, 0.06912333866608295, -0.141692573402447, -0.439502382026012, 0.39062407014638656, -0.00350882256681284, -0.43447339949925845, 0.23786883869950548, -0.28936312577988704, -0.22742254264396147, -0.3040520157397597, 0.0238602713628981, 0.30657582038488684, -0.5430929535535433, -0.6031706598081475, 0.27722642830666977, -0.26503935608942714, -0.3105874659422189, 0.22753843833882764, -0.19967713345390253, 0.28618239516366867, -0.21275367777504606, -0.029689998486703714},
    {0.43722861336550983, 0.23369764023824255, -0.28769080575298167, -0.4782613944759503, 0.37224138772217363, -0.5486828963349819, -0.13023253747385188, -0.4712575364851922, 0.1874576701324699, -0.47325095675503814, -0.45667919030603027, -0.33916914498659084, -0.28680898617747613, -0.41991250035833033, -0.5840316930585152, -0.36967689886131716, 0.1700047636117259, 0.19862010522669674, -0.36125992939792534, 0.5135403132878082, -0.19402838238899395, -0.0601335490722364, -0.42138522035415277, 0.3395885658025854, -0.1980802383279105, -0.2966323888710525, -0.4718917931356089, -0.20737174062848981, -0.4513120206869789, 0.13849721661294095, 0.043249424261364584, -0.07775047822464697, 0.09082388074233395, 0.1440723452997337, 0.003277926328308617, -0.10786312668544461, -0.46624212514477925, -0.18076089948565555, -0.3413331496112702, -0.2224302937577825, -0.5826715547375985, -0.24064012257936174, -0.05939978107243137, 0.17856177506054105, -0.4176835968857856, 0.6206539326337767, 0.33079639878401235, -0.1644022418487879, 0.1604632839651123, -0.38401183551943835, -0.08544501177179559, 0.16063036076809914, 0.4104375690298778, 0.3178287419354074, -0.4809619688392347, -0.6079944630761751, 0.06815816276592253, -0.058884884166937594, 0.14764617701621366, 0.14613833383974575, -0.2200224407606996, 0.5178919367818966, -0.003285869014325724, -0.17026959275134926},
    {0.22682062879082976, -0.015114264778292625, -0.6058025405742903, -0.6333366976538974, 0.23264395211250222, -0.411630140510141, -0.32505045061281124, -0.276864682907708, -0.006172968847219975, -0.7588858535679761, -0.47130483621637803, -0.3243715827133233, -0.43786065521677864, -0.44195415312833025, -0.5776030998263211, -0.39238180788727833, 0.38835294809469206, 0.09879458998916309, -0.7099661825629795, 0.3269928463215825, -0.2771484110517644, 0.0189518244290657, -0.07626331491226004, 0.23016589945736984, -0.5627841078292835, -0.16162200125068113, -0.32775451494444546, -0.3474872132279316, -0.7288395963476939, 0.27437237010586574, 0.08703711843882539, -0.07987753214597337, 0.20641678456605903, -0.10890853153547154, -0.08476756221572623, 0.1124806491021115, -0.5592032644803762, -0.3269821789451018, -0.2859711902849914, -0.1652774945371118, -0.6259086965714855, 0.16322359456579444, 0.01086011056932233, 0.20304492124858461, -0.05021573643494802, 0.5906133401101161, 0.2746055846445215, -0.0981138083449836, 0.05764636014850855, -0.28330600159718916, -0.2851598722757624, -0.1368521945404903, 0.08641355523091165, 0.32186182173041655, -0.5270043785302779, -0.36316563013527986, 0.38570786030153503, -0.04054620110873304, 0.15788828200664778, 0.20833903016043798, -0.3681672457880763, 0.5342959058465796, 0.01640238163987995, -0.24778548701054445},
    {-0.0705221213607788, -0.04427601889140214, -0.5459892546958628, -0.3751052327923629, 0.011797429460325385, -0.5948709742178795, -0.3960976842679587, -0.6738801303472449, -0.01984839105025438, -0.5238600027808783, -0.3765441302742212, -0.5864688304329968, -0.6931328597139116, -0.19272577049753833, -0.7615953560154864, -0.20646223771960145, 0.2270875997581329, -0.1337911144097708, -0.6582724293292075, 0.06300343640430772, -0.5129037791881675, -0.05301272248279906, -0.6258442038505456, 0.30526884609566035, -0.5011312125673831, -0.579715008428647, -0.741821279417871, -0.20008737910906704, -0.7360721691671253, -0.22678972685014587, -0.22033917894507116, -0.44223641330856817, -0.2332079861373313, 0.20496507528952818, -0.20614883662098493, -0.3008298530050303, -0.4377951787668486, -0.4641622707706718, -0.3872820216512872, -0.508247118240985, -0.5278415227225106, -0.013974907778781093, -0.13717859430874876, -0.11220149479237575, -0.5236107743173153, 0.19981815887873625, -0.1770125756938605, -0.5959376757540013, -0.1586528821459255, -0.2197518637782736, -0.31417636793688647, -0.3738655696138317, 0.11057859690929568, 0.17799853898059895, -0.5589748884372175, -0.5353625734521404, 0.16421803140618704, -0.16908745492278932, -0.20964387859057354, 0.1283415327458341, -0.7307435636706834, 0.4668233435468216, 0.021649582904977732, -0.3224218990043839},
    {0.35459022525977674, -0.1632310831697712, -0.6149800652982841, -0.586146661995711, 0.299635435079616, -0.31647430655572417, -0.525851150266356, -0.7744478263317588, 0.10385354859367288, -0.5047516819842356, -0.3359218077003093, -0.63673485486476, -0.67000018424138, -0.24952451441420626, -0.5933619136927742, -0.3515339973060765, 0.20601389044890217, 0.3573646549223534, -0.6542271055223392, 0.4301419336337925, -0.5055540804759462, 0.07141867268793828, -0.34886637374147617, 0.2278959731194314, -0.19047282440821872, -0.5617209652389726, -0.42683200196563764, -0.4454632867979621, -0.7375889967223678, 0.15733238175251946, 0.17717797914196937, -0.2342443719115309, 0.05578469670067622, 0.2547683615141182, -0.04951603859433282, -0.07947857597118334, -0.4573329936990105, -0.6480291239053257, -0.3906175604473456, -0.40790186798963823, -0.6111103078394964, -0.03591316408142125, -0.06163165257576275, 0.3731419602126091, -0.4879564180072788, 0.43101771421426105, -0.030379474745225017, -0.1941246141329566, 0.18205200297271082, -0.46470272415484937, -0.20879095831007644, 0.19648558742809918, 0.29574109450073377, 0.3171168190605768, -0.6432494050824994, -0.6321778924752087, -0.015683918995367797, -0.0694968533944979, -0.10431612707751206, -0.07412348019537793, -0.1932279020313794, 0.5023828349427825, 0.12003152675515671, -0.07735966073194064},
    {0.5226235082466977, 0.3952363633407696, -0.4674810634300298, -0.4781418336693907, 0.4281139234658201, 0.027582504325408694, -0.3043408771273907, -0.5570857348185839, 0.35167737002163313, -0.8833361882170715, -0.4793700274490213, -0.24431771366282132, -0.538132360400889, -0.0776999272032529, -0.7977346402836392, -0.2975540005674746, 0.6739921826587263, 0.5016074386156681, -0.5567455999840502, 0.6273210379701405, 0.07607569764973664, 0.42728062321967003, -0.04133789798848929, 0.5423335354766847, -0.2743762953881773, -0.05121300876858046, -0.6785270448609362, -0.39264446910782114, -0.855232782821466, 0.17139543571046406, 0.5205548251600429, 0.09431007223147152, 0.4381957115293202, 0.2842299179379355, -0.1499680300368413, 0.35579585947143527, -0.45205200891004804, -0.21214232944112293, -0.16166753149843896, -0.3216116179248071, -0.34285647460371427, 0.19211651978969313, 0.27825677210034844, 0.5928177963240381, -0.05702662775867446, 0.6025926334172025, 0.30655360946099297, 0.07762351946231916, 0.4289688062376427, -0.43631957324251675, 0.0028807177215765503, 0.24819490773336103, 0.5533613672473872, 0.5929417466413274, -0.30161786654998507, -0.5904855490324135, 0.22207503108496793, -0.2666498709066062, 0.3963156525766455, 0.19298210894319484, -0.11843585151551653, 0.8127992438095347, 0.079513480558974, -0.04807081707714411},
    {0.7508537042829742, 0.3560736801104992, -0.32016452847036303, -0.41936397749072607, 0.7369448447026978, -0.16417256691979962, -0.02887164682732273, -0.5574500916550771, 0.5606902480797664, -0.8407221149371423, -0.5839541493609616, -0.14016581331493777, -0.3901942447998607, -0.09816527052562855, -0.6480070000383572, -0.17163946826432386, 0.6057912878697852, 0.2626516815398334, -0.6694184362961006, 0.5244960552151874, -0.21565884163979565, 0.3944586198194369, -0.12681450341692904, 0.6850783224805904, -0.22843143344326308, -0.024953059745301875, -0.19496631894597172, 0.164210727076819, -0.8376417387753999, 0.37421134189585453, 0.47418256575862233, 0.4971581447924764, 0.4591686095323136, 0.4254913541222623, 0.37780806375630677, 0.29873683958195224, -0.11386198234286642, -0.25735719433504134, 0.09788403255812891, -0.47619764899619627, -0.395899224526037, 0.4049105176367373, 0.6200706664584569, 0.6188907007106786, -0.03934969948574411, 0.4877675238325328, 0.4506400697825642, 0.09488677255448506, 0.40061841444979995, -0.0021276435979111883, 0.29212632756167206, 0.21238232189084255, 0.378820142995561, 0.8223868286457029, -0.27330578899571173, -0.38797378381538933, 0.4919756894960652, 0.39801888822680426, 0.6044656032399314, 0.6040835031450775, -0.5264204729591795, 0.526889595711434, 0.3782055814253537, 0.3231571177845972},
    {0.7537076890950007, 0.21466449585563083, -0.4478875811263953, -0.49988322968143506, 0.49286155034410206, -0.09784621781419056, 0.014772802530845145, -0.4889037281733091, 0.39194893265770525, -0.9126817409211891, -0.5462153890369451, -0.3543057274682669, -0.2721807285228795, -0.14815616505548435, -0.6931854611335798, -0.2755598151466484, 0.46789863380443547, 0.38359201328096065, -0.6472258759381366, 0.6185130731609783, -0.14465195451578286, 0.42615678941350915, -0.12307172522337567, 0.44909127283770994, -0.5002768236318481, -0.0368672516099095, -0.3139598874683561, -0.07898995961681152, -0.8149840903790658, 0.45154962824527284, 0.16929748584239468, 0.22828029044758638, 0.3035841017445245, 0.5631841097210244, 0.008205050434065475, 0.20345307087682804, -0.5135699909201135, -0.6118877875321068, -0.30234313343548413, -0.6648544885361891, -0.5453548537179563, 0.1384817558413838, 0.29753659011595374, 0.32895904036538925, -0.05366269684061081, 0.43763565492587175, 0.14958487200089815, -0.011842618340269138, 0.5399887360339428, -0.2452209164508992, -0.10895901496823934, -0.06697528601540313, 0.2829008351721692, 0.6750361467326434, -0.21830060985144464, -0.5291073495106778, 0.406929890610519, 0.29594480961400266, 0.22306433476906318, 0.226095490604303, -0.36341600637288574, 0.7844363646067918, 0.2674130609596427, 0.23566598416801168},
    {0.3118614538295055, 0.3037686988673259, -0.6479978109896256, -0.5046875946955245, 0.1979126581908499, -0.23691979653910894, -0.32392942591117996, -0.7666825873794683, 0.48924917065180035, -0.7028774098730357, -0.631205741371738, -0.4995104257784369, -0.7033568326921622, -0.3292415566550349, -0.7849870422106328, -0.2649001478165654, 0.49476163045324323, 0.20268438671205685, -0.4095430159833429, 0.267980841204012, -0.5140702259495518, -0.11744357248576817, -0.33054747470434803, 0.17464172203251394, -0.6249091003105772, -0.20291828477613075, -0.50634799960213, -0.38394579281866764, -0.7558301261750421, 0.10570782818140102, 0.21196147872814403, -0.193079607806029, 0.03876361014187806, 0.07264394279216602, -0.3873622663865801, 0.10918869742542549, -0.40087904670397506, -0.6842096184251147, -0.14423261081761987, -0.7326322005603422, -0.6231326584312009, 0.08717329835737414, 0.08716298195562527, 0.2439555301746537, -0.4552114750658348, 0.32465130342333204, 0.1037138746727029, -0.2842133163513718, 0.31879788863270936, -0.4913848189197893, -0.34318139002709575, -0.34950683151210077, 0.18910629097939483, 0.3835921603886737, -0.5300411933542505, -0.6989985592360897, 0.3007050896692655, -0.12957382713450158, -0.17704784739741464, 0.03204309269419857, -0.4439700129796905, 0.2982510936855646, 0.17145131460259389, -0.1067054338678901},
    {0.6376753546269065, 0.5000619612700674, -0.42159843327320345, -0.27850352207916845, 0.2772373373897507, -0.25462285356638453, 0.2681597708168128, -0.6291796793471122, 0.4622796292434573, -0.8174616483636368, -0.5142515826406119, -0.23626502672189578, -0.28991820484634384, -0.2517167261842074, -0.5834905108260265, -0.18832272140805814, 0.7317972660374971, 0.11303875712259827, -0.7267940944579744, 0.4602228232805295, -0.20139784286855225, 0.5107652133742396, -0.37034539467080646, 0.49979255763046737, -0.3885332439112334, -0.2873435543981303, -0.34146937552153667, -0.15199052280476769, -0.5581054083555754, 0.40388559728946477, 0.14340103914936184, 0.105991256045307, 0.3741941990122088, 0.20391187481593284, -0.09829683966992019, 0.14586359008905808, -0.3946831507393537, -0.378737889172882, -0.052447345450392986, -0.7698086127374361, -0.495382547992785, 0.2720400433735656, 0.645145261383224, 0.46730714378968174, 0.06051110300011664, 0.6409372546750287, 0.27610921176522923, -0.026342168679233398, 0.15976653465120874, -0.0024270521514109995, -0.036502793974788186, -0.20726068041460605, 0.35958284101598653, 0.4171945098452343, -0.44084329912798803, -0.11707918895932733, 0.39358973634936445, 0.18318091450618446, 0.5069847661042669, 0.4672155060350599, -0.7162570681497139, 0.6496882648841713, 0.28587483890195775, 0.17119286825905028},
    {0.6863373566257193, 0.26246097204799884, -0.4375320625807148, -0.5860054883222285, 0.3940384225308313, -0.13162126375788027, 0.04447260102724214, -0.7571565556085774, 0.4912829234785775, -0.8712285578385144, -0.6575715596118388, -0.14183020959079373, -0.34005452710945516, -0.2802053898776269, -0.833007440925188, -0.10021780184429542, 0.6461471461603892, 0.418156351624733, -0.6381772758052764, 0.6391763251739961, -0.282267852616095, 0.32407880059257355, -0.314948647903363, 0.5105978915538948, -0.33231538028559776, -0.11721963572860786, -0.30923708954302304, -0.278258094279424, -0.876690080429296, 0.23830157949763509, 0.1382090082471178, 0.004740738663547365, 0.3213658402006124, 0.5743389462911902, -0.06708714271018876, 0.3570413103979891, -0.35895152871059355, -0.7114380774353872, -0.027131784979434578, -0.3381144169642892, -0.2605094658426189, 0.2391795007074153, 0.5333507559191839, 0.1596497922558654, -0.06152082923493556, 0.7415767659460029, 0.1436317728836236, -0.04410418402945958, 0.31744195536017306, 0.0840172576255076, 0.063373193405101, -0.2324871523739412, 0.5432592750478858, 0.47786420504933064, -0.44527116904927977, -0.49707893657637847, 0.6354972270245604, 0.015949370973321452, 0.30475501796632315, 0.31568580709802896, -0.5869968846232303, 0.587241434443073, 0.49772482831621484, 0.45610630017943615},
    {0.6464404986219167, 0.2467624291431531, -0.2580373061121551, -0.5512617719389177, 0.4162491197958148, -0.30517734246629485, -0.06410292269256702, -0.6135531739534494, 0.3917498379144976, -0.8463595200968487, -0.2854955144411054, -0.28467797246247833, -0.6199287031463447, -0.06610501057428973, -0.6360800544498958, 0.02018128622190567, 0.5857420212680913, 0.5007066258571033, -0.6553140080834806, 0.6264379663103032, -0.45212953597579125, 0.3913769828457318, -0.17627083336513483, 0.3230349402417122, -0.7031382118925905, -0.3478715135023796, -0.5450163114594977, -0.18488073450613537, -0.8696723397594858, 0.29928048420001374, 0.0907304828314504, -0.105997347523038, 0.3172236522682934, 0.46086220714462806, 0.07894416399231034, 0.07035233158372386, -0.43408715169513007, -0.7153846226989302, -0.13210090577676176, -0.5937918621773117, -0.5523522740910195, 0.021265269550881486, 0.559946686775407, 0.22640464652051442, -0.2192454661136411, 0.5982783681165773, 0.1290756050407548, -0.3300252932117603, 0.36581929650176986, -0.08023934948897421, -0.09704472228246315, -0.0851886876975543, 0.4133983911141614, 0.3724735775407349, -0.36031473453348134, -0.3232070317221874, 0.4869796369533405, 0.01579312246714456, 0.2763504689762663, 0.293651633393162, -0.5356425499421918, 0.44389128798042543, 0.08897254383378365, 0.06395757159679492},
    {0.6664847227677437, 0.4062129422494795, -0.5443995710842231, -0.5832602207240154, 0.6603395144256148, -0.24366638895625486, 0.14132139741506342, -0.6525248530196937, 0.7086258933876731, -0.6985536060518664, -0.537819747122071, -0.3936157495548283, -0.22222289642613863, -0.16049388044274984, -0.7460882417472114, -0.06118451736961946, 0.720272351099007, 0.520754940481158, -0.7103466828388616, 0.7031249100424171, -0.5129540085853634, 0.23265034572217097, -0.2001027754371385, 0.6900185419337946, -0.4480045705717448, -0.16852207083101042, -0.2680731646345348, -0.13785291984144726, -0.7361508906482127, 0.42010581000834396, 0.18925793347859016, 0.060445396479602315, -0.006286360204541533, 0.24293233462306238, -0.0668579106153037, 0.27968097635340555, -0.13408786654262758, -0.49188376224827474, -0.08542983688048675, -0.5156606366975844, -0.47667779984351627, 0.06978067307753075, 0.41348882444733387, 0.32291794838187277, 0.08122970219164463, 0.7560747057709589, 0.337148882170246, -0.2519956145356646, 0.5608926381547074, -0.08525022161422205, -0.13906313825983013, -0.12928247688489233, 0.5809828535584199, 0.6755423319025159, -0.3290777888101502, -0.5470034291919471, 0.6408031223695723, 0.12029571247240885, 0.3819994678108362, 0.5479735980058973, -0.6501095937579201, 0.636200161156142, 0.262748830704951, 0.271305832053091},
    {0.6450128522013396, 0.4868575593805474, -0.397868403633341, -0.5988160908125625, 0.5994996817310178, -0.23128338178242835, 0.1599499918862695, -0.7663486058194474, 0.5568855332941948, -0.8404224973975828, -0.4641498098463332, -0.32789777323354585, -0.19307620719437488, 0.16708479598134815, -0.5398535382439283, -0.14717552651055238, 0.7168871861371995, 0.19622689439276733, -0.6852381094384077, 0.444604450931207, -0.1181883374796036, 0.21786154755880754, -0.11801950127876988, 0.6976623342398729, -0.39812041288172684, 0.0904428996679135, -0.43945348864774336, -0.1251488082770353, -0.613926596246235, 0.5924630140570819, 0.06165513541143395, 0.43705298565228873, 0.2901015417560729, 0.4129856338699166, 0.33071016235009176, 0.3262171271095559, -0.00708446066934902, -0.5721995559416508, -0.21448433666147695, -0.7310658141024967, -0.5457580210576705, 0.4429074926914049, 0.7511194110696411, 0.25486791606871717, -0.14865105775282783, 0.8301029692422197, 0.2503999892415956, 0.05822027837446671, 0.5331769157524471, -0.15143219829068993, -0.07390736046882862, -0.16345830045548004, 0.45909976678309206, 0.7461097252331981, -0.41859006103721125, -0.46046277893465765, 0.37628505005562096, 0.09039483285943828, 0.5546791332842105, 0.6060993749951197, -0.29820838929560217, 0.7236259157427889, 0.298108923497264, 0.4082008828384355}
};

static const float b1[64] = {0.7984649363544519, 0.5410733674039753, 0.8091312864124592, 0.8133495685884139, 0.7853387913754603, 0.8138826660729271, 0.7849849575730709, 0.8280881627761465, 0.7424840224277804, 0.8412107435042535, 0.8386679660487946, 0.8125597818214271, 0.802381889636119, 0.7701938770429447, 0.8464929515569227, 0.7886527509526134, 0.7555877773535135, 0.8354115435069026, 0.8131267685435866, 0.6353100519433633, 0.8735684783172886, 0.8040884626427064, 0.798884452763412, 0.7036047729941639, 0.8609134126004531, 0.8278888424664481, 0.7974690217903876, 0.7929303395268115, 0.8243204906376035, 0.7593956916421986, 0.7011797232551478, 0.8162239398871556, 0.7509469894073675, 0.7743525291009407, 0.7155114565549452, 0.6915071369818185, 0.7989333659060599, 0.7101577674795921, 0.8303473549064152, 0.8371182984467425, 0.7985672383750241, 0.7644245076367646, 0.8192193197996605, 0.7052076235222073, 0.8040605089240846, 0.8314576885665933, 0.6425992839861185, 0.8093122256698048, 0.7762256348804484, 0.8018074950085089, 0.842307837021475, 0.8069351761372978, 0.7962115188513961, 0.8076624125614185, 0.7906714229796377, 0.8493325892654332, 0.7131178276886654, 0.7834688161911734, 0.8200175658117528, 0.781312853902838, 0.8177850570322227, 0.7954936652444538, 0.8568256088166476, 0.8162526979225173};

static const float w2[64][32] = {
    {0.719553508497367, 0.861802583273754, -0.10981454298935465, 0.8225197301164106, 0.4644754389126184, 0.824252665067897, 0.5138024982234561, 0.9371287483701561, 0.9848787915146483, 0.9147237484653783, 0.735956591792799, 0.6507457850350534, 0.1266885449415594, 0.05271871293674705, 0.37065997403896345, 0.14078737261229127, 0.5870201288062843, 0.9379970025820544, 0.8805412435639166, 0.8759490942640857, 0.590978288003395, 0.24293980409412808, 0.3859406973155812, 0.5087858807816029, 0.9627024385256879, 0.5434895846096092, 0.7964525985228145, 0.5049121544173224, 0.6538262815312449, 0.7470593211695843, 0.6926557864639068, 0.4798380941788515},
    {0.5467713890292776, 0.7273186681541254, 0.07314026686046544, 0.9611671644284245, 0.8587006291878891, 0.7828578953419841, 0.5060808576369722, 0.5573541045870902, 0.5957203635789017, 0.588462423103469, 0.5029562475665605, 0.46720859229876244, 0.07275132348686399, -0.025349056463460296, 0.5492824579439032, -0.18390216986066052, 0.6907302775571683, 0.613385255752343, 0.49372199879312473, 0.5892807775145065, 0.7181996984616924, -0.07155108904054687, 0.25149699976514756, 0.5518387286866742, 0.7519556314897484, 0.6245252486665254, 0.6257663812280271, 0.6501779435003069, 0.36446588221216564, 0.5903367465683811, 0.4730082772641305, 0.9231134522065132},
    {0.9278420036644541, 0.5066086672047776, -0.20885018976731642, 0.8428922232142113, 0.8997918389569752, 0.7990915781303493, 0.4598828564801458, 0.6616816114531707, 0.8954398565077032, 0.5852262287654011, 0.7304568815873573, 0.4382471042837406, 0.014927385153005207, -0.1481055273916585, 0.584964647805989, -0.021411180301690882, 0.901333761916798, 0.7676674354949681, 0.6950797869680633, 0.9191071441846801, 0.5512434132732582, 0.17817014898344594, 0.5547027417970172, 0.5300322843756307, 0.8372614743735718, 0.44681124061820243, 0.5881317839105834, 0.6275748029790803, 0.42167471377207144, 0.9018800892328215, 0.4843463607527994, 0.6037260785068385},
    {0.8612055258747027, 0.8485854327905414, -0.07273610780107788, 0.6155013844187405, 0.7700600576278805, 0.707474455071775, 0.5647141610177036, 0.5398057809592983, 0.9258950676118554, 0.5624897060082147, 0.9145943593794816, 0.5903336185808075, -0.010097946111356906, -0.0281516726079697, 0.4735321126257532, 0.07508867276546329, 0.8372673816103742, 0.8427581304870262, 0.7483445328160169, 0.8225883148645221, 0.7398936905814846, 0.032931283008947154, 0.28442787546750004, 0.6100182278006074, 0.9404366782836132, 0.480131541770568, 0.9472933275090781, 0.4333456221133069, 0.33071685621002306, 0.8285400345734625, 0.6784850274039834, 0.8695818118659322},
    {0.6184919742884253, 0.7506341292953952, -0.23980685120584738, 0.8929793966676192, 0.6863180790725191, 0.6530618056403665, 0.8515003250811026, 0.6688973996969146, 0.8886549548435106, 0.8613012342834647, 0.8002708564897001, 0.5227354157691089, -0.16005999307642835, -0.22743512364792845, 0.6813471465024763, -0.05234291698001998, 0.9384204631088727, 0.6699147040862645, 0.9317630121658977, 0.9344306914734645, 0.613986649522911, 0.16505259183081622, 0.22888926746582472, 0.8497357523043368, 0.6089192678990129, 0.8944304356580554, 0.8239653469436988, 0.4698426895930372, 0.5897073938373478, 0.9418947456122543, 0.5525674742671884, 0.5803051758885172},
    {0.7053823582613057, 0.8856443366118911, -0.17026723237163627, 0.8160650024108596, 0.7012553050709154, 0.8454715970807856, 0.5875660084793394, 0.7877017692782647, 0.9116145443496985, 0.7308482688475536, 0.5652505270787114, 0.5476695192846018, -0.2566434464125367, -0.12262523047595823, 0.6316710086385993, -0.07279540342804813, 0.6618209580252296, 0.9601753240956935, 0.9517695743315018, 0.8993095812279159, 0.6066015612136563, 0.0781797000766265, 0.20277221921271552, 0.7488526248438148, 0.6912863819832561, 0.7116774906609636, 0.6411562616029167, 0.49619766701876905, 0.3765801117220259, 0.8605068627774882, 0.8051867586739294, 0.6522637453524623},
    {0.8183494541070884, 0.8302233342876023, 0.05497506008866423, 0.7913745577368021, 0.6750922683251834, 0.6949075791572386, 0.7326345005098989, 0.49722212237129537, 0.5448849831328093, 0.8470511326542634, 0.5625263946466998, 0.8180501155720599, -0.2729824854700151, 0.14349819311990145, 0.5594796850771071, 0.159799100307254, 0.5893372236472922, 0.6381705206132936, 0.5413064436537107, 0.49756704339877705, 0.7231541060786316, -0.12679208150663523, 0.5195408723618942, 0.5697123427506126, 0.8927782669218879, 0.4620562040692593, 0.8608991634122315, 0.7449117029786659, 0.25490152357140716, 0.42821479221359454, 0.6634036952125073, 0.5757879129981628},
    {1.0042529961050601, 0.5815008877671031, -0.27017881013134903, 0.8367136412057132, 0.8671976631485547, 0.7547320533140964, 0.6497283073045663, 0.6404152395278985, 0.9821645626022368, 0.7178457665670964, 0.5972142225824729, 0.8687259348165671, -0.17248064376815003, -0.06247812803197794, 0.7371928499785946, -0.1524881414455361, 0.5463819795587578, 0.6196353023271922, 0.7111882844747052, 0.8092236000774066, 0.9272662987147724, -0.08811332063696738, 0.5485166824210227, 0.618856918278041, 0.730310562821836, 0.8688507232379807, 0.812859298700959, 0.6931487379221407, 0.6725221966412743, 0.45978241127690084, 0.8506545144540667, 0.8444745921416079},
    {0.848795083387003, 0.9794645713320824, 0.03455435970830681, 0.6906384221071904, 0.5006913433519091, 0.4712888463362272, 0.6815711865210822, 0.9157287604063343, 0.7472994715253044, 0.8642762083838555, 0.5312576740318881, 0.4580957863094455, 0.038517595980461665, -0.04353482190229745, 0.8091085663176651, 0.006692888813797822, 0.8854592042523711, 0.5103261993481231, 0.6904317240037144, 0.5700679971156648, 0.9846090059155149, -0.01389558448306376, 0.5926247408651886, 0.8573308720305708, 0.5208427174485402, 0.6706928776167951, 0.5481326576455788, 0.7613713557604896, 0.30982495985463054, 0.45496927796708997, 0.5872183395540039, 0.9031034575211383},
    {0.8472417171599501, 0.9973333494633957, -0.009354155589433769, 0.7547120462890434, 0.5229295646523232, 0.7900418748174265, 0.7587178951440154, 0.7906398901869542, 0.6178820575448496, 0.7763556122672124, 0.8823309991433232, 0.714343163159574, 0.16979562202844217, -0.26674664145673016, 0.4249709053141961, -0.2700749954325382, 0.63729311579439, 0.772616758925974, 1.0015308532115, 0.9925815509113114, 0.7259217781643114, 0.1905872457999172, 0.2838019695970204, 0.677227608878999, 0.8264129250584318, 0.9207474956167941, 0.8105877181735762, 0.44006543448351015, 0.3491265330690173, 0.6101798032087772, 0.9479574927147827, 0.9311380181148163},
    {0.911150028602937, 0.5785255652451657, 0.018403274314367928, 0.5917286792646378, 0.8178980695067227, 0.5005048441596014, 0.6337280734546547, 0.572459151243322, 0.7113178216732018, 0.7784805906158982, 0.7329734381551658, 0.5241005603312193, -0.1766377906850883, 0.16161800289827258, 0.853127014507228, 0.02001498575736888, 0.883901377717644, 0.90472467676862, 0.7911782227787107, 0.9360459814244007, 0.6585985434189129, -0.029767124724196018, 0.25182506581038805, 0.8970012995388028, 0.7412519502246862, 0.853293589886282, 0.7259420997648031, 0.7126884911821574, 0.6255320897865068, 0.9551909246547061, 0.6797438001084376, 0.5452887422299502},
    {0.9342626333713613, 0.6482664595101942, 0.12573572746165754, 0.9311163082347332, 0.500705570961046, 0.7860876310213029, 0.5411430999939913, 0.7113725637454404, 0.5415941838712897, 0.8014786239010182, 0.7670018853782, 0.8230437052799817, -0.19036079989890906, 0.09888568141446676, 0.5213762931186711, -0.0941105108071698, 0.6173617844475178, 0.6748085242478373, 0.6198179384946475, 0.9213045822654302, 0.8338640044946857, -0.0284346445507336, 0.5435692673967446, 0.5035182030521232, 0.6279863719517482, 0.5366353758068955, 0.8977479961769327, 0.7131719989046995, 0.535330609125443, 0.7944089368925705, 0.569088499690247, 0.526682753741968},
    {0.9067069793877784, 0.5400150458452271, -0.13856650398571563, 0.5535307593858217, 0.7164008179676541, 0.6840784280972602, 0.32613865411058196, 0.6135356014722055, 0.8235710910902593, 0.6650366454025857, 0.503617596834511, 0.6662304397295711, -0.25408545107793556, -0.07238499894633108, 0.7359661906982696, -0.17980369780413127, 0.5045035209198937, 0.9621967617777487, 0.7346335965840493, 0.5385057858932644, 0.8725677749027655, 0.1808392220783259, 0.5722843435292189, 0.7823400804542183, 0.8865422125798078, 0.5355144394505151, 0.5404099180870436, 0.7197046909530835, 0.3035504297481544, 0.698980032150996, 0.6157309177327401, 0.9269210052788116},
    {0.5736025619090486, 0.8912466834858069, -0.18515690862648207, 0.8365262797637357, 0.881380790836614, 0.5153080616503511, 0.3079772482434152, 0.7352388950857925, 0.8045377142461041, 0.6532972658862648, 0.887563484298613, 0.8064564885131552, 0.19864693101108638, 0.12197159347124921, 0.7380986399078646, 0.1756597391169188, 0.7604979622268618, 0.9190190149888997, 0.6219633274782015, 0.6080146904198858, 0.9387646273363941, 0.1329344456477497, 0.242800836160874, 0.8437269470581188, 0.8558668726143239, 0.4377774378211381, 0.6815387463209931, 0.38105863447980426, 0.4985927708434986, 0.685155547286902, 0.88725409676746, 0.7603309462692803},
    {0.6407076674073565, 0.8020535941693324, -0.052944098093649306, 0.7882442856441089, 0.5767072009200441, 0.6079980364718967, 0.3922605280263476, 0.47374431223404795, 0.8696021452073979, 0.5762517799895235, 0.9548700421567055, 0.4029305033999513, -0.09191583955126266, -0.2547434627587778, 0.4697699643760554, 0.1269070184212656, 0.8610931721303708, 0.886850903828784, 0.7851540845389257, 0.5000271682479137, 0.720332778185996, -0.06494844579448612, 0.5893028786062859, 0.6185918938256907, 0.7359006226894865, 0.5883238453752866, 0.9601909456913036, 0.4460156261285472, 0.2767304886178625, 0.5821060781470841, 0.4757814204979168, 0.6252628439392313},
    {0.8800237719416761, 0.6271214896755517, -0.1595485226727291, 0.9483563919601483, 0.8798935847602942, 0.5253023055802891, 0.7146790047639033, 0.7956041135582373, 0.5187245879115111, 0.934984041142737, 0.7130605773506039, 0.6487801420717785, 0.12841540969175982, 0.09451879381623056, 0.38545192424761093, -0.05616678831926363, 0.6022383304525237, 0.707633368780791, 0.8650153905346903, 0.6001620035632488, 0.5420389524680542, -0.037334079924173307, 0.6537514139532563, 0.7801832772399383, 0.936326988796643, 0.7682082995230759, 0.9181435029942815, 0.6175257185340065, 0.35252127517668796, 0.8327900318059804, 0.7144232741852328, 0.7028473470411278},
    {0.8184156559949461, 0.7280036299548621, -0.06700042147368142, 0.8152961212176812, 0.7554717016845857, 0.6262533416187153, 0.434403131776968, 0.6469978942322321, 0.9478836826843603, 0.8754635239358677, 0.7860692389880102, 0.6066561263269507, -0.21793714318799967, 0.16031809689716767, 0.7348086584420903, -0.296144018255248, 0.7230309885325147, 0.5898719805151297, 0.6609386128166871, 0.7260833903004883, 0.7823486795447353, 0.1909414870999202, 0.41138855613514, 0.6113261771846272, 0.595759865189915, 0.5998433923483703, 0.5818407636863068, 0.4199575009277185, 0.49539497097548707, 0.8954126449772628, 0.9004678920943017, 0.7840232618718768},
    {0.745206380864185, 0.7696562684706251, -0.07257059794825028, 0.568135195529766, 0.823088063853114, 0.5005107593389992, 0.6754829631595095, 0.7754143832186775, 0.6322749758888458, 0.5564759386428634, 0.8032859214150002, 0.6222413486719008, 0.05526535446687322, -0.10794225094238752, 0.4192558525721013, -0.05511020249013389, 0.8093917992171459, 0.9425316290608106, 0.8958123644508429, 0.6860213245342632, 0.7614579226149789, -0.00811652878547072, 0.6409568740863989, 0.5964091719188961, 0.9159095568706968, 0.7350135159226339, 0.5859276838354304, 0.7935494388206532, 0.7553644519794455, 0.9122150490082597, 0.9340949484401266, 0.617883359270191},
    {0.8517190815513017, 0.955392625623959, 0.05302987446892563, 0.7827356635701178, 0.909175229900884, 0.7551113136615469, 0.4344161163369855, 0.5976656906939057, 0.5496862408789291, 0.9674532710334913, 0.6790777406188809, 0.7202639594083887, -0.06048719488386909, -0.1597264934198855, 0.43647211132747354, 0.17318475427525892, 0.8961589841523452, 0.8523571497899171, 0.8651197919021341, 0.7540411316760879, 0.5600429295857757, -0.13986738501670795, 0.5789701019442794, 0.45357097952698083, 0.9257900684419835, 0.49994744064972363, 0.8207764308624509, 0.4115399828576175, 0.4851575318541076, 0.8851284119035652, 0.5372399971188667, 0.5879331319008058},
    {0.5936466222554373, 0.6235704206031111, 0.21128391155489823, 0.5676407819437179, 0.8509856568114825, 0.843664668873796, 0.6667183522811098, 0.9917926456853048, 0.9654140337481876, 0.8346618974708058, 0.5780746128450385, 0.661844434690376, 0.036756557572180486, -0.2040930050705505, 0.814464280436315, -0.24667249970981714, 0.6338711584617306, 0.7585423272957559, 0.6973130030962914, 0.5447613924699334, 0.7438732959459021, 0.5649182065966629, 0.5308749794690563, 0.5049716205129126, 0.7468664226763269, 0.6038838964235342, 0.5897569842101227, 0.8742919705245586, 0.8583789346503844, 0.7635767872740783, 0.8487221111969453, 0.5254911091243778},
    {1.0117169615966721, 0.7604196794277236, -0.08381085182675381, 0.984091119465897, 0.6199647941082654, 0.6499849521056426, 0.8072847175502671, 0.9509470027290383, 0.9546266794589633, 0.7464133854854978, 0.9452021888402269, 0.48256800896883134, 0.1464112245499711, -0.20562305773829373, 0.5296358456974376, 0.13914358217947623, 0.5536124684159214, 0.7636123216076944, 0.7191153089517461, 0.9505504909208738, 0.5378626596412686, 0.11770329834449404, 0.22469735098862403, 0.6100713083519133, 0.8807043334459429, 0.8985742742804356, 0.7330144492596259, 0.675175632656479, 0.8035464457269009, 0.8813117554411298, 0.8458125581479512, 0.5140170164661425},
    {0.687646009651209, 0.9153287598922729, -0.031262562005765514, 0.7397768818451683, 0.7264887449674902, 0.7352498520658454, 0.7450591195430026, 0.9305695492482028, 0.6775537548631686, 0.5860137657647871, 0.8667401591428704, 0.36759931897311177, -0.06805598282489496, -0.16397242423636155, 0.7938256694870494, 0.1845746305595365, 0.7556611947566289, 0.8574821797698898, 0.5700124814670591, 0.7742497365598762, 0.6354309207285009, -0.08570550267491107, 0.3994019360579438, 0.5820888765842067, 0.7384733823161106, 0.3901706136092706, 0.7170448972379442, 0.4553627875179953, 0.6448745324511654, 0.8503331702262472, 0.49855619263317363, 0.7212571125092635},
    {0.7123146349799141, 0.575687831684437, -0.05526127669323328, 0.9075286418922118, 0.9312892251781087, 0.8874683380690067, 0.7572590027109032, 0.5871656115565083, 0.7129128166672071, 0.901972415442629, 0.8834843706308118, 0.6767360882716458, -0.15237301610141607, -0.26992907171838304, 0.5565701200471705, 0.007679313822341499, 0.7718819865623628, 0.8230130837943135, 0.8737311553617843, 0.902061925635417, 0.7821935140407521, -0.05425868095738733, 0.25776681325395334, 0.5410845546797686, 0.9549884569241575, 0.6486053961245418, 0.8619633844001138, 0.7685794822270524, 0.6866658715276314, 0.8769156674194774, 0.5298366411562686, 0.7252355234977564},
    {0.9195881678871476, 0.5648147288677183, 0.1958151098765775, 0.6530058822251901, 0.8783069220243157, 0.8837800003783738, 0.49171468997082624, 0.4799210032565223, 0.5471715438646448, 0.9041794765532142, 0.8704638662764186, 0.6591383935428725, -0.10643703667652392, -0.13971623595502372, 0.6583379924305375, -0.13000036811104057, 0.472056965316722, 0.7035975041861671, 0.7336781453488904, 0.5311160588037366, 0.5725917688319612, -0.045720147603338444, 0.554272897114363, 0.8996630395409717, 0.8754835739379458, 0.5830754589205529, 0.805569112430179, 0.6530196900989583, 0.6444109718585722, 0.6612111562804569, 0.5175524201815719, 0.8166548270179523},
    {0.8514509457949747, 0.916096366816991, -0.2184721693022307, 0.6547049888433671, 0.7139653142718866, 0.7267665889178857, 0.7052341365280226, 0.8080112170205394, 0.8511658164898099, 0.8795142575257643, 0.8582368537856578, 0.5365407243727568, -0.21185368093290938, -0.0445409061146966, 0.48513148179366716, -0.06995321536841853, 0.7915793619140733, 0.7677519599523743, 0.9673169235514124, 0.7361563076104831, 0.7677838911831064, 0.1503098151817889, 0.5709083698375846, 0.9108848758584854, 0.9663301384154197, 0.8773007061603564, 0.8197078249737971, 0.7529450196503382, 0.613998660028258, 0.8347069863013331, 0.9545204484119815, 0.5750040447874716},
    {0.786359409433493, 0.7147607511341909, -0.09912503016566858, 0.6189137835658924, 0.7598647326622084, 0.7949313050604018, 0.3538733357907891, 0.8780229875896971, 0.6693436522211027, 0.8388259996330936, 0.8616288931190692, 0.7400980561809695, -0.01584540894782655, -0.27829649880726687, 0.5031467648968433, -0.2367592435600118, 0.7730563457078458, 0.8585242756489174, 0.49778289272874937, 0.8229369709381116, 0.7679563412164226, 0.05168224921417998, 0.30802531534089694, 0.5687111426964455, 0.8797214988710637, 0.7259354829276947, 0.6185576948903554, 0.7012669659820033, 0.34797707015297985, 0.5075361131918161, 0.7708086039829429, 0.4966817342966631},
    {0.49626643620361577, 0.6375015273341584, -0.019903456840543943, 0.6642169031592111, 0.8941743125326734, 0.4679857898254094, 0.621312000770514, 0.8737321882888882, 0.9849636996683123, 0.5310947374793039, 0.9522828640505749, 0.5777255706129747, -0.13810253587265692, -0.11872129238863138, 0.7288513216440702, -0.1480333033611486, 0.5956549521238445, 0.9182431371612771, 0.5928007680651142, 0.6677157090076891, 0.6918912545675057, 0.09022117878996473, 0.325430542000648, 0.8247568074478453, 0.5594328982790371, 0.7410995631085816, 0.5443978952167662, 0.3728713195435756, 0.38690220478206466, 0.5226380222575403, 0.9351731509509811, 0.7849116113970527},
    {0.7981374716670625, 0.7311563475328715, 0.16796661047189843, 0.5879909260322146, 0.43935961540332424, 0.7538187338754095, 0.755286873143048, 0.5205896001431363, 0.6618123056578951, 0.8657301181258387, 0.8632727263556662, 0.6909333761635206, -0.08563435551193276, 0.09012020753798947, 0.6013940319936373, -0.17692637376719886, 0.7928717283976188, 0.8703289660381478, 0.6726127940260013, 0.5504157021239657, 0.8969807403369345, 0.051265298917477706, 0.47219833443675774, 0.875348862513739, 0.4956036234171973, 0.8078821177090639, 0.801148151575002, 0.4428927166291469, 0.6649957591441977, 0.7851127476146212, 0.6599495361866191, 0.6131107005764465},
    {0.9393556229905544, 0.6375551530257288, 0.13933489984406802, 0.6637070070596108, 0.7957322657959349, 0.717892176463146, 0.46989735741330974, 0.8113384759797619, 0.8478535421051598, 0.8857816224147375, 0.8954659975311579, 0.7188066465632112, 0.0010649098012684357, -0.2569932413146418, 0.48922708572103607, -0.08168302009252296, 0.7204453091874503, 0.7005987209328324, 0.7629565329693817, 0.9433898891913579, 0.9044361062517506, 0.21860464606732233, 0.4821905880602621, 0.8871109600610089, 0.6198852933081226, 0.7400380877769143, 0.5872011564243318, 0.7197662514717241, 0.7026079407823087, 0.7899553795070352, 0.7648387006475665, 0.61924035480267},
    {0.9774061497027183, 0.5589531458102012, 0.15339404527513797, 0.521132031829306, 0.5270532665317785, 0.820266740145348, 0.3316254515364685, 0.8495126146791867, 0.5945359561311374, 0.8374186015866536, 0.9596375018398318, 0.45809617974928146, -0.15135450599431907, 0.025486216902794994, 0.3893768028545263, -0.11285847404646655, 0.8158737947379255, 0.5547735567770796, 0.9798480612011525, 0.528372547272138, 0.7284288326953434, -0.08022465550046462, 0.3164383064179436, 0.5316137724513738, 0.7118037428518615, 0.6591090223576854, 1.0059669464625127, 0.5325787737514331, 0.49931569076627863, 0.6674650391402298, 0.4565590652292966, 0.4827855631671609},
    {0.7111304241995647, 0.6611375392010251, -0.2535809535320759, 0.7027024824458276, 0.9592390201283599, 0.7891574245811273, 0.7984323573726521, 0.9268472285919561, 0.6434382625373753, 0.9963654708199857, 0.9880459614867251, 0.7859444123956616, 0.1159405741231133, 0.013842207891032403, 0.8348896393841462, -0.26092250312054055, 0.9988402583570252, 0.6285629590625225, 0.7600875003090015, 0.7958748873410068, 0.6654340803036187, 0.26420795915429957, 0.4102555940165979, 0.8310758408323357, 0.6723712739654124, 0.6988878361943431, 0.8010811417032723, 0.7131605166643205, 0.8208974368275453, 0.5534102907615478, 0.740932542972652, 0.7794007319165486},
    {0.904266567733272, 0.770307703410611, -0.027737454502875535, 0.9382963740609988, 0.5441137417146386, 0.662780107024558, 0.5503409522749195, 0.7943818864513565, 0.7765679558653973, 0.6847067007908628, 0.8068143635144747, 0.565897156759258, -0.03198526295772108, -0.22305217889216009, 0.5663783285397717, -0.21014860297558913, 0.9104199846487787, 0.8678613855896469, 0.722657330598291, 0.4719981799057165, 0.8152547623458206, 0.2958109729414554, 0.45887749626944163, 0.44653882866486166, 0.5438976802818792, 0.46172279054199655, 0.9765690447699429, 0.8139881106990158, 0.6914844210032146, 0.6205892443207323, 0.858730647818179, 0.5667070350795821},
    {0.5793130428422386, 0.9500164616901574, -0.23221763240845317, 0.7247428891586241, 0.7500160191587001, 0.9512696965517368, 0.8830842309549811, 0.5436640849030738, 0.7580922318141475, 0.5517983937971742, 0.9094172616379066, 0.6838785299923476, 0.08228047624003561, 0.15994904075976765, 0.7204048578873834, 0.06532580443713597, 0.9033275909549517, 0.7537173358286714, 0.9437641251197245, 1.0348511737140842, 0.9669574889841673, 0.045063235077038945, 0.6613167007047388, 0.5174205034628144, 0.5274556807023189, 0.7964133710127376, 0.6758481422160709, 0.6646952214449766, 0.8770257857470815, 0.8574644438008433, 0.9876957725929459, 0.8038890206837085},
    {0.910279726394769, 0.525934453928493, -0.00685661356300417, 0.6684660551688554, 0.7600366056703602, 0.6296055026662736, 0.45043467079788574, 0.48064047361504697, 0.6235041613036659, 0.8270796214515449, 0.5401538774715556, 0.5116611762126728, -0.2689718583663989, -0.24262410829238443, 0.4651608571751259, -0.26490246682132135, 0.9082093480494704, 0.67020403096136, 0.659523541678455, 0.7952090333639784, 0.9468863713129129, 0.21301868259984508, 0.5916716586242989, 0.8772301308055309, 0.6060018289412571, 0.4682304319072856, 0.8798156842903846, 0.5733433249344597, 0.5895115065365913, 0.7949687556152396, 0.733564816737013, 0.6433528497613531},
    {0.5375587062461984, 0.6388468634647915, -0.25207041633100297, 0.7459130780901236, 0.9423517095202055, 0.7395150551837719, 0.48792345885174765, 0.5738531136356156, 0.7032973890202037, 0.6277075774744579, 0.5175898152608515, 0.6689952169211193, -0.17848407549888778, -0.03543421379805817, 0.5032527463469534, -0.025554346841692756, 0.683417414252239, 0.9184163437774858, 0.4927535940849126, 0.8864723340864578, 0.7176289303993942, 0.3232407211807753, 0.1989863412207249, 0.7148348020982979, 0.5876684685952244, 0.8211252351349082, 0.7406019640162359, 0.4007428970384276, 0.5672863310548472, 0.6567125482080212, 0.9401109860256379, 0.7614342239097384},
    {0.5008642087520782, 0.9090022160064645, -0.05684039686822006, 0.9310608859548561, 0.44772346055308393, 0.8062342338915557, 0.7653407823992011, 0.47524196123841433, 0.5727427260565129, 0.491828239192776, 0.8737807145325341, 0.6844213683342889, -0.25792892980926635, -0.23705233674448822, 0.6309721012377463, 0.0871857597334336, 0.8405072809225093, 0.9833659181791441, 0.49608610630011796, 0.513108109699167, 0.5994863750442411, -0.04527423859149608, 0.654136566816767, 0.786549911102534, 0.6482140231124328, 0.5945260624735779, 0.5592001605958974, 0.713591442058108, 0.30219014644257974, 0.49837371570761174, 0.7273215736233539, 0.7938744120662472},
    {0.8988081473778702, 0.5569313126398839, 0.12901950693651573, 0.8365639419980475, 0.5485518139554778, 0.653062524013062, 0.32292172284553605, 0.6870430192742558, 0.9231157814818218, 0.6825017750089176, 0.4811973672809354, 0.6302094543363883, 0.11826402325322755, -0.23484610642003542, 0.46110297697344, -0.21783386220132053, 0.5604473598446158, 0.9174611896635783, 0.8550519908662506, 0.5453100074227597, 0.4860627877640175, -0.09746248560632866, 0.3084114100142692, 0.35393266882614244, 0.6993678709989533, 0.611842492375078, 0.6190448270329648, 0.36538711441646515, 0.588011964995676, 0.6906605326416841, 0.4979703625141603, 0.7513501153160862},
    {0.6632954751845833, 0.8916989654321078, -0.2655000032545455, 0.8151611536585507, 0.8746268646442167, 0.7888741054025876, 0.43673496657882144, 0.6382801345661347, 0.6781199687316786, 0.7049561361727175, 0.5308389379535035, 0.45741438451947075, 0.07484370686577113, 0.16529557649954824, 0.8342034113095592, -0.26827524132917296, 0.549565604718209, 0.6233771393530435, 0.9160008554559685, 0.7234719333269181, 0.967482934697982, -0.021105439840010374, 0.5244480534765126, 0.6492955151841578, 0.7729585550997756, 0.8427713086354861, 0.9074768417953575, 0.4849670602448952, 0.7502635703002354, 0.7147148818184449, 0.8678335830107525, 0.9282124316962943},
    {0.9252264947493927, 0.8135029597541786, 0.16875277869852484, 0.9495354065835306, 0.8050716500515527, 0.8787509052801441, 0.7554933743361746, 0.6762907327881649, 0.79208527781118, 0.7277793824039647, 0.536922276261241, 0.5521378524301152, -0.17529402275218173, 0.17491908426354638, 0.8293994849241814, 0.14284516284485343, 0.8795380746521997, 0.9319506070413573, 0.980595279833952, 0.8173470934624455, 0.9632293851305549, -0.027780279122721102, 0.5310990967467133, 0.8849932114966583, 0.7616276288250492, 0.8645922973398347, 0.9684232313875978, 0.911365733699853, 0.6374528910361769, 0.7287976756220231, 0.8090951414164974, 0.7162473460201274},
    {0.7784369716132072, 0.6461772568167916, -0.19546264645622063, 0.6748038754954452, 0.6383636085039746, 0.8394851407216561, 0.5593082438024584, 0.7357965057461369, 0.8153411912560714, 0.6665529652471249, 0.701358366165121, 0.8805435573044884, -0.1756766249017187, -0.09714824107288678, 0.8619109766931141, -0.18529543430601395, 0.5080794243568063, 0.8978668582880707, 0.7498639672712288, 1.0508339987099167, 0.8161449262125194, 0.13859573146296675, 0.5221070745880155, 0.6989241846137078, 0.6179503795633778, 0.5272022237015752, 1.0695927212196292, 0.7510164540618676, 0.4741613709073208, 0.7366590026515166, 0.9553381222309132, 0.8241032645852631},
    {0.8336609305691508, 0.6964176467317585, 0.09997278799226875, 0.7442361981717144, 0.8647151223094766, 0.697195090393034, 0.6598317510486705, 0.46146805547957637, 0.5358397744290808, 0.4980743345845996, 0.9170374206652414, 0.6802851259923165, -0.05199145628851094, 0.08712214511208687, 0.3572270102239853, -0.29838809789288084, 0.8663418974449898, 0.7200050983120115, 0.7882943915225872, 0.9194272639686187, 0.5728869520689391, 0.07493683879389272, 0.6550153588261866, 0.5220717452153296, 0.5692177747207529, 0.6166763680552565, 0.5826486289975058, 0.7441168878220584, 0.2604507072023607, 0.9160862844911848, 0.5787257479653843, 0.555389061462404},
    {0.6127396240826397, 0.6892432302642857, 0.04404179495542912, 0.5472704675436774, 0.7072901959848115, 0.8499524917261143, 0.30781878075080205, 0.6735644594023543, 0.9154443544505055, 0.6125394568972905, 0.5532780063981043, 0.3427717064811625, -0.07995458179288921, 0.009746976708006836, 0.3089988872990287, 0.09107752209370215, 0.9071462085744344, 0.8089970785016342, 0.8482827396210659, 0.6828062268964276, 0.6503303798512903, 0.19954837433802666, 0.2622641008573555, 0.8298040555463596, 0.9096144706134571, 0.8620239854747229, 0.6964219032749067, 0.7979346647925996, 0.28202848851772516, 0.4523850101254348, 0.6669675413214755, 0.9373972685590376},
    {0.9692734828692202, 0.8734825009253022, -0.2173628518330255, 0.8092724563472129, 0.6224822144909441, 0.5410683648098464, 0.56514217422729, 0.63058092958871, 0.7236770900617288, 0.7646850089489319, 0.5973293045535816, 0.8178903789852485, 0.08505349378987556, 0.02425996082319123, 0.514454063197503, 0.07720704798649927, 0.5971424307392146, 0.6486057529346313, 0.7920452470127772, 0.6406850727905556, 0.8099162741798549, 0.10945296353767034, 0.43710347501476143, 0.8291064990789778, 0.6267742412683797, 0.4853880354481599, 0.5909483286766497, 0.7248302531348135, 0.2403120708824025, 0.48188243104844086, 0.5859306634635354, 0.4688152896109058},
    {0.824196569455851, 0.7281662063304758, 0.1651830565406814, 1.0082758561306555, 0.7164524936224652, 0.5016666164517046, 0.49105525832768887, 0.6384073540518813, 0.8873679335581494, 0.7396504309355861, 0.9605472149928629, 0.4800772534135732, 0.09566815540867815, 0.0653450517824061, 0.6538903915307276, 0.010684812290870179, 0.9098813839213329, 0.601939416726654, 0.7394062057545582, 0.5760091449138267, 0.5991524065412593, -0.09174060770034463, 0.4013199456004923, 0.7910585800880913, 0.9329805414579789, 0.8003323773431316, 0.722008701694271, 0.8283364279834183, 0.6331394667325838, 0.7775667912922581, 0.7226404258511784, 0.669422514791607},
    {0.7870463258770116, 0.9305520937748941, -0.13146008810857032, 0.5333125990437786, 0.8209023422916387, 0.7474709378619853, 0.5869235228970101, 0.7820564070630553, 0.9749057758074503, 0.9220353719991313, 0.9251545006932862, 0.6996410727690807, -0.013762914169593462, -0.07626044761932128, 0.3775254659533067, -0.05563114119441521, 0.7732639681161871, 0.8701543034732441, 0.7963458701080467, 0.7735930031992172, 0.5813322023857782, -0.007985634474799838, 0.6726278322065824, 0.5583406857176307, 0.8201248766946598, 0.47144997268800065, 0.4936939994432295, 0.6140295464085878, 0.5202333628227116, 0.42255765713134913, 0.4204985408159416, 0.6892467483156218},
    {0.9772765799403332, 0.734080347941046, -0.09263621874639641, 0.6987135511881929, 0.8939945156348346, 0.6290637134436217, 0.5910522062212121, 0.9100059126027636, 0.8978532205187706, 0.7207103849603789, 0.772124564764262, 0.798660311712013, 0.11640606416628192, -0.07930624748498363, 0.5035752775517209, 0.12565280898054762, 0.9143863207656113, 0.9873087043063116, 0.9229665167519816, 0.6660861026129264, 0.5257891615190158, 0.20228917799619744, 0.6179139267938393, 0.8885019145624825, 0.8142540551746232, 0.6151099676804113, 0.8337816941086945, 0.35267472243607023, 0.48957477504537994, 0.8314943262321345, 0.4894214425389306, 0.7481038337663828},
    {0.5957787711891394, 0.6871766256363245, 0.12697407726709786, 0.6045348894676104, 0.566993012621847, 0.8547712229757413, 0.5922301419521958, 0.6555044872118618, 0.8995603756594027, 0.6088384673620097, 0.7277000743346757, 0.5927881460073954, -0.044238940898066334, -0.16835911249707766, 0.6405335115990575, -0.011950619363794771, 0.7464316311679384, 0.8320180129444059, 0.8611980926630035, 0.6663697223267957, 0.795261182378925, 0.11944761635295986, 0.3178453131548474, 0.6798713413090716, 0.7240069092397616, 1.048892623644491, 0.8832409835410275, 0.8747615478037851, 0.6473860068200663, 0.7848394346253954, 0.6432886006815229, 0.6415280612920486},
    {0.9485443227173019, 0.5503919672884251, 0.12402917509180142, 0.6477940361128137, 0.5495739704460234, 0.5710101257276935, 0.6240888759087951, 0.6155462910304758, 0.575159814611949, 0.646759438445752, 0.5332499330600455, 0.6378800336941642, -0.2376418357379583, 0.04761924298058868, 0.6920245889736881, 0.0012929676827089416, 0.8800310930218371, 0.8158987494529264, 0.8284551970254049, 0.6793576090268694, 0.4923859493022693, -0.10817133638668606, 0.4528285350009951, 0.4047329002757932, 0.5911949494452015, 0.833867081925892, 0.5141256388762069, 0.5414826785477634, 0.4315248539218288, 0.4295316927391313, 0.6944527743635649, 0.8947475280236684},
    {0.7839644790743691, 0.7218825267600741, -0.04388030500167468, 0.6769797308709742, 0.8208111990399181, 0.9561409572521083, 0.8565118576209884, 1.0119917872274367, 0.605915592896923, 0.8962775655643992, 0.6051260046347977, 0.524588176767451, -0.1761490767055748, -0.07047336498208732, 0.6331405636896649, -0.04495091338402572, 0.7581775496694664, 0.729264070874668, 0.8249220267384497, 0.8791733234250193, 0.9209597076382009, 0.2104641793084771, 0.5202282199791448, 0.490204554293168, 0.5853367920738155, 0.5798478161679299, 0.6937111684967748, 0.7586947092328892, 0.4739841668227368, 0.9208002489218928, 0.9392286265501176, 0.8967928437826812},
    {0.8840140506831292, 0.8653482810372138, -0.1312148352045958, 0.8769644624849761, 0.7727019934890583, 0.700644373700925, 0.5472494244360059, 0.7422996210389452, 0.903977893578484, 0.9110296078736462, 0.633645996444018, 0.5626009895251974, -0.18847676625744142, -0.20664316782285422, 0.32147640780057657, 0.15565546726055549, 0.8426179422326805, 0.7867919859328942, 0.6145961825369812, 0.6348536364980254, 0.6595483674971049, -0.0060039243852354, 0.23072724009854917, 0.35118409099680703, 0.5391547221501167, 0.8918127310255519, 0.7574012390033958, 0.638096093497867, 0.6868123177100689, 0.41898244541081786, 0.4797545991518528, 0.8713523771114114},
    {0.5663945285774009, 0.9247065552338632, -0.237894650050004, 0.838926113876396, 0.7216511796688029, 0.6205809402009889, 0.5921026485771039, 0.7161643837040013, 0.5365079111627474, 0.6542133276989262, 0.5160070042124371, 0.8053474817498525, 0.052108900428594646, 0.1484081643330972, 0.5696055858375192, 0.01692111498255305, 0.6866660100412343, 0.8447709914350217, 0.9347575833493792, 0.8797498324112366, 0.9800244265772726, 0.16784079014149028, 0.2643809668128503, 0.5566461001024623, 0.545107120110778, 0.7329592900918668, 0.9570109410839095, 0.360930354367593, 0.7510331677701534, 0.5717751280847108, 0.5311964406057887, 0.47023870940438245},
    {0.8839805494636427, 0.664325362403801, 0.07898854819983013, 0.5988326278849825, 0.6089671763639032, 0.9375615816442165, 0.8668176009733966, 1.0061173411400495, 1.014701953792752, 0.6741403909839372, 1.0361324234906895, 0.5442790224632159, -0.004560808554935066, -0.09118748772202735, 0.6511669812854387, 0.09946381867734669, 0.7506632623431901, 0.6807410155128285, 0.9362686015127096, 0.8718433016887389, 0.6908536167615787, -0.08236479634544022, 0.45566866255642563, 0.6627823627355665, 0.6550978793824395, 0.5493999665248799, 0.5791640228613908, 0.9417238778746347, 0.7490206374054775, 0.5942105106361845, 0.7531685548404762, 0.873599934368765},
    {0.9503003994627051, 0.6110319259762816, -0.17222848817659533, 0.8090629846118931, 0.484200041504665, 0.4967133042785783, 0.5587142890964191, 0.5048154673304392, 0.5187357204227141, 0.7204132213626039, 0.6936781453022239, 0.7686750372765138, -0.20348140154857636, 0.036292948526124594, 0.5392896610967755, 0.053629579477647876, 0.5039033299573785, 0.7612013950349795, 0.8233005652523542, 0.8274194821557543, 0.9792730724984372, 0.3543789691445354, 0.4060390881153724, 0.7887280476942902, 0.8051087773921763, 0.6762743242397408, 0.8723265604366411, 0.7859315259334922, 0.2639154556299827, 0.9125640948737661, 0.6113630123863804, 0.675259665052625},
    {0.7549258844173111, 0.8355695335582322, 0.13576841705782178, 0.8738464950745217, 0.7453187571984278, 0.6764341968879923, 0.6129507197430271, 0.8355886762230246, 0.6334349423137616, 0.8330913609383036, 0.6294579132230061, 0.310682896514912, -0.13049132465561122, 0.036999530936658316, 0.3758294066755532, -0.20900467679087512, 0.6498286735051622, 0.7534439264661225, 0.892763355224572, 0.9086991506339883, 0.7127404655282426, 0.20867683070581652, 0.22723286836469628, 0.6077088717237206, 0.944238550190852, 0.8693775183926357, 0.9069735598360599, 0.4144550426796264, 0.48410528854312246, 0.5373414878831221, 0.7686439902540022, 0.6854630030784097},
    {0.8864594227163556, 0.720291574907924, 0.170325672343301, 0.934351371172608, 0.5562368331936285, 0.7700155389469255, 0.495454990081441, 0.7898807583256472, 0.7690670748741607, 0.7892885582352426, 0.6441037262444164, 0.5077836698913454, -0.19678420338901273, -0.042857747198938964, 0.6780153604879501, -0.026947147704769022, 0.7123058655076412, 0.5181116968011059, 0.9235194996297406, 0.9200350316907687, 0.6598558318204563, 0.021926898363395862, 0.5071985292098604, 0.3983255070676763, 0.6957263517366803, 0.7802826844120656, 0.5873362362174476, 0.34600347424924094, 0.7259098307060656, 0.8778606799759199, 0.8296294680581818, 0.9055547604326811},
    {0.5450219634403457, 0.8284356251784601, -0.20931744605913497, 0.687222937819178, 0.7661145191260331, 0.5644784445222489, 0.5986720787438042, 0.5076287557273083, 0.7912511918903906, 0.6534362336219993, 0.7927050099320936, 0.630491095999985, -0.19794622516651406, -0.04443787997490035, 0.46183083113133727, -0.23466947377608824, 0.6797241145519808, 0.8170809931929693, 0.5625284155260867, 0.4630476982602056, 0.6855588793213642, -0.08453632414313793, 0.7070170199157587, 0.6558524278942811, 0.7671485506756996, 0.64693608341618, 0.7020598259478279, 0.6226381162551008, 0.615821732933331, 0.5991457905796059, 0.5672261625388673, 0.5948516435664845},
    {0.5329457423439096, 0.6937660460368539, -0.18739595270668602, 0.861542766312246, 0.5200786976870103, 0.7287284646333578, 0.33115696314343696, 0.5639578937603656, 0.771355538393168, 0.7796528479038247, 0.6385562080559967, 0.7510617211690872, 0.15538144900278705, 0.11456046537514969, 0.5851813812602629, -0.16031153072850646, 0.4994965468625574, 0.8760252546668541, 0.7472702520926305, 0.629901967730892, 0.974232009509485, -1.5747819805369884e-05, 0.5804086329805775, 0.7782846514978556, 0.6410289158191409, 0.832781418181915, 0.6775007818860393, 0.4518413986702249, 0.3924417101266649, 0.45339979857899115, 0.8812363170332453, 0.6212634154261317},
    {0.7441298050579968, 0.868749584282192, -0.0782281847236072, 0.8491723604109942, 0.7978094738236193, 0.8520074793926689, 0.5757374096440222, 0.6657565345150395, 0.8748066994288094, 0.8451462460197259, 0.6428853872432986, 0.49021902340889634, 0.19823074010566238, -0.21279388716288408, 0.3737882904121496, -0.2442503244644836, 0.7793935843071835, 0.857865608157913, 0.7810593890259081, 0.48968230315085487, 0.5084785617897539, -0.11474080334345127, 0.3574393697762017, 0.7051730815300081, 0.5609255513893597, 0.6848915761604983, 0.7260051834652888, 0.7040364496602576, 0.4855318773331017, 0.6849807844916849, 0.4977048387237638, 0.7571341754934708},
    {0.6352042261739145, 0.897612144354391, -0.24853992775109685, 0.5568681309371033, 0.5299768859711144, 0.5859947432458963, 0.44965056126399583, 0.8710762472520841, 0.721223831010627, 0.5304975033270531, 0.7952101615596262, 0.508787376316644, -0.2619414009074371, -0.21198068888400307, 0.6100395753936839, -0.023054890576880625, 0.5415960341324725, 0.6991854703254677, 0.6367961150946546, 0.8663169713022432, 0.6943978937965058, 0.25390140550446466, 0.6003882965989136, 0.4588808990214582, 0.8566220603576384, 0.5504157384757372, 0.8040674888872267, 0.7490841217583278, 0.4085266367074812, 0.5906446554087175, 0.6950827433327296, 0.8186659016142362},
    {0.5422957790607222, 0.7466838461963494, -0.1989116368022063, 0.8087065651195279, 0.6687456725361419, 0.4933419012582366, 0.5032116166217087, 0.8848263507463241, 0.9461671391254437, 0.8722664180573335, 0.8390791282625728, 0.6483499126614707, -0.21065446177074987, -0.1094385009611204, 0.6498284316418171, -0.2258195072465514, 0.7937080371280731, 0.6779501437493194, 0.5002247657080974, 0.6509260925709054, 0.7991143469707674, 0.42785094813659, 0.3182201537559391, 0.5766586332283163, 0.5734620671054469, 0.72236156624112, 0.8156878912360045, 0.3823225472936211, 0.42465652625155925, 0.5175087682022431, 0.6734723119886956, 0.7929657872156879},
    {0.8169522746157839, 0.758756491170017, -0.0835730139427856, 0.7859116853015968, 0.5676307761061101, 0.7254844071646503, 0.5107706898810567, 0.5608666193701524, 0.614446620135545, 0.8348153892379876, 0.6819376560401793, 0.556071413568193, -0.22712336331229652, 0.0900521825265996, 0.5160131309329878, 0.0067948284742261845, 0.7832545970961389, 0.7882260796066947, 0.8808721812909281, 0.9384029367304525, 0.6264674288197498, 0.028728980495099567, 0.6082232343867836, 0.85036147228152, 0.6466393331369532, 0.9166699544781836, 0.7186606536519681, 0.5576319374012568, 0.458655010827008, 0.6646684499175021, 0.8304417816167611, 0.5760013711456393},
    {0.5958462554251275, 0.7063229382843818, -0.024439798461085696, 0.6673639075985227, 0.5325116782776073, 0.8693204280637219, 0.3306165750340862, 0.7725638958671655, 0.9124151066624365, 0.8400646288003609, 0.8572705789079005, 0.659207740813228, -0.08211289506899028, -0.024055121935088696, 0.5533314271623773, -0.05510904156945768, 0.8073700822810116, 0.8542111468378245, 0.808458926963103, 0.9594588788583056, 0.5108379011741568, 0.5016472558396226, 0.6290736700263951, 0.7918897137644537, 0.934893363263932, 0.6209238209528596, 0.6963703707024157, 0.5262769909299252, 0.6425066538394664, 0.7740763903763919, 0.6693620682593672, 0.6989008275163311},
    {0.980740026816199, 0.7097435208009024, 0.09229654751020004, 0.5004722748196202, 0.5364337028762484, 0.5429892729368382, 0.4449129057475178, 0.649164570590498, 0.6920725901954284, 0.7152075864677142, 0.8730422533335488, 0.6754446154912899, -0.04955938062459291, -0.08495251661157867, 0.6764023793344736, -0.16099294819306456, 0.48969038625297806, 0.554419002084756, 0.5799070590565569, 0.7313420240382029, 0.8731973811770563, 0.11118953127175969, 0.47845602403255205, 0.6067124538204017, 0.5081728571224416, 0.732269924010516, 0.6432561620981093, 0.4928747831890678, 0.3754350800807154, 0.7218292571672763, 0.6187261501851742, 0.8542465429002909},
    {0.8492687552880882, 0.7440589602703575, -0.03415701221624478, 0.9156720857628903, 0.6185956000103934, 0.40665004509781194, 0.5622227645746636, 0.6078152508336393, 0.9031768200822569, 0.505091537146029, 0.5513202380309329, 0.48846380240391174, -0.15205522703954877, 0.042536616205441684, 0.4326522351582243, -0.14804485110911653, 0.8587339867279603, 0.7209081203925783, 0.6088117412257381, 0.6768829427181863, 0.8328407215178938, 0.30603842663814573, 0.27691259951952624, 0.4208073065625368, 0.5109771584918626, 0.5649138944235992, 0.59570713280326, 0.6024153991978182, 0.30754465014485477, 0.792918712415958, 0.7174144995127164, 0.5336188348934704}
};

static const float b2[32] = {0.6913938367816794, 0.7024509620884793, -0.037710189293439805, 0.712525639506807, 0.6892911067482063, 0.6192840558453838, 0.5927674310038208, 0.6841471087921025, 0.7232510379262805, 0.7055431134813074, 0.7038143664382018, 0.6001113066307473, -0.11743112641692542, -0.07476649498628976, 0.5560488674372699, -0.08459617610544069, 0.6557879572219653, 0.6788667247530117, 0.727901469548413, 0.7132366531610381, 0.7107970450562906, 0.3803991161901969, 0.47234574683158503, 0.6188605114319883, 0.7317864809182201, 0.6711368835592051, 0.7546840108271617, 0.5982147752829586, 0.5364025887340879, 0.6551551360316173, 0.6885948894495713, 0.7001313724159124};

static const float w3[32][16] = {
    {0.9872561131475573, 0.9884101804943746, 0.1435613012588011, 1.0722892895335407, 0.5813992915794088, -0.08509934022988824, 0.3261963185755434, 0.2830822821501145, 0.6946710293657965, -0.06546462578122028, 0.7986187717963253, -0.3677098446941767, 1.0153282928285907, -0.17866529107312476, 0.858729001202837, 0.7648168842266362},
    {0.794961758650439, 1.1087000406967826, 0.15945774958846545, 0.9766725806403995, 0.6642315602418047, 0.09270270064992157, 0.7567311266017531, -0.23348341384323426, 1.052252469810857, 0.21281647131121548, 0.7918903658311466, -0.17318853749369711, 0.7235685719027867, -0.285431344754075, 0.49306390554565765, 0.8415105465118411},
    {-0.052402175610020994, -0.22767959134938973, 0.0952037579411193, 0.013639966171061143, 0.11277903201972177, 0.06618425726472311, -0.10433297936203713, -0.23292246599882097, -0.1588508746656938, 0.2835164201502082, -0.0015529981163742354, 0.22280263454197344, 0.18142436282922517, -0.09261819726433411, 0.23763652193145607, -0.1754535146119484},
    {0.9606655212786349, 0.4748045547729484, 0.15768100595568335, 0.9087277197993471, 0.7132098188602054, 0.16632722657260388, 0.4523990326402746, -0.09346744225857051, 0.49057541106549546, 0.1782355499907732, 1.1425465718501802, 0.31966818361950106, 0.7077509108748691, 0.2857907087963473, 0.9161973118876141, 0.4730106633402812},
    {0.8652389961384044, 0.7066517735130343, 0.06208754304265863, 0.7680433164137727, 0.6385565080462088, 0.30564865656570095, 0.6909608539051559, 0.16398548165451907, 1.0245193162181863, -0.36602792408358004, 0.6507845850465592, -0.10024680593990991, 0.7793149776774477, -0.14441548672967752, 0.6489345767361533, 0.766895929496977},
    {0.9663496168075659, 0.6597616476139136, 0.2477435259683478, 0.527261116364405, 0.9595828893476628, 0.2793029593758799, 0.7486340364773416, 0.10137714807540314, 0.809041209596694, -0.24929910678900655, 0.6838685646209347, 0.07820278892398169, 1.0167207789448613, -0.24772610932914055, 0.8042754177248002, 1.0478890636873819},
    {0.4826463042976236, 0.4631846781857679, -0.07057128044780972, 0.8638961652672438, 0.9036914766873391, 0.12020689816760938, 0.8148677683858444, -0.3728415099173845, 1.069591598254794, -0.3246388894815794, 0.8170662268197151, 0.11353539297552179, 0.8696369155628842, 0.07187131380375528, 0.6213726631897317, 0.5884210868140917},
    {0.7188135235769164, 0.9009584716525277, -0.29203894956805515, 0.6336966911278453, 1.010628015580718, -0.010172561463675851, 0.9545175903480417, -0.3146178070200411, 0.7584067142149881, -0.3241354777653957, 0.6550576600857075, -0.30784052241144455, 0.5502675893044843, -0.08642479725505653, 1.0761703600751635, 0.5510110431361487},
    {0.713733401006127, 0.5401396018169845, -0.2904127173407526, 1.0284497701560438, 0.6119740469794539, -0.22985837346390647, 0.7928753793668999, -0.24108753770703592, 0.8080048350044122, -0.021670380223099233, 1.1350524623367764, 0.029704715157427286, 0.9051309467982934, -0.13116604916286406, 0.8946003609580258, 0.8612153554773572},
    {1.0218317160868404, 1.080997488470205, -0.24995144350044377, 0.7256914301348564, 0.8387389736263289, 0.042922558503790294, 0.9033930207466768, 0.15527137990074252, 0.8389653249185239, -0.19374112757232034, 0.5685474329515362, 0.30849543870528845, 0.9082586891294099, -0.055954595661948964, 0.9617018323399111, 0.5467270461653907},
    {0.6049753060517225, 0.4985710998679055, -0.2728346119171226, 1.0204935186902153, 0.7255790822794048, 0.059831879868898916, 0.9358344274113419, -0.33928684895235317, 0.9749402073871731, -0.3121884585404044, 0.7355081791537382, 0.152892324803473, 0.4448485265592495, -0.08858650428269063, 0.5645866609924026, 0.920093316828262},
    {0.5359239726968217, 0.9923368225328809, 0.20219549698789852, 0.5352101436671999, 0.5449544489418872, -0.0375966422593498, 0.7697407440349442, 0.1649407999031559, 0.9609260060461559, 0.20683024846458034, 0.6523388067167311, -0.21620190576013448, 0.4130136102345151, 0.1877094399923185, 0.43319363358582913, 0.802411169366538},
    {0.02825292715271357, -0.13956403342258447, -0.24046059906501688, -0.2007998766435394, 0.3177122940213416, -0.2211608291205333, -0.19742997685556413, 0.06153816601781063, 0.13440834213555994, -0.1553795602583631, -0.1473163733570279, -0.15714295430188333, -0.2165903142767471, 0.04156239418015539, 0.2642439071145167, -0.26038532625979943},
    {-0.12397596668208022, -0.24376471876805775, 0.2642311524654735, -0.09122084913323023, 0.06727974019877686, 0.2757343716296878, 0.011790058431608028, 0.0767658003458205, -0.18746861755805183, -0.09709327232001641, -0.01633793223454316, 0.19744992197246058, -0.10385573926404243, 0.14153352984183643, -0.3180023078694372, -0.18664859783029658},
    {0.5292044679503127, 0.7548169360226654, 0.19262198112558426, 0.6885271842340337, 0.621376737015013, 0.3145049308470574, 0.45613055579257666, 0.2978424853858745, 0.9792355153193942, 0.009834587219928637, 1.004161061000634, 0.3259640118606784, 0.5825755080564081, 0.034608494986576636, 1.0110311990334104, 0.7587552306189803},
    {-0.2809039317565978, 0.021728816833680505, 0.05364232248818952, -0.13244180358171026, -0.10753477210423923, 0.025751408239973267, -0.2055766627778721, -0.08678177712224026, -0.06407664946664589, 0.10701093140534422, -0.06934119445223441, -0.3567363246662663, -0.25332580124833165, -0.06586259488604967, 0.042287110185315384, -0.07373518900984989},
    {0.7464313411030097, 0.6415095415793326, -0.19127054246387495, 0.8094290199936669, 0.7800188595204415, 0.12015168218370928, 0.7041813297573649, 0.07332199387635481, 0.974750728050774, -0.24769866208445482, 0.8993305394629475, 0.16703669345964842, 0.4215403240993267, -0.21591377852410323, 0.9513840448408823, 0.5315222043684631},
    {1.0513342226871745, 0.6124018080540891, -0.37732852397813793, 1.0505994793637734, 1.0071044429522455, -0.29158907481709406, 0.7281607306921213, 0.16177666994943493, 0.94364050815891, -0.06318246106854036, 0.5609337546920088, -0.09485270681127075, 0.7720589212022129, 0.15236774695697441, 0.6523179543853024, 1.0878621050592578},
    {0.8606570807338767, 1.1231704833937506, -0.22889622928698816, 0.5119465004241607, 0.5627507963320283, -0.23438510072986155, 0.3785812580802746, -0.2189340447574025, 0.6771396547720117, 0.03912042991590198, 1.0459715372343417, 0.06122704140005062, 0.9054319979514684, -0.29670343630745966, 0.6700705839141295, 0.7600373430584503},
    {0.5624784391316637, 1.0906455068161476, 0.25702636783233934, 0.9606873372937136, 1.1110053643302507, -0.13336620992840625, 1.0047466844321087, 0.07550419728642259, 0.9743092085368151, -0.05007964549791597, 0.9822519796421657, -0.2073873074633887, 0.880662388950958, 0.09382047081827027, 0.5684068580816648, 1.0054694985561072},
    {0.9854610188268021, 0.9646442969648205, 0.13445496061746304, 0.8512414114499232, 0.5039590923475785, 0.08244389588583866, 0.8707127637639275, 0.004598763996900064, 0.6417740557537341, 0.09281056187451892, 0.9405050887206406, -0.1738451131249307, 0.994230382615614, -0.03241514693705088, 0.6206738074382308, 0.9096029241544328},
    {-0.005200268984769638, 0.5334245438976141, 0.08546339767377492, 0.35283882253316934, 0.7334210826180222, 0.19591000542469622, 0.6187008625682564, -0.004117333592060184, 0.27560387071119485, -0.1506881023780937, 0.13287476683945548, 0.04767149685214148, 0.6971606947171481, 0.04977605952252817, 0.5709308173423039, 0.17054893694561093},
    {0.3728781183643595, 0.46844281030749907, -0.13120248683166486, 0.8802403935330575, 0.41219300864068986, 0.22736486502440684, 0.36530724847012636, 0.15306710461787162, 0.4552136482443488, 0.25965798064522383, 0.6955145551684169, 0.28940059497888865, 0.4244204983456093, -0.221710738857923, 0.7061872211273418, 0.7374471883041936},
    {0.7103767099839472, 0.9173659997601163, 0.17832495641110827, 0.5391538560709913, 0.998524198994252, 0.017406092146116867, 0.8095197094787241, 0.0785288631937864, 0.9438989626638496, 0.29077213362034454, 0.9812411415715893, 0.10915087539620213, 0.811993011931823, -0.15493886344361732, 0.47538966801853466, 0.790274290468567},
    {1.0487234768078975, 0.8636189994653398, 0.26595564905012264, 0.7749326795668238, 1.0200117755272873, 0.16792944281925692, 0.8024052509538653, -0.1419130293436551, 0.4327878532991742, -0.14890595962472203, 1.1271279260464355, -0.0014641142836945597, 0.9902210272783004, -0.15606556471371835, 0.5563406372417377, 0.8648706907113096},
    {0.6108274635969686, 0.8615801070825418, 0.21064807731639965, 0.841847491827546, 0.59048026463265, -0.27237578473881724, 0.850187777157694, 0.2623122857608862, 1.0143984250029925, -0.3059337086068954, 1.0688653409999194, 0.07380407704840419, 0.8322666311224002, -0.1485668872732472, 0.4926790392739053, 1.1235888348103518},
    {0.5512291508246238, 0.8151922765881583, -0.08024491003466755, 0.8377777863526582, 1.1804172879669979, -0.2947137264785678, 0.6333174173402496, -0.3270763906799906, 0.5730630378484033, -0.36903690813022516, 0.6578214200309722, -0.12115711099142155, 0.4037924005853125, 0.22998816839175162, 0.8882095872513294, 1.0519052958601172},
    {0.5208617067816341, 0.7288627486010909, 0.09372369752666447, 0.5791894042475569, 0.4851791884932804, -0.05103129902995087, 0.8636877569531075, 0.31326596615776214, 1.0207885558182397, -0.020246467120822058, 1.0362315160014608, -0.325446685470316, 0.7374651027555148, 0.2943158498597569, 0.9632841120125306, 1.0322598836084544},
    {0.4926153321025687, 0.928073696955096, 0.15314741213180877, 0.5909680475878131, 0.4603561510119489, 0.09347450872733948, 0.6272516401641294, -0.3212816223302733, 0.33202995647380495, -0.30256094576083714, 0.7711954906221052, -0.20155071338443556, 0.6223439493437414, -0.2030269058316515, 0.7522139894174782, 0.9667333519358927},
    {1.0766419288993578, 0.5699902015371926, 0.07716538953446422, 0.6618388690683313, 0.6099059301088483, -0.17330535622307494, 0.9340016023095182, -0.10884740284889882, 1.0606809517190596, 0.0547021217061356, 0.8341989877317983, 0.06910076858298553, 0.8118945324682534, 0.049153524331372954, 0.4445903870296651, 0.6532270145943138},
    {1.0074764040268702, 0.5676121986988112, -0.11665554349649741, 0.5761905634751472, 1.187488023372877, -0.19796834970548366, 0.5689885748234264, -0.24502178240211, 1.061946136369881, 0.07346993606287403, 0.7219508979522202, -0.04115736447156654, 0.41492725109113204, 0.10543577301705777, 1.01640505015677, 0.5533618342481661},
    {0.7185441033016807, 0.4457002523472596, -0.2662685509302794, 0.9877687629516678, 0.7285373378891156, -0.17391070512119353, 0.5791852470082633, 0.2576831322187792, 0.7180682452292476, -0.10674607526164716, 0.772032203118614, -0.32159413194281417, 0.3643264334090543, -0.18395233395780367, 0.8954029758613683, 0.7354538280003223}
};

static const float b3[16] = {0.5049248034150163, 0.4960588497353502, -0.044053668364511515, 0.45791267132850233, 0.5980918163943937, -0.018823218355511713, 0.47156653415033983, -0.029252892911849748, 0.5617588510182561, -0.023424040029208247, 0.5594352663390415, -0.007064874164459153, 0.5622624435059813, 0.006856166188133628, 0.504982186439941, 0.5580818959438014};

static const float w4[16][12] = {
    {-0.43408441834995887, -1.0800895941185762, -1.060793190868575, -0.43144976501340476, -0.7277723497034059, -0.638076649083801, -0.5749003967853012, -0.28432627864535737, -0.6093508995864401, -0.932490564707833, -0.8448433711982204, -0.8572571551789692},
    {-1.067714367143157, -0.9602267578706205, -0.1959438186913892, -1.1418340662249278, -0.22769591557639682, -0.6999508638009235, -0.6987739484860914, -0.9412284423411155, -0.5222175256682662, -0.7554885699948293, -0.8436589741286835, -1.014643578578963},
    {0.12735185319036046, 0.31912383488758106, 0.2660262158686818, -0.4900467156527189, -0.15173293472903773, 0.0669421585699989, 0.39103162410349485, -0.11618213075540158, -0.05779235606074179, -0.06261838195452092, -0.3945341533997474, 0.12518314341805892},
    {-1.0651282693446524, -0.6189633669810298, -0.5711307011182534, -0.7403210516870979, -0.6514342298569307, -0.8053824551454716, -1.071948253502156, -1.0808693658290585, -0.6195013543583441, -0.33092997890117937, -0.9318053737491516, -0.9055890741839658},
    {-0.5682664073424539, -0.6668277849649872, -0.8633040540210155, -0.6489994896176313, -0.9274992842951811, -0.40782260592238895, -0.3717558654588307, -0.9771944915636558, -0.5258604214046457, -0.9920370133572869, -0.5383866440002819, -1.0949066336736302},
    {-0.16342394192086523, 0.288334922567566, 0.31743848211857184, -0.36721511992954986, -0.15482125427929225, -0.40241447381509, 0.28362160747448595, 0.2315356536579793, -0.21400757028613587, -0.06678731008588448, -0.024407752450503258, -0.204745825304861},
    {-0.3047980494423765, -0.7047208506935844, -0.9849052962393244, -0.35660756242520936, -0.6750176897793962, -0.3506123958947706, -0.8015708620327281, -0.9394838874652838, -0.558960435069573, -0.300386697296636, -0.41324551276588606, -0.17341968762787438},
    {0.086802063527647, -0.16975101250372934, 0.35611404014465015, 0.38551727349769793, 0.3312481139642447, -0.1982112140076116, 0.2558454952939237, -0.36139742570541195, -0.2872301795964485, 0.3195493690081509, -0.02523768545888138, 0.004139641961076989},
    {-0.9085979756341624, -0.2930140354502743, -0.6956165769196355, -0.3572075150249345, -0.6291917270063393, -0.9875960819509896, -0.9058944207630758, -0.30615117717737506, -0.9140201904051426, -0.37506026616106997, -0.8980046344149775, -0.6796605742674864},
    {-0.2686726036814241, -0.13797797887891733, 0.15755495563980446, 0.2939234287181712, 0.04707584188571824, -0.3633416737780604, 0.22977287954254674, -0.16395868929548288, 0.16174699695003183, 0.305287282676132, 0.27463623871275256, -0.25465812076096267},
    {-0.36746198548910375, -0.3640531521825247, -0.6469180250319102, -0.7807743148836445, -0.9856165922158507, -0.7310721839230855, -0.4285301735941782, -0.8502170528989388, -0.7650679333758295, -0.9885918431684145, -0.5120623856016293, -0.27037747391244843},
    {0.28900051950797584, 0.3816325678478421, 0.21922157795176703, -0.22672913949256995, -0.35054194597510074, 0.37001261414257675, 0.259149124507271, -0.2813722997643496, -0.3947276138177876, 0.2513041510540965, -0.09569182198457349, 0.3198078955350068},
    {-0.8854637695744256, -1.0949787795445163, -0.9531511506947629, -0.3400212548070713, -0.8738000141338113, -0.6854360752911701, -0.38262585869835625, -0.2540422501771996, -0.26911842007088504, -0.9868605110478185, -0.5965547826697517, -0.37962583838853403},
    {-0.22219916528451644, -0.38645344777180163, 0.2612786879610403, -0.3526708745750863, -0.36894857272487747, -0.45821405291322204, 0.15890279833465634, 0.08899807099103492, -0.4419095224331045, 0.09356832584914394, 0.19626254201814797, 0.04182156812542425},
    {-0.5332900380472833, -0.4062592926646205, -0.45627090657128566, -0.9921166907184841, -0.21438221075042205, -0.35867297911261914, -0.7661000438040446, -0.4752432359173058, -0.9392365764616473, -0.2961166130291182, -0.7858754096288103, -1.0672486886806718},
    {-0.5360232097828769, -0.6914466887801113, -0.3354824828802945, -0.9516095941491096, -0.893964223853849, -0.81342287893557, -0.6156579756028419, -0.6556785839402272, -0.9015089714284177, -0.6638029050649807, -0.31089684571823756, -0.2476809499805127}
};

static const float b4[12] = {-0.34525177223327713, -0.27829543549890423, -0.24597070917334304, -0.26702422152146343, -0.16373252571228314, -0.2092116558422199, -0.31702819539427257, -0.2621299927171009, -0.2143342290101719, -0.18467634037829042, -0.1369471534372467, -0.21106582758654902};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
