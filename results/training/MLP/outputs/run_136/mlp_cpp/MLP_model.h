#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {1.8707072434782377, -2.2380194876663677, -2.9779438263642373, 1.3826707459306435, 0.772534810035447, 0.23244492675439626, -2.51770394386441, -2.777510948962891, 2.416751870183813, -1.6058048632208057, -1.7681363254277758, -0.502213619732528, 1.6136958673446358, 0.016270265725010356, -0.4376883534010507, -1.2536711249358858, -1.7869966537579522, 1.1183564195546036, -0.42145511583702927, -1.1893330836687077, 1.2761621586124805, 1.3191677119778624, -3.3318999927285957, 2.475874342636385, -1.7235789554881318, -0.6042594332413171, 2.154037882153977, 0.5417141446728688, 0.957291422497181, 0.15914391314843793, -0.5681354532241414, -0.48025326767026516},
    {-1.4864768588989257, -0.3275605573298154, -1.5687097341743113, -2.7099351997721812, -1.6033969878783643, 0.46510485155142506, -0.5796649054658779, 0.7016290385635314, -1.1977771148197007, 0.2545907629165901, -1.2181087570179905, 0.28286821262584155, -2.6270965619589752, -2.40322477357738, -1.6303022856477551, -2.4307834166003155, -1.2987338468720595, -0.6547975816642351, -0.38206578870102936, 0.3984986469931862, -0.8347252643726631, -0.6189329827293722, 0.05306104429360982, -2.219001295946577, -1.2148161628920024, -2.1828443850795436, -1.5318084631457136, -0.3819132754050935, -0.08137366456263383, -0.4466468862118363, -0.7393532110356258, -0.6162312307977219},
    {-0.17538936240919928, 2.020635932877194, 0.22256205242343052, 0.17560757765148122, -1.0797956447056674, -0.6412087843653006, 2.1469772941411462, 2.395351962495286, -0.6289525136660118, 2.572305924339112, -0.8244135626962921, -1.3180682495351126, -1.8412100295612528, -1.4093356938372754, -1.6362475323055574, -0.7150854312424715, 2.359605084573175, -2.978295248722093, -1.9269678484024877, -0.8896375203380079, 0.6858246057714449, -2.457049194945279, 1.3872852256440245, -0.6427570047245562, 1.2359418586862652, 2.4617644511351133, -0.10593377587714549, -1.3465925037872457, -2.5497943254172886, -0.056253654223010825, 0.8363648663812062, 1.437158466749752},
    {-1.3117384810016917, 2.091844004733226, 2.968371483413575, 1.246939696431046, 1.0717319085606807, -2.6138777873683954, 2.203514051535439, 3.365550447254737, -1.129336198573184, 1.652581107518557, 0.9983809972121422, -2.008740750624348, 1.1259470794606337, 0.8635159380092378, -0.5221116159394755, 2.436600792850533, 2.9995817176486685, -0.8599307639102908, -1.685286909254305, -1.7171725962541795, -1.3665147861513454, -3.117629255083827, 2.9490401337221113, -0.7778704577388282, 1.866483953544351, 3.6125750132678327, -1.3026963239562437, -1.7550969301254542, -3.464245963462806, -0.6753247869233742, 2.0451443519880605, 0.25990969720712637},
    {0.368916748513587, 3.496533310701264, 1.9287369752698074, 3.253325463321858, -1.1572454712433375, 0.38641324257946813, 3.7016413273058295, 1.7065031724546136, -1.8781465839043907, 3.0008948529338184, 2.4934145395473997, 0.2032208087611232, 0.013167162441026814, -0.22971524827882275, 1.793927424637773, 2.4805399178792147, 4.104270274496135, -2.19613262279046, 0.38493783544055266, 0.9687179439533644, 0.687402108537349, -2.036917573642391, 2.825962980403987, -0.15986354852237702, 3.4552394881266806, 3.364922004015642, 0.5318859411751604, -0.09304578519607234, -2.107157496581514, 1.6949429637677136, 2.036839715870288, 2.5515108315621116},
    {-0.25523499005974015, 4.3242261972424645, 2.14610645325994, 2.6518754928812434, -1.697220022079787, -0.8733603808796668, 4.167652050711379, 3.220132528655194, -2.7423488812210173, 3.2723655180378164, 2.98730655563269, -0.15673336166506888, -1.8428850816142284, -0.15306192644108846, 1.6914739397720042, 3.065819984840448, 4.212791056423157, -2.5090804765705266, -0.5683297327735777, 0.8677122149397687, -0.41170274444171406, -0.6321532624734643, 2.854633323331145, -2.354771359120273, 4.2606634882491505, 2.688267950971344, -0.16821288099142132, -0.40392267360700496, -1.2452055430262916, 1.0107070666445108, 1.335097710150722, 1.6095131381385608},
    {-0.024432224884544836, 3.956496958014122, 3.376104111618757, 2.3668915135257835, -0.9547442853405831, -1.5032182346304628, 4.148065095383553, 3.8960747993996505, -2.6035871679950966, 3.466642970559803, 2.500847094104831, -0.5420643820305041, -1.5761715468924042, 0.58961184470485, 0.9100044269928099, 3.9095601049284276, 4.246344217156753, -2.2515918979607115, -0.8677099582823952, 0.571164443168488, -0.5553499007047532, -1.488686525147147, 3.8398075057087673, -2.008660453872683, 4.04874083850547, 3.4639116766962705, 0.09725202222554084, -0.47745160781666907, -1.394785963803317, 0.46769897411115224, 2.351626479916292, 1.7479608596445648},
    {0.4628401092507631, 3.055491642634123, 0.763037224688045, 2.4206793092524217, -1.0392266616898855, -1.0775998630999997, 2.514377410783167, 1.939479067593108, -0.9008079644571547, 3.191169194992632, 1.2119991184367334, -0.2603820833644885, -1.1577538654176214, -1.2795358531610626, 0.5071899456110226, 0.9830199860009198, 2.7508757786652476, -1.9595638145967702, 1.1309729325431697, 0.035644654210807473, 0.06733983666617945, -1.3731912460452613, 2.055815157423614, -0.08155749881205261, 2.695373436064575, 1.9867698886688585, 0.5840986194619745, -0.32061697697240027, -1.3250075135115942, 1.0092874222597072, 2.6266320700180548, 2.490056995950993},
    {1.7326487394159376, 3.2216519674645734, 0.8057553318486225, 2.5140793996642525, 0.41723735921004534, 0.2587938593740278, 2.705004142939526, 2.404159677931911, 0.7742939886584732, 2.6404747308219725, 2.895969996106873, 1.7059345864362683, -0.9597886767064832, -0.3707706772055698, 2.5513229176778425, -0.5960342641493693, 3.134399602890443, -0.7837388943982699, 1.8649392466259702, 1.5479180220027358, 1.699914113086269, 0.47944123558694274, 2.0747769298734338, -1.0067652375189795, 2.8447054631614392, 1.1415620225376568, 1.6156990040270844, 1.8268510242119653, -1.4369400503656775, 2.282352607835994, 1.1058224859955499, 2.113030145001078},
    {-1.9425736099095672, -0.9503526881964968, -0.16631530258893865, -0.9890338791275799, -1.03422181099798, 0.8333112276372687, -0.756968711515011, -0.5055658887690009, -0.22600143251467472, 1.0361103354685275, -1.153079777320068, -1.00599812456829, 0.635426727435875, -1.636899450163133, -0.6595808907008763, 0.3225540501568773, -0.7052713914983513, 2.3029022943692907, 1.1044227812809941, -0.6236839599953328, -2.0704666493168093, 2.1932776255673674, -0.8183158342544417, -1.1408291314256367, -0.9068353061526538, -1.1254633777375787, -1.7359284049307788, -0.18483362998554884, -0.04192527871960361, -1.5841028268515893, 1.9484145546575613, -1.2272811346941956},
    {-2.4325243532917, 0.15841020772587852, 0.9176758973427142, -0.5672100155249565, -1.1246141369352454, -0.7514992059509075, 0.5983958977401297, 1.3947552183449237, -1.3831251493248626, 0.4891809541240025, 0.5383169636281842, -2.1722324433852123, -0.6435271982663451, -0.20533297380335752, -0.7045684717118594, 2.2144529489487987, 0.5741097726944492, 0.8382562366926712, -1.4331779539875027, -0.794874656166172, -2.3095036707753116, 0.5100951603003415, 0.980741298981236, -2.005194665065266, 0.9237434730101655, 0.9342532703765607, -2.3423729772097404, -1.5228753479104236, -0.9853416128816569, -1.9272899016321807, 1.8665090516855962, -1.292836597669887},
    {0.015756223613441808, -1.0055780887313586, 0.9862535361778408, -0.8055982817030339, 2.300802313474679, 1.1018163136677477, -0.962551087875777, 1.1284069134713552, 1.2180040303016073, -1.1268186304344165, -0.6178766745535277, -0.03649464207821171, 1.5318088494011914, 0.8661223730000025, -0.4509036829441618, -1.821607262594386, -0.7727243798733038, 2.7860249234284975, 0.14523082879278196, 0.1278997319263475, 0.3521401001050059, 0.4106738265606567, 0.30693194596150997, -0.17692137296604607, -0.9517651842927487, -0.07577986800055177, -0.6131099271899256, -1.1033655513394254, -1.2675719371729104, -0.7631123182468145, -0.042485360910527174, -1.9999420450208618},
    {1.4322180248651788, 0.7981051376910444, -1.4428116813403142, -0.9785382429091883, -2.0987260787243107, 1.1609243429469236, -0.10113453829693199, -1.1742884298819152, 0.39417759085367843, -0.005071957619111352, 0.7688622810738199, 2.293347390378907, -3.221004590648579, -0.33456927712202517, -0.1631012132849553, -2.156686783393096, -0.9523850307419124, -2.477581500873345, 1.6346061267133936, 2.0144145390056805, 1.8314322760199284, 1.62641826740552, -1.0275119375061401, -0.8493380758334411, -0.2620745063779255, -2.562493300729502, 0.6051435344258698, 1.519561848606105, 3.1021726599938937, 1.38985136487885, -2.314317298552279, 1.074935509496503},
    {-2.523329938982919, -0.23521707905190836, 1.9744429783817463, -1.689058594310771, 1.6767866668630795, -3.22988513439353, -0.33110893119800866, 3.3282219758849187, -2.211541221142466, -3.172524774587598, 0.8370630511604936, -1.4376023843847001, -0.6642663430402291, 1.8667289460375438, 0.07914758230818553, 1.3917842385209191, -0.5707350371041074, 1.8068782546582005, -2.837544250855923, -1.4372938445880281, -2.9131817811531335, -1.5145009273423875, 2.7848219999369874, -3.5253269938481937, 0.9562503163998987, 0.5107799502101379, -2.4819688329331897, -2.0980220234607216, -2.463232314173938, -2.46449275389695, -0.9200391131420138, -2.9427061851185203},
    {0.9872663561805736, 2.308037474216175, 2.7638596272834364, 2.2287911561191205, 3.11336178946535, -3.56931521537487, 1.1497979920125672, 3.180008489344192, -0.16467397929755856, -2.5895536344633983, 3.2849431595991954, 1.706102165214819, -0.12732734871804602, 3.511696692981213, 2.5900546030526357, 1.7296376654781151, 1.7567487107370359, 1.0604055399875827, 0.18433797325518772, 0.1577000130421835, -0.14952652365163005, 0.5731566275711787, 2.801108657906167, -2.1365163076829154, 3.31475196110061, 1.108295085941383, -0.03297869160955038, 1.1574977761495708, -0.025441641158867552, 1.6384682276575409, -1.7565083493095537, -0.916247980091495},
    {2.089496133971729, 1.3399195604670506, -0.8742821375779655, 1.0104783602210197, 1.1724509186233176, -1.1330058212318004, -0.21385173128503215, 1.0602635597285095, 0.6958818409194325, -3.0944660582703363, 2.8207184937506393, 3.043015009545366, -2.21086133569147, 2.2773672129378473, 2.458331323940865, -1.8837936172650331, -1.14358756907421, -0.4489115605381514, 1.425808867435666, 2.4324369285232605, 1.824639072290453, 1.9631025912674245, 1.0970962722204927, -1.9683429689508956, 1.8366692984856394, -2.948340455681356, 1.548520147293892, 2.728186316141855, 2.6512778046217087, 2.5814857012742762, -3.2170709084156544, -0.44132722080850884},
    {-2.043125924534302, 2.447825097276171, 3.977191768344931, 0.7065629112905757, 3.1165598478382552, -3.185690764388215, 2.3858350907734027, 4.3605910859923815, -2.5361433475120525, -1.6446421747146536, 2.740233391984125, -0.5254761264556586, 0.5112822497862334, 3.2339990135302883, 1.1593472522535948, 3.687878920285787, 1.674032292487983, 2.1788783941523557, -1.2283126677624587, -0.2319658730365734, -2.7601874023250854, -0.5602971067857375, 4.148117538412432, -3.3188136007050013, 3.0742917822582676, 2.6269473022809713, -2.406119381976592, -0.7708775074390898, -2.0624951757159145, -0.9820986855740516, 1.9169648230803829, -2.0497292777238565},
    {-1.0246513917619007, 2.0424225300983183, 3.168284354218927, 0.6146671161967905, 2.192963023953955, -0.9204288598291289, 1.616061640744746, 3.2164427158882134, -1.8075505539977164, -1.472310607082561, 2.540110285613152, 0.6062233909003746, 0.2877471749837992, 3.2540616704923653, 2.2899587344708245, 2.531859284202293, 1.5258121415933448, 1.7170030727375643, -0.9577914210791986, 1.6977997088002006, -1.1719635280660206, 1.6742024142642975, 2.892036023239442, -2.8734369653717247, 2.745701318087788, 0.6877502924067102, -0.7516249490473802, 0.8664223336387887, 0.28000853313237417, 0.5882830286509777, 0.1876748904153128, -1.2821403194134864},
    {0.5062519485710996, 0.3193723960795279, 2.4916249431277073, -0.4343435915483382, 2.2167417668827474, -2.230474305114529, 0.9321192311262948, 2.556447565823456, -1.1035997974517155, -1.4471591609105725, 0.6591408385200085, 1.0600861522009746, 0.29656746178847765, 2.9895597938888625, -0.0879322728146263, 1.169706329756203, 0.2601048777850495, 0.24749513828057274, -0.17460001002429787, 0.5827319442687298, 0.5609608708418553, -0.8985187762706711, 2.6065597956952384, -0.3285943592825974, 1.3589590673184855, 0.2276036458654296, 0.05312838395468436, 0.5339883837728547, -1.1252985520746557, 0.7325721781936415, 0.23305960252401917, -0.5720325874790964},
    {-2.4605789003706744, -1.3413633344822244, 2.905690380151925, -1.5485229962272984, 0.8990362674911868, -1.9816484064079265, -0.22115276283830634, 2.914635354010012, -1.2983076997481393, -0.9459699739861135, -1.8326597980016541, -1.7346506228872465, 0.7825282491964171, 1.843524678017122, -2.2769838070224426, 2.944919377857762, -1.3065225916991667, 2.1137527220047043, -2.1580381486869222, -1.707294840326503, -2.3060446556771708, -1.6991576688258971, 2.8207044657966747, -0.8871821427456882, 0.009418397716441443, 2.234973589413831, -2.324139857835965, -1.6654030476229318, -1.5837624998374333, -1.6406942736496035, 2.496297687338549, -1.605186703450568},
    {0.08606540280970355, -0.49228462857632754, 3.2245747124014565, -1.0115909085578803, 3.0267880149967974, -2.4860458799826315, -0.2497850626137856, 2.8122039690933196, 0.0040955439168700964, -2.6328355953882214, 0.010452312231797146, 0.7011098606663745, 2.1817034717865966, 3.2839248769317413, -0.36349264600749676, 3.0296534596590234, -1.1501498047349763, 2.1471709492376845, -0.2553286138644156, -1.1075914314860864, -0.1055190305574374, -1.5721253028598414, 2.755829089294206, -0.22325351782781364, 0.2590518005807878, 2.2215618160014423, -0.5834901393870541, 0.18534961910459152, -0.5479089526529123, 0.296963318439399, 0.3448912824590502, -0.7148619093899131},
    {-3.1991535794134403, -1.3520847015652255, 3.2061820962040444, -1.1419992349945052, 2.254252975892752, -3.367251311312563, -1.0373823905889703, 2.459983304917076, -2.5425081141099404, -3.1832414435651355, -1.0256360708711245, -1.9102706161622354, 1.598359651713844, 2.5129281520462663, -0.9737072959233775, 3.3057898728824453, -1.3118214380263793, 2.118251435305876, -2.3379024514491453, -2.5366632774342026, -3.2867520127843926, -1.9350901985516022, 3.2043712292211466, -2.6840606168994756, 0.0013732569281239993, 1.3802722056534567, -3.0904869635974976, -2.2208375857731983, -2.478291788302642, -2.783242261692995, 1.3374620736414857, -3.2675712908709684},
    {-2.165139438240018, -2.7924437706462384, 2.6109289765597827, -2.8580009411917744, 2.834141168094338, -3.090859348618058, -2.246287338134457, 1.920045058035893, -1.8356407256233467, -3.3638494068572946, -2.528906865331599, -0.8692746599342764, 1.312482933239001, 2.348438190765875, -2.5199445591440486, 1.7852341630543762, -2.8300471332432795, 1.321222106241899, -2.061564916666722, -2.0982994607590593, -2.256995763813886, -3.3119352877071457, 2.165908315706662, -0.558656872940004, -2.2538253160180206, 0.5224676824730605, -1.9717400993352634, -1.8491913141423648, -1.6807580488250922, -1.675757886946277, -0.0014396593461081324, -2.561909819989906},
    {-3.0554641380096506, -2.5349671263686817, 2.2448978423567385, -3.0666955933518225, 1.3277410466867352, -2.337532395128169, -1.5171727450641412, 0.018280099745144218, -2.9139337740873636, -2.067109916081248, -2.8665216738731822, -2.139101735958736, 2.442057036006598, 0.4513469392477744, -2.5519934081297158, 2.465594040813272, -2.8081986507128986, 1.969193763693132, -1.533797700761965, -2.959844424074611, -2.733206145895333, -3.255114721845992, 0.5950017849244584, 0.5569558266730857, -2.3690952106175462, 0.9113505663950864, -2.5282071453244046, -2.6046199693400336, -1.9075764569672258, -2.9403978130614257, 1.9865785360065116, -2.1347075630292958},
    {-2.881356403136172, -1.9306633170020904, 3.611625325686971, -1.713949508635106, 2.3507010927767555, -1.6966391901388511, -0.4650231320560855, 2.927510016609973, -1.7031673543050538, -0.6712752573720868, -1.7831554731766528, -2.84258362372631, 3.5840901687639906, 2.0368353847367513, -1.7328638731170818, 3.9081557192257583, -0.3100895919151473, 3.638076509975574, -2.6161848504881604, -2.6671031779540066, -2.5273613509332047, -2.608889993564096, 2.5996885998336383, 0.03429750192173997, -0.6505880642415075, 3.7829944981828376, -2.1122503032442967, -2.7600020154380767, -2.9819042527052027, -2.464811000444548, 2.9361171771361287, -2.0430461625013843},
    {-2.3237578427815593, -3.4528807997908677, 2.2900002574384923, -1.7891634418156916, 1.7362408337142927, -0.0340800828539478, -2.0047913523146232, -0.4230409637638103, 0.2940678882216544, 0.09826274361455146, -3.2050413857951017, -2.563879079320956, 3.6312404992962017, 0.21287513532670677, -3.039898476172704, 2.1895300497595596, -2.3845880441921445, 2.7969875634571006, -0.5542928635320844, -3.041070100783806, -2.2359526627522692, -2.274228975732403, -0.383479867141245, 2.565610759021895, -2.9574876032814537, 2.3067749996834928, -1.8137570779178955, -2.5950181236595413, -1.9447954305650705, -2.490202584445331, 3.0862884559379533, -1.6615873339257516},
    {-2.935318203950924, -3.504475774579549, 2.422278340438518, -2.350101783371852, 2.549251498382423, -1.0496319012633717, -3.16643468105471, -0.4213879381339854, 0.06058425167817821, -2.2198369071719113, -3.0618837284505016, -2.6321517401364742, 3.514132808355718, 1.808779625345259, -1.8011377112173517, 2.1299767323071306, -2.9350890582579723, 3.5336264561337343, -0.5926969135166539, -2.389386337548254, -2.8324837130136706, -1.2378952607140707, -0.1029098307796778, 2.1080089699060482, -3.514638976852497, 1.1033230800905467, -2.940407158019211, -2.3111091863961257, -0.8804728264220463, -3.003627496703126, 1.8202884539739808, -2.772250381638332},
    {-1.9666108527154258, -1.6017560579595644, 1.4144728225606176, -1.5638394115559457, 0.09365128149840357, -1.139135981314759, -0.48874634828491215, -0.5937768790344528, -1.4508234413985792, 0.46075134501017395, -2.6795967295901266, -1.7680048453239479, 1.756734313523052, 0.9553634225152312, -1.9838877001048196, 2.3080087282353414, -1.311563293758647, -0.63454547098231, -0.8097476352115195, -1.2313417845511865, -0.9873377392282928, -2.9594289829126756, 0.28831803346270235, 1.619932475618453, -1.9924210635335733, 1.8177076882436638, -1.3452260940916272, -1.8520393612412462, -1.1852625496565585, -1.627407951317069, 1.9576905118277614, -0.0034945992691681185},
    {-3.8961991878670483, -1.95224444778223, 3.92687210315725, -1.8650547761700476, 1.2657467296670404, -2.731900868265371, -0.45196442478739035, 2.157544572123745, -2.4957191724148826, -1.3877628747622481, -2.0159276671894846, -3.352959290054283, 2.7464738424920183, 0.5244470953124054, -2.689152481550979, 3.6510913078537772, -0.26853429019079744, 2.5755583324471387, -2.5805552005910024, -2.9228423340801033, -3.8043555401183675, -3.04041515203531, 1.8486814301902559, -1.0612937256642507, -0.7986839185129769, 2.432339238323366, -3.8160796340599066, -3.2837417742192203, -3.591117447797914, -3.4327779685023296, 3.411648013704026, -3.276053221491983},
    {-2.697777294739869, -0.5085635163607085, 2.7938814366506906, -0.7732276400042044, 1.8231708405186628, -2.5438116932404005, 0.131448437578841, 1.2831159107439567, -2.244195298079512, -1.8388127382472232, -0.2939458449851455, -1.6151901489973366, 1.543793852087533, 1.536305605600319, -0.29347594970148744, 1.8863439914087383, 0.023055656054106543, 1.848788510057134, -1.3403904640717987, -1.484264516069688, -2.2004777168402367, -2.566796168733507, 1.5150096408420108, -1.387429614550259, -0.17518799942968594, 1.188656099164353, -2.5651863626740568, -2.3435446985488677, -2.20586731124086, -2.2512430884367225, 1.2647924990384236, -2.1910512600720646},
    {-2.273211707756362, -3.574253097944518, -1.5659576227195673, 0.7009557609638507, -1.0372262822987495, -2.7585738796731114, -2.956363291160312, -1.6516776733141392, 0.17583712523410125, -3.0562619136456948, -2.4870275033054696, -4.156147218467136, 1.335482557347102, -0.33818486162472117, -3.847303884911277, 1.3219850330273704, -2.911910927046777, 1.12275429569257, -4.049160573266079, -3.9305715413346674, -3.748512724917609, -0.19625463366976903, -2.2620409240745136, 0.18360332967949605, -1.2287989615752681, 1.3918301273471376, -0.838440021178073, -3.3558057103746415, -1.4894285430610072, -4.055011778942357, 1.5038065601697694, -4.030812265481585},
    {-2.1781701782135547, -2.8918619522232776, 0.11126892026973172, 0.34916514558160516, 0.9849317121856473, -2.1510773338611946, -3.102248443052263, 0.9681748071484467, 1.524538524466482, -1.6216728226286423, -3.136179166822055, -3.8106072908697777, 2.040606409257587, -0.09562843777471329, -2.6870136883615072, 1.5253814724885097, -1.9170354084308152, 2.4259279810399863, -2.579318738891468, -3.449506489078638, -2.7705796651175003, 0.034336737949738946, -0.3343863652103826, 0.8033490323535787, -1.8298372573461823, 2.575691810318133, -1.2501316660085382, -3.1952726315888373, -3.04384911498527, -3.5444759462393995, 2.5501654795048045, -3.044561212118734},
    {-0.35656466586245417, -1.8611743507262168, -2.1393277946850096, 0.02213503714353384, -0.5031408955999022, -1.2326544431282815, -2.990738175317387, -1.6926160503430436, 0.846696611661187, -1.060109523980989, -2.8609712095768507, -3.0248276327344032, 1.6755933837354, -1.0980955402116557, -2.4908792197784586, 0.06909189327242736, -0.8816904724833202, 0.6950964516700701, -2.886080101436259, -2.6971062219592348, -1.6176985207488679, 1.614464584596019, -2.278194712177275, 1.3055862738043302, 0.029736659368776584, 0.930111833030726, 0.14166922137843094, -2.4655347780311865, -0.560457982206881, -2.4685508943135095, 1.397197395228981, -1.6224118521641953},
    {0.11497961549903382, -1.9710999299113887, -2.4547026922743185, 0.5322841189628387, -0.936827794305716, 0.19139511409706586, -2.8081892497691645, -1.2731321862167015, 1.7247166942422492, -0.1850087866439563, -2.0412090200379165, -1.9000693862052374, 1.7978597433415893, -1.8317266632221667, -0.6785350103281504, -1.2116171110163458, -1.765696976218843, 1.8981839495073316, -1.707987761062593, -2.660290929982462, 0.702053503527186, 1.7003074454834197, -2.6487112437951987, 2.0756161322563313, -0.5004935125082288, 0.22126938589685624, 1.377329691092891, -1.8566816915202886, 0.5718304987635137, -2.185845349589518, 0.8312248855955662, -1.398769541029831},
    {-0.20890964476284496, -1.5624493716594516, -0.35651428924204737, 1.8771046384710806, 0.33233571755290525, 0.30961253830089347, -1.6270449542540122, -0.3485852826319959, 1.8460258553963467, 0.47696248587710643, -1.0222594287966544, -2.106821170059112, 2.3377893082249317, -0.02328722671864918, -1.1108597211518263, 1.8305998149737555, -1.4950107267656105, 1.5389392827858148, -1.1575553096658213, -1.9260480994039628, 0.16210748320480728, 1.0512384886616006, -1.0018825184916882, 2.2594957471040304, 0.36695494740870205, 1.7996891775103048, 1.6240012062884204, -1.4761040490507384, -1.2743037891291928, -2.021380468652927, 1.919354361380043, -0.29966400967685364},
    {-2.009909198316245, -1.0335248272809736, -1.0427674378509524, -0.051695793035804134, 0.06186027809427613, 1.7855624588613441, -1.1061353859563081, 0.28229884578259606, 0.6896233977461622, 0.5991093682046106, -0.8269440096315296, -1.8092706779961365, 1.5544802756949998, -0.5397017697755258, -0.6996943246898627, 0.6820967962178411, -0.15401350219704338, 1.6665248242289403, -1.324566155471897, -1.4092620880508917, -1.5072307055337844, 1.6393884010042892, -1.6757495278938797, 1.822015311751652, -0.2583378499443548, 1.8859037562253476, -0.9527589532509867, -1.4188679423283277, -1.4064452766554623, -1.992748388407543, 1.758442199038123, -0.8830074042173222},
    {-0.2681275331793961, -1.809662424603652, -0.673728962102409, -1.0434216127542681, 0.5263464793288778, -0.34707440979811444, -1.7405725084762853, -0.9130469412767445, 0.27787350780159015, 0.3505090534313666, -1.731339707270996, -1.591873560504059, 1.8366606028124102, -0.6478138331188814, -1.8296958382237178, -0.0991233517831171, -0.663123912153065, 0.37097093964637323, -0.5950779032996767, -1.3616885171869313, -0.17147211856865713, 0.9879607623593913, -2.113081622652273, 2.0780569110637255, -0.2913546321777503, 0.8213358916003537, 0.7192221277183075, -1.8935000461688642, -0.7280464213460673, -2.278773853630354, 1.8617200668145606, -1.6704185325860401},
    {-1.353570079305962, -1.357248503301443, -0.3137453601407016, 1.01974300080861, 0.04658998003693609, -1.5889755789825835, -1.369610222743148, -1.312908339203578, 0.03312284703852438, -0.5935048984896221, -0.04809084207032219, 0.3114996051508675, 0.142532724337041, -1.4149983199208693, -1.6282559582978942, -0.7183922390658007, -0.06107552429057036, -0.6526559585083743, -0.8986882461265614, -2.354935685415474, -0.7762964495791294, 0.8982765488456904, -1.4163597573085216, -0.8397979415448807, 0.5026369925848322, 0.3461407144789448, -1.5634085226742493, -1.9796195254872802, -1.3448932333230197, -2.02935715186429, 0.4548906737018323, -0.8448254947124838},
    {-2.0742229200754654, -0.7890738548771069, 0.17122990052139617, 0.44039079937138226, 1.238884662822987, -1.5688888368276181, -1.6287840623831615, -0.2850647705390226, -0.7530923295473743, 0.5095132115996419, -1.2194922522956801, -1.5957624775537351, 0.9898497082550798, 0.3074139884204673, -1.176745812143416, 0.9153267937347271, 0.6233159255204215, 0.7954851159415038, -1.934182061135904, -1.7655391736980628, -1.7350466067153287, 0.6375536800617313, -0.5404854510183865, 0.05377652257783475, -0.3983320258883774, 1.8069233774530389, -0.8231152968852854, -2.3596779744380973, -1.6920251795919499, -2.3233381161740807, 1.9425152435536117, -2.092573992788719},
    {0.023889934020767552, -0.3969499394835545, 0.18551925812040695, 0.9169502136235883, 0.3803688614777698, -0.5543881863490329, -0.6191677187691068, -0.1449376036012814, 1.745102944204114, 1.3917382997295302, -0.4360098896493464, -0.21701062798904788, -0.36717276974883045, 0.003548527478269955, -0.7862571405455551, 0.1935701896248199, 1.4201483683826228, 0.053920920415985146, 0.8200316079131195, 1.0554896941432454, -0.21468750423222624, 1.650109062290092, -0.7443542320984844, 0.3089139807086415, 1.6928230955307537, 0.6303231070775767, -0.517126156611239, -1.0376457765475715, -0.35310960904374616, -0.5888614071594375, 0.2863802016431313, -0.6057605723696814},
    {0.8164883347067221, -1.5429595039306123, -0.2316259832568636, 1.0464620993153397, 1.9501327697093607, 1.454017722486438, -1.7205668878126827, -0.9557792600887658, 2.2599666089771624, 1.0403188603620661, -0.46382267837794455, 0.3875002225222523, 1.1088571904218758, -0.23894654909474833, 0.5735550951365388, -0.7962469688261338, -0.8237280882309125, 0.916753209212772, 1.5615779726757504, 0.5929513617296248, 1.399222598366235, 1.949296794754114, -1.5192538091487977, 1.9258245748820704, -0.37144580048582054, 0.05885225609939489, 1.0060541518135058, -0.32793542648182766, 0.8968060539042555, -0.3249940792081087, -0.5818172268739226, -0.44382122645946254},
    {-0.9174186983428899, 0.034948787768618636, -0.4285793502434555, -1.30097274467081, 0.8191766367341256, -0.8140756016898129, -0.3886776493737346, -0.2986571184717124, -0.5355132411015547, -1.1703880138314668, -1.2781656613745243, 0.42927068732783635, -0.06936773846957542, 0.6866958480721492, -1.7329745565702157, -0.332237527047797, 0.044329713411211995, 0.9142549160113164, 0.09859152170727709, 0.21602663278863007, 0.7936859122027022, 0.458144939221577, 0.1540963147232439, 0.06889857366113548, -0.9806899091950385, -0.27104905031329873, -0.9217181580344995, 0.40026410377697075, 0.6065459718008043, -0.45327569898367187, 1.2101648809323422, -0.17794273014229056},
    {-1.0873747016122246, 0.806722340446404, 0.47731283553055565, 0.39462963848958127, -0.22871833613377782, 0.08332826403184235, 0.12739937330965112, 0.6743615337461545, -1.9688210617167972, -0.5239384129909401, 0.37780991023894006, -1.0267643265691822, 1.242963777769923, -1.5006420507677052, 1.531277811297474, 0.2659714730373135, 0.7113855047215226, 0.9496474194380428, -0.8651465561646152, -0.36463387870944647, -1.1609119509368777, -0.9313279952268074, 0.6541851695440853, -0.6101075780734928, 0.877537620623846, 0.02200532013136897, -1.2701763318633164, -0.22262340520695012, -2.0461231603159233, -0.7887533191272035, 1.5558706488575436, -1.215801610344624},
    {0.840583477951546, -0.8935825150974992, -0.33007400794046104, 1.810676731627823, 0.39107967815323214, 0.5560948852114102, -0.9648458159156363, -0.8892011010065792, 0.3509241519106473, -0.6846632357991528, 0.17103737759616908, -0.2858593570842191, 0.5471703571371523, -0.3386096650809702, -0.48702178820648473, -0.6047584012514154, 0.13173357676852618, -0.4708427719951044, -0.5197856647414087, -1.380896643621476, 1.0397220991882083, 0.6257478421428936, -0.6132382266497561, 1.3818577032386576, 0.6169449204911159, -0.1000823851241056, 0.16840402594284176, -0.8907201865705348, 0.963414134328888, 0.1522172539138914, -0.022600160200408895, 0.18496618452537184},
    {-0.39215050117611383, 0.4489508174689118, 1.406963494929421, 1.5169677578503182, 0.5667702964521889, 1.0135962576419995, -0.18238106130707052, 0.42842415835502334, 0.27506051478119387, 0.9159013274226242, 0.17203362455652504, 1.0668789828033656, 1.0264700266282092, -0.8272493669720316, -0.5997355602700194, 1.1449940153403153, 0.3837672426334157, -0.05447000633350863, 1.7050084876250604, -0.17680927233784746, 0.37766771353733153, -0.24854280196980252, 1.4193989469278674, -0.11845773955332137, 0.5009673748625688, 0.43996229655750146, -1.2924498617011264, -0.8080300490153269, -0.5359184918315961, 0.9268488961180938, 1.5701363111927003, 0.5928529365995531},
    {-2.557874224943793, 0.4179877555236274, 1.0398267912292245, 1.1440492383644698, 1.2915747765527263, -1.7603208731683546, -0.2745320266781722, 1.0952217109601476, -1.803086205504899, 0.7258523669365987, -1.1296781767140167, -0.281784506781876, 1.1170694872719102, -0.6702316539575601, -0.4810255652948015, 1.4877436181632353, 0.1380956479280991, 1.4085348566741636, -0.47629746543159407, -1.2330248651860758, -1.885704813811299, -0.936184837506286, 1.6061557115341762, 1.0074334916363268, 0.17533186171251441, 0.5798451796489084, -0.6921155975322094, -1.6640298686544306, -1.7006713994844547, -1.3152812064578139, 1.9954460116223676, -1.872067056037232},
    {0.24870658587774402, -0.4946857244021743, -0.3264428337616817, -0.43010561443877976, 1.2628415996728988, 0.25455951971805063, -0.9862501694570589, 0.7058897291836664, 1.4265049836267651, 0.8211321536042941, -0.6828872795122756, -1.1548805003919411, 0.16962577607390078, -1.5874091131145178, 0.40778059641335535, -0.4588088277025038, -0.05272483726493062, -0.5528389488263531, -0.7050687897928761, -0.834386091116696, -0.8773800342181126, 0.5742109347386976, 0.05160778114795372, 0.8365000557369393, -0.06824420908349273, 0.48331427446520664, 0.40409231676416724, -1.6706063810719953, -0.9419000661949078, -0.045469102079856445, -0.10277563323554455, -0.0012763230778110811},
    {0.7532929333538418, -0.3313026043376399, -1.9122573084997077, -0.5804580628488409, 1.166368039274646, -1.3300182392153985, -1.3244736190785693, -1.0473354657907394, 0.615116553463713, -0.14252176519999557, -1.1308113962934658, -0.40047176314009647, -0.5145616210132797, -1.559277717297717, -0.0009194003046413765, -1.1289501212571253, -0.30398944525913246, 0.43672953429234873, -1.0751482606442293, -0.6303479373473568, 1.1087617000240637, 0.7054150863462613, -0.26509324920866517, -0.13474172328967568, 0.31637100520466105, 0.9480988766728633, 0.9439733500172383, -1.1869887699409565, -0.8104411389559406, -0.1746910049939803, -0.6922018161736372, 0.882487601174914},
    {0.14047763037337327, 0.025446224720879432, -1.9299448439049245, 0.200774358904284, -0.5922939719994024, 0.6789924514275754, -0.6757615539546074, -0.0591922067475572, 1.548275933772536, 0.07841332799963617, -0.737799942104598, 0.34717759236166396, -1.4430713000339532, -1.898456791508493, -0.42500473995392646, -1.3395947353305682, -0.2564072662944512, -0.6096740570147082, -0.48655792993392, -1.4798549016039404, 0.23855549001226128, 1.2691710511247838, -0.5192775955363661, -1.048602639970838, 0.2875118732428501, 0.23458357442730132, 0.14316771766267833, -0.027899808449574435, -0.545225482555494, 0.30903850596077553, -0.6770290759875179, 0.3640378637933817},
    {0.5350741511258325, 0.20172142270310822, -0.44413074338690883, -0.6160360186868431, -0.038514665128522044, 0.45455402089565744, 0.6188128927811511, 0.19576949381625994, 1.111784100214813, 1.031384442500116, -0.8934119682987935, 0.8667364020271879, -0.6700383839393145, -0.22243337253095694, -1.4864207946080117, 0.3463060243026134, -0.45374373284340874, 0.051839463968363426, -1.0947684351175366, 0.16938031015499425, 0.834805562774408, 0.2864004982260427, -0.34932188354857713, -0.21518967955507068, -0.0009495623814124892, -0.056443720211019066, 0.3332988177663093, -0.3700647197023314, -0.6425472333262264, 0.3018859212621381, -0.7209273613858007, -0.0954401211752712},
    {0.16167911016787984, 0.2972459386140928, -0.9176567046970336, -1.007710139408129, 0.9674307655414645, -0.29264620677313313, 0.8578791077851258, 0.479525779078546, -0.17846189500933618, -0.3132945766061296, -0.8461623664688417, -1.143644134183825, -0.2469368411798893, -0.2522739923994441, -1.4111225644266667, -0.9733251603087794, -0.23247335046591908, -0.2338396219177827, -2.6624298104664117, -0.3644657918307287, 1.329323776773275, -0.698401076599706, -0.6759215491715267, 0.24660242221571962, 0.5318817237789337, 0.517864572895192, -0.20110945514381134, -0.9433645755765081, -1.8482313170158784, 0.13420041301222388, -0.37086895532723013, 0.980756107553007},
    {-0.9903544835810433, 0.6232416780650939, 0.3300876781720696, -0.9195553243642907, 0.8500038605801934, -0.2657830391149798, -0.5562621382225464, 0.44855102566171895, 1.1944845527735393, 0.9269087035836909, 0.0641308810730401, 0.009634200677568788, -0.473996273771305, -0.41249877213414654, 0.5975434437233191, -0.027617186134020866, 1.301978827735907, 1.2159525238519004, -2.0211925762570013, 0.963325680239285, 0.5357381742002788, 0.0012227027667237262, 0.12125099462796995, -1.035312183932122, 0.8166044953256216, 1.180395549585999, 0.06588923865983971, -0.6163761855854357, -2.0628509900763716, -0.07387125096174849, 0.8960863671808028, 0.11675893157368754},
    {0.21930183541690423, -0.5116063114230779, 0.04310023063792995, 0.6742861523503032, 1.9156131686444389, 0.4945142420863864, -0.4901553720804689, 0.7828191395276253, -0.5657744450416172, -0.2279040016750678, 0.2458590287212077, -0.516684897569794, 0.3298877033521592, -0.6113973909323249, -0.41911020964308626, 0.35942869494911767, -0.9068121072181695, 1.3220479025485556, -0.552644381805277, 0.35975058408230653, 0.310855930608253, 1.858463030363809, -0.040608330929914796, 0.6083375652848467, -0.2736853742310787, 0.8773157517636028, -0.41489123125821953, -0.7011032048174167, 0.6542346194845148, 0.8923908706270978, -0.07069420998903769, 0.5933810978009245},
    {-1.3251114317373813, -1.4837515265200079, 0.5610824747881799, -0.06372972391504853, 1.061092008757613, -0.4641520015362604, -1.433529135575484, 1.0075939605563715, 0.2300673714143663, -0.04194644311942011, -1.0471288043782383, 0.577510742748, -0.10831454159746419, -1.234503815124445, -0.17448193830426167, 0.43405055173908774, 0.1489636779253122, 0.17045934470793603, 0.30177062130788374, 1.9635627931738537, -1.3231907631280757, 0.8828249747592698, 0.6359821297527961, -0.6725599287842652, -1.3322632775618544, 0.863711157226199, -0.07993809664778843, 0.14061159196842993, 0.6524060509036189, -0.8144405880246187, -0.3776072381024786, -1.1526116695086315},
    {-0.9461425245732897, -0.5141776670609877, 0.3442111579950897, -0.4540448757149274, 0.6350041224183398, -0.4722231257253675, 0.3404598194818658, 1.1061037460643974, 1.22430654466222, -1.3690854276090958, 0.9711500900249496, 0.6599970622845405, -0.7404293104884193, 1.0833269001229568, 0.3290115774244117, -0.6634357757594427, 0.3695692946038691, 0.5031238515741617, -1.0603345585591082, 1.0454321077910511, -0.599778457034733, 1.0313023835718196, -0.1664869170417823, -1.059621605646438, 1.037864515419051, -0.24582269752139704, -0.5396119657660796, -0.6153277147638737, -0.8755994783408807, -0.14747187965642047, -0.9418398083922697, -0.6217467712051366},
    {-1.6036185892836925, 0.0677411787032726, 0.6529855118380052, 1.0587431543287724, 0.5860222014323102, -0.1575828274381545, 0.3304146185691329, -0.36117532032834987, -0.32699526338749685, 0.6610693713164525, -0.23620279705332323, -1.7499848735153558, -1.4388441710398585, -1.1020039588242418, 0.6533945400135598, 0.9255851301416198, 1.1757686630151611, -0.3397895020226621, 0.47574032281114487, -0.36797145621461597, -1.4736666667627856, 0.7595937483970214, 0.4789103270960996, -0.5390559870211651, 0.7112645423953912, -0.03197280889080843, -0.9413628726069035, -1.5975529865819822, -1.1051477121534212, -1.1320392201506186, 1.1421773052626722, -0.16024876705288393},
    {-1.2368074753661205, -0.6437519485367935, 0.1439198855335027, -0.49784933458522573, 1.1404792355763014, -1.860802127131269, -1.642956781800451, 0.6249819942141707, 0.08996646321324797, -1.7283182706294482, -0.4633573605087535, -0.5784501622934606, 0.291057063549739, -1.591044608372033, -0.6751466730965272, -0.1964382257235331, -0.6236432289970067, 1.5824234851108228, -1.6021513981581232, -1.2850230629818482, -0.9976839499406404, 0.7761915446281582, -0.3481088340835701, -0.27945260579512854, -1.0000228064980847, -1.2580347062653343, -0.10963278575525741, -1.639368774989726, -0.6056797608890881, -1.568820275074474, 1.1037349113485997, -1.7627420145484078},
    {-1.4460925656345867, -0.8889481643502326, 0.3822339670689821, -0.58468468702747, 0.8301797251900911, 0.7794367197783426, -0.9897231092919714, 1.1175102841674163, -0.06416643449913717, -1.172854406935456, -0.4725560334807027, -1.2945172674304661, 1.0156651111386006, -0.34967799289983686, 0.28259145621745996, 0.008357374409871795, -0.526878294929416, 1.2536268681641796, -0.3930083924384474, -0.6517391288667643, -0.8971653707814025, -0.9452998454393394, -0.9566047439847294, 0.9160093699926201, -1.680830286913989, 1.2676800941320279, 0.39321450961308135, -0.6082654016008787, -0.17880898505184672, -1.5737626785517336, 0.5760904380311482, -1.0039981001000893},
    {-1.7372180262106842, 0.7357706293494111, 1.7418257825207308, 0.7067233397948606, 1.2537587906566101, 1.423250649691391, 1.1916498870947005, 1.7782767169673257, 0.2746862661200031, -0.032107228498668705, 1.0977591636238249, -0.3650498798820278, 1.866822734636878, -0.25495958502981003, -0.22267707882126336, 1.3638286217374704, 1.1157695674794672, 1.9345133321559385, 0.7327786185761936, -0.03467120704747474, -1.3609790781800526, 0.1135942313984731, 1.7686594059313163, 0.40669748366688, 0.8038362403457032, 1.6575310889194375, -2.188508569032177, -1.3929560236449785, -1.6725260367113952, -0.17372191232860104, 1.0681539353109366, 0.7498742668734741},
    {-0.7713520171715746, 0.5756958875905707, 1.1622903161772347, -1.175988841620531, 1.683143332383348, -0.7719672622271608, -0.3587009776717289, 2.096500748557255, -1.8303119884208277, -0.8039514885906573, -0.11616234182290557, -0.138872722035122, 1.2650661231254943, 0.18538774991813745, 1.1207723977784538, 0.46868946220297597, 0.336368853462903, 1.1199582609266758, -0.12646341514060258, -1.343555725668586, -0.5666867425547821, -1.0137081226767575, 1.606372288445915, -0.4626766780993421, 0.7883664900478354, 1.8985298697905304, -0.6887191725556233, -1.1311007242014812, -1.9423630511662926, -1.3436067088830161, 2.25270830743221, -1.779210844617632},
    {0.6385482358014928, 0.7970772196038877, 0.5800804343086418, -0.42578124693378855, -0.7426380229086817, 0.8177402734355754, 0.3547661208860515, 0.18343522212859256, 0.1674812249931215, 0.6630845725239858, 0.0073327196434740975, -0.031896321608200134, -0.4714171901770889, 0.38648600569314273, 0.5113683577984767, -0.8147249906236801, 1.3836946106665862, -1.1285982536631658, 0.9723111328010193, 0.5823473646507771, 0.9920831312785037, -0.32491462575457625, 0.9055458432393491, -0.31599977709150495, 0.11016484680366749, 0.003593031212231821, -0.8898649824660242, 0.4390765706099196, -0.9520418137451432, 0.2475394073444382, -0.2815573916915259, 0.4808661015736129},
    {0.7474471976665188, -0.06936243507554685, 0.47696552056190217, -0.6447426432030278, 0.12411086599518052, -0.378969382932964, 0.5662326467220327, 0.5776489023923466, 0.6915176127932492, 1.2490093062165795, 0.139230930396708, 1.075197004101373, 0.5535790408209801, 0.7623424435960077, 0.3775226781289756, -0.0023571729476832225, 0.5276633429594019, -0.6865465018774917, 1.6342708914096689, 0.6218920449576992, 1.3626354460488492, 1.2848282154495643, 0.1544473296339797, 1.1012957005852069, -0.0272949276564945, 0.7267977927048731, 0.2917931070167716, 0.07986555014382453, 1.331413419274352, 0.09226643625180404, -0.05252174528185253, 0.4368092104617851},
    {0.12116530448153884, -0.4630388231047252, -0.5464547422841092, 1.2135505598955907, 0.09091582361406655, -0.047867310656762245, -0.4319926551451145, 0.9564266534485945, 0.4645179837766838, -1.515777713385704, -0.23193052462953545, 0.5796436182768986, -0.9463116529290211, -0.4179551828927818, 0.6697189929450119, -0.12971038671166676, -0.7400009223533006, -0.16499366349363812, 0.45958827056503965, 0.4534103720993761, -0.5774531679584402, 1.0753805195792048, -0.04859563447048656, -0.1011722744685303, -0.49195540214414546, -0.7413508298033145, 0.40565945228794886, 0.0366115170399496, 0.40195307145000236, -0.9543183289219239, -0.22873575801092252, 0.04423992466019078},
    {0.28999007995274007, -0.0788239943713857, 0.3519567670440783, 1.4262479604427505, 0.4823595936572612, 0.6484863216604966, -0.42670106365821336, 0.2792666912056603, -0.31058733300814156, -1.4335938277799236, 0.20002890479681543, 0.3204771539110669, 0.12905436798480885, -0.28108372084143807, -0.22296500232049618, 0.8432475997308767, -0.6626660123382024, 0.22285337266734453, -1.2677674697198211, -0.4641900028869444, -0.1217510853751507, -0.9405077362025822, 0.7056986017306726, 0.21130866700554302, 0.3060036230388744, -0.14969433419600287, 0.7365311735513481, 0.22876440622980818, -0.5432106431813548, -0.6407444439923602, 0.14401904320477882, -0.22146214870075998},
    {-0.45956226048403215, -0.6798056793999837, -0.18040134636544186, 0.14014519115428517, 0.7888567712596071, -0.8650541727375395, -0.8050936710225469, -0.6467509590641634, -1.293344524317281, -0.9877603513205713, -0.1982448092304162, -0.7279634235564343, 0.8181420381316851, -0.7293600490091774, -0.14715753463521844, 0.32755661365968985, -0.3904545617703532, 1.160067668661662, -1.12263839225959, -0.2315481355780391, -0.9309764153579158, -1.0110522541768483, 0.12207323665945868, -0.16110473442662374, 0.572098629652821, 0.41308668562296835, -0.12079703113841087, -0.7625182353721652, -1.0935661325844697, -0.006452142732705031, -0.3720193177802285, -1.5747967320724514},
    {-1.2715656630343317, 0.2801796152268865, 0.1226607883386988, 0.4863406119335232, -1.213919374124449, 0.2820606475895688, 0.32105196535529773, -0.748904104230965, -0.9270310184233311, 0.3912842575014884, 0.5447991231675994, -0.3544591974984662, -0.012884753672472495, 1.0392079247416313, 1.046794056975904, 1.1490105778899034, -0.3939965499024801, 0.7282630384848323, -1.1932073996512655, 0.46087532996980796, -1.0405814813518495, -0.3500889095544109, -0.20292889571744716, -0.8831107672858509, 0.21867264944185408, 0.5007012828617352, -0.2082453196078609, 0.3749935993021843, -0.39223741749911606, 1.2599177112967421, -0.6168017573578289, -1.3745472689672564},
    {-0.43988818715709166, 0.9115723072868822, -0.6723358069023131, 0.05814851351985693, -1.7181528692151766, 0.4714406892916122, 0.36921737440784624, -1.1401454019243729, -0.18237022036348355, 0.7086602905717648, -0.025605397849188388, -0.572048548594149, -0.3256466397767372, -1.0406127032171748, 0.4235327942387573, -0.2793213843657513, 0.31746199424414684, -0.06588398547494928, -1.6027408570159032, 0.25128013382866027, -0.434765147447522, -0.20417354227735682, -1.0636039276448703, -0.49006645291563106, 0.18321861357964472, 0.5341662405197127, 0.01598207017911712, 1.1695543992661135, 0.13463651520387074, 0.4815640729212793, 0.017664314859052774, 0.6598776450515077},
    {0.5753440198921372, 0.43360637054816886, -1.0321208149908492, -0.1903903678162571, -0.510209058650211, 0.5080472775636822, -0.2376142291168529, -1.066399891723847, -1.098170808249735, 0.3328794810393944, -0.46834888528832475, -1.1376116703127301, -0.2776385000876102, -1.2857756490832075, 0.09323549750553649, -1.2507458431375584, 0.4053191796140166, -0.4206293237033449, -1.32259346936743, -0.4397339792771499, 0.3110060137518245, -1.2309313063852814, -0.7705309305167842, 0.565288981608602, -0.33186375138075236, -0.6624784514754022, -0.45082841566940396, 0.006706273400673397, 0.5074671204055146, 0.5284020122393945, -0.3718612047663573, 0.9288560808439692},
    {-0.33737142734651004, 0.051593170094391405, -0.3616496068638095, -0.07324860032258743, 1.167845943227591, 0.9506845233295789, 0.017001733312115713, -0.5115324451568198, -0.9669206516839514, -0.21890894858458654, 0.28866391504989614, -0.9497117845380676, 0.8103214118322611, -0.23617196702974527, 0.02572145254507423, 0.006742340417893142, -0.906738224689139, -0.5015318717095709, -1.6026468032859305, -0.38802088710779553, -0.7590212769732749, -1.2646245898965205, 0.11548593880188743, -0.018652231939929584, -0.5626172747107256, -0.039407741207177806, 0.11633880721795098, -0.8912473855076194, 0.6422625553556954, 0.10288472506467265, -0.5605045657919552, 0.9692441162031304},
    {-0.21339647640880594, -0.7688431940809743, -0.08463926003620927, -0.13946429638091945, 0.765945365426564, 0.7850542994997719, -0.20201569261301086, 0.025039937734684416, 1.354727504461238, 0.3750276056580564, 0.5422992075973867, 0.35283181383706436, 0.8343919329888345, 1.0677101663033959, 0.3683156980983127, -0.07843361823556352, -0.7788168243759906, -0.026887469264656672, 0.7089126373715937, 0.280786052520028, -0.1438706999901716, 0.993826120397637, -0.5282252458336797, 0.6932805330338982, -0.3969902243484993, -0.7235084765970202, 0.9770689773724219, 0.3660425889027069, 1.9615790913710518, 0.15735063180882372, -0.8836356077236648, 0.7560827686940589},
    {-0.5266885569700773, -0.7090854934614372, -0.3194949727449752, -0.4933073988484875, -1.4341262855810917, -0.8603365633874334, -0.11628019342155037, -0.7344707206782332, 1.3589922047120708, 1.0306843624685664, -0.5782919000668064, -0.8007236803955179, 0.4548915300720839, -0.39670882278553127, -1.1461314635484379, -0.9013614134785495, 0.28817179929084463, 0.3315664929118192, 0.6393970723859272, -0.8374091761903867, -0.39795643349155596, -0.11012052481920069, -1.8500737966427185, 0.5119485252526733, -0.38559179332555865, -0.10078236179621924, 0.11061489695585668, -0.03518545588118562, -0.34839349757766513, -0.8584754264045783, -0.07124270450261028, -0.7136582873067536},
    {-0.443522734849458, 0.4957693713813288, -0.6152646401148117, -0.206774175913829, -0.7928672054630377, -0.25600005663057424, 0.1623108595677123, -0.8012194486725087, 0.07909242727317316, -0.3805982393634876, -0.5374684695746089, -0.25151775030947726, -0.2651958573410332, -0.6693335814644082, -1.4570097007033584, 0.4304904503572046, 0.6580606426633681, -0.2623239126965604, -0.834900901010317, -0.18635851726044286, 0.15626550683252935, 0.11499229410281717, -0.6787749465058945, 0.15803902641430773, 0.31601828479645305, 1.0514211966029108, 0.32351160687020636, -0.6597538868249373, -0.5308847389998071, -0.5602756541316612, 1.5931640172290749, -0.30499943294613624},
    {0.19277597118680392, 0.023075740763479454, 0.29020906177471717, -0.21333978431865624, 0.3789137326078935, -0.28983410825952277, -0.1807059119959513, 0.5602537637426913, -0.6112164023698545, -0.2715483133673981, 0.6466378340308746, 0.8765597277892048, -0.048082172685508226, 0.006533505869506891, -0.5292506367835126, 0.6092237680985312, 0.0006847219946265984, -0.9013413400309226, 0.312232057447482, 0.20064378462034596, 0.7176270147526413, -0.2627508137494344, 0.8155880140576449, -0.7145074163217296, -0.45135331398887946, 0.8697036268685547, 0.3202617515581914, -1.2558199854232177, 0.0850634358209192, -0.3003960944748547, 0.27997527816930123, -1.0644677784981629},
    {0.6044414731433388, -0.4986775065696461, -0.42664622575161115, 0.36399421648373276, 0.1349386310393177, 0.4617832114519805, -0.20319868190219664, 0.19664396862019562, 0.5114515637990444, 0.26859395086536947, 0.5498890799763175, 0.43545906989118704, 0.6417765077531717, 0.7437672887300242, 1.32201606379753, 0.005922997622213258, -0.8159921748920487, 0.26798147762136365, 1.2154770293278268, 0.3878863583572622, 0.8802806432574153, 1.221336417516144, -0.18948044492438743, 0.8191410114410319, 0.18186895818699159, -0.8645226905122615, 0.21855617266121372, -0.19381246439417227, 1.0169569823950666, 0.0059233909066627715, 0.3683352764693454, -0.36707590251018263},
    {0.44670913942470003, 0.223247028176815, 0.08451019511482069, 0.7157380548559983, 0.4785037964157623, 1.002314577545683, 0.4698000998726683, 0.5633715789256601, -0.10854408709624215, 0.053518941427548664, 0.782190417234919, 0.34089853379473317, -0.3870938870771852, 0.4393435163410025, 1.4811036841419902, -0.0839717655442005, -0.056370234901683185, -0.016400613937579914, 0.9269122962917965, 0.5071969156831141, 0.39939265721968403, 0.7474667939285827, 0.7312963319644985, -0.034175131446025374, 0.7608977605684647, -0.42139375284647407, -0.0800303074662095, 1.3983045848178264, -0.269701251683168, 0.7306405120111824, -0.46470875570305875, 1.1641007220403208},
    {-0.722833727819858, 0.6280045136067731, 0.5189792060010966, 0.31790658048639403, 0.48882353331825035, 0.7421880838650647, 0.24928186422284165, 0.306977677125121, 0.22595337036830418, -0.6154803641026739, 0.5150565120282937, 1.2332648539087954, -1.3733793698962016, -0.6550731078937728, 0.5661373650488666, 0.8310337643515261, -0.09428422779668694, 0.22517964921612924, 0.6337598571802331, 0.015755050474772856, -0.050193362946422876, 0.4382444452541357, 0.1684054704566251, -0.5788384660799183, 0.5265257343147067, 0.56534087037348, -0.17263886676066248, 1.1096453448137296, -0.23766335625453286, 0.3698290794276134, -0.9548627343102027, 0.9201945060748427},
    {-0.3624406918100471, -0.07872869149178059, 0.6457492412705964, -0.2265034677655918, 0.7192856338152304, -0.8152167423200113, -0.07203813511247129, -0.38547239915168247, -1.4370942784634206, -0.6323697538267657, 0.18518233616265153, 0.4504793272034229, -0.024162472235843013, 0.26197812207237703, -1.2950657389184008, 0.970914776592029, 0.09877716602271096, -0.5442125402993643, -0.4697267540429371, 0.5701417357981883, -0.6938106251134313, -0.8915232778866876, 0.3914129649350175, -0.3016949738925002, -0.13420872007762832, -0.17515904992715858, -0.5883664518312107, 0.44700223514868687, 0.5175016911639834, 0.017990744494208368, 0.0005999909521560269, -0.19273484270780858},
    {-0.8865235273986123, -0.5480489523920615, 0.20398466858148795, -0.7593616976342189, -0.8582586284825391, -0.07009016985620371, -0.5191991283802411, 0.39117816751353035, 0.14627284195817183, -0.2218740243675224, 0.995638169768651, -0.7385137325497915, 0.8699548709410015, 0.6449071377605334, -0.8921637222055476, 0.44409694861183546, -0.12280259033427, 0.710735860396988, -0.8600244356018707, -1.362296398556418, -0.8162602734645359, 0.5280708910256303, 0.1650649282071031, 0.08071527410802273, 0.3142127459848549, -0.3228134130083379, -0.32299305819405516, -0.24907877619682964, -0.6752636476939247, -0.1090244958804303, 1.1614303424720689, -0.8160111619158532},
    {-0.02201328608773788, -0.03941502153693095, -0.37036996500193836, -0.4457503372571929, -0.7237267228008128, 0.5762730830473342, 0.14254195194999167, -0.10878407091972543, 1.0640049671546896, -0.1663083749978533, 0.5958217553383441, 0.1081618157383741, -0.09344282576769918, 0.15069123882740104, -0.5110515293028823, -0.054268058728010396, 0.2804826173294967, 0.762046031532973, -0.1822930092346031, -0.5257817013138555, -0.15137970202404322, 0.9425202236454064, -0.06987686163362918, -0.5191163583348507, 0.7566797633572865, -0.5902566352075905, 0.8276908471696044, 0.4232492735248233, 0.19973712501451288, 0.08966767616356555, 0.22556432252772782, -0.05815604882620149},
    {-0.35462804395834335, 0.3773311681418771, 0.0720951833057636, 0.3097042195256839, 0.654372899518626, 0.03440042312983621, -0.6099530979639297, -0.2585831225505663, 0.4144647972177743, -0.5934256791610827, -0.28463361157102024, -0.2375812251062067, 0.042924269164430824, -0.44946110063134764, 0.7445529632002345, 0.10356934450064811, -0.28347185033378425, 0.48961341301427297, -0.016686529875395147, -0.47005592525458517, -0.1790288424140172, -0.9741814597472593, 0.2691889740645358, -0.03484561690488987, -0.21182381477405235, 0.21598056677145677, 0.1921200346895148, 0.54411402148007, -0.7759588842962101, -0.6567357645184353, -0.3079196769843456, -0.829298503037401},
    {0.6419901518243211, 0.0857828212287442, -0.2561925210376756, -0.6497739043154809, 0.6056378150340338, -0.32881127816330863, -0.1854395795958431, 0.16108423026695481, 0.24989249773237526, 0.29640997879194825, -0.6059854449406157, 0.2987647516079862, -0.3586898079890787, -0.46095608308753694, 0.9764743974296688, -0.08522159367292387, -0.01866634369358466, -0.43107802041258947, 0.042557993527292025, 0.12331051335908412, -0.024850143232309517, -0.6919099103863179, 0.15073234866614837, -0.24124244123468827, -0.034324956489967216, -0.12351071132447901, 0.15599060489262703, 1.0013437433184342, -0.059344886842388506, -0.6605764388282251, 0.8219974137123238, 0.5083738398783892},
    {0.37206915088975184, -0.14859863947804153, -0.5951556532023372, 0.14317907094192275, -1.1945316284190186, 0.065338983840243, 0.013603829414649039, -0.6751637321048986, -0.39210250845969524, -0.11216396936939185, -0.8457660815621623, 0.62425085895002, -1.063731563016031, -1.0332987107035263, -0.13334549570359866, -0.6404956824339708, -0.15464175808397157, -0.2567205776186546, 0.08912486726375414, -0.9102434789935161, -0.20817931433161443, -0.9356077313426278, -0.6212577034367587, -0.23784691374773395, -0.9052922562977026, -0.7552116375169348, -0.3590991228882701, 0.6708043764434394, -0.6410805241244005, -0.8860610686229018, -1.0763011604548143, -0.22500746264411603},
    {-0.7575614601988601, 0.6645671076893118, 0.2038371004325927, 0.5617190723625495, -0.5467232393269822, -0.15263027050180222, -0.4736061036733986, -0.3001449081103664, -0.7715193082232219, -0.3137140901883095, -0.6510170611300803, -0.6021943812446083, 0.911256452989907, -0.9302414125935491, 0.8082792394452722, -0.1071903024713726, -0.4747772808567539, 0.06374710340975, 0.27202141715975414, -0.7201263406144185, -0.4072873614948847, -0.6063013081780231, -0.1409989535804897, -0.7685267950078019, -0.5673056294371228, 0.3817276994067227, -0.15925913479379172, -0.5968565992190118, 0.3438456328450109, 0.2562172856442677, 0.4071141776190485, -1.0282616647489669},
    {-0.12764222602834785, 0.21154235955037515, -0.08062631331598784, 0.3319518531049419, -0.6179549081152296, -0.24665988287825635, -0.7756743506865797, 0.07223792632637942, 0.49883617707431177, -0.07410275423412029, -0.11986596990077279, 0.47587730394898015, 0.46557540797161145, -1.054228829119937, 0.5423518366763157, 0.07481339856287766, 0.7813127679187446, 0.1957303319847919, -0.19683013252408987, 0.13650491604685638, -0.13773642472956588, 1.0077232268950576, 0.3866814061551047, -1.1581445407727173, 0.7692179259402443, -0.09516645516381436, 0.2401600815703059, -0.659287260042128, -0.5691606380534124, 0.07825659938705015, 1.4209966114958315, 0.12231068383836623},
    {-0.02219809680480135, -0.2768121767186825, -0.048930641507834084, -0.1491071585574248, -0.9706376598180093, 0.06370638351270733, 0.2555618533811127, -0.9281384732377281, -0.0491538433195818, 0.19957213460044576, 0.13640100763862403, -0.17916502748359037, -0.530057659055977, -0.7013468248722837, -0.35520668462439964, -0.20819673860976207, -0.5539092997619223, 0.3516026413798459, 0.5265854919340797, -0.4768560745665433, -0.09009210213972621, 0.7162408804884615, -0.31487158709159263, -1.248707199468973, -0.15806341066734375, -1.1804676101511156, -0.7044068755721996, -0.3795938024691789, -0.04824632592918767, 1.111380510783708, 0.38218345564353756, -0.010975116939652986},
    {-0.8939858845606308, -1.1252080418828787, -0.3152444371712625, 0.1835749759679391, 0.532384406359983, 0.48965705880891774, -0.3482923975178914, -0.671296329779948, 0.8275728297228885, 0.8917370379072611, -0.4722650884141059, -1.0538714582606497, 0.6510734145920248, -0.09447261735224907, -0.3869757643234099, 0.356075525593523, 0.08261192407138955, 0.6037743514571515, 1.034731931242048, 0.20600129177011833, -0.8874916420916166, 0.8715263504353031, -0.5835493592318797, 0.5930909449527585, -1.1776255039519241, -0.34739302774854774, -0.507147747394882, -0.7430891689763164, 0.6548085063693446, -0.42447485633283494, 0.002924740827316095, -0.5178023154977938},
    {-0.6869619657295125, -1.3778059438380843, -0.7776134880643711, -0.8867088603147132, 1.6909453668511747, 0.35892524261319525, -0.13861366618776993, 0.35678137933862, 0.5821923891838376, -0.28832427680841466, -0.43433621133348593, -1.1660647055853506, 0.5250734392527306, 1.1441723749507418, -0.9723546541189869, -0.4576281656949601, -1.226549936387405, 0.4644452562848319, 0.32021318679899374, -0.8264688040551605, -0.7898877605726761, 0.007378445716268396, -0.07372154139422175, 0.7093240304643793, -1.04606391445047, -0.4823825425315836, -0.7829167674541138, -0.7642315233087209, -0.028726531472663682, -1.5476407883935428, -0.3072435069580036, 0.03719981594803472},
    {0.6678701371895606, 0.3685446546092574, 0.17437752902688816, -0.5030514345030476, 0.5168237924646939, 0.3977796382387115, 0.7499146777063009, 1.0068680480380705, -0.7957706397870464, -0.2818677766227898, 1.2069343772863799, 0.33832521703724017, 0.7017826212812031, 0.13793203744196775, 0.12977184840495046, -0.13707872056117576, 0.023886900632598084, 0.3233599820612017, -1.4601779619451496, -0.4788977695805082, 0.5634103787710469, -0.8802814361830741, 0.6561709257794353, -0.38405367427468784, 0.42204848209462503, 0.2239977342500469, 0.479335413278747, 0.8625968505552762, 0.6162258773465257, 0.6276299741710267, 0.618280751566297, 0.2307429051235544},
    {-0.6339612490916897, -0.6331007682661912, -0.5128000376236052, -0.12878218347518158, -0.7507898539242478, -0.1809518047008236, -0.8988667212772963, 0.06863296771376566, -0.01869848979126495, 0.20111749108542587, -0.5795881429035444, -0.1683507327800114, 0.8949826089325933, -0.4606765035562773, -0.40112260973727054, 0.34328453355225225, -0.10883179780835128, 0.5967155147236652, -0.2930272484899872, 0.17051970041894546, -0.6000647977422165, 0.3800334151920295, -0.32078358870246676, 0.13546578693589975, -0.16774590788917446, -0.4048160161915547, 0.05201560703850503, -0.33634175258792637, -0.5370385018489575, -0.09660238791041399, -0.1419364038815625, -0.6060445320804598},
    {-0.13191584998121442, -0.5219302988488477, 0.035093227472261665, -0.6579640418498741, 0.10482782559119071, -0.842357082030056, -0.05158299034242715, 0.31855721042855123, -0.3202655016872791, 0.5080314433401301, -0.4276534499189581, 0.34624077699551814, -0.2503997924810384, 0.4497143413443383, -1.126101219806471, 0.6309428781921983, 0.6723556865491792, -0.4764259245687603, 0.5934869492246625, 0.5999412769282697, 0.5939121189265285, -0.09272875820643128, 0.25801175394531506, 0.9248450297901026, -0.007337021797137211, 0.6572218395499331, -0.11276935644209954, -0.0521553226942345, 0.03172171392066364, 0.1437201598624891, 0.23966267017573586, -0.5369626830402835},
    {-2.8469312911078606, -2.6440485383178522, 0.945424134959184, 0.646303942405615, 0.2516945966134434, -1.5520429988886049, -1.7680394654695337, 0.3894257289483822, 0.620282802961812, -1.034661480608523, -1.644037901490623, -3.9885993303928826, 1.9986840081275363, 0.36316853407828825, -2.8206623455940045, 2.2836235918526087, -1.569397377789107, 2.283951629600399, -2.568425990338169, -3.1830849882769545, -3.6851292147597667, 0.8154654010728417, -0.36125183098649194, 0.7015594695357705, -0.6081480741589406, 2.17837123532687, -1.0359796891969864, -3.0735347624888267, -1.563493081039597, -3.278877421122723, 2.419431451369042, -3.6734453845170107},
    {-3.375370195477084, -2.7135502648699656, 1.5349525763231608, 0.08933263700719071, 1.191881435441556, -2.456986593204492, -2.7282892034049437, 1.3895620830220983, 1.3139856920836288, -0.7478525505188182, -2.3006876030961108, -3.9737636577846236, 2.600090992721327, 0.416752937152777, -2.435965580810969, 2.327476597492965, -1.7398449802252693, 2.9060392819610756, -2.309313764858535, -3.088973398262908, -3.4613104384721267, 0.09983427580143167, 0.19821505395027764, 0.52449463729451, -1.681619499058033, 2.636703230781652, -2.921679047695512, -3.649904786224164, -3.470510928517715, -3.6955307776376234, 3.324515697940336, -3.24750589293063},
    {-0.35056937725323, -1.9871524999882872, -1.6519260371239828, -0.7188950492552911, 0.20452298261527382, -1.5001134719375275, -2.8005851465108527, -0.8435598563438317, 0.9141466552498823, -1.0661165820674052, -2.240161976753864, -2.7108215424097226, 1.6137611524127424, -0.059787190511459885, -2.0825843278505025, 0.4515523623196575, -1.3869138439509763, 1.6970114551346898, -2.7907997243799905, -2.5181056455259228, -1.56520388756639, 1.3302504925509246, -1.2460139263367316, 1.2158969316873403, 0.30227980324292913, 0.7621742114860927, 0.23384019355205415, -1.5628651133022289, -0.3509884731731414, -1.946677666625407, 1.4557326579864485, -1.4891912543859942},
    {0.13072515054891048, -0.7442637020803805, -1.6295093640066025, 1.0972775247942859, -0.4877462206151583, 0.5099845892026938, -1.9086072912531504, -0.7484910081073071, 1.433360290231251, 0.1583378211936079, -1.3059112650642875, -0.9188577413088259, 1.5697183627544236, -2.0715855882996244, -0.0296030763811512, 0.009854140171604393, -0.7440145513401873, 1.4245799363429088, -0.9279742971349308, -2.2011402471946213, 0.7811665488274375, 1.5163678590778213, -1.991916390963522, 2.0155637271579288, -0.17244920842871417, 0.5720502258269216, 1.15513204888701, -1.3651334338800454, 1.0122912317978472, -1.5329275883716496, 1.5307739639188953, -0.4678963321199477},
    {0.14209721092494845, -1.4556045093971934, -0.6837270482692707, 1.2399804180535157, -0.5718051505483119, 0.05519921020741322, -1.8258807097872016, -0.4346344718914963, 1.2703458974458812, -0.6831549338804149, -0.46808482446301736, -1.728712207048812, 1.459126269115621, -0.03184579275607035, -1.0626971959115574, 0.7976479438768196, -2.009977931542223, 0.9759126154941576, -1.4130144175250086, -2.0878856180657337, 0.1426026374984737, 1.2279923834775661, -0.6705897553787614, 1.500582586067675, 0.4979455967554352, 1.2984351152831122, 0.957212866905967, -1.7233116548404064, -0.9947259227538232, -1.7812746309389187, 1.288732820530196, -0.8402252481261923},
    {-2.2959525787683686, -0.2539371323485762, -0.7381059314724142, 0.018336122953404446, -0.10342216559856485, 1.3554664910830416, -0.8820648998071661, 0.5915328224766208, 0.18507803127820352, -0.07785819348369248, -0.3631716740414282, -1.4287048808949643, 1.587352176519111, 0.10233880360436752, 0.01712866784055465, 0.855712090332832, 0.053288564629083206, 1.91437098829749, -1.4977967539963561, -1.9271309785993467, -1.8045867852454005, 1.493778214685624, -1.0575625432950235, 0.4703140433955838, -0.03273248486908488, 1.2842149274913561, -1.1640692582345324, -1.6036729709673705, -0.9763994841341321, -1.9028280711323178, 2.0167061783089397, -1.3695444463364457},
    {-0.4925633779032935, -1.0672948339885855, -0.5048316373968349, -0.9660147504706206, 0.3847241110400077, -0.8498282075454269, -1.3244084949507158, 0.2407022363700047, -0.12710029333870593, -0.412333621667542, -0.6683191874148006, -0.9970004695663647, 2.372625335300884, 0.2107362174878322, -1.2495462473666892, 0.5398995361064297, -0.01929691470449798, 0.8310136995524458, -0.5981960260463149, -1.0296526067010294, -0.17964026821159243, 1.2718830870563689, -0.7453800955476085, 0.922887942038038, 0.5978886553203206, 1.3711274956459207, 0.6199293810088755, -2.0068992948379707, -1.3325097096594272, -1.7730314978357666, 2.0660371139267384, -2.300587690488587},
    {-1.0952998520950192, -0.6182427485550238, 0.26427088205155336, 0.46571558610960667, 0.25902289304417797, -1.5453478684321005, -0.9532078490263627, 0.13766655495691177, 0.21273371356656168, -0.9724761636206716, 0.155326213089507, -0.13628804819014131, 0.7684400165101948, -1.2159840711373593, -0.727395928681554, 0.0669671821003208, 0.8938014307216593, 0.18697183278180587, -0.5702693440937653, -1.6881457872593366, -1.5817905276672988, 0.95938737259761, -0.533013160768451, -0.9488327822304803, 1.1737011662349417, 0.5791164147759634, -1.435340865450687, -1.9588719612132484, -0.9768924233951173, -1.6035048422153788, 1.282202034744865, -1.3090634606137048},
    {-2.302253459703824, -0.2050600683561347, 0.900442272896198, 0.5988716578323027, 1.8440488770496952, -2.7042464777352055, -1.169909860361532, 0.14718760752444238, -0.3881501007392749, 0.4925816818158167, -0.3137015380044274, -1.5126576476580986, 1.22411479463044, 0.8995983579346021, -0.9290585936809216, 1.3070439448843454, 0.7833136073741283, 1.2867661049926389, -1.4208636479256136, -0.763602874428578, -2.3407532960843143, 0.4909974626353711, 0.07410908938189141, -0.45506607622450995, 0.09014953364725635, 1.944585111827212, -1.3190883404767142, -3.1486904159126303, -2.311858087162343, -1.6770297795512294, 2.6780993506523303, -2.6860722327517745},
    {-0.22821615934398806, 0.2056259354285704, 0.3897897431019207, 1.1129962786932877, -0.06790662163689772, -1.3802359070449353, -0.8618807840040886, 0.3093843748281624, 1.6203013069152747, 0.3979063508498663, -0.23289441629389654, 0.34841050728780876, -0.5471110359829292, -0.5858740138648716, -0.5337837554134848, -0.1213594395354858, 0.7662980442141534, 0.24931882453819273, 0.2205957490195569, 0.7824330631817005, -0.7003894684306988, 1.7400708549127077, -0.8568460550920677, -0.2852804295951219, 1.6037762358456054, 0.9128434993298137, -0.6625408413903556, -0.9243989776248129, -0.45931253975623143, -1.1077839694341027, 0.3351225643338619, -0.4821558557948035},
    {0.4865789710704805, -0.28877190732191566, 0.6131339848486547, 1.5496836303812391, 2.403024710396728, 1.4792867624623525, -1.6814604225364016, -0.5370847779762352, 2.26752213005679, 1.53876781839736, -0.02525166953941603, 0.37309372965217286, 1.479505669746453, 0.5757221887281033, 1.3147157002286591, 1.2543845516263519, 0.0588127551382484, 0.6409073364905538, 1.8567190762382306, 0.7610500686141003, 0.6005910260691116, 1.7165931333920137, -0.8085024199086097, 1.5369426725375788, 0.22800523494441502, 1.1460377082141449, 0.9291642948557047, 0.3031888102883183, 0.868965760177047, -0.004137867397194507, 0.6404606216221616, 0.14547112092918796},
    {-0.6429401081130546, 0.38788610929703965, -0.20990423834497812, -0.3889951326282833, 1.3635574118278802, 0.4019604045912938, 0.6161098979763224, 0.11894475462546668, 0.2231935038562543, -0.008396359879267902, -0.7037471265576509, 0.5822619244240294, -0.12942125257680737, 1.2200648669351708, -1.161770303611032, 0.5855681768972565, 1.0111267337711234, 1.3884077391357854, 0.7204235628042248, 1.357203836147365, 0.512625804416677, 0.2430099557247279, 0.6238635526329942, 0.8985487326064532, -0.09428385687034785, 0.2955875333996894, -0.7087404715382476, 0.9456732800482973, 0.8709062924720149, 0.5802833357779118, 1.1297810558223191, 0.2840077171311413},
    {-1.5880430816201936, 0.3947758585462656, 0.31750997487645194, 0.37076008715829606, 0.29535731061388104, -0.2369377660345322, -0.2758465122641496, 0.32881342608149755, -1.4867001009503682, -0.6566025973079164, 0.44458532299450804, -0.6020953901559686, 1.5011527171470211, -1.1513207111603907, 1.665635044445206, 0.05923720488241943, 0.6155812309803051, 1.5483718224784246, -0.46340878892246146, -0.09252848436436074, -1.0941726418466848, 0.33555679637454044, 0.9790130500970107, -1.0916530695661322, 0.5973393863547486, 0.232931634660198, -1.7247650851282068, -0.5978047071776849, -1.9227234239323514, -0.9444251066992276, 1.5263417757603335, -2.0627561298852997},
    {0.4577730612827755, -1.0061281802604383, -0.599272816352946, 1.4489632137388018, -0.7149760159436385, 0.34826892966154466, -1.704056578625246, -0.8580096331885702, -0.5510618539277656, -1.1823835755091747, -0.47551304214022283, -0.9452466028816469, 0.15730361896973744, -0.953238533735786, -1.1220756334453557, -1.0772110968398463, -0.07414144985036827, -0.35293682193646947, -0.914651256880487, -2.0487740740522575, 0.35305080645549075, -0.10772672845808028, -1.106907476377538, 1.2564971891434256, 0.014732183306423651, 0.01785261462552644, -0.12301818729558157, -1.3645917118291462, 0.5648603661365716, -0.14210571852544482, -0.41169453228490976, -0.41305999434469043},
    {-1.34824724507944, -0.49426990450926644, 0.578991192414476, 0.6731986119597183, -0.38551932866975275, 1.0587180750993743, -0.8800044267526348, -0.27680075683206273, -0.20945570740362893, -1.018017054927844, -0.21393649366109838, 0.07108751456231133, -0.22294257215906838, -0.8891716188763104, -0.958891897525861, 0.14264649520231115, -0.5789189678534477, -0.3285732159736353, 1.091174084285127, -1.132192565793195, -0.674276198650546, -0.23671932862975437, 0.40902982611088745, -1.2757379179904074, -0.2890331001221683, -0.9332439127793906, -1.7242124603092497, -1.3511711408416325, -0.7515939552904406, 0.6210497992925811, 0.5144280074198414, -0.8102741909725237},
    {-2.335545255373681, 0.9996825614289377, 0.5474529827554374, 1.5402812388238851, 1.4542665702380206, -1.1375330678203748, 0.2590796608014816, 1.1756122225870562, -2.0615479378411785, -0.08833206911012187, -0.3594056772430065, -1.0993659090372652, 1.168970702113563, -0.11051093019266665, 0.408234866276785, 2.129291017637504, 1.1169489964302879, 2.031006482479266, -0.04242156718307624, -1.1821125428537052, -1.6938118209582789, 0.28466954876120865, 1.6535888225217124, 1.0059622467273903, 0.7930129048830072, 0.7035177750975106, -1.0991865271244812, -1.3081447743374408, -1.726412605990926, -1.3099014497501156, 1.583930572502928, -2.1920003511047206},
    {-0.44321528585009334, -1.2790759116530197, -0.0007581734221410356, -0.280376832152154, 0.4306210920442203, 0.4021157881103844, -0.9402472134661944, -0.17023179963364332, 1.131242193430696, 0.4390359678758891, -1.1160413507916602, -1.8488557938994254, 0.3570380201607182, -1.8579588073397268, -0.1558440912548731, -0.010122084660697533, -0.23909209218568192, 0.34294457069047507, -0.64098617803753, -1.258532256880967, -1.5802201052669007, 0.9306325619518168, -0.09959932048208346, 1.3779006586286255, -1.1160228579136027, 0.21923996157996525, 0.053833438134319386, -2.121946548475517, -0.5991642696048192, -1.0035571147237612, 0.37793947990083543, -0.34542531695994255},
    {0.2940871015119245, -1.064551356653929, -1.369414494942086, -1.3021342735043298, 1.5773878264064984, -0.4730585538483938, -1.9791322595296927, -0.7561985068393113, 0.9132880750860078, -0.7279802919387751, -1.4725066907562707, -0.7556483158427737, 0.4605154604109727, -1.584721136030419, -0.07818639125611053, -1.1225163122439223, -0.8187071411039317, 1.502732183825104, 0.1397272407030668, -0.8556990826568986, 0.9870699370068156, 0.8385562199542057, -0.8077303577364043, 0.4811139960167655, -0.2802509736863911, 0.40304622805724893, 0.9958399358783374, -1.4666423525068462, -0.857876849223255, -0.6335642133603061, -0.24750338258574142, 0.2702560441784497},
    {-0.22194301321272905, -0.18042411380969178, -1.522572625837891, 0.7540510482204652, -0.5777762014794717, 0.772859611194869, -0.7363946509422017, -0.4096014538134215, 0.859782134060296, -0.0068179580278864785, -0.4670988652759625, -0.15212934771913142, -0.25750040543856, -1.1528556126241167, -0.21513061601348474, -0.5675299034819088, 0.08884920502145346, 0.22006031852064642, -0.1345371925588159, -1.0946217376259402, -0.3655800685627731, 1.1360833180230434, -0.5253043476113922, -0.860604344473147, 0.293053632460163, 0.68535770087011, 0.08999837938106096, -0.43499806978756905, -0.019931532399412793, -0.45857776134579775, 0.6404855427022712, 0.3511801394632781},
    {0.37445679447731195, -0.5553262582878356, -0.08237062037848342, -1.0712712477085018, -0.6120324087569118, 0.4277552730139795, 0.3768179989338986, -0.469539706548608, 0.915489639005623, 0.8070593490445358, -1.1423069947851678, 0.5854387441216145, -0.19225752196743107, -0.5342049730523717, -1.3086267946812542, 0.9987418614041332, -0.8648881915756705, 1.0111374927730583, -0.30264496980326383, -0.04933737982445708, -0.5695154942538851, 0.8102123265620101, -0.4698723908865161, 0.33706427044102144, -0.2172867591700132, -0.2090237697923982, -0.19822306989585425, -0.6402536718785041, -0.46621571584460114, -0.1750631279326912, -0.024853676128820782, 0.2494970923983452},
    {0.27279462198237636, -0.14716674103412966, -0.9051197479923033, -0.737377987388419, 1.1904950074401737, 0.22137903142665138, 0.35186218808423375, -0.08157783137091097, 0.23919193564326466, 0.2680943575944162, -0.9870831294596469, -1.1468875644298304, -0.0870412288693406, -0.4978181394806093, -1.7840406367428157, -0.8789690983507638, -0.3887783589058041, 0.37927574453185114, -2.0528203741655995, 0.29141676110625975, 1.0342960929617273, -0.46637290217930505, -1.110779769509533, 0.872262668750381, -0.3316002226968809, 0.5078386606209174, 0.020148474662497983, -0.4440417831683724, -1.2500109150795775, -0.04392174761740652, 0.19965718713168965, 0.8367521311604814},
    {-0.9170264117527215, 0.3271342156083898, -0.27989926324710207, -0.7511389802462959, 1.0935430269658646, 0.6911079436609386, -0.7893254882419501, 0.5374585112951198, 1.5355347810288507, 1.2814105078730382, -0.11700581243505986, -0.06046463623491411, 0.20478149010176966, -0.42515995192995465, 0.4042166962526204, 0.7876215170157602, 1.3897696546369145, 1.3629997013400674, -1.9370135133312998, 0.7081021769839027, 0.33383174060955684, 0.833997007446759, -0.43605101062767376, -0.2245672618349766, 0.1955966657503375, 1.600874498963885, 0.8366435793446636, -0.9849519187045187, -1.3227540993996727, 0.21775908651450512, 1.4841360605055254, 0.16699852032141083},
    {0.6631668030099609, -1.062244989095492, 0.6857017880169026, 0.7514141541579278, 1.9300543304204039, 0.9673733769044562, -0.3485330303550297, 1.0124056507210162, -0.4525147307405485, -0.24718867837665337, -0.19575571730504152, -0.2431324604387186, 0.6683342089509104, -0.7273727879602865, -0.5811275157290569, 0.35011652845381674, -0.9547468414851344, 1.9808291742597404, -0.2935570107853184, 0.34228457643795285, 1.0055867077654554, 2.0066722170561984, 0.27511392677825386, 0.4640476058627311, -0.37887674391229403, 0.7123912659563414, -0.4569661420829897, 0.15619491025064605, 0.9891614384321742, 0.9915994395352687, -0.09023075946648687, 1.1352935384059137},
    {-0.5599994834947641, -0.8400273724430705, 0.6333862018843506, 1.1016370001977196, 0.4646258134632526, -0.06028486241974907, -0.5413826183562115, 0.6554742421956914, 0.17791308172054993, 0.7737014525405412, -1.0092802588071161, 1.031485620833146, 0.07384211137645799, -1.2705204541334834, 0.5181699427452555, 0.9958715384014384, 1.0173728321550877, -0.6061224711587272, 0.0004817155113220394, 1.3274738625201585, -0.0860974926311249, 0.11058008196365411, 0.7639293906019115, -0.7829358964590009, -1.3446725210539552, 1.1479591194555356, 0.3187098303889618, 0.415663652278582, 0.5502790782485715, -0.9072617858434303, -0.5120544225097279, -0.683752595442876},
    {-0.9459083686188499, -0.7415326957756461, 0.24018013437833652, -0.392209246470949, 0.2989593410557954, 0.1149764456871307, -0.08942771172799123, -0.7734689505936688, 1.4942283230635964, -0.6352533251994698, 0.29097773670573834, -0.10728611289588019, -0.6567234857941088, 0.6275712189601765, 0.4396638440031854, -0.5534605328089939, -0.3074281199778883, -0.11132688951573169, -0.770584358042005, 0.4497143940216746, -1.0380417810237048, 0.9602362019106764, -0.5049221832430716, -0.4616124859852047, 0.1649698323614593, -0.6663209086363135, -0.890007461503228, -1.2527562838775779, -0.6568980623403504, -0.11975717566320988, -0.8895150820706662, -0.7783044284023345},
    {-1.421014922049919, -0.832450944120707, 0.4746961367970358, 1.369452386675928, 0.11591386246439138, 0.6460419809714621, -0.2992697114374596, -0.8542019651643327, -0.34576138379512766, 0.5363754841716979, 0.06899371953256583, -2.0497408894664124, -1.2044063433700432, -0.839472172024338, 0.8042593608948195, 0.5997248587915105, 1.1117260406596685, 0.16581992030021078, -0.04665252816784504, -0.29051495064613575, -1.1186959422884373, 1.5279493438114438, -0.14632936202680227, -0.0881790496826718, 0.0502576471457421, -0.5402270810249712, -0.9049703858718154, -1.0176850790085508, -0.5029348893761932, -1.0322623810818996, 0.9604821124064425, 0.39343308708675057},
    {-1.229599545330744, -0.6218102844959444, 0.3641635698449812, -0.9435954707143218, 0.9507424678711375, -0.6393646674703544, -1.6901609537991127, 0.30787695430082446, 0.16006143492713867, -1.0759791742469769, -0.8756490215658996, -0.6982674912523442, 0.5039720438511474, -0.8446287438016465, -0.5253595237863912, -0.33628057325442, -0.37487587190122024, 2.3186112094286564, -1.052153198287498, -0.5637765114701657, -0.970652468419609, 0.9661025885771105, -0.39904920762646473, 0.3861138390772997, -1.0456387524350907, -1.4963597281438359, -0.7441042201226405, -0.9198593975656856, -0.06668138791253295, -1.1584080113963195, 1.227317664858455, -1.3167705431289327},
    {-1.2749816413011505, -0.9704542684542579, 0.04687969856266723, -0.05855686342074833, 0.40005195035616276, 1.0754789887204357, -0.7326434907331745, 0.17823083534526182, -0.06274405941208544, -0.5639795961949501, -0.8245706158931535, -1.0287671790480326, 0.13772598938871708, -0.46297740921607866, 0.14870060563623358, -0.4859094317454798, -0.8223851368325394, 0.6220385676171504, -0.07796169801277537, -0.33220453425257856, -0.07006257504757712, -0.7480466818954891, -0.9570836945825867, 1.357265624067216, -1.6840921218882727, 0.9709396633353107, 0.18743097282116514, -0.7650157538386767, -0.6318910226871665, -1.6705089481240225, 0.470686686974841, -0.7211618107876007},
    {-1.2328477039329913, 0.24138876100935397, 0.861047120630245, 0.8021640400309663, 0.8730002846706583, 1.00429240613225, 0.7071475944370221, 1.1521334823293368, 0.4350712352470632, -0.41907615235063195, 0.22091047064743435, 0.1409431753657548, 1.2215854339227605, 0.12496464321748087, -0.23951991261723754, 0.6507455780105763, 0.8173916503218611, 1.3381428947951974, 0.2644808954315344, -0.3384290642763107, -0.9376763402273469, 0.9283549711965509, 1.6581402721811704, 0.049378382024262035, 0.791363353825317, 0.8869465192105248, -2.1505127446852943, -1.15327839042473, -1.0190051479905884, -0.3549175995029878, -0.02500434141730923, 0.8141034527846968},
    {-1.6663084674681872, 0.026878249421201098, 0.33587717150557894, -1.1314997986684436, 1.1358657253066786, -0.38689902660611813, -1.1395682852273932, 1.168543481079911, -2.0335846117070235, -0.8074051994385574, -0.6678115711819217, -0.6716077228119629, 0.15078095249393325, -0.6297705322949808, 0.7315950279441295, -0.2755072053079568, -0.09703996808663025, 0.6002202454133371, 0.4815925501920947, -1.1063795506180947, -0.44973082271475484, -1.4686108836032759, 1.1849097738292387, -0.2593028169141896, -0.08996444154108282, 1.0626470840414854, -0.8394031244872837, -1.1986581320524194, -1.9826320699889852, -1.6398095882630201, 1.8613295590652732, -1.9325933278481282}
};

static const float b1[32] = {4.785236972577446, 4.7967070282630555, 4.91406016371561, 4.822352341745759, 4.849444212542438, 4.819535815116591, 4.922302027265581, 4.955631415459418, 4.76535199187405, 4.857022989753881, 4.68676345800766, 4.727439668211538, 4.872651315015147, 4.842259755256588, 4.840663151765648, 4.9889093324304525, 4.881423477433328, 4.83284196829975, 4.871136133474311, 4.792141665839165, 4.667029576512262, 4.793429381634033, 4.863529941162926, 4.684614635726651, 4.727684005943845, 4.910042674314435, 4.790408003549538, 4.763351419359256, 4.693644433470513, 4.943529528030353, 4.955343770276911, 4.825062264176754};

static const float w2[32][16] = {
    {4.1212899397014, 4.396647510346684, 3.9141887359808534, 4.353241233779867, 3.998158205482647, 3.761787309306334, 4.610187410238833, 4.0544715414108685, 3.5173751427352187, 4.776165730675658, 4.2201068829332105, 3.6552667688384366, 3.639390022138049, 4.435640937378079, -0.05164344944609668, 4.1851386655313085},
    {4.7289417921460535, 4.701087708610222, 3.8027924541681717, 4.397317516136454, 4.459521294738963, 3.9927563675952498, 4.749487605505746, 4.218876194774086, 3.7417669312330517, 4.502690223727757, 4.343090229954654, 4.616748655241575, 4.198346947288917, 4.754669802209554, 0.09879611704256475, 4.79479341550139},
    {4.574988911311714, 4.63623906250116, 4.569692054665735, 5.028109265208817, 4.339213878787934, 4.318698838224521, 4.711996525151217, 4.658861022230507, 4.142257772157117, 4.303015455980301, 4.556334495807496, 4.697065638716513, 4.723249019495507, 4.125429711334387, -0.0731008882036835, 4.387484164426852},
    {4.4537028155063565, 4.300426444726682, 4.592873320231131, 4.151587524860738, 3.903807259114678, 4.100854107147368, 4.142346495813957, 4.514264346371876, 3.991313324073565, 4.469431512673539, 4.113635683654372, 4.627209260266199, 3.7182791057046822, 4.787980866547658, -0.35066127341077324, 4.47073818177217},
    {4.298979637817105, 4.643939479728356, 4.650811347401054, 5.013228141645979, 4.440865256088688, 4.125904298121075, 4.530562385414773, 4.446540732452003, 4.3678840489232105, 4.744748835035861, 4.342231329175122, 4.770023631109852, 4.5502407882239035, 4.665028692656512, -0.2530667505191323, 4.391159353634231},
    {4.27120685820183, 4.477644941691736, 4.668584497514015, 4.723784368550033, 4.332490120390948, 4.451724263560707, 4.66263275172117, 4.21168293954179, 4.250685386993087, 3.999091979095453, 4.399534066750601, 4.716640756270666, 4.30650572029467, 4.53513243650308, -0.13458156151555223, 4.782146107716144},
    {4.071303860872905, 4.4736341206664125, 5.001341062819165, 4.585523667703322, 4.3356151319321405, 4.279050113232897, 4.058504282337233, 4.548551257903817, 4.521896547640419, 4.387990439207335, 4.389928995276131, 4.865607169953453, 4.54578508694751, 3.9997163180542192, -0.4888204449711392, 4.509727748323107},
    {4.453660362593267, 4.4360009367070266, 4.4873735580104865, 4.679940410971885, 4.4117340027119765, 4.051996995942769, 4.927960201774265, 4.5792853685689545, 4.388262799340774, 4.780882014094005, 4.443486563316903, 4.206982446196718, 4.414096521352696, 4.515759173781004, -0.3042978343750765, 5.011818928273836},
    {4.51109230329002, 4.4331604318425955, 4.5582859553447515, 4.079333217084897, 4.154771279954332, 3.746121769397461, 4.151047675373541, 4.597364927732896, 4.1571731542227255, 4.080761028126675, 4.512655788495269, 4.260939816072629, 4.144554009479893, 3.9782582755097144, -0.4481641798768708, 3.957993433387792},
    {4.421410728233197, 4.696545127921624, 4.508772407776829, 4.183809775899452, 4.66849546874517, 4.394948443683796, 4.6603118136954675, 4.088544605324925, 4.3918943390006815, 4.368866355149273, 4.633579052999511, 4.433183002398376, 4.643409121751629, 4.811782172893237, -0.05275668567015582, 4.788458111029118},
    {4.578026265722584, 4.276500496786305, 4.361973814888861, 4.5570636035307315, 4.769577424418785, 3.91350714416422, 4.750985611763541, 4.234503756621678, 4.030574294916987, 4.5342108277986615, 4.506434527887025, 4.613572042378991, 4.30060187644471, 4.227488853664108, 0.36435980498069837, 4.448066453873393},
    {4.142565285762331, 4.407187853497101, 4.277244297988047, 4.033343199188457, 4.776031684820082, 4.186213561464411, 4.659862973543855, 4.2015054646286885, 4.059449716411183, 4.7938411244627614, 4.29337546745101, 4.389784014662619, 4.444730964244853, 4.478721994148193, -0.1637640557979652, 4.306259547476843},
    {4.531563730122385, 4.071036390123259, 4.378400425727784, 5.3097507822907035, 4.180545217450677, 4.057903753699773, 4.701534626282208, 4.339610416931977, 4.171114352273154, 4.644490651457402, 4.633925133096717, 4.249208097243605, 4.885090225987567, 4.14264745532247, -0.007424807094053003, 3.920070827198374},
    {4.705207336703735, 4.156737347940819, 4.460544778054433, 4.925178676379644, 4.585607795580516, 4.238695185624295, 4.45124333497495, 4.65672494300667, 4.061458203487727, 4.512550834847544, 4.598294439489306, 4.4781325762048745, 4.349066598692766, 4.728054219677533, 0.37505920385339336, 4.191459864098094},
    {4.400047225579896, 4.309984164051082, 4.595240900363331, 4.567069382701448, 4.273207301774878, 4.088187522215672, 4.71682782881615, 4.575483560022792, 4.211448138535701, 4.522309110280098, 5.047791347633883, 4.40571599695938, 4.722185145781957, 4.3026076593176406, -0.1488808985742524, 4.0532164137877915},
    {3.943175496955237, 4.423231345893195, 4.817877222562121, 4.617596783276209, 4.551026391929432, 3.718783375302461, 4.730876585170923, 4.426852306894172, 4.170321698315479, 4.325075312384448, 4.630328064348737, 4.659126268644774, 4.569064064343818, 4.59294788504679, -0.21207647522835565, 4.436295811822699},
    {4.84877125940002, 4.277542974355469, 3.974347223909665, 5.090910814549625, 4.5547480208327205, 4.3096510121775555, 4.528539732058508, 4.997833700313617, 4.187293131669221, 4.872481121477893, 4.458399298345149, 4.297700323074175, 4.444390315773075, 3.9510507244079847, 0.0669321135824275, 4.377539191896399},
    {4.363541990434723, 4.173999844037986, 4.63663904024412, 4.371100196710547, 4.35611257241458, 3.9650919705974523, 4.659846718479702, 4.479644539989762, 4.044597744338844, 3.9650963164620494, 4.480732791775689, 4.5256593280915824, 4.043913787479761, 4.456773172013927, -0.03324682179289543, 4.0869015526591665},
    {4.289815651863236, 4.36024635781198, 4.29241733580078, 4.263444582704274, 3.879101956177999, 4.062541739463703, 4.2879074748325126, 4.631558066589169, 3.5665774593853525, 4.305173596767426, 4.466927381402259, 4.12931724290807, 4.440944394569845, 4.430349473118862, 0.08085693925525718, 4.521045306278466},
    {4.484240764539066, 3.9943510387682792, 4.757286621264204, 4.51427541645336, 4.553456457868209, 3.9349844466134227, 4.5223065147689825, 4.034715558557481, 3.8412100820903787, 4.147721388714514, 4.719587220257665, 4.20090169985828, 4.630661649091834, 4.237137834326996, -0.23296954423796087, 4.383300122493904},
    {3.929653807803688, 4.72504066226271, 4.297566383131447, 4.615288781541781, 4.587999183834583, 4.291378103352841, 3.9809895142824936, 4.303802537086761, 4.20187444011563, 4.347497342693644, 3.9754301259042966, 4.934665093420643, 4.5237736618172635, 4.338746454924836, 0.12831679770794036, 4.506293501657784},
    {4.349927874937724, 4.298046842090246, 4.177192360077526, 4.750743665881277, 4.148670556758549, 4.425474496500667, 4.130052360529483, 4.189388163493811, 4.028417545603052, 4.180277859544692, 4.826314380522516, 4.414611318276166, 4.4224802030602754, 3.886229902903085, 0.05586371262392772, 4.225702275627167},
    {4.693881924886025, 5.113624466437867, 4.448772761918468, 4.318796209308076, 4.35252704162747, 4.582470995859409, 4.762123502091887, 4.855927485031747, 4.103312372864922, 4.539587693105508, 4.354412074136904, 4.71984197793852, 4.568977551196419, 4.510880232097239, 0.014785633966652693, 4.470256176031123},
    {4.542467616472281, 4.671089220916696, 4.130072045986755, 3.484556697088633, 4.707787750885991, 4.07213873631666, 4.738873393005688, 4.82863670759497, 4.142844039489361, 4.565407373282592, 4.909795261494437, 4.074435287868379, 4.847219452933795, 4.589211513714047, 0.056459781999820984, 4.162995832206574},
    {4.249852884762252, 4.192717691880143, 4.981428680141834, 4.270529961384574, 4.562005579744197, 4.180743666868067, 4.353010513564771, 4.090704738609863, 4.293661816413563, 3.9514889881723776, 4.640793823266199, 4.658152239642859, 4.807869010396414, 4.207632923865207, -0.4373885834061223, 4.81857265134112},
    {4.643667574909202, 4.8150982947132075, 4.6729661773310385, 4.647789541027035, 4.582751021345869, 4.074338018243393, 4.590583086516377, 4.84107307669266, 4.512335655660888, 4.58882615610154, 4.5984238455926665, 4.051548351917195, 4.567747785023553, 4.459106313278283, -0.18773782963483215, 4.343925751905759},
    {4.35974186395359, 4.585848475503612, 3.777359015605525, 4.3354922037782515, 4.240946246016238, 3.9490965081728406, 3.931475560127647, 4.332710350350567, 3.957333665579699, 3.9590980807207106, 4.671560026262227, 4.597709395330005, 4.521998412928705, 4.082571442191636, 0.11043442305188864, 4.641032894377923},
    {4.2015513532609505, 4.349698179449505, 4.070093542984034, 4.530948556977806, 4.281956560778642, 4.103552536248828, 4.51413241841044, 4.349272895414211, 3.633778922225812, 4.538240864644677, 4.351050114278075, 3.697440904707987, 4.766036852229258, 4.28295562650146, -0.4341940829400228, 4.478784476737594},
    {4.357181956811881, 4.46086193854133, 4.832712664989155, 4.3232490810022, 4.052148479376269, 3.445264767593983, 4.535984924437686, 4.074147351430429, 4.164418713537492, 4.0776139920161025, 3.689485171413651, 4.0359971138447905, 4.1620126302135265, 3.951655996284542, -0.24579562375843997, 4.127417430241106},
    {3.989080965086926, 4.343039800890416, 3.8709235350878033, 4.2457968939545045, 4.432429533762871, 3.9630960579682535, 3.5006948213476683, 4.540527437019462, 3.7437167366539796, 4.178899298983496, 4.229566394802114, 3.9433007619644376, 4.185351377151416, 4.356373330195218, -0.2934889231956379, 4.142534172426615},
    {4.4541845215748745, 4.720053458449586, 4.310565535149695, 4.348579393503139, 4.227902745514687, 4.64068480325405, 4.86638844777254, 4.542115479449285, 4.4574150343139465, 4.406680572639827, 4.741194165607712, 4.844775775266762, 4.351402072588994, 5.055233419608999, -0.20039019634175886, 4.015375111039171},
    {4.13966909399935, 4.229850290919191, 4.275838846688063, 4.730408174844963, 4.37126552310268, 4.147396705201615, 4.236818333755164, 4.379355504746462, 3.839549004530518, 4.02250814759625, 4.224094651445109, 4.0584145547887776, 4.502078748301164, 4.260417899949746, 0.4405006100791659, 4.207372922233408}
};

static const float b2[16] = {3.777867901808905, 3.7886027096660966, 3.7407832282071434, 3.669988328220104, 3.7415193253686865, 3.9198611033813107, 3.823172586573464, 3.703512661003054, 3.804322849132194, 3.6594199567194643, 3.759651444792215, 3.8134875374107176, 3.7733671543034397, 3.6530598240662946, -0.09537217989594797, 3.645561309253202};

static const float w3[16][12] = {
    {-2.885338143955876, -3.9604938760250383, -3.892335420832055, -3.7471701608951102, -3.8046814656115884, -3.9284630406458483, -3.1465582273171653, -2.9040110158106005, -3.2697984147380894, -3.3144618497268885, -2.979812509991383, -3.28707361799597},
    {-2.9439474249292372, -3.9817641383968128, -3.8025513831434417, -3.188892951131034, -3.4256587138006314, -3.790866690130106, -3.120281766315567, -3.4410494628370993, -2.8740651534814647, -3.7350695596680064, -3.451029246967892, -3.775629284822419},
    {-3.631666030423572, -3.5151264475529787, -3.7431964036439913, -3.335602716935709, -3.97792158515646, -3.483438954117815, -3.274099290096697, -3.443020571163658, -2.8629020454955167, -4.142351917730582, -3.48190192254189, -3.441429206924282},
    {-3.2025693410955562, -3.4477291753597825, -3.330883502519429, -3.6654266218032125, -3.772209711777973, -3.281105811275656, -3.723937828219463, -3.855589366532675, -3.9542573944430077, -3.152170270990275, -3.418476916386606, -3.497427328318095},
    {-3.3507463139201628, -3.0820490776370733, -3.6276020561551072, -3.493619829102699, -2.553487626299549, -4.003545655662506, -4.3997960567192775, -3.8032445052255808, -3.2546847827220633, -3.465291711386951, -3.3128234426926295, -3.730393516317226},
    {-4.004835049627573, -3.3438444735284882, -3.7417276399026305, -3.1121989812012183, -3.092954981274797, -3.209088830492868, -3.454029674746947, -3.116778472614539, -3.294296172072214, -4.270750208657459, -3.0995690103648514, -3.44415789422312},
    {-3.294572962138801, -2.9609755042800305, -3.5543066777936816, -3.4449115708373905, -3.306841193461762, -3.203823029718577, -3.9162360616453524, -4.051903558590117, -3.2033319640219253, -3.9026704719630856, -3.4659233723224987, -3.9759939986054103},
    {-3.917839379967057, -3.5550885601772206, -3.0014424219538043, -3.614843589204013, -3.379522728912939, -3.2661764673489855, -3.280566586321714, -3.2922028317376353, -3.0810476198080408, -3.059273165026349, -4.009924434104533, -3.8611304660166583},
    {-4.157649031223954, -3.789356189274825, -3.269130591452061, -3.180046524906988, -3.6031766659840154, -3.417933040692589, -3.342887048541633, -3.570403850194725, -3.8866726716689266, -3.4647826433369047, -3.4334294354171253, -2.2288024549985526},
    {-4.022188941828363, -3.0500578035698793, -3.0722717034436156, -3.790474099772914, -3.6366484734230164, -3.053561366622026, -3.5605922230583436, -3.8093380661213896, -3.584298498836699, -3.2029814917013906, -3.6498435991860507, -3.7148902008023867},
    {-3.605354275179018, -3.1636037663966254, -3.5224553981535687, -3.593517477246186, -3.25315651962737, -3.311685000897984, -3.311250643529821, -3.5545789696496515, -3.337167779513313, -3.4480381032345266, -3.796593530100877, -3.7782710964161312},
    {-3.389225484990497, -3.5560719110388592, -3.030581686692824, -3.855270484138456, -3.6837429715426997, -3.4660763684281375, -3.661826373751062, -2.8642878737485398, -3.6304289295694265, -3.013962916735978, -3.784526298667908, -3.6018034862693766},
    {-2.986555074622425, -3.8577581603907327, -3.1871004071503446, -3.226014941116252, -3.5524046861126837, -4.231835869123943, -2.7050280246025933, -3.77218329836147, -4.200918926642702, -3.5466403430998663, -3.7225284148885955, -3.2889652980162047},
    {-3.78343175197791, -3.344700517529478, -3.9299562478757726, -3.489213651496091, -3.838387614510506, -3.418006141793877, -3.311467509388131, -3.397977543451749, -3.5622657121256607, -3.7840256933117766, -3.314857507505369, -3.4203580489178034},
    {0.11547168312549078, 0.14749782544118137, 0.29373959995675736, 0.35247602758773455, 0.31893118784036734, 0.15413369573376268, -0.49007529337735317, -0.1263496640000447, 0.17967869947266976, -0.13081026903098625, 0.10636188643279931, -0.3499672644817306},
    {-3.4091470506708794, -3.9150769914302863, -3.7708704493235192, -3.6449493760481526, -3.510043524899009, -3.3651945164308006, -4.3028488209769, -3.3672892972534454, -4.498382410345999, -2.9712214283467433, -3.4515318964807538, -3.261363880734161}
};

static const float b3[12] = {-1.257616321875972, -1.5943214436387083, -1.3550495869234087, -1.3774207098170668, -1.6152720497061557, -1.2348987287529805, -1.8366417886299673, -2.0067866623604886, -1.9192391056948284, -1.7894110600590516, -1.579600430731719, -1.500630443085315};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
