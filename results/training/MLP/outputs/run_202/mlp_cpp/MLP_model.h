#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {5.300040278976779, 4.921299737440435, -0.23686428021150258, -0.7890089111453412, 2.155842880461167, 4.9226233345591215, 2.1589813128697313, 1.39258341604205, 0.16581038721645783, 4.40945102363058, 3.516644704173471, 3.5751803619876372, 0.7243800388337922, -0.49065723306479564, -1.7048936138399613, 2.942568181003164, 1.4498466738758014, 1.5301225788680033, 2.648260774712061, 0.7621972088581457, 3.5633659955421115, 0.5821300371923527, 0.2902320823693427, 1.561622488116078, 1.5868030168616092, 4.537304228659417, -1.0798198630729225, 1.6779354843272645, 3.877014962304267, 1.5161894361245847, 1.235332221544277, 4.0132031155184595},
    {3.293140114633701, 2.4323159236015335, -0.46737766562746397, -1.6433286549895314, 0.9227400687933051, 2.3481784299276676, -1.096131749132335, 0.7114110074273701, -1.6999512470479137, 2.7814199984142634, 2.176778431812859, 2.150995660206157, -2.3220916394997775, -1.7054880885196186, -3.7792484914463373, 1.9087389445870255, -1.153173969574007, -1.9473981831815907, 0.06569775390714211, 1.0802061950680548, 1.0222985482149747, -0.7198388856150825, -0.6827384252710055, -1.5353691403381697, -2.4960463741413177, 4.121283698051274, -3.2233462575538514, -0.7431797164793552, 2.7033048306486696, -1.378224004645363, -2.067801321610224, 2.721495420196278},
    {3.7943234330996485, 4.131171856287684, -2.2449197348299177, -3.905480010364758, -0.907177809147231, 2.5447082939017363, -2.0369814568714366, -2.308045177041555, -3.534955695984604, 2.363292504444292, 1.7513973053025105, 3.1149597709258887, -1.881663102649747, -3.935554955112592, -4.688735873428154, 1.785930411491868, -3.4011651727432035, -2.6684226057721205, -1.5967130336461572, -2.272638662622857, -0.3703537657784986, -2.2916724845051637, -1.9559315658645355, -2.7009448088729564, -1.5747565848835543, 4.112395379692617, -3.6746166735953354, -1.008943751655637, 3.517108184343747, -1.6914797656328981, -2.684546370505461, 0.7451895203905323},
    {3.4808932741476046, 4.25701748409504, -2.72528465363029, -3.01313859926988, -0.9900565793342943, 3.9752060656427957, -2.6308685460882324, -1.8827526024590997, -3.8093767736114166, 1.820659378677067, 0.7035263483164352, 1.4281352399511111, -3.7758617418012306, -4.647354487822233, -4.354276768338395, 1.3849121014095258, -4.6843933939110105, -1.939961099005658, -3.1667095485132193, -1.0172416432066826, -1.3091097215903864, -3.836350716793206, -4.023754909197218, -3.6343194699305617, -3.833967581663249, 4.657387773329567, -4.385546816480578, -2.3989295307052556, 3.125861928790711, -2.4794543136602036, -4.227649884518156, 2.1471742770230975},
    {2.1991597455492267, 3.720890410960966, -3.943517815980868, -3.973119033295992, -1.5353611119990844, 2.6300772783858055, -3.0667266317745714, -4.539303430034883, -3.9828326660382127, 0.5732090315011638, 0.3725457807911876, 1.184694365158788, -3.578064141731883, -4.77798356866655, -5.644014506435406, 0.9068634714333442, -5.832672377041644, -2.938914742579705, -2.1230272694508323, -2.6195354838133027, -0.9927494362157977, -4.1445733333079735, -3.6727305810143362, -4.065001597922958, -3.6822860136913405, 2.81679273921669, -4.9964856384391805, -3.355321884814585, 1.2963855181954382, -4.812846148135506, -4.718032795963821, -0.3865735422055125},
    {0.9540594144472484, 2.687236922011164, -4.726405303270079, -4.406833631556402, -2.3782952656517904, 1.6773281924481227, -4.472875918931682, -4.407708323141963, -4.293495197616985, -0.2528106255336101, 0.282996216348009, -0.4110640807996508, -3.6919631510910795, -4.651674225221406, -4.534003843811234, -0.03441125353041952, -4.693980901314743, -4.226921796373781, -2.5454991779126983, -2.9281436927061733, -1.611785750400417, -4.04469096437201, -3.814615075034329, -4.80894859722555, -5.228011222762361, 1.846351747534863, -4.184715242494391, -2.5494442652144182, -0.701636416627921, -4.311101899574067, -4.746235894118791, -1.166604085773563},
    {-0.44455278516823293, 1.8740133877285008, -3.8622083585498084, -5.261377563197029, -3.163848321407986, 1.5275997758744648, -2.852442331848659, -3.538439639968266, -3.560013936767132, -0.0035348542386517898, -0.6116683118219779, 0.7615579083350188, -3.87972965786456, -4.293402724367175, -5.266776510356637, 0.7589747249856115, -5.361532418100996, -4.454537095063517, -3.548122459373911, -3.2064557055782705, -0.8574865602818608, -4.962841169631396, -2.79495767224435, -3.8788240788119435, -4.8200076757143755, 1.8286327081604368, -5.547351112980775, -2.472159515050161, -0.021076229421939895, -3.6119917713111622, -4.794548111435174, 0.000450917189320284},
    {0.08704997226663397, 1.6072189029813915, -2.820443244355145, -5.114050961899283, -1.3531743467432957, 0.5347795243155113, -2.5550527250382458, -2.770434421116206, -4.553489991906381, -0.25473211263165135, -1.187069146618492, 0.6069091411271488, -3.4853913051647476, -5.602687097156583, -5.086159150551117, 0.30821247082654984, -6.051579873576111, -2.7810111673747535, -2.7472832564911505, -2.84515404243778, -1.600383532832328, -4.259755875844713, -3.61671990967262, -3.5157850262283676, -4.782923643751097, 2.3313890636995533, -4.415749478112458, -3.662652210468975, -0.5730622384953098, -4.486126117771808, -4.5129853157491056, -0.1846990236211162},
    {1.914482976242969, 2.552243556982018, -3.581388408781156, -3.7457180462040585, -1.9129878716341835, 2.851313505688473, -3.2764067433948445, -2.41355651514318, -5.233697465732886, 1.2123735235456314, 0.09410056120458099, 0.7299863422049203, -3.3969715402741203, -4.139665500266097, -4.99867670322696, 0.9655272894705338, -4.015697657299218, -4.304561908079823, -2.951025067640032, -3.5584312558406452, 0.11684634707027594, -5.021139869450747, -4.612508420135703, -4.56661486409516, -4.3661083374570415, 2.732361921411811, -3.8785312048829943, -4.112544317318637, 2.3321895269484743, -2.8608912165005753, -5.680197135008492, 0.6844882767476737},
    {1.7414052317422446, 2.1587924658162514, -3.888995126796052, -4.100675323326828, -1.5687240443138848, 1.7226360061577333, -2.712859015987413, -2.2602219569558466, -5.404144806782253, 1.4003322849857105, 1.1881288529191052, 1.7403306405876966, -3.546494061900709, -4.240162487689987, -5.100156605996446, 0.3811933506971274, -4.518092508951242, -3.5708289937156596, -3.3460305906182173, -1.9489190927399407, -1.0170650780000483, -3.918500097745326, -3.6818964912939895, -4.6729232469668665, -4.151038729617354, 3.8413663022828524, -5.289166538788456, -3.86359672918567, 2.976894988506855, -2.631494038723038, -3.813640661798256, 0.7848420223131095},
    {1.8480837448195642, 0.9959714599830117, -3.561488024697777, -4.507387962461703, -1.41142220449084, 1.4202492605565933, -2.6428982973288755, -2.6032314566446635, -4.932792171859401, 0.555256422048494, 1.5043623027657251, 1.1398988059771955, -3.114917500746229, -2.670475582415306, -4.262141869166559, -0.43497207227001294, -3.1808283005268017, -2.5247252513895595, -1.5198442056900214, -1.8211626420779004, -1.152023486754025, -3.4586598590557127, -3.2338125258257, -4.2558119407362405, -4.2467303915141414, 2.299171640193839, -3.776157250166302, -3.4638986576595654, 1.1944495435851896, -3.8868770136228012, -3.615233349894013, 0.5895189390781592},
    {1.448823554724074, 0.6548355252243403, -2.8731717165540585, -3.3129466617280765, -0.43677508998075604, 0.6522976415370718, -2.9890761623065356, -2.5437008645991783, -4.124520029441546, 0.9763765928316965, 0.1372524032886143, 1.344746742180545, -4.085567343453464, -4.127320786682491, -4.981280294655703, 1.1653165538495713, -4.2967403838310325, -4.552702038111975, -2.122659486933983, -2.467284329407232, -1.9654249795469056, -3.742265583405561, -4.237465440558218, -2.9661410043458005, -4.717635641316701, 2.443370845454195, -4.190435024899925, -3.366813223196841, 2.433822832026379, -4.318590775403665, -3.0708665944728946, 0.14930880111033715},
    {1.3659148833896309, 2.367208717009518, -4.25787085449931, -2.843741732676738, -1.85457082734813, 2.436821407470893, -3.2580557466849327, -3.05870741439916, -5.483829176198062, 1.3684225516703727, -0.9396975551568307, -0.44789345498286987, -3.591868284585178, -3.900627905042636, -5.317920852570807, 0.9722867852143067, -4.408118712809408, -4.458296470957414, -3.5937564734648153, -1.5218942005303457, -0.8541664220717016, -4.5097935686812605, -2.931956302803504, -5.017597806782402, -4.108942243016779, 1.419422410058266, -3.4883870599499436, -3.617757194126439, 2.2615952691743173, -4.40626590303606, -3.2402957879033054, 0.8719573623374955},
    {1.449805999782185, 0.8444693221791155, -3.6960274423963795, -3.023962628693547, -1.608900343504203, 0.36976067786186295, -2.6260569788780344, -2.998917071942068, -5.27971580470232, 0.29034955878397445, -0.1014884705177921, 0.20970370428963825, -4.306360087152044, -3.8161024704685276, -4.629024832561452, 1.243444660333192, -3.4667132212089986, -2.855376338691714, -2.4379327146025798, -3.147901545502722, -1.4614480998877148, -2.9531102912679077, -2.837432721066708, -4.934822280926593, -4.19634375050512, 1.7283531167615656, -4.888228575831057, -4.337368983685826, 2.0929830355245675, -3.5096134822795686, -3.5643442255323623, 0.7046049885672823},
    {1.6451640519869626, 0.8471454016379414, -2.678423784810047, -3.5506988011908187, -1.5440803535399146, 0.8721975565012836, -2.1659196601710993, -2.5374319987483807, -3.841213763002562, 0.13816840393933696, 0.15977314925769678, -0.030782910219257196, -4.090079536023296, -3.1418516817494377, -5.01640488597542, 0.7109216056314843, -5.310718052198761, -4.436607510567382, -2.6191019140153866, -2.149635866327194, -2.182160566919516, -3.153202590199767, -4.32954579325886, -3.7714662480589904, -4.396072571176848, 3.058344696098322, -3.885522025706004, -2.8556360944032693, 2.099797119136613, -4.561390183944725, -3.6928320231623726, -0.1546572886707169},
    {2.054011026895016, 3.1856564797984133, -2.494574567963798, -4.035985019050661, -2.646024871153352, 2.5242150558509566, -2.772612227477228, -2.985575280903384, -5.678774973407214, 0.9103804671301698, 0.34875185184894386, 0.19218869460147192, -4.108652793126452, -4.3477109030231125, -4.757207666127916, 0.536687929253892, -3.9683122547018965, -3.1419733360879305, -2.384576528193145, -1.939745586318926, -0.8051088915576883, -2.9790725707808474, -4.1523580485788, -4.951571387347757, -3.8050590077560407, 2.4682301411777887, -4.8258519569023575, -4.094578342728495, 0.8213633476156524, -3.280288271197684, -5.505258941337094, 0.026129485422264842},
    {3.1065110018646473, 3.12714226587309, -3.1436643949905934, -4.786496127053607, -1.5900486845071857, 2.5623897161407774, -2.4451232718116542, -3.5327559691927615, -5.068856607887619, 1.7624419748472167, 0.7211887598616865, 1.1635871870699734, -4.929499854086593, -4.297815932611383, -4.0131564369254, 0.8412501673903244, -4.153935816090841, -2.9255174366655896, -1.8994765719721143, -2.2767509282901988, -1.2839083503879112, -2.526779497838972, -2.5814176016141537, -4.076977590425205, -3.8798096420020256, 2.628035899743414, -5.224050638500181, -2.9361302964129194, 2.4478275794812845, -4.1654345954896925, -5.2523514175486525, 0.8215498133761119},
    {4.205203094364656, 4.672038450177188, -2.398727762288335, -2.9834900685734214, -0.2521713418764391, 4.167335971916083, -1.825749114762359, -1.9507438007791291, -5.079894253844084, 2.2122539576605065, 0.6508940587617003, 3.101640669769089, -3.454155040433981, -4.169721184352348, -4.541931514589664, 2.7171395131887497, -2.7879582858733243, -2.202455583376721, -1.0978083554222309, -2.6321450366675987, 0.07572968962658247, -1.7241660651619868, -3.6413498074278468, -3.5501944365250515, -3.227816879631587, 4.887775054529164, -3.917162285860739, -3.6820381729798837, 3.9436661242329745, -3.5192133715918104, -3.033216453173526, 1.4703527635327922},
    {3.0945034739834, 3.5764253976390097, -3.109370024731316, -4.341848684671184, -1.038526291790752, 3.953352753225571, -1.909706241085036, -3.5122275275657096, -4.621383198002245, 0.8335492358062008, 0.5158595741365326, 1.5420573873416326, -2.963419276102097, -4.580573560312431, -3.5774250321117993, 2.568204860404539, -2.802132394054262, -2.9768705329195195, -2.362610076636632, -2.0781531675140985, -0.8067705007850963, -2.4719711296632387, -2.1404475517526227, -3.9662922509131135, -2.2571593076543746, 3.9009970738615762, -3.508486258962212, -3.7802235610445294, 3.617240034445949, -3.025243819699907, -3.1696731561581166, 0.3121987322664559},
    {2.412738430687327, 4.140589887157918, -2.0968297412728445, -4.1996444597862315, 0.09151614336738421, 2.86644411631854, -2.2855931848604163, -3.3393654205859993, -4.257219371214016, 0.88128865214736, 0.6122675188122386, 1.1931647857943335, -3.938128695869304, -4.08759530834838, -4.7877545587752195, 1.846855658241914, -4.91505014137349, -2.7059846267041685, -3.4573444501990993, -2.372600870122244, -1.3465711295076863, -2.822263195713044, -3.1171897624710767, -4.630233980378109, -3.2762919165657256, 2.953922778513407, -5.221395991515796, -3.307722942526299, 2.2014362296361885, -3.904896674037007, -5.0094709847478445, 1.5490961108763344},
    {2.253261931187894, 4.116837176637154, -2.9393306215387276, -3.0952669209389683, -0.22628749176964888, 3.0673530295860445, -2.504760370317893, -1.0856782474280855, -5.497129635392521, 2.1578666278330174, 1.4472317233393377, 2.4329722843886765, -4.195422445803266, -4.036503548988713, -4.742001202794127, 2.396434798933042, -3.5001510465174968, -2.654282038024414, -3.168267534599025, -1.4907111188336724, -0.9288621800699909, -3.2733625522688343, -4.198458055248577, -3.908918850124281, -3.068031444231261, 3.9985971237455855, -3.5634008306300227, -2.2508590075746255, 3.9989092787947755, -4.276159102143857, -4.484518256957227, 0.04583895276717857},
    {3.1673370832899668, 4.386502346693436, -1.155517837210289, -2.004582681301436, 0.14667858536992806, 4.4483327443920855, -1.8036759029676173, -0.2786192670185799, -4.685643140300919, 2.412004386730773, 3.000584833700003, 2.707948388462072, -3.151298809617363, -1.5978437959555112, -3.7369225229568173, 1.730062113356873, -3.3273060808661823, -2.9811986067292837, -2.0832465776216873, -1.1728253412552694, 0.5588040612239834, -1.188096394739204, -1.6594516465868392, -1.9302943816914298, -2.8262633937583206, 4.680945925393926, -4.0822190260709865, -2.7707991087470307, 4.239184320982673, -1.2959724173525038, -3.352226915947423, 2.1545506389248965},
    {3.734168720256079, 5.040313251783059, -2.046005771557926, -3.231855074648646, 1.294468232754159, 5.362889347800092, -0.9770216088118724, 0.029563210390346935, -2.659990840095606, 3.008007332429412, 1.6139505045558247, 3.9162937305774763, -2.593943292775082, -1.596217105240335, -2.3722538763983767, 2.2097548663276085, -1.982864277187346, -1.550164104924749, -1.6258086999535628, 0.23870049665957124, -0.20684303474914462, -2.0034426642970575, -1.7279522264897156, -0.9441406203673876, -2.1727926449325508, 4.748806981433008, -3.4772387315314743, -2.4814378396811816, 3.1865467031959875, -0.6851903864831188, -2.5769080722401148, 2.4578677308080303},
    {4.3935921721747615, 3.885114172050581, -2.3323602627116258, -3.3198986051511046, 0.4370467232128727, 2.939063488470099, -2.4294994005571313, -1.0789140451348527, -4.404815736039044, 2.4091565552233054, 0.9748727405248114, 2.901010148132953, -4.0573725081521, -2.8160598991858623, -4.205009557126674, 2.6759908064261873, -3.398121746141483, -1.6847183257242266, -1.0779761514409485, -1.486927930243472, -0.7293697162690681, -2.414640587536296, -1.7511794284258229, -2.9132795445697997, -2.118167028461547, 3.6543180714900885, -4.567770586032475, -2.0143913910362747, 3.502864326831557, -1.7031491515524475, -3.356785102083811, 1.998030877721546},
    {2.7157307925183227, 3.198216962764038, -1.3364085114912552, -2.264478235384793, 0.4668834632250288, 3.6899147235924286, -1.1405449447759166, -1.468713475468187, -5.238742985739192, 1.856655363771064, 1.319890082609807, 2.7030530952827445, -2.832152901415463, -3.5181563308192274, -5.1505118790141315, 2.2269967306090654, -2.48710073162866, -3.320714130151616, -1.7776178026534213, -0.15108278067901135, -1.2060338228755472, -3.223239643082818, -3.5541331119239827, -2.267344058011698, -3.461899382447829, 3.8274966083965856, -2.995685130182909, -3.170672826449478, 4.078988577860189, -3.509059062492251, -2.8571454202984037, 0.8340037701204839},
    {4.005096159130894, 4.789568899771761, -2.366156977652489, -2.3824352636025585, -1.044754117913487, 3.5920525548125624, -1.2566096681687917, -1.507670081749706, -3.9112288007845044, 1.384555257442383, 1.7147134017237233, 1.8460226598391765, -2.595145125314291, -2.2618142809566164, -4.266765414402515, 1.9756115985330374, -3.262748873361255, -3.0571739202949653, -2.8264726088318786, -0.6599892478574996, 0.33534276787848966, -1.9797033768401398, -2.0472279437020355, -2.0253774888286173, -2.649911162268374, 4.970399314585649, -3.5367326696604375, -2.033290864055882, 3.2318555500282917, -3.5092848538528756, -2.654925896002482, 0.11944219128538039},
    {4.171682609719081, 4.073816163050265, -2.9569623782202066, -3.3939896717481264, -0.4161419262578253, 3.1918874063386715, -2.310608002739653, -2.5465854607317113, -4.265577371698568, 1.1473292381051545, 1.830415140560017, 1.3556238273083498, -4.113704404743506, -3.020971410574146, -4.942958001388543, 1.9657704564249094, -2.406095584774051, -2.482986384222436, -2.640044527874836, -1.4880899479606953, -0.9790664125966017, -2.182278250754279, -1.5337035402389958, -3.3418195294092246, -1.960968346750499, 5.359901643995409, -3.998285201504024, -3.0215279939057393, 3.1142755636408745, -2.6144717850549988, -4.373281905037945, 0.8016169958445343},
    {3.260318971709931, 4.914701239903815, -1.682326260961949, -3.5552069216274096, 0.43920590759442335, 4.373113836266874, -2.2154144499159765, -1.2362809111363247, -4.658891668179516, 2.2733689449316463, 2.6242244528461978, 2.5929979389996607, -4.271059417577333, -3.2837200669379527, -5.132805748968942, 1.2338702704690605, -3.6830709808043376, -2.37720994227688, -1.5194950952327604, -1.6507416970560058, -0.6398326320131541, -2.091770220373233, -1.8845846882076038, -2.76984013590233, -3.6847843261774993, 4.942249978694066, -4.063142506698692, -2.295562247539715, 2.996589700749239, -2.3325781280016193, -3.7467746529287766, 2.0609363391257607},
    {3.104601190810722, 3.2690303164190495, -1.7472393436447586, -3.836065429194053, -0.9507920693569584, 2.403588972326825, -1.7567430141821254, -1.7528700316575059, -4.961306396657378, 2.5006906050192854, 1.7800859702214227, 0.9583439347492932, -2.579989422902472, -2.8714853775104836, -5.2723860053592055, 2.680986866007436, -3.7582910641331133, -3.600619016573374, -0.9888686357784284, -1.8734631936512192, -0.38493655227760565, -3.2171502037939166, -3.5076228858443748, -2.1335466717750946, -3.2760490630545855, 3.4006003425843736, -4.257755024312387, -1.7241780343566242, 3.6965040298371865, -1.7013750146298778, -2.5953527804809133, 1.1385741620530336},
    {4.122330493373687, 3.929566836658893, -2.4829562801232807, -2.5226057287306762, -0.0152384564270739, 4.414251093764446, -1.831045978006878, -0.07152746779014475, -4.914864305098927, 1.6664853841507417, 2.2083124991277145, 2.7836515739747494, -3.899420805361564, -2.219281150930257, -4.074449464383689, 1.5402609807128236, -3.5326007870994123, -3.003830599471012, -2.5507319963991306, 0.08005712502155149, 0.12105108564373813, -2.6814929474117615, -3.0593907580418955, -1.6806778144316419, -2.519953481059839, 5.270408047025524, -3.8493605030891063, -2.63843182484597, 4.432442568284816, -1.42386686248224, -3.8551611953072666, 0.564130142454178},
    {0.517059577331062, -0.9740161581341713, 0.9858687040392645, 1.074537776730014, -0.2524544710890269, -0.9536777944344319, -1.3567370142319013, -1.8320168329516744, -0.3403542312053413, 0.4676125323744084, 0.2797755600718561, 0.8600255111269229, -1.1266174911294868, -1.226238411717808, -0.17388291532094405, -1.9251759707038554, -1.070045742650974, -1.353156608153855, -0.08182261196078697, -1.067214995532118, -0.33083486146898117, 0.3193435995041386, 0.2422394170840593, 0.07720579206617019, -0.6297812594280534, 0.09624482012995668, -0.25107317351338554, -1.2209317982976462, -0.7684436050685904, 0.891650438403903, -1.4447999663260882, -0.8355829162115053},
    {1.8575248179434285, 2.7505153200148755, -0.8344091837985936, -0.5633416817058444, -0.4768621074979285, 1.4366292399292924, -0.17925086397229623, -0.5314599608901749, -1.754979476792642, 0.5114140370045426, 1.7827195751945308, 0.23987634227535087, -1.6294216166527054, -0.8499692329580525, -2.509039905439309, 0.5374781887842247, -0.9765821820807886, 0.9885306587714193, 0.0741976516522914, -0.9197299068495607, 0.31974250019665973, -0.5266557434069337, 0.951641255527219, -1.5866657108170843, 0.15746350623577943, 2.5420351144236712, -0.8253429293531911, -1.1331132949077398, 1.3343993761953956, 0.29182507892000004, -1.083807185005098, 0.979589723346652},
    {-1.373840918876231, -1.5749043637874394, -1.4332145737145843, -2.66451759752807, -2.9989462294945963, -2.1831377210722316, -1.7937029511010758, -3.768148411629194, -1.1396713547596042, 0.11649431939526599, -1.69363409401187, 0.8918365243669181, -2.036369975131697, -2.4917115974736777, -0.9050559605289124, 0.40324579895662194, -2.9124003068772137, -2.083360489199405, -1.8781874813429897, -3.0402375081842217, -1.1045003880331434, -1.2173612119729924, -0.9381445024821123, -2.47863252926899, -2.416551242475058, -1.1583060941065482, -1.8303544272017649, -1.9281080358163027, -2.3417153716593138, -0.8828882981609668, -2.3551727507086393, -0.8030883111750691},
    {-0.7316497690908645, -1.9478035052247817, -1.868492572080662, -0.7015681362301075, -1.25996536722898, -1.3665946755424703, -2.664804624253149, -0.8625106439932615, -0.3150537015985932, -0.7649279421245175, -0.28508060991032486, -0.23970692561238197, -0.2909221727476047, -1.252582121984673, -0.36874216030497614, -0.13651128753030686, -0.2586341896538016, -0.7332854078577133, -1.0032551486449675, -1.0687067247883846, -1.3507370624341948, -1.9265229727300486, -1.4720684438750185, -1.3542910903314833, -1.19763248696445, -0.2893857691656902, 0.5435769154722334, -2.2947657662876435, -1.7193465643920387, -1.2200028764480584, -1.2046318018088211, -2.0740192053887014},
    {-0.4093419065525784, -0.5762044116959599, -3.604867684201871, -1.7820894762406179, -3.387079786183173, -1.110621203343029, -3.913138407847566, -2.750817327261193, -1.8539154769608022, 0.7478316972208308, -0.7841813555509275, 0.7888755915154705, -1.5400742673490488, -2.7382562896545815, -3.6020984451631666, -1.6855162619641213, -3.4562355905854996, -3.41243949682018, -1.473961114639835, -2.5644380251075503, -0.7619587577911158, -2.4395081073668137, -3.388176740813596, -2.7295899587459957, -1.713158907226931, 0.7699498541693521, -2.4665511234328488, -1.0221520557883064, -1.679910790491178, -3.296671877832309, -2.999320349090584, -0.41862444870820714},
    {0.15973625773951872, -1.470941275793149, -1.9112751047889895, -2.828249729251397, -3.1347141360651176, -1.749078737891342, -2.9235817516465086, -2.3757265066223123, -2.2273913633972313, 1.400692776231831, -1.035203443743377, -0.4717754978317183, -2.9973069293707337, -2.9606494675678534, -1.3625813888056784, -0.05589196620156839, -3.0745773249583856, -2.187419450531662, -2.6861629849619235, -2.029352744022564, -2.1030606525023794, -2.824514110840251, -2.8718915035001773, -3.8303870549560886, -2.453812136173777, -0.11756195852701248, -2.0235719465238606, -0.6912188458036782, -2.1769739013644784, -2.3129081574146824, -1.003678824020732, 0.07640840797862379},
    {0.5254568914751967, -1.62175469217224, -2.899924323723859, -1.1031788190283303, -2.892300357425864, -1.4783235583028422, -2.9050354608793407, -2.4849249139396083, -1.8265969465846459, -0.5937368953884529, -1.4285000215571158, 0.19385635737318654, -2.682425404132868, -2.344189544531964, -2.8778534054178637, -0.5963589025480158, -1.386575311148705, -0.7173313501176969, -1.305712651648645, -2.6275509380601783, -1.6048967837761334, -2.441800380682138, -2.07237200768653, -1.6061647006548934, -1.2197739584834182, 0.6921349125387272, -0.8497407292336584, -0.3509115265212704, -0.23428284450934456, -2.5802063299923716, -1.1870251610885791, -0.9587207793356232},
    {-1.1873738887513876, -1.6327754977610376, -2.2085348869733887, -0.4283699650960125, -0.4887856315697361, -0.3272872710659654, -2.744622622730172, -1.6754440345609125, -1.5205352120520426, 0.7390050182991464, -0.03214832225845514, -0.9301914706635175, -2.9662098088417777, -0.6937510032958549, -0.3583876296288672, -0.4934794992677436, -1.5049544587238737, -1.7467680718626484, -2.2551470173688877, -1.7118801988015433, -0.7431550575179107, -1.8730065200290644, -1.232454535452188, -1.0267564412201913, -1.6175548208931472, -1.2617181176732788, -1.7374075332195116, -0.8298266341091081, -1.8952459788201725, -2.2893838415422576, -1.6827699319742833, -1.9688087468298814},
    {-1.9405684187596823, -1.1897350518571075, -1.8795856069870114, -1.5679270426821745, -2.9362890385071663, -1.2653240268721673, -1.2957542915364164, -2.5614934437331676, -0.8278914837892195, 0.15365275787462812, -1.4000252252096816, -0.836999032307848, -2.1139886950080626, -1.936964593589804, -2.1545662366582046, -1.5947364808337199, -3.7438402479667965, -2.3854722996062705, -1.6000454088028326, -3.331441408332932, -0.6068960373696957, -1.6197955681009462, -0.9422092875528815, -2.110495528402202, -0.9303765971365867, -0.8079232197330004, -1.5856604330158375, -2.1507726632894735, -2.572810936855544, -2.9269665424725844, -3.026905343087418, -0.7064632161617271},
    {-1.5951199058924284, -0.37740117455396976, -3.3048730525793184, -2.266428947440315, -2.3839403597052757, 0.6310029682335547, -1.454228879777147, -3.802225081277106, -1.418059430274014, 1.4191567897774149, -0.1297994419813548, 0.12063218820701345, -2.3372116340687987, -2.835269702336834, -1.761432179215826, -0.7557643796985893, -3.748328117213754, -1.5428702758485375, -1.8619645502672484, -3.3678186078045793, -1.560271699325473, -2.3470555762713485, -3.1165099969263106, -3.0932734765299434, -2.607755771689059, -1.2057469596058117, -1.7522918029049979, -1.5446574738733876, -1.8894345680755225, -2.330627662476028, -2.7825814391197614, -2.5208216754500388},
    {-1.7519272721528953, -0.2736467373924366, -2.4952580999581615, -1.724176728954731, -2.3135097526932977, -1.7996384009988788, -2.746898056377725, -1.5861327548421384, -2.1499547430737933, -0.7969602131819318, -1.5463197364173196, -0.5775002539293334, -3.141836375241124, -3.340199599493522, -3.0675680986441973, -1.0327036476801257, -2.8487991488138835, -2.974697510417468, -2.0543378973601687, -2.2682080025786884, -1.87381257685048, -1.6748926312948031, -2.1062152260714613, -1.6591557853599026, -3.0705642068321843, -1.0891905260369805, -1.2649453094632082, -1.5403424722512566, -1.284729657794143, -1.9948233966182551, -1.4155580412123814, -1.9985998274254682},
    {-1.15535193396103, -0.7964330567115929, -3.3618259947820657, -1.1446440725509155, -2.1223824929613353, -2.2040761453938753, -3.7439046239336315, -3.8983313141902665, -1.0686611921557476, -0.43120766906608166, -1.1667831118538194, -1.1312148858473803, -2.4601365789241836, -2.4676081869324102, -2.3045360998884488, -0.7244142312065825, -3.784673823347837, -1.5428259447317305, -2.352834267825813, -2.0574185761649573, -1.650032745241756, -3.5818509711266637, -3.1147618317432992, -3.194684399771441, -2.042294862612656, -1.4726422227365075, -2.6363750484234054, -3.058319818179532, -1.7911265589128422, -2.1075408125332884, -3.279929914975471, -1.4894946219180765},
    {-1.1429228921080172, -0.2396557196236421, -3.461881475362244, -1.5972819598531955, -2.5547231918626143, -0.692385181764084, -2.4646386384453103, -2.813862305980442, -3.0939974714220506, 1.4561894675433176, -1.9829687838649996, 1.081957597375836, -2.5925909434186245, -3.639440701671763, -3.1581539998511303, -1.4639305275592263, -2.303164998159047, -3.1153349529889547, -2.251308653666255, -2.2216364133465385, -2.6669604415451538, -3.9599226571389354, -2.454265053924346, -4.006863524927851, -1.858479895636706, -0.3429723505441026, -3.3816196248213277, -2.03566311887866, -0.7012239801449767, -4.021950996068379, -3.4952462164855946, -1.2143694097385287},
    {-2.0731794272487516, -1.0556344207289594, -3.203613964323292, -2.073699840265097, -1.889080401345365, 0.13267248743713903, -2.724596638664879, -3.5056008938212515, -2.785171704443296, 0.13285167737896603, -0.2515003570841131, -0.5999731675871905, -2.2016729761838203, -3.1611323229894843, -3.196856101255851, -0.7924189850141111, -2.1478344531294797, -1.8268553588446292, -2.229318760440878, -3.6373397928534312, -1.9813683772160966, -3.5750829039163317, -2.357417918441298, -2.92361578391307, -3.836249239166366, -1.4544647975051153, -2.2997223449889006, -3.4694252343269696, -2.376691530079874, -2.2317593517313297, -2.9704008687621926, -2.551581743223285},
    {-1.1879181100735332, -1.02340933490298, -2.6407641442954835, -3.9831570180213443, -2.489762445034061, -0.3933357631471881, -4.043595268866012, -3.0712187644759372, -2.3738570356802833, -0.912703431399605, -1.3767631274272611, 0.6741872804287734, -2.5167217641335475, -4.073698403669322, -3.5623804743030076, 0.22631666227495403, -2.7792237311936634, -2.1749779024101796, -3.515815939590619, -3.4490959098370064, -2.244045813525731, -4.140711389104289, -2.776858668409535, -3.6262595350908873, -3.4695073063476607, -0.8124364103570348, -2.7114142639949526, -2.2704300490208316, -1.5083200191465889, -3.23772325208447, -3.084261207810708, -1.0005957456323602},
    {-1.0047653594266475, -0.5828471595212237, -3.9486306669519333, -2.6664300828618566, -3.669586400113963, -0.7208710155348538, -2.462099479376042, -3.804740397255272, -2.774588580110374, -0.9622502413036789, -0.13233096113726767, -0.026217465555652075, -1.118417685494193, -2.1563815518032015, -1.327817675066057, -1.0022835613175045, -2.915777285460316, -2.931389368803623, -3.2181501314083563, -3.9490018360000314, -0.7114444958820275, -2.4834153280163416, -1.291631842407868, -3.1733762529490384, -2.853290769829073, -1.362418454974772, -3.3606661837453182, -1.3152310261935922, -1.540147033358558, -2.92181649965474, -2.534298618388626, -2.270166211946482},
    {-1.5723485044262586, 0.2354022148982076, -1.8048775258458851, -2.864488153738227, -2.712038164526161, -0.7189961093851189, -3.2587465297852316, -3.900918097315633, -1.9152069716618112, 0.37935018586187413, -0.4146188169098889, -0.06466983532228723, -1.5791506497681438, -2.3656255096889245, -1.2104012042240029, -1.4531390905164203, -3.291945476432447, -1.7350231208922184, -1.6300136706057855, -3.2979547305303494, -1.1699619505000227, -3.37021199318643, -3.396479599272052, -2.881344166878112, -0.838924058493528, -2.2810317841039, -2.6804783944671478, -2.8849193282821517, -1.7154528743332331, -3.0219843436972074, -3.145314440145433, -2.792108378902639},
    {0.1064324407894045, 0.8781481552029234, -3.581993452049993, -2.791442981928452, -1.6302820909810865, 0.23726031871643902, -1.6746655102622534, -1.8354101651801886, -1.178718956891855, 0.3152366155015775, -0.5892407304812233, 0.10858384272550313, -1.071102103246844, -2.8933685330675365, -2.440840049739539, -0.5056221130681497, -1.5555350186560186, -0.6567076854072122, -2.7648224718870638, -1.4594569227990932, -1.6741422653588787, -2.243755783999568, -1.2064985222717066, -1.3948627346370421, -0.7622592482841848, -1.134973229940734, -2.0978110396132963, -2.420499127353015, -2.4552193334570953, -2.9421849500576416, -1.8742134440079525, -1.7577707495905903},
    {-2.587644557716537, -0.7369806029555065, -3.6468954733283856, -3.3460639651645834, -3.1668928152850193, -1.493936850672808, -3.4208584647469915, -2.6532030760950263, -2.4964798730292377, 0.7501746617884996, -1.7567355968896299, 0.5633694702259684, -1.7805707678169513, -3.5838071415818424, -1.4303379211758052, -0.3620393992055189, -2.594434658844682, -1.946447253597955, -3.374648209471216, -2.4127782899341845, -2.604083017897518, -2.907318175516224, -2.8904174073437425, -2.394411435786197, -2.9413950281093504, -0.9413227010046628, -2.6008381331130654, -3.1520095486409168, -3.7332673474602522, -3.8227096448050264, -3.952650425089993, -1.7901235921814296},
    {-2.1652586662075466, -0.8086942983028604, -4.414801509351193, -1.8698809675590589, -2.877021773258585, -0.7729597592443775, -3.1260450015375194, -3.8679177853794284, -2.7070444484441416, 0.7493345907096138, -0.5276648375994369, 0.24436504510092108, -3.056699461982564, -4.4214405891111825, -3.5325452653585434, -0.43775849834758235, -3.6619672259926115, -1.817255753419808, -3.958610028754604, -4.262594780167241, -3.2040400355403356, -4.327595161813129, -3.5289730238694164, -2.419019612322789, -2.002333960878654, -1.8536247457715616, -2.2680436801822306, -3.2692068888809516, -2.3971632784557597, -2.774839286339658, -3.9976976281824856, -1.9454149449736928},
    {-2.2478351540372086, 0.08132492499939815, -3.356205878768154, -2.2856697395073424, -3.9731364799119713, -1.9067766889108448, -4.525562910289994, -2.776498326191246, -2.5877417974455112, 0.4680368485913625, -1.9826537090059726, -0.7844320068311006, -3.617950371387262, -2.440338876338269, -3.1324530565101627, -1.5226184245826508, -4.200116022598213, -2.2710701576896333, -4.106820333190847, -3.019419645892167, -2.6961575602155308, -3.7095100890375874, -3.0817309983560186, -3.522849958482131, -3.3518356701365017, -1.0863920241666154, -4.2562881343990435, -3.132525089549133, -1.1799172170896088, -3.4824104118809434, -4.04190009217265, -2.008733371594879},
    {1.6326279174756386, 1.2530388193877258, -3.472584992380167, -1.8879008752193702, -2.636405365858246, 2.2316143802082946, -2.083711272431321, -1.8503682740813485, -1.5124509695701516, 2.612254111477465, 1.6353004701268241, 2.4407262503070593, -1.5886499190872598, -3.088322541692904, -2.587292677271684, 0.5098161948708843, -1.9777365589506084, -1.0468258651780928, -1.844038085900377, -1.6015878689100156, -0.26103942523648327, -2.7709179611925405, -1.2157976499920427, -1.134059683017691, -2.5149525029792303, 1.6999843825035756, -2.369159905311264, -1.0884017019593968, 0.5555814496735635, -1.3000053970519931, -2.1597569453117527, 0.13898487891122555},
    {-0.09809628130985955, 0.8037455072817609, -2.205478391197635, -1.5253545521979823, -2.294565110663815, 0.44778119340540024, -1.8754581970062063, -2.105315918505052, 0.0060152576614132406, 2.072599424719558, 0.5307106586083136, 2.8030206461093172, -0.9786301365811025, -2.968088066366279, 0.12950227809163467, -0.3711156524970307, -1.5245728507934337, -0.5978502094201342, -1.4524336289365958, -3.153542216767572, -1.2395709558395254, -0.6730648451417259, -0.45768804324145396, -2.635719826399433, -1.442245493839576, 0.22563149089140716, -2.4103523690318873, -1.1097212621087924, -2.3030888489342733, -0.7231442373085283, -2.2293488928699596, -1.5257403702287902},
    {-1.7604841624301815, -0.7415877783097725, -2.878669034160355, -2.2944803400670017, -3.900017773710914, 0.38628509979044146, -4.091977669679625, -4.87488756138014, -0.6887805526234915, 0.722322563321147, -0.2607875259607654, 1.4062162646791856, -1.401310753026246, -4.129073287045275, -2.0979729611709326, 0.14519880114891762, -1.9124733933711435, -1.2834785039235124, -3.0357362361223514, -3.3441443367188795, -3.1272859844765555, -2.10824959709743, -2.0114121367902063, -3.565473837791395, -1.8087893731136244, -1.7058191974616785, -2.809323404312055, -1.8417250895710187, -2.8775710722126466, -3.221323173231629, -2.9592942093906105, -1.4590547471162008},
    {-0.9286457246693024, 0.10067812857717204, -3.9765826469228323, -2.703881462573499, -4.730603390446144, -1.7988066547695951, -3.680455181252564, -5.167535252932582, -2.553859253863508, -0.16410605685385796, -0.7034955034933629, 0.45457468034734677, -3.0158767068871244, -4.719824642073917, -3.8205446139215287, -1.0588588713193252, -3.0619663978426397, -2.983113192225682, -3.424666024290567, -3.2222367349829852, -1.6230755924514169, -3.719132106619288, -2.3581884371308948, -4.345886525604707, -2.709294862851491, -1.3964068465112458, -2.7364056534010555, -3.30820490677423, -2.5821608278415797, -4.205859866141148, -3.8373136721248233, -2.8383206220613175},
    {-1.2512322358383594, -1.180217280850079, -4.309435184957408, -1.3642411426779766, -2.830461628310468, -0.8533240184353129, -3.061694654503986, -4.239768937514164, 0.12624736733178835, 1.757505020866443, -0.8215014030808907, 1.8487588761882274, -0.9729862019335822, -2.405250089874225, -0.12379488482934314, -0.9022796853985778, -2.6557166666125185, -2.6568130902866107, -2.70526812392906, -3.361314225209522, -2.053122108234227, -3.0298956182980397, -1.2020121387482756, -3.6094979758348944, -1.3956828749722792, -2.59606950245826, -2.372698838595232, -1.6668027302664683, -2.424487373806706, -3.0436216823166746, -2.23495960677449, -1.8842000071757128},
    {-1.4604696204275278, 0.694437132801695, -3.431159391790168, -2.7290351857183364, -2.3346884252591713, 0.9170191282777311, -3.7167098228489, -4.05615901153174, -1.1335876374029001, 1.9515309388282949, 0.5587348505555296, 0.8502090155947041, -1.394413978217241, -3.7903213318920383, -1.1789848382571708, 0.4051987781942846, -2.419577074129908, -3.019922520749589, -1.8224224885944067, -2.380478944949308, -1.2362893023433232, -2.2386887009644743, -1.476010167476646, -2.4061620850925176, -1.7980116300790183, -0.8422509690202712, -3.6164384937396616, -2.456335917438856, -2.0225813891902567, -2.8973216526806933, -3.334143442166428, -2.365822566518655},
    {-0.9204451384038279, 0.48876463166392714, -4.500659116574363, -1.8519710726720842, -3.9111777083965595, -0.14788726902022928, -2.7183126183127495, -3.0325982178038795, -2.0411119905553523, 0.8592581024408467, 0.23900102500502937, 1.3422298924236686, -3.446161435327397, -2.943389749090753, -1.9182217026629063, -1.5437221548948636, -3.7496009229890257, -1.8613802462314117, -2.728723056682038, -4.634784930241748, -2.088086345877051, -4.352335863850098, -1.9129529453683427, -4.10977925193418, -2.1693130293331304, -0.33448621396309514, -3.112126471271125, -3.187080750192256, -1.789134908567815, -3.176048138664402, -4.279858426043741, -2.641982678279737},
    {-0.3135553219826057, 0.7856552354936102, -2.5729829390267227, -3.2089496464102063, -4.09522964964483, -0.6606177519696413, -3.3869243109729124, -3.1018234845618604, -2.8154799249982125, 1.5744459645012425, -1.3367250038359497, 1.9166622499785704, -1.535281107474161, -2.761493155794938, -2.4984323197132823, 0.28976872139887777, -3.758136094106544, -1.7415550620035356, -1.5825734105203737, -4.18804836142845, -2.424175699333081, -2.1964167576828633, -2.4077415093941803, -2.9162632500829186, -2.6960706046617977, -0.9614240997271517, -2.4396511178188063, -1.9102910006874523, -2.9416795504666027, -2.1996789770512595, -2.7961453199325814, -1.6706152334239501},
    {-1.247142071637062, 0.11851944991333535, -3.802580392409099, -1.9420255282798022, -3.3358320775887096, 1.351903141882088, -1.7641727683095179, -2.924803444867637, -2.3066683601381133, 1.057371937403825, 0.5480056473824882, 2.0758102737636848, -0.6445234765721644, -2.0521239565961773, -2.244693196543015, 0.9042515759627298, -2.9400639981809924, -0.8968435311999777, -2.1111629486154286, -2.836780026420782, -1.4171977943520457, -1.595031381143855, -1.6103941208619301, -1.8149811187457474, -1.173488513944928, -1.1767148784807824, -2.496033222405259, -1.3522897370606504, -1.7360462547242161, -2.475679669656198, -0.9370605488399375, -0.4035934841576192},
    {-1.3780505591119196, 0.7217828767103814, 0.3095137376407738, 1.9793232533020788, 0.1982651939377351, 0.2774663678567356, 0.6887652118935009, 1.1889739805789823, -0.5854305214497921, -1.2817124161155726, 1.9869812735421795, -2.2307694996701075, 0.2411911884552658, -0.3694851744733913, 1.008089163357959, -2.908366092947256, -0.8028562073793637, 0.2744869891813077, 1.734570842089289, 0.9445806523876515, 2.3745081893828472, -0.39055571047926163, 0.49855548774970726, 1.6769928438370278, -1.6474446997410166, -0.47085054721200015, 0.37839065760174123, -0.16395204727596407, -1.0298208775107591, 0.34321999823382465, -1.9374458578919784, 2.333484115038299},
    {-1.2639852153037168, 0.5978067776801167, 0.20411815810921452, 2.1284714357741072, 1.7290217700447534, 0.9129961265240657, 1.5320596561155644, 0.25635338900873544, 1.2998148213453806, -2.003889390983086, 2.2553279126354693, 0.014732241359202914, 1.8312431938395586, 0.6900167894643949, 0.8077193133826107, -2.5816175860320447, -0.7923432967020293, 2.5511772443625444, 1.9555044601484126, 0.37680875627605387, 1.6183564459125048, 2.2890735823560804, 2.3441913041708746, 2.059431489557928, -2.0054201019012505, 0.5491147293698696, 0.6157765382411966, 2.034046156567972, -0.7882659121657324, 1.46370574556036, 0.13621677633631754, 1.2359708807001613},
    {-2.7206193223526225, 0.5182220656196306, 1.6155515573527486, 0.8885994164992278, 1.7678651589093637, 0.9661140391766171, 3.1625882483639334, 1.6566639748993692, -0.2218858112062334, -3.4651475955840243, 3.057483188360217, -1.293887078408349, 2.9506764442235554, -0.4336816361740962, 0.483111466349546, -3.731101191197745, -0.9884083867955256, 3.4095931117788876, 3.1854866935377406, 0.7027934355022313, 2.3483894313230733, 1.6639538532854448, 2.0015664986974517, 1.5201060498080343, -1.3784968215184081, 0.5799414467330755, 2.0092707761893926, 2.3895707742882877, -1.7629760119162086, 1.5904618490055047, 0.21463559994749926, 2.5884763191638305},
    {-1.536117690634294, -0.3978637177024956, 1.163675274060592, 1.5332192635181656, 1.982504400507437, 1.2832679674478598, 1.750515167847432, 1.0600001963162313, -0.39415851021068365, -2.028233897179394, 3.0144432481649037, -1.588993997165557, 1.8865200038295633, 1.2264550833077368, 0.41080123115151085, -1.403055573065775, 1.6019665007570532, 3.151688512983582, 1.4822717462290893, 0.5657492198279747, 1.9913273493813513, 2.3523060579603103, 2.135816335289687, 2.219519238256823, -0.8437960416019173, 1.1094669138755109, 2.3274925682151344, 2.4883041803194943, -0.5240859602722193, 2.443957385616806, 1.157465487591205, 1.7151578761929558},
    {0.454908030317183, 0.4229711771981363, 1.9701588605399323, 0.48110622041715906, 2.2309734408337283, 1.4954240584509977, 0.9690349767879461, 1.1478606954608894, -0.2138287518025666, -1.8921267416281453, 2.8422626657714605, -0.5821349985188524, 2.010080800324369, -0.27886800416713753, 0.7061337640919455, -1.2055249856110906, 0.8274575931071064, 3.019113347249923, 2.257937366393563, 0.6338096491359249, 2.7458689037024056, 2.2137061352286893, 2.1698797479414287, 1.365378930007956, -0.496782020445871, 1.2421766785916717, 1.0462548087767163, 1.644172738599903, -0.5043153736793043, 2.6999365764000762, 1.2914726454338548, 1.4282824627570763},
    {-2.1163722763391983, 0.8716108767787687, 1.270613238026214, 1.373002742826101, 1.1039036914608988, 0.11445690407058498, 0.908450334619364, 1.4046237796842451, 0.6606457241144832, -1.3132833540338107, 2.8257284698998735, -0.7489182033166326, 1.8011637936857454, -0.15713276126501236, 0.1674691353368357, -1.5666522797704907, 0.9740140385339915, 0.8602917567543974, 1.8773623426883244, 0.5132562118266552, 1.9776207217120254, 2.1891130490895585, 2.6534839661489618, 1.360258331489743, -0.7842698846296893, 0.46760114164801203, 0.23917090266782548, 1.1735332455888576, -0.7396487860977906, 1.2054181834783197, -0.46981604041036945, 1.0282634594825542},
    {-2.48719294221819, -0.3128110976917199, 0.6287730830714058, 1.7657756937240898, 1.8315749425086996, 0.5041336076393319, 1.4232213304522496, 1.119944576581968, 1.6122732133307334, -3.62194505173745, 3.1857576534986225, -0.9756493555726617, 1.4958205744802964, 0.633870614868974, 0.21560459148246777, -3.716404609581498, -0.7115093102964217, 2.4866736802611324, 0.7249865317934387, 0.40489900468102746, 1.4692638013331205, 0.8858385436526643, 1.7041893198741414, 1.2931290677411107, -3.000429072837861, 0.44386943101838766, 0.6415271476028448, 1.9097871890667588, -2.203760696478968, 2.5518002633680714, 0.186418423744674, 2.3416734012616476},
    {-1.2769802311799328, -0.3350226568545369, 2.3114229787575784, 1.9559170335513354, 2.5172081691009294, 0.43654789198528465, 2.8193138080875255, 0.6177644861566162, 0.5135144622975193, -3.263577067323051, 3.4234338079429767, -1.7580091594800007, 1.3773234082410157, -0.42134592861553943, 1.2404405702653933, -2.880556923295499, 1.1003111171887752, 3.0371796892676315, 2.46244546018272, 1.0020470584045953, 2.8220063495477854, 2.3209587092318493, 2.9205366841688645, 2.176367496970084, -1.2821495491273776, -0.38505062309153604, 1.486858770926501, 2.0845581389356855, -1.772447488410909, 3.0512348630195802, -1.545530581391307, 1.3661373224163404},
    {-2.5118701900614537, 1.1398297461383935, 2.5203853296657774, 2.049844658047858, 1.2958846488450737, 1.7118851692402932, 2.3916754785412415, 0.29068688844257, 1.1664323755771147, -3.797633841618437, 3.4315569386321, -1.5094354547041229, 2.962614588777102, -0.9087699710802506, 1.2346064756556367, -2.8708882672230387, 0.38628725403946795, 3.3971760491938157, 1.6164241928053324, 0.24089500269868455, 3.3724575971206354, 2.0473465665080335, 1.322352939696272, 0.6278984472493228, -1.8110191860511518, -0.4798261258714323, -0.10517833987987715, 1.9723079934907872, -0.9771555565449941, 2.302695005594291, -0.29782766142598954, 1.9255139164879038},
    {-1.4381145968916718, -1.0651160618707856, 1.0028044603460364, 2.7323173096987294, 2.7176314061475977, 1.1017869825126454, 2.535357335633441, 1.5859384997299883, -0.2050672978902741, -3.54795555690955, 1.6912234794040508, -1.3579818947382327, 1.339218160205663, 0.7149346968629658, 0.8155484146326907, -3.4712162194542295, 1.125826340672944, 3.380996320167609, 1.2376048194606788, 1.705213150316639, 1.5546129217703883, 1.24484640614347, 1.1998828672069437, 0.9538316306693972, -1.2667207143494894, -0.3553396437893753, 0.530134084865632, 1.6964718415475752, -1.66742238601037, 1.7151327881628815, -0.10466066794331592, 2.0568643187352813},
    {-0.5468715844282579, 0.2648105220187891, 2.0240010684949343, 1.4631539590566227, 2.154186679978591, 2.6207696947303036, 2.1668645050499924, 1.152718486399596, 1.625159637849022, -2.141448695315803, 1.5685305441130732, -2.5871931014411405, 2.0008062409916185, 1.2205535512508268, 0.4317022431490597, -3.504511145759215, 0.9213299822629339, 3.6449288072374935, 3.566807454520351, 1.465570488555505, 1.3153707175110638, 2.1437606643474814, 2.6796444856380472, 1.2616389214938437, -2.4547500242532982, 0.7579077033851365, 1.2567382995794079, 3.092532779196381, -0.3895664838273587, 2.584546367181199, 0.2514796587675433, 2.353817380681378},
    {-2.1701406067836206, 1.4204539103341116, 1.6363458583823483, 2.445444007542315, 3.144935266436328, 1.8843743920685518, 2.4375529005473, 0.79309848644798, 1.2889670338466053, -3.2392333392996893, 2.2006491883631143, -2.1447895457350725, 1.960708733715679, -0.461048115513354, 0.11333987467756024, -3.400128866851228, -0.6170691979814155, 2.253272070952876, 3.232065245909083, 0.6049844923231033, 3.710403183157169, 1.4253196281334752, 1.177884602297842, 2.2657549395358196, -2.681261599161935, 0.34586792691636725, 0.38700218501501116, 1.1335146811978538, -0.038477945048700495, 3.2141717380074524, -0.45941742639872635, 3.68206220505618},
    {-1.7034538942526245, -0.9307747353203776, 0.7270212415330762, 2.751855167115439, 1.513999980941648, 0.6127404238170305, 3.0248020526634556, -0.38632341852677754, 1.72882549851249, -1.989579378953836, 3.2229157444765786, -2.5210174430383736, 2.3384613468540647, 0.9159731082893741, 1.8907553607163927, -2.679117414494695, 0.04129194116798624, 3.5519642747914815, 1.525477265767017, -0.21030654036684518, 3.063040482097942, 1.0099191206075084, 0.7286705255555017, 0.7475134120287807, -2.2220660715595084, -0.8453115786565414, 1.4323974269587416, 0.9269666028317172, -0.6833388739425957, 1.8021646328288357, -0.10117076446538471, 3.2386245885992038},
    {-2.067655247983806, 0.48151392625867284, 1.4242049464355881, 1.9076588933521699, 1.6948606299642555, 2.0589227377147283, 2.256979868968699, 1.792941639425636, 1.8252252425788755, -3.3876416106189646, 2.2212514687021643, -3.3468282371459273, 3.4206414862575394, -0.21555166825415265, 1.1806407975614626, -1.3663703038088033, 0.6051114977843655, 3.3393112986788065, 1.5731430114850262, 1.7513445439354982, 3.8176580664175024, 0.7797974057126756, 2.5569034878122308, 1.923496422407801, -0.20809735063276538, -0.3890656837431503, 1.6356913141268976, 2.652098338142582, -1.2501515334804294, 3.2237841711691244, -0.6437863733576964, 3.2764786908917425},
    {-0.6429231092547445, -0.7039775244741381, 0.8378361030189381, 1.702422521865787, 1.0026076750225665, 0.6925727837305501, 2.0164686211192917, 1.4732285587484575, -0.6488091177686302, -2.7706897957932215, 3.4970308313526117, -2.2869123061900654, 2.013375508751203, 0.17981409187252728, 0.5659679708238329, -1.4642888953824413, 0.4474948814968722, 3.0490504700015406, 1.6186643326919157, 1.0381694820983285, 2.8307354848916972, 1.8221617829830685, 1.8585905239102565, 1.2768355271874592, -2.92302572459335, -1.118684858240669, 0.19436555334891784, 1.408023457764112, -1.5330647344701187, 2.315492875513491, -0.8587506778391195, 1.9995557367807826},
    {-0.9892556016700973, -0.7012388744979889, 1.4226179784368593, 2.659155766920581, 1.7970129972107258, 2.0821572972244993, 2.712159574354339, -0.045368293318927964, -0.045175829626280806, -3.841365740546545, 2.695613896744307, -2.9893867032998847, 1.3175747245188922, -0.05245596116035881, 1.093157791151204, -3.1175767801149092, -0.12771688603569398, 3.7240790314449455, 1.9218809409313535, 2.171436715363927, 2.472014099959404, 1.0622538703613729, 3.2463193925383558, 1.3656866148175901, -2.5129901367446026, -0.04812881198350047, 1.396951809124071, 2.4978774844664304, -1.751646530519724, 3.078227005091971, 0.28529648132498386, 2.560009228405187},
    {-2.468999264294719, -0.7220350648571359, 0.7521188472085034, 2.572459999019436, 2.2755614186799424, 2.370025200634077, 3.2099999442259612, 0.35847018550401144, -1.191839272038523, -4.389505467540584, 3.7823929737308917, -3.886140482908088, 2.141813737135086, -0.3771378075293633, -0.5951388969710955, -3.6898942705656017, -0.5616777073860671, 3.814634893664742, 3.104881877564461, -0.35655970467509246, 3.3902257877217905, 0.7614521621802027, 2.2356063045841714, 2.5583368984316683, -1.1224229773662528, -0.3526348801513397, 0.5984391231821807, 2.665563285270216, -1.121481332338995, 1.470839442363777, -1.1446288247073477, 3.573386183175923},
    {-2.0896726207290777, -0.5472508333556432, 2.4664396838406777, 1.2341950748087893, 2.8127291866792383, 3.0560978699609898, 1.4369190736126063, 1.1238885647226011, 1.3059788712576113, -3.5276911783524407, 2.6128362601746775, -3.4845876934533093, 3.2844823850494063, -0.6424106914245369, 1.1637325183628218, -2.4776350422123987, -0.35456084741186417, 3.8272580387520643, 2.7535315753473237, -0.14179688801768126, 3.978244066810236, 1.5867770422303507, 2.4741321467488433, 1.6166632980684101, -0.8221234230416733, -1.7023744060566508, 1.9719677767370387, 1.9593962432320513, -1.9639655435964087, 3.273531401973159, -0.5571562586444758, 3.753542483084356},
    {-2.198408085107417, -0.7095727947408323, 1.131430727229629, 0.9057888604536273, 3.1875634891718936, 2.131267839691009, 1.6500075533172214, 0.5909173165676485, 1.1863618836305359, -4.133869671010405, 2.7099214237865934, -2.184201493792955, 2.961191417614976, 0.9057821050542967, -0.18915026069622154, -4.280566530018522, -1.4753163119555162, 2.407406735563618, 3.559316608917554, 0.5412469430492286, 1.9228750429065204, 0.8208970186965963, 3.3952353814702225, 1.0836521573076563, -0.6755670755568335, -1.4388562121143156, 1.4311535131600044, 2.5855342649638295, -2.66844517036135, 1.1544968273806984, -1.3373954397839536, 2.8443661777157807},
    {-1.73491175055065, -1.0965734005786436, 1.1675515070169575, 2.0436552678578503, 3.1296395532788783, 1.3972148003649871, 2.88454158912898, 0.15061049407303775, 0.694277300232116, -2.5276424514500553, 3.0572818995425046, -3.0186845705882654, 2.837912669623423, 1.030412208060788, 1.3012055835362037, -3.8813863179888477, -1.05616391126461, 4.246788328757941, 3.6915326104743684, 0.9920883368412536, 2.2418117776421194, 0.9488975366052311, 2.4886275295832845, 1.318195579876138, -1.9429921888104065, 1.0217784417985862, 1.0251607237643547, 3.1945452435159676, 0.24711300864254088, 3.386115337992295, -0.24856094282675434, 3.9508565174376513},
    {-2.088543738406054, 0.7622305068557677, 2.224176386227662, 2.542984489694695, 3.1025390071684313, 1.4439302520447213, 3.568277813452839, 0.2918134939838221, 0.8428969682414507, -2.0336805146230934, 2.1866444255881112, -1.3585044758369647, 1.0465672939816444, 1.5369150500784305, 1.076472521141545, -2.951612304224333, 0.26034785777312186, 2.7102427695876834, 3.383518548615384, 1.5890380224341187, 3.1667692695702723, 2.346398337525311, 3.3887229100876737, 2.6771289101447278, -1.7464629624502594, 1.266788861157053, 0.3338649121306666, 2.469176893267246, -0.38776470524787543, 2.81218575753777, -0.6996702876995718, 3.459940011814379},
    {-2.3034430375489423, 0.19178041517403804, 2.7995650097311224, 2.579883838444149, 2.77942697181819, 3.391949688994098, 3.7262087272821396, 0.9398405962113536, 0.9733518879773122, -1.7459000894885301, 4.275248484503437, -2.624795379580424, 2.3023463021765354, 1.7557445923420858, 1.2776525237569964, -3.0189974198783394, -0.8524812305526304, 3.556248460923942, 3.5487859173582987, 1.400711128605568, 4.180251918951448, 2.677807251492784, 2.6426985125662075, 1.1856061830129456, -2.2057172406968415, 1.0829854202251465, 0.7585424648438757, 2.1063561890334803, -1.983913040167935, 3.330546204930702, -1.270713518634149, 3.178650199246837},
    {-1.873779616300888, 0.35283003029438315, 2.7041063216316696, 1.97155515488919, 2.478393172285503, 3.0773003069625346, 3.484904137878323, 0.8222270619731238, -0.05652664039971854, -2.392154565192517, 4.422861714437224, -4.148306334985654, 2.814560426747689, 1.5734862813762143, 1.3419266195324606, -3.5065245385288786, -0.4932263150020747, 4.147797846214477, 2.737883791428818, 1.4735902201486915, 4.0916660505589455, 1.384876219555318, 1.832294346896037, 2.3878915754784793, -2.7313816039944094, -0.536269234832146, 1.6025004711832012, 3.241230192918403, -1.2439824099900465, 2.5876467638822156, -0.9047293103845525, 4.263461642359429},
    {-3.03848473502936, -1.0307287588950365, 1.9230780707492785, 1.5534151178291682, 2.267722090417151, 2.5831924278121385, 2.401648404246343, 0.003960321005266816, -0.5657251439708101, -2.9430075517742322, 4.347691184431243, -3.4030643239581666, 3.2215385669899614, 0.6000786939083131, 0.1420742658267783, -1.9028416155895838, -1.2817528641821472, 3.2111907845378824, 3.8837659755316234, 2.137381150172826, 3.4264989132102004, 0.9039122460548503, 2.830843956306742, 3.2144728691978357, -2.499175313232983, -1.662454367973732, 0.7593454442167711, 2.3676600755319606, -0.6057363288395866, 2.75843053020992, -0.8096605328010871, 3.8200501310114863},
    {-0.9984479732103398, -0.5313448881146687, 1.6617450974237962, 2.2770836626861946, 2.9425016462199682, 2.5311609293594275, 3.268821722470339, 0.5530599275106909, -0.21540479906708507, -3.179098238717394, 2.9394773286648297, -2.133454816322148, 2.744179058237753, 1.289508597628831, 1.3067034184619195, -1.8228743442328597, -1.255553338722603, 3.9561484611542634, 3.705054230326331, 2.367577737678105, 3.9360048918426713, 2.0667517541025267, 2.624048616834762, 2.8821540225174704, -2.8546926577140517, -1.2112409882597404, 0.4946733878533577, 3.601479109986138, -0.7626342140133326, 1.9514981212055158, -0.5908217568788177, 4.532410403866047},
    {-2.16230374980017, 0.34954153461339055, 1.4959836084260751, 1.576366904468051, 2.2855244871426117, 3.070622334780636, 3.291960006943464, 1.1080040213924516, 0.9962264019450845, -3.646451300198272, 2.941834920255981, -3.3521815361140974, 1.877229275439649, 1.8895376823940582, 1.399633313924325, -2.632965475483926, 0.7170309333942073, 4.004302881362878, 2.304765456014527, 1.097532290279859, 3.640413097972298, 2.3442552141305604, 1.9357784845327652, 2.7815988307380124, -1.722388026378634, -0.1596066733791006, 2.183960709892785, 2.8291096370999793, -1.5684662048547473, 3.813409745470389, 0.06487709989160283, 3.209524710676123},
    {-2.501351532547671, -1.1720005631582122, 1.688587911546814, 3.338742399291252, 3.6404550262586577, 1.2005544451264345, 3.2150344889614617, 1.2649364704379373, 0.3919838354106001, -4.027440213637204, 4.179243106970493, -4.086231611907229, 2.4812056034226835, 1.8473525870594456, 1.3221060166495404, -3.0818390880785094, -0.26619458261617923, 4.257353140849069, 4.299475404607859, 2.2988633795449798, 4.4603040591391885, 1.1596457701815137, 3.1844325313632416, 1.7249677602781963, -1.5023704501563757, -1.0738287529140045, 1.2719863283266504, 2.684049805458406, -1.458716617103162, 3.290461436342252, -1.2823598976644202, 2.8596861148817814},
    {-2.3062617246224986, -1.106318705043872, 1.7332281559641265, 2.006944343834642, 3.3862380308077977, 1.1903076375365873, 2.1655832016918555, 1.545751973173952, 0.7677027492597239, -3.526666017742323, 3.756845704630462, -2.425841462863001, 3.4313575146538127, 1.2395931242440983, 0.6771562491800438, -2.7896814765130915, 0.30738568740880623, 4.245983486353028, 2.935201872115682, 2.092835398546249, 2.863298962006522, 1.4267301167556832, 2.2660163637336925, 3.1540614037846506, -2.6051416328114114, -0.5549889671864878, 0.8233705899698769, 1.7437213952003807, -2.290173500619198, 3.8393201244666457, -1.186039436980148, 4.138749155289296},
    {-1.7412818891854749, 0.10131568242823875, 2.583585959990495, 2.749405805645346, 3.4819387696805673, 2.215832500866517, 2.7481653288216448, -0.02666839009971881, 0.3678464271614217, -3.7293481524798744, 2.1747323993572727, -4.208609384770653, 3.0800992881087668, 1.294098098298108, 1.1654998704321677, -3.042554328155527, -0.2998071331669067, 2.934231821106496, 4.160354584189602, 0.08721910241347974, 3.268566415789111, 0.964224014128185, 3.316598209156656, 3.2256965062353227, -3.0843075034994034, -1.2242048580453424, 0.23191299501223353, 1.9702801919026123, -1.84409962127133, 3.298539551955627, -2.033417071895769, 3.682049668153822},
    {-2.8866567180920155, 0.08698987059956974, 2.663335587234155, 2.8537761458971245, 3.285457510891945, 1.3556792474119892, 3.3252988302565956, 0.22701208095802924, -0.6130536964508886, -4.0090442993827535, 2.351884346242424, -3.3546046482005147, 2.4369383577767967, -0.05456835345327295, 0.36724711146449646, -2.9505948805909283, -0.7123770187573084, 3.7354765452692162, 2.8019147100236013, 0.22821300385530477, 2.567860958023012, 2.5651147190697188, 2.7665668708206748, 2.486553689849796, -3.5779823645875704, -0.447843066896031, 1.024944163614931, 1.4151472100812206, -2.8326797221482165, 3.5266524342212606, -1.9256134762214892, 3.4923712887018596},
    {-0.8552998372589482, -3.3158946975726, 0.5075362045252716, 1.390895809706721, -1.8626083139782343, -0.7654343488230122, -1.8687201723686, -1.358257938127904, -0.6964077161013301, 0.47409264529151063, -1.5967210016377966, 0.9654587874101221, -0.37943069346238795, -0.2531539037395301, 1.2456331464933317, -0.6063291757477319, 1.1533936772382418, -0.1257690927437288, -0.9706988119848783, -1.9210840794483006, -0.9842011493913294, 0.6113879761348096, 0.34983641235045126, -0.7643169321636546, -1.6693807485165948, -1.941226616385818, -0.9086229172647343, 0.13042343121193964, -1.3925343652774815, 0.5991503353616197, 0.22665075364117016, -2.2450894081099566},
    {-0.656386073344897, -0.2014145098408461, -1.5023007539568938, -0.3370011209969008, -1.7227211688603148, 0.513910590491606, -0.9577651275258319, -2.379636389710898, 0.8739497487392159, 0.02790548733085335, 0.03872677173134038, -0.8581044011978564, -1.1379986219771219, -0.8066290608801369, -0.973359516694614, -0.03769725559850853, -1.6887564129110277, 1.0859664447973432, 0.4375449108299263, -1.1955865957263847, 0.31349283424819774, -1.1736769296098475, -0.4160762509234988, -2.207594177786623, 0.6343493422563271, -2.040132538014926, 0.5220121869798292, -1.5514808725294331, -0.06803176849669737, -0.5433755908684629, -0.18191252496452606, -0.8771435118841113},
    {-0.6041917077840456, -2.1849114144274595, -0.8158969951099854, -1.0701244021543224, -1.3268272952201041, -0.7392711384710489, -2.8744578173913156, -1.7523253812485067, -1.5546027151576542, 1.8193701402052223, -0.021210975584439844, 0.4577963873902035, -1.7522611781269093, -1.2825517083020037, -0.1801061698294646, -0.04254287025252382, -2.396972224045379, -1.5085887662438495, -1.0912168058798009, -2.8848346815433197, -2.003148964632817, -2.36450921543338, -1.1914978155952578, -2.395600583043242, -0.9251206064356627, -1.7133574991791807, -0.6146162165079742, -1.1825948051216915, -2.556307956747562, -0.923252178338111, -2.0108471751478016, -0.9035178816564078},
    {-1.8121242495094017, -2.1812621106061947, -2.2742414566788085, -0.19532520012253995, -1.165462363247144, -0.38086947627109774, -0.43951504950430154, -0.29729974586996283, 0.32028928563369485, -0.21938010214052125, -0.6437821719676657, -0.017442415173800352, -0.5359170460809568, -1.0033322978225758, 0.3405286232079324, -1.230057395552749, -0.8050773329741231, -0.41009541507345576, -0.8277633195180106, -0.8577174486257012, -0.49353827703540176, -1.8036510860076782, -0.802446835633832, -1.9073078922824442, -0.2453609574741054, -0.5666539513283632, 0.31652223038524185, -0.14866451622319524, -1.9128457739118174, -1.7245717578740332, 0.19489077269578906, 0.17676412476562134},
    {0.36028919770678436, -0.925245321661366, -3.276328970170819, -1.0048954875561906, -3.168028808776578, 0.42280880662666237, -2.4435428692662566, -1.2041419878105706, -1.9278439308119588, -0.29923613759097556, -1.0628959333863097, 0.9468401440570904, -0.8655811273380336, -3.212168604764329, -1.329688209717006, -1.4954179130166037, -3.196248866117755, -0.48619464541771296, -0.36162342508962225, -3.3532537831690643, -0.999746093547675, -2.3083091050315594, -1.913881309081732, -1.552626578477311, -1.6051284040202238, -0.3762443031267859, -1.1193026840331264, -0.9865617684598632, -1.498192433914276, -1.8050165994877754, -1.1988849212193986, 0.2183166984787306},
    {0.9640164119621043, -0.8298462635766594, -0.6825915598925538, -0.1292737139595267, -1.898195098370194, -0.8189216888405826, -2.68624746511809, -2.6305709508611708, 0.1199707798076552, 0.8326462355860624, -0.4120021195895543, 0.5613782829812352, -0.8262497012526382, -0.6351207920962376, -1.815095913685069, -1.3280552959614438, -1.5262403623657756, -1.9576483465175183, -0.672825133474478, -1.8767391206635642, -1.3493407346554307, -0.9632622599154174, -1.2673445600039752, -2.9164447320825366, -0.9210121850932284, -0.13308787809793626, -0.5927155776473735, -1.5750146395664004, 0.1983163235496568, -2.3311011272518374, -1.5836918800356963, -0.15065412320936017},
    {-0.006636776020045635, -0.8413603273999416, -1.537434660032736, -0.4575467361872709, -0.8789205436591758, 0.10026533127691115, -1.8762306859084725, -2.5223975110865977, -0.22590970333453386, 1.0719339822114349, -0.891169179633078, 1.129304316359314, -2.4712501885395963, -0.812012976651411, -1.3735977835666808, -1.4666444964245462, -1.0720268610647563, -0.2648162200054177, -0.18079154716559218, -2.2455485003002074, -0.6789668756423086, -1.463555247329151, -0.3784614739812146, -1.6002924971105286, -2.3229485449341176, 0.8874062737377963, -0.0074328877495796605, -1.4323724476848716, -1.436644161054629, -2.395594344170962, -2.145819880659118, -1.6939382841337092},
    {-0.3235804166426698, -1.4233168219900716, -1.4008844417190287, 0.0173477002251453, 0.12728956537746136, -1.4212777399650158, -2.1141207378836464, -1.92766048631135, 0.07272883255275232, 0.6383221097908247, -1.4007126340058818, 0.4710436420144776, -1.4657198970745506, 0.1981474931158997, 0.4711028591872688, 0.5925602171291459, -0.5780022464041537, 0.005154043019935041, 0.2921226427556547, -0.9712686287302967, -0.4168879658132814, -0.18726206622095498, -1.056861631004681, 0.21705527972367833, -0.06207474122103744, -0.4781633368839384, -0.026965631171420604, 0.2112744008843644, -0.9026960334839296, -0.7087491597330208, -1.1605850725654452, -0.31547894040927005},
    {-0.9478905891128956, -1.5205461621472716, -2.3722658027931556, -1.1671912567548506, -1.4914136656636956, -0.9063974297754975, -1.4835917328822623, -2.894206011161327, 0.8674282506667245, 1.7013964279520444, 0.032888048968553484, -0.6653066610894164, -2.4699436080430064, -0.22107592099452958, 0.46314906589175436, 0.6469297333844897, -2.791435194887495, -0.6324296009096971, 0.4972748740529415, -2.5739572167285627, -1.6984144520452078, -1.9130800942931032, 0.4233987428669088, -2.1624505476014306, -1.3211222011003783, -0.6041513019389612, -1.6881452884470778, -1.3508725379645166, -0.9914031711450425, -1.0797749525502631, -2.0187372504295498, -0.4928765495510616},
    {-0.9661620170714379, 0.529958148825252, -1.8782126210118362, -1.1841093186343645, -1.095297774702156, 1.093206489608215, -0.5137953290784685, -1.948822272298282, -0.8878729490346913, 1.1846970395479792, 0.9165371600543452, -0.1715430711675945, -2.507011319416011, -1.2634034272998234, -0.5693092150987981, 1.3689502609889839, -2.9292643347385225, -1.0963806407948444, -0.5852296017388671, -1.4908587544293528, -1.4051026108081324, -2.3735337204376106, -2.53404873903533, -0.6735528761166472, -1.8212485266960836, -1.0608219518801072, -0.695637462586752, -1.6682696538767943, -2.2213081112189417, -2.3500690905977515, -1.4217879407582554, -1.2224091768319396},
    {-2.3250203864562873, -0.3720547713992441, -1.7045675764279589, 0.0011131035584362851, -1.7302243569460838, -1.2969562370140528, -1.1648931811858927, -2.1302605004347153, 0.34379741596064517, 0.57398516044233, -0.4140913068892791, 0.22502830372094762, -2.0713511373037132, -1.6267625101996988, 0.11167784963662954, -1.2331712516247455, -2.304327735799716, -0.8798521191673556, -1.6383259698932193, -2.084766451199284, -0.5139328847024468, -1.5480833633129525, -1.0418340633795542, -1.1116641210539766, -2.4102903680737087, -1.4434108702300952, -0.6866895621581723, -1.944624179950346, -1.0023457453909141, -0.8819478667579527, -1.300231829536065, -0.1886190833696344},
    {-0.12533158975982886, -1.2737191061878244, -2.7842682250505773, -1.0114869594385663, -2.660935646262859, -0.5012702648772164, -2.5046922854468137, -3.134318664486689, -0.31289288141715893, -0.18986551191927645, -0.02572800860280124, -0.8861995217474882, -2.228893395233058, -3.206081737055128, -1.7544544687883026, -0.6632978442991975, -1.1990245691134238, -2.692630800307883, -2.692904200646501, -1.2602684543383484, -1.5159818218026344, -2.678856323243112, -0.6972374490426253, -2.083817647999535, -1.9548460853379128, -1.2242715819780396, -2.7639613740467013, -1.763020125111159, -1.65239578266229, -1.3986972358984968, -2.4240786321411263, -2.1853832198809933},
    {-1.4104581625160069, -1.877756193026257, -1.6567675573136245, -0.6671405029457319, -1.3715952078077582, -1.7487618220136154, -2.515390787416939, -1.1381787598303057, -1.067432686005391, 1.6632257599024536, -1.6565007774343885, 1.008928664309484, -1.4723972604088418, -2.3060782014252443, -0.26829142180839016, -1.8213220009632407, -1.660467607965798, -1.5880430129841687, -1.4055469233142963, -2.190417907545127, -0.5853633481168086, -2.782446424709571, -1.4336929453022005, -2.0628169652720763, -1.471137821360527, 0.20932760588122584, -0.8550715133649098, -1.1341125432766523, -2.128036112181323, -2.318172103711137, -1.0440065442704456, -2.1896488261913767},
    {-1.7112276180981667, -1.7332367928038586, -1.9029805864845082, -2.2818283467618885, -1.67735661340027, 0.6738277442831002, -1.7529282927129293, -2.543468680472279, 0.43321106564540907, 0.10217523065972063, -0.04100652563558304, -0.06637834103875719, -1.458128907089925, -2.849642404979692, -0.6006202791355294, -1.4866645122646118, -1.4916344195975013, -0.8496439514800473, -2.011015676110485, -2.666198620139083, -0.20285599280127747, -1.6748962341537958, -1.0362082274267015, -0.4405841809118225, -0.7799881872217995, -1.7117916766844445, -0.4950435394162761, -0.4354118970968783, -2.5425544356140826, -2.193665030367006, -2.1651234128126133, -0.9132601301662578},
    {0.035660149915316644, -1.6112046582852795, -2.0811642057101687, -2.758928545259471, -3.325484074752495, 0.4779298868290806, -2.786329189248596, -2.9771610326334508, -0.352410677111762, -0.11370238611558063, -0.3351353273813602, 0.16565294915698467, -0.5060936611749774, -2.695329790054998, -1.3585678299949913, 0.678514447937505, -2.3855771482271257, -0.9334329163113789, -2.679873128647646, -1.8363800494938014, -0.7754004125798466, -2.086304647208947, -2.6938762155383027, -3.081305346898584, -1.7882015775751174, -0.4457906990934996, -2.5645865993661876, -2.5724351346280265, -1.1215708888867955, -2.054625898255355, -1.3226608507966855, -0.2672832115817614},
    {-0.5983741497503556, -0.34120109631844775, -2.4371683022187516, -2.219096646320734, -2.0394555337333413, 0.2871461797637083, -0.9676848721492131, -1.858280421879161, -1.1468227248744847, 0.20124828833450453, 0.4395730330253389, -0.10370191350596289, -0.2507708286962593, -0.5170171914332713, -0.12687619121431779, 0.47895058789019107, -1.970762673454485, -0.4650707732620188, -1.2688384355947318, -2.8138276792059673, -0.03847752889366017, -2.557372373030608, -0.07859107616666015, -1.0303996559102622, -2.4319854177700786, -1.7791550157786769, -1.0993356464368176, -0.3825040111667023, -2.66191460715788, 0.010293232162044032, -0.6429196502820302, -2.2014658829417115},
    {-0.3298007093293939, -1.7306712696529851, -2.2450529779366097, -0.5872877762302829, -1.4357036432351868, -1.1068759343848542, -2.6849666500393146, -1.5623864471258329, -0.6905656370804353, -0.08728166050497985, -0.7143830856037422, 0.22496299198914832, 0.1943778419044347, -1.1550631298477907, 1.1211110145143994, -0.5893165798098724, -2.1028139998700235, -0.12777678075143237, -1.6804396144441582, -2.0723965840539584, -1.304130567334297, -0.6708393434305876, -1.7920319069192352, -1.969167921991636, -0.5248421292067833, -2.771804360502595, -1.6821154040637698, -2.162912636742644, -2.296387544247014, -0.7576956341725489, -0.6363028689844368, -1.238567803250244},
    {-2.310546064037736, 0.3786831467151363, -3.1798161045121054, -0.14648273186740038, -3.3928661839633465, -0.9519135517413775, -2.1978952159522733, -3.4438029156664896, -0.5233410490238006, 0.7935442605483676, 0.38924795942456336, 1.5582786506353714, 0.41200353853663196, -2.481068839895174, 0.39435114288526385, 0.7831461343108969, -1.601058204152425, -0.4316379154705938, -2.4275583159097973, -3.466398659062385, -0.6702917945273725, -1.2152441130137646, -2.271495471642829, -0.9107267337452472, -0.8321648529813127, -2.159799243877578, -0.195034733521741, -2.424291626174713, -2.404668997835417, -1.9925954578407574, -0.4620000607697004, -0.08301834828302508},
    {-1.5595932280447826, -0.9231356728714427, -1.9265753475361702, -1.5577487341589384, -3.1690098598527436, -0.8458273448509668, -0.9669834291266577, -2.770584626725498, -1.2672862162159266, 1.7223209763336553, 0.47412051701805275, 1.4525483155961185, -0.07398403871439238, -1.4898401183259877, 0.734290149180511, 0.5818721662169639, -2.392995893785735, -1.875518314011044, -1.3305915952639773, -2.665650980751308, -0.1634879085738137, -1.5206159156227599, -2.290874246994392, -2.0699330691381883, -1.08094749810972, -0.813602235719093, -0.4285390076165008, -1.3106814794675197, -3.153280654920292, -1.6122894327264476, -2.0395431513264968, -1.075086037347215},
    {-2.0453566929469114, -0.5914777763238331, -3.079611407735072, -1.3298223886649814, -3.089831680612176, -1.91875317006424, -2.510668084676924, -3.4274567652968377, -0.43683164182978046, 0.5627049090930756, -1.0147538238077078, -1.062091639547882, -1.123633658558072, -1.4716942174979366, -0.26674297830550964, -1.0073550134745302, -1.3856844085191282, -1.3896313074727094, -3.0337189225690206, -2.4803462260215996, -1.8966988366822621, -1.9423882435836202, -1.3592781041584645, -1.5214017479967186, -2.232578242758349, -2.6465427832831514, -2.0852755000172722, -0.5805064727797654, -2.7719401919175075, -1.8032392419937457, -1.90608843372783, -1.872149314084931},
    {-1.809295699958566, -1.0386611479259515, -1.9181748020872937, -1.5467704474055641, -2.3021361255668076, -0.8914185757000107, -2.02876676366601, -2.749876314143481, -0.2506800746292352, 1.0885209534908662, -2.1919111176582593, 0.7156059018612483, -0.42672686307329905, -2.468991180587593, -0.6922498278341205, -0.20101381517846234, -3.249454394339731, -0.530675222533725, -2.3139265507622233, -3.830597174706088, -3.0065517448341774, -2.7183618185892033, -1.5235299371696347, -1.6100520839444896, -2.6017928208853696, -3.318926036621133, -1.4132021584627632, -1.6299996560492664, -1.8296780322870405, -1.063682940659225, -1.544452916360756, -2.8181602767262204},
    {-1.370528556995785, 0.09033158146228394, -2.427399986673951, -0.8386245578075697, -4.107666900758968, 1.5632398500767202, -1.9524281397533014, -3.240782961873306, 0.6783717052634316, 2.5539733118606187, -0.5064971700671984, 1.9557330675210594, 0.17248523568868276, -2.005062957263565, 1.030924305502003, 0.10002879372674674, -1.1888086477873159, -1.2824336114150863, -1.6451108336097062, -2.2355443513996556, -1.5063637544717214, -1.0792879865057694, -0.5989872703815269, -1.7813959155367947, -0.24714320036655968, -2.20864395140053, -0.604129463643485, -1.8389222117487343, -3.6868928446638543, -0.49538244361865774, -1.23554233012573, -1.8784360157962368},
    {-2.0502100434384025, 0.06541422671835924, -1.6045966459723637, -0.569683600578649, -3.456980563259567, 1.5816499348955064, -2.419988414383295, -3.1377966157502595, 0.5435418308426705, 2.212333953059324, 0.07543433414052615, 1.9282185196291097, 2.2869514951725165, -1.8738529514341995, 0.7468609255971385, 1.804271793583508, 0.07772254075867986, 0.9625999725256825, 0.06026453959645446, -3.2727191402457776, 0.2832160834174643, -1.1569807996648243, 0.6770193341434946, -1.2884036212785426, 0.12212687258908331, -1.724404677541046, -0.6482405718242895, -0.3430228844356348, -2.480339543553157, 0.8473740310380911, 0.23699834695554234, -0.0328382341034705},
    {-1.8695882329529885, -0.9461265607409628, -2.359704311291753, -1.1070112511722392, -2.883311847689169, 0.17057881941485614, -1.9002081330533946, -2.684354527908394, 1.009793083452822, 1.54893433104277, -1.4207776469720121, 2.1295112008951715, -0.16937637067697156, -3.190850607486012, 0.4950227723538793, -0.6326500581919877, -1.7264275093318895, -0.3435630879105957, -0.9626914033415916, -3.7420979974561313, -2.503337625016999, -2.8802347603838627, -0.0678772263041716, -2.891682030555031, -0.8340517608335357, -3.4048590780004964, -2.183771637750316, -0.9722847351731071, -3.461550524655691, -0.74045953541998, -0.6676628878073968, -2.476705919162699},
    {-2.9859990662930795, -0.9805552858972496, -2.169172956455521, -0.6743899464382265, -4.329720626951699, -1.462493280131596, -2.8038491437610413, -3.608706376420038, -1.3464392801834328, -0.48468892861031093, 0.2482963632916654, 1.3965518293614259, -1.538654468322859, -1.9667543825347575, 0.15506569651772123, -0.01379286145238567, -2.7185441071469585, -1.8881504791580639, -2.2802830720508283, -2.3600209395386353, -1.434853540496878, -1.4641728011441668, -0.9683566396529194, -2.2916536883639376, -2.2953405208931, -2.404836177388243, -2.7810516277394437, -0.982359980859095, -2.818311446174204, -2.457074721932889, -0.8959665054257648, -2.8477844704200255},
    {-0.908588535827055, -0.5176736931622392, -3.3145284837119524, -0.9698452015935121, -3.521926368244172, -0.16551828013622424, -2.6028606852105507, -3.7823787267329485, 1.4546025613946805, 2.0515122267619206, -0.04294957102512433, 1.3362450658005947, 0.5851228672894555, -2.6300219713740085, 0.3872758745326248, 0.6524623038834575, -0.5436342441730141, -0.21375585016158494, -1.6406398587509496, -4.152608860546693, -0.6814227068811783, -1.4917749180792872, -1.88850058906394, -1.6727832674665357, -1.9172153623205934, -2.3005581347374067, 0.045451734320820024, -1.0722299313539287, -3.4970941614099975, -2.219668975171546, 0.13738450522147316, -1.7090689961154717},
    {-1.1900421931287992, -0.9282724581435363, -3.742333911818945, -1.5284682039343152, -4.251792877175837, 0.3268378776720993, -2.429899220091946, -4.103184986884376, -0.24079696494073072, 1.3973413120786997, -1.0410442248155003, 1.4555304505473767, 0.3345265347368035, -2.2305768652346876, 0.19182576051383296, -0.6360814949142414, -0.8228938623378403, -0.4385289977493209, -1.3205659440871493, -2.9752538938144086, -1.759099811318596, -1.1390232297107525, -1.1885464473162621, -2.0646063290880368, -2.0395453241304895, -1.997476717115109, -0.3237018582246348, -1.2428822618123985, -4.334535656122733, -0.9302960404892724, -0.5670661808245396, -2.5696545584560297},
    {-2.585208944948745, -0.09024777866864801, -2.5756748800523583, -0.49018633171685105, -3.485046456441508, -0.30697602792191925, -3.7153070395772834, -4.770367756992349, -1.0182791030947322, 0.691875170391547, -0.2513954351493407, 2.139631110204638, -0.37491207412980154, -3.5239908000924087, 0.47973042957271145, -0.2232068110309077, -2.0129540335454816, -2.329238473708383, -1.5121963205292208, -4.616557693291188, -2.573697378501327, -2.656754902550932, -0.7256146229594058, -3.298484377020983, -1.4644525782299054, -2.11817848025067, -2.4556766752200483, -1.5386871877193475, -4.099636579127221, -2.116312713743618, -2.1461243193166677, -1.3883112277912493},
    {-3.2133593604817996, -1.7602469168271175, -2.5754148883826042, -1.5856191002163351, -4.131685123395946, -0.12795662986612935, -2.258163527850388, -3.0949843727809383, 0.7613427364052062, 0.8386174344482638, -1.308852917531274, 1.0594285460530146, -0.510487987111502, -3.0043818054800013, -0.41190047864382384, 0.9568988730051671, -1.9300698379693826, -0.621056991380167, -0.6587084916636844, -4.752413881784701, -0.8975671856286347, -2.1530084849568367, 0.31225606835741443, -2.9063171266768455, -0.965850816863475, -3.6821761954156105, -2.157357313326478, -0.9892195983069029, -4.612711337700809, -2.0161144749422784, 0.23373245620068828, -1.835691372933647},
    {-2.440298800741069, -2.0743308896704677, -3.0440556745960414, -0.2861038674470661, -3.5795462759385974, 0.6503379365333002, -1.3689463409136498, -3.4010838731935356, 1.656672873867266, 2.4732567726611787, -1.7078970118222205, 0.8930694309384692, -0.09016861777483513, -1.580142123258764, 0.6476760791581028, 0.5672350001506884, 0.18027958318270793, -0.08840201052684388, -0.7344604178955516, -3.2663826452511655, -2.1178432442624855, -1.772571430998514, 0.46200009004540854, -0.5821223424308224, -1.8972153675013164, -3.8985276343517237, -0.6268807487559888, 0.030739549455996166, -3.9206619813302037, -1.3106039001484737, 0.16910413209139608, -1.7902926413263673}
};

static const float b1[32] = {6.551115913356091, 6.509622042264281, 6.673841541771288, 6.3155182457142995, 6.796568863441088, 6.442727693125695, 6.658909590609099, 6.868179075511976, 6.427850540760379, 6.748648686852225, 6.210621953127558, 6.59184557459514, 6.5466029524388665, 6.696591265721025, 6.489739991050174, 6.697577692243746, 6.94548056378048, 6.583357126413154, 6.6187461114897985, 6.637243371757048, 6.295745585227257, 6.6622851828996295, 6.480933678079387, 6.505531642560603, 6.752308646441013, 6.465565456114275, 6.512917154038702, 6.181412867999182, 6.542150461409148, 6.581557633167669, 6.697369938327516, 6.607345087909049};

static const float w2[32][16] = {
    {4.502897406564774, 1.6977367864880983, 4.213045432148488, 6.010276731904232, 5.135328430620138, 5.709905453575476, 5.8071515697719445, 1.4416513698756064, 5.042289800072707, 4.981147215545572, -0.3405997149796748, 5.6368073922266015, 4.960520954972123, 5.146418432905022, 5.993837820710779, 4.872395716318599},
    {5.086297322493107, 3.061231635902073, 5.392333564972306, 4.158859094917922, 4.099393265046255, 6.177007017202109, 6.068259188003128, 1.062821844423514, 4.796314908656666, 5.554471707511681, 1.2120579751599465, 4.326396141170931, 4.474659360687018, 6.079097582196408, 5.831946025895221, 5.285477668188957},
    {5.670879851920181, 1.6530669623648402, 4.358178725066014, 4.552533624287756, 5.01046887393661, 4.948198638727186, 4.818321717393121, 1.7431192973878733, 5.758919558440297, 5.141258489954753, 0.4620753034652201, 4.872722348070946, 6.262219894509711, 5.402893613717486, 4.874177876674029, 4.850711554024799},
    {4.783091308736341, 1.8020316960946008, 4.79948809810402, 5.926091781443153, 5.02608546855151, 5.584014043005105, 4.800090838258834, 2.2138359354330137, 4.378208146044148, 4.858239112196993, 1.850284348010629, 4.326871196983898, 4.7276566588408775, 4.471401255435974, 4.514616699850234, 6.031089493310742},
    {5.860234434561874, 2.3665053136011176, 5.615467141527865, 5.700079480943466, 5.18412946731876, 6.294688470904451, 5.82195991492981, 1.7305383655319988, 4.646641676107908, 5.256267819391744, 0.4776788110342765, 4.546864761312133, 5.043518834344297, 5.092075601746762, 6.624940817361639, 6.071627131134706},
    {5.479803396434004, 3.077205211198731, 4.408527784476806, 5.321601566238182, 4.204623799576528, 6.232765102246794, 4.874735703325883, 1.5225880651354853, 5.823997386308221, 4.526517142049076, 1.5531194416929597, 4.056824008829026, 4.894545201998725, 5.550114641513798, 5.138901169531365, 5.848968932022903},
    {5.288532734776111, 2.9352659253803637, 4.485093945763467, 5.678594070834603, 5.313590076752704, 6.187825452516215, 5.830346977133804, 1.4328975721213832, 5.681726503132685, 5.917223651941133, 1.8062260577633806, 4.916003219803385, 6.283649874760488, 4.309262604563195, 5.1372668427953645, 6.1236297322937085},
    {4.854865415902477, 3.692310036020145, 4.216426856029884, 6.20676487494673, 5.486750726590535, 5.238742618093946, 4.656595877833974, 2.685136903671804, 6.312599428567622, 5.891824262538947, 0.9010210943724392, 4.476992502211752, 6.054376253177221, 4.701113531522638, 6.3349508611112215, 6.314152595173944},
    {4.951238099359933, 2.3155007473600877, 4.163257143802971, 5.85603853273073, 4.917622279797488, 4.669460019740236, 4.978978521386213, 1.6376470895192836, 4.808893981015444, 5.455485245719717, 1.204693079602605, 5.604191477668537, 5.383365642522256, 5.1760443132504275, 4.281464534685766, 4.810457583588414},
    {4.0414375126859685, 2.5105869212828282, 3.7720927095719867, 5.272861884541096, 3.937755904177179, 5.275031399027621, 4.778963854784295, 1.3266032333076476, 5.653078103617747, 5.534957227155221, 0.3918306785834711, 5.354807934267316, 5.178486226984918, 4.555968583431619, 3.9581881401861683, 4.122535532549809},
    {4.484804877361098, 2.8009240141892082, 5.01056089793536, 5.494920325477189, 6.0975063373428915, 4.566704369011934, 5.5446125502486705, 2.879733386351896, 4.631597942142154, 4.746966161177162, 0.04570728613130236, 5.251544619485289, 5.7630560535573325, 4.940916049214707, 5.924782063725741, 5.3581678391837615},
    {4.12205277135775, 2.3482882723842122, 4.630499154982014, 5.377947860310209, 4.307359124624847, 5.748675421314509, 4.614013334775509, 1.591365881506866, 5.622763853577224, 4.322316235917016, 0.6668697161723158, 5.243545265610503, 5.132027843238455, 4.019696544764466, 4.2420053236453645, 4.06156779949135},
    {4.188612126628471, 2.5625256337528586, 4.2754622655272945, 4.45959238920077, 5.508447808157877, 5.628528976261273, 4.70770351541443, 1.8822767239943121, 5.784319097223279, 5.240837928247325, 0.20428974117823717, 5.004154883223338, 6.001566692754297, 5.2954118079560875, 5.558004556331379, 6.225242587487693},
    {6.068386647539164, 3.25576455928656, 4.0545863665902555, 4.791094339939982, 5.114272632032106, 5.537412851934274, 5.842588478267849, 0.8477768567358535, 4.422893667998335, 5.614231296321501, 0.5010394545666677, 4.285543424621481, 5.565535468182667, 5.048632671883153, 5.328612969852537, 4.363097227314007},
    {5.626399413744566, 3.0171894988090537, 4.106475657942488, 5.53829152985284, 4.558526042649967, 5.299778387864379, 5.723573235980268, 0.9674806396349717, 4.323869918394984, 5.211328550337562, 1.9497534111928985, 4.91159566557351, 5.626812014061985, 5.265485762401585, 4.875465026758347, 5.820666368795407},
    {5.217223625187799, 2.7170796903508614, 5.635333509225349, 5.849062567545674, 4.57684278963726, 4.661664011212575, 6.420263950110695, 1.5893022067603024, 4.7155842612723315, 5.172065974749545, 1.056106943520343, 4.659378893005286, 6.395773928271366, 4.718493842043846, 4.864555649778994, 5.500636778440654},
    {4.800278451021798, 2.079475461596133, 5.337783673542568, 5.683220958361212, 5.198269279154295, 5.204032575013226, 5.633621847104354, 1.7733488112964793, 5.031458775087378, 5.679985469194569, 2.0201004271729937, 5.525203515898993, 6.142427920629271, 4.771578681395124, 5.541609332274029, 5.159601698845186},
    {4.660127296511554, 1.622440466041314, 4.157491347915385, 5.08146450672009, 4.8335790372051415, 4.874596186314063, 5.153462855527488, 0.8479006486662529, 6.027542676661322, 6.123084214920292, 0.7728493644410293, 4.237747560163404, 4.8576472814062415, 5.473006123719199, 5.666357806084385, 5.791562065139078},
    {5.8185466411421665, 2.3022423252413216, 5.150752201845101, 4.9309309126313705, 5.791434170838487, 5.499254329682829, 4.732700335127538, 1.0850453285823818, 4.6781308335732055, 5.323844844385102, 0.430481388841014, 4.813116469468145, 6.084446485223103, 5.512924423614807, 5.996755971830648, 5.493215856520262},
    {5.430383385918003, 2.248501562762381, 4.68805736043341, 6.596348655798326, 5.342407196988218, 6.206037755774933, 5.139743084447014, 1.6050304385958678, 6.293269957852699, 5.035429550311143, 0.34542259339124215, 5.61554078317532, 5.6676783258339825, 6.09872370245151, 4.766918356671781, 5.014252678549472},
    {6.154284924611632, 2.909704920663418, 4.964507782980086, 6.222518191150493, 5.881064858759676, 4.809722493177959, 4.818395197025684, 1.3001226000749644, 6.09635513186511, 6.217329908307812, 0.6948805011938485, 4.996744031545619, 4.82033888547514, 6.267268727700953, 5.045925645944754, 5.22785350675164},
    {5.679204960246823, 1.6403678289450732, 4.658594039202609, 5.494965787521383, 5.541508284981298, 4.495585700967302, 4.6326040511554085, 1.9018450888498402, 6.195406796985899, 5.121274792453314, 0.29300908220630706, 3.9999743511425954, 5.421360744876016, 5.318227737450024, 6.195289636088149, 6.1490555519354215},
    {5.326250957355628, 3.1368297221772456, 5.590937019525687, 4.999893329336853, 4.776662273977778, 5.026535703159858, 6.292046159653681, 1.9790223613175448, 5.348210251643946, 4.644916719009723, 2.102801636965497, 5.523538926191773, 5.923958664610014, 5.567483371867001, 5.791456280048819, 5.887145208308655},
    {5.924200909168607, 2.3508224906391644, 4.337347886226525, 5.461533576797904, 5.967536089805084, 5.593095691519809, 5.532076611146281, 2.0229542969791514, 5.663816090082318, 5.793887952986579, -0.06645318992081395, 5.54723731063806, 5.90144909648761, 5.900748917173481, 5.683497143239213, 4.686511277163787},
    {5.596213698395258, 2.0011235390951607, 5.203523420425378, 6.007206028124597, 5.392632569723574, 4.8376057550620555, 5.092680941483384, 1.5858031851521945, 6.164155992758815, 6.073833403723411, 1.4837931452882838, 5.316549841035291, 4.897701836858271, 5.826898781313543, 5.899695217847733, 5.8045418662944},
    {5.76824407379077, 1.7646060334768674, 5.254327591807443, 5.45467192663531, 4.531614148942364, 6.105549529145298, 6.289164576497466, 1.6823659185189546, 5.471340837361585, 5.794146003886089, 0.07723390493131845, 4.0725249866605635, 5.594083654330315, 5.817859211966181, 4.568610973275664, 5.041211302462814},
    {5.96731360823747, 1.9164470095679882, 4.019755798278777, 6.019663650513952, 4.898722737491867, 5.759513717919255, 5.532486424100204, 1.332181833498106, 4.313928141541834, 4.6860851797691705, 1.5770540974275478, 4.056238754570113, 4.555275353646803, 4.472104642251038, 4.392354367899473, 4.9213221239316685},
    {5.630038776218341, 2.537852071622436, 4.454554226141084, 5.782349831922073, 4.599830188807297, 4.958139681671149, 5.712015372804981, 1.7535607055755043, 4.340482937626063, 5.024989480019104, 1.8917198311674515, 5.601797471815278, 5.045528218247324, 5.116028816265488, 4.405358634987363, 5.30453384312946},
    {6.008612655441312, 2.0336924157606533, 5.216793107216599, 5.146411724823426, 5.863041327757642, 6.227204282686194, 4.678108831914313, 1.1855009985637164, 5.683875162824073, 5.076697425672808, 1.2289250238402467, 4.671289098446213, 5.132464292223802, 4.407006305810828, 6.468237749042686, 6.076380084882431},
    {5.404247423341457, 2.5574147020078413, 4.961617814320905, 5.111868945312162, 5.212470334381184, 5.66969423662102, 5.724902460057947, 1.5323327418718813, 5.735115762562351, 5.026248327898108, 0.5971384758828293, 4.912478439422113, 6.204986265910076, 5.954540941083399, 5.443551907063633, 6.28207000801501},
    {4.752171882225918, 2.401318416481419, 4.711715072657218, 5.755856793396683, 4.579076675512962, 5.743051610658638, 6.070784601472648, 2.1225761433554577, 5.9312120912841095, 5.786579443094461, 0.9355957844807198, 4.889940447180805, 5.069375524656008, 6.101548603794667, 5.009420284310351, 5.199694512646948},
    {5.5852403963615975, 2.7986926819098654, 5.927887377159361, 6.467777940253643, 5.336221680199629, 6.312582503149265, 5.841663403940657, 2.52735413267708, 5.014146136468086, 5.185751435741101, 1.1629200479720867, 5.454394518636197, 6.101675485211739, 4.740079380726433, 5.1415410625084235, 4.904503058839059}
};

static const float b2[16] = {5.850225706253084, 3.377289708657947, 6.065356105569046, 6.0461102450542725, 5.952755936407, 5.886430490650491, 6.0010095800802485, 2.5461020395922693, 5.828473977053785, 5.902478447407622, 1.383512958491997, 5.746807463047307, 5.978244820133342, 5.792910716024628, 5.974714030390257, 6.097860419374167};

static const float w3[16][12] = {
    {-3.669134049762894, -3.197002027308776, -2.5023617472850392, -2.429788019801732, -3.83412657728836, -3.017368249311799, -4.430868227418651, -3.0803629800130223, -3.6185441837811654, -4.042637306516081, -4.5175393739162315, -3.6707498284175206},
    {-2.1915730447024386, -1.9178723937384872, -1.5049975683408001, -1.578362515287408, -1.6034092988881132, -1.8207874209040122, -2.2776338218152827, -2.6937271840717654, -1.0990362479232836, -1.5260496892876538, -3.069061955628705, -1.563967651920262},
    {-2.8734155563267305, -3.8360969048470137, -3.0589489612024297, -3.5246326578662934, -3.82635946577792, -3.1614257479399046, -2.767357335932207, -3.3191819684762214, -3.375333211738584, -2.976817481288968, -3.045828300875613, -2.9083667859938327},
    {-2.7437440057273133, -3.679500800174237, -3.0716655223470988, -3.6772866435223643, -3.029331490987907, -3.4202881328487815, -2.8722255025428534, -3.8345048503708186, -4.559028889518115, -4.0004319904741745, -3.895001177759973, -3.582068346301663},
    {-3.2306131500666355, -3.943307578597435, -3.722541197062563, -4.108585923233045, -2.791835223066904, -3.6475341974190005, -4.2442712203837285, -4.178721000189232, -3.009456116719951, -2.391888331534844, -3.035897250999079, -4.357724826919497},
    {-3.5116972777634876, -3.245567533147857, -4.41972626059712, -3.650255728406994, -3.2396595709001796, -4.188332722174805, -3.5881999744266224, -2.4510078962850605, -2.9500525156321658, -4.265693351656477, -2.582068646539588, -3.0911753283430423},
    {-4.236471061613816, -4.145307959287263, -4.47723272794975, -4.221363095566524, -3.2101058899483244, -4.026516431132742, -3.055095869663635, -3.2614841334524955, -3.107849097889687, -4.1292713343424525, -3.2205520875081843, -3.023311691789103},
    {-1.6400292514453518, -1.707962265200516, -2.3367030727202924, -0.7971342071776666, -1.587780862727633, -0.7245767918701508, -0.805080542355262, -0.9869790752376435, -1.944033491843203, -1.705740032713223, -1.2111237747812837, -1.123735836424602},
    {-3.3807509187371205, -3.9750876471000227, -2.6089313894287964, -2.6259749852524683, -4.08554173675537, -3.7680134473544835, -4.387085658814785, -3.720653739841297, -2.92697570290796, -4.020267283679814, -3.8269601558073885, -3.4943994211559213},
    {-4.424138369001646, -3.113846295113863, -4.135956165108954, -3.2748442832770523, -4.382145139041843, -3.128221944753349, -2.5355549575563887, -4.093706894271846, -4.2221836908952675, -3.3078048257197934, -4.525063639896297, -4.183616799408954},
    {-1.3336379247273094, -0.7252339679447604, -0.4963964994364338, -1.0845267016886904, -1.2059176049522051, -1.1293960330046715, -1.0635339047517616, -0.2045204215254457, -0.26401336073302617, -1.3545805204061037, -0.2125721866830879, -2.6914811896539277},
    {-3.332648295112059, -4.045949811044402, -2.931617572828934, -3.7064396020694574, -3.0434618330710963, -3.8507159921923435, -4.271473013457945, -3.734991041492873, -2.921414403909845, -2.604255616202445, -2.6682826463296583, -2.6360333648365484},
    {-4.353575904539774, -3.236319874088208, -4.175394707142728, -3.2379184404443575, -3.2090073615476444, -3.159369175106622, -3.7480404295240692, -3.711446752188873, -4.3547391244943325, -3.0512362097212664, -2.7720051499509206, -4.557213010843212},
    {-2.46496410489065, -2.5612823540648075, -4.501808640474966, -3.2341307026337938, -3.72459826188335, -4.457368624490756, -3.832992275381061, -3.43515110602221, -2.7108673354006814, -4.337368596038182, -4.174391804844211, -2.729120211291993},
    {-3.369766753884639, -2.8344437678093675, -3.007335884997779, -4.177611217621642, -3.579220623209932, -3.004476630332333, -2.981326282946948, -3.925266982651588, -3.915089879751057, -2.465369824432916, -4.4695127781455355, -3.719201023722557},
    {-3.8255052598000208, -3.9949172080852233, -3.066456588458847, -4.237388529269677, -3.873281136707717, -3.204651305661609, -3.1245269981465214, -2.97071809351094, -4.283109836042396, -4.085875369208929, -2.6501148002466977, -3.830329299513286}
};

static const float b3[12] = {-2.212874397198322, -2.0969322107558095, -1.9547852066575793, -2.7367581134992505, -2.8848648317044363, -2.369862390150619, -2.214271691040948, -2.287159687933206, -2.023027498540012, -2.4746936436569356, -2.3364219937558626, -2.4608883447969205};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
