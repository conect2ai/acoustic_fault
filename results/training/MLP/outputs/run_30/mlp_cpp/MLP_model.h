#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.810416291191828, -0.5155520802535335, -0.451837484222965, -0.3986860544964798, -0.6806472942065944, 0.3158421365438796, 0.9277284287316947, 0.5922137551152882, 0.6267641969755432, 0.23590268649264395, -0.05116687058045659, -0.23281772395938152, 0.10877365578282835, -0.644897270043685, 0.4423476606815131, 0.7371708931706447, 0.6606208327301799, 0.09723537629161089, -0.3737134779927198, -0.5327289829610428, 0.8635123213880198, 0.18503214241372298, -0.1455020814290351, -0.361679558561351, -0.7276906656903305, -0.971889498139201, -0.07539854497304865, 0.6405095370604521, -0.12228482613217419, 0.02322746338133442, -0.6751820231119752, -0.3152680394135226, -0.17618396827407481, -0.7084158102314381, -0.4910433665111391, 0.5511074065320887, -0.0006696086448396158, 0.018614422013996993, -0.6961275222136596, -0.4404038866992911, -0.2876628639448774, -0.614628820044936, -0.7285190993908466, -0.6976162613343739, -0.5689603735010118, -0.49060664698906914, -0.4494982482234571, -0.19592117756233568, -0.10666929711399452, -0.0035235026608520866, -0.716945421118806, -0.7146641709829237, -0.6671065999593869, 0.7941118698456567, -0.9202132668202341, -0.0026485610563405856, 0.8637466079856655, -0.5580681549180988, 0.5421858002943971, -0.1748867467772224, 0.29010838197086525, -0.282428860717978, -0.4897971927694111, -0.7561420021969739},
    {-0.12544765941625505, -0.05370779779222283, -0.09558420240958296, 0.8540790096715825, -0.24182625367517308, 0.4252936158673332, -0.6093037675006341, -0.9309599096991599, -0.5344591113334491, -0.6516787930423973, -0.024358422943748313, -0.10444076831024969, 0.7966516434762155, 0.4354916794315891, -1.0248056995752093, -0.9463354184448288, 0.14836546149188506, -0.11055351908803895, 0.2753274377504157, -0.5926611723423137, -0.4422695608085971, -0.31062769536436746, 0.671131208182286, 0.02205382439461115, -0.6714332234233314, 0.6492187603835597, -0.13472746027445337, -0.29150149230669675, 0.7590478062042681, -0.30076519103440674, 0.10597746643523759, -0.6352326258665495, 0.09206798813467716, 0.3972417617172148, 0.006280075898260016, -0.08528287403691485, -0.8592457328808072, 0.19414531652166134, -0.25848595039946104, -0.015582890969327667, -0.2837191497670041, 0.17080074280198335, 0.7608330975379937, -0.32960695581089433, 0.7864333813257394, -0.5325985145062692, -0.40747976201269964, -0.3851027479646605, -0.4049227240831841, -0.8363686213376503, 0.04256852276147753, -0.7704526708207682, 0.03812668367012615, -0.6178120009853906, 0.5016545708987624, 0.2211605550064589, -0.9447518294615888, 0.07310674927002517, -0.6418416111493602, -0.2552262176380298, -0.44992006826466874, 0.5556036746082875, 0.21453954221238222, -0.3871229937668489},
    {0.2830298712127566, 0.8445395024829184, 0.7593574713640021, -0.014011237950498507, 0.5573325344274019, 0.09912652966629588, 0.6505007425201843, 0.6700874865097004, 0.8691163809514856, 0.7367737113217935, 0.34082339892056956, 0.3691379787753079, -0.7141077826725967, 0.6194993220806433, 0.2893737531851993, 0.0012188029573402361, -0.21047710970015387, -0.09886106066934283, -0.1548782914918263, 0.12707334762964867, 0.5196046369503868, -0.7708815162889783, -0.3164342228660625, 0.45729879144804914, 0.9134328085080652, 0.18586004727548572, -0.5377802157460381, 0.3973620259131354, -0.4823842976271925, -0.5110057775276411, 0.12471781485306292, 0.2524070221775354, 0.27109014512628377, 0.4656061524310223, 0.8530501501293878, 0.809578036957772, 0.7205908546645913, 0.7607665888655043, -0.18646260263323758, -0.3969809606952444, 0.041228552346861964, 0.9418842640835969, -0.0737779030307527, -0.2665523512383796, -0.023545368841986603, 0.6866546726310037, 0.5752875267119444, 0.8357730908096661, 0.8081772741157308, 0.5886859215828735, -0.5734760344679504, 1.0786641522554443, 0.5009814133378474, 0.2664023877448837, -0.3324551526165425, -0.18153747440983212, 0.6108965152645596, 0.8843252469819012, -0.2514949450595404, 0.6204640526509745, -0.6299908460938873, -0.5885788977134403, 0.7380440735365841, -0.08917360696650903},
    {0.9110739093523226, 0.48783335896971863, 1.143046897680402, -1.067075807985112, 0.35423194988386436, -0.5113106534851597, 0.6537772502067579, 1.2686599991655638, 1.0306862430059942, 0.9868808498734081, 0.05974112036592046, 1.015316256295009, -0.911982242533345, 0.49863956253180836, 0.9431157901836349, 0.875348198184349, -0.3837533668649484, -0.6229911389704581, 0.3692490398242625, 0.8916300379972217, -0.1984079977743892, -0.4590313349284594, -0.9323815049312826, 0.31651706874462016, 1.0833548110295106, 0.36231821840091344, -0.08366801656278645, 0.7046911553479887, 0.0937485091044601, -0.38086594272786256, 0.3065196240015668, 0.30077053291683004, -0.15325368228338784, 0.19889644294755118, 0.16698480089020823, -0.002821127007052174, 0.872791397114658, 0.4122944881480675, 0.47164413648217035, -0.538821234564951, -0.2391106202431902, 0.2916861759197084, -0.5041149629107581, 0.3627578773489288, 0.04310172526010106, 0.389128052385366, 0.33550060182929864, 1.0586106287911379, 0.19018456198219288, 0.5021391666371979, -0.7093284992488684, 0.9120945752135928, -0.09517812867586348, 0.10491659808861534, 0.332083127739382, -0.02239753139008921, 0.8768980726514128, 0.9650281394904063, -0.008769594180656159, 0.9010993912571553, 0.18421704969242256, -0.7194962904970486, 0.5180295679143422, 0.5404565914405485},
    {1.077831060303586, 0.925160335053941, 0.843409458430814, -0.05833463515595729, 0.9009116913035004, -0.5392744379363096, 0.19606494182112572, 0.38404555413704694, 0.9938106148832739, 0.8534651715992989, 0.299750620553244, 0.4627542414021831, -0.5433203903560584, 0.34859820128791413, 0.578755334251683, 0.7222302396723501, 0.0694181209883033, -0.35369714098500105, 0.21649727960567852, 0.5837363898944536, 0.649338552254124, -0.6617420441491753, -0.8235596817669509, 0.48284684222643104, 1.0142520242289939, 0.29716286306221346, -0.6328873692986413, 0.20066053014920215, -0.19464299447278044, 0.4948989667473649, -0.2910384928735037, 0.458630072687299, 0.17825600282553125, 0.10387605493341587, 0.5354595529266636, 0.5981559415484183, 0.6514979784021205, 0.9224192844954882, 0.5973240323474153, -0.10134625991802543, 0.4083940304197416, 0.7473278540406075, 0.6735098887487865, 0.2736531088530335, 0.1571697239046265, 0.8085917432192608, 0.42919148531409784, 0.2949109698600225, 0.6377247554516852, 0.4862326270310725, 0.13380599854152064, 0.8696372575917157, 0.689206383253179, 0.1302054017909137, 0.43156145487842845, -0.30743056099588956, 0.6174168310868822, 0.9478496936619577, -0.1235566198679819, 0.5498175963354549, -0.1884136954744434, -0.68927882986967, 0.6303693484645613, -0.02893079137584974},
    {1.0891477607423838, 0.913505793974153, 0.8967716566522567, -0.02764151214431229, 0.5900861161538233, -0.6253285936846893, -0.05036446529674693, 0.6186960495166178, 0.40783134179764013, 0.6838896434573869, 0.1672848539096353, 0.20279066671947, -0.86633800722938, -0.5585145147006165, 0.739177854926023, 1.0090549140574576, -0.69276891146145, 0.0772727210092944, 0.3488885819396296, 0.8790416268349327, 0.13406885628686602, -0.807301839578809, -0.6506401020423024, 0.8436592545893143, 0.9507315420768868, 0.3924425043253087, -0.6065149029535356, -0.03287141445956198, 0.045684609397334756, 0.5110599527334959, 0.37422822906318315, 0.5586617953828383, 0.43545277335954213, 0.5547498907950561, 0.5870738795904039, 0.3974015449966254, 1.0893909725076696, 0.5953695745938192, 0.6699239177362256, 0.14854623180455354, 0.18100145981264631, 1.0621472594756005, 0.24156614722514308, 0.5564664778501012, 0.276706390526582, 0.9431527792213182, 0.7687254505586572, 0.9933790882965554, 0.5487588938879001, 0.9157148785254621, 0.3181229440183454, 1.0454566111200216, 0.6215097478750499, -0.009949264970318308, 0.5154120152043707, -0.2794038363775788, -0.07461539075084013, 0.6621920461210533, -0.29483026274316826, 1.0782536608601514, 0.2831401077110267, -0.4823549851894828, 0.6274716903146867, 0.9101537680422691},
    {1.086829130767992, 0.6924700072991414, 0.7885476081347363, -0.287286122958438, 0.6831494057338172, -0.6585697888774719, -0.2025752642953404, 1.0692337739366482, 0.5768134161623866, 0.5821946625984304, 0.21029381882539794, 0.3666623800973256, -0.5770110922923931, -0.04402905497452601, 1.224887025253604, 0.5936313264508495, -0.4377821820757973, -0.03288591302122918, 0.6540759048947088, 0.7530009162749419, 0.25252415151473184, -0.6254143041175826, -0.4274435034318251, 0.7492494060995537, 1.17183173977505, 0.5582388171685586, -0.20099586199156103, -0.08447315321855929, 0.27201252592646574, 0.5573927820715024, 0.4692106137862041, 0.7578945919512673, 0.33000270740933435, 0.781998294888097, 0.427252935478388, 0.10350166072323469, 0.9167672788483824, 0.3955905947412571, 0.8002116765052039, 0.3117346929381123, 0.05324712149328074, 0.9860560417717951, 0.515783820937931, 0.6518439303549242, 0.48224977538508196, 0.970569282597544, 0.8841409707536144, 0.901179188349131, 0.33480161569881145, 0.778675938195574, 0.2524159409252186, 1.1241900632964672, 0.7710372712783519, 0.03647865882579627, 0.8227449531668213, 0.18947474019434563, 0.12247418352440484, 0.5223024744269806, -0.43361624834583035, 1.1098491469728848, 0.5387008683246036, -0.4241726544870829, 0.5389036430303469, 0.7026878032059019},
    {0.3246383380799443, -0.03536205689363333, 0.16250259126168398, -0.4250655213522466, 0.08212223363226392, 0.05167354000898454, -0.7663236953099243, 0.02525250086561304, 0.277447874594519, 0.5275297850139281, 0.5088024189226352, 0.4826908240118293, 0.09922822349591484, 0.9044713394631153, 0.3410869217973025, 0.4691822100368342, 0.3656718152896582, -0.6790547176127126, 0.15607966496099202, 0.2697078869126021, 0.29689811852408754, -0.8203846482612556, -0.04146742025914062, 0.4359095794941257, 0.05754639384791123, 1.057269811736133, -0.8285570546153485, -0.3188195104989184, -0.22573388071851372, 0.8136530818668146, 0.2341594384225343, -0.12963766340438398, 0.025309919276473435, -0.24198316603562703, 0.32152298933614837, 0.4432930674650111, 0.7320940551802255, 0.7624344233627353, 0.11036349647065709, -0.4229829109509284, -0.07243711867910839, 0.5126740031112496, 0.5832370377017844, 0.5779812024728258, 0.6725874286332274, 0.23911698410970156, -0.18517884104218033, 0.11721663100289201, 0.1503366024788739, -0.01221993366031821, -0.26290530534671763, 0.05202544362855696, 0.17332422242514792, -0.3972178685204822, 0.3477691820363006, -0.008742373394645281, 0.009521995914818206, 0.4498296453259304, -0.3254709799639295, 0.23517728190511028, -0.4369803075966704, -0.8288305812035287, 0.46788318448598115, -0.2770503370840599},
    {0.8488299289652673, 0.8288155299430218, 0.6697881793783536, 0.7941827650794124, 0.2472398500815386, 0.29349368117962493, 0.08862015253777858, 0.19145604885438802, 0.43746156811961223, 0.7500493583063806, 0.14384783996895514, 0.4924364429134858, -0.04350496782176909, 0.43994781642555025, 0.07111164744630304, -0.04068592743194702, -0.328952372416041, -0.35857227891904747, -0.0679942418247565, 0.6576440170659501, 0.5784228016131795, -0.3752250635702432, 0.5488598894894211, 0.48001605370832257, 0.5629591654634284, 0.49481809010474753, -0.4704002074723274, -0.3262613463808681, 0.4118942440628981, 0.7483507788237401, 0.3274334663325968, 0.2853771398800563, 0.47001193805446484, -0.014692323227533104, 0.5188405709354267, 0.3378396595927615, 0.6791143106669738, 0.5447269633739737, -0.1785651968151751, -0.22392402485696744, 0.490287880531229, 0.43651647446319347, 0.468429302922152, 0.43941246781713916, 1.0109622338387125, 0.7433384650146697, 0.6501591799460095, 0.35725103699348026, 0.48553509694400115, -0.09322739380045529, 0.7576557644667737, 0.43259244928877943, 0.9005852351293238, 0.30174431490407866, 0.45024058430109076, -0.1680285347263801, -0.1816728396796242, 0.5506396467665599, -0.09514163238607683, 0.2902329600880516, -0.23404773951597635, -1.0214043272824491, 0.5704295883181799, 0.065988389132382},
    {0.21354982948554826, -0.43935211753402753, 0.1167824436179554, 0.7752115271247673, 0.06817213941891465, 0.7569868608132219, -0.9144083568782205, -0.7694077854747284, -0.4334891930469573, -0.6080543796870215, 0.4255820925400911, 0.4393140766628233, 0.8923789967183023, 0.8464781564215175, -0.7550510554062335, -0.3342568470201645, 0.1378763332381357, 0.055274474394957814, 0.4536597046527391, 0.4796988948770584, -0.7666030095905354, 1.0416890863512207, 0.7238491141188876, 0.06361995811086368, -0.3631035040201927, 0.9870776588012694, 0.47049866025717596, -0.13880615600897406, 1.0012939147401343, 0.4527135584716536, 0.2562900129376739, -0.42329226472936743, -0.06363309801475171, 0.6614715216514572, -0.2622951620706505, -0.34327785196219107, -0.7180342088135988, -0.09762463862292507, 0.6046876702705545, 0.30037683961998624, -0.09585222296827185, 0.14947275423151068, 1.0896019176497338, 0.6303396621039653, 0.23105527703656817, 0.5602184990600921, 0.1182887597537126, -0.07290259160410635, -0.6897895901383848, 0.0018857002359365651, 0.5755074469380003, -0.24413655572565246, 0.3841002537178576, -0.44273102417938764, 0.9990555324062146, 0.8277360072658138, -0.7797518892628534, 0.28994290926221195, 0.5682717171594502, -0.4614633000069238, 0.6781656554522002, 1.0403609401531002, 0.11057456771228792, -0.2910602247628952},
    {0.7237763563312243, 0.3014740796143134, 0.6694230758319659, 0.2937286361713691, 0.2797310252918445, 0.038894730279054775, -0.5909071215196126, 0.13042341410849376, -0.024927199952110384, -0.012663006626883628, 0.5797684467935249, 0.33663313125561767, 0.4384683765301412, 0.2857650835389568, 0.4444380581586687, 0.01199792477703842, -0.35341211326785293, 0.17175889377925793, 0.4531082274984931, 0.6311591914673006, -0.5779957830479286, 0.5693901791526147, 0.34391080211045666, 0.2685283376823416, 0.7500599887849095, 0.9133831818686632, 0.7272633624133784, 0.03576775810912901, 0.11290954625512539, 0.6017385283901852, 0.30569478852953497, 0.26026144863104733, 0.2053125173394697, 0.6592571506802468, 0.4276379017724051, -0.2670930897242678, -0.0326955900174556, 0.054142712857391334, 0.5342701254410813, -0.04760066321900558, -0.00812385275827125, 0.22480228236326197, 0.6424312304610614, 0.49130171970042674, 0.7302375209286119, 0.600775470827993, 0.3702859648782806, 0.5325679079823862, -0.03906960913681122, 0.11351730176920606, 0.7115265964277622, 0.2848766450440112, 0.9338038702491845, -0.6193119321844345, 0.8760418865701185, 0.6825299632982258, 0.19585909223045922, 0.11947842422534688, 0.5488094921532953, 0.371753917456728, 0.4164175603164644, 0.611554956749103, -0.40981546528152535, 0.5988769941035104},
    {-0.46457240087781815, -0.009439968271249748, 0.3586124876625853, 0.48734495989421295, -0.26038033942367034, 0.43525945568224145, 0.521943309381429, 0.7143687582388758, 0.4645578085534364, 0.4239801252398845, 0.30333457581992324, 0.6622035418036394, 0.41896056530517034, 0.20198064413526412, 0.09879073260877165, 0.4929081670878357, 0.2155990615589131, 0.26186116974382834, 0.7660724633151431, 0.058698545906098416, -0.05145289039967581, 0.7682191620308078, 0.43150878562478207, -0.369286846125327, 0.3358323458762222, -0.1510796624840074, 0.22779073245019077, 0.379830839738792, 0.7332732286310869, -0.920787339267685, 0.5490738043120909, -0.5357735981238232, 0.09657249469500699, 0.15966546206164745, 0.4151713582927651, 0.7007768847782833, 0.5773789066374516, 0.2515212972502598, 0.015862489944346716, 0.05913951058406505, -0.00756356324591435, 0.2874847598242457, 0.6124373038072262, 0.10088555167352195, 0.5329714476373344, 0.050217059251460326, 0.0941001006023521, 0.3510829829654785, -0.1370659096925838, 0.1633866151138002, 0.00446025271709373, 0.5379538477917073, -0.34379136659816695, 0.29361034469859304, 0.2797945107148482, 0.4628052478133808, 0.704454677432661, 0.44682039027584175, -0.0008509390370086138, 0.5743661268220824, 0.8050381766139967, 0.13409838205786134, 0.21217313158516335, 0.32815370475738737},
    {0.07090782823400428, 0.40957219822020147, -0.6339544045214985, 0.7210616211299133, 0.5717073053176389, 0.5674678563145227, -0.039403474806844814, -0.34310300568026625, -0.6273778252583151, -0.49109100405742834, 0.1840661802357604, -0.49667849299327843, 0.49026895311919966, -0.23835615462992446, -0.30894263485999107, -0.8683741032928665, 0.2091019903738564, 0.750174497688477, 0.19550127077466373, -0.2103348021441028, 0.011553349795043863, -0.517425395220955, 0.6485001570001802, 0.22564826114752043, -0.5871916121278786, 0.026179276254433278, 0.35356539312184454, -0.9170519857977506, 0.09191861958831694, -0.1437251945552065, -0.0369195890096966, 0.290414913630134, 0.9541495539602932, 0.22474574024320582, 0.40652245378309293, 0.44239343071950016, -0.47209102304772843, 0.6319445464952365, -0.1568816643094327, 0.9501168070428488, 0.4529701263582473, 0.6578532790586962, 0.40210150848731463, -0.0018595449399206327, 0.05435387221794895, -0.1119748721414159, 0.452850934988232, -0.4399952153292677, -0.01479298804909612, -0.7687115785575807, -0.06432392294025083, -0.26193625074151283, 0.5321322806921317, 0.06943193116587473, 0.19284928545574298, 0.13471433619864126, -0.4790570531538816, -0.0196577515643795, -0.3251674470146314, 0.5724596297996258, -0.3655240390604739, 0.8739631537758864, 0.5685616353746097, 0.12917253133437875},
    {0.3390253748546581, 0.2470108542969188, 0.6433423850689428, 0.07181294817439562, -0.5047513018246271, -1.161046809858865, -0.487979703353474, 0.49336682101729934, 0.028817900454909107, -0.3783495822213233, -0.41826143983550645, 0.5478551343161403, -0.8793205119644848, -1.0217409069689847, 0.6910327515071971, -0.018439828508366337, -0.6219930664375686, -0.19028507321307125, 0.3889341508965996, 1.1380443055534972, -1.0793897895264555, 0.6746946768406815, 0.3536351822047638, -0.47651905814025125, 0.8407886591549414, 0.1398297606020137, 0.6483538637581394, 0.18891926898946307, -0.03198189339030557, -0.37477689043754553, 0.6399550732983587, 0.2622162275821265, 0.06699516082680185, -0.2765834678360751, 0.14963720082469956, -0.9172366550554104, 1.0889941141336656, -0.9085034026308032, 0.6427581483577252, 0.13535616213808283, -0.6042827933095092, -0.23158295693609893, 0.217598152691351, 0.6622731116809946, 0.32614055979717044, -0.184367062090183, 0.23935132276398427, 0.7036678152912084, -0.7294929133409235, 0.17871275492814004, 0.6546880347839591, 0.2187105495282012, -0.17900207727293102, -1.0970777984104008, 0.2972463908892974, -0.0087883725233934, 0.39929331873537177, -0.3575220723339516, -0.6194060906447542, 0.5694766433630513, 0.7313960567569034, -0.3822363929986067, -0.46533397005852367, 0.7744541777528893},
    {-0.10643283843072314, -0.062107899277678735, 0.4660771915963022, -0.85637261824268, -0.7923777260510425, -1.1489743979915643, 0.19401984917242646, -0.05062907677350948, -0.48064945137590726, -0.1261292701869561, -0.7268698742964609, -0.6614566068850224, -1.0977861159366988, -0.8029347645890886, 0.891678014488222, -0.011474051087595744, -1.039699737765809, -0.287032727638879, -0.3782440402211904, 0.936589571843062, -0.9820635460760109, -0.7070631857434385, -0.4876123969334798, -0.8303913489233793, 0.8422295499127438, -0.9106915834034628, 0.3824296482391696, -0.12016367183869824, -0.5191747611269711, -0.478647784513179, 0.5448234904352742, 0.4862078790170885, 0.13081562735180624, -0.8067063596363483, -0.15900349360097277, -0.8043806695832054, 0.869015986797287, -0.9052479830984127, 0.0693292926238389, 0.0861351766645773, -0.5783356362951397, -0.4293913016435793, -0.963334050246621, 0.5743695178502147, -0.4913278021862305, -0.4330218424498935, 0.1769587367512729, 0.5822793750862053, -0.4308832169592468, 0.19238422255418403, 0.1783980990522921, 0.18563652835045744, -0.34144676643209554, -0.6988591610468811, -0.6667096908473279, -0.8618152079674594, 0.2126234136556532, -1.0161527993424018, -0.13687172697723382, 0.7034806917217818, 0.39943575979528795, -1.022424214609416, -0.6089827353263391, 1.1241612136410133},
    {-0.24576651511853212, -0.07932375657690809, -0.389525957497259, 0.301079851972483, -0.5184671116990767, -0.4380698570569042, -0.07830364732905658, -0.9738775399110883, -1.2425358548731114, -0.9375703051081645, -0.7948526743783155, -0.9598377715732316, -0.5420616426870055, -0.8957707663061015, -0.7119165182740597, -0.6213517871562704, -0.8488791904199562, 0.4433105571166981, -0.5658315476711878, 0.3813590023062732, -0.20169127101965845, -0.465109975594627, 0.46758680662969604, -0.4970748770815889, -0.19396965798677815, -0.6237880646137002, 0.2496092454770653, -0.8227900925338382, -0.9355774358902599, -0.09715018173524298, 0.5527654959238285, 0.7494033412950507, 0.5304184781718753, -0.8335004824323736, 0.1017150603954205, -0.2664620503850122, 0.2702266894085693, -0.5915949717694241, -0.4147662370283149, 0.5266945902185948, -0.17282097002878327, -0.3487464263149001, -0.858515186057664, 0.610283426988614, -0.16357129329032155, -0.5491724543273329, 0.6203485848641208, 0.10341008203128667, -0.5131656441535655, -0.6154798547125268, 0.7287562263410966, -0.7258730875305593, 0.04935742119298938, -0.2852446899834479, -0.3910865529630344, -0.3543243339813468, -0.9954759852547336, -0.8631865586150081, -0.49213451027562133, 0.4260682862906327, -0.015119344334978359, -0.11651319787178668, -0.27056482319304737, 0.47210780176696876},
    {0.5500529732204282, 0.0899182491475496, 0.8920645826255095, -0.6995069711201489, -0.8039525851890494, -0.8790934350769442, -0.6458874737239273, 0.3608017727768457, -0.12012481281007875, -0.13786802330841708, -0.6409215422948255, 0.22324217485016756, -0.7425093714387994, -0.9857986697563027, 0.925091160024896, 0.14214663967382518, -1.1346831453066104, -0.09393057939701166, 0.4925935266089921, 0.9821490724596716, -0.8395810997233615, 0.4491614553483822, -0.17754911534493817, -0.5535877343558229, 0.9585698362792949, -0.006614965423683964, 0.9674452861379375, 0.38433503095491994, 0.691073531238908, -0.1791562865584432, 1.2053126184693468, 0.029403979515571423, 0.20786215251539925, 0.10275268962775201, -0.2201257025912572, -0.7532677415366349, 1.0164085206467905, -0.8502292465469198, 0.7847800815679341, -0.38666414588755554, -0.8159552684210747, -0.2954028638133178, 0.14219106400136639, 0.8536579047460099, 0.002004301551299762, 0.22404502098757234, -0.025961496917196358, 1.0639632008368718, -0.9746318694455168, 0.7330820781339628, 0.12451706789483871, 0.6726184473868022, 0.06092565527056898, -1.046170751759991, 0.42927013138850445, 0.03508869870114983, -0.08262447243011205, -0.2910312174408061, -0.8192426747080553, 0.6047242632599171, 1.155476616624607, -0.6085005587006268, -0.3338024008073486, 0.8749647507685959},
    {0.176959662438872, 0.588071448064903, 1.0804133780373553, -0.18398245450455983, -0.08621495039593899, -0.6824290621693716, 0.13336961693643257, 0.3169561708532065, -0.09397682121970302, -0.1909904197798338, -0.5058638235071464, 0.20030921525357517, -0.7582228026922315, -0.9330161861957599, 0.7389315278102777, 0.6174410640549103, -0.8957891269481704, 0.5413579015020226, 0.5948757892727768, 0.8958724227119045, -0.44091361154438785, 0.042103828724164384, 0.28742927277574715, -0.2401916082854957, 0.8759390124860807, 0.16899818997922092, 0.9599279935728741, 0.36797501392441234, 0.42214576519899527, -0.13179576504649654, 1.0146776715339927, 0.5180834000770778, 0.6994685912413698, 0.07440651763551918, 0.16129395147665512, -0.7688382785697457, 0.8088345838646008, -0.3503812170115541, 0.27887859358302736, 0.5896853236787301, -0.35665984649017896, 0.059745016215592195, 0.5053443259331936, 0.614053647999601, 0.6946537611925568, 0.25045752212682854, 0.5371364407938107, 0.5308735575559386, -0.39506066756999464, 1.0597528110945802, 0.7779520954275291, 0.825489852701376, 0.07036612324515781, -0.390832374976059, 0.1791195578571381, 0.3577181988888885, 0.1899074216826445, -0.14685404793795004, -0.5909847823357851, 0.9521621982432564, 0.7798345741565728, -0.400126468703569, -0.10201751757382578, 0.745676165702521},
    {-0.15402336766838168, -0.02264416376273156, 0.3926898791817815, -0.5241303871634693, -0.3498590196938309, -0.6926230902295442, -0.09696477693929516, 0.8887466014692827, -0.16728933744773677, -0.33340853288781597, -0.6612276204443006, -0.18308899246481655, -0.7679405585206898, -0.35111951470440794, 0.6085546602628332, 0.19225147767569123, -0.41971855189273566, 0.10080560443057988, 0.02018261108233375, 0.07995059044662244, 0.39924646942563086, -0.26375820268207545, -0.2754951266991125, -0.20551509385436778, 0.5050467168650121, -0.6770884235131013, -0.06440931314819155, -0.010957868870341935, -0.17059165943098153, -0.5070392151247146, 0.569493296001016, -0.052786391494222894, 0.1806103064312536, -0.5503321471550177, -0.10705157325824302, -0.2657498790119074, 0.5045011248183728, -0.32665854584962406, -0.009793032113765034, -0.07106254874570629, -0.05543810901304435, -0.38227097989817455, -0.5056604169759037, -0.12606349414312604, -0.11530408530772876, -0.558372434099939, -0.17118511317972662, -0.08867679618902284, 0.15246533341148202, 0.6620689054669688, -0.6300816940400982, 0.3627291212481894, -0.49138223340051207, 0.1838522227454655, -0.3170296612537016, -0.14065871880620828, -0.11581738866769652, -0.8061236716518244, -0.5333849951306431, 0.5999152581678302, 0.3230807037792293, -0.14472660052600694, 0.30131105919535084, 0.19248148349950392},
    {0.38066017213007375, -0.031081329862681775, 0.19300642470456153, -0.5269565123006718, 0.03123116921476448, -0.7344675109371912, -0.19231962654484477, 0.798202159420671, -0.1548987950526066, 0.11829148278753314, 0.3213888896914819, 0.6657265426972508, -0.1583189316985788, 0.3130290795658034, 0.8395709904998485, -0.032213782190339484, -0.5929296908113623, -0.14969970679008698, 0.6770919541242596, 0.44961059261699315, -0.37871135452097454, 0.29933713157410835, 0.48794426637789423, 0.3604861545543254, 0.47692079444126845, 0.6147902428696677, 0.5786259629337696, 0.5000524306910978, 0.875447997891541, -0.5356635620710606, 0.34133521981313214, 0.6145219344225069, -0.34404575417158456, 0.048992644703771494, -0.08079045940485384, -0.8942823432516973, 0.21220118565446253, -0.08816719764244882, 0.7488590308555343, -0.5204786625690023, -0.21738958958925675, -0.06160378110227932, 0.24620560739704622, 0.25505138060776467, 0.34371478410846307, -0.2799528929441512, -0.3515656303442697, 0.814273933543592, -0.5286948433820174, 0.42153843034063826, -0.7369549480089971, 0.661212676534895, -0.02804250858871082, -0.5226341053096081, 0.2214971986883174, 0.16345375887479363, 0.7236538174305348, 0.1966027026851506, 0.5180704491777688, -0.3476002338191412, 0.7525576048680677, 0.3820504379900127, -0.817721672238804, 0.6475768095507797},
    {-0.1184511677577901, -0.28906293184662996, 0.3731464189809614, -0.9705251216467199, -0.5219234959361111, -1.022140696215254, 0.009995436045472266, 0.5673447179212785, -0.2750801896717803, 0.21904165658329058, -0.08001743977067248, 0.1385618410811739, -0.7020767308744055, -0.6208867341938803, 0.8606660514337675, 0.11540944426289199, -0.1994326081043061, -0.028000575100499636, 0.09276834066561737, 0.3300671096223165, -0.4936677255867052, 0.3890803770239603, -0.24343199055585255, -0.7195590560440646, 0.499952062309911, -0.572592699003868, 0.8369787187894813, 0.5753549364776875, 0.13814477577405918, -0.23622600812291428, 0.6124803130820669, 0.4040525082485289, -0.44564960981366114, -0.6323462474321244, -0.629225694490464, -0.23944774382920117, 0.4575259382413236, -1.1871194797997728, 0.24320160668367216, -0.6101042482204984, -0.5158094151202607, -0.5508846863452235, -0.5451476275801685, 0.7470502462245178, -0.2908771226688219, 0.30966302907871013, -0.3712386480394951, 0.6982105083309323, -0.3719229311488247, 0.6056621122610802, -0.24085825950001089, 0.39463189494887907, -0.8232091067973475, -0.5162467868276371, -0.47774221907644, -0.273420630179744, 0.6482411386556031, -0.4640329262452959, 0.15628480147590634, -0.4839349243352552, 0.516774159307002, -0.26919751812398734, -0.7606933674655892, 0.640946777866576},
    {0.2334737453927504, -0.5719458439673397, -0.06806732229904024, -0.8522059422420795, -0.90986517989534, -0.8574652871420531, -0.8188253558474535, -0.05522075109135004, -0.15085994752057333, -0.7727467837057856, -0.38581555446599386, 0.03567174517358379, -0.8398211000235825, -0.5666537486167028, 1.0278438486707, -0.03427948927894253, -0.9724383642642703, -0.7390736013156786, 0.9024436562415823, 0.7416168790936438, -0.8260018424317745, 0.6899003663531206, -0.43040242497283426, -0.5626671767194621, 0.6325215518411816, 0.02636042115360895, 0.6506066071240683, 0.24015381617591752, 0.39640552537938156, -0.04580719949009839, 0.40092019944414475, 0.12168682141229667, -0.6934934876823533, -0.4851306889003252, -0.6474957227243068, -1.0850131260144056, 0.38230929917128104, -1.0295142864285445, 0.7259514354281309, -0.4115987162043374, -0.7677607037372273, -0.6941647000269695, -0.23011959904786142, 0.6943032668005154, -0.7538520053599748, -0.2149987184423078, -0.5173553065972202, 0.2403143163241955, -0.7252519468008927, 0.02036285292005284, 0.014630420392799307, -0.40409031037383625, -0.49697577865904125, -1.2146992490322506, 0.2601735090550245, 0.3605016387038455, 0.0067068192624524774, -0.5038711699486561, 0.043652069741264975, -0.22086862288642134, 0.956215320423325, -0.25278031441278376, -0.9871974007406779, 1.0021464683326806},
    {-0.6655464788362931, -0.7151372727929505, -0.26749221546279506, -0.8325696713613281, -0.5745778702545431, -0.6351476912185345, -0.5137514504690386, -0.08885563919517075, 0.045408669153580446, -0.6696142759697921, -0.5486187379374955, -0.24535724850215418, -0.2978359971665102, -0.4800889930461947, 0.5769583198738008, -0.3514760077180772, -0.7173848315382847, -0.354539655616887, 0.264909381069414, -0.5756127944374432, -0.7913217756296209, 0.22315302056612293, -0.2206005541101049, -0.5226488303254646, 0.17359227094754964, -0.4852233547132242, 0.7765447106402664, 0.3032065988475323, -0.09222527745404331, -0.7830961073934048, 0.5251433824646139, -0.23822455469061593, -0.657816992960517, -0.755991532540127, -0.6982981096222188, -0.9689050388912667, 0.20287835990474468, -0.959694491444624, 0.25474975306655545, -0.025613333421054315, -0.8023523878986575, -0.5515932614945875, -0.6962875640227164, 0.25941914029197094, -1.0241924928346873, -0.8082622903716009, -0.42775237851213355, -0.21213854242801297, -0.8173100940093335, 0.6208109738439569, -0.8715250472988172, 0.17141886796233305, -0.9584986812450109, -0.5454793079971246, -0.6271658382806696, -0.005645864365840669, 0.388175973310378, -0.5392653376356171, -0.024015295275022736, -0.7893101506695696, 0.6334563775845379, 0.03150693405297022, -0.5082953857925684, 0.4801040398150383},
    {-0.2508262457596042, -0.7497034953191706, -1.0500318453756265, -0.7499603167692377, -0.4231514413885005, 0.07577166295159156, -0.8820608954178312, -0.23621258706870904, -0.14862975478269402, -0.29284439656934735, 0.524140099182959, 0.8295109758263073, 0.04121606560037706, 0.750487582687238, -0.010166842287537671, -0.4123592292519155, 0.39494533505724677, -1.0701099461754933, 0.9547841350887657, -0.7299823285460018, -0.5924331393971748, 1.0862178032385241, -0.6116198112301181, -0.5725895791989236, -0.42781282059447345, 0.07741562673566181, 0.905805489958061, 0.12702248595062718, 0.6908045905437401, -0.4654482028055615, 0.5723099385669499, -1.0605362023614129, -0.8051367163550297, 0.23387608823144884, -0.6835968764782927, -0.7559469458411394, -0.6233099470132468, -0.6204609503650849, 0.36546557107124233, -0.48860922494893716, -0.524614085152233, -0.7125166332739505, -0.12318943008307728, 0.03979111312583877, -0.6119898180026323, -0.034666503705910935, -0.7188185071705493, -0.6236487322851815, -0.5166892752190781, 0.1975322443263726, -1.1149158468470974, -0.25369737064514336, -0.7824863894861057, -1.372733606786489, 0.1405893243603457, 0.33619605855743145, 0.06875641024779279, 0.06013416270183245, 0.13289708298193645, -0.9621817321546503, 0.2699791678016676, 0.4102267599865838, -0.38018012237261783, 0.06999585536189723},
    {0.030014970240167232, 0.05125191448207673, 0.16383114996133388, -0.5068240853310679, -0.44826994352869054, -0.21458384967638222, -0.04731389173172536, 0.9698219645513854, 0.930872454952038, 0.25992304048877124, 0.6755336236317321, 1.1762600354214314, -0.2791303423745986, 0.29763294365359083, 0.934615675419847, 0.768054186217622, -0.08147397010012455, -0.6047257920102678, 1.019600277647912, 0.2716721239126313, -0.22849842118211688, 1.0441084761121597, -0.5457064070032628, -0.0013522873170630169, 0.5069980716357598, 0.2617482584364377, 0.8712654316928543, 0.8515413796725617, 0.9428058945423048, -0.2264031754934828, 1.0855025207671694, -0.37712342704832436, -0.7432368943550134, 0.299736928035615, -0.5001166514212767, -0.3839066844289922, 0.7696047504936407, -0.1520356698258652, 0.8453750074120916, -0.7711772605920963, -0.24887925121872612, -0.13478506163907336, 0.7234500547762319, 0.5972252743618356, -0.1295328640140687, 0.4484426798727279, -0.1661004198629391, 0.7372505998586275, -0.1589418496490128, 0.9344216906647766, -0.4875224890396396, 0.7882564167374209, -0.2595639000718681, -0.5423483707496415, 0.713558053019312, 0.8196817780544684, 0.9888118747789592, 0.9007822501969768, 0.3472393013591532, -0.49459351546800673, 0.8255352669433628, -0.07761852176924217, -0.054358314604978634, 0.7014067324188016},
    {-0.7890815792594944, -0.66957170932074, -0.6176045173033037, -0.6585274101803553, -0.08724624108448428, 0.2768969926929267, 0.0110437061370907, 0.7908886836794904, 0.7284960831949461, 0.555543624473143, 0.7777575710032003, 0.9386879213285837, 0.24234136749879154, 0.6759110335509468, 0.673072134645329, 0.8328552958662634, 0.890275370279448, -0.38268221125619367, 1.2741973873835826, -0.5012365846503699, 0.09829746212746127, 1.035326639858629, 0.024413571854856903, -0.3632434591212807, -0.41322869903957554, 0.001635237746668061, 0.5606286076921884, 1.0111873096558321, 0.8436667727734822, -0.3554789153971435, 0.31113864115385687, -0.6444268201175517, -0.7665102521991077, 0.3549716319283117, -0.8934104880733938, 0.0008613183078160029, -0.39928601590003665, -0.10418636044962969, 0.5856044742690248, -0.6889136211564034, -0.1816701936924938, -0.3984643925688461, 0.32663221597201697, 0.135079162396038, -0.17037528038630348, 0.43286941069568935, -0.8294686622999359, 0.07469820064548462, 0.19748605440955996, 0.6347955804842137, -0.85820228583837, 0.6186565623354789, -0.677500919558334, 0.4390367553832733, 0.46711947478792887, 0.699094553405252, 0.5859248641637079, 0.8319967449043779, 0.5797732110481757, -0.875253225178304, 0.6696376362676327, 0.5992205433013613, -0.15600757881705826, 0.016604118208943284},
    {-0.4900929793613465, -0.6641524718354789, -0.9125773796172127, -0.9990581985159527, -0.48777874570766444, -0.6067498634418191, -0.5493742827105921, 0.4034880423878995, -0.004943863862796384, -0.5266876487736467, 0.20502017185742236, 0.5546234302860834, 0.2848456437938879, -0.26690904987730396, 0.47124017192363366, 0.5114670003293177, 0.21426853526698744, -0.5668926033644198, 0.6185656472608041, -0.658156196225189, -0.7706627763414432, 1.2649609246186433, -0.06979296553742953, -0.48084729249835595, -0.07999840939745621, -0.6448798865274742, 0.9860509051675299, 0.8384563305877913, 0.7882286283150903, -0.30494998049920785, 0.8129064442987839, -0.5283147292784601, -0.5686726540538186, -0.4460019447657136, -0.9034887614026107, -0.7459011048228513, -0.1752739742750506, -0.9538866004691412, 0.5767225949683213, -0.23642837541337797, -0.6818299629277587, -1.01392241574207, 0.021959373837903043, 0.442737873237844, -0.3530743343085082, -0.04756855555957935, -0.9162536043503873, -0.36854019531331783, -0.4646391104417425, 0.3854081596760648, -0.4583464989808645, 0.18912679902082538, -0.9270890775515261, -0.2746267423989946, 0.5860072597582816, 0.5628861868469518, 0.2910985621112538, 0.05763573464371938, 0.5215350149497181, -1.0292302915767981, 0.7279392796838449, 0.45868521200885515, -0.6746744118502371, 0.6155393542037162},
    {-0.030430631963136577, -0.4056702853164196, -0.6934439808332015, -0.7391068731448153, 0.5417448752582423, -0.14950791323495186, -0.6020402987349136, 0.538351269678068, 0.19228727774496202, 0.4397423880043642, 0.7611744333873782, 0.4952528775952341, -0.11509789975858285, 0.7986597811215618, 0.47077225543785606, 0.11052030055314845, 0.7747741859532347, -0.38107311384473674, 0.7765664343006555, -0.7706060031374412, -0.1423571469274502, -0.26497336030539603, -0.5223186111705231, 0.45450286627992453, -0.1488287477813474, -0.16771763602250409, -0.15541768903845898, -0.1848154616557998, -0.0949901582560853, -0.39649354872862974, 0.33035102981513254, -0.08546974542672515, -0.5945665354082194, 0.5865536575974611, -0.297509079599898, 0.18721166007991843, -0.007067598485245781, 0.2253506093129661, 0.4951554824387899, -0.4167548196784381, 0.5044708301612097, 0.29111188381395053, 0.28441791593374766, -0.2789593741363031, -0.008529235250882365, -0.0921599232285004, -0.48879839603430597, -0.08180981691568846, 0.5157510367370133, 0.27887771287375784, -0.7144226754992645, -0.16380973722458578, -0.011022975836584625, 0.18225586425204676, 0.9261522914839485, 0.6324589808210583, 0.06364924210308613, 0.7121557646691248, 0.8859505080105854, -0.6157505263070424, -0.19727181697617371, 0.513528880761325, -0.1739625828271959, -0.19985124716444846},
    {-0.16471367413214041, -0.3490467929916062, 0.14397335108403564, -0.8405157350923008, -0.4665000795995432, -0.7833601316406994, -0.7370272177432386, 0.4869424880977777, 0.9017722035363246, 0.6726842685565315, 0.5453155628618814, 1.0064916103737962, -0.5063862862049678, 0.18804631895544593, 0.9090315690034619, 0.6077739157375248, -0.26689827581476605, -0.6050434821405488, 1.014599890522584, 0.4734715868022833, -0.8041397138036616, 0.7861869912270345, -0.5164500730347965, -0.6422282731845707, 0.8983414379601985, 0.12884631855339598, 0.5409640985865335, 1.194643121656328, 0.4353846197706218, -0.5430352572376539, 0.8078145404916, -0.38396747549139026, -0.6576537163774019, 0.620419917679884, -0.5705012560744852, -0.47261584210453267, 0.5053640690569644, -0.743673728036521, 0.83522009523632, -0.6003976327675933, -0.690508251216546, -0.722719694701936, 0.23636871936550713, 0.5493022222498259, -0.06281665117847447, 0.32845392854961497, -0.9066034142924035, 0.3893758744323683, -0.6766096895107547, 1.0556883930037284, -0.5926481511728419, 0.5590492202105255, -0.6662366229271762, -0.5817344054764393, 0.7458115333869748, 0.3433316166953044, 0.54744915575089, 0.7720347195562458, -0.1129962139663978, -0.35288671427388163, 0.8548138661694277, -0.11179969819435329, -0.5581359311937132, 0.6003504440148328},
    {0.05889223995768751, -0.052325083584466074, -0.06037914868752222, -0.7706405075983549, -0.40596789651890675, -0.42424684882778196, -0.15867616584229421, 0.21990527406331725, 0.03755564182333503, 0.29654037188038146, -0.22794689282363872, 0.3145352087105041, -0.5006940383843828, -0.6594220834235592, 0.6017934349868899, 0.40394205883925727, -0.48862003026051026, -0.6548123945611489, 0.6761039742424982, 0.07581641014112826, -0.646651868374843, 0.06079033043793158, -0.08461843615248829, -0.6185744501305727, 0.5679662556206483, -0.0858602329346861, 0.2520996871644138, 0.41325788560925275, -0.19789288407558664, -0.63463070713748, 0.686815582920114, -0.2921904707742054, -0.26352377066826677, -0.18140345982059425, -0.2788282654891266, -0.5258627072073231, 0.3389480400965405, -0.6792888678258878, 0.5604707538324005, -0.16705426232850823, -0.3993072319249286, -0.4908845581673826, 0.1821872398664183, 0.49432132432950554, -0.7874739593355099, 0.37281989429406087, -0.4679219009438128, 0.42618232740066886, -0.43350598576714744, 0.4770462426229684, -0.15448819305514244, 0.4142780343846174, -0.3720982671086559, -0.3211771218532338, 0.2153167415559915, 0.4274785280855029, -0.08801938108813345, 0.21037656252074216, 0.08290769142417118, 0.0485518889726985, 0.4025661090151659, 0.5010280990770921, -0.5492725759820115, 0.6552419714013495},
    {-1.0607879884962408, -1.017472785622666, -0.8190076289378991, -0.9738929716653997, -0.7797815711226949, -0.1803359877077433, 0.1744430369049061, 0.16712304774699274, 0.44888827463085756, -0.3324322728694449, 0.11401574408538807, 0.2378909563271345, -0.09744131250496349, -0.6461192535333691, 0.47827363959082647, 0.38490939837699045, -0.07602098181126597, -0.2301621449379197, 0.10610036198718964, -1.0177463683381431, -0.16681739304606177, 0.09365731819636183, -0.5101574059351937, -0.7537301969184599, -0.4647939163641832, -1.0671928102082926, 0.3469488956741939, 0.2429905515156145, 0.3516290649128101, 0.23641388446410386, 0.08475602941564966, -0.8053739164975594, -1.0014866278756915, -0.8037542233880194, -0.9635527932697112, -0.8388755007503481, 0.05438920543907055, -0.7656112920421468, -0.40408053647909054, -1.2163718482183932, -1.1731894201835613, -0.94551872735666, -0.35746739675245726, -0.6278721586204365, -0.555921071263303, -0.9834332573475462, -0.8729513581733854, 0.2868810301033999, -0.963845350657904, 0.5992048125854764, -1.0340344850102188, -0.5549693944800755, -0.9020792880220453, 0.24617523062077035, -0.8040698635283241, 0.15386816475594808, 0.2964563362388868, -0.6568400997429948, -0.12326020278530406, -0.6094021353721187, 0.491192975031293, -0.5008273808133102, -1.022678624043581, -0.42357389782462185},
    {-1.0418148078105733, -0.9177025074317425, -0.5546734447775592, -0.9638614644117205, -0.6879523892339012, 0.1149231092343478, 0.25685584590205834, 0.7039276857474246, 0.5868480103731597, 0.20165249721187264, 0.5007706020098591, 0.612898821159852, -0.24353901658865493, 0.0935647931942691, 0.5074454044221586, 0.32661947508542954, -0.17983028915544932, -0.9214975209224063, 0.09370391360425347, -0.4644728846325925, -0.21452868088666252, 0.5787081570960275, -0.3016475282806364, -0.8239611477935533, -0.4492117648523605, -0.8129834469785775, 0.4302606831720521, 0.7314130412550146, 0.7481054431062345, 0.031918482001571935, 0.3501947817624959, -0.7508558419372957, -0.762308344748553, -0.8580493972110358, -0.9691408571744576, -0.19097519553234957, 0.383028297099845, -0.41529611409040823, -0.0678343506346472, -1.0327337273662394, -1.0523247982789532, -0.8136954868625581, 0.028852120646507065, -0.0829588298079622, -0.24850525196833848, -0.7836943841539785, -0.477183134792684, 0.5151399543739615, -0.694487993141714, 0.40313255194763475, -0.8740191855250848, 0.26105612862069766, -1.0030431265654922, 0.15003307148339803, -0.5150370283079535, 0.6247156793226575, 0.7596640727691366, -0.257753632309889, 0.2127069490118383, -0.3154307950665976, 0.5806810600770684, -0.5246210559438025, -0.9759825058692589, 0.1375170581170116},
    {-0.5992974725327092, -0.3972612470759272, -0.1491541522883417, -0.5474218496985527, -0.11706245763085893, 0.6015762875641629, 0.4751306690674782, 0.3428098178893777, 0.632831395448473, 0.09119035743445678, 0.3563535458207705, 0.3899461165841513, 0.4261567111462189, 0.3182608111727816, -0.2905414060033681, 0.667317136376507, 0.08218322715812146, 0.3895648143966266, -0.4202076523099979, -0.6226517903427014, 0.49078680527996715, 0.4888687561247531, -0.442839261368788, -0.18732429936010897, -0.4185470439126537, -0.13157148653060996, 0.24720244035325104, 0.1995828922294273, 0.3012666473364972, -0.24367053098813227, -0.17090027884094483, -0.4117314856437108, -0.20934259446755682, 0.14276414249081046, -0.5575863172843337, -0.17316530253081536, -0.304273257930271, -0.01700597821773815, -0.40322002077155167, -0.8954214545170758, -0.6991850425276661, -0.38335832491848215, -0.012548402416461744, -0.5861451966784814, 0.17581669768703245, -0.159049003619613, -0.7820853666340215, 0.2753239919467163, -0.1761554912849068, 0.5548191500840794, -0.7374418225526874, -0.3704855999183646, -0.44121285391527026, 0.7392051633700396, -0.29376918609255165, 0.5180208020173913, 0.12744254280082215, 0.28360962969315395, 0.09642238167692015, -0.0636003861315842, 0.6472329535589602, 0.2339148964711853, -0.06958396302243061, -0.831969077780425},
    {-0.9332675795105849, -0.3021730727007914, -0.28330014905205714, 0.20642502179060168, -0.05516102444832319, 0.28432031488229, 0.46792503420105896, -0.14555553812003744, 0.4764309849529842, 0.3589811125133267, 0.4156909175194617, -0.07965188726838733, 0.4067263256160207, 0.3132166511245868, -0.21717901205545012, 0.7768619837595488, 0.262449321062836, 0.28473870652377153, 0.05300724373859652, -0.8845038614491137, 0.40457011560212813, 0.17778760383966305, -0.4142996266922382, -0.31512948770789795, -0.26797618842156923, -0.03996776143188948, 0.1013903420833788, 0.06786205041880218, 0.09330469433568489, -0.00914623310565237, 0.07983024276986662, -0.46916680125483007, -0.35808848051204273, -0.6498841667632579, 0.07742143753515257, 0.14988590507720811, 0.3473938336334225, 0.4649235528315076, -0.6834214050178021, -0.6618615876538703, -0.5087380573309198, -0.7107350457571, -0.27005748863148543, -0.5952798268594928, 0.14596891835129921, -0.6002717100853096, -0.5643140989169941, 0.6477863551678463, -0.1273692428929268, 0.07907355890566108, -0.4152571095969104, -0.37493261201969785, -0.5066107995563037, 0.504899246566791, -0.20334808996139944, 0.5742229267111231, 0.6048862006887201, 0.2542057139812341, 0.3002849383380568, -0.025494256646982072, 0.5654811864944215, -0.013250144274916893, -0.050572010457358346, -0.7180675244997572},
    {-0.5275041505082749, -0.20704809332791702, -0.14276134952896247, -0.17048736057518896, -0.13499416065400877, 0.331149046634678, 0.4748763127143157, 0.31403857740969915, 0.39889890998672434, 0.036924678314071195, 0.36514062337707304, 0.4336894505145863, 0.7346154186085952, 0.5306221069762657, 0.4415004820456936, 0.42742876448628997, -0.22627568061396475, 0.6205417615961947, 0.8387187939567704, -0.32173279893197176, 0.25009905897462475, 0.11907357402737993, -0.3029593753476894, -0.42107791477072515, 0.09163585184080514, -0.1091457936576634, 0.6843108071564106, 0.9170223016703266, 0.28352700839150424, 0.26800672064970593, 0.12395403981720435, 0.0255823050171934, -0.40347912202001107, -0.46758926835511117, -0.34357840598417605, 0.1699409932047519, -0.2988695996448953, 0.2642465878054646, 0.1326019286191729, -0.8232896366890917, -0.27959950502780495, -0.3442535642396558, 0.5209204798609954, -0.2708400206278052, 0.4215550448134245, -0.10496606607528612, 0.5238478421875509, 0.7350529253858359, 0.31486661053157206, 0.04100815048032661, -0.15144583363475067, -0.0680070326965654, -0.15976211176148714, 0.673603839182464, -0.11873228927008217, 0.6662667460807552, 0.6472631457914317, 0.3176637102326204, 0.34935011324450044, -0.251768855664444, 0.47256076896734733, 0.3745672259459403, -0.03137708198893324, -0.31796353298571367},
    {-0.6324772692760425, -0.009679080189896066, 0.4711074096847599, 0.04121839557804768, -0.12554972018632365, 0.39759277788503955, 0.3157721723711782, 0.17236403351974544, 0.294327705648504, 0.6099168672055171, 0.69828061335338, 0.5542360257248048, -0.4506621437101491, 0.5644389489292196, -0.046881185852199, 0.9725395908070309, -0.07119647437362714, 0.6649760918062926, -0.19227249874609365, -0.44422158990588756, 0.5332192548435774, 0.5117001013302187, -0.2642175899677328, 0.31652084070385444, -0.25771582016588523, -0.25954612203733013, 0.5437551210986488, 0.517062915221492, 0.48081404853038595, 0.13718875091161833, 0.17061858004268898, -0.18862280759755543, -0.17679020829345657, -0.23572623418006075, 0.22151262602572394, 0.07175235612670634, -0.16175089599824577, 0.42181183583011617, -0.16073295621398495, -0.24690517226921138, -0.4567612443638589, -0.43922945239920935, 0.4108033874546774, -0.754638166999882, 0.395681192863347, -0.3393211161309228, -0.18282699738899824, 0.28399296647191263, -0.2099411757160909, 0.2019655878173756, 0.18688634552585848, 0.6370319909981196, -0.4269369980594296, 0.12108421237721355, -0.12856952928595433, 0.08801818492014432, 0.03186748812709099, 0.6203272444290396, -0.21084210138482515, -0.2453946334882432, 0.5492610572031282, -0.1784559686211949, 0.08904093874822162, 0.2191745532116477},
    {-0.6823754796130299, -0.6898385931382125, -0.038692744039890384, -0.014202509168679146, 0.20244187616888426, 0.09786452208700339, 0.7465365346852112, 0.5370955424720564, 0.3663777841120095, 0.7108186191868978, -0.035060325639254514, 0.5583070501579447, 0.17151261404993398, -0.16043580407308686, -0.1542247374519214, 0.269277633018859, -0.759343353306019, 0.6684289709224331, -0.3037436166788575, -1.029229415201603, 0.5006714764267916, -0.35856742479768927, -0.5545873028406083, -0.4469614964040561, -0.33361302268264276, -0.537527137537561, 0.3257785485323401, 0.265020885118768, -0.24301245440835617, 0.1488478101877835, 0.03873537302003915, -0.5265597450069851, -0.33779457013807074, 0.3164121989045249, 0.4295257203082339, -0.040393794301043597, 0.0030435838529601265, 0.09110996547102657, -0.754979121709695, -0.02136770626163554, -0.22984519931087247, 0.22966112016361753, -0.36239834899161505, -0.5204267102693944, -0.5138130746097958, 0.06916961984553184, 0.36597256099965814, 0.5357392874405451, 0.5488869350784709, 0.4212221922318874, -0.1236260682631233, -0.40007142418896424, -0.13406952361708735, 1.058132989736999, 0.2880861482260772, 0.639860767779813, -0.8192027613818555, 0.1854266971567706, 0.8960124122160303, 0.6115433465583, 0.298848495383753, 0.40002682677435425, -0.3294676266303228, -0.1905946826478655},
    {-0.013034179065234306, -0.12026391818815725, 0.32074263224594013, 0.13418815811070203, -0.4900901334128344, 0.5070921808551492, -0.031661378295068945, -0.21374443317900366, -0.07597992245888396, 0.09402283563634783, -0.3883753537219336, 0.32913836153553117, -0.22732786614699765, -0.004283857305409936, -0.038193287351239086, 0.708356356950379, -0.1703070876000613, 0.5280454967377115, -0.22678491455720715, -0.7337345827411804, 0.08894503006184261, -0.28611889733508283, 0.05456912126157243, -0.7574950711592155, -0.029350313468815437, -0.8996576548224737, 0.7744389788386008, 0.30796130665289195, -0.3907360822641578, -0.054821521466010846, 0.5402273367194314, -0.8120419213237933, -0.2124081130542418, -0.6391925859498361, 0.6126415903554873, 0.2895041159474247, 0.16847579709600974, -0.4309915678304465, -0.9788868505859466, -0.23477357867033855, -0.38480034396692486, -0.03331061550503464, 0.23706422033983318, 0.2603465650826488, -0.2840549646141242, -0.024172543041887328, -0.5192175598546481, 0.2937146548793812, 0.32961087213801493, 0.06876966404656337, -0.14387127344627396, -0.0674834418528568, 0.0863554288687915, 0.045166265856575204, 0.11679900246386712, -0.07123348777629304, 0.1754508294099535, -0.23313923992990265, -0.26359410649402903, -0.16559008707837544, 0.3278101162699145, -0.6026648966863457, -0.2568458280226987, 0.15398287356974935},
    {-0.1829835890399858, 0.23003653560525208, -0.015977384407200878, -0.2283033689257716, -0.8888055308745056, -0.42549817750789154, 0.07611525365438977, -0.1268690446648316, 0.655717190617217, 0.3883042219348386, 0.5148241157228285, 0.8078682342566514, -0.4349361598181343, -0.20242225761024918, 0.2668773589972936, 0.4011535253207435, -0.43813284809370245, -0.5234951176201782, 0.38812350355417885, -0.6394013416870643, 0.2032501597848135, -0.23122410504642085, -0.6996112890704523, -0.5495033217816049, -0.28351676632404177, -0.5103464712513648, 0.5541116263556768, 0.6298480836658626, 0.29774555178117573, -0.20224510162867532, 0.7476391943323097, -0.33747715646222487, -0.8567455700176615, -0.48337410939435094, 0.34186385099424005, 0.2342280676111244, 0.5028780650783933, -0.03865717056161988, -0.5319050277124093, -0.8052929346171898, -0.5408028339439578, -0.7916314217003633, 0.6422643853877704, 0.29404853819484755, 0.2504112128575533, -0.45387444905695185, -0.4096131348988561, 0.7016355085122572, -0.41829323676732727, -0.22694310763314496, 0.02971567558431312, -0.16067239829740315, -0.055258770105143996, -0.1330248248244432, -0.36398571832829774, -0.07903724495763492, 0.25316490279475734, 0.24468156256678616, 0.3243096008409836, -0.07714666754578726, 0.477513519482912, -0.11427212287306684, 0.14073404403145895, 0.38768088760915215},
    {0.2658411477822614, -0.16468472229031197, 0.08907631975210802, -0.424615027728463, 0.11050809277654819, 0.6529166270331499, 0.17275768341681744, 0.023907149777303224, 0.04261452775427182, -0.49868106476538493, 0.43174560212510044, 0.11699800377810096, -0.20470144076119642, 0.18824042785079245, 0.3828542650810167, -0.07987772931628624, 0.3135709452007898, 0.30102897052003363, -0.25708856656698204, -0.17461012507524107, -0.2736223441054167, -0.1816811050705986, -0.6825804017822652, -0.47404572106513726, 0.08809551969177837, 0.1692756186383067, 0.512467645067946, 0.5350501557109238, 0.22826855302252094, 0.048547890130303945, 0.10195062787461082, -0.8178726108535428, -0.9212749156815339, -0.0790164769376523, -0.05171510622853128, 0.10479815504233791, 0.013370428244281536, 0.1374722398959682, 0.045012077549906486, 0.2851591011834033, -0.5385851006980341, -0.4022757682716133, 0.4838693607052617, 0.21179378966199552, 0.15688422855597708, -0.14989763484638627, 0.6224848928733994, 0.5219509262553, 0.3592179232463144, -0.3332059202301577, 0.2803449619119521, -0.004729918523178273, -0.59688312631194, -0.0019985519577409767, -0.21863420511333234, 0.38899161153746453, 0.5680106544746247, -0.025728238767111715, -0.12063726733784, -0.25692574943371815, -0.10277389593310766, 0.03743298241330046, -0.35246225243386065, 0.17918534982886894},
    {-0.5651321794938641, -0.06102057757895263, -0.3804953887578939, -0.05538114548989818, 0.15205562185343324, 0.3562940338159205, 0.44931222158775436, 0.1608107167473566, 0.20572978290991362, 0.5658259889018628, 0.6436446588498594, 0.307432844711068, 0.2915434860025303, -0.25385759398527913, -0.16760940120428916, 0.6051585284070171, 0.5089881181882567, -0.2381861099266962, -0.3159847547925221, -0.13746819145061814, -0.05341766270559133, -0.2143531478897484, 0.035399728139438064, -0.2414238061440578, 0.2471612030267549, 0.0033085022390159594, -0.008345637934897841, 0.408178159826886, 0.03803274245809534, -0.12578994807377675, 0.08584698921193436, -0.05308344406882549, -0.09794896295486709, -0.12083804201603042, -0.08283742522213096, 0.5166475439476611, 0.34810549836331256, 0.5023766105797808, -0.3316016482798907, 0.21800718801472635, 0.37149629337222934, 0.49667675355858576, 0.726277313194243, -0.3174722071072317, -0.09114550286944283, -0.6438164192910606, 0.14113557520134115, -0.21868192419304786, 0.44593149474442895, -0.04376939903136929, 0.066163899297861, 0.1650428150759899, -0.01691981419684508, 0.41663728262961097, 0.4078322816623522, 0.4994066089895139, 0.5124863223627396, 0.7205498592350151, 0.03978067021750972, 0.14139612276729605, 0.12306574245453293, 0.44030204984222227, 0.36304810944860433, 0.21317448884381202},
    {-0.3107393168066351, -0.4938698697309669, -0.3397185946137754, -0.6300137347547103, 0.3076190389453607, 0.2959957663949403, -0.1429217744697542, -0.17895837905527998, -0.11150296454997442, -0.33592349632115276, 0.2802472520782602, 0.31495747514698896, 0.09966076523963883, 0.3534155666009531, -0.35489520774743166, -0.01666059390661559, 0.34770165987654744, 0.2683045995550722, 0.5371466728790025, -0.42264544952126215, -0.6254634731922405, -0.458597046833027, -0.43947732955998453, 0.020757680473129387, -0.05654558130031491, -0.6985674871222951, 0.22522387878723263, 0.4772990589680989, -0.4427066713114267, 0.022650399157655838, -0.07136903236671413, -0.6196074729392271, 0.17220459337582128, 0.14946864586419661, -0.21711503244169142, -0.021285490635290005, -0.019923389973840362, 0.06322046829192543, -0.0569340100836904, -0.32075061830628193, -0.26992535942883045, 0.3886427850809118, -0.05382247085285197, 0.3664484837634406, 0.20809183202303475, 0.5537915106416923, -0.5305068718283221, -0.4521631806606681, -0.0727400945119066, -0.2317363405378804, 0.3872665233587087, 0.02146979927050793, -0.47043446767020225, 0.77307565160393, 0.4968628017505758, -0.6366880387980127, 0.1965062011215075, -0.28503779978375515, 0.7162524248514358, -0.5543753023729859, 0.04893629233052584, 0.3137572220084947, 0.4583718861826391, -0.17932316000135617},
    {0.14353933469341634, 0.09048689535683835, 0.11245002025461504, -0.25189509694707046, -0.4586146906513121, 0.06469514849026296, 0.5266709773381312, -0.160113493591402, 0.4951516492903107, 0.46980227678327036, 0.47006097945887415, 0.6944973866534956, -0.7806149434982902, -0.4014860514891589, 0.15838638443678602, 0.6004311505419551, -0.7927561625512025, -0.04654846955820445, -0.04424500423706079, -0.3304173553883685, 0.20979247534517437, 0.003593199558132242, 0.08053415798751176, -0.242300295326115, 0.33501969793388686, 0.18664106535413139, 0.645438863381103, 0.6266985064770776, -0.3114505160880402, 0.4124399730506882, 0.18172939136686114, 0.07387137453808396, -0.23025710382204767, -0.08468720673876365, -0.2920833468377149, 0.43276449060812616, 0.7890155776821588, -0.23487251116277677, 0.09220957246103252, -0.6796817574468818, -0.18710017067546342, -0.3585490807767294, 0.5310947049576806, 0.6196749110808123, 0.04024185790734292, 0.14935405629086912, -0.21530992671465368, 0.08624301661001885, -0.0842424885723863, -0.11589821378595376, 0.1755787388815703, 0.17349768865394094, 0.11268812412629829, -0.7904471984635767, 0.15509416923603117, 0.5740092843556496, 0.26321385472166203, 0.31895047462068693, -0.5539985367738213, -0.3043263755954832, 0.09328360059979775, -0.6816000088840171, 0.012463199307607526, 0.7958016402694796},
    {0.23817391381759168, -0.7257534508748932, -0.5228532412478385, 0.08424807586183677, 0.10275450836463264, 0.10179286915454545, -0.021504036608685557, -0.5297801809322368, 0.6425047254064256, -0.35334837060795427, -0.24209366440644187, 0.28200855492883103, 0.5714345499711267, -0.2358285768536511, -0.4086406263773481, 0.18384918407157658, -0.2751490968828981, -0.026181818680823907, -0.5613312091565551, 0.2631239862167061, 0.4715468097318961, -0.27930119581780277, -0.5205983573168164, -0.8774764471521657, -0.37458822286102683, -0.18716322326821108, -0.05053607541272883, 0.023595440895920704, 0.07770955279730728, 0.5209649121722525, 0.4945086412474821, -0.3901620312773991, -0.3613979890170484, 0.1424640383183582, -0.7472886771310422, 0.2072845785964058, 0.08461464472160417, 0.24426029353936757, -0.2717409797292877, 0.5087166239675694, 0.1938462700170829, -0.4374083605446587, 0.06188187731739098, 0.39769700138292435, -0.5675100960508089, -0.9962877453139692, -0.15263818092497647, -0.42442135646371193, 0.42512549814031514, -0.086199526488109, -0.001574429728634336, 0.0648431092237054, -0.16631580699701123, 0.3588907747565035, -0.4535036620888679, 0.46704775575154756, 0.2821950520973931, 0.331684783714947, 0.12657263617545342, -0.3674634654188737, 0.05898070872291777, 0.4906360510747928, -0.23741652026625043, 0.014957059304468228},
    {-0.5657062097105036, 0.013266792712536411, 0.10694168136944951, -0.5620463081013772, -0.12840065474726012, -0.04027686335396051, -0.354881602237909, 0.8098058919057931, 0.19302652736898013, 0.22054645465371875, 0.6649214596282523, 0.07605338792717065, 0.20567209445040466, 0.2987756440651499, 0.47823421609426214, 0.6903910049591441, -0.04497842715574482, 0.0042933287082046615, 0.2260307458347057, 0.09878076520321213, 0.18875366588829467, 0.07525710097126982, -0.6102449293770168, -0.21601644428914377, 0.02074667672714455, 0.3520019292416674, 0.2616266473669661, 0.35916578098386026, -0.2551375131741174, 0.351059902134614, -0.25762002064343037, -0.283193734616019, 0.12480388125749438, 0.1272861331009826, -0.21301637298773257, -0.06002864060670858, 0.13408938499760564, 0.3191415282289909, -0.2163240903087591, -0.6272810766994698, 0.3369213319342641, 0.05720331285098075, -0.3641648831402385, 0.7170307845817041, 0.5874866246562628, 0.7034503017890551, 0.01699254202279689, -0.17593060022807627, 0.2000654427834846, -0.20671489640204285, 0.4841814923350755, -0.48236884341790986, -0.11220035384406796, -0.5086366238053098, -0.361099596070439, 0.5355434853013887, 0.3404524882493117, 0.0210793971792795, -0.18438235399706973, -0.3620352283869815, 0.6378417768302393, -0.1285531309150204, 0.3522175780236643, 0.23234623367421198},
    {-0.03193556575302634, -0.4363292925945411, 0.24837234685690004, -0.23050634295099776, -0.017824783546482193, -0.07940913546566741, 0.3922238517330113, 0.1736561344241434, 0.2866711942247157, 0.16090751731880976, 0.24294175516580888, 0.7343702318594806, -0.25303143321271043, 0.5816450192351905, 0.006012993955601775, 0.08541661233067402, -0.25908775604016726, -0.42307135976735594, 0.44546584417567814, 0.4429291662861529, -0.11870125121366504, -0.09812887139119807, 0.04872157589755983, -0.48178024406730846, -0.16808650734210018, 0.3000490002141444, -0.00362913015155415, 0.7939704547344221, 0.6431029468140199, 0.5179304735328464, 0.5638920897885854, -0.7518105915759034, -0.7926320115328568, -0.16968338233094402, -0.651582634289613, -0.24313585609621385, 0.45567849613484523, -0.11437496578096384, 0.16040505029429208, -0.3629523115190342, -0.07730543114177295, -0.39082231493227165, 0.15030132270397115, 0.38418999749582255, -0.19712676228172998, -0.21366860047032787, -0.5252255996049492, 0.2377108234552538, -0.48610231419999367, -0.07691450858105617, -0.28138639195992304, 0.12729001024094122, -0.3551356236666287, 0.18749273908883035, 0.05798604968342109, -0.7230588479109881, 0.4322945019913167, 0.2654387915433901, 0.3388010418959048, -0.09239880094353622, -0.15511790486677912, 0.16534390781469246, -0.3391685427048098, -0.26101260163836887},
    {-0.019753329523417525, 0.16979104715941512, 0.5577963806640369, 0.2723244138156148, 0.10472178206617865, 0.32778293611286463, 0.23156606443168803, 0.11695260370603228, -0.09756385676302838, 0.2633053280671621, 0.6038167016367093, 0.3188060744920122, -0.21520917830361164, 0.40462441166626745, -0.2642410804590038, -0.05812642489539831, 0.18306069831426863, -0.30595096124304133, -0.6727014389228763, 0.23469203948571313, 0.4562599407697876, 0.4954925905335569, 0.34396658110181516, 0.1987199794677041, 0.20455534548904977, -0.003156284321007266, -0.20662099197693332, 0.12661107313070324, 0.2677288529406817, -0.20995715180258778, 0.2594401379249669, 0.09702864898044017, -0.2790795585786743, -0.21932424716052648, -0.6368892484282197, -0.16961742377850708, -0.6139051644377028, -0.09442779396068292, 0.15313149737226087, 0.1370859422698179, -0.1453866564349724, -0.25328069173965245, -0.0849465294752921, 0.29854769449085367, -0.33331792089714, -0.10468978384399265, -0.5830976740399462, 0.22745453265723592, -0.01995152654280987, 0.24603094174465914, 0.08787502430038836, -0.09889162879536537, -0.5671975776979638, -0.10580485862699517, -0.3592457777901909, 0.20796566413617829, 0.12758411383955176, -0.05786503984734129, -0.44235762575616394, 0.09741624715800264, -0.5838739158601988, -0.4608794834736389, -0.5282798436546183, 0.020934835134256702},
    {-0.10243098218104123, 0.4054627619509396, -0.05563770843401353, 0.2495435381547228, 0.10709508555099273, 0.35131821538270297, 0.48946608712712425, -0.042922129890836346, 0.29420260832398065, 0.9498757278760185, 0.6101278170392419, -0.15912564734400775, -0.2555982242223965, 0.6225195451316551, -0.47514268947791155, 0.2020209851539654, 0.29500689027089505, 0.0007596486787224767, -0.145731160075147, -0.17964990019343685, 0.11193971534854534, -0.06963768773931801, 0.4184757777799954, 0.31865396749259656, 0.3148872234910495, 0.48887095582608336, -0.5050747157753623, 0.231350081025621, -0.24282979075712935, -0.32337914851831656, -0.21192412192792978, -0.18888992622759732, -0.07479694959693833, 0.6072161733455467, 0.5005118700307556, 0.6375599665018534, -0.08225109521502535, 0.37691797783240294, -0.22433403433425628, 0.5358205225440034, -0.4472048656450603, 0.04439845678142015, 0.32183173957520617, 0.13327801787079796, 0.29437156899307587, 0.14956922024180244, -0.3636893439183323, -0.18376326234293217, -0.2105386507826093, -0.8033237152063353, 0.1743570674773267, 0.3077636325249376, -0.44258732761602526, 0.4607172618660655, -0.026842654198814906, 0.13311538489275757, 0.6033894046765844, 0.4901085811988846, -0.21286046772300854, -0.366784082618448, -0.6954651707393209, -0.6277665014352674, 0.4034274948733756, 0.1588519781551711},
    {-0.3112118404420041, 0.22462870230864407, 0.38588294621146013, 0.2820266280644399, 0.3726435622889789, 0.6530078728400412, 0.06734886423107657, -0.0594198447790485, 0.4706435789742834, -0.20647565349693206, 0.4031815439351723, 0.019145814983599296, 0.3570659445682409, 0.39506290271835215, -0.5061542807130179, 0.16909140348386478, -0.21008300222085932, 0.45281493964816905, 0.08768328939790203, 0.23368235976207358, 0.6023255288950264, -0.23178906377461503, 0.35019509536166865, -0.4076188482092388, 0.21745209154081324, 0.49716012233207635, -0.3231072890909917, 0.2974326396205702, -0.09101498132653797, -0.21012707451369325, -0.17945340419180436, 0.20955097270835463, 0.48274053446264914, -0.09056740024652163, -0.06996498830156386, 0.4111062058723482, 0.3367131849039192, 0.18837924777662876, -0.5745227868430967, 0.1401369568722606, 0.04815464599525683, 0.030615667194344533, 0.2581192002093549, 0.30262589068825774, 0.20050484006636243, -0.467955438759014, -0.16485099457168403, 0.11520468782545384, 0.43063968265813285, -0.19192114657356352, 0.6335557549263728, -0.2828731726863218, 0.20598980111799792, 0.07228620607263866, -0.1752690770469265, -0.07151967432006893, 0.11536504176789805, 0.27956392986527007, -0.04735390494019793, 0.25534735319155655, -0.027025309505469927, 0.1546901981922697, 0.2781024196804255, -0.023467320163325023},
    {-0.43770298722440265, 0.205046393384608, -0.0016266751824699352, 0.1531220097411615, 0.45493205468610537, 0.6101083388422004, 0.4192200873848947, -0.09181623594627823, 0.04889887497118587, 0.16859083092014385, 0.4373778404714938, 0.1606079807854818, -0.064529538882404, 0.6712123313149043, -0.3957116944341589, 0.27664542324018215, -0.24142737177182252, -0.47143835252005034, -0.39405077965216845, -0.41573355170806053, 0.7719000231982774, 0.1662637078957962, 0.2518829918546227, 0.2263044801543464, 0.4270490998122387, 0.028476638584283624, -0.3742157492266813, -0.08384220713852579, -0.01674833938577601, -0.44648817805876373, -0.08675738578281326, -0.16998506877034536, -0.24420108020157036, -0.1819485980221778, 0.5744739713139614, 0.21290097079981635, -0.12237121219661469, 0.6595787964520348, 0.1616820445727954, -0.09235160058704789, 0.6343133029654356, 0.015178120475666378, 0.4574545922222968, -0.40589578414330735, 0.29515490489528995, -0.8459988468140295, 0.2775984536174979, -0.06919564989416535, 0.37952168438642686, -0.6406446850475491, 0.2558683191364268, -0.46382949292091563, -0.38241650614489253, 0.5762047588847142, -0.657869127165884, 0.29338318270057595, 0.2581789179752463, 0.42054849468102873, -0.12895709816523618, -0.2009627609568952, -0.7469270818763493, 0.07635443721711645, -0.2841081116127086, -0.2396872669643366},
    {-0.25846187173541374, 0.06174363073350327, 0.433649954753509, 0.2945897993393412, -0.667533880467992, 0.053546306618341956, 0.6208317957545225, 0.4336624817036873, 0.02604063954427169, 0.36332659839757053, 0.07477044834209456, 0.27570682842514255, 0.0838548207160596, 0.2181290524293335, -0.5451931956692652, 0.3202627676929267, 0.3498257190383441, 0.04341361663357422, -0.2426275997612665, -0.33201141499439074, 0.39120400798838234, -0.29264282628770916, 0.3418624757380187, 0.3982968676439194, 0.699564644790308, -0.11294756533549401, 0.08764694942059079, 0.22635289105617207, 0.44786381270726583, -0.5159403472311542, -0.6291447949360718, -0.06270571632956806, 0.33650036120496346, 0.05596872134218336, 0.2792187188763132, 0.4682745167629471, 0.04251473015599418, 0.049114152515685676, 0.09866603812671412, -0.5617284240768874, 0.32666147331723433, 0.7565074790830497, 0.22899240559949796, -0.417416991226025, 0.76809856200228, 4.501212726141417e-05, 0.2633924608036546, 0.489064665156201, 0.39011884574039946, -0.6096998704670701, 0.012230955042220661, -0.05791398471757772, 0.293957301520773, 0.44004049558969127, 0.14326290319485768, 0.4509042300553631, 0.41310655272268293, 0.519308566797138, -0.5236653380937966, -0.3471086089218332, -0.8059182021295772, -0.1636656851736941, 0.286165277325433, 0.04980525927343652},
    {-0.3051314828774736, 0.5578003694371976, 0.5004389515765209, 0.4678931356246318, -0.031081592306830455, 0.41837518971415216, -0.1336915182324941, 0.6096492954979952, 0.0821545269963854, 0.03873276849600493, 0.4810024144066698, 0.47308280138784103, -0.768834062092347, 0.46138402624043306, 0.15509948816807456, -0.24771474236561458, -0.4258556315228652, -0.3359801171905904, -0.033206452834848944, -0.2698233091851519, 0.41876431069155357, -0.16957357752705826, -0.3703545759366534, -0.2546453076488789, 0.17324384430119985, -0.35178920628099947, 0.5018053692819159, 0.6199681860347175, 0.7613221928875619, -0.8824241454665563, -0.637794963313108, -0.20798476256643655, -0.16700019030728916, 0.5224383743115988, -0.08830262735926904, 0.5578292409543402, 0.34173738311895135, 0.5041808505729534, -0.09525274841253693, -0.455938487343186, -0.3262882346711665, 0.35961255210304993, -0.07710019822523777, -0.31441747665193726, 0.39422561503678916, -0.11208070726373012, 0.22109744317165528, 0.23230186418773213, -0.2063257989641137, 0.3715502696037836, 0.007481928119545637, -0.07552882219403885, -0.18145133229061355, 0.13579113689342093, 0.40106941032867954, 0.5246665872630643, 0.4139535088975765, 0.5227257003488928, -0.8694697389330622, -0.2856619755281968, -0.10104493020418792, 0.12570952488231488, 0.8958310854237481, -0.1955334273007781},
    {-0.1339998436037767, -0.2626646225680078, 0.19026756152406607, 0.22267186893637464, 0.4733865922736292, -0.22383040628076395, -0.055539062124259395, 0.4194972176897878, 0.29174129163433665, 0.29530273722138534, 0.40287279592375097, 0.4853871093948355, -0.4206806532573503, -0.11824530230582031, -0.07346931659050562, 0.4409761559368875, -0.16081409964231583, 0.05190631725761274, -0.15245995904483373, -0.162451719038646, -0.37232133989865623, 0.8452179409893366, -0.05155739176465884, -0.0818690689528717, 0.0962474154020745, -0.006179685545804967, 0.46897018966996523, 0.3391839282490781, 0.5117906692697017, -0.4816599641376584, 0.20725331100310385, 0.5471219751385101, -0.204785641915726, -0.026616432558852494, 0.6664525528483821, 0.14722034147398763, -0.0655451702175751, 0.14663104109646266, 0.5883207245504258, 0.022203069305306453, -0.39574875905039764, 0.48166207920823834, 0.007126305524380316, 0.2022662112911629, 0.4853892121497079, 0.5493577758321827, 0.793516409757538, 0.21379987020480262, 0.16275525455165352, 0.10213178195611237, 0.5466107523738912, 0.4653826695707654, -0.29545767741815493, -0.03242537487455963, -0.16031315444576114, 0.33551323056186017, 0.3254228953349512, 0.7222933455186235, -0.23012894315221238, 0.057776991957434916, 0.5970467474017672, -0.21844128853479994, 0.4612223576948775, -0.059511658893689506},
    {-0.3820640230909028, 0.13308747022864637, -0.10193884930990714, 0.15599808751713923, -0.42723363937184156, 0.5190934390012695, -0.3453788314948904, -0.5187431818455699, -0.47386276414864154, -0.4054294108125328, -0.7339022816634454, 0.07987693531290838, -0.17131167747570755, -0.24854453403694543, -0.4728951720469463, -0.028065516907292, 0.2537110423693578, -0.15986895791887076, 0.2547847534565132, 0.0656053438898448, -0.026261945946206774, 0.45353688324171676, -0.43724144496151884, -0.5010524582380594, -0.20252961092954722, -0.009922323681237069, 0.4028895458289726, 0.31761029001899593, -0.021864219678671585, -0.5599411348319351, 0.01829595093550066, -0.46520998883535575, -0.001150971168975347, 0.04823458464710545, -0.4900622460847188, -0.4867571262259749, 0.06495032356934219, -0.1761636381926896, 0.10979337052079134, 0.005212151210550929, -0.7301612439639096, -0.26669954566958565, 0.3655278765567803, -0.03592813160505318, -0.43463352165794655, -0.05765295154344874, -0.5543366096739523, 0.3609598670243793, -0.665336035564391, -0.37340434870779726, 0.48773115901544906, 0.40574194034536026, 0.11612243314572346, -0.059548851455433476, 0.0257028837294712, 0.12461204258598182, -0.0699463749328273, 0.012795005651062046, -0.6606574903238993, 0.0565194348281026, 0.3473321236032705, -0.16238679067966955, 0.37441182390609157, 0.0867658587756647},
    {-0.22429698792495803, 0.057500840850327264, 0.170223180903304, -0.255658290851155, -0.0906215794863037, -0.48896734549506227, 0.06906439947705985, -0.14557989970691076, -0.023072327358021397, -0.1378473810969933, 0.017277833966523236, 0.10649878266962824, -0.5991648034121084, -0.5628656065389599, -0.09696085827681027, -0.7931819568052645, -0.4293971527244758, -0.29522884951466755, 0.2668846296699592, 0.4779430983848683, -0.31545305815345576, 0.13093204261411145, 0.2284875656030803, -0.29197129568839697, 0.22046578606292855, -0.2943261870541733, -0.39806740853381134, -0.029507020670552164, -0.03589069308501954, 0.11132833672859214, 0.13242434533110778, -0.7156274579849329, -0.43209045133767304, -0.34729328348697763, 0.46348160831203633, 0.3235826978516398, 0.7539343908706532, -0.661393599894957, 0.2747748570163078, 0.30301771728024446, -0.3255724864949814, 0.014075250081931468, -0.06286501568819253, 0.02243949080814893, 0.2916676156418564, -0.49362310762304423, 0.7559608479740095, 0.25529756640283274, 0.37068498604630395, 0.0185985195190947, 0.0888382272366675, -0.07164278629420348, -0.32857215974214726, -0.4322023260437987, -0.3033394659832626, -0.20625004693277485, -0.3373223421330078, -0.5027376819220837, -0.13996678247601652, -0.2004139440161242, -0.4241757531502383, -0.10040938091521703, -0.06627393603038395, 0.44975152717801914},
    {0.20129444067571473, -0.10145440255638773, -0.3318669349025376, 0.577834516961469, 0.2516104840925919, 0.10021629385723023, -0.6488978124123925, -0.4184332059853224, -0.15694491873678545, 0.5455596524580765, 0.2074643110362015, 0.3925325273629833, 0.019345900955739924, 0.2172635878694853, 0.3126828548320165, 0.48952619049701485, 0.06586149452775869, -0.4487102514823053, 0.20600493554344032, -0.5378571084986815, 0.053946157786004395, 0.1615480559288678, 0.558391261428151, -0.23633706524317594, -0.21044563602672442, 0.5268841468011862, 0.08256772610529667, 0.189873463294818, 0.44783096435121456, -0.612718451293452, 0.0024101954254932404, 0.13964766005298343, -0.21334977304324174, 0.08787518079490685, -0.45122589269716334, -0.37745567456807205, 0.24730515491901045, 0.2728783883222273, 0.2726967918967553, 0.4049404595129036, -0.11531203138826988, -0.19376714123704328, 0.12027806510372924, -0.17953898855438616, 0.14972170433218046, 0.059665962944004315, 0.24232813364396727, 0.39169771355423166, -0.04908576685929594, -0.4666847555188279, 0.17122052419677752, -0.11893212503382519, -0.08059797971627174, 0.512211141509725, -0.07480463138461722, 0.39256825207888496, 0.1711889149395185, 0.6717673778860471, -0.8462133250183593, 0.27678479904907594, 0.014179223330943187, -0.4820079031517896, -0.0070812537878797675, 0.26718012527235296},
    {0.06957276703133831, -0.4724918522267685, 0.5348145066203367, -0.012152838837698746, 0.11418493452916066, 0.5361778705573226, 0.1737794406971202, 0.5687012014681299, 0.501912691070774, -0.009635473393888497, 0.5773983918947063, 0.40627101330926946, -0.06330536871397904, -0.23426996717349385, -0.07769509932756134, 0.09752031416522185, -0.2942860655279301, -0.8167303973291171, 0.12366702313849978, 0.18296023594711483, -0.9595261054842995, 0.41102102810319957, 0.7769306180330651, -0.8613646579275905, -0.1972397159494374, -0.012514603976786986, 0.208902021008077, 0.07286596312770134, 0.6181229770242116, -0.3177522641977106, 0.046065824321189164, -0.24567416137138412, 0.0554479750111677, -0.4217882642902817, -0.18075020758065508, 0.16847519182356507, -0.41715729131690965, -0.5216107135814912, 0.4504340498604597, 0.12382972632136834, -0.5952628544454447, -0.30599755504949255, -0.10310878316775555, 0.22498277914512824, 0.5658976893478777, 0.30264300900584745, -0.11330876191945044, -0.44552210504800455, 0.06517113029892813, 0.0921185299593254, 0.007997614676781084, -0.21389807364083055, -0.04105599804941659, -0.6044424336301032, -0.3150561214551655, -0.08921554107254245, 0.1675123619288451, 0.3221187944654632, -0.3456935976594346, 0.3648995946777602, 0.4430615250215881, -0.2642345708177743, 0.04260191013601767, -0.10715628506404554},
    {0.2431842929264118, 0.0849810901098772, -0.1484677607418834, -0.2685496017120321, 0.12752970400135216, -0.48750145459264155, -0.36980624798941203, 0.42200331412631115, 0.10498608807364429, 0.6183759613107164, 0.0716198519589363, 0.2454545560106896, -0.25147833010373793, 0.07999647356898106, 0.3834694079424184, -0.20006242303658422, 0.04861300988848944, -0.13173204567663718, 0.498612094055758, -0.36192898991642225, 0.14171678074593977, 0.1414726730059371, 0.11606467289264472, 0.2242714460918711, 0.2506434820232974, -0.47292389004418683, 0.5924919233354524, 0.42128905529195315, 0.44555630933775925, -0.3485056016596245, 0.008731618698508444, -0.4156901259342234, -0.15507485812487878, -0.7254618760407078, -0.13557562251206348, -0.5444419302367446, -0.4853973404134732, -0.286954427254206, 0.5562650328323632, 0.18533476046060415, 0.3081828352976753, -0.37559263857129427, 0.2885306116485434, -0.4583644466670796, 0.14185493472671956, -0.25401716113001427, -0.3436131591427365, 0.6634184197653968, -0.02286309518540302, 0.41275108873999716, 0.2996362844098486, -0.49209924469191607, 0.17753697772746352, -0.2777789425856876, 0.15864950556757668, -0.052107300750770906, 0.5583563250620278, 0.21169623577495367, 0.1629376412287077, -0.5733088455562154, 0.26101105345093195, 0.12428426074970256, -0.00565804275235849, -0.1381792504441915},
    {0.20716329031391428, 0.746063591094791, 0.7282535471707219, -0.22435951767620826, -0.5531030619796731, 0.42300973868677566, 0.06516174830110949, 0.16557798255698314, 0.311159020417884, 0.1324294468225249, 0.057869768051506065, 0.7325487565373715, -0.4561500373333818, 0.3331163998714015, 0.06508076003227951, 0.49665436200217883, -0.1776084177066872, -0.11714475139813946, 0.24097151045184942, -0.27352371552711396, -0.15764013065358387, 0.26781618914406974, -0.06348946288142239, -0.13768970510702414, -0.032325710136769104, 0.02622948526136677, 0.44116734718936496, 0.8694937494529458, 0.6724402909878908, -0.38533541285627615, 0.518389190395689, -0.5227987222768774, -0.19488703066560364, 0.511014738329136, 0.5021707269829602, 0.2154521628820374, 0.4911343556329886, 0.13797250369751304, 0.18401846939049069, 0.162741749789393, -0.6139408686649492, -0.2574397236888421, 0.09223119682771441, 0.21551936303403327, 0.6648420674162069, -0.12095871367328805, -0.032824537140147686, 0.07959945888781543, -0.16507326915153633, 0.322582881185518, 0.5467794533407052, 0.830012108002134, -0.6385789508541615, -0.14471967764727853, 0.3425195808501972, 0.3352786256378539, 0.20780100454868358, 0.44365647776602885, -0.4889965510269986, 0.2264142816971108, 0.21562312002729594, -0.45253356865879535, 0.002389711466241369, 0.6302351338049177},
    {-0.3346491610458562, -0.26364022025882056, 0.12081880324664321, 0.5567148817688053, 0.22629343354636275, 0.08210767943539914, 0.3553720586792876, -0.15642801425457106, 0.7632797432100028, 0.19665845273482205, -0.07471533634626806, 0.33852377278759865, -0.3222386288957696, 0.08903854949153278, -0.22948328765192844, 0.05996834832478999, -0.8021382877695993, -0.670762744941765, 0.17171746330557605, 0.4128713858270804, 0.08995359326900207, 0.015269692308977121, -0.37643679661539514, -0.46107340706700534, -0.197315147385804, 0.13111318627230376, 0.4224020692412038, 0.15692208906863642, -0.18808122578821115, -0.10904128772629185, 0.6996073728645028, -0.012026993281520265, -0.5592340732503673, -0.005575342325055218, -0.034583247912805995, 0.366456706193416, -0.11815645073186787, -0.24844526870098665, -0.3392000184717311, -0.10578542094452467, -0.5135064231330386, -0.19254758659015725, -0.2883482949948183, 0.07065421541146177, 0.2616439742484798, 0.29003635984386517, -0.034345532598136365, 0.019894262639993613, -0.7728024939790186, -0.28318000605575405, 0.2650818155569125, -0.13475838456110878, 0.2789043980293815, -0.590101139705235, -0.1985584157394845, 0.12439250504649767, 0.11923450148960717, 0.4719233110887435, -0.6681819087513402, -0.21751513933443598, 0.46595649482079254, -0.16842387576270818, -0.012124118684424645, 0.26588787302142913},
    {0.3541825434796913, 0.14792034246361593, 0.32959202343279503, -0.24523207683076018, -0.3782859515773329, 0.10096584204365618, 0.06854240077853603, 0.7580389075988015, -0.26752287085168924, 0.09028809942642173, 0.014025792086937335, -0.00712731464270315, 0.004206897618053588, 0.19896550779148686, 0.13360074558822563, -0.2493390443883876, 0.006700294806588383, 0.30703096249180106, -0.03866843895398843, -0.20982095753678384, -0.1286470431088709, -0.3080533951200476, 0.08203900922545547, 0.36247736613463555, 0.1613673680438963, -0.07642668890626772, -0.10737959990927598, -0.2942042649558989, -0.41954345324289843, 0.26635237665327394, 0.18557570060269804, 0.10782054408397004, 0.5790653044163573, 0.4426164950266487, 0.07552336832061707, 0.28218092923980825, -0.26743304452475625, 0.006203173862795963, -0.04639181959520888, 0.055690988016780206, 0.40706873085664835, 0.39225565070145507, -0.15451794737751387, -0.5935570363642864, 0.0701341496323787, 0.09698898231666751, -0.23671182718382466, 0.36514333943247346, 0.3585816649747371, 0.17315786442069833, 0.3006415404217994, 0.0035296070245404874, 0.27242004955390065, -0.2974675770659694, 0.6550733120730986, 0.23426280803070762, -0.3674577932752679, 0.30206902098563815, 0.13683900638675975, -0.008218753235633038, -0.2434309031110712, 0.40933080484571677, 0.2405663596509127, 0.1819969066155593},
    {-0.028085723591325218, 0.20955432883422406, -0.21841215297150188, -0.16853763250781556, -0.7397588091530506, -0.11599001828953376, 0.18683642846485235, -0.013446090406530642, 0.5562646228262537, 0.08839382841002771, 0.12029770050849545, -0.047473409844615774, -0.3202709246511103, -0.46118248057968547, -0.08842515220522933, -0.07940193364278902, -0.1377004491682366, 0.6299921287680704, 0.07578948157530321, 0.08702144072965708, -0.2907600519630141, -0.15680608354165965, -0.4836676784993687, 0.33533562464937505, -0.2564459565858185, -0.7901299018677544, -0.051984038021772074, 0.1903309362596276, 0.2890212448892678, -0.36809899125376105, 0.4040081833239593, 0.3097511845077636, -0.16166193732569523, -0.6282159171086467, -0.5394877833646042, 0.48796856908369807, 0.02870809951267336, 0.5125098333429576, -0.47034530728929574, 0.21648315374844163, 0.219002585582102, 0.7321822508882833, 0.2734313111444813, -0.34592913317968993, -0.3301106204507112, -0.2109513166155844, 0.3839886811163828, 0.009636438335812564, 0.09486091606350722, -0.33670722551732424, 0.12597463246449198, 0.19743772498301243, -0.055150842977901855, 0.09850040531783776, -0.21435258354918485, -0.0644291245529819, -0.19018602695700768, 0.13896738309382906, -0.2080013073005838, 0.21321465899336625, -0.2619545056854558, -0.3734586802980423, 0.09273452066342307, -0.3390067445165784},
    {0.6841993763925043, -0.18315541241057698, 0.18586579592015223, 0.6766485107384645, 0.21716588945756912, -0.294670331414848, -0.02629438395670344, -0.27688896977037214, -0.5878948894047104, -0.1629099021245686, 0.31630721837716985, 0.09200091499732635, 0.18166013786664376, -0.6118423981934098, 0.14457943004957435, 0.08124319675262007, -0.28708601902060005, 0.3717111966386821, 0.7387237878831865, -0.14472115602632696, 0.152796549412105, 0.2004194967914198, 0.48071651203173926, -0.12470521656904932, 0.08703833413413686, 0.21816846079702237, 0.4401094657882955, 0.008276597270645532, 0.40574024672548115, 0.21305069188484918, 0.13598540039667636, -0.2660083953247041, -0.05070417693464582, 0.07001197240649155, -0.18148702876725678, -0.03288445859904121, 0.22402332879755, -0.12552395683443757, 0.4273086119616746, 0.25485103687502575, 0.11959417207697468, -0.3389097797397311, 0.05441183640683871, 0.11455657277448734, 0.11905360567317219, -0.08645992771830899, 0.8268960643021795, 0.152616266711749, 0.22490293093609853, -0.22766148820900717, 0.11326794661412742, 0.08303739359970992, -0.017439657907237338, 0.11468970818708588, -0.1500823550785434, 0.1945312450348279, -0.20738277182451065, 0.40987544661480474, -0.4986311252521519, 0.27644949992049517, 0.22323319043039394, -0.3394589106436833, 0.13323300783793732, 0.031241066249047385},
    {0.06558497489052216, -0.34497811399942363, 0.1994887747298303, 0.25359002585788964, 0.07561981298885313, -0.5005622734530063, -0.287398690694729, -0.1445564172990377, 0.21958459186339657, -0.01843269424376799, -0.05142441134644536, 0.2416593028910155, 0.03238510140848166, 0.14844684103348935, -0.14028392996833225, 0.4298986821558763, 0.03421418344803387, -0.6457769288261314, 0.2952952549554376, 0.2898354779640032, 0.633821803469787, 0.3736818238069166, 0.5317520329025414, -0.45498127188432685, -0.014033145413731395, 0.4265398104797502, 0.4002754654057017, 0.018769269966068012, -0.03816557536007631, 0.027807950346081217, -0.05713445189730151, -0.4440914719064517, -0.29818418915046563, -0.189615575977339, 0.5676800434532278, -0.253529861570014, -0.18373759308186832, -0.4774293273643289, 0.6917940390296065, -0.4630582974810017, 0.49882298673304937, -0.24431224820933467, -0.3344719366546801, 0.18060753545049024, 0.30875604635658827, -0.11975673084326584, 0.1999566043743988, 0.14649114961540086, -0.11228937094174658, 0.07671376661685068, 0.2782943196963315, -0.041786923008203025, 0.13838224652487938, -0.11325084545086093, -0.38721948590110555, -0.039345982428109445, -0.13019519168746163, -0.34946720073631093, 0.020798817287682445, -0.3414041468985906, 0.5866388029076453, -0.5941251533852291, -0.1417374103984724, -0.12058511505909437},
    {-0.7135861170168425, -0.19933950158122393, -0.2703247865637724, 0.060557258734429104, 0.7297802728342018, 0.07939338838815035, 0.08234073394969259, -0.789459535134208, 0.3175562141860136, 0.04655312578691803, -0.2077235564763178, 0.05276636220349682, -0.022334056515506462, -0.14148860103024272, -0.022568179372815047, 0.07838371106190925, -0.08758308727082774, -0.5561486230688878, 0.1030614336707943, -0.19315161148586943, 0.24895181749737125, 0.23939678753687219, 0.4576234951880746, -0.3039598165141008, -0.11616882632417844, 0.4143118278444725, -0.2757669035900283, -0.16006825781488335, -0.5009745559426582, 0.12223497594763197, 0.35900055486471716, -0.5129877051172157, -0.8206431611763617, -0.6456293549466134, 0.49302030298325095, 0.26508469714573996, 0.25426788955416274, -0.33995970269124304, 0.008727721364277824, 0.34943212014154623, 0.15525369056757846, -0.474954715358451, -0.325729316378134, 0.5788431494470118, -0.0340712663017096, -0.3232644621348674, -0.20423759381370685, -0.7322842273813152, -0.18324393137813222, 0.48971446945104113, 0.2516349362364107, -0.2579251335497139, -0.04367685288643919, -0.07753887321852244, -0.7744636466761207, -0.17730605021556484, -0.025789747670100872, -0.28085891075328007, 0.5118769873863257, 0.005914571598771171, -0.3624236266938414, -0.21059498130676893, 0.08495584482669373, -0.28001249538224476},
    {-0.16979574872984518, 0.6663562904120974, 0.10248317616162504, -0.008762960264887286, 0.5009720486833458, 0.22459701704805457, 0.4452221951202787, -0.4887152962398712, -0.25457423374463806, 0.26832643866077777, 0.18130355385101654, 0.06910312177788358, -0.023673771822706382, 0.23026246924236282, 0.05653724876674148, 0.1641167611827323, 0.4359515443112487, -0.22354376338164256, 0.5078954783788792, 0.06373707873410704, -0.0008323419049808703, 0.11938887374390711, -0.3135129346984348, -0.517284069786073, 0.4749555849695072, -0.6306906499126524, 0.25237764445063837, 0.30310382093342936, -0.30679366102045175, -0.1880881314031479, 0.41281647094772983, 0.5785447622539881, -0.04101160639224104, 0.16439622134616683, -0.2070946894188553, 0.11994775792800069, 0.2720488261100225, -0.13576512782168768, 0.17314335179663098, 0.6021736247302271, -0.1445328245984111, -0.3788604407473091, -0.41939561841664613, -0.35806624009887034, -0.3146188764622204, 0.2828351612405067, -0.35297429228618976, -0.32862603218837083, 0.06612087137659554, -0.05938833208854554, -0.11587344361624977, -0.0561620422204439, 0.3105808049537529, -0.020043347599713327, 0.1283171452847179, -0.1356731450248882, 0.7347225410262717, -0.05790050908975446, 0.09846700444277141, 0.08949824769372346, -0.7638303068617555, 0.8620721911584979, -0.0943866820971385, 0.5607094524138668},
    {0.06175435141859346, 0.42536905896676713, -0.12335398240595992, 0.14445385110545333, 0.2623637458927477, 0.4294528491373959, -0.1959125558751267, -0.2656811837397104, -0.23683943059356513, -0.16687325575984102, 0.03517901499542432, 0.041498411411668074, 0.3556396237984171, 0.16404192065148068, 0.15259784696938525, -0.2856469545060861, 0.5012270201875269, 0.07050207270862678, -0.16198258493417003, 0.017284588189215144, 0.37102550346598046, 0.2207106165090166, -0.2751367840800483, -0.3352784876501904, 0.3708809416908475, -0.7171025483735709, 0.3410082644028204, 0.30353564003377864, -0.13180630432543128, -0.10563203987218996, -0.41561104938686205, 0.15122386537802004, -0.0036549092798093476, 0.25811245972187236, -0.3518001466411797, -0.16753233332067285, 0.21636603812023927, -0.23421956468718189, 0.24897430488269298, -0.3182959842358179, -0.2553755210289256, -0.03126833630469907, -0.15008741760701358, -0.25856621971398264, -0.11355304673219896, -0.11567373147370792, -0.7734516934163923, -0.2513637931382537, -0.4455398808412729, -0.0550986557403897, -0.04076641909768083, 0.3158131834533339, 0.17925526124390118, -0.17667875466344451, -0.007322291008075675, 0.025048444999267675, 0.324186618013836, 0.5766676470926125, 0.010702650449364927, 0.3965072955661155, 0.1305687068218445, 0.038454061198157675, 0.05628749794241418, -0.19196451778153523},
    {-0.13862591373987662, -0.12714594823706302, -0.780647774261661, -0.003951276134292942, -0.2585254676657973, 0.3243871453763813, -0.15945163971554213, -0.4478853250553066, -0.32676698225871015, 0.1509309104422786, 0.4686069895376533, -0.46087049015111353, 0.11580533395527536, 0.4394167473018966, 0.05783289125210501, 0.11002153349487204, 0.10648186744757163, -0.3021991123566199, -0.4998516033740005, -0.18078063983303178, 0.4098349566820884, -0.29713571503748676, 0.23379831816750615, -0.20151786401032798, -0.2063121009161631, 0.09210706270273764, -0.35560599246781593, 0.2701520968020678, -0.16039383697601145, 0.49496430759572774, -0.36444411205686567, -0.587468135577321, -0.3987803243139143, -0.1743940127186627, -0.1506503409286182, -0.5884254997143026, 0.061402386673148894, 0.6684320615594249, -0.5981314817259229, -0.19619296764888208, 0.07886533397499434, -0.41737160342498697, -0.32118793178255606, -0.08498530850153763, 0.2684242620760111, -0.00721102571620007, -0.6784399291267601, -0.08689525739748975, 0.21921379299550536, 0.03214573408270663, 0.19046169393403656, 0.2706918057133129, -0.03160865739079069, 0.20989251907518924, -0.21769567368330475, 0.015637291033996328, 0.3292338953053011, -0.11523719059130912, 0.027665574245849475, 0.0704891888696234, -0.4169441602251797, -0.5884474252581071, -0.2760936930225212, -0.49439699399345044},
    {0.2767518787381331, -0.28557624854958075, -0.18545449601850672, -0.6336549137472611, -0.39565564268497755, -0.011842166653916785, -0.1838604736609213, 0.06238137516375022, -0.26440723395317794, -0.16524146933485617, 0.06424186289273283, -0.4838813748112635, 0.16691780021579516, 0.33342215107702855, 0.27402645140536547, 0.2053124785035114, -0.18711295138769243, -0.5720481726486281, -0.26819065271877784, -0.011155562812754356, 0.21071504673558167, 0.13389250447142417, 0.2770913310751176, -0.16513922750173993, 0.19952290147527096, 0.5192475175301391, -0.20286516190472512, -0.12217957431056334, 0.09807252712935206, -0.2946523310958518, -0.18184806960570202, 0.11857537103953278, 0.013690128132562053, -0.041534294628065814, 0.4331293770903874, -0.31070700514219507, -0.09570791554344465, 0.19078882803804065, 0.5963362290173307, -0.42097143954209587, -0.2092006480711599, -0.6086661824250401, -0.3105245852552164, 0.33966127369207244, 0.19501005650538789, 0.5527809027789833, -0.27943809979607065, 0.3771044140215791, 0.5673908298726735, 0.5231559141697213, -0.019528778612228972, 0.06681356172809473, -0.21143779431548645, 0.2124886510544187, -0.3810383643291002, -0.01816490230133948, 0.1291536411136136, -0.5425625309741956, -0.3661456027212323, -0.3226191325025342, -0.28895090428555836, -0.1633790221845862, -0.2852011001168899, 0.6314400549610215},
    {0.06576936735894584, -0.3683836881358738, 0.3608061394898106, -0.012102228760647576, 0.09210592066148081, -0.4986454178178542, -0.533563956936229, -0.2178600651765695, -0.007581964551647536, -0.2757013183737584, -0.4298026914508278, -0.3999255223178475, -0.44525610424278333, -0.1213068589129035, 0.26314322846971316, -0.3463003332260241, 0.2285318328385894, -0.334248851391812, 0.3722943462971248, -0.20103593011711396, -0.452068060647377, 0.43056322141755493, -0.06760622343243027, -0.5362657907572275, -0.34789601196896497, -0.1530154987705681, 0.04593494517964408, -0.20622680459042841, 0.4638072264909467, -0.21650624239325317, 0.05052530991131025, 0.13473372567779676, 0.2178620518567988, 0.16578104492962636, -0.044279026836204924, 0.15886625762099824, 0.24737524559153076, -0.3471690804880612, 0.4766037500833066, -0.12912276186367977, 0.11480643826275244, -0.1266689021936493, -0.06493992326811138, 0.1639706350328867, 0.0010618982999626133, 0.2875047175585689, 0.3111315651459338, 0.29240720002533477, -0.013956521661568261, 0.26232089221333676, -0.27674571703881634, -0.2667483137562961, -0.2325518652987108, 0.02597161472221485, 0.666073222287713, 0.12684895909202645, 0.12453165596604882, -0.012222897988464982, -0.543665076977882, -0.30273867778265984, -0.04151873663878633, 0.3456094683635116, 0.29796410909361776, 0.650745756621156},
    {-0.4001445673782058, -0.4482276252321021, 0.14291254749614485, 0.1462341269002197, -0.2992710959221203, -0.395603804218186, -0.2507677354683334, -0.1771023578776022, 0.3544737662135381, -0.42524917391313566, -0.6992168212632016, -0.30543657189150897, -0.18282539228327715, 0.467913605579231, 0.21579105419397096, -0.39063161677617486, 0.4689809518693135, -0.6127801734738768, 0.15693505425353, 0.04430843237598591, 0.05219998893485331, -0.01101545971091744, -0.5352852757130454, 0.10377637220290356, -0.6107060019082272, 0.28257206880955804, -0.08932336095745293, 0.07413925105174655, -0.06343353579272551, 0.1396289551151805, -0.4524759046428441, -0.14995074023696114, 0.04126438490571611, 0.06926676882510428, 0.2823544580859172, -0.13973668240704984, 0.5875517348683792, 0.5636149573798982, -0.19793923777335504, -0.1402152503719889, -0.16453405067471058, 0.1896213618519456, 0.32893888666836935, -0.2025234961563252, 0.3241601209756306, -0.18112128027954824, -0.05201231525016329, 0.2047273414515741, 0.1446257296478146, 0.13680938836159567, -0.007811996992354314, -0.27949251492680166, -0.1894061083418932, 0.5864927466008254, 0.4538709593947838, -0.18836414222068643, -0.2833327786148877, -0.12285019370330842, -0.339489960351788, -0.17088489063463516, -0.7305719486778293, -0.1217088092247142, -0.30568206597740943, -0.0005829260902001018},
    {0.5293186179815801, 0.026285006216471674, -0.216138204888625, 0.4172178844082108, 0.22094141577341012, 0.052297336268337165, -0.012451544669534314, 0.32558649847383536, 0.2289914100528647, 0.13532324017755798, 0.17325718846132435, 0.052895041023177033, 0.6706612457500136, 0.21536478176221968, 0.4750950182713125, -0.16899539987453363, -0.15475451698188047, -0.06032974440417557, -0.6099758571790835, 0.2963324732606024, -0.11663993667733658, -0.1432303737274059, -0.24654685307649857, 0.3655596651599233, 0.31663709727983647, 0.30437230458231107, -0.13448350240050455, -0.42440892070235964, 0.042502341989640806, 0.024456352425972435, -0.6482280672608097, -0.09803503485182517, -0.060764667387589594, 0.20150283326213686, 0.32216064968301394, -0.20881559668456365, 0.20954679657950276, 0.539681717454771, -0.7667648376504433, 0.42217254328544324, -0.1738732736859721, 0.01571969463465666, 0.35264622222572206, 0.01356229225480653, -0.1049236717198432, 0.2703464739522097, -0.22209108868353214, -0.11384103891049176, -0.26490542838760833, 0.12996249754974804, -0.556171183709787, -0.01905234869110546, 0.2335983386821287, 0.1852652615880713, -0.29255138954346716, -0.38455015819153354, 0.45483775669980536, 0.26675918011637223, -0.05779045312459471, 0.08868928972707829, -0.3112090592037104, 0.10965297953662341, -0.16777249930528618, -0.390125063287082},
    {0.04599695710771244, 0.22599452536761166, -0.02501880418531518, -0.0037384504265642535, 0.09570854924492168, 0.062150515696726576, 0.8821948526957107, 0.07463403181755417, -0.009942864508203714, 0.23386044885061336, 0.030666909367473773, 0.3239292586551372, 0.45801590189099534, -0.31270316047410673, -0.09945749923574652, 0.9069058664480041, -0.5102619837126499, 0.4386939416088953, -0.23045788128663766, 0.3993079200042474, -0.13240651588791433, -0.13410967107924215, -0.09277968722177998, -0.22036472520669065, 0.596629481041861, -0.4120545604265289, -0.22939584679535438, 0.14587218406985794, 0.27170772885687877, -0.11895193102650334, 0.074990569884727, -0.0967505720973683, -0.31403858590025197, -0.4247765796848221, 0.08083551247410971, 0.047341831969611156, -0.013238028397112021, 0.23525860604780943, -0.2891692484385725, 0.34858966887720555, 0.3505909083890518, 0.627386844589319, -0.11962272927046508, 0.021586719899547586, 0.11731571636721284, 0.022308215316161974, 0.029763685378973267, 0.04780388444098738, -0.18083754123493861, -0.25745477259314015, 0.41265765579616703, 0.22890636953933882, -0.4566909433947795, -0.5698272309107147, -0.35672408902460745, -0.4700212347638185, 0.038998403323772884, 0.4409982539944802, 0.208619041714522, -0.32089327073726576, -0.04739937066230433, -0.4014204731336034, -0.3181700363018535, -0.0692764070048247},
    {0.2284498880983868, -0.33582710660636705, -0.029641211163573416, -0.20408335483859763, 0.14970005517330862, 0.4164670730127686, 0.26219504470692584, -0.15501817021810552, -0.09972028385013515, 0.4816568491632852, 0.35193134653663766, -0.08070049134524189, 0.2548954847397684, -0.4202193467653728, -0.15909603655227, 0.4483903525908192, 0.14617103593945166, 0.378114734978426, 0.6350797413207364, -0.4698367093994768, 0.07241483882368367, -0.5424023132592625, 0.19432041577648795, -0.36400519525842495, -0.3072235747462641, 0.15138964432569435, 0.008817424307527653, 0.02876990385992556, -0.0005652697483266082, 0.19128876518766938, 0.4056659850699185, -0.005083531976320885, 0.12991015398339442, -0.19425103509618075, -0.20132822501657435, -0.17832805291057158, -0.2119720028725006, -0.35272802601868536, 0.19103175192117663, 0.24093206680116805, 0.02106637639054662, -0.04855054478030268, 0.09889931557228489, 0.09709515925982833, 0.1380171324870704, -0.6322004876119972, 0.009029682535525859, -0.5335899812562561, -0.3815119980915999, 0.03835363773678867, 0.1704302432019023, -0.06797259599570595, -0.160532556803019, 0.04267955039152181, -0.38325942627922943, 0.1945285494572376, -0.5317430300109359, -0.17109317922188153, 0.4852607661305777, -0.0656398856563242, 0.13696041505667983, 0.13727870512388252, 0.4941906271939668, -0.4653439377543744},
    {-0.17012604374422113, 0.011262650551671166, 0.23484179204453268, 0.4102005881786864, 0.028544129907493117, -0.006945426880051678, -0.1830159707410102, 0.3848459680457178, 0.011484513719546357, 0.14958081793219358, 0.20019362436765772, 0.03524425074687638, -0.9730914172009679, 0.22625849072453508, -0.24317653472155024, 0.4026862948473799, 0.31167012695945107, 0.34159609988810147, -0.13003334096090244, -0.2988190522549345, -0.5549043965892733, -0.10170571986776913, 0.038195782991350104, 0.16124160517724023, -0.22431964969077042, 0.14337904093122983, -0.25774452410949905, -0.01173224526026626, -0.5566445235426039, -0.22664722659277695, 0.16020063457370087, 0.19081192424900792, 0.6205173236527216, -0.10448793276989667, -0.4426470286553216, -0.32582826642097135, -0.14275194451857232, -0.3199463750540533, -0.3322621975973742, -0.2588935989650058, -0.5503901512960273, -0.16769284761728298, -0.17101425259936584, -0.3952931587107275, 0.49247115408210107, 0.26957398018434986, -0.21728089961862893, -0.257595217691811, -0.22897845497906888, -0.20338410257657458, 0.063364275546233, 0.1012116846516175, 0.007440823813151773, 0.26794222850962646, -0.005757445087718505, -0.5635024123470547, 0.34824923029888716, -0.06328412275679977, -0.27611817737174216, -0.5975714565824958, 0.07855738013935962, 0.1970843201817136, 0.381687008474541, -0.42332981759504346},
    {-0.41384009628616925, -0.011916128760060912, -0.1708563701925436, -0.014422248353576504, -0.15982539729808526, -0.18751240791665785, 0.2787413236906605, 0.33653517547186984, 0.4036193349245985, 0.07732592479918596, -0.05747486060857388, 0.05947724621268529, -0.23526291496859128, -0.20808258871494362, -0.3614234549683723, 0.08123964602001978, 0.05602034443465073, 0.38826109784853224, -0.5061891376855012, -0.36782796052136846, -0.39380781187682784, -0.143632464099326, 0.16900555905338352, 0.11310256470072215, -0.10633693807656827, 0.25501562544954476, 0.3960321302062874, 0.39544231427965454, -0.4107817159776295, -0.17852385288504574, 0.20191448664696915, -0.011859416958038594, 0.4412172077424525, -0.6375411473087891, -0.45698661813875846, 0.2828449234894103, 0.07709735434698924, 0.37601097069429695, 0.10657229174128748, 0.06107201157346065, -0.14316766009021548, 0.3896698694908004, 0.5888293841422715, -0.22265984761454732, 0.14008298957322524, 0.2919062016122818, 0.03132512449002818, 0.19157869098783184, 0.48653360897763664, 0.25471785960718973, 0.42991081769965866, 0.565959183259785, 0.020429856906712736, 0.062007753925795134, 0.34374970843574665, -0.2257105657098217, 0.05220251926139145, 0.16224152429044073, -0.7427394155079645, 0.33502130605735597, -0.018251259391758257, 0.04814722210075852, -0.07249230587940796, -0.12208145139754623},
    {-0.09649885921101571, -0.8315546399565368, 0.20991985950345746, -0.24994288019634148, 0.18925745097520305, 0.1098195938254714, 0.4483672281047801, -0.11207831787908615, -0.4693299626499518, 0.21649803172892831, -0.030316088681307723, 0.18119470861434217, -0.1449126146811113, -0.013110433023751646, -0.19727706076973878, -0.09398232193218206, -0.46699492935979875, 0.3526804817033958, -0.48742226636865105, -0.04832800397003965, -0.027250853596995906, 0.04771946439018262, -0.0850804680352357, 0.22478584602087073, 0.31792030765246077, -0.17741982670399803, -0.12055441797515853, 0.01470972086644139, 0.13505184145206903, -0.11757416055224523, 0.10913127983753478, -0.01080265241551385, -0.03947598077821151, 0.19846417565918012, -0.1573837172619032, 0.38148201941750437, -0.2729528147223153, -0.13900919200298853, 0.6644317775352686, -0.03607229043118786, -0.1596834536575758, 0.027795335555643695, 0.25764137162731593, 0.75727725487802, -0.2363930815787565, 0.45040399539228787, -0.19454786008475947, 0.2741412893028109, 0.057806714389992256, -0.43448119619539133, -0.44321031409540523, 0.5126778782145587, 0.3866753436816002, -0.18610269505471025, 0.5264387056943517, 0.16679619961659686, -0.2826397232780569, -0.07358559867752018, -0.43765243223304495, 0.027239400871566233, -0.1924003015110107, 0.362235970303239, 0.08899259583731065, 0.5036339242605904},
    {0.07317687932001164, -0.38764965456288897, 0.09879358463984562, -0.3819879841500504, 0.5926770906928988, 0.15844860709270647, -0.3108211316196501, 0.3361707096252955, 0.06421055180278037, -0.3127262622083881, -0.2678895659847307, 0.004294116224034756, 0.14421566885607442, 0.265788804679445, 0.3305447888659765, -0.34760744625645656, -0.22852506307932333, -0.08807434136730846, -0.47370597186984037, 0.12229943461060024, 0.08363246367291599, -0.13782620896980474, -0.23156622393499035, 0.15359847579722963, -0.2756709066069467, 0.3093457849362255, -0.15382775270616636, -0.3615751077767778, 0.4003881480359061, 0.018388395602925094, -0.20546064868646977, -0.2235305178491269, -0.0917960196565068, 0.1349551572893681, 0.110591497849694, 0.28449097820248187, -0.10969114865588518, 0.059219040158629783, 0.3036525741359189, -0.5462035499720519, 0.3718067237063201, 0.20221237374889675, -0.4509221947072027, -0.05117793422396633, 0.048537212018286466, 0.03421226351463148, 0.11424440510112495, -0.008160912979690833, -0.6117638890194896, -0.4020095026286887, 0.1481768206660777, -0.006451226658052077, 0.31711374826710936, 0.4912077553616667, 0.6131469063083653, -0.24500476084832573, -0.37014815001858975, -0.2976793298471803, 0.3357685274160187, -0.26645461274794807, -0.08589186323254562, 0.1823732090297708, 0.0796245832814906, 0.16541992230998293},
    {-0.32511059171820644, -0.3510048093553011, 0.3509177892113096, 0.6297752697537369, 0.2934822259038448, 0.2969070773740831, -0.41481582010588935, 0.3154527465952969, -0.13305553121511235, 0.36354542881298335, -0.024366185151128882, 0.30328367023813024, 0.18132262714251593, 0.02108689071142265, 0.38063413311423894, -0.23568115961484196, 0.39912799617857286, 0.054951163064306224, -0.3429433373251396, -0.019450253650490835, -0.36176855852377765, 0.15795953049431638, 0.6736957661339074, 0.43602842149066845, -0.09678513911227882, 0.0928819784869612, 0.19880563167068213, 0.15825687534263036, 0.38188258036770967, -0.1494317754999633, -0.12513543614810288, 0.350419421845282, 0.6645576889796074, 0.2119475410299923, -0.22058767021988024, 0.6542323171795182, 0.786967262220394, 0.47475338156668295, -0.1422364322955171, -0.18802136096836342, 0.6443253900328367, 0.05825059256213255, 0.28503924087015536, -0.002303565931390479, 0.5347790640942289, -0.23890936163964122, 0.16355614209941208, 0.30549519327148683, 0.4212867744656524, 0.38096816588448684, -0.033892325549576496, -0.3360288446416976, 0.48859556145024163, 0.21511240417817223, 0.2998744889629166, -0.1261427440488763, -0.10192943173978723, 0.20799798883520068, 0.4631126692479623, -0.18394739359766882, 0.05786556144785273, 0.2597342402477578, -0.07114773768096906, -0.26986812225171347},
    {0.012464278690275294, 0.16943426423840627, 0.6291128107014489, 0.048373568706779516, 0.4806797416204134, 0.16711520152803186, 0.04499167671323184, -0.371332511908929, -0.03643081262314881, -0.17539791822827547, 0.017995303475530324, 0.7522236321451019, 0.1252785145227987, -0.12935820295018038, -0.49932541818951076, -0.048117014339826715, 0.03702696179317792, 0.48888001678348875, 0.4448528209300449, -0.1070252893777438, -0.4337193400866742, 0.023763666573775405, 0.7132155250516522, 0.004767144196913279, 0.30576880803196044, -0.49573391218790736, 0.15298078341968951, -0.03661993297345989, 0.7172979102422178, -0.045268136233264984, 0.0007870979635184771, -0.15932500731941718, 0.061527343118924216, -0.009324415583552879, 0.10044530334549422, 0.2501456584427734, -0.0644611707537303, -0.23200504707939046, -0.0090769219166232, -0.20920492543633426, -0.27313544867719075, -0.51678463312868, 0.2919338066024884, -0.03683982173079028, 0.14243699345490962, -0.5481518872244099, -0.04804503071330334, 0.0031007517470133406, 0.10417435025850963, -0.2376268697015846, 0.6264925783873606, -0.7233853261250623, -0.14049937243985916, 0.15410361708769973, 0.4551132209490889, -0.5129177502360555, -0.4069169831449898, 0.512889357132577, 0.3292767452434713, -0.0074781671736911135, -0.3697183215246387, 0.33253395221210374, -0.23550036987132267, 0.08465742844256235},
    {-0.03282312573246623, -0.7302196100260013, 0.025563260078055643, 0.42638524895243096, -0.008893982233922388, -0.35189763071232766, -0.25955673314022903, -0.066198071486059, -0.1949750634432709, -0.190586636711193, -0.09085371447997297, 0.05473324093093365, 0.35233584007321095, -0.14975562692510752, -0.18728204275135, -0.37685476119561906, -0.23906023397187082, 0.4923503741135166, 0.4530351293096378, -0.2806964983131953, -0.1456415646266336, -0.38188777519480155, -0.7085444003578025, -0.2091141761687061, -0.17070414395306108, -0.37908130610628415, 0.19741489862750727, 0.1666842114903352, 0.2273089580715515, 0.07487516943427173, 0.16874476300287874, 0.1694040089653878, -0.21060084371861187, -0.12962947594353902, -0.17644760240185417, 0.031177526851582527, -0.2710722985068868, -0.08823067638497786, -0.32104197917735205, 0.5253678500588278, -0.49001647003047266, 0.0759285100897217, -0.357946445446748, -0.5174694750765503, 0.15290282334164873, -0.6690650350382364, -0.2909706639870038, -0.5612225845885497, 0.1459813788193565, -0.7466709271849377, -0.01335281579353821, -0.3868835623335776, -0.6744311990707514, 0.2038928709848446, -0.44204858792711255, -0.006927602309605271, -0.2163179265246512, 0.12058878627357238, -0.1454312625893093, -0.07059546911048045, 0.28707440589391664, -0.12457102298064546, -0.15731782394919552, 0.0659466159262011},
    {0.20736195016185652, -0.03248421789101987, 0.0788043360873897, 0.019648977534622063, -0.3877346309250586, 0.17091785205514748, 0.4151436013173345, 0.06237990790450129, -0.037276375486219995, 0.09118733085221355, -0.16695443062789728, -0.351662666031118, 0.201890731027297, 0.3149653947124529, -0.002926892876830116, -0.536622260169601, 0.06077658771725999, -0.12996517525020787, -0.03752237165320509, -0.32378524152031724, 0.2370480967235683, -0.38058249407477845, -0.501071308095821, 0.14629457625410794, -0.2307152781083718, -0.050928934920188615, 0.3144695446713645, -0.008531929554448104, 0.09094174055751607, 0.4476044143106673, 0.03280511353204194, -0.4019433859213044, -0.3119545142907573, 0.1535796027176797, 0.1288832727137988, -0.2979067179858531, -0.34193487962350516, -0.18390777334520916, 0.22989202385390484, 0.16548471720320201, -0.12564821002631327, -0.3744867262338567, 0.09997661600490969, -0.3323000708273755, -0.3768514025253836, -0.08512889597897202, -0.5343753767090583, 0.1631086604136537, -0.33716121825799195, -0.18955578041574273, -0.47534699671346414, 0.15125001108816158, -0.2639155363408098, -0.3835201779910251, 0.2743736508221769, 0.015241931102133283, -0.20251824829264406, -0.37495318543840483, 0.671200533794643, 0.006211345877197971, -0.12418556653802577, -0.2920199747467052, -0.17689018681419372, 0.3984635888544711},
    {0.5941958872822029, 0.361096862604135, 0.19257233185720937, -0.057325729446067494, 0.2594178807213734, -0.02196689631433345, -0.6961413394145998, 0.4152256607001724, 0.2491413679589512, 0.07092652968405082, 0.13279558142982215, 0.16003702038373244, -0.1960792233927149, -0.010657163040128287, 0.11805123382902946, -0.16175503602652044, 0.7168267039979489, 0.47380245282091726, 0.4016515722312128, 0.0806687452767899, 0.22070906032387644, -0.35967490534379215, 0.1608854352322717, -0.04280098793029063, 0.548590661744887, 0.7807849163621599, 0.3678126313494982, -0.2831944508741957, -0.217116597983379, 0.33096823701354244, 0.24158942641630815, -0.03798755390485114, -0.12125076955865743, 0.31523414528484883, 0.40641404197547043, -0.08341492647306156, -0.2398110895854386, -0.31886671441932224, 0.4668207766177842, 0.16973418648070412, 0.2943422688621303, -0.22813623903219035, 0.48710245639649075, -0.3742886174761348, 0.10476657421050244, -0.24433421275517428, -0.18741061967210737, 0.19205764795625602, 0.03581076754658226, -0.16753423091721112, 0.15007744569079112, 0.15074797049493502, -0.33767583959425235, -0.10995728140175733, 0.08685612755190039, 0.012805523194279897, -0.5116028936098636, -0.32781861156725683, 0.1495633249986775, 0.25132029165917164, 0.3154486775820708, 0.2552728516354716, -0.0725561181837533, 0.15476636495643895},
    {0.04809354185255196, 0.47680287904356455, 0.09768974169960157, -0.24421584922414108, -0.2575226975402244, 0.026344190843007556, -0.2816811588838366, 0.27473815549436825, 0.21499116233047288, 0.20169253848302773, 0.6592015605643032, -0.0012562011297373218, 0.056969418387890616, 0.025183233277972717, -0.25480482961950557, 0.09778834913695329, 0.3549951733646811, -0.31333088771319784, 0.23015029250190308, 0.16554794234028194, 0.0321420283250475, -0.05673061042750877, -0.1106364308511858, -0.15198687383294746, 0.2537480616447703, -0.038578794887029415, 0.3603946296130706, -0.42476418451537423, -0.13508411347633426, -0.17694816886888665, 0.05677730092590127, 0.23109481043305097, -0.18372249260582788, 0.5595111002056906, -0.08181059428779151, 0.42455388214974726, 0.019139308022314387, -0.18996105246673237, -0.12117844828097703, -0.2688320212691636, 0.1201418983644493, 0.028282886609960256, -0.12140922302545851, -0.3420607802712244, 0.7820185944943191, -0.2989949114107503, 0.345897187963634, -0.7161209394031037, 0.10076240930374464, -0.07762683438534827, 0.1900246288953178, 0.33447270968734083, 0.045655582102196356, 0.459649034209998, -0.435570770974554, 0.3659346111447753, 0.32886137325652365, 0.3536538672335272, -0.5789086331308606, -0.1609202526198257, -0.2342668646452137, -0.22392839683558005, -0.17661717540516977, -0.16348643875534755},
    {-0.5643985519489031, -0.05724720345562324, 0.19385584061591293, 0.1274212954179919, -0.05366771785849528, -0.06911666854870384, -0.24681213861470142, -0.3168993086719532, -0.06330025055804572, -0.07526773226468912, -0.0532044104530724, 0.005318855777353839, 0.1509458423844419, 0.3588430442731394, 0.02162295781848202, 0.02720457849086865, -0.5470905893708387, 0.012133809263382969, -0.13091179337538356, -0.03331913121460018, 0.21912556421375612, 0.26113781929940955, -0.23641501516006977, 0.11366748513936975, 0.18923268226500908, 0.11274313559172414, -0.05507479074047883, 0.2702855234770199, -0.04492198461622996, 0.12089032233796419, 0.5707084523973627, -0.433131310231291, -0.5224212433103538, 0.1287020977999353, -0.007280016127876013, -0.25433824031853175, -0.32282049572770494, -0.30680769254410395, -0.20069051326699877, -0.11485949141826696, -0.08273896477002597, -0.4000218242024832, 0.5667216300018708, -0.13506651008646084, -0.2987423877863001, 0.039758515583979984, 0.06398518428626748, 0.2960538695148691, -0.06358173521562145, 0.10183225859093012, -0.45454550316564235, -0.28557609872090906, -0.294024898397745, -0.03209007017815511, 0.01186015469240488, 0.2802820280664608, -0.4973909083168131, -0.46524012708933465, -0.21818329222864438, -0.02616262002694604, 0.05386836028805659, -0.5562534934832445, -0.5331833272615016, -0.16286416485046235},
    {0.08167873484037981, -0.3356671325619153, -0.07806826297504194, 0.27909509652306774, -0.28849354338527344, -0.24619076850236185, 0.23000756761273103, 0.18586452188708127, 0.19203246191998222, 0.13731159982720867, -0.3624336290242277, -0.2585653426562592, -0.3662624155063347, 0.2109295060833838, -0.30400459875754643, -0.0007957082013452156, 0.23668453675879492, 0.38667904157299604, -0.4917262666694627, 0.1538691860483737, -0.21412386489747687, 0.6206546057653491, -0.5248614945471355, -0.5394762535489752, -0.15251163022920738, 0.406613579802084, -0.017473360102127303, 0.4245068541537039, 0.4461751668463198, 0.26139989223444593, -0.22780587368733335, 0.2751162557843412, -0.12353129270232245, 0.05112593841989049, -0.14485332396386474, -0.02399863908970425, 0.3229147584057944, 0.1958720179598627, 0.2949298038261198, 0.20526961996994927, 0.3899809502789594, -0.5727958135791495, 0.08173983116809348, -0.3661511807764265, -0.6634527169873953, 0.08206749436358433, -0.1600586071934591, 0.5720653655233058, 0.2309512644930895, 0.1261548386081237, -0.20128816972808541, -0.5331358230599085, 0.22598139594116556, -0.05835065893405064, -0.08357482051975809, 0.2617154350869097, 0.01648612212095408, -0.39416370235471776, -0.2062932597658011, 0.4895864952204111, 0.11304411265923466, -0.13252057045210316, 0.19305377332001758, -0.43733108390124087},
    {-0.4557133799110927, 0.013498370832004192, -0.36257666091027857, 0.014827574594630731, 0.26641564528592093, -0.24430614068326592, -0.2705613565453783, -0.13767743770628596, 0.022830591365138174, 0.024005777147973393, -0.4755736148595119, 0.22772242979668447, -0.2810481412178909, 0.25004540107311063, -0.22189360882277395, 0.46819199501541564, -0.354522283243837, -0.3398365004169235, -0.5826516088566445, -0.673217398632758, 0.3898632544421834, 0.19426688542765955, -0.06081139485500114, -0.3464147142847417, -0.1848064606751738, -0.08689068867189931, -0.042720198508679225, -0.33522851784638646, 0.2542814001266191, 0.05987178363403269, -0.4977956808807086, -0.20673469609270861, -0.2674454072870331, -0.39215243365430225, -0.3015364419433937, 0.24220628035380898, 0.14293987741083822, 0.015376130751068879, -0.14919873056108063, -0.3713413003051519, -0.21630302312973518, -0.17092931124316998, -0.9132412466169346, 0.1017328725528352, 0.20972907504969146, -0.02848634986146215, 0.43021180153487, 0.11957158950663628, 0.31339861755363546, -0.27806865823626736, -0.0027285397597702444, 0.18121928578546434, -0.12969044574990188, -0.1066295128242909, 0.18222098961295047, 0.2568588747052119, 0.06307914933539265, 0.22751403397741, 0.22204102781989857, -0.19582513006996743, 0.02829371191557058, -0.32960685604304785, 0.21503221607382464, 0.05420739621334377},
    {0.051658560702784344, 0.044336923691067204, 0.045487379376376494, -0.28337712406234833, 0.08541577346260652, 0.23949226966294465, 0.052270814302148055, -0.31544409663753714, 0.03550494801813458, -0.12272699899998828, -0.2649527419605, 0.11928040887080651, 0.055538145361296906, -0.4356746912621304, -0.1635796740044722, -0.185595457309051, 0.4011782236276429, 0.03849236435970314, 0.37059313619578554, 0.3099894204097056, -0.16800650478936255, -0.20385027281707488, -0.06807698989331049, 0.10715471046940869, -0.08205212872172957, -0.26673557700997763, 0.05537289893494477, -0.16954818383640025, -0.2469693667050432, -0.2044000251715056, 0.08503196747737093, 0.08138982513982766, -0.3082410009924089, 0.15012052466614123, 0.40312137217146243, -0.39234618258557663, -0.4410118512446621, -0.09147944474305107, 0.2804813816590844, 0.6201711498971679, 0.01223025575069467, 0.15079487784204204, -0.14602563430171653, 0.6472366330264784, 0.4197222753650031, -0.42696650692201943, -0.04544068894318975, 0.01495896266321736, -0.12173056901412305, 0.34107393418219095, 0.3050825200029888, 0.3767106661920776, -0.010976733622754755, -0.08507743475534345, 0.09459324419574335, -0.19121172884286072, 0.25226241799083604, 0.29926150250632744, -0.12365835326312179, 0.18574215290444812, 0.32493396324304297, -0.029381102469418895, -0.3051965656680955, -0.1588494761459776},
    {0.405671898197034, -0.007358666533772223, 0.04893188895358934, 0.1805199797417045, 0.36403608174605795, 0.38676938147357437, 0.1866753143407339, -0.3967162673691611, -0.008644721927749805, 0.23512968580281635, 0.35824451634481863, -0.019406476356505522, 0.720874222813655, -0.44006831666623364, -0.05055792774446075, 0.03570219649135673, -0.0018626953904388672, -0.5917618635022509, -0.18941434430317372, 0.16980120379424438, -0.13734685632585883, 0.07919291627217277, -0.098064788875968, -0.472059851268815, -0.1275535148479577, 0.05089180337285258, -0.008538591803118382, -0.2251235455329365, 0.1726571008765063, -0.1200745614931918, -0.17418167166232665, 0.28738101262625393, 0.45648879519892543, 0.21995461521324294, 0.08405381584714093, -0.4261620159758443, -0.30692100119237753, 0.21079326767319623, -0.21806148552065052, 0.23030811643562688, 0.07027794213626884, 0.5307508660752095, -0.33609499962855993, 0.2151578034468426, 0.43231854059686775, 0.11965989228863101, 0.36554397509446723, 0.18188567246536305, 0.4334387342165507, 0.09250694380554658, 0.05605317573312674, 0.266300784336336, 0.5348388360963223, 0.29622573677864916, 0.12359853900320922, 0.2432134262973532, 0.44209635660543023, -0.014965239561972465, -0.46612799536626853, 0.06463218307189435, 0.10962938521132382, 0.2787288169735408, -0.1659441500093703, 0.019355033046840164},
    {-0.032141550261691285, -0.39707257577233646, 0.16432637619787352, -0.4132704819220943, 0.22253814267746302, 0.4974225239319958, -0.03325361083430806, -0.43433105450769643, 0.12433846985760828, 0.08955918124441264, 0.06753222564949252, 0.08573730420665274, -0.07068000786286432, -0.5751174942241274, -0.2820294677415561, 0.2826002328578217, -0.5704646648235083, 0.41398523569218426, 0.21065686853816593, -0.32491333506127695, 0.5694922748198246, 0.12272974275682721, 0.21731456869409815, 0.10057265734914339, 0.06947490187583681, -0.1824751741421363, -0.2017098641196848, 0.07574736129059396, 0.08648625725200994, 0.11241511465597799, -0.03182601106881413, -0.5034862066323339, 0.722653604310497, -0.14302223320214263, -0.0465918127662617, -0.19849057300846826, -0.023026764702488982, -0.043850018023418424, -0.34538908065288654, 0.24959424911524988, -0.44412822207541014, -0.11386324319316941, 0.05945610667566256, -0.0010403250087546022, -0.21440704244765144, 0.40907615794953806, 0.05573948721975967, 0.05492893304262519, 0.1413444844953902, -0.10212856695000266, -0.016344070982606613, -0.061536030373089995, -0.0008521615811452719, 0.1675754710135182, 0.161975805455311, 0.32123652761222266, 0.008444133470104975, 0.40728821363024875, 0.266934184977406, -0.09965597377799858, 0.08387101433298581, 0.18155892634422469, 0.45770390989266835, -0.26410039759812876},
    {-0.9230821786470482, -0.7358366193881049, -0.4050286954907814, -0.8652577818880302, -0.6098550907901598, -0.2579274484832266, -0.05766443304548383, -0.16819691737336603, 0.3686786039765249, -0.3263134200262996, 0.06897086405355174, 0.269328863090689, 0.10820366643871851, -0.35304974060357414, 0.4731470038839308, 0.17310708720592385, -0.2986076459783745, -0.49385738831698867, 0.3350888628968226, -0.5699626263530835, -0.5665988658714607, 0.6139814728346338, -0.5637393456378712, -0.9059870217868058, -0.29877906589231196, -0.30531987821333945, 0.5474455553896977, 0.600564845553534, 0.5533141628874595, 0.13378744475130336, 0.560334268176023, -0.5849972215043633, -0.8069249977263275, -0.7088320992689526, -0.5888024390088747, -0.7695553869185756, -0.3885409702124872, -0.6410402191875272, -0.21605590774801595, -1.258138316193389, -1.2118661323863806, -1.033259726682854, 0.04238981114677081, -0.3726070383910272, -0.45001594369542935, -0.7078097720149695, -0.7313190586352555, 0.33375400517649534, -0.9401611351801138, 0.44124046141357837, -1.0666743054499062, -0.14194426018572803, -0.6588231787823158, 0.08048069016178003, -0.10570090614195303, 0.740077616167862, 0.4467437165321619, -0.4669497817031415, -0.3061207360887233, -0.2195754699031754, 0.6206022764627895, -0.5682783521480674, -1.0381762898508506, -0.3608228486861383},
    {-0.9294852056474117, -1.0068075558668679, -0.40101497276458503, -0.7766721647192619, -0.6503017060290416, 0.14963921963551968, -0.5470780378588571, 0.44857372364318787, 0.5393222269346825, -0.465836077187182, 0.48930838226654266, 0.7033842636950196, -0.1686832194392296, 0.2548807925651469, 0.4603513194262665, 0.03317282479859361, -0.5308224020071944, -1.1846730046523555, 0.3708764328470092, -0.021451882507264295, -0.8699461824187008, 0.7765482579377166, -0.421537858333709, -0.9956707691339328, -0.3618103341710278, -0.6069886089394931, 0.5641892414458293, 0.7290435540156875, 0.6484671097618213, -0.3441640936382925, 0.4906205559070999, -1.0313821320272434, -0.8785221943042633, -0.6903369089808731, -0.9907603608356175, -1.0374345943215675, -0.0866376731621166, -0.9539620778940662, -0.30912610433319454, -1.0192513771162262, -1.035887289597885, -1.1426826527492762, 0.30925261972063434, -0.13716658447527413, -0.6187990818724379, -0.898478500440286, -0.7491552004136891, 0.4749167597887015, -1.0291198331850364, 0.1765481543931924, -0.8110811648555608, 0.08456532575466305, -0.9794267810371698, -0.5569097571132642, -0.3709270459107036, 0.6394497178145659, 0.3053407082364656, -0.39268866182173917, 0.26577015684795385, -0.7897150109441827, 0.3742911206914012, -0.6896144014815654, -1.0895690362247104, 0.1013073990290499},
    {-0.8977448493605643, -0.5471598880011288, -0.6992163764785824, -0.2650673422265641, -0.524186232546168, 0.28795046566101734, 0.3288886589555267, -0.021539577480471313, 0.29779673206615764, -0.36070152720862336, 0.0895457969396953, 0.7318930297301444, 0.1296606962846492, 0.33054404215610406, -0.6709020990493051, 0.44039500524140995, -0.13147229295476887, 0.3069305215033481, -0.12304676192877623, -0.694409154511291, 0.27483223245605065, 0.14599210163388407, -0.1009797764527249, -0.4192533406405812, -0.6138315894969233, 0.18523567447430567, 0.31845604749423156, -0.09803349131181274, 0.2528916579279297, -0.45285332325349364, -0.5257976998863582, -0.637735466254247, -0.5673381228471153, -0.44060356624310965, -0.9230781889474253, -0.12530302396875326, -0.2483763534561293, -0.3329685125555521, -0.39169081007670253, -0.6595878329431392, -0.7498258248544368, -0.45139821163008303, -0.1844296167863542, -0.649037513364618, -0.07050841999045517, -0.16145117109427354, -0.6706113099920237, -0.1826818625527556, -0.2824635753311352, 0.2726133052010815, -0.6784117156108446, -0.6191650610455243, -0.25143158550132877, 0.35115809411200294, 0.06520302573471187, 0.5190220086315396, -0.12987364555673728, 0.46759442566738574, -0.20143806920166832, -0.0018921878277942982, 0.6897953276410289, 0.2315204250179346, -0.6093393478444551, -0.4604276581875151},
    {-0.7239419463450264, -0.42091508018281976, 0.02644480842352275, 0.08606236142096704, 0.4866418568358987, 0.8439252354445522, 0.06775273276177934, 0.0751505635900571, 0.6370204310413162, 0.20188832829661538, 0.492292057983161, -0.22979773885299748, 0.6181112595489506, 0.2540029115158179, -0.19569458617944496, 0.6703583095498268, 0.5247702993688619, 0.6666266897121641, -0.1843330047776681, -0.7701312364182211, 0.3595160946436788, -0.09705150050341167, -0.34372536562780387, -0.4182497607151403, -0.1115126827029343, 0.15741499680030144, -0.06634952514930442, -0.15884210361842388, -0.020505210478017292, 0.6371086427693701, -0.28875824868583233, -0.39387317194399657, -0.3618355932773384, -0.5200377003662476, -0.1007965345766813, 0.3262739580972864, 0.2922590363512989, 0.02182403768071329, -0.721363245916577, -0.496929018780187, -0.583740684653533, -0.45084883017043775, -0.4997585953129364, -0.8749295379989686, 0.5424634990865602, -0.25032102798029177, -0.5225346325209917, 0.6879712621078522, -0.32082246248028795, -0.0653678085042007, 0.17616987592947358, -0.4385812995437292, -0.7924666293899796, 0.2967089658150899, -0.23045319240047665, 0.7755597526710268, 0.33884054193856006, -0.1062452429952285, 0.2821289902655632, -0.1567569736902632, 0.7453430897289085, 0.008765788855258215, -0.5198809813468561, -0.49750862923109795},
    {-0.5194078369478617, -0.23141807937285733, -0.24016059404332807, -0.2202698188730015, 0.08614070431519442, -0.13627260387449583, 0.09429748618878914, 0.08221528356427323, -0.05363422396805152, 0.06802411303466332, -0.1207984457243052, -0.03146135437224394, 0.3238750594518134, 0.19951540100167034, -0.0007717045183667336, 0.6378005736217923, -0.4219897153890094, 0.4882286606182065, 0.5898292399958185, -0.5710239932474904, -0.01980475058188661, -0.2874825903312283, -0.019560212212855827, -0.4291781068028361, -0.7492901578664349, -0.32239239611705284, 0.5188686630589512, 0.3306885939917022, 0.043662772900076155, 0.15490988542254344, -0.14976646302435165, -0.13427379983139556, -0.6557261226214277, -0.13250517435381864, -0.3065237188525206, 0.1247853826208992, -0.476545851477496, -0.15806227151630206, -0.18389253742202777, -0.6640723353731337, -0.37779647667821353, -0.14443185312226067, 0.3746092075161258, -0.5680293519519449, 0.564115510919319, -0.47950571204993986, 0.27009519061224674, 0.48979536097419707, -0.3035722493949755, 0.16138731074136536, -0.32298010016673395, -0.06732518059444192, -0.36099051348256905, 0.5572908852366735, -0.18967591526271818, 0.4671798631967427, 0.24222884582832746, 0.5298976016108439, 0.3112382227683343, -0.380075370551048, 0.6282279737025095, 0.2909793292079373, -0.1550921710121187, -0.36351037854850804},
    {-0.848226765661457, -0.2712068945112314, 0.30978176275438746, -0.14294665336203238, -0.06099251514168506, -0.12046692066441209, 0.31978879728051496, -0.18778680093193775, 0.4855031636914999, 0.2686038300673586, 0.5689166331582249, 0.5589449954455206, -0.08652936328848301, 0.13520615535645308, -0.3883765226212133, 0.5198777040694026, -0.21344325726616228, 0.11541127443425823, -0.32078470365226996, -0.30133428962312425, 0.2618944176819822, 0.5087167441498485, -0.8031853629838628, 0.10712039306029586, -0.024894469754693622, 0.054333596366141504, 0.17986556000165965, -0.07504347481735883, 0.501974272959782, 0.7725533544563808, 0.11916163740057344, 0.00815407850579474, -0.23220571100862206, -0.12740674921270928, -0.04675818159750064, 0.15772527264443403, 0.13097148980650702, 0.21266952680105405, -0.7186660273563354, -0.529936567253765, -0.8113554904711289, -0.49501113713452155, 0.20728130888122379, -0.7602244896920501, 0.24348740907354188, -0.03492357572525845, -0.14749362981415923, 0.420655779816626, -0.5216491696310285, 0.16831903724410857, 0.02906531253156602, 0.24031663793016328, -0.47907119178350577, 0.03368166732047148, -0.08019213712765039, 0.13447740176908216, -0.4018020480930484, 0.43559515818864475, -0.604554073314815, -0.3889704445488636, 0.8169385037148551, -0.09521082528142588, -0.00032907665161912387, 0.4231161535264297},
    {-0.8029254514247823, -0.8339109446604005, 0.2818233437132096, -0.26830461330266286, -0.08608830247352815, -0.1978694353820407, 0.1544627818468673, -0.09986070856132767, 0.14342442631473576, 0.6320368562706595, -0.150222906507791, 0.3737657832778478, 0.4305192968822738, -0.5772106975740646, -0.37708161800888174, -0.11336983424446292, -0.7798219458145385, 0.24598010967328007, -0.29960065302597416, -0.42685575850578333, 0.5047001293731339, -0.2498221636706432, -0.4994948822973544, -0.6929339997866514, -0.08433531416455813, -0.031451738767845565, 0.38821797082468096, 0.3865649488526887, -0.26701663543405707, 0.03827942887877296, 0.3862255552303553, -0.7318623935915386, -0.4130808783219288, -0.1715177862846957, 0.34119922821627446, -0.3927134411196525, 0.20842935007564706, 0.0675378293247562, -0.6525223888721416, 0.09170112920960842, -0.5426972867737291, 0.07191847000765964, -0.4164205496994721, -0.03378778336466762, -0.45116219661514334, -0.2404717967406215, 0.32123467735611166, 0.5353930702294631, 0.14347738407887495, 0.26319138003179315, -0.3155848294534748, -0.22394779813892338, -0.13093481359718392, 0.6051574589253047, 0.059068601593959116, 0.4422786843143321, -0.582536614786052, -0.32546903418492124, 0.5105354854036587, 0.6057902623563622, 0.7694678081150286, 0.0852912006814999, 0.006417162112642534, -0.18153259884361855},
    {0.4837533278975524, -0.20732685283435637, 0.022678736368222197, -0.38209180646274016, -0.325017237157152, 0.22512360714097973, -0.009876781702913095, 0.26940544783131104, -0.09711133054678868, -0.24346469087831532, -0.4793984904457748, 0.7899329935010604, -0.6306487680413436, -0.04640264167911035, -0.07899992531059298, 0.2651457620169754, -0.2735989442341507, -0.09574827027147603, -0.309242199849614, -0.4271904128311508, 0.21863411224393417, -0.48813380504548154, -0.23935322733926626, -0.7915500614639632, -0.02974557356133709, -0.6774998658895443, 0.6373979271939699, 0.3117509815803793, -0.15062986103748513, -0.042431796043903645, 0.67272362171765, -0.570095360968964, -0.22603281217812404, -0.8221674745314447, 0.3164010311467638, 0.14621606099477172, 0.0522286471928284, -0.5734846325261994, -0.898387693480778, -0.6166062720668223, -0.8521595879518464, -0.17208846467451325, 0.2563598930000344, 0.03786974309529814, -0.2362156417021524, -0.2517168698397298, -0.5257971785898795, 0.26342048790141936, -0.2714801925671321, 0.10411285648551838, 0.31882356625586583, -0.08418783377114282, -0.16186883484673448, -0.35362478706424033, 0.053011752785614125, 0.09757815788622544, 0.3775094095696617, -0.3117652696346799, -0.5782100392518171, -0.41506190046541674, 0.4578276377394792, -0.5614628539815919, -0.27222994264555184, 0.13512136787248488},
    {-0.33498838535207637, -0.25946588266413484, -0.03612591577922097, -0.3351750938506763, -0.9702266078628191, -0.12218431532897622, -0.2735813113344383, -0.3961314771290056, 0.3379549664588584, 0.01841230515355466, 0.19093452431881985, 0.5140163377920209, -0.647707830325356, -0.20816485840540996, 0.332038666703095, 0.32353019581887266, -0.710259858471664, -0.8262997245127629, 0.5034899328635002, -0.27161183306701026, -0.10784705158782988, -0.2442196926025422, -0.36236086228201353, -0.4928656945268314, -0.31206288537953614, -0.32584769865136587, 0.4947003121355653, 0.6014313409657912, 0.3496215691797942, -0.16085534683423927, 0.6209598462113338, -0.8574470756058589, -0.6842714994177833, -0.5605930047177933, 0.15075288595587735, 0.13412460810463048, 0.49363763892755935, -0.31995584682579525, -0.40270327197708283, -0.7927763346822381, -0.6325574116875435, -0.6836101915057105, 0.5376012571137525, 0.27786672107464827, 0.21854412811038004, -0.2670745040021864, -0.10343313095544028, 0.921209742704138, -0.6214771862625929, -0.3007138660480621, -0.08469410472901251, -0.36707922719888336, 0.28390800675531697, 0.09569818538835771, -0.5864602776840021, 0.5497084293219648, 0.16591675169586723, -0.020296647051480328, -0.08603143999067808, -0.08376205701617577, 0.6324959957984019, -0.8580611004472719, -0.1547930993276059, -0.06666829683465277},
    {0.4238978866225458, 0.4552046635414865, 0.36532782039342154, -0.36281139814079955, 0.29526797942216554, 0.6030854630390979, 0.3226608710629662, 0.12544986529511074, 0.4388566730194441, -0.1854260246230907, 0.3961208011603132, 0.4341506989235762, 0.0354539794171256, 0.09448573803303995, -0.15779277006135292, -0.1600988332179992, 0.4770954228219645, -0.012831466410942051, 0.1935455619541313, 0.3707464408974026, -0.007085239769422966, -0.13740244724322376, -0.8049920573317729, -0.370536539089714, 0.06765347222143764, -0.32071442898747193, 0.4868001821378977, 0.2503932973001219, -0.04944150073483516, 0.44238553425417126, 0.15808504646148488, -0.8472049494185815, -0.5041995981297077, -0.04819050082302675, -0.10699800310755465, 0.04681324128543227, 0.4765219567905204, 0.1575015842467134, -0.26788420707616983, 0.4167357731638877, -0.8184305893219199, -0.312147065705648, 0.3407341038245401, 0.36098425648814086, 0.3583360061713845, -0.06743956901984063, 0.23349860546093237, -0.044187006539402524, -0.01875182683128118, 0.483460360606437, 0.17974941874088302, -0.1481706426214707, -0.3073791967037904, -0.21060619168110223, -0.28042095567959735, 0.30748175678700473, 0.3543386261551735, -0.06462825042279785, -0.1653050835478191, 0.022984237831326294, -0.1357441815683921, 0.15035236732619117, -0.5117490036203638, 0.3197718825535615},
    {-0.3987818920858849, -0.22468661362642617, -0.20225692999218575, -0.4833788439589157, -0.11304272777788253, 0.1760002197866321, 0.1898289473612709, 0.036259731500294864, 0.6206800753232878, 0.4129413977653603, 0.19133176640763444, 0.32139761960488034, 0.1417061081523506, -0.14480453319073214, 0.1163226887431752, 0.435749839599195, 0.449411089604461, -0.3561480843530731, -0.6035277144143146, 0.012781508103655071, -0.19104541364736213, -0.29201644165669083, -0.3352705356768724, 0.10235243222751127, 0.22972173575623936, -0.008779476660904692, 0.1632356702102853, 0.22447746966352114, 0.12627384821348975, 0.19489739787401258, 0.2016714196087719, -0.032278553470652185, -0.4237441319085916, -0.28505901745726475, 0.3261329585654743, 0.42718802059292, 0.3485917803123283, 0.3721938230746896, -0.10527356482235899, 0.13773072963448987, -0.15255146347300164, -0.10526488194612217, 0.46669235123847874, -0.08960222360278443, -0.2708718758239116, -0.9436127469216845, -0.2527226080571264, -0.2808269379564106, 0.41869145377452993, -0.006719432655622965, -0.11976175264665172, 0.06667157159374348, -0.474866656311732, 0.5014602740412268, 0.6150528441012152, 0.2489789996716339, 0.4072128916456256, 0.7607635374772186, 0.42631170539199525, -0.05049197841255657, 0.6347623757280153, 0.19043997761545906, 0.5393974426306027, 0.052550522179917854},
    {-0.23389896790644912, -0.1787965678720032, -0.21281238865404162, -0.5881661627943428, 0.7674105142875535, 0.29219686694461494, 0.13361774815403535, -0.03518114718852783, 0.010595461653163335, -0.22058928451638699, 0.3644829423518947, 0.25690504515614615, -0.07606766745629993, 0.39685888381962936, -0.17745078799665567, 0.32973684450772656, 0.527697159854177, 0.485252310617953, 0.7450624947628051, -0.5156159175851333, -0.4470652144194173, -0.16401081814587054, 0.2228957515560161, -0.006798231165923477, -0.09098820407624858, -0.541370053373192, 0.3676763856600286, 0.3171029886770825, -0.079765999462113, 0.22533190630668548, 0.17721241149633515, -0.45910311050251706, 0.0986210916870639, 0.23766360691017002, 0.4017296802883277, 0.18250069659329313, 0.03717721822236431, 0.27124430574823777, 0.40678410830444045, -0.3638777635079236, -0.2996766454377606, 0.4664879289690758, 0.4658557580338915, 0.15542625878486335, 0.25985400656291663, 0.8133036719897616, -0.30349734426976854, 0.29543737552408095, 0.2748429656679093, -0.31755377552236896, -0.0030987582683333153, 0.24155436145659215, -0.19945050005945694, 0.3143239380456494, 0.4822001334439053, -0.09025568799265417, -0.2936405899975888, 0.030377887111292703, 0.541850713698069, -0.22124328777247426, 0.15670092771105795, 0.2929275351258143, 0.5629705313081275, 0.2836362517859578},
    {0.29233801262798886, 0.2987616251216481, 0.4646690310781221, -0.41037650098688727, -0.09985347911303946, 0.38082506100231484, 0.5791544942872894, -0.4664886937187855, 0.6142083204155662, 0.5783436376833062, 0.35392120526689774, 0.8114504893351867, -0.4708623914572991, -0.02718135038047444, 0.27406969564336076, 0.37699062827742874, -0.7433717260004937, 0.20893881420018748, 0.029835662553732236, 0.04461568258823197, -0.1583017526375581, -0.026587732497533063, 0.1355223318303048, -0.8390746418287177, -0.4288499004671547, -0.151805845375505, 0.7241353887808616, 0.7577500753334339, -0.5711611493817073, 0.487206136942852, 0.5060462928618084, -0.6869731861466294, -0.16708784301826257, -0.3421568101076191, 0.17634509507431734, 0.7197331245859975, 0.25935247280418927, -0.5198170684626603, -0.28116759328298807, -0.30282671191351257, -0.6444388633822334, -0.5154016639028801, 0.32443539784779374, 0.48256099260377366, 0.08360316606724924, 0.060323808998856775, -0.1265385050083913, 0.1969839244726824, -0.10706330904989914, -0.67692847547228, 0.2785203312461384, -0.13115207895823655, -0.09363472806503917, -0.21710633023810588, 0.31116097914786117, 0.4564907685667583, 0.2019609588789441, 0.47223435147315995, -0.2974340657061133, 0.3089881414377475, 0.04981212254006525, -0.47740588848759885, 0.007913733769551505, 0.35024211945924744},
    {0.07401728246938176, -0.9244371974860662, -0.48430684169925364, -0.24377021404673938, 0.18154549686796623, 0.3359212743810394, -0.30059568105115186, -0.011464056764191152, 0.5919167407652542, -0.40897753930031133, 0.04000244716207158, 0.26619541021411763, 0.6086694016502902, -0.11680905597132958, -0.3750816837534666, 0.16167310218031447, -0.37741010225502625, 0.24342453224250568, -0.08618351050844317, 0.1492447271548387, 0.14737201692463972, -0.4552813439569254, -0.2685698728998698, -0.8961678025252992, -0.5059871755240164, 0.16007666034199186, -0.3395361361260738, -0.007739970253062966, -0.04053985911390784, 0.5551841888889557, 0.15482238602921633, -0.4617317852899818, -0.6279743147190703, 0.043550801325627594, -0.6389042284452667, -0.2854911433916466, -0.05699778685069398, 0.1842366837831444, -0.28563143167266264, 0.13099750774816038, 0.542065698399343, -0.4382485690475724, 0.38184351965296465, 0.6036774259763132, -0.2507560259002669, -0.6880919434692315, -0.05013535565914671, -0.5536091837046806, 0.014320740999091919, -0.4208448541675797, 0.3172632210733228, 0.08251890990850327, -0.020914844807441883, -0.2932189796154572, -0.38529496387312123, 0.763435373738214, 0.16899980746150112, 0.23954766654271473, 0.5341892136166194, -0.08854883479443999, 0.08236375778605608, 0.46194808200366977, -0.5463865044164963, 0.12257485185157925},
    {-0.33934354039509124, -0.1828712218987776, 0.11148013034098232, -0.3432286814242545, -0.29801834636374136, -0.4146625207531125, -0.6395433962130564, 0.27926352359208406, -0.2809345157968626, -0.20659853423300711, 0.5371040244739301, 0.3300222811539915, 0.35162162181072587, 0.21103396683441103, 0.12774697932702467, 0.33806062133310466, -0.36196580194382927, 0.2639734891791221, 0.1190547823639811, -0.37838931904667783, -0.0013009211853121862, -0.07416898511839089, -0.6946061371888486, -0.5331116993216433, 0.06878761407760561, -0.09121060018190409, -0.11974322017377408, -0.1523228524801538, -0.21152046942012473, 0.017908196398181073, -0.31535518074928576, -0.19350790917452218, -0.039772266635755955, -0.2244114553817374, -0.4287279150193755, -0.04167316530917751, -0.3934969879231221, -0.38429871264363874, -0.7280290997614985, -0.583870344209025, -0.02128016322883488, 0.12803885429620224, 0.2788062936811092, 0.19904244195454288, 0.6245187803622801, 0.787510002137106, -0.1571351375692177, -0.3078955127107875, -0.22315907483055494, -0.2044425547521573, 0.6312112129079869, -0.32553248145853514, -0.1457582631581568, -0.5743360751508237, -0.2342318886214253, 0.5727663102165836, 0.14145614170099322, -0.11309384027248484, -0.46486741849269086, -0.6582154871532689, -0.12795971236626139, -0.21951979086865966, -0.011165391602012596, -0.011152272414056742},
    {0.26214233661754044, -0.049338051421514637, 0.3067366518130888, 0.384368868490198, -0.41764575104972446, -0.26171803924736187, 0.43155859782404343, -0.01693281021250302, 0.2811858400827376, -0.02255963156757301, 0.2908904855109062, 0.6498571905055308, 0.08214900255551089, 0.19744046170747467, 0.41804203122369055, -0.08282980609125669, -0.2934607779733583, -0.5084275946693639, 0.42724498213233225, 0.3062477140830538, -0.6195865761579857, 0.012354961067303365, 0.1264466426721879, -0.46603390382647253, 0.18309106740550934, 0.46176026256623853, 0.14757498803341476, 0.7767269162809488, 0.5502695717189269, 0.3212416367778404, 0.8911045378818241, -0.6089354971627724, -0.8594231815131429, -0.19978698410747553, -0.5359427237359111, -0.05380437043592329, 0.36879376342429726, -0.4203915071507486, -0.05628554136252029, -0.36478044046941993, -0.6188158523684374, -0.4855780712972928, 0.38647725957608453, 0.3111567721643514, 0.21252424014621274, -0.3131369141097639, -0.678018932495636, -0.13941491455859625, -0.6394731798949197, -0.34824200366282365, 0.01242023193144284, -0.144431605208342, -0.3812677564803661, 0.1204617252071198, 0.21139240309088952, -0.6326427134847226, 0.23816181149029889, 0.554854506532027, 0.2591654734154038, -0.21649919567114564, 0.3496219480520733, 0.4298185346293389, -0.5974588371186909, -0.5306490727218344},
    {0.21147588013445073, -0.012184825692759459, 0.5404587541636456, 0.201518814894481, 0.1865599343418039, 0.12137985584889137, -0.34043104426875664, 0.02380576316053476, -0.05834745850519968, 0.13268996228030058, 0.39123399248725843, 0.13120389904828977, 0.2747658822823639, 0.04319054717202198, -0.09864585408731574, 0.15788682906085683, 0.047580489206058965, -0.5847692801881818, -0.26827760043091575, 0.379357676636236, 0.2895210085043339, 0.7960172797912977, 0.3757098750261867, 0.13058012218690832, -0.023123376409170487, -0.2456327293956057, -0.37637256379423617, 0.25342796313410576, 0.25097733194095767, 0.19061136322708855, -0.048846522679621814, -0.11997659182111013, -0.3530460963159825, -0.3441860319412139, -0.4940710739539016, -0.011442230657742618, -0.6392420568345215, -0.3301123830581299, -0.19229268864387133, -0.2327092076067654, 0.00233983482430822, -0.3956636782962501, -0.010712289496966504, 0.40255684958691507, -0.32715480264632035, -0.373193633817292, -0.7092258127924685, 0.38335918006739506, 0.03308537370027224, 0.1192720502106578, 0.28130986812404135, 0.1108313136596876, -0.4142697708366119, -0.24943127299238213, -0.20998508285294973, 0.4379779516565478, -0.14634900862718433, -0.07700183403315038, -0.14199877882287526, -0.051235662068941944, -0.19609280318882194, 0.211869232677026, -0.8058215671629041, 0.44743548512579673},
    {-0.415082983915015, 0.047102349775357114, -0.5047837009546134, 0.12749778423280286, 0.2707560723328308, -0.02155937895673566, 0.2145509858326521, -0.20449710528323775, 0.44226667334115294, 0.6375457472503113, 0.4337436991828334, -0.46650207040581754, -0.38619444774433886, 0.05991334909637547, -0.3062612855651852, -0.1488210196996368, 0.13554835719493696, -0.07452130998778064, -0.01237477125853882, -0.5013293791072444, -0.22169326831878627, 0.17592747436928122, 0.1827750083522727, -0.294250789443951, 0.1647390891098557, -0.022029991218847137, -0.4889114407158925, 0.4427050988558334, -0.1925765288748968, -0.22720105562358212, -0.10149487103763559, -0.1226929718522907, -0.1013738457276711, 0.7019930940160698, 0.1926069197377007, 0.31229998437022594, -0.5869720850312222, -0.04122482512128181, -0.5037670241006237, -0.11088026753555573, -0.4847619645281519, 0.06214062872688567, 0.7229678737791809, 0.16737622580112851, -0.11019736211500841, -0.015924220050021896, -0.6547046235006438, -0.01664347230532923, -0.49018737822605063, -0.22610424845105845, -0.07003502685114875, -0.41891585199206943, -0.29910603590738744, 0.3090774954792285, 0.41917624569306355, -0.14949352061166016, 0.2783714608195021, 0.2649707818577021, -0.4145680814205667, -0.6259533541738178, -0.2284338579348612, -0.6405952227116445, -0.1575648430096981, -0.07041136280733239},
    {-0.0677713866458687, 0.0778543577224065, 0.6151910671321263, 0.12009110616646688, 0.48207557578634497, 0.4174323376924863, -0.243144942624655, -0.16061448745983187, 0.3656599729063664, -0.17705411241921762, 0.8444018746361074, -0.28033784443507037, -0.07505252984847495, 0.05501139616648336, -0.3402778477590711, -0.4045084331263995, 0.02266977278293365, 0.5092974285872113, -0.09693421706952829, -0.16662954262977173, -0.12620083164190085, -0.11728022834616901, 0.07191645300108204, -0.4895514992970891, 0.2891299817926113, -0.009496749951124372, -0.048766707093547204, 0.4900673842189895, -0.0007730977123536656, 0.06683456907577867, -0.05874812229699665, 0.3424892863310298, 0.2595627607778209, 0.09692851463645552, -0.35294491218435203, -0.036901334895381076, -0.09337653291667815, -0.14292875679376632, -0.29327419664588883, -0.3541780677794356, 0.17570450276295643, -0.14806279094044789, 0.3761472183468059, -0.3882827759426582, -0.27631026128472097, -0.32495039476634685, -0.4674388281093421, -0.15628851151813147, -0.24664743069697684, -0.07739785035009705, 0.36945326524947525, -0.39443968711855737, -0.014733737463280952, -0.08600373322732582, -0.38978574513274383, 0.0973997165362414, 0.07096911265871353, -0.06579760988517078, 0.13147905317570863, 0.16479132187821197, 0.09273039163544955, -0.11997219793928945, -0.17473819478405453, -0.13090569457343934},
    {-0.5337990196244808, -0.46597234589748293, -0.2767833429655557, 0.047739901256398695, 0.3674728134993334, 0.5939799235470242, -0.10819865685312043, -0.4154802250712604, 0.5128408174184361, -0.011241287467960943, 0.34633937674375403, 0.18049322535065032, -0.1634810330788343, 0.6029621127760891, -0.3624657862996278, 0.42349768050590836, -0.24494077507385123, -0.6590880112294983, -0.08206325403198987, -0.39970651186935113, 0.6332633878115871, 0.00921977332789075, -0.15768675623630657, -0.06736929923625908, 0.10809307886344527, 0.042507627356843776, -0.5975707170483953, -0.0905580547527079, 0.12424642225292393, -0.23617136492549168, -0.05871701377278967, -0.636648658741875, -0.382138677048777, -0.6043302255742449, 0.26495703335052434, 0.27263005997124923, -0.5055158066171774, 0.5884373419920139, -0.10388271600491833, -0.09966647251424744, 0.010482915344994338, -0.31311020995976313, 0.7593195824757798, -0.3260839135193448, 0.014741134124134005, -0.7571913176282237, 0.4202682943472265, -0.04505167635935407, 0.1395606545835341, -0.7858768812383411, -0.1966513037442272, -0.5489794571651984, -0.5514999164165002, 0.052722808983923494, -0.09910445982266515, 0.3628714704758047, -0.18682471057394137, 0.3296900630600016, -0.34904656732475, -0.10665889359523699, -0.4745345695343529, 0.3539129702758813, -0.32895419239236506, -0.14900510939124897},
    {0.3721293934374007, 0.11057373005018256, 0.15832846247138657, 0.13248013829668515, -0.08553526012504754, 0.011716653519915379, 0.5680748249476212, -0.04660120922069922, -0.17936309303459727, 0.5548867599163332, 0.5276697082497953, 0.531822830629363, 0.43031647101341786, 0.48718948573915055, -0.5289572267244329, 0.17291508888055832, 0.2345125536553305, -0.34551147888812256, -0.10995704953428398, -0.5842551969535389, 0.06661314812684817, -0.09909067308430505, 0.1266110158651393, 0.5444620183802545, 0.37365068518651934, -0.20903826661240174, 0.025886199583259602, 0.3845346376305358, 0.2134992599631108, -0.6572115735750538, -0.4697530707098422, -0.17989184949537504, 0.3070647256796565, 0.10362501528117264, -0.11086215695617421, 0.33813754825546677, -0.1920102569942125, -0.269360587826789, 0.04402726572027496, -0.8748354881018263, -0.1435796332165107, 0.09901131043708425, 0.10667773293564832, -0.45742635228840867, 0.9858599612862299, 0.0021701459098919782, -0.14761659947118955, 0.5171059051423469, 0.08946016461236563, -0.3734606995312297, -0.5271723083141658, -0.4455558826152054, 0.019806121141974328, 0.21298944804764397, 0.1580044790390743, 0.7017427193078639, 0.5304378518654626, 0.34463752188874175, -0.31826081118037625, -0.14463022338065334, -0.6170367055126882, 0.24268268150045355, 0.26174640319558556, -0.12870997416143717},
    {0.08321082846984916, 0.48482917358134386, 0.5372383437573486, 0.4880314549360284, 0.26864559631417906, 0.5776174305746717, -0.09286856591003848, 0.11654887769263961, 0.5333131804557389, -0.13087662650257018, 0.35779243470950706, 0.6806217332410497, -0.8576294635556976, 0.5015686320181414, -0.28355344505387536, 0.051725018189484065, -0.07569029862320464, -0.18706852850186875, 0.423053312943709, -0.20010109967267947, 0.012719752526069737, -0.06222672375549765, 0.11130457619052186, -0.31863743990287235, 0.13069057288087058, -0.41038618641319885, 0.1836476788649598, 0.8469206708718984, 0.750543908871278, -0.6705570520049908, -0.17297244528310365, -0.3434914209383905, 0.22958986699993403, 0.504466692610721, -0.1836679383930476, 0.32816692977047646, 0.29485248513459417, 0.3896745611531174, 0.06544598180792256, -0.3250982519759017, -0.18045610596711886, -0.06023333555887953, 0.33355823181103844, 0.27391301622685144, 0.06684485555810574, -0.5439663347546588, -0.05351924779000498, 0.06895795178722074, -0.3710740843946995, 0.17617603730963577, 0.0204660302907734, -0.2007885568132075, -0.02446969795404569, 0.48753702949503996, 0.30192615042677234, 0.4772360003694299, 0.3857519821301219, 0.38319284546890797, -0.7908641371578076, 0.01173045285932568, -0.4543832317498532, 0.6525840000550199, 0.37943819767298725, -0.13927206265442194},
    {-0.13430305056472217, -0.4867567731815681, -0.20480453903695645, 0.10466160483553842, 0.461191153283025, 0.08711723320474743, -0.019256249117670474, 0.06488462405541656, 0.1058889804076579, 0.09868171939673921, 0.15695831753703637, 0.32324130628426245, 0.15239174934784755, -0.2208000952762309, 0.1758788457856982, 0.49032229037797664, 0.12762285955312463, -0.16725222115600366, -0.1344634573195432, -0.12860724787108188, 0.004375141118341098, 0.7863905953106175, -0.08110405184586213, 0.11123487279230088, 0.27771807964318923, -0.4163990093686134, 0.039291535334009496, 0.5170899923703757, 0.4200718441259465, -0.8846384932268394, -0.20422560712438287, 0.28967120930815565, 0.3261211727983592, -0.4559240372881951, 0.38449500852994617, -0.10641570850872868, -0.3733337742679703, -0.02759626054743969, 0.16856214190296512, -0.6348932356116649, -0.2943363403128752, 0.29118400726695987, 0.016004543370996962, 0.45882232901101705, 0.21530920664139128, 0.2200883221806309, 0.10316796811041289, 0.12744945562988308, 0.26844194973149277, 0.03843178229685532, 0.20879990021859512, 0.20288332986090005, -0.23251734522886525, 0.2621262608258485, -0.14488728976516327, 0.46620430040877864, 0.497979681535313, 0.32097749423669253, 0.14298640477616417, -0.3975673795348271, 0.16671043693828327, 0.06985030258143905, 0.5131175531521556, -0.5445335023704514},
    {-0.25724434034707583, 0.03207351144797106, -0.3994886151591662, 0.39293504293977305, -0.37140843054906514, 0.7387516372646437, -0.23013190252803656, -0.2453168866145128, -0.6426604923287643, -0.5810867852560146, -0.1806352209798797, -0.01784162550898621, 0.2008866278275042, -0.49264767559239425, -0.1988327151986981, -0.058918965165544006, 0.7956422330738561, -0.012829958080127766, 0.1775156138641374, -0.5734713319321852, 0.17214455186446098, 0.7350975070142796, -0.20419331937876872, -0.4282079297946864, 0.021257995247047294, -0.11928435201785031, 0.09942033109546093, -0.009651573735496015, 0.3360292586693076, -0.7737324082948427, -0.47530006364867866, -0.5172576050244397, -0.48687439074014865, -0.22520017970522072, -0.4029979110636788, 0.023898027718553292, 0.42630864130452334, -0.28701242364548196, -0.08013335585971687, 0.201544770525175, -0.47635760653627024, 0.020698118478139436, 0.19137853969664662, -0.05209877597828238, 0.284928663802996, -0.04455703161697706, -0.4364832937812361, 0.34946424142259386, -0.4789079762369802, -0.19866855421751425, 0.23995543978594236, 0.16808187881115838, 0.16352578344871693, 0.108357114725953, -0.22405251714167715, 0.06753844091837685, -0.217406025264393, 0.16973862750202057, -0.7312247427130033, 0.261854843776059, 0.09104690682975598, -0.4131811370570312, 0.34952802893418833, 0.07025858119368777},
    {-0.36065607190491705, 0.14728094970011907, 0.29021912580474235, -0.09988300055271873, -0.13084793306152687, -0.1534925592575638, 0.06638499312857869, -0.3576192493582092, 0.18783639883806402, -0.592666937492314, 0.1547784296947518, 0.09926755953461833, 0.31216400315475656, -0.23800277961111038, -0.25816502428751453, -0.7875321370719365, -0.2958485826339222, -0.1980926925246193, 0.08382666173021179, 0.3503004005171614, 0.045411039565988666, 0.094641885527159, 0.21959775809752063, -0.2550881065184742, 0.40228356838970836, -0.15053546079291152, -0.09378045180824304, 0.30364470399356935, -0.056723203021735384, 0.31105938822209606, -0.1385284973381484, -0.5693747027130651, -0.5043027783072136, -0.019449025006643993, 0.15040718569820877, -0.12594541048654248, 0.489122307128609, -0.7943729391883273, -0.20634009986706178, -0.03528820518687403, -0.19542192941633185, 0.27074839928910094, 0.2603026392901956, 0.35945877701648793, -0.014339416833702054, -0.25166253407683753, 0.48625110795544985, -0.14234907439507263, 0.6087115445206193, -0.06114723065732675, 0.11562907088536287, -0.0714614379399657, -0.06179788922338829, -0.15851925994438523, 0.2839790743748813, -0.1935397206944632, -0.3235245658490743, -0.46378327843534517, 0.2893926361718227, -0.31870043697511463, -0.12409625227933557, 0.3820631646235216, -0.14946958558961757, 0.5880665306964302},
    {0.28708558983327487, -0.04469206158902918, 0.026732485274664486, 0.45717709976879134, 0.1268594803633984, -0.07037341477410669, -0.14432399065128293, -0.8203233569031012, -0.28527757563836736, 0.4252473202034023, 0.22540171455968203, 0.5187846469288488, 0.4737210825964803, 0.5310571351188486, 0.3571852168241828, 0.4021230889943143, 0.032414463361675236, -0.6659398008526033, -0.1409937245566487, 0.06967497417993393, 0.32308838997891276, 0.6031417191773134, 0.055077692004936785, -0.5705753979122953, -0.07752022436208432, 0.5162110315734041, -0.38362937300479555, 0.3363185655670918, 0.4233132772750994, -0.46385793784318524, 0.12729536239463518, 0.05912239737113127, -0.5134461998567038, 0.17651065368815536, -0.10679460997321537, -0.15894094291340066, 0.08361355105815996, 0.534725869786608, 0.45807500370611776, 0.12302819713474247, 0.1822657239973502, -0.23001036272757272, 0.7102349807284584, 0.27486388739547135, 0.11002160158217117, 0.4886449756414499, 0.3438086187195258, 0.6027114422108515, 0.04634710907376457, -0.16722389602205262, 0.3392832591318407, -0.08393766706261682, -0.1766105291963362, 0.5218072780074995, 0.004136936910780135, 0.4067334361826625, 0.38390249096795936, 0.7658587287089205, 0.06652939509599676, -0.3747101628758467, 0.5049607081704519, -0.4301968149251288, -0.07878406699594555, 0.26619458624814635},
    {0.1706268059667833, -0.4974914004959591, 0.40117361163474347, -0.025915483962770762, -0.1570010745982822, 0.40386500782445417, -0.06451466078722365, 0.3276011836468025, 0.42424679971380813, 0.28044669803340067, 0.22172805002863127, 0.2455591203051943, 0.15596923257636366, -0.26216972957699686, 0.10786544512184389, 0.100919492666951, 0.40918662787237997, -0.4420113306069743, -0.1223622375671158, -0.2724625004220368, -0.9455851570340729, 0.3549598919901958, 0.646903503594512, -0.8551959332067316, -0.2189857666073598, -0.1064663079345101, 0.28744615509810467, 0.01055153073328945, 0.587487206857001, -0.15300151956323782, -0.1766310105521191, -0.7323632022939873, 0.037084263294929476, -0.22697572483041273, -0.6509023832660596, 0.08387773666859477, -0.29952337373708116, -0.33373870573504155, 0.00825692219538008, 0.08180855396515879, -0.6928452910945111, -0.6236616691520631, 0.2886685333700641, 0.3206888116467889, 0.3924057306409473, 0.22187402612615273, -0.04176846159908516, -0.4887846305553747, 0.022745986753208023, -0.07608694121716744, 0.22541148091993973, -0.07648052065165306, -0.27277084543842633, -0.6455899130690532, -0.47102430960926933, 0.09919733233484535, 0.2828797460248127, 0.7180158632072488, -0.4249255796775567, 0.43705842286931035, 0.12002715613232115, -0.49846994463655603, -0.3166701779945048, 0.06493923764663924},
    {0.22172747735248852, 0.13600813020179697, -0.034737134433767976, -0.044729584961817524, -0.06257579189617266, -0.2765528734864729, -0.38765089213168463, 0.36993793398486746, -0.12393721473564377, 0.2216342111474497, 0.23744585736126245, 0.0781381403553159, -0.26961160501340564, 0.07443328042439257, -0.25624770830071625, 0.08822463156385575, 0.09548904212203214, -0.23698878898306316, 0.3112466123491954, -0.3283252459441947, 0.2842290237717719, 0.3302359988192443, 0.31470488639750444, 0.04831337021993752, 0.07658003506850906, -0.18122042282667408, 0.29390697156196094, 0.22606464798320208, -0.013583755015276021, -0.7630927544062301, 0.09218116122815848, -0.48298529880925933, -0.5502725820666173, -0.5916164927114086, -0.233308935661469, -0.454686525686774, -0.8786012874035259, 0.10417560101441432, 0.11845634325479394, 0.3048542995692311, 0.5900710042082999, -0.4203186540172187, 0.398129526776262, -0.7119196443947157, 0.23492460288831318, -0.3972709053032019, -0.7456303237031979, 0.8002674024312927, -0.09516179022615381, 0.35595593317658103, 0.1115867766589832, -0.7894251641392972, -0.2234723448766744, -0.051343236842235865, -0.4535310649777212, -0.49549684389463244, 0.7467388871978005, -0.21105384829915214, 0.04269661524445844, -0.5844808588544433, -0.09484187473454811, 0.25430235645580723, -0.06333221615955294, -0.40734884552964856},
    {0.04530079373439439, 0.5335098845304023, 0.6039352096988326, -0.5470211329589971, -0.30680264851422256, 0.6971757328174896, 0.4718233737385821, -0.2027795605133091, 0.036219094620007684, 0.3825008156228649, -0.07045327888316744, 0.2779931693052837, 0.03272265751857792, -0.1351425072179776, 0.22988187044459152, 0.3808272060532632, -0.20094729315973633, -0.1763415894200671, 0.05175689728902869, -0.160199883624901, 0.037721888890041896, -0.28955552050519895, -0.38279706290327165, 0.12523668861097378, 0.1132004236853693, 0.3181292092788203, 0.5744587736367056, 0.5922267024106275, 0.29392065011161844, -0.34517508334316815, 0.5453426804093673, -0.6721919388682918, -0.18773479749874136, 0.03468774439951476, 0.42095281032852544, -0.24802684201499312, -0.002084600908454367, 0.20979158005020013, 0.14680209149251924, -0.3218099084295663, -0.7721425026473653, -0.5441328637136889, -0.08950472036107766, -0.4071147881954446, 0.6647444447632543, -0.3565037857353135, 0.29783627840944527, -0.016215242109488458, -0.3204635008072937, -0.18973990574783994, 0.5067667794418522, 0.32138291349620396, -1.0682250028620086, 0.12054187446212335, -0.06227917972144911, 0.28355628619153916, 0.2302101493998383, 0.6741204711727538, -0.6592303357539848, 0.47460016967411817, 0.11405051041178843, -0.2795611444345438, -0.11743330840370139, 0.414252650044652},
    {-0.4049803246384694, -0.2371429455454803, -0.11152438235010469, 0.25837422676935884, -0.17865493530557675, 0.30086244292571196, -0.03651874721340465, 0.4108471474405812, 0.7218933954580945, 0.1205902587085249, -0.06181671437579502, 0.22496973819601393, 0.08591546520394487, 0.30338903611257095, -0.2880539626937401, 0.25455445818077344, -0.6612138454066545, -0.5446611610972488, 0.5019203279292576, -0.1600891995791759, 0.4307732531610358, -0.06087267487773047, -0.2549077318051003, -0.6675465954303034, -0.06364469162923064, 0.08179296126057883, 0.4059317033937792, 0.1270169914604646, -0.2750619324708728, -0.24824009557521798, 0.8381063884006111, -0.482326834444728, -0.8176451951887074, 0.32919582594618957, -0.09601488036782581, 0.24903446760795953, -0.31577829355827974, -0.44684837328139726, -0.47263335622111763, 0.6051741006259386, -0.7412263728408007, 0.07698871400773179, -0.3091075769737725, 0.07687733519530657, 0.10885537546078491, 0.25219212039072736, -0.04093994848747632, -0.06745821334956044, -0.7014833869569725, -0.46514894040384636, 0.2510564742227765, -0.15560473873061517, 0.1690078507430086, -0.5889000852813071, 0.1411226197486487, -0.1014517848014882, 0.00026587169586625317, -0.023236116832715, -0.7264162600231227, -0.2795844739120427, 0.06662860117542055, 0.30087190329265806, -0.6259061193867032, 0.01272496440977419}
};

static const float b1[64] = {1.1860333910898135, 1.0650329604291235, 1.1853602827134981, 1.2047602014373204, 1.1799474319894707, 1.1244533419610174, 1.1449452285590485, 1.219745582769827, 1.1253205539628799, 1.1215411138956015, 0.984933905757348, 1.1481589685759641, 1.1689285787658812, 1.119174324781205, 1.2175350089211765, 1.2345325787859722, 1.208067962388048, 1.150492578934881, 1.2240322027539339, 1.1903854960570595, 1.1950459438147012, 1.232503772546725, 1.1523387860222314, 1.221350493910776, 1.1279823354740508, 1.2289689137079878, 1.1273038954972308, 1.126650326797494, 1.080272160814639, 1.1059047380913476, 1.1140212042439788, 1.0683158415085072, 1.0999616871976963, 1.0127677832421218, 1.2021001726015943, 1.0283034419164638, 1.1846189958984472, 1.2106603209805094, 1.2168610892008724, 1.2336270953475708, 1.150743734196673, 1.1090279863930588, 1.1646064368740225, 1.1141853857968773, 1.1292101903263272, 1.2088797115069996, 1.1045246427115718, 1.151135640275508, 1.0375588309302128, 1.1014845318994957, 1.1696932474434119, 1.082483075124221, 1.0245505851546375, 1.2066036770816448, 1.042282419520563, 1.100105934758508, 1.1789917777587442, 1.184568014820301, 1.2408568247796372, 1.114853179077131, 1.1363200046850586, 1.0880385743444472, 1.1629710285860597, 1.039325025523856};

static const float w2[64][32] = {
    {0.5823426537227502, 1.1022878850399436, 1.121430183090089, -0.08012581127460718, 0.840160618458474, 0.9189317800975331, 0.889086070932848, 0.8415820461092055, 0.6620828211011467, 1.3356846333145647, 1.1427867915612366, 0.5291431438022375, 1.0361860745691855, 1.1533985144161134, 0.14059691713886655, 0.2937179730477915, 0.8022843175660223, 0.9657817783577524, 0.8104755330647931, 1.1031191134584493, 0.9284281364861183, -0.2815820069501231, 0.8475727078177383, 1.0864665286844495, 0.917644443113366, 0.4604462312490217, 0.6537127497617665, 1.2158454750741294, 0.9071133872759374, -0.1819696294555084, 0.4202536951750511, 0.1510537352702611},
    {0.9147941710352572, 0.9291302073174323, 1.0297465176342573, 0.15322917677048395, 0.9747986473370082, 1.2000959179503912, 0.8791993967791962, 0.6416901045856633, 0.9278183669108535, 1.2242151714799903, 1.1594343869646506, 1.0050659138471347, 1.0169429124967941, 1.0304136374418564, -0.019440230794697096, 0.3457205014813542, 1.4830122111216575, 0.8133370552568481, 0.4914634764819292, 1.031381781232825, 0.8022987390516462, -0.28744420127722053, 1.2749804563095979, 1.2261155740544754, 1.0307117353568453, 0.7043929880797736, 0.35273840902252296, 0.6112001406114976, 0.9101037878777615, 0.3089364853158349, 0.6138590851240049, 0.02647033097051231},
    {0.9420617871451498, 0.7572964032717509, 0.848787270402387, -0.25126158454022435, 0.9126109990377619, 1.2563298295161067, 0.9562671629397663, 1.311946863534041, 0.7226271145357991, 1.1211026492715324, 1.2311461464130076, 0.6721628080983935, 1.0451789839328736, 1.1141133101702605, -0.20765622503351303, 0.26665084210289636, 1.0660042023427339, 0.941977695916726, 0.4423317855883191, 1.1829212824420214, 0.843926603872095, -0.1429554259087083, 0.9829328090160957, 1.171334061570736, 1.2278371638521692, 0.4480224823251858, 0.3816398626986468, 1.093281638482499, 1.224251360265818, -0.1129951067437002, 0.428864997863363, -0.1458651466389614},
    {1.0463773311526985, 1.007393345604094, 1.2775103305152946, -0.03267704141131668, 0.6458790636227341, 1.2648636053324658, 1.241421112839251, 0.9285539889999674, 0.3743673880296153, 1.0943362628707276, 1.0769516834300819, 0.7125947677378242, 1.0864584085916258, 1.077902631364409, -0.02197704072798265, 0.23834987825060377, 0.8227967155810778, 0.800760780766015, 0.5560376190770706, 1.3460815795105296, 0.9976458626562139, 0.08839800707476632, 0.8241947558598804, 1.2759574059173528, 1.258761570049627, 0.7342217694646889, 0.568643841205375, 1.1698305586386668, 1.0375085216881712, 0.27796888339037756, 0.487283423822097, -0.2045947680416997},
    {1.1359643119019376, 1.2680450328873147, 0.7881003293285896, 0.02940906728809906, 0.7882747371180244, 1.020546699124022, 1.1266434291963356, 0.8548508440442524, 0.9161074040920044, 1.1430070538257693, 0.9204807036535635, 0.9498733646609248, 0.9695401521026162, 1.29884216206472, -0.03345681897483907, 0.33175207064530265, 1.0436216155198441, 0.7860775584026056, 0.5346284120865433, 1.213295068769824, 1.0031992134140044, -0.09913119950873005, 0.9377305848605582, 1.0889352011144595, 1.1690796046496852, 0.3365532214717261, 0.6968873165698127, 0.8978427150877091, 1.4660138749877187, -0.17069063754793123, 0.585229925904164, 0.004251492288325344},
    {0.7456340359158474, 0.9558859948024684, 0.9337836028876226, -0.45027986904744455, 0.7951907342650951, 0.6284251382391622, 1.5168803022251698, 0.8386110905285349, 0.6946912789011497, 1.1255147105302785, 1.0160383662528685, 1.0762745596592713, 0.8962579931705859, 0.7879103761394252, -0.19436125789422956, 0.4398164425865407, 1.1527230212892738, 1.0818779403303571, 0.6303286712009463, 1.0541450040762224, 0.9557897658504367, -0.09252545002457221, 1.0633316939444188, 1.1375179642685018, 1.251484033997289, 0.6259760348012625, 0.5535335827242792, 1.0247217750492223, 1.1823118146382094, 0.11285510478807226, 0.6832171388711451, 0.12810255222566494},
    {0.6058176674489433, 0.8334005532010424, 0.8398686314329886, -0.1771554049016678, 0.7133536173331072, 1.2225408440367063, 0.9948218626351213, 1.035479887754186, 0.9451483596454788, 0.8972886923386572, 1.0206387590916421, 0.6732263249780616, 0.7718364912658541, 1.2304626380223815, 0.24657105901619705, 0.28177645743279844, 0.8696056726164786, 0.6199110186854707, 0.4347329289392806, 0.9257401565759662, 1.2701132582284718, 0.2399942275328526, 0.8974390365530365, 1.0882760725027985, 1.2754277547030177, 0.1926276902840313, 0.6549604893042054, 1.2045754373659991, 1.2600139346581964, -0.12432930747366136, 0.620126036293225, -0.18199724813283916},
    {1.0359556979339812, 0.9334123085145236, 1.076005861983235, -0.08971756172210282, 1.0527944691722726, 0.9177615252652511, 1.2877178254134902, 0.9998303023781977, 0.5269007294229119, 1.2007173202068173, 1.0926049877782555, 0.9255562910595593, 0.9042103811161695, 0.9706510546481147, -0.012521817013834771, 0.15903447208262259, 0.855095576161019, 0.9328989957118776, 0.4732306792525566, 1.0534866448940463, 0.803716459480562, -0.10022934147285201, 1.0944855845213424, 1.1823683466460801, 0.9097570491806032, 0.4935890897201746, 0.5539195717831863, 1.388653887428871, 0.9683963734131369, -0.14655157725631174, 0.521198002759792, 0.19764188295608645},
    {0.8199132597469377, 0.7714471247171649, 1.0450412736177501, -0.0815222340146238, 1.045681811299039, 1.0920148839635577, 0.7814714817057852, 0.9643769498463812, 0.3311625310987465, 1.1468503055650052, 0.7890111025118512, 0.7621475651592313, 0.7438511808112593, 0.9099236888058699, -0.07624925418389351, 0.29044371339348296, 0.9107162150305598, 0.6844293102159058, 0.345557107117086, 0.8656402864396352, 1.0101498551132515, -0.08519328511576486, 0.8536917013759855, 1.2946865719409157, 0.8475599349436977, 0.6528668789020844, 0.31773687944312323, 1.1019610294615056, 1.0464732276818531, 0.07801477967299153, 0.5193072919421604, -0.3554957187197466},
    {0.6839083519491671, 0.7960722461790875, 1.068642907134383, -0.08017054654631625, 1.0050286394458217, 0.9128731924466417, 0.9919779160873236, 0.8058206966483402, 0.7443563453672222, 1.2079337804351906, 0.9720754175433768, 0.849459729945833, 0.9373753696941227, 0.9975987389440899, 0.0831159505260476, 0.21976455802061962, 1.0212718619353407, 1.1046778156990422, 0.31606381022220065, 1.0329132721562282, 1.2230737859120968, -0.3579534125431805, 0.8374386964326671, 0.9768989860426011, 0.8838837563729621, 0.859241505735786, 0.3329808239436208, 1.3430095521145629, 0.8901865650394715, 0.17213637153258135, 0.6149175342824011, 0.07242836590391855},
    {0.9867275243993107, 1.1969944762503595, 1.0797663266882798, -0.19232598688436128, 1.150541295043166, 1.2022098204038847, 0.9271079389798572, 0.9972433568723243, 0.6004826891174143, 1.0343905310760688, 1.0514574997580726, 0.9716917883163095, 0.8331441117846585, 0.8808037856052462, 0.1866873958334471, 0.5761691589072966, 1.4315014070904275, 0.7819264829860217, 0.23828080592895698, 1.1428226415766463, 0.9471496692653187, 0.16634259974493315, 0.7802071352843449, 0.9369502616029556, 0.8803762471254736, 0.7261031324122741, 0.6044004963152676, 0.9958378703298398, 0.9451413481080267, -0.23195098812413173, 0.521626879624945, -0.17963974933484986},
    {0.9347696965016232, 0.8133479793038016, 0.9159856307892207, -0.15308758353340934, 0.9240818832842755, 0.9560878092448293, 1.0001186636256547, 0.9158606150801969, 0.8111821888986173, 0.9114059877034028, 1.0614393295444713, 1.0902859733113859, 0.8558011915012009, 0.9589690655444835, 0.20926784756669659, 0.35691458767048595, 0.702309276685452, 0.7856606277265946, 0.5929655881294758, 1.0890629521837636, 0.75426150526422, 0.0908504801254154, 0.9779816285698069, 1.0421024856306145, 1.116125195153075, 0.6886073987328875, 0.48426911905418774, 1.426134557139559, 1.2149106435422177, -0.10972472323437, 0.79338688788046, -0.02093082876230992},
    {0.8362518546797578, 1.0479514231608538, 1.1145956887053292, 0.031448941572688315, 0.8891073567222528, 1.2919088711847186, 1.3184547076780375, 1.2390993178029124, 0.6590759319226636, 1.3561719497326559, 1.2993284339269857, 1.0117778470558494, 0.805908613644413, 1.077648197580414, -0.15714878017406078, 0.5808399339607881, 0.8476640512515226, 1.0910073696350535, 0.7674903259524377, 1.1890797254999437, 1.1064898330398145, -0.36763170112245036, 1.082669589991051, 0.9193507815693163, 1.2502233445361517, 0.5863106467843456, 0.37628786317652374, 1.2195751515300504, 1.106006854347259, -0.02866848957636653, 0.6488650197965601, 0.0829854284456713},
    {1.0412541726060467, 0.9470007665259363, 1.0173308531615888, -0.10709239991358216, 0.969377251298333, 0.7942480382752308, 1.0499397106812314, 0.9627751275112282, 1.05356908289381, 1.0732595149834523, 1.0512422705865418, 1.0742689065644844, 0.7408186750813823, 1.3438723663011973, -0.14020607241544517, 0.5070279195747794, 0.889258532696619, 1.1969399578634887, 0.5792798259008654, 1.192953103330906, 0.6626035177701572, -0.1686427358244943, 1.0449694400581748, 1.2941396690202278, 0.9965712306357697, 0.6813511603127766, 0.777379648871312, 0.9651650022433703, 0.5598701341315182, -0.2096173143664625, 0.29963515627877524, 0.11654319756221544},
    {1.0383279463197717, 0.8384375957532397, 1.0210086180959748, -0.09021582762942529, 0.9596532334839245, 1.0554082147913961, 1.2173413588496518, 1.0643437778540565, 0.8103618792640859, 1.149739600391274, 1.1232969148319925, 0.6973767601382864, 0.8407105023013333, 1.0613714947311952, -0.25906081171182843, 0.5050437790498633, 0.6743740192237572, 0.9427207790603185, 0.8439595917059458, 0.9795248576285299, 0.9493272377543794, -0.1780062302013692, 0.8952849538763356, 1.2755580712071741, 0.9785209356485345, 0.5451543772148615, 0.3357826061718007, 1.254863540301769, 0.9714764112654847, 0.1871229480160844, 0.30904371218852617, 0.09321323847140266},
    {0.7694931001037408, 0.6761321784070962, 0.9603774864768715, -0.20130888201165392, 0.9913660250676537, 0.6759740017264865, 1.2775372990049318, 0.9802141945314624, 0.8564880320223279, 1.1364243959500273, 1.194028822196161, 0.7924529374065595, 1.0856110021070786, 1.0529971656443067, -0.16538006215402587, 0.5126839613416566, 0.6933644425714358, 1.014231882040791, 0.7982522903305087, 1.0253734757448674, 0.8572202917994131, -0.5077093493708571, 1.1342456290814706, 1.0893568396528146, 0.8022868802320985, 0.5443747443122807, 0.5389896146699711, 0.9025271508420103, 1.1338578635769585, 0.04657348648854833, 0.30308309665473077, -0.13052000461445373},
    {0.9416851232767508, 0.9019789759922585, 1.141623747449097, 0.2442909579526845, 0.8820873883213195, 0.9609421954769638, 0.9756618995103491, 1.0362839256158707, 0.7118211650668792, 1.098825543478006, 1.0189908377025925, 0.6652338654176312, 0.9760291730865139, 0.815840722009724, -0.1358516805603053, 0.24336204968947683, 1.2143304747530679, 0.8082532986462955, 0.4044695641865029, 1.0312174809322137, 1.0520271495997195, -0.1281925993455941, 0.6736005569007817, 1.2162426579535934, 1.2176574788410655, 0.6850658897278141, 0.4165374943356494, 0.9682231242949125, 1.1488520097758659, -0.08010153962672296, 0.6329251907716721, -0.24777462823233581},
    {0.8015622159137247, 1.092198029200664, 1.1694767793595433, 0.0638762423981661, 1.0922491374220868, 1.2447911190277774, 0.8581149430512783, 0.9762862631448521, 0.7286788526533011, 0.9165870800156687, 1.1143809787084664, 0.7180888583280745, 1.056708793307463, 1.1033774315962885, -0.16311245560256965, 0.38726956017230707, 0.897082232065891, 0.9528947807194417, 0.7835590665868771, 0.9368022324099445, 1.2436240753907029, -0.042731591355430885, 0.9191611947861875, 1.2897225490164852, 1.0316547584268965, 0.7332115237681562, 0.46477285961306564, 1.0097629170598397, 1.0808446831668108, -0.07639079950348995, 0.45127579459449224, -0.14948332007720996},
    {0.5631465663868587, 0.8273704598993911, 0.9398812075558135, -0.36088375557059027, 1.1436818514024745, 0.969830876874503, 0.8186347067879718, 0.7500683834608463, 0.8084713591965152, 1.2179918364081668, 0.9894551387779617, 0.9666865592046381, 0.976121781287304, 1.1374148769471992, 0.2140051953576362, 0.5362545860314605, 0.7310732411280726, 0.893603154514453, 0.7663498544047698, 1.1749888104979336, 1.064925766521769, -0.32119727982329166, 0.9544559366431891, 1.1065608218511636, 1.0663783072191355, 0.5148069747134314, 0.7017238478515737, 1.306993262551633, 1.0951851233165086, -0.06606860597613852, 0.4907787263179752, 0.07335791014675747},
    {0.6863376872079294, 0.850642465619942, 1.0224082842972724, 0.23249582848928693, 0.7982756297366577, 1.1914805382050873, 1.2023621015829191, 1.0576209199497584, 0.6155558841349955, 0.9861590844583474, 0.8832782540041212, 0.8229117949655679, 0.8099780200905098, 1.0355765990983212, -0.22146570551036915, 0.20947770313104205, 1.3250504622328405, 1.166215863862458, 0.48445301807645913, 1.192246270995609, 1.2511947977072102, -0.22424143570327676, 0.8699159893227847, 1.0489724160737983, 1.027408085364134, 0.4427664306154112, 0.7201755374340814, 1.3124461996881258, 0.6189695068398454, -0.46095355820414946, 0.47074159446946745, 0.026676035306000975},
    {0.88551279682542, 1.2876922655576275, 0.8322357171767597, 0.09048572230788125, 0.7548037889442136, 1.1759125101255474, 1.013436499516806, 1.1138646943552861, 1.044467283788328, 1.2117671683107953, 1.278662927469811, 0.9365696456307977, 1.0697397134623918, 1.156157589159562, -0.038858285656664125, 0.24149804779108894, 1.08538977918696, 1.008476295643848, 0.623451606616364, 1.487552123077322, 0.9409021625953781, 0.20992896113876058, 1.0771420182825726, 0.9267438520795312, 0.9407782376510684, 0.35318672530324857, 0.5102119137982339, 1.0337776653287687, 0.7975227705558938, -0.29813899099850943, 0.28329627710222827, 0.09443874586072248},
    {0.9944921839199825, 0.986722628461456, 1.068984985023609, 0.102254509881682, 1.0360912965266675, 0.9654575666303271, 1.32863285626243, 0.5622511074858082, 0.6871311916851474, 1.4864377137931792, 0.9113306380466651, 0.7667731745496383, 1.1395971392369493, 0.6763835888746988, -0.021718373695046086, 0.7132142758412116, 0.8210019429700995, 0.6346677286181032, 0.4249966800347826, 0.9376607513062197, 0.8216896790184172, 0.3324284553700859, 1.0903456470815975, 0.9482341995180781, 1.1514603375543204, 0.6401571211061236, 0.4741070438047769, 1.1761884473878492, 0.9195238264051558, -0.2004355004733183, 0.6207162528522628, 0.09654433849410216},
    {0.8700542461169312, 0.5994460533866536, 1.0944982768582256, 0.2661055606395583, 1.3281056304894092, 0.7851173125901951, 1.107261579855488, 1.279611462841178, 0.7201967704155154, 1.1152907728206742, 1.3480427245047522, 0.8845604566282833, 0.9121844843486259, 0.893623759988632, 0.21012148759807014, 0.4249130214579704, 1.1701605561872408, 0.596342450545925, 0.8786720935534917, 1.0655839014823174, 0.8704493475043075, -0.31367370507719056, 0.8122314447415422, 1.1339206861632702, 0.9314613259350704, 0.6373827772576627, 0.8013339642022007, 1.224783304495377, 1.200276026274333, -0.27893962691496266, 0.7344494345985253, 0.035047266646924084},
    {0.6225337973866343, 0.7799737671133717, 1.032135871506168, 0.11962863722900975, 0.7557843792114433, 1.1001484671382629, 0.81736725336882, 1.0210950844771454, 1.1431074128521297, 1.07639076124278, 0.9031678426419951, 0.7399980874183735, 0.7568589554296407, 1.0763280473973507, -0.1892195599958088, 0.35662444560746814, 0.8673873589475078, 1.0133066813312126, 0.7743192788430008, 1.3747609733801942, 1.1541177807204135, -0.17728276987369768, 1.0433276022585178, 1.3399082647944875, 1.111278800239984, 0.5238306538657503, 0.5040657450534523, 1.130872169147977, 1.0895517007130333, 0.11375503046855477, 0.6495898695417989, -0.39855479046134945},
    {0.8492549555066323, 1.0870437334959582, 0.5065207414157087, -0.2852744740356766, 0.7376092232012291, 1.042089419464318, 0.9552438919959441, 1.1130611741527767, 0.8202929371957288, 1.3712187171774086, 1.0724101897794025, 1.276932651587267, 1.2640254987256647, 0.9645187773616182, -0.30437989524192954, 0.5361680641927693, 1.1550739738299987, 0.9879814903879467, 0.7030049563888459, 1.0405231538057627, 1.3295257961141542, 0.008430052243263911, 0.8207489253681264, 1.0882413821659722, 0.9764521888979127, 0.46208350634410067, 0.8428289427323877, 0.8932114075300988, 1.0143049264147024, 0.06743076825382342, 0.524566111428359, -0.0559012771368504},
    {0.9988179662866447, 1.3139223389789376, 1.1348560241868026, -0.3254923364088716, 0.860003657018112, 1.2747333276006416, 1.3304955246076722, 1.1882199165481593, 1.0298727448980094, 1.1643592554575146, 0.9574690111471659, 0.7070924691005619, 0.8853436741710263, 1.3271999632077196, 0.08142042789162326, 0.3767367890756534, 0.7717023451834317, 0.7540510463972948, 0.5830052554191972, 1.094670495766248, 1.0613021528526076, 0.09827332697160139, 0.9869539075438666, 1.1749272192344025, 0.9095919038107017, 0.5785472511381, 0.7828346300422085, 1.0182650100813817, 1.044918874765804, 0.0902808058858458, 0.8029800828138887, -0.007954710570085675},
    {0.8589950362843568, 1.005042768956472, 0.8121902904665248, 0.06045463130753196, 0.9518396893297942, 1.144277179468235, 1.1288529059162018, 1.0608290866405352, 0.7013165242543968, 1.0676361215425605, 1.087647029288883, 0.9192466879834603, 0.9854312099834562, 0.8147897661583674, -0.2116658901458355, 0.43991423407554, 1.203554170602383, 1.090632188715905, 0.57837387715588, 1.2230733549023516, 0.8853926077830923, 0.01871518649625116, 0.8851555487086995, 1.010685255797248, 1.2850115790786507, 0.8651443084428423, 0.3102924146273868, 1.1353245243780496, 1.2481415417420962, -0.03505800141288331, 0.7295882373126309, -0.353747760173411},
    {0.9120794343135535, 0.9008739742487778, 1.1581811937468391, 0.15390498747572928, 0.8965878019494125, 0.945469137475439, 0.7942619101140221, 1.2282711014658914, 0.51445583344037, 1.3182179292114247, 1.2283604531952454, 0.9863340530963969, 0.8888537692802709, 0.9621912951753355, -0.12807800659285615, 0.38248736373550435, 1.3464669239563547, 0.9954605644928431, 0.4129311997947199, 0.7895498977307336, 1.0010765469557217, -0.1325005874583594, 1.134145575748268, 1.0274713369045105, 1.5047980929051237, 0.7008745663059393, 0.5637154735933716, 1.5415724652464504, 1.0466304147644327, -0.14424181734650598, 0.7182798452810119, 0.027395309624448114},
    {0.880869789011295, 0.9870127753858036, 1.0465454777022625, -0.07251586670215396, 1.0933218279285093, 1.3958206630561596, 1.1146142729831119, 0.9396841693035949, 1.0610846727831165, 0.9077248108313403, 1.2149061197265247, 0.9907607171663513, 1.101957937551949, 1.143963745576036, 0.05185278003044096, 0.7248375869437828, 1.107366840574591, 0.6018064109835332, 0.5715280491282563, 0.8718114204040055, 0.9799356868156605, -0.17178578214669935, 0.9012849099370057, 0.9885793149337331, 0.9025234235870494, 0.5270781751208419, 0.7521408980388313, 1.0540452930931907, 1.0843352387557186, 0.13255665889351018, 0.5280009856625335, -0.348484363428611},
    {0.8151113422902198, 0.7944437374590576, 0.8960227566206066, -0.20959220378119917, 0.8504607163076384, 1.0529770112127408, 0.942852451602011, 0.8400908146266974, 0.9990095779904271, 0.9405870039366511, 1.0916616254000584, 1.1737263024867672, 1.1777378050769092, 1.0892205163386963, 0.03648095865328438, 0.5613500159552584, 0.9098628297253611, 0.9887384196477143, 0.23794913664510314, 0.8668631799075477, 1.1316815718153213, 0.011619682193972122, 1.1416507647000533, 1.280224631647186, 0.9586023597581483, 0.5004679991223133, 0.5996074485519711, 1.0502364714943733, 0.951376862413422, -0.05948091726516628, 0.6877875815818576, 0.004876054226366445},
    {0.9900216308059292, 1.0982761993492451, 1.1642575758394076, -0.1443803497808421, 1.0953919363956506, 0.9826557736347649, 1.0959109724332285, 0.714515614935945, 1.2749258375231565, 1.0257863687608932, 0.8887464229569633, 0.8912471920439704, 0.8722547237976742, 1.0357098151870647, -0.13807092518650035, 0.6887591641617036, 0.8684073863027832, 0.9020505637200052, 0.5655214201950374, 1.3145868835159153, 0.9228490227286243, 0.11932562097926254, 1.1181833547299869, 1.1981640308347834, 1.4587252391307377, 0.618758388057354, 0.4373604045323324, 1.431063135911082, 0.9254083851295881, 0.18568185206206714, 0.6230871501401224, -0.04317875203407116},
    {0.8125671661055264, 1.174758157186326, 1.003277415275189, -0.14345019203322096, 1.132786122488987, 1.1322622404730578, 0.9044302104305607, 0.853274723794796, 0.9783347755008319, 1.2001662826478043, 0.8011068864178855, 0.9157696058421431, 0.9169663364664636, 0.9902443451673983, -0.23583520496787866, 0.5889958391475699, 1.0574550030243923, 0.8526570132665247, 0.5034997053147133, 1.0648469824750406, 1.0835217094732927, 0.020011063723659708, 1.145106746709339, 1.001544265784948, 1.1209034985262865, 0.8123750157524071, 0.7446506852251317, 0.9892873119714178, 1.0521680922760723, -0.18126826903787943, 0.6241057465583525, -0.14351647981371163},
    {1.0572914043551689, 1.203904515288713, 1.0110084302341376, -0.3670903924718513, 0.9198453472003432, 1.0568362407492657, 1.0241532165857894, 0.8035105377855929, 0.8712899860003164, 0.9971205297491718, 0.9976556624803171, 0.6950261192138291, 1.0908239837222466, 1.092065376488262, -0.1706618959182574, 0.5924542427291474, 1.1368992550325399, 1.1127346966940597, 0.6245071761108437, 1.222374736551292, 1.0635896875151203, -0.008351768801952849, 1.1037467080718693, 1.109348371841132, 1.0351816974862207, 0.33016079896068967, 0.6066611012099632, 0.945539933394571, 0.715422320601397, 0.08401097306612736, 0.5372382400429011, 0.017375278213307147},
    {1.0349425766796763, 0.9151009562874117, 0.9146384657902582, 0.40161783992934036, 0.8422279228662477, 1.0067668657369722, 1.059496463132768, 0.9585356559128124, 0.7290588128179262, 1.321402961716275, 0.8643689094169218, 0.9946721887096253, 1.0594336915551354, 0.9162007006086624, 0.09903881640151756, 0.5956845780904051, 1.1862895694313829, 1.078633543077726, 0.6420471970129347, 1.0372529339068177, 0.9818097958211295, 0.047545814793374, 0.5552019089581902, 0.9195490523523716, 1.1048795933270212, 0.7890880703307995, 0.6826122230530383, 0.9933254908929224, 1.0774679339172912, -0.025946282040959508, 0.5379227051293238, -0.16990692483163886},
    {0.47430869874714304, 0.8678496146078009, 1.005298322006086, 0.08114577022240302, 0.5383465321485826, 0.934837526985313, 0.9533504488536141, 0.8732102129326792, 1.0996987825546296, 0.9477626782179241, 1.081281722987491, 0.8431266209085904, 1.0909690605885105, 1.2488558788286674, -0.07687510180940905, 0.5935590353615667, 1.0886450191717578, 0.7082199054769477, 0.6124455409366539, 0.9533689350703416, 0.9144391956352477, 0.09632223340028709, 1.2463091025361313, 1.4927223809844636, 0.9708260427538524, 0.4279315602076949, 0.4608312947265385, 1.3210070653955963, 0.6768525031369665, 0.056047910059278575, 0.4328658755311709, -0.34933775412276663},
    {0.9646895599066085, 1.0404652344942733, 0.946458837787346, -0.058776130860322635, 1.1551595032156652, 0.9654658339959212, 0.9643301359633707, 1.080306183370915, 0.8833837961142075, 0.9069365579696669, 0.8681781802720409, 0.5990237835787864, 0.907993868163866, 0.8156249774778745, -0.21902267300130857, 0.45752768437424957, 1.1656418445386707, 1.0459442308874365, 0.7043582025123927, 1.1965879438930291, 1.1828137148427007, -0.10448902618318544, 1.0542658083264342, 1.2109838674976163, 0.9151546597233081, 0.6575026897461362, 0.7957946627280957, 0.9630457474795432, 1.1297525759911915, -0.09985502364194704, 0.6150133516261661, 0.14009387846573493},
    {0.8556938448685855, 1.2610118873269782, 0.6987197211331644, 0.14966814642765686, 1.0212239939502823, 0.9688857876892037, 1.1408171862627754, 1.3948615191836249, 0.7560027231055962, 1.0551532564749713, 1.1614888576034057, 0.8446109831401487, 1.1113501890344093, 1.0276281428218002, 0.1216692707726244, 0.46826026487707845, 1.1151582766791783, 0.45054704432982334, 0.36765862767531976, 1.0006069144020555, 0.6583613673775516, -0.22586093946957553, 1.0625479504982163, 1.1369111858001633, 1.1717937666611609, 0.5853431387405542, 0.5495832800341703, 1.2683863495867471, 0.9724212864428028, -0.3063076319477847, 0.6108304668356408, -0.13751796808746752},
    {0.6121147278493416, 0.9583205693912229, 0.8798896266736874, 0.19954917734908587, 0.9447226658080812, 1.0897822469701923, 1.3938076794894287, 0.9446239367909347, 0.7304826038139027, 1.145538516187344, 1.0640866630504573, 0.9663673362585297, 0.8679945245610156, 1.082148160443631, 0.05128841340931495, 0.40973086420279753, 0.9653683131347092, 0.9437362927179068, 0.6688327950935475, 1.2480450119417161, 1.4598921413998127, -0.09885377625281667, 1.1487331066221254, 1.272310030018963, 1.0199777676465236, 0.38562315519144136, 0.7990490264591668, 0.9836221268099418, 0.7321437298116367, -0.28216793273491825, 0.6782723500303254, 0.10065741907727581},
    {0.8071712567855674, 1.0777342702805246, 1.1395816646942398, -0.04880907981872175, 1.0049982157350414, 1.3335510967528035, 0.8757464140187112, 0.750931155940312, 0.585112251752626, 0.8995111424480495, 1.1654783283711914, 0.9058716305322362, 0.9060596133519463, 1.2306115199544592, 0.03992925113336892, 0.2908859168032141, 0.6067941298799028, 1.1809363069057566, 1.0593994954799153, 1.2823670687754576, 0.981048709409972, -0.013286293292097276, 0.8932753914356393, 1.0838410964290435, 1.5093028057587548, 0.7118153106450418, 0.43892438747603896, 1.6055360772672163, 0.8321709841306084, -0.009537979381311743, -0.019495880296720877, -0.18169918342306832},
    {0.8977028029087025, 1.082124491259164, 0.9770060201563459, -0.2980002517558066, 0.9277774990672483, 1.0594879548709393, 1.064721426135708, 0.923453676307926, 0.8533277424680694, 1.0685763190379964, 1.3370250419179062, 0.9944519068827451, 0.8316793774199347, 0.8691282889863045, 0.0015655260595308644, 0.2188955421520907, 1.177081626665798, 0.7894286830701229, 0.6075567251994687, 1.0097322370228035, 1.137179039180219, -0.287293096030835, 1.030688836101665, 1.1853651985706255, 1.2924088783312075, 0.5150614330615605, 0.8761557367964411, 1.1039955483173023, 1.145202532686542, -0.2792980960844595, 0.5896428329451958, -0.05468567048620061},
    {1.1378639782090403, 1.131305203942439, 0.9991801644880097, -0.06479619131317907, 0.9827588504671938, 1.030052334635602, 0.7496122003755993, 0.8728752126881384, 0.9613452353666585, 1.0008157100652801, 1.145715390304406, 0.9021562347486733, 0.9861645141935456, 1.0326845853985502, -0.18929571384851046, 0.6416248852618824, 1.2491020270434114, 0.7169921628778556, 0.42604992375512, 1.012537428547089, 1.045767788944259, 0.18192644554023088, 1.0700980781643035, 1.5208467162483503, 0.8824610913908261, 0.4215600401105435, 0.7054085095131704, 1.2412771834134824, 1.0449435419377864, -0.3273492423348724, 0.7656394011584297, -0.2191451883446674},
    {0.9971146981600366, 1.018575961492314, 0.9768111283235639, -0.07663919740339711, 0.994851364106701, 1.334181796303854, 1.2658371875093732, 1.0972232393948647, 1.1001994247098879, 0.9336637621713335, 0.8095857515870648, 0.8475009573598888, 0.6622529321245239, 1.105678863672717, -0.183024457167338, 0.19491324100168816, 0.9860801639641258, 1.225044546203542, 0.697192759397397, 1.0529000902771621, 1.0921678383771976, 0.3216549234358106, 1.2198030819650336, 1.1019811502650805, 1.0657007642006775, 0.7115615229193253, 0.8575378021693439, 0.9492065512182432, 0.97010810416967, -0.21424644558174738, 0.464968151623343, -0.06063830574662026},
    {1.1107968856433088, 1.0026363920362533, 1.1084426385609951, -0.15062016709949017, 0.9425751199738179, 0.983787489157346, 0.8655666672500505, 1.0353318969086807, 0.9094717623887271, 1.1177988222469037, 0.8495133203079586, 0.7087093392358328, 0.802961779739951, 0.5783788784530441, -0.36183579512303005, 0.23229913854043768, 1.12658719444977, 1.0242395301754401, 0.15760982430757386, 1.3180601385010837, 0.7636631356361142, -0.18215810459244716, 1.3036597407447932, 0.9529303492454492, 0.9985730090606795, 0.557416733497945, 0.4169037509476666, 0.983253050541129, 0.4849589574935373, -0.16223458750359518, 0.6327461445341941, 0.08969431014116107},
    {0.9629235155449051, 1.1257095159422614, 1.246430565956698, -0.4144494606408844, 1.3340623142369628, 1.189367039762739, 0.9772233981109096, 0.8749954466018856, 0.8655723398247928, 1.0694361053849228, 1.0852356716276734, 0.9550247349238544, 0.6635942984619034, 0.8049788431495098, -0.17428685266322605, 0.5441951988003108, 0.9874914720057452, 0.8198374385997058, 0.5319827432300728, 1.299098637328443, 1.068354884281842, -0.02626598924367498, 0.9354591668725896, 1.2407942460747785, 1.0579338804298841, 0.5481674261352694, 0.44282429156887493, 0.8223377800234891, 1.0103484528962525, 0.09274289993356094, 0.6660694934605008, -0.2831114335259284},
    {0.8309168621774586, 0.826037008454591, 1.0858881957892959, -0.00409209052509842, 1.0306269296226795, 1.021697057913057, 0.9504825367210166, 0.9757446124084016, 0.9519671582436052, 1.3826524211783304, 0.9356778572319051, 1.2002031825953114, 0.2818114680819154, 0.9413590932759375, 0.29417745554663105, 0.3693378641286283, 0.6712414358868002, 0.7713854193227346, 0.6478203349646066, 1.2293445320788254, 0.8576811258703717, 0.10701235563682719, 1.0103115314110003, 0.9318351716978239, 1.0190703454645387, 0.4242213383160829, 0.3637958314120694, 1.1800476049384043, 0.9782272758134105, -0.160605052801377, 0.7517622702837893, -0.020632785813645357},
    {0.8100704350898074, 1.3681808226631673, 0.9090073992715706, -0.2920953213050279, 0.9332528218054742, 1.0208176337177144, 0.9337925671858065, 0.8045897449237265, 0.7096372327972116, 1.1152564026665035, 0.9063574080217537, 0.713404459683709, 1.2305451753104635, 0.9903899245059671, -0.11477818672931848, 0.46845505480640576, 0.7876693372033297, 0.9797603245956322, 0.7951941132149158, 1.2417524729922722, 0.9030103803535897, 0.024911239316757, 1.1439351787628869, 1.0334229048692825, 1.0666671331448951, 0.3522225660038166, 0.6570828108002832, 1.3492806880664492, 0.9173166410314515, -0.29645095382221504, 0.3773730953612001, -0.04359346292817263},
    {0.8461764161322258, 0.8178432533696003, 0.8635467479800821, -0.24128782171417204, 1.0249141539659268, 0.9184645766037484, 1.1097814430990762, 0.8712991324371595, 0.885460111337548, 1.3881001510452622, 1.1014115903409119, 1.3074596817690045, 1.0044452680741711, 0.9881546850776574, -0.23018020103532533, 0.13615710909288664, 1.2505454767966206, 0.6850784043273435, 0.5530844041929368, 1.175941377537977, 1.1066475869535377, -0.26444160926150323, 1.0936260603847707, 1.023694477605372, 1.0210673229741845, 0.6536199638538039, 0.6627421589197525, 1.2735569461852287, 0.9776055542545465, -0.0005435921874475045, 0.6570745018329672, 0.03293397325605117},
    {0.6431713543699062, 1.0545364170733431, 0.6317627582372826, -0.19752286205337666, 1.070284490577622, 1.3799845346263522, 1.2671543078749885, 0.8605073709487581, 0.4576974586568847, 0.9635970225199824, 1.0528223245925883, 1.0665269424489228, 1.1604770919754543, 0.7531480186500612, -0.4364511873126146, 0.6745784478868512, 0.9413925712067891, 0.4575790489820546, 0.5891921993648637, 1.034143041406974, 0.968734941467063, 0.017229826267620006, 1.1197958685126097, 0.8122700434804625, 1.2466738254142409, 0.6124653522018695, 0.7372957199908983, 1.1922829616773483, 0.9412807060755433, -0.24399121760426482, 0.5981755822382706, 0.16021220745784956},
    {0.7736077090382357, 1.2755683561258724, 1.1405175246228585, -0.32295011447790706, 0.905219115306017, 0.9575689132141039, 0.8647225924809051, 1.2252636868078775, 0.6822605267698473, 1.0106529459179145, 1.120567939912389, 0.9564177995093952, 1.0607095255509904, 0.816711081442001, 0.11668064273914062, 0.15075989875815385, 1.141893340037978, 1.0169018883452356, 0.6230319181313623, 1.248968897255619, 0.8325890400628762, -0.4799732861899278, 1.2485072304610427, 0.9098025835032292, 1.0370866944661334, 0.7814047453159989, 0.6386788777925922, 1.0452763779016452, 0.9315403284501858, 0.1832029625766809, 0.3398451444735548, -0.0018744170890376188},
    {1.1222033816945995, 1.064599796230341, 0.885843367986225, -0.024862460707553328, 0.9690362987671812, 1.1026850366979302, 0.866894161587223, 1.0861756699086837, 0.8743660249057186, 1.2107195306031235, 0.9968401287867661, 1.1695140601059657, 0.9929661618878626, 1.1938518415532657, -0.14651265817216844, 0.5490087590981956, 0.8986345486503966, 0.7671414398100111, 0.4356801317579945, 1.0799438670435038, 0.5777221585573105, -0.15334701608471238, 1.2114270659500144, 1.0570457903859563, 1.0453044101013065, 0.6161849889566393, 0.40345412499148786, 1.0761280433526492, 1.0466458506881013, -0.19998079750260256, 0.7165199125033312, -0.19826280792716408},
    {0.8994676860497508, 1.1720171692085408, 1.1873373464116506, 0.1416264397567927, 1.085927721772945, 1.056497337304078, 1.1783760695916836, 1.0270171381256417, 0.736340321466669, 1.0019753610795292, 1.0431496772869153, 0.7115590042559174, 1.041011374478599, 0.8559511973271582, 0.15988611996871033, 0.35291732066126635, 1.0784545224374102, 0.9099180118133261, 0.961869047252493, 1.1817090254422347, 0.8865862193386678, -0.15374198787709756, 1.0723792658597966, 1.120130192745189, 1.0987351948920459, 0.6441318782410997, 0.5255482425737441, 1.1021675690368329, 1.1459776633937393, 0.09499621539871728, 0.39209685550188766, 0.10055627662274308},
    {0.9760529970844822, 0.7513646947498828, 1.2982618467394003, -0.20735370943272977, 1.2567635209289987, 1.1286887752734664, 1.0072384392326517, 1.1075492742788147, 0.992771624043332, 1.156911573947069, 0.8940259004106248, 1.0259251221567263, 0.8092699947629348, 0.7624537777351271, 0.054441098461636354, 0.8653877928821055, 1.0312774680054098, 1.0712142913735512, 0.29024273590293803, 1.09277352981782, 0.9494517181655624, -0.08795969983948586, 1.111484097101564, 1.118568186769083, 1.1246745923186698, 0.4398438682881118, 0.41633734744932255, 0.9644760167433575, 0.7598748488196512, -0.036492863536648205, 0.30939628382253725, -0.10501463884173572},
    {0.8693778481350612, 0.8427855447025454, 0.7737723962476932, -0.13273015665398025, 0.9362633049840743, 0.9837542975352974, 0.9217219456325986, 0.8546906811908864, 0.5811851699349546, 1.1250446525027775, 0.8715186666239643, 0.9394440206438153, 1.1586137918585369, 1.4307162537696165, 0.175697737928326, 0.25240990305397343, 1.114517564553171, 0.760560956963831, 0.6939536014661525, 1.282738957482218, 1.1268503959722957, -0.10907051774929316, 1.1497320159247715, 0.9102576443392117, 1.1697678878238258, 0.2222003057788815, 0.45693672073157826, 0.8577888548405365, 0.8126685737725382, 0.0257083608104255, 0.3051852118223769, -0.060654561284555986},
    {1.1340120505998053, 1.0670720839220198, 0.649014401071832, -0.3495915611890712, 1.117881127471315, 0.9448134955208731, 1.166638685609489, 1.0610632236729765, 0.7908379294789756, 1.0937072352506725, 1.2781875611545759, 0.99063807870119, 0.8547717781626958, 1.0275871172274489, -0.01406108266588519, 0.5208024383041165, 1.0428933580676873, 0.8691577389168138, 0.7283994095539442, 1.124329042040746, 1.2273049694872564, 0.04495964506971065, 0.7826485052711897, 1.140757126882699, 0.9501571866207287, 0.5511065084492789, 0.69755338360009, 1.1592944820967035, 0.9494382628131605, -0.03696128082570335, 0.4685636018674472, -0.16036455366549296},
    {0.8317623343677222, 0.9126856323583329, 0.7841294266469033, -0.24353094531708078, 1.0509511660384319, 1.177447342403544, 0.8666478036044307, 0.7496870157030135, 0.3154618731078628, 0.975651517496716, 1.066398348304282, 0.6812662328943399, 0.7586292625738273, 1.1385242372321789, 0.18235594096064597, 0.6108727025965157, 1.3216394392103803, 0.7041535165083012, 0.6803429602011555, 0.898161629154763, 1.0271047083734222, -0.23715176658615417, 0.9101561455788842, 0.8608093030215636, 1.02117717944741, 0.3753544443557691, 0.6824353427302404, 1.1816671192934733, 0.9971450446655801, 0.1666894686757734, 0.5255804883376297, -0.20016185955103655},
    {0.8571936522570457, 0.8997001263539868, 0.7468280621817639, 0.13349921755506544, 0.8529423741158921, 1.2115390543985771, 0.936309190089429, 0.950489256196832, 0.6864479786847341, 1.023318460857627, 0.80168706020844, 0.5478734006342433, 1.0222605532646474, 0.7468278453708039, -0.07239616965516023, 0.5120426765257153, 1.2631781209634354, 0.9908156704731997, 0.9009911687385688, 1.1287200549648162, 1.006281991548776, -0.073504592610613, 1.06154735391882, 1.2123940778281703, 0.8934908251739601, 0.849971495835033, 0.5755909521273328, 0.9467633374030427, 0.9175259437119971, 0.0182509929025287, 0.5350566175676211, -0.20267683380012783},
    {1.3277645421528876, 0.8421365888843421, 1.1243552410094553, -0.3549126721100253, 1.2841019772338271, 0.9730577146842575, 1.1085773905897651, 0.8656579530744591, 0.686136114824856, 1.1999074462625667, 0.9990934985871114, 0.9017576681871701, 0.938209621966984, 0.9453335674678299, -0.05771433143279614, 0.49139581668815474, 1.0023251676068095, 1.105124158023086, 0.8375619429209272, 1.4680408328082681, 0.7653819973805022, -0.10063677936780875, 0.8213139876054648, 1.3686210214438586, 1.1348178926016002, 0.5730657069894352, 0.15453831931460402, 1.1681155225488173, 0.9970608939832449, 0.038223369168807655, 0.5485138169850495, -0.14740904650143521},
    {0.8082384641019806, 0.6623867606076379, 0.806509953628849, 0.10576105856808868, 0.8399874602963809, 1.3467169429565622, 1.117136317533116, 0.9251676748744097, 0.4879874077730595, 0.9537500417213581, 1.1790000975895074, 0.9412938903472373, 0.7482584215609609, 0.5268291561236612, -0.2116903308478296, 0.38958773927804086, 0.9001631119367497, 1.209879353166847, 0.5205732351057611, 0.8756953133479449, 0.8718703054425365, 0.2354443244960876, 0.7965420776113574, 1.466951385967316, 1.084394080897457, 0.4717983495661721, 0.44895874755687337, 1.0552889531445209, 1.0498360680758534, -0.3151600552817147, 0.16606106092330972, -0.07747351577806416},
    {0.9852022953951926, 1.0489027951400656, 1.0006428829249534, -0.06814466186724827, 0.9854389047594853, 1.2172028071621153, 1.2284810530092407, 1.2874715983628395, 0.6343316778594462, 1.3269823297411385, 1.0119735416750193, 0.6699546073522832, 1.0684890031502727, 0.9572392613093075, -0.4354783554881331, 0.49453985138171064, 0.8029156703582178, 1.2478438732763903, 0.8094674622564174, 1.1028588757742102, 1.2913939493244102, -0.5359260494230886, 1.1070476766426287, 0.9026411468935107, 1.171733358211254, 0.8338452281163881, 0.6379444732626003, 1.1891402487812848, 1.2935409510139584, -0.04024487070488285, 0.5239165311821489, -0.03447972480805545},
    {0.6989652013368959, 1.003829579037609, 1.2093796758761588, -0.13833596619470323, 1.1412753167988148, 1.0155506670047667, 1.4231926984604601, 1.1526730840025436, 0.6640145225965114, 0.9812738770128006, 1.1256993977553298, 0.8653114548099214, 1.0715801311924165, 0.9838978047472946, 0.1464750468036558, 0.11708163944950309, 1.2103626657980953, 1.0545282878470466, 0.3286409313518326, 1.2956606948152323, 0.9309045047868274, -0.1836004466702524, 1.2810960875888515, 1.0899922736616032, 1.1507915686020886, 0.5225864007291977, 0.34794581200480384, 0.8450609160930207, 0.7961368668329003, -0.2948850971631441, 0.4895170000628245, 0.118170321447506},
    {0.7773570146396896, 1.1733377314575961, 0.9239950303280471, -0.007368491631628205, 1.21228650886971, 1.1661784402682682, 1.5469364171529691, 1.074558334795023, 0.710667049770736, 0.9481439319191045, 1.4496389090239943, 1.1383896454107372, 1.1434168229900514, 0.7272926003560234, -0.14834850623238932, 0.17349782736874927, 0.8168999330994791, 0.9193664940607601, 0.5449597798165209, 1.0746439364653233, 0.7297953874096299, -0.022535134347080668, 0.9175817485115351, 1.056083686241289, 0.9436047217741563, 0.6202413416552152, 0.6546195927131474, 1.0869316740316337, 1.0824755862589168, 0.05360441953587617, 0.5759232999231528, -0.12303847839915953},
    {0.899986511129352, 1.2854442957722299, 1.2286710516912223, -0.09194000363311743, 1.181202758585655, 1.1415959005295822, 1.0028204486696097, 1.1816754702159704, 1.2089626426884723, 1.078609376752325, 0.9097793242879951, 1.0720746895446571, 0.871844143010627, 0.8716237957213816, 0.06012777445188291, 0.3304312562498574, 1.0133462993478395, 0.9938160908064035, 0.6294500011728501, 1.209914034920587, 0.913640291724152, -0.06502118981721755, 1.290311341774574, 0.9897426711034613, 0.9920177879710331, 0.698756263450824, 0.6477508815011, 1.1109631907933877, 1.0972768996403768, -0.12258916979325107, 0.6159539412982219, -0.025049638865969143},
    {0.922714376936333, 1.3030928826935557, 1.0005099589191704, 0.1493874175107345, 0.9580301622679053, 1.1192134107170764, 0.9243287560057976, 0.9426470016247415, 0.9398966547735431, 1.073333177551478, 0.8175977853763705, 0.9516441522925774, 0.8469154560638245, 0.847407562365174, -0.22529409426420918, 0.6883246383954384, 1.103750715466815, 0.5844888232133875, 0.3992239606805848, 1.0723772551924635, 0.5565274870356266, -0.46768675796639547, 0.9995300691386056, 1.0784568366029763, 0.8997154956409298, 0.5578089015511275, 0.8031426881117094, 1.34973058522281, 0.6780032852087587, -0.041686423172852004, 0.6055406993383986, 0.018777232292830112},
    {0.8694638361758671, 1.1743028916239038, 1.3977433683241245, 0.03632123290599927, 1.2300018445707046, 1.2211928646897094, 0.951487679340619, 0.8296348090624361, 0.6356587935736769, 1.2318816502055299, 0.9189480314244228, 1.0141983681804865, 0.9898017789683391, 0.9800074563765946, -0.18070943635425557, 0.48735925733828217, 0.9737663252166222, 1.1884163292313543, 0.6112140950457647, 0.8963644120867068, 0.8551963757568399, -0.11816761818954657, 1.0735773832061732, 0.9458844830896278, 0.6804859273553602, 0.5780377586169823, 0.6339548600860381, 1.0110227445438036, 1.1713112336560358, -0.27753708585327097, 0.8269217618691905, -0.4358186360141989}
};

static const float b2[32] = {0.8726589186268696, 0.9724823212803395, 0.9416263835304357, -0.052291059700822554, 0.8754717862870779, 1.0110843325117767, 1.0344618343899195, 0.96027181079861, 0.775478255807008, 1.0056186865755352, 0.9458472311936713, 0.8047466364003915, 0.9203882256111208, 0.9072825059673904, -0.047967299838438636, 0.42225717996106643, 0.9235709749820552, 0.8224127668275426, 0.6477690626417656, 1.0510593024301211, 0.9553802042413655, -0.07296896304575595, 0.9268808627289975, 1.014779130462151, 1.021702740528545, 0.5589143210832195, 0.5903362177799126, 0.9934727501575386, 0.9957334853591597, -0.07904713370274734, 0.527102553607113, -0.09159429598767849};

static const float w3[32][16] = {
    {0.9991257972828939, 1.003187954108585, 0.2049795530859565, 0.9719267339244306, 1.122696972935934, 0.916852665778382, -0.3960026187093049, 0.29505873344551636, 0.28211115571279516, -0.03915959224695989, 0.3396045845024448, 0.9836317749652351, -0.14749606355416828, 1.4613412433572286, -0.08633097611830508, 0.9251982422823717},
    {1.3184135170802374, 1.5680091816679942, 0.024228567172055016, 1.2944881482011923, 1.2878267143688453, 0.8707502439616062, -0.037032967493673005, -0.25870867277671195, -0.06531538852121312, 0.5356235050922303, 0.026374111756097544, 0.7563672475954493, -0.017202084377405474, 1.5818896726702283, 0.28464563172028623, 0.7366415262235038},
    {1.401341835102971, 1.1658347712441028, -0.10906486126718952, 1.0921160183811303, 0.5154145324319224, 1.361390902593154, -0.01467543113205361, 0.2830208173707122, 0.005143390256075222, -0.3590074843736957, 0.14444310605000393, 0.8298999959508635, 0.22511733824168584, 1.0715839391993303, 0.08727089162216824, 0.9518048074127021},
    {-0.13600329058350077, -0.13565911701211983, -0.8128543523254534, 0.02727003239659429, 0.4813764391782187, -0.2098042103044501, -0.2467883364435293, -0.10797912802776082, 0.13469899368027805, -0.1730205371284751, 0.08345094726142553, 0.29960586306166487, 0.0591514236124975, 0.03995335182307616, -0.2879865560826238, -0.23428143555765013},
    {0.9027219700335978, 0.8252385141237727, 0.17939019481957053, 1.2502356000278911, 1.1081338962980711, 1.0978407799398264, 0.18157460748409385, 0.025022145767885758, -0.1933760966071359, 0.08791587683796695, 0.1696036811411038, 1.1098843434263357, 0.2050750134178568, 1.480333166557904, -0.0012216079618726533, 1.3013054788130456},
    {1.2291902812990019, 1.2334800885210306, -0.5178649056418358, 1.2589735188495637, 0.6944383621933921, 1.259754064689289, -0.14452261791699797, -0.20014882003344234, 0.019741127441271537, -0.4017023703381813, -0.10240711739430935, 0.8360609683194642, -0.14712351549825867, 0.7267530994871345, -0.08052388033351306, 0.9143924892581653},
    {0.9917383671809207, 1.2618694886232251, 0.4260327295477152, 1.5251902888777693, 0.9769948199165943, 1.542486978557605, -0.21565875410499585, -0.5024295574993461, 0.33617677175260385, -0.41387465764468445, -0.26497891243958926, 0.7237371331666642, -0.24051302184910162, 1.2585142368034925, -0.056297487418625905, 1.128959986930904},
    {1.2383439166634769, 0.8642765787951947, 0.3647211882662346, 0.9899326523792564, 0.9052789720037708, 1.244351449150981, -0.3018963885271819, 0.08913765423847096, -0.5481640300871488, 0.20034975986536466, -0.40249397075178767, 0.23666704666897112, -0.11954775679405526, 0.9351201897808431, 0.02589434285114501, 0.847516133750996},
    {1.5159697781378598, 1.4921550992081918, 0.25131284592044456, 0.7829141977894306, 1.1035827941603134, 0.7515568409035769, 0.45076502786743744, 0.31195779336451773, -0.02153697779124862, -0.5806956515659748, 0.16246881783740327, 1.0561456026779854, 0.303108829832753, 1.044643438947388, 0.055520783927050864, 0.7665145215993631},
    {0.7353367768622223, 1.1275574005056384, -0.3409322629584238, 1.0813957916680834, 1.1215163684189104, 1.4059858169373447, 0.21657332548885264, 0.04003074497426629, -0.16418315031466793, -0.20338726291744716, 0.034662131002950985, 0.30545087737878185, -0.26258644904685147, 1.489606333691515, -0.25299528221019785, 1.3657114119063176},
    {1.0641969134765499, 0.9902662482839178, -0.40882493376984835, 1.1201412645052082, 1.0796105648195509, 1.382713861533051, 0.15362680998079217, -0.5471700495312781, -0.05777498032405592, 0.14456489664228095, 0.10056043028649178, 0.9264605182387449, 0.12216026820296368, 1.6508091941047065, -0.1681271076310203, 1.1872032360951528},
    {1.1223489827870627, 0.8148762485888411, -0.0895179351435674, 1.0223805910686252, 1.0064401488255568, 1.0168533929473094, -0.0017236987237939563, -0.22180702103144825, -0.3046454381407298, 0.26151255714069255, 0.010104501076746871, 1.4083924743349945, 0.3558616553045705, 1.2309567432293915, 0.21683721183144533, 0.8725257623150973},
    {1.4227321007878126, 1.4010298184812804, 0.052830922121952485, 1.0507795763459795, 1.0786253920873068, 1.020229077444734, 0.2948786413578533, 0.028386223542882266, -0.09688053821079935, 0.3455757552005084, -0.4888648220647577, 0.9851086145614757, -0.15261314008307544, 0.929050254318508, 0.04401976031418263, 1.4975066634862815},
    {1.261757215647236, 0.9522452511167804, -0.033018754876411496, 0.994365117423772, 1.1126959249197403, 1.3727888794319862, -0.06484581022545452, 0.2375675305331041, -0.3348197728327434, 0.6079191550412447, -0.060347124633502794, 1.1938058125226574, 0.2938722593855884, 0.9083886633809355, -0.32530755339172085, 1.1210484043287523},
    {-0.35561464543925664, -0.17720565293842486, 0.3564247676647407, 0.3028004270367524, -0.01803543573786424, -0.1547404974267307, 0.0589587173800486, -0.22294992747351672, -0.32333229248152084, 0.2898450495229139, 0.042577609907525724, -0.2693187734036813, -0.46005599937706726, 0.02011832469967083, 0.062436474191453255, -0.06305459950848309},
    {0.5595509528704399, 0.5225395777019272, -0.16006417585484656, 0.7095525407784614, 0.9424977473226657, 0.06113097610762147, 0.6968894820017878, -0.38054741246953494, 0.5439236501855843, 0.08728794187136907, -0.03911817807771175, 0.5869678677767596, 0.2159833307368179, 1.1227408384627071, -0.24078422086932383, 0.686378544885223},
    {1.1283952488802744, 1.2075872177613722, -0.013603129362840619, 1.219813580282626, 0.7912795559851673, 1.0492550900525448, -0.002758237389174249, -0.14283133476926826, 0.3699677481203493, 0.467199086423385, 0.10954360982197002, 1.2596137136814713, -0.4697787752071073, 1.1527957523010457, -0.1285209891938722, 1.2758289823427926},
    {1.271446074137981, 0.890645566034305, 0.2857341793065992, 0.984924015489022, 0.8650028380363045, 0.9754087322713301, -0.0124731865285204, 0.05155710706557659, 0.31814397782366177, -0.028003262133928227, 0.11078624873175612, 1.0344081586875638, 0.01473609303226754, 1.26500167591245, 0.3024971612257314, 1.0229245876763398},
    {0.9376490181573414, 0.851465950443388, 0.25266461801753254, 1.0199456523753403, 0.4020099880478055, 0.44931268106606853, 0.29349231186022706, 0.3833305118943623, 0.17751340175645064, -0.0907323837133149, -0.08954202443039626, 0.6291466724069326, -0.2789527231773878, 0.7820231723805845, 0.04591598987158383, 0.8759874758736632},
    {1.6444956313770023, 0.9774677922334288, -0.37830687675350166, 1.2471066541124456, 0.9115767166197604, 1.2522413559820025, -0.2404148975314592, 0.36494462198674865, -0.654645396441391, 0.1652234288025264, -0.02085371748630453, 0.7379302993382892, -0.14020840304589163, 0.7467330491202888, -0.28557372352338894, 0.9367413229808534},
    {0.8393900540811271, 0.9657220515865615, -0.05480310673762536, 0.9825462625163028, 0.8618786471293267, 0.8841094717856648, -0.33933641881403287, -0.24763793675151016, 0.015699272888285848, -0.12524935374630092, -0.04716816089079438, 0.7570879041793627, 0.055006142244683295, 1.563049381819731, -0.1919483568445202, 1.4277093655059567},
    {-0.13652375103437503, -0.14522395473028818, 0.03801649214969167, 0.06829105085720132, -0.29811157954822387, -0.2559054958513954, -0.07838084315767498, 0.49773741562157464, -0.12090472227023817, -0.2978811038048269, 0.03940557371620645, 0.11185010723316122, 0.28727978045720615, -0.04750497901443243, 0.27079525790365083, 0.0001634767232725576},
    {1.1627401318726123, 1.0130570338588423, -0.16985161194949452, 1.6657907381455876, 0.8457308162262978, 1.4308708079158685, -0.07074440911152664, -0.3467546908773191, -0.2758255734637241, -0.256044190136631, 0.3502617893345924, 1.028416061957671, 0.21791905794931157, 1.0458731052125796, 0.10732472104205226, 1.4258064879261922},
    {1.4701802946821614, 1.490066276249089, -0.27559167107467814, 1.5997567704420765, 1.1296755423087068, 0.9757017100136495, 0.049622120196726266, -0.3654710729743921, -0.2206893791292834, -0.11320915324924294, -0.3070367424324594, 0.8043957970936798, -0.23292886048604047, 1.5955537027764521, 0.07214136265279941, 1.1640492582829378},
    {1.2209345676422676, 1.3219154789861485, -0.04457445565104974, 1.5372009828933948, 1.2264487555127934, 1.1205178310819996, -0.037224924627996044, -0.13126596857732942, 0.0472092931456241, -0.11130240905410942, -0.13576831712662343, 0.7629798928159874, -0.23683473442237982, 1.028146797382213, 0.03171475588736367, 1.1601699951567392},
    {1.104010328709557, 0.635189150205553, 0.5467881379991087, 0.5051072765379228, 1.099177467015431, 0.7581441142818396, 0.03937004520525752, 0.011906885945594234, -0.49110802423666966, -0.2472326836164607, 0.19352426922388505, 1.200596261902773, 0.39305511987026076, 0.8735446264077295, -0.03156596162716553, 0.3811036409052789},
    {0.7599936981630148, 1.0101917875021476, -0.004756219309345652, 0.6434316203640101, 0.6270923682001195, 0.6239481015514983, 0.10642503045661988, -0.3030710264036657, -0.3260232264073145, 0.5841639928308549, 0.2997824407478416, 0.6327299815981998, 0.3255905077960912, 1.049638087302624, 0.3043459315359479, 0.5959483343388493},
    {0.9808456544701448, 1.2507784601883423, -0.21709374655924804, 1.2563470796879688, 1.2675506311373663, 1.4151624930914615, -0.39657002427933097, -0.289018103057918, -0.1904226767098755, -0.4895466645018534, -0.034750514646395635, 1.0096778022440758, -0.20453842867937327, 1.2899711863151369, 0.038904301977655036, 1.2879105873346743},
    {1.0127038942606847, 1.1052708483100777, 0.362792917345278, 1.0288733856432213, 1.3181575641679824, 1.1575368706484777, 0.17314101146363856, -0.06985640643234899, 0.442993553831292, -0.39406259635693985, 0.044243610121955344, 0.7752189531713807, 0.23163939629987704, 1.5535872974818457, -0.19325243954280838, 1.1183264285084422},
    {-0.22821757669890064, -0.3434596704489777, 0.3997340258709933, -0.15509554510786452, -0.04857864127837568, -0.290781805335035, 0.16152388779854565, 0.024344749014581314, -0.40764312489824545, -0.10711365441972819, 0.2046646382549767, 0.2812203319317364, -0.6268329862140708, -0.13753327919847289, 0.18308335927870542, 0.0928031315801858},
    {0.6462268470782941, 0.5544740741106986, 0.036829564397433234, 0.32949352681944727, 0.935261343623644, 0.8780586033051254, 0.2040542758358366, 0.06703983914080121, -0.059972610715384705, 0.08413496963158061, -0.2489062508858179, 0.7333509431257956, 0.23546248594570382, 0.5959928955907249, 0.4439482750055476, 0.9456028679813573},
    {-0.1984454515539287, 0.021810032190457837, -0.2918095358932305, 0.18935707478730504, -0.043712247768160024, -0.4139425771534711, 0.08167443919980706, -0.253427117534027, 0.4122340658016773, 0.44585316403477065, 0.18067014495879372, -0.1246187561222036, 0.022726839282811214, -0.23872242967395388, -0.2766356494415347, -0.1433798708096361}
};

static const float b3[16] = {0.7462323984362587, 0.7908289240381451, -0.03322837909465594, 0.7811450111863196, 0.6749390613983779, 0.7136341758300538, -0.0467246516350715, -0.026120999695223957, -0.043793069517104724, 0.06779760642295934, -0.06769608615909053, 0.45846662534748606, -0.029732238009715622, 0.7750479079558661, -0.026900860075253035, 0.7619921053324012};

static const float w4[16][12] = {
    {-1.0560516771566506, -0.6333242611094133, -1.0709680474933676, -0.7452519079632435, -0.7306437747906747, -1.1355326813844482, -0.8538626222745296, -0.5112166089601196, -0.9467042711099068, -0.7679991745693276, -0.8397033485122506, -1.1907402053151646},
    {-0.6341665103860727, -0.8854665021671891, -0.8266904765682196, -1.8063086759025293, -0.606820304283937, -1.0289998342829918, -0.8678356474344118, -1.1946779050619947, -1.9176466040319091, -1.356520135616916, -1.1413569684286458, -0.6737361383800673},
    {0.49681951072633634, -0.5457492006591013, -0.5375228253634121, -0.19381766097075115, -0.34504165751016186, 0.38077963326759573, 0.01800525697860679, -0.08652932020589285, 0.1326620084969451, 0.7732840155484887, 0.022547114152451093, -0.1820601832449244},
    {-0.8819752248918344, -1.2683035947445815, -1.2952587014619472, -0.798474082622529, -0.9822357081787138, -0.6467906306260998, -1.2408668932413716, -1.3697053874756273, -0.8116932692525309, -1.049457919215173, -0.9830310671426253, -0.36583376763312275},
    {-1.3934643847809196, -1.2250404366169585, -0.7754570039572787, -1.5788484508469876, -0.8034662487796244, -1.1805434954505865, -0.6247934748355839, -0.44078548975839127, -0.42966778374265185, -0.9656334470325841, -1.132724629086438, -0.10410916697514039},
    {-1.0288013498341129, -1.138407249698614, -1.0159514584853913, -0.9189753754389878, -1.1706099497370777, -0.8961672389458305, -1.0391613398324306, -1.3255918998089626, -0.7141269089550818, -0.8557495352370306, -0.6292265530077839, -1.6253195573852466},
    {0.2756497130343653, 0.2676860586261651, -0.1962378050297853, 0.13548591482487224, 0.35504408096576595, -0.35629638719325746, 0.5864189053937536, -0.2644306571517828, 0.11599669480820488, -0.05530183596666515, 0.15899060787176142, 0.49308195835372476},
    {-0.6369490875330847, 0.14761806027946853, -0.2398130762971832, 0.26316425876374044, 0.34377774203667305, -0.05624084088079009, -0.20933695815207673, -0.3393080901899927, 0.6005071902777278, 0.41526157684012954, 0.24546687957129237, 0.08286214090768605},
    {0.27072977093055944, -0.28868571461325454, -0.06963763677259173, -0.38701629345118316, -0.04124574142740881, 0.8048412631150673, 0.09454763090304019, 0.08296392506559697, -0.31974970783085827, 0.2774505128950781, 0.24692805641674892, -0.08004265969465997},
    {-0.2501728262594918, 0.03403702918735606, -0.7286665145689786, -0.2588652552539796, 0.04881815440943665, -0.3456424210748291, 0.3977557434487529, 0.1734495619436816, -0.343927812818293, -0.14709002941273452, -0.22340858230559962, -0.08386694136377511},
    {-0.16587979408442233, -0.2560942714477722, 0.32537562789744706, -0.021996049305298707, 0.2531056651132415, 0.034546255259587454, 0.1174251284933653, -0.25498174744660645, -0.021655815229586126, 0.4191240763469358, 0.4194154804171195, 0.18648905650045164},
    {-0.6472053406246643, -0.5470220664279841, -0.9316713720819809, -0.3495974620365799, -0.6461925971604815, -0.36665945239741626, -0.38642699491830723, -0.9218816927577608, -0.44247454971568967, -0.4882668059212921, -0.37523058827850525, -1.1999169551110687},
    {-0.39674019974823016, -0.40929435678021814, 0.23712459252011417, -0.15118851764175556, 0.42608730435981235, 0.16945653061646512, -0.07799387925414189, 0.6211197991133794, 0.3177667479453774, -0.24319077029481598, -0.2472578988234231, 0.13544172509675512},
    {-1.0268866580689635, -0.7269217862639666, -0.8983426218914009, -0.3990711737889937, -1.0206513858587136, -1.1456988601107068, -0.6067982567144852, -0.996336930019486, -1.266297430036843, -0.9971786536574382, -1.353152398587581, -1.2337480522671234},
    {0.246627460857197, 0.13867180947078578, -0.1441809694659234, -0.31055009576543396, -0.0839205386664717, -0.6281702398743638, 0.4261255002687529, 0.2364055057324463, 0.05534559984410897, -0.42068683646483224, 0.43051962834822627, 0.1908808171474887},
    {-0.6918995823493108, -0.9248848799595791, -0.5307480890310338, -0.8100763602963019, -1.3563610383886486, -0.864893408213951, -1.67122445001233, -0.5279498855170437, -0.6921106240777398, -0.8223339342616199, -0.7859379471725577, -0.9495107532446783}
};

static const float b4[12] = {-0.3038670908863693, -0.3036140869541549, -0.43812015045271985, -0.277736366287072, -0.3657164138967837, -0.30677102162026215, -0.26928886684156644, -0.4442642673763862, -0.32690044277410235, -0.26382413664197774, -0.24065935526121024, -0.2699219211386016};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
