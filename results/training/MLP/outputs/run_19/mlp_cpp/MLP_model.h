#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.8893176588903947, 0.29090155910865334, -3.3858421446510465, -3.3019899389436436, -4.691643649201112, -0.5689087004634593, -0.635593344243464, -1.5535832972735144, -4.50044320269091, -2.8788770853570225, -2.1019261682886947, -2.3246668067064764, -1.810458630751053, -0.9779714487699015, 0.1705206399609218, 1.6404747092475096, -2.3923481216466946, 0.6905155845515655, -3.0143734153882455, -2.852795847663671, -0.5513499595532916, -2.9789883353387903, -1.2364094107530124, 0.5552009051836361, 0.6631182341573834, -1.1298179599198555, -2.82836548067961, -3.3163711083373038, -0.19201359074169544, -4.267705028450105, -3.0738654987772835, 2.911367947146785},
    {-2.1154102351573933, 0.669613839398305, -2.917333040715778, 0.4194801472083648, 4.164629919330193, -1.0164582254563554, 0.342459752515928, 1.5434642585074183, 2.613013852395845, 1.0232069042134655, -0.8636949350091724, 0.13132128512980437, -0.07151994798780135, 0.4446584290399826, -1.3305691354716433, -1.6446526963610648, 2.0564248756019996, -1.1842558056190267, 2.0619869881959167, 1.9394215840432787, 0.6018747962535754, 0.03197429244068775, -2.0828182899975594, -1.1594469859413241, -0.9775790176486256, -2.0883073542827817, 1.9862385668064397, -0.22247732450852045, -2.5024476648958673, 2.3257807132740305, 2.4470274664767215, -0.4854763182919743},
    {-0.44240417638455765, 2.6449444616144406, 2.3104349755270057, 3.0269387011170696, 0.7957663093021347, 2.0493065992002095, -1.9216660637900649, -0.915038513751631, -1.2436337785930585, 2.065271577244136, 0.8271961550649772, -0.027046992943477084, -4.5389245682190005, 0.4493554655121425, -1.102231474886747, 1.5256423899296907, -0.3205222206764914, -1.4584730746685997, -0.0019177725249960196, 1.9029692635030941, -0.07215793697060627, -1.8091366585473514, 1.961910285167144, 0.4624734569506873, 2.236009434797698, -0.7692823520335214, 0.4001078887641872, 1.208721128990696, -1.5593130218081457, 0.6001368011035585, 4.102143430764444, 1.0369743864644247},
    {-1.4108817815268055, -1.4023895828715203, 2.705815926583976, 2.9063561445634916, -0.20069205254448325, 1.2683305319916847, -4.052015715301999, -3.700529020116962, -1.3632999079443522, 3.75745661142761, 2.3818077687216554, 1.5208946329734667, -0.21458115612730058, -1.8126569133980333, -2.6446230525016103, 2.1307673465810226, -1.1319184330600178, -2.699456026190042, 0.945332785669638, -2.964655937861606, -1.1827712121741687, -3.747589800752437, 0.11982264878369357, 1.6103116747635422, 0.6314678399090994, 2.6534992162032482, -3.226137896938457, -0.27706130582963073, -0.053173590910845704, -1.614028708559941, 0.4488135094339726, 1.689183052581612},
    {0.22923260766800826, 1.138906131733945, 2.1931355223547855, 4.2387209320034485, 4.12872784820326, 0.4092432785528455, -0.38613347587494506, 1.050268869241816, 1.2405663297944203, 3.119905883416874, 0.8632109972818267, 1.2804709181723117, -1.170816232225381, -1.1136829716161134, -1.2618628664996125, -0.6072245789731592, 5.4757652206588885, -1.5880652618192295, 1.4323034394802745, 1.029215139240312, 1.6441353463476633, 0.02237095507870436, -0.25046016305992574, 0.15254878617440887, 3.2836313821142546, -1.0305438318232478, 0.18862829445609405, 2.1287662873994497, -1.7513542426767108, 2.118772824593061, 1.2196351391446907, 3.275724136463486},
    {0.949542472517064, 0.5872714544793939, 6.443443692134398, 4.726629640265538, 1.9826077323827032, 2.1485007322459913, 2.1463400910258077, 2.441365272695591, 2.581903821492153, 3.121920356615814, 1.2882213107953104, 2.5894854229741373, 1.0099229479047511, 0.1537069493977869, -1.3639165109338476, -0.7818926804039845, 1.4638739384845176, 0.4975974083739366, -0.18747594403360074, 0.15350013564720574, 2.821977749677204, 1.0090305214890025, 0.3904305492595045, 0.037403623657789105, 1.96027524479407, 0.4306728015925115, -0.5958068026426339, 4.110628215609685, 1.513309648997977, 2.462963097165439, 3.0407153390300965, -0.5068989594349127},
    {1.3876899190804346, 1.0036510535174406, 3.9402164127185135, 2.210748530346807, 3.185662416527888, 1.5766232349195621, 1.8578382860794378, 2.297969261351751, 0.5150164617115663, 3.4099259041908043, 2.10812651693708, -0.07058364549212245, -0.11294415454990274, -0.0528100153541319, -1.1200073145809064, 1.0530040419545954, 0.49844584338761316, 0.1557178757953815, 0.8604117067046301, -0.05125230215280153, 2.6539322436266737, 3.8863453028454114, 1.7425430775975155, 3.7390501178660225, 0.7071432551008524, 0.5988896002816548, 1.547294940542782, 3.04694925416111, 1.0613278377517674, 1.8861620259737768, 2.6948129962762706, 0.05688126072617274},
    {-1.386542271514171, 0.04253517550217075, 1.765459559763515, 3.160843655088296, 2.4928973911295373, -1.5585922898630105, -2.5814700557034636, 1.9790106092529958, 1.2165833479639605, 2.7645206993430698, 0.22334982783717655, 0.09326254173924278, -1.431486310372479, -0.21498572272380226, 1.285082986732465, 0.433583246475254, 1.9647120427904547, 0.4230559562757637, -0.05211366732019115, 0.8408018626941695, 0.2579832775698886, 0.5883483877701086, 0.6191533970423494, -2.724094947445384, 2.3254966610269587, -0.24678668935165293, 1.3209808368370888, 1.3732383196291311, 0.8299238728076886, -0.2224290717437044, 0.7432739763223165, -0.16406236761492696},
    {-1.1833374246378734, 0.9844752379683732, -0.9236978032173785, 0.7249935077348335, 1.82088333066151, 0.006946582725677583, -1.2497805180829515, -0.6836263910810043, 0.7337089963212264, 0.1596907352424608, 1.0116517365884237, 0.33023149162066207, -0.8769776784775236, -0.15599961771728524, 0.07624260726946683, 1.0395851757319874, 0.09751343831074795, -2.1601107066938283, 0.9851729963064243, 0.18926710206715336, -0.7019029469902374, 1.4879155203106378, 2.915710915220562, 0.4593130423930014, 0.37416300180728207, -1.0313468381397182, 0.43984620161211213, -1.451695022102782, -1.157518254240354, 1.1817868649111085, 0.015498612252728838, -0.2737857080061956},
    {1.3861277587560776, 2.4851409288549084, -2.3589739881068517, -0.9675402739008195, 0.2087662001916143, 2.0108675495620747, -1.7278574452164561, 0.9229758156462173, 2.9596168700785173, 0.6561199129493102, 0.16827545874747388, 2.6568070735639977, 1.3066301922367165, -0.036693153141656845, 1.7258821865479765, 1.499362918461527, 0.7240836873284066, 1.0925655007117747, 3.7704732539359993, 2.1414639683400405, -2.333829881490332, 3.740137815175043, 1.4001270156199406, 0.13125030007088725, -3.557689666811599, 0.659281309565375, 2.442881930003092, 2.4374212315232713, -0.5535291293463127, 1.0276175527229665, 0.6956325582446736, -0.894159050226689},
    {2.4226128463389185, 1.9049441982539974, 0.032820281035815656, 1.3016858260471253, 1.619521084518985, -0.0876500155137378, -2.5214814277010023, -0.13199090271341898, 1.2329135685918904, -0.7760888598362982, 0.49465899601204766, -3.2273693972779935, 2.8701370761842546, 0.008285766328812083, 2.5355751307791863, 0.4408316705070907, 0.06677612099208116, -1.4547923579577406, 1.4549352850072217, -1.6632109951877752, 0.9597153211046138, 2.06810246164259, -1.2596859538164396, 1.9927269799406844, 0.21004625554370107, 1.4411690935075854, 0.26900240521752616, 3.3413080127349963, -1.954444344668719, 1.4917409598937668, 1.1593304352423102, 0.3580152406239568},
    {0.21887893679562742, -1.2684074588551184, -2.6859656004891073, 1.1858892533620218, -0.8061528847414258, -0.488608942090543, 0.5769214603980051, -1.9505194829186352, 0.8968652307421554, 0.7422643682301268, 0.584952620628024, -0.627029688130591, -0.20623830984616912, 0.9468502411382549, 2.1131621393478297, 1.8298354853458076, 0.5921337072204219, 2.371925014555469, -1.2094821350790292, 0.3522466927806119, -2.3971042836478342, -2.1889070262486747, 1.9993243486834815, -0.5073607720856581, -0.11458575984345051, -1.0116551607122637, -1.621923582787176, -2.163173628183541, -2.410894578466049, 0.5861285470097214, -1.443195996819006, 0.39698039932421664},
    {-0.4145297448118452, 3.478793067216803, -1.2347598410522065, -2.2633468285654357, 2.239574903483035, 1.5320959696753087, 0.8943341963729285, 0.20151876683488856, 1.9035824667971122, -0.9100369024524773, 0.7514171237520297, -2.7049164346745234, -0.9068947482645272, 2.2736109068459665, -0.8759580737986007, -0.6769098568579909, 2.5407373800605906, 0.6640363232629021, 1.9868803384105196, -0.4251436171041486, 5.190842105770261, 0.7853157692724703, 0.9827498407861532, 0.8471940359939826, 0.883547931571718, -2.427755365614905, 2.341031320999059, 2.3320241188210318, -0.4463447801421968, 0.713956629326545, -0.03033238450794124, -0.8546540129996255},
    {1.1422023015945533, -3.361332613328969, 1.439676419785829, 2.1033589665717995, 0.6714140654797407, 0.6451221664340863, 1.6403885602932826, -0.9256886016206979, 1.4877926634121195, 3.0667493216452795, 1.592065535741917, -1.3230161981140771, 1.3664914917478899, -0.5944733308983239, 2.228797903852379, 0.4902208343211024, -1.0665779230094885, 1.696324486930701, 2.66204030035658, -0.552739978750219, -0.09634648153576866, 3.541585480022141, -0.9269754204812648, 2.2046917781659445, -0.7233913057060798, 1.6830482660032438, -0.35892963220145224, -2.3265777366641816, 2.041649724238815, 1.0484621565394419, 1.245664355453522, 0.8585549675837658},
    {1.9525172116073446, -3.431687156721297, 2.895935556970685, 1.3924923935405875, -1.2422507209957117, -0.8653846412529657, 1.6544445720655259, -3.3347110296100517, -1.9163085339261814, -0.34592295857235855, 2.576790935536578, 1.0819527946569008, 1.4709389154833339, -1.072742922171216, -0.13846665474177294, 0.8144596238482419, 0.12065146178096366, 1.1785959072659358, -0.8645755456051983, -1.3707792377432675, 0.03563297226732115, -1.4604209108835342, -0.9006344610168997, 0.7098947481023102, 0.7967123601857878, 0.6738463870876525, -1.0957495290273358, -0.4600516436980247, 2.0298044378385005, -0.7577591997128025, -1.4527356650002565, -0.9878617653703018},
    {1.7077739683331703, -2.485531951747146, 0.23194012922603072, -1.0593490941274846, 0.8708790101710305, -0.7161128680502759, 3.7931104487680325, 2.5679861572664593, 1.0877428228864352, 0.6604897886241923, 1.636862848599751, -0.9675054091988273, 1.1050828608536547, 0.8516479976228767, 1.5413978309920227, 0.20963821336416022, -0.11301139926491453, 1.3331172672399, 2.420804119335452, -1.9981428553827685, -2.0949937700044114, 0.16625121013306465, -1.20439448485851, -1.8765745932359057, 0.6113250508664453, -0.43118163900522727, 0.7057643589949749, -2.5845545034102986, 1.7055583679584818, -0.722048460461955, -2.6120469781256253, -0.029851770883571233},
    {2.2775544570405133, -3.4226275714099783, 3.0655445972411894, 2.8597756190216086, 1.3170945135933705, 1.55743357796881, 1.3250567156402884, -0.017370945596450416, 0.12523388206337083, 4.1254661929797365, 2.2822730615352214, -0.64680989947256, 2.3765712872035802, -1.2577599174876726, 1.1652045824372796, 2.256705897045955, 1.9683591664210227, -0.9487825499403119, 1.6154629567073238, 0.4591597981193292, 1.7401609510462965, 3.113299685690595, -0.08383006449716073, 0.6243911449453472, -0.20538618358284957, 5.175302621872788, -2.641571983774889, 0.22835082131687817, 1.4976025652115899, 0.4617422875178285, 0.5360215040011727, -0.24752268037749034},
    {2.703235025940164, -1.0423748115962506, 2.8910696401112714, 1.0708061969607963, 2.265975558506921, 2.2970995496044133, 1.3571390264442618, -0.7729096327069391, -0.9249072471742091, 0.729999582878771, 1.3763023229932554, -0.3154146246612794, 3.5231323414480613, -2.1071339182513307, 2.2578328920832003, -1.219637687957266, 0.20392007226128323, -0.5787405818971475, 1.1173047886397125, -0.7256931529444681, -1.816950234636945, 1.135542460938257, 0.7874191541308379, 1.3487311232752224, -0.6500696220015687, 0.31205779841798753, -0.27882567705635797, 3.3707721353481026, 1.945634288164854, -1.038238248043875, -0.29683012295244776, -1.0950885468746276},
    {2.153262027764744, -5.018981482037125, 1.4378308519865872, 1.9416601735189396, -0.19838734847464135, 2.559094533547109, 0.6939193797422907, 1.421926000479529, -1.1331318507938801, -0.19491170530464177, 0.4848090353915454, -1.8649001257514515, -0.30110166226259893, -2.6141674867075015, 1.193993797572054, 1.8119935603160595, 0.6275569044974839, -2.9528240626481015, 1.3435128692652705, 2.55215506666939, 1.618855467910687, -0.08395116607774145, 1.9100915100862847, -1.962628194153143, 0.3496113671351209, -0.8337399068001002, -2.138223272438602, -0.8816508082628025, -0.044837371957538015, -2.673308494171028, 0.7661854344735399, -1.2259882070438393},
    {0.6904139647806214, -1.2004041257843805, 1.3205423842242021, 1.630658565952812, -1.6048515881621133, 1.6147182380703153, -1.661306280727899, 0.38814234365752687, -1.131532579129495, 1.2253453519591884, 0.7258462336857562, 1.3499177988683049, 2.000793907872748, 0.05140574261577353, 2.127801261293775, -0.8781847059489313, -2.89229651568716, -0.001509665351318854, 0.1155201788225709, 0.5111045806704663, -0.4386296546598721, 1.845147179268829, 0.9447710249596589, 1.5637550815320427, -0.46601164342708135, -0.9568944348994347, -1.9845995891187542, 0.5148902377289496, -0.5739108953897838, -2.7141309336661137, -1.604297489733184, -0.11870149539865382},
    {2.13597235275885, -1.6233969017111842, 2.99108723506697, 0.5191772238183151, -3.068307935121278, -1.6142997461610524, -0.03671917597991951, -0.6078236196423238, -0.0003627288875557275, 1.1156000882805706, -0.16593914136467777, -1.9396182623971767, 2.1873741406461935, -2.4970377147272247, -0.028194163541734842, -2.074526152021298, -1.4328689968599195, 1.46570381087704, -0.5602980061405547, -2.21744364144597, 0.5956295234287701, -2.601346480960868, -1.1313221839915524, 1.5188311219112312, -1.2489055378102945, 2.545279373727304, -0.8628344269371047, -0.37388842408158934, 1.2230543297539092, 0.14819745804487747, -0.7989682321287745, 1.232584911730901},
    {0.14157269011164436, -2.381947820183171, 2.046065853359391, 1.1652026411494716, 1.6315173511140262, -0.1905562248487927, -2.42478686272307, -0.2843321736008622, -0.817762137198724, -0.5998454336585364, 0.25689293697231225, 0.28505131928005484, 2.5807933994676384, -0.5549914737659983, 3.47692258011088, 0.24408403589676766, -0.08221546208299414, -0.4722715921058554, 2.847649145255059, 1.5132443532704916, -1.067666943483946, -1.38152110532534, -3.3804407786259425, 1.1795654500822788, 0.39970116969020747, 1.6184848803807135, 0.442181736369576, -0.7762275059341541, 2.211981290418194, -0.7848223682454282, 1.6677195648466665, 1.4005164882431234},
    {0.17278841105925094, -3.7222845435501233, 1.1483843327761836, -0.44857176166083346, 0.023455840635270637, 2.8603735908755854, 1.382440000853505, -0.23183711674064905, -3.2190601296060346, -1.0439267784644353, 2.7203386306612307, -2.224823506855171, 1.574202181503532, -3.40032424104987, 0.22846267146714194, -1.1856174650036897, -0.7781409317757704, -0.1704272759275762, -0.21975397594018814, -1.096143963022914, -1.6602375515879881, -3.5480645853585875, 0.39469300492277803, 1.0861233903201548, -1.9008082799315944, 0.7899451794512989, -0.03618685100042924, -1.9978891400278864, 3.4009160315580726, -0.2604336724287209, -0.8287504702784473, -0.32297744387654015},
    {0.26854378562981746, -0.010849857562915271, -1.2610066113199705, -2.365450153878369, -1.0130682372391957, 0.288691760075479, -0.24407800767434834, -2.121116481815646, -2.516109483065814, -1.6623151202161273, -2.89897394309247, 0.3477089391764022, 2.0996470457361873, -3.581693762034194, 1.0754303215498342, -0.37885745535684495, 4.002667659427016, -1.2149605131105101, 2.5225179783783647, -0.006203060929717367, -0.47167203245156814, -2.1136275707305536, -2.1505033204007376, -0.05914331976705367, -1.5090301360234804, 0.9228383324119418, 0.7691478721940893, -3.3429801326566206, -1.674563550414271, -0.15560769088659232, 0.36842007462055243, 1.9420460605251184},
    {1.2447439733534995, 0.2764294063507943, 1.1875641481826074, 1.262702658652656, -0.2421603292755824, 2.426912456185038, -1.1598267589655697, -2.1963727891398985, -0.04073838181077913, -0.5668372014153334, -0.9080342007552604, 0.1598878394816537, 0.9151597061176415, -3.6691537057724943, 2.1419270539279154, -1.6894765014952813, 0.6683915276015416, -1.3813057760533987, 2.1853835001299355, -0.2288710407163218, -2.324215329527687, 1.1258548872028407, -1.626814372253579, 2.5539784771576413, 0.5801973721371205, 0.0037964503831695025, 0.013167929516696061, 0.9477392229041101, 0.07360013396712543, -0.83234034834746, 2.2388805031014183, 1.3615675553063535},
    {0.6128948875998506, 2.5226232380159237, -0.6359086786414488, -1.0503217835729275, -1.9166246080358729, 0.4425229148356651, -2.1877392217597977, -2.1501417671962, -0.8709103788159166, 0.5421545080237249, -2.0165277636604118, -0.7253255548099933, -0.9294919375856887, -3.088430813612788, 1.605663970821829, 0.04483713379797579, -3.6601575064827547, -0.04776186966695189, -1.2665350850093513, -0.622334600259568, 1.5308232471198842, -2.0173053485415195, -0.9828806391098314, 4.022653039865879, -2.2467354517050278, 1.674169365183148, -2.239651228031659, -1.0168519350998229, 0.919673990492788, -1.3092607550203328, 1.331823307733269, 3.2889888404877867},
    {2.3692418667955706, -2.2868498573297846, -1.0999473909822457, -0.8947756401566875, -3.192976490015657, -0.3208501526230612, 0.020187731928933157, -1.7943332147159712, -4.534155577510066, -0.31940884301066674, -0.2015107233410918, -2.2301877935955816, 0.49528933397434205, -1.041738998066407, -0.16646034000151907, 0.48488997780859305, -1.0985607647403288, -0.2666734214408158, -0.6783264981039996, -0.09514368966298278, -1.380434757412556, -2.020680673905131, -1.6084336424007804, 2.2910384225368627, -2.519013233379527, 1.8576919670779741, -3.0767588504676175, -3.359372422280137, 1.548451775340346, 0.3520628603382687, -1.5121833565485554, 0.6651690317392093},
    {1.9968563492004394, 4.181736273203938, 1.144233206578278, -0.44669554324693056, -0.8164412500923915, 0.4526049047391205, -1.5025151792342304, -0.8601779901095512, 0.09547152175361422, 1.3988077373074792, 0.17390817236368267, 0.7128963537315717, 0.8693721754824533, -1.27122894719979, -3.5150734520117783, -1.5740007581515707, -1.4948727852266077, -0.49079496202538087, 0.8849754925926608, 1.0907508848712104, -0.8691669393953478, -0.23360387213130554, -0.305014218156958, 2.5923254229398935, 1.227177569663414, -1.4887999476055676, -1.468545753946724, 0.21875214497539364, -0.7410946390316745, 0.2200885903208065, 2.21255527795072, 1.844987307701258},
    {0.9204878816239996, -2.3637692438831066, 2.5613594413278533, 1.0675006746035587, -0.4365770301595091, -1.0696702111963148, -2.5981741666546934, -0.9568579664354766, -1.5698003967357859, 1.1666048642941045, -0.7669062868415021, -1.308074872633193, 3.4481426704374663, -4.587861905330673, -0.20981519181410516, -0.4949131686050209, -2.2057973126367365, 0.6823217323216807, -1.047757383283609, 0.4143532272773115, 0.6073606375322267, 1.2729570431206645, -2.09832279669514, 2.50380416830224, -1.2154029544098897, 0.16709527004415395, -3.705859297886961, -1.5678261729934078, 0.3506446047522923, -0.5162088021287886, 0.7084113306036656, 1.5826788242377587},
    {1.7230779041255568, -0.402572899450246, 1.6882953514601504, 3.2246739635384984, -0.9207708575316372, 0.9658102357262621, 0.21383305143183967, -2.5801338926447297, -0.2715294025403151, 1.7598028332040734, -1.0551097588618676, -2.582723436058651, 0.8152878939564033, -0.49271338824024624, -1.4744119427092781, -0.7558778434189509, -0.9699037341450261, -2.3755594856282998, 0.8449528911250185, 1.3038820518902527, -1.7817849621276072, -1.3198921644434636, -0.133537888468084, -0.5693500644868301, -0.5041069459171521, -0.44977439977637546, -1.1879142618420941, -1.478848378260462, 2.3946781765757676, 1.5104592300802533, 0.1249663392029493, -0.04889804367204125},
    {0.7125423394119736, -0.7553515379184715, -1.1611228452744893, -2.6984143279982162, -4.744514548888811, 1.53333848811529, 0.5982612949940088, -2.5535747224597953, -4.283491104556181, -0.977784991364318, 1.8771963450838067, -0.4024040893334432, 0.12172262744090015, -2.203005653268488, -1.4337547591945834, -0.49380833180330225, -4.266449418491027, 0.9007283050000372, -3.6013927764518106, -1.9562553662906998, 2.2599748985526165, 1.3688703024882, -2.6780597392115726, 0.3870126849199634, 2.9496090418126992, 0.021072181666039025, -3.7583521718643897, -0.29488091136348255, -1.679230159303695, -4.415834895473802, -2.595645779195897, 2.390448182892828},
    {0.47737840428871686, -0.6153499784514888, -0.2132767486286098, -1.1067948474637637, -4.235043478598118, -1.5263970055973577, -1.0407400455794333, -4.39545367882442, -3.2941683418223064, -1.7903866196806024, -1.9301193134326031, -3.7326068081020565, -1.9879945961897412, -0.7911108451578148, 1.3097376204285838, -1.412163346709248, -5.562923105018554, 0.38287508290210187, -2.0905444221338465, -3.527302143934756, -2.3154832916959562, -2.388416359260013, -0.14623811096669312, 2.919094778168627, 0.7837426763876288, -1.546452715116042, -2.699971366894247, 0.14024479029473302, -1.1416591927635416, -3.461945174687733, -2.8958308292527275, -1.246216587407928},
    {1.7382503233657904, -2.36248178835458, -0.8185632229232944, -2.5754386740037205, 0.08419770856274249, -1.315142174482325, -2.5763885505677075, -1.014018558409908, -2.1656745701227624, 0.29786274441058974, 1.0810491000225282, -0.35948089683115353, 0.051720183756792576, 0.9906027394399449, 3.0235992599283525, 0.46047587533568296, -2.776454553696589, 0.7785308898875174, -1.6196963205016874, 0.33742787370231625, 0.09991738188634795, -0.5351213882765873, -0.7120801015531194, -1.2293528364164217, 0.6021859695423838, -0.25430973691945225, -2.1231427859344274, 1.6494209829409652, -2.986364487052447, -2.245542201885906, -2.21780287059942, 1.2979309787398885},
    {0.15509205886781813, 0.07918067729767886, -1.1071431187093905, -0.9086135578961941, -1.817516672516282, -0.5590849788397961, -1.4311126379499965, -0.10564751476925162, -1.9690185909634552, -1.8435990193522669, 1.6188173524427194, 2.3539630745201325, -1.1939627288491077, -1.9635704279681483, 1.712157094879153, -0.41563462926646466, -3.873893007606468, -0.8076843949141733, -3.8892550486489954, 0.22821514590571976, -0.6706379335861451, 2.2723156562162323, 0.728059855405815, -2.338306007831231, 1.4153022550028664, -0.6860086418615299, -0.9177983564288492, 0.5650477792083929, -2.2714748262265223, -0.6867531324609926, -2.392713230786838, -0.951322328220549},
    {-0.4006524833409056, -1.7433403832345356, 0.5188501023958162, -1.817577562232565, 0.06325404415137677, 0.3329072373634539, -0.21510176545594703, 0.006934851582950706, -1.1694941043520566, -2.3640814202314044, -2.19685268065885, -0.101007151737369, 1.6119909875726508, -1.4635976408999405, 2.4202231740279863, -0.3021722874843349, -1.8120988243021159, -0.3098823485933974, -2.1920973907393884, -2.0252900171631825, 0.9790784168348323, 0.9969999313446151, 0.9535391098615863, 1.7086512102382692, -2.942967266363269, -2.801165340613515, -0.6723211072423868, 2.5091496165962264, -1.6709556202019993, 0.626715899367982, 0.2507622047029102, 3.9645171999548814},
    {0.9468672583015142, -0.6213000119165234, -1.36902064433591, -0.4673293761288524, -0.6692465316460775, -1.9451006875367998, -0.9074231906250809, -0.35872349771800216, -0.5901015079943477, -0.5724050112634156, -1.6793152052464269, 0.9472915776397295, -1.2383219755304433, 0.6015819002480823, -0.2645948218656294, 0.7840440499532412, 0.9235292465714577, -0.03349756685434963, -2.761526773732479, -3.1158996325796657, 1.4700980262679963, 0.8173672271003202, -0.4656000540990493, 0.8102843377288586, 1.115553981159395, -1.3867392180213252, -2.386957999755456, 0.5367514675898862, -0.4871949536646595, 0.05861288533612294, -2.020682413211504, 0.16314200110855318},
    {3.407583473462253, -0.02729727953311505, -0.5373354234912913, -0.3464018792502936, -0.7628325941069385, 0.9723559800296083, -0.16033120868502354, -2.089351396633864, -1.045654495230613, -0.9942443701318493, -0.014454373935626066, -1.8982050675418705, -0.3944954188973679, -0.7182577031112503, 0.5449038815995726, -2.298777383519922, -3.039962860445145, -3.4218626617062466, -3.092336197721751, -0.9676909791129682, -0.8367601651280678, 1.8664620935537006, -1.536395324309111, 0.6499512061802326, -2.4080110424266192, -0.4654192953585786, -0.3289376759934026, -1.9806487201571832, 4.115256997533349, -3.3121055040530627, -0.3814238229832903, -2.235491706508893},
    {1.9748258101622476, -2.1710201226564587, 0.9998924815259317, 1.387729714844473, -3.1673568868839577, -0.19252169119488688, -0.8900324047829635, 0.5715275237548877, 0.45135971257060936, -1.4819205093505678, 0.721247725044677, -1.9204148751710364, 2.852802755481268, 0.1598593606151474, -0.9356733468592973, 1.5635916883484353, -0.1481302041288954, -0.3537860894155586, -1.4455894516578678, -2.5305022391465033, -1.4214031601755415, -3.3630365661675476, -0.6582914924917121, 0.566954769073594, -0.8699693812224302, 2.321505055880518, 0.3836223190629898, -1.2526673444355718, 2.377224845335847, -2.250015178131313, -1.5269141374663362, 2.165287320962704},
    {1.1348346866399746, -1.168045841632575, -0.24680396007898392, 1.8805039342153977, -0.3081518226659247, -0.35955481005907197, -0.5874361925978974, -2.014461755613298, 1.2529673829785228, -0.14764652577437515, 0.7123535433933151, -2.057854634040435, 0.18544792018653886, -2.3780803789064, -0.9256366576013522, 1.3375395384764874, -3.7111169675855464, -0.23037893488016195, -0.308505843750795, -0.4978737816360268, -0.33590116945809584, -0.7100861982051914, 0.8422729724619092, -0.8986845164191561, -0.6839023686816815, 2.4352006898258756, -1.6924489139973542, -0.3752947560832532, 1.3496746344140795, 0.1934281026602312, 0.27506473610727916, 1.8670808245205786},
    {1.1495167182647974, -2.0601329840884013, -1.1878446088780394, -0.7735391881401755, 2.5707358074242155, 0.6247978176074486, 1.9767746884372828, -2.5050424654520382, 2.2213808569145357, -1.8852703820140793, 1.5799434741198704, -0.2243556432114482, -1.0275556733272497, 0.8531484728671366, -1.2013708921870365, -1.6748717818811534, 1.7535062661846135, -0.5084903962032828, -0.016669095459837236, 0.2405424242969657, -1.5935337310696631, 0.796127473162781, 1.8809904442296344, -1.8132487950162566, -2.413825289260153, 0.4496231532326181, 0.1144103815998303, -0.07490656650143929, -0.5508276917567072, 0.8930110925314124, -0.14638694565511928, -2.107363700946437},
    {0.5176421974366369, 1.9743487906236026, 1.0238858565090685, 0.7046147066990098, -1.144370581879262, 0.7815293157556367, -0.3844184410575605, -1.4919309718642142, -0.9826224134674307, 0.02210039725249544, 0.4405607925795749, 1.5573962681820097, 1.0130271647569982, 0.04025912578983527, 0.5222648809529225, -1.0638287661814094, -0.43151034952507267, 3.2377975203938463, -1.3542275330246742, -0.37011183504795236, -1.7516603299279105, -1.7921124811549107, -4.277287996788149, -0.7888692433259051, -0.012850059165243613, 0.006175869192762964, -0.2831704896834886, 1.1446204259186519, 0.4376701668540016, 0.9444486420751897, -2.06000329902685, -0.06257369129374936},
    {-0.6772978457859057, 2.7886100709409445, 0.4806149393690819, 1.3598706024269318, 0.33436510737161657, 0.31733970594066124, -4.1092720958726705, 1.0781086304064242, 1.6475424611337472, -0.8073510547034768, 1.183412182929431, -1.8206149830559566, 1.326816348318374, 2.4055014459529924, -0.38482727444202985, 1.257280249387155, -0.6440229134332327, -1.2127110115638693, 1.7530342265972514, 1.4803554829894836, -0.8279591095135741, 0.9176090372867967, -0.5965214479328237, 0.6615416007859828, 1.3440996006379982, 0.36652481116806745, -0.23413130974950272, 1.2193456820543267, -1.6554906069015987, 1.1545281499879516, 1.7066778035354784, -0.6685902283038776},
    {2.8819190631110696, -1.4612992897219264, -0.3504544116670265, 1.8473787525072682, 3.2588162818670363, 3.144628090666981, 1.9284317492332816, -0.1393739431742931, -1.8639285821774345, -0.04709361947947542, 0.8728479808879938, 1.262162279440683, 0.8199319092839397, -0.9791049108602975, -1.8041772395020557, 0.9281862978671199, -0.5112421460755094, 0.4168536049300884, -1.5835026535275827, 1.336689131169134, 1.2580110592678821, 2.455677179525987, -0.906390824563536, -1.0485270982679287, -0.2111582879103218, -2.2431149144303864, 1.1415937385175206, 0.9336936300044799, 1.4325168590063762, -2.231344667675204, 0.5617590500869462, 1.280424249003076},
    {1.5061167995900595, -2.397347301069976, -1.107741851538489, -1.1043389617636374, 0.16043867858318434, -0.26468079867819316, -0.0015958238815665217, 0.7275211936835374, 1.0191690394008348, -1.9709291842199919, -1.5610942861812735, -1.4973581579811244, -0.4140644543315186, -0.34581430286055154, 0.534760355371825, 2.037839111615736, -1.5272105876033586, -0.8296093244122347, -0.2474455905254248, -1.1655965234651875, -1.6422740275419418, -1.2179657517010838, -0.7677004194440263, -0.12868172716504148, -0.5130807025762897, -0.9753538862027881, 0.08617510357122747, -0.6602330562358666, -0.6070282379428548, 0.1908385498254007, -1.2942469476521496, -0.2799154426177759},
    {0.03637914546567297, 2.576467911747882, 1.3239270678955326, -0.2670131634952882, 1.8387570355305054, -1.5063620508775952, -1.658167321088968, 1.4956613834451788, 0.6780752715527064, 1.2521072981336352, 0.9657301261293917, 0.38231319340148473, -1.3627382435430602, -0.8331179232761292, 1.2467197463605297, 1.3575113874426745, 2.7353104391411995, 1.0725594906874778, 1.2085374747031632, 0.656741159763565, 1.0228333076631535, -1.6138573235778528, 0.16288928722420767, -2.5510770876108104, 1.637715956599202, -0.212280267869615, -0.3422283292710093, -0.40993729478936586, -2.475503153502664, 2.130032662026542, -3.8946235847076855, 0.3509443700736075},
    {0.5251784926977492, -1.4182950890284107, 0.42496513032475836, 0.6654815795152913, 1.4611132536368658, -0.2841789864472473, 1.1613438281646642, -1.1718086082828147, 2.4917254981746795, 0.2538460957135405, 1.0542423193303403, -2.913626982276006, 0.74500705231042, -0.7073784952868312, 1.1959348195220854, -3.2298963887309355, 0.7619900098518846, -2.8300878742607214, 2.1261042404283508, -2.101096449869125, -1.2266835820825126, 1.9643778444324815, 0.45659811032426245, -0.9894349458423146, -0.24821389098835805, -1.1904756837734667, -1.463857457247501, -1.3645975629194993, -3.328644714535462, 0.6173510078324972, 0.05557843138599971, 0.15458601993680904},
    {-1.2816471306445254, 0.7678703320273834, 1.6284825814670068, 1.9316350911341333, -0.05448590098701447, -2.038942163156139, -0.8181175971539246, -1.9060439942047513, -0.7737814212756954, 2.573824148282802, -2.134708903529779, -0.4892012480042429, 0.33618281123228594, -1.1913566057799796, 0.14187749123528265, 1.5161764513017029, -1.450242564992199, -1.1195067292455372, 0.44142035943132163, 0.3767168254053458, -2.346052803456183, -0.2628142106400456, -0.2995450530956468, 0.7127803559340452, 1.1250030312248238, 0.341730263203178, 0.8187075689697575, 2.381955814407749, 0.5457201346254481, -1.2604398034881668, -0.09179014806841282, -2.0121462212831025},
    {-0.09294517344599254, 2.5650108407179704, 1.1567866794211608, 2.1077179729002773, 0.12202747270971345, 0.8422194631105937, -1.455393539439215, 0.23912286313972506, 0.7817771387252801, -1.7756569042433572, 0.9146337638306244, -2.8450427142908636, -1.718986668118325, 2.3017575175729394, 1.1438582779213537, -1.4925156928105134, 0.128349826216379, 0.010541313568682108, 0.5446419857805409, -1.2279474596981959, -2.2115557727817245, -0.9177963196678016, -0.5943643335416124, -0.07442743634849391, -0.1197259550073964, -0.6139577217864662, -1.0674480618517608, -0.21033784719305357, -3.0302498119365664, 0.32927521792779296, 2.1133349989530887, -0.6115381366970685},
    {-0.3850390521819245, -0.4297538993955747, 0.03965998946960277, -2.4113586096017148, 0.3169269147746024, 1.8080056190796656, -1.4558352452468122, 1.3516075982129945, 0.5168716596046066, 1.1356872959924194, -1.5848522514820012, 0.7900497221154564, 0.43462035567577273, 0.6766787551190105, 2.6886038849886553, 1.9535419294297127, 2.2666361832520936, -0.8578217999333863, -1.7199020936363454, -1.0335239288943037, -1.3210646445987295, -2.5258016615016463, 2.592516628579584, -2.028233338153214, -0.68434167915352, -0.8967692072909497, 0.22958495830173187, -1.0563936320995095, -0.1612319707371482, -1.3708399644235696, 1.349755335155499, 0.6771718964144857},
    {-0.9052597843262707, 0.26357198018505684, -1.5988271409759953, -0.4961021114395004, -1.6007834940846137, 0.5345809851195551, -0.08014604547902683, 0.4346148641896742, -0.5671834733517667, 1.51431040496053, -0.9852253722555276, -0.6396693567228638, 0.5496647435171266, 0.8456565524241275, 0.4695239662933695, -2.412617013050279, -1.03393266832221, -0.4507591375176552, -0.3972265199523679, -1.3586759516708604, -0.7963967886357505, -0.5206151639984893, -0.6268928481034505, -0.9205702972343998, -1.1349154010091793, -3.418812541430207, -1.0513397849028188, 0.6068983309398437, -0.6317599539869039, 0.5058466780687261, -0.5224948504695671, 1.5549238613592358},
    {-1.5776609026608854, -0.6516390693447669, 1.739774898575585, 2.436779645504749, 0.16633127931578465, -3.2914515760310477, -2.5029945567402776, -1.8469173312842222, 0.5158928434565637, 0.18404155628765528, -0.4704522353495088, 3.3865817755606584, -2.560287880406204, 1.7367644613953401, -0.6445374381504586, -0.7929550759759155, -1.2791775463402044, -1.814500676624159, -0.9820325705812254, -0.31603151605754726, 1.4459038542914002, -0.5725794609872487, -1.550879239846169, -0.07994768153022515, 1.9363514427605484, 1.2111095310238418, 1.4786483637654186, -0.3163093977125936, -2.43383346835996, 1.485260725280501, 1.4690789035905931, -3.728814469637617},
    {-2.475490014077401, -1.9628533486672946, 0.6185336808104395, 1.226593872775699, 0.47196901829774346, -1.4971920338872398, 0.6645149572800519, 0.8593021092561697, 2.62423056414359, 0.1968403519044244, 0.5168250493789719, -0.18883231642529807, -0.3376788413767912, 0.040795488109574604, -0.9407643061019249, -0.7599005736121418, 1.4785619265316627, -0.24352955655958897, 0.9087246637299143, 0.3376924176217281, -0.14908715700743955, -0.40373133073960643, -0.5578627810646134, 0.1213288056944864, 0.3555546165142702, 0.13924789366912552, -0.6702642446070284, 1.0104473320617764, -1.3993109838170248, -1.891946666249031, -3.249647965316256, 1.502539051025187},
    {2.2019072101816506, 0.161733491005428, 1.0552804147671087, 0.08688666775266042, -1.4627800204536925, -2.2604045744744163, -0.6772089414593857, -1.0063360884050836, -1.9800412856202654, -0.2051837501051535, 0.48945376043278993, -1.5257878778058132, 1.261311886929856, 1.211995213212206, 1.1192012979360133, 0.615728040697062, -1.795317799240039, -1.492421939601949, -2.2324024478645166, -4.663164812466482, -0.19440477523659935, -0.5976059978644483, 0.7129504328872391, 0.5245452661840391, -1.9315299881168042, 1.228601226113954, 0.8640950733857334, -0.9861293302779002, 0.034109237855647415, 1.6716804156620604, 0.7019748204109781, -0.6386910429265558},
    {-0.25621043790199144, 0.5757244808200519, 0.23311148706271714, 1.8667224291191946, 0.2888174199940395, -3.2358203639551446, 2.8164038747895592, 0.01409106229920219, 0.7913341943723636, -1.2032895132315475, -1.173831746550201, -1.4431885827965782, 0.6390582324151475, -0.2088271952480921, -1.1391001643749983, 1.4129237668936157, -0.48359856452888794, -0.535781274553361, -0.846173716154446, 1.9173292704076363, -0.4153946264910266, 1.0124683784381632, -0.15301717777834925, -1.6465593993828749, -0.8970039332768331, -2.0650178547424693, 3.248552544724853, 1.1692622918617226, -1.552069927354328, -2.432585150583817, -2.6822145825563797, 1.886617168731997},
    {-1.149831960884778, -1.9482641254368782, -1.6099571893461333, 0.8561271920756433, 0.5319009197343574, -2.441119264768143, -0.8120922141424072, 1.973284414812179, 0.07898624247806053, 0.6427929550760205, -0.12476309325088439, 1.355019265688994, 0.6215846595698311, -0.0158137259165692, -0.2584617532590083, -3.281908950120004, 1.3454040320934575, 0.25961093845677186, 0.08969110708152445, 0.2775084510666656, -0.20018028297874219, -1.1169443333950502, -3.825782465291828, -2.440065128813058, -0.5083397648587464, -1.2288531758332242, -3.1028143465148834, -0.07402967438391757, -1.6235155706455064, -1.3631067113741173, 0.6490213428697319, -1.3464090356841714},
    {2.2904195351816963, 0.4283876356094566, -0.8917544224621115, -0.8253585653048598, 4.457666253942992, -0.9316591117130543, -1.4087118982062496, 0.290289664939327, 2.301458031954048, -1.783034752486775, -0.5330842492800727, 0.2901089682138226, 0.32186558148047567, -0.40331143951891696, 3.1131617100172324, 1.5866151946394011, 0.4300792602332645, -1.4166227980408093, -2.090248725208456, 0.8179682038424845, 0.28450917017579963, 0.6977659526702984, 0.8120551738552859, 1.9134087409795353, -1.3232027150912946, 0.8221023327678171, 0.09340787102871641, -0.5329349811931786, -0.4694325604203504, -2.0504288744780994, 0.3223073986976705, 1.6245679050925488},
    {3.415256828066622, -0.21234284285322963, -0.4083381559842865, 1.9215375676430126, -1.6706400853272672, 0.9898938614620065, -0.28908248206859277, -1.791595976048963, -0.9992163395529958, -1.0048556136163955, 0.5929604458761055, 0.7748920602029742, 0.7818419766211328, -1.074769557976177, 1.513027357498033, 0.1398340969721437, -1.1260010658455835, 0.015947222079735077, 2.2625292148817233, -0.8667319636864327, -0.956433826759083, 0.7981592171153088, -1.2711385546767453, -1.027976435562367, 0.7468964000980024, -0.5540156786116152, -1.7789477440330108, 0.40586254910637504, -0.22834976701245108, -1.5324816292772196, -1.6271887909247136, -0.37167462727963685},
    {-1.8869731518101445, -1.0489926332457993, -1.5984382279166522, 4.677560218936993, -2.5211461615690514, -1.6995141846971447, 0.7876668918551845, -2.2383670254488703, -0.8334686095645936, 0.9426163668830625, -2.04473850408098, -0.6046783515446428, -0.692969320852481, -1.705232052191196, -0.2343454900425349, -1.50078470840887, -1.7834727245642203, 2.958069529718941, 0.4825040875023201, 2.2826980997066584, -3.947971692242399, 0.686250419935273, 0.25076933061045537, 1.023328394339986, 1.7608577827498328, 0.5639868789966683, 1.7638132154233601, 0.301668806120388, -2.2063837401686124, 2.2719096746755105, 1.1490565445667424, 0.4617628750692416},
    {1.5537178317561846, -0.756926165362035, 0.4201741216854677, 1.7490466902379764, 0.6426077006276452, 1.2764032673093912, -0.31313854853561834, -2.547320341171058, 0.6615601746552893, 1.0149511524484414, -0.6272387668062757, 1.8206357420896022, 0.9399807930150527, -2.052095269424552, 0.2626292606294719, -0.7297951545382688, -1.8252794124445972, -0.29424867679794325, 0.23401829463031767, -0.9221211046004834, 0.11673164565133586, -1.955292926980363, -0.7390685651439178, 0.42435676798390365, 0.2224572882020501, 0.9552862284045956, -1.0320139030872282, -1.340963203037497, -0.5420591043852528, -2.2005864290556545, -1.3204315797231783, 0.6542464069076354},
    {1.0119449885639265, -1.3973739941009302, 2.8153918050571267, 0.24856276745928754, -0.613053413972832, -0.7236078104373571, -0.4468422513623298, -3.068924532098297, -2.0302721675612174, -2.7356223533683695, -0.5993633877656073, -1.4786682622419571, 1.0271721591845213, -1.2701758773632403, 1.868969244622373, 1.0798006317728703, -0.44644460147798454, 0.4202087203034495, 1.783230958984496, -0.4310569028175859, 1.1205543532960225, -0.2155459950261154, 2.179665927727727, 1.9894104020528536, -0.5557367467062929, -0.6363479279820181, 0.17927752495199273, 2.4111991404937267, -2.8349629446282636, -1.100290732466625, 1.5748401266630148, 0.5979867402558242},
    {1.7622197340105088, 0.7624589601332633, 0.12297353827437159, -0.25252808715094993, -1.5212555326177013, 0.1621061863023488, 2.8209998587360867, 0.6791670119540822, 1.2440687589063253, -1.0469525268674533, 0.2252955722821621, 1.5722853338863874, 0.2666020987814516, -1.0838819657330283, -0.8105892202842068, 0.9387775638339028, 0.9226277703045237, 0.3745363483023316, -1.8061662868243704, -2.342916240297099, 0.8522900469248019, -2.051568456550073, 1.3373864798361228, -0.3850376226848046, 1.57718913813653, 0.4097898670387651, -0.45381192310679364, -0.35320983265525435, 0.7568956563022478, 0.28899533779138176, 0.738160665163381, 1.2772305950124625},
    {1.2029374487518822, 0.5630861869960018, 1.8233776863340794, 0.19475981215297875, -1.3616097960194684, 0.14683869243800488, -0.5842886075807125, 0.27951536731926296, 1.2875807195299223, -0.2473178691187011, 1.92793114924487, -0.9571454076382706, -0.39375784710569894, -1.7260780080534779, -2.311207417609078, 1.1635854762570317, -3.1611462451168957, 0.003233057237245745, 0.1953523412425663, -0.7172805782534702, 1.6627192476734747, -1.8232906733815057, -0.12644476207192634, 0.8178813250009158, -0.6470788735034597, -0.6482318354039247, -1.5141546288030245, -1.005390778076892, -1.3715572632503235, -0.6988625506186331, 0.24373361985846104, 0.8795880297651872},
    {-0.01040518126831787, 0.001696698951339717, 0.5508260342502246, -0.5076800108005605, 1.096330126259431, 3.937762108607294, 1.8174746579180618, -0.07008814665894884, 1.4713427213661283, 0.5150580209151728, -0.4453092181931466, -0.6231558963676769, 0.2458473014102415, 3.5976867024079744, -1.6440919912925644, 1.1139346255780012, 2.7570535122184485, -0.6278242598047655, 0.4898993655795443, 0.31045807379106544, -0.44398016132298285, 2.0050276713982527, -0.5415343787800199, 0.8918791874742793, 1.6634650876794355, -0.12887610289369641, 0.758696608791894, -0.1140937483679859, 2.0418512204214117, 0.9039811873101652, 2.695012626859794, 0.6173479282515574},
    {-0.7112375150649524, -1.240542552309254, -0.899130605164841, 1.4039522909487612, 0.9903344426345814, 0.9999616663551661, 0.13849320031604875, 1.761884283564268, 1.2470469187105835, -1.3427012292466198, 0.445866670848802, 1.61810537688869, 1.5312107732613338, 0.013912674368714828, 1.6962392044157086, 0.9048081799215179, 1.9889065327867763, 1.4878507647811547, 1.7676044144422143, -0.53294687551891, 0.2481010183844175, -1.417422267822202, 0.8772693767818465, -1.246588382825502, 0.7215362106275278, -0.5323455948970807, -0.45952924389072897, 0.5488910721369535, 1.073861464362717, 0.47987934063114934, 3.3021896222121145, 0.8997227264111597},
    {-0.06263908919413494, -0.6205591669306689, 0.9014473949019443, 0.019251098232409395, 0.6278500693346978, 1.3038499924263793, -0.14819533558105608, -1.2676614392978938, -1.5083799528035942, -1.484742649388734, 2.263250910065801, -0.9890848428015533, 0.8873279022475385, -4.217278513577742, -1.1085542680279385, -1.6075512384019162, -0.05039860223053334, 1.2351305012302474, -0.582630560656086, 0.9790935445338267, -0.8285398584427012, -1.6355597866745757, -1.2328632685853882, -0.1178952951302631, -1.5488089606318671, -0.6962398637859207, 2.6658700482504685, -2.6662352598790644, -1.3605018979030614, -2.3143170638880437, -0.16505723927238083, -0.5401230736755473},
    {1.9970940373082715, -2.507516289338549, -2.8421422878714298, 0.5799356459096393, -0.6150864087244812, 0.3787058564058703, -0.30805719351349276, -0.08584200361971554, -0.10161219842570848, -0.5182892911409069, 3.1240730550448186, 1.1205532454250495, 2.019841567456086, -0.6329432369391735, -3.0688411601888483, -0.19773754856743864, 0.14060215669085094, 2.4088139657738803, -1.0153818042473373, 1.9696882980904113, 1.4913827809088533, 0.44921284589209937, -0.6741584271793175, 1.0906765117407533, 0.012486275662163197, -0.3658871844277628, 0.36955409355655666, -0.4577069955421229, 1.4602758435956504, -0.07071549627379814, 0.1361654323935893, -2.1860551453878556},
    {-1.5852198917623639, -1.4638488352241894, 0.3741007955952339, -0.953430833373588, -1.2864733444775696, 1.3183263352679677, -2.581506131918842, -2.8767242296785547, 0.3979133441945242, 1.9977559925542479, -3.5633666741723635, -0.3442903655373655, -0.2859426063603143, 0.64397280724747, 0.17418441907597537, -0.5250854416369369, -0.095314699209975, 2.434520300066051, -1.2876646904529676, -0.09325893805524064, 1.0513580922858365, -0.32391165312127823, -0.3311873367170072, 0.7004568325500805, 0.24245752266725873, -0.3487519111707993, -0.11696781459736874, 0.3158737331364928, -2.307267518080878, 0.3852852165237531, -0.9945200160776083, 0.5557129877251551},
    {0.39867241296451317, -0.28118607665662826, -0.6262908344747292, -2.855060973591421, 1.2616880134919815, 1.8610177454716323, -0.3977630043119958, -2.440824458633759, 1.731774989650875, -1.3991080253322101, -2.449728883595876, -2.1822191942027502, 0.5389748662799771, -0.7385276467836577, 0.22138717721764942, -2.2559512310936736, -2.9559929992718526, -0.3166464278180924, 0.08816683200225593, 0.4837187284992441, 1.4861774569975745, 0.04697803544322364, 1.9744380891615112, -1.3035671556019341, 0.19713118016526726, -1.9260589217518918, 0.08872066747930246, 1.2753344998044225, 2.382687547528447, 3.5243003368463213, -1.7235711253894934, -1.4539013128284268},
    {0.5419526291125039, -0.7323727389501102, -0.1990843564339078, -1.461990017747134, 0.11911562109605457, -0.4468687161091842, -1.2202278419741215, -0.909900544001071, -1.9014261935462609, -0.3679839416359988, -0.440200204408846, -0.02025990668935088, -0.3412523696854948, 1.1024733240075355, 1.2753308151233211, -2.6410852428201803, -2.755973957348873, 1.5986933685609277, -1.4879717122936662, 2.61405529930688, -0.9323692937529092, 1.1350536786120393, -0.5751810230257604, -0.3650375424334424, -0.1606167941043997, -0.4864129842679916, 0.5643785502340238, 1.7456458319778931, 2.7077150112776716, 1.7947841704529026, 0.5976019953699042, -0.43041881338289917},
    {1.0109310639249196, 1.4515085052032703, -1.5536396412396005, 1.6967640031388445, 1.7119543728561537, -0.9729836443673597, -2.7224671529536137, 2.5992785712877673, 0.66160657174275, -1.4192625163547807, 0.40481587778045103, 0.2626320479828515, -0.38864857289858595, 1.918179021920147, 1.6781481570301735, 0.4290744406789393, 0.5332494703720787, -1.7459394733082807, 1.5567601559979607, 3.1954691244841533, -0.8727181345371551, -0.16836533305167337, -2.455969632486655, -2.167166430295539, 0.32873061630222733, -1.065587449674436, 0.5049763378486333, 0.8710585228068928, -0.22152628996672616, 0.6072096300910447, 0.7689849531003462, 1.0276029417295376},
    {2.5436962727466255, -0.37032909497324185, -1.8433060352315982, 0.4889471184872238, -0.3584740555639123, -0.5773232795562807, -0.8133218209938871, -0.7650190748247702, 0.7383075959910622, 0.43254186846808773, 4.291094658779875, -2.303777307306943, 2.7056320647663568, 1.1017485960405116, 1.7141927711167915, -0.6134527047640181, -0.23219801299036097, -0.6158896867946586, -1.8693377741084751, -0.12568145019017116, -0.9650021676281907, -0.9983993363213531, 0.07243887138683511, -0.3644060886461106, -0.14819652066391562, -2.416329471971566, -2.6335224577624943, -0.7463073609973194, 0.03133808152388677, -1.7389539368004652, -0.03042735152309155, -1.9049968148830863},
    {0.6178892849106773, 2.4847586638962853, -0.33769695325315763, -2.5715490028293786, -3.695086417466301, -1.3692960039109017, -0.6730761872414212, -0.21757103926764412, -1.7997916452786247, -0.6555636482976501, 1.4258751298603218, 0.11685426697575672, -0.11055574274959915, 0.6313813659365886, 0.7890034860661165, -1.111100434389776, 2.9783478546592077, -1.4145063286298802, -0.42431535529195025, 0.48786390237720945, -0.06898753384268075, -1.8050636698904035, 0.017544552228828357, 2.399583242989312, -0.6667560453092009, -2.663110834058633, -2.049338066242535, 1.193934121305561, 0.2640469112595586, -1.2106257091973516, 0.07709151597945735, -0.34170521651358254},
    {0.12271191844862671, 1.2128592915189969, 1.5363095969378364, -0.15081808329516636, -1.5451089650921175, -1.068898775042914, 1.8971817798157462, 0.19482109859422142, -0.8091022725810829, 0.7901128335641837, -1.2885840375446684, -1.2029095749804395, -0.12645936900165275, -0.6450685300664368, -0.9677413765420433, -0.06768664582169912, 0.22987452911196699, 1.3159552556311864, -1.3796004388673713, 2.457438189281175, 0.7990917732646579, -0.628298782088938, 0.647854151365906, 2.0463085248040214, -1.3703376661537892, 0.8935922073280878, -0.5894304648523786, 0.39832706650072175, 0.8072059007177507, 0.4341643315355106, -0.37493652972652647, 0.13063268227599248},
    {-0.8013886496748288, -0.028705409704814614, -1.6979948107735197, -0.1388124875000915, 1.1224706218775953, -2.5007806117050477, 2.2025184196135084, -3.624408181902837, 1.5005515017026994, 2.1471585533119057, -0.8168897467358948, -1.8608769934412075, 0.2696143972258844, -0.15399783824172425, -0.05255685501690283, -0.8196117359056861, -1.7926605663703121, 1.2350356031157095, -1.3654878703844755, 2.3426224105797315, 1.6301897744283407, -1.7652501785269226, 0.06185005487179262, -1.7525554781602122, 0.8428739407475532, -0.7846755149142947, 3.212133266045946, -0.5391802585216998, -0.8453123950436212, -0.28382410949788345, -0.8917528308595069, -0.483210456207298},
    {-1.5860809840319714, 1.8903618786120775, -0.670872740435954, -1.5677872490715765, -1.10703203971039, -1.809887928018762, -1.7501164289825883, 0.38762658955890855, 1.055314221655094, -0.32547527305459417, -1.8311201350501316, -1.0976320599426699, 1.0824854642346924, 1.4839288868575706, 0.6797479690315624, -0.834957501499912, -0.3375385369613386, 2.048508739080423, -0.6170513912150809, 0.6333157758507929, -0.29729272575029947, -2.0079762984361422, -0.013287499385176347, 2.8230947917509526, 1.240707477289732, -0.5447008231937656, -1.2291982233621979, 0.3228205617132228, -0.7723471009856755, -2.2124365512875217, 0.7128899307064613, -0.2220470538760327},
    {-2.2379333552170797, 0.2508734985653243, -1.537619022215715, 3.007572065290989, 0.46984492592209126, 0.7245164033696386, 1.4099115234875506, 0.7872166499224903, -3.1753627625126715, -1.292711241128735, 1.4858846337743483, 1.2161740828803467, -0.2648541203990343, -0.8568903750013479, 1.3042612042333497, -1.034240120075968, -2.801039707665212, -2.5483391070231782, -0.8401049019860815, -2.0858762635064756, 0.988046102826886, -0.8024989493722015, 0.03197040473170083, 1.0621458191164779, 1.5431001861991955, -1.253799430163469, 0.6327908741678357, -2.0689972113382984, 1.2429441675269932, -1.0894962960227756, -1.0000876954807991, -0.15521318981168525},
    {-1.4535558840922058, -1.4076620431580307, 0.30657713222966443, 1.1215139726853978, 0.5615840402656941, 1.055138134408265, 1.7924683512841966, -0.43441785914961206, 0.6299971209150699, -1.8300764960197848, 1.6843376565691197, 2.5326050018465707, 1.0888045194277807, -0.19552640628566398, 0.025253779823326078, -0.6246626961995473, 2.0838216392770597, 0.3421968674878732, 0.8098059431779125, -0.5185094274909369, -0.1443075583559262, -0.5722634508765542, 0.711610893598357, -0.5878187950356704, -1.1274864398083537, -1.856398970604332, 0.4787796045363965, -1.8993278988621896, 0.3847152897021152, 0.1136494400819482, 2.080580788928489, -0.15659744761919497},
    {-1.860944741842708, -0.16120514349243864, 0.4249261756624636, -0.8124658126659238, -0.05364646119927639, 0.030537848400089607, 0.9380322016498587, 0.40166997720545705, -0.028272152370835295, 1.185321445892216, 2.2086461155581647, 2.2642533768549615, 0.9246653140240405, 0.8775918269685093, 0.00044785626805743866, -0.3795083855081051, 1.361158722891896, -1.7520739327021047, -2.5404063977095657, -0.6364985317161458, -0.524808752827915, 1.4975934114473493, 2.4115899006124537, 0.5168973375275598, -1.6518861721796252, 0.5094869964837637, -2.8308440799816696, 0.6933237675689637, 0.3253125973947483, 1.4393183419062578, -3.1465093223180007, -0.245472837124728},
    {0.11149213654116139, -1.7702801865105064, -0.33849291949035437, 0.8903093122591288, 0.5725906015633551, -1.6153286756535516, 0.4886958253609781, 1.5907510223835737, -0.500419566535083, 0.6523036985807666, 1.1417304328316338, -0.23463469851155033, -0.6295051990782399, 1.3104824471573138, -0.5372532512277497, 0.2848681978497483, -0.5269983720055411, 0.6642622389160507, -3.7856009898764102, -0.3583987041203578, 0.43274505778387723, 1.1768334707436787, -0.772082283001477, -1.239960440596807, -0.8925994364800834, 1.2117314038787552, -1.4035141050014621, 1.4210348427537565, 2.2730704406710966, 1.0421795454603489, -1.235395162398837, -0.5570826153246146},
    {0.08798543096634905, -0.5945266944384432, -0.7187675443234363, 1.18780283116129, -2.3171825075516375, -0.8455858474563793, 0.5665567421126962, 0.3525981765667312, 2.4777534262149823, -0.4792828568694806, 0.7660149038897528, 0.2017314363657745, 0.7209927495986276, 1.5680882740159685, 0.11334829183111599, 0.9904844861031824, -1.0163777790119917, 1.3695855600683655, 1.134825740879665, -0.9089610551756772, 0.6419949991609353, 1.7721761421729827, 0.7438336032273901, -0.2536814570023179, -1.1356455243907777, 1.07691766630727, 0.7749835219615914, 0.6003084079153747, 0.35827552481071473, 0.20712761786567424, 1.849083533898413, 1.4458144642993587},
    {-1.7518275352687729, 1.741488002391177, 0.24261299334130856, -1.822909329896792, -1.2163797786274095, -1.0989182731088714, -0.6143548473725873, -0.5846891384867496, -0.051432123396620504, -0.40790913369436993, 0.6439108300745673, 0.8230137725073942, 0.2759314369084838, -1.2046857212242077, 0.8579053859274383, 4.297928953626922, -2.2112886245915053, 1.9655526003135462, -0.9453798857383855, 2.242022066389047, -3.4608953100070896, 0.6165222353396371, 0.25736129145923825, -0.9341706896644816, -2.5164768976809277, 1.2032632668365388, 1.5167256300218932, -0.6003549986864517, -0.11011000624933238, 1.580928178076498, 3.8155624426880146, -2.1498496338187603},
    {-2.0875748684255795, -0.02813143934847925, 1.2517829696962324, -1.6724832975087773, -0.5076717263820243, -2.565956345504621, 0.9299389550774471, 1.2934706240742604, -1.2192844641247225, -0.8681742378311726, 0.8503323933921039, -0.7090933179325359, 1.2290454153668355, -0.023014589773712055, 0.1064554373854684, 2.155916220570683, -1.5730511066865471, -0.1892307715025329, -0.03418871111002251, -0.5899718845295974, -1.1568530316176993, 0.4623640088502254, -1.1314519960324834, 0.17048159164855722, -0.029590204464450154, 0.28103839353991045, -3.608781566236776, 1.598843176814009, -1.8361789425685977, -2.168542409809679, -0.3461514192051782, -0.44405258963577304},
    {-1.3320425201785833, 0.25157876570321025, -0.884403496456566, 0.14485337897783207, 0.47785133583352823, 0.6111918223249481, -1.623699944597732, -0.8117145680347007, 0.6788746660529378, -0.9700580639719933, 0.10268881483049298, -0.5712332481081169, 0.7786621338607437, -1.2566274440322378, 0.7234612076584491, -2.629123775846284, -0.5704207813141302, -0.9109194408738222, 0.3567592940427, 1.2657135352380242, -0.7036852174996013, -0.7639303953978605, 0.31032513089530867, -0.33945238498763003, -0.2802242150671335, 0.15643303811348092, 0.7137112212075156, 0.18092214275508015, 0.3652112857349002, 0.31158909245546795, -0.7125626955110338, -1.4990239436376442},
    {0.4806419149004111, 0.3871768628425732, -1.9185304086315944, 0.7474789822023701, -0.43653110634395936, -0.5843699840199863, 1.4400009206306288, -1.3320771059145486, -0.02542729499664748, -0.559900199016308, 1.9419606025223457, -2.1288661920802916, -2.37893124978199, -2.40441396467605, 0.5719095882912977, 0.9274003768664695, 1.0686694810321467, -0.8714448813557653, 2.4196188004239674, 1.0861714490447123, -0.9520054443643545, 1.9209857076613974, 1.8408435307083986, -0.3397217938162247, -1.5980837679636364, -0.6565122848096765, 0.25419433713775563, -0.10989033044978765, -0.04904094536283176, -1.5840092660618548, 1.7015864262353604, 0.29770843578472794},
    {-1.2230532103970841, 0.5858284008422331, 0.6983450003760545, -0.8820370780297375, 0.5519880529145847, -0.47715885096791266, -0.7419917258154229, 0.03945907906458585, 0.13722167932375434, 1.1718868774345716, 1.1186116652488176, 1.2065265909799896, -0.7302899753944057, -0.7160928214481606, -2.189279464657725, 0.04189816236214162, 0.13314053449407348, -2.619627985705736, -0.4910473145540243, 1.4288923637226985, 1.8652837068421404, -0.9010150276722086, 0.4008769899746295, -1.8795716930671929, 0.03771721019389029, 0.9491545226399437, 1.0429237517119123, 1.347163811283195, -0.4227737915621924, 0.5316217358573812, -0.8268195107178731, -1.7843659272016188},
    {0.535772170509197, -1.8273515804877694, -0.8323562954731054, 0.7266150222220668, 0.5142802137523794, 0.44662418298829976, -1.193564257154937, -0.14393523480196102, 0.2641967094206951, -0.9293749187792657, -0.9310520324846063, -0.9455846161335598, -0.7551154761173952, 0.5582794571215521, 0.696607219550013, -0.342921360056098, 0.07844283594394758, 0.8105496353522733, -0.6465717157251866, -0.46860268425239765, 0.6584971664136549, -1.141278350412154, -0.6005452263884368, -1.2616047887545396, 2.3818285397055172, 0.9654733946456153, 0.07282148848432242, -0.3680383915242368, 0.4208570261531101, 2.9690860124621827, 1.0956691757205228, 1.6351783915622249},
    {-0.07575069622544972, -1.1020503331994456, 0.41100708811870157, 1.9888657058654864, -0.17153088505350683, -2.6738429143174014, 0.06876849673601713, -0.8857917988738948, 3.063050842513159, 1.8170712899606343, -1.223396248026906, -0.17006896430734622, -1.0368326952252673, 1.6907448659015187, -0.864180918474613, 0.7029868437353701, 0.46343161013989476, 0.06796300538395945, 0.7541590679757837, -3.1447686507011205, 1.44868002238734, 2.393029687783744, 3.0056824268838778, -0.13908760928021366, -1.1135378747623186, -0.5916142437169267, -0.524600825736375, 1.5541857878188772, -1.4899991838188478, -0.1367595916421622, 0.5502282213045068, 0.21122630832345585},
    {0.8843583708637451, -0.8889096343718139, 0.13642176622603328, -1.5266234649399475, 0.531606885514783, 3.1277184093338914, -1.387291992383229, 1.1650112064213924, 0.01530689726965463, -1.4434548266900027, 0.9976225686541419, 2.5415944976243354, 2.0903731002178256, -3.156274532644744, -2.2854539068575357, -1.0794968820114845, -0.40730309908278284, 1.6549961098183543, 2.656716459115751, -4.30474910260811, -1.1119416754295914, -0.1236904957328515, 3.912923107710058, 2.8329651312573914, -0.41299677011471536, -0.9675908527908024, 2.3781097761562866, -0.9543994752078958, -0.17779454482068563, -1.8466755130473853, -2.0553510038311886, -0.8125864332961796},
    {0.09574243820868952, 0.12214368253305999, -1.2260712341280617, -3.9554602835966146, -0.4074825442438367, -1.096003727616436, 1.3095593655438507, 2.3882505253442314, -2.8145283846718026, -0.25072453124691907, 1.6702333361657558, -0.08835883892365123, 0.8109056279104816, 0.2955351751387711, -0.3181595939723122, 0.9513792437467706, 0.9347930302106052, 1.1177610374549305, 0.7498014519069774, -1.0948482736094025, 1.4202718312834643, 1.4229091932451843, -0.47142866954890905, -1.2310401831798374, 0.1984473149893706, 0.9266930308288359, -1.4856712523582523, -0.8027266885116705, -1.0650044986704157, 0.053867868751275055, 0.8334892265387535, 0.45138595448472546},
    {-0.5503310876013107, 0.7229077611116144, 1.8037741456989134, 0.7735307545098303, 2.0278218105412376, -0.6424488868231167, 2.974115877759944, -0.19756331932323098, 1.2547319178972947, -1.8160600790399206, -0.6241914064812393, -0.5509619792016208, -1.7302998692158182, 0.6322643004999109, 1.5570302140003036, 0.09778227038654826, 0.278001522401729, -0.6315291119854747, -0.13254119703166675, 0.7924186934914925, 0.1048674438471221, 1.477550094064452, -0.7422681933822314, 0.316166507013529, -0.035449298771139594, -1.096688746199761, -2.491249351763725, 0.5521213174229647, -1.6465693990572525, 0.1552949738371869, -1.0165766319662939, -1.7762712692454514},
    {1.9549859582142832, -3.493140696297713, -1.4567941084314753, 0.10566934473498206, -2.391726277554172, 1.8697743528111344, -0.2603761239674459, -4.151322846269867, -4.396437154157905, -0.7439062281432277, -0.8692530953189094, -1.8229537222063883, -1.6737881342793417, -0.7962923657855231, 1.4058393341087378, -1.8298571511239206, -3.390763886601049, -0.1780382806290266, -3.7538668731901144, -1.6134801948678172, 1.7164711115554194, 2.2116318020532177, -1.8791244178904272, 0.9794307530796483, 0.8234045370342857, 0.37561308595584575, -3.7962353200643197, 1.5827544836530232, -0.7117418062942729, -1.1068171369734854, -3.28762171614308, -0.20302355421181417},
    {1.3959684989732208, -0.29039633561449657, -1.5132125738713371, -0.3713909766506673, -5.761355202779968, 1.18641702925405, -0.5492390441438151, -3.2240302212707115, -3.506868784153638, -1.1094313924708281, -3.4950391894913686, -0.7293395617655671, -1.1691543091189365, -3.523238643122987, 2.438096959374257, -3.000616109274454, -3.830197285200211, -0.4699598327024296, -1.344581695095874, -0.898030487862928, -2.5095109256523327, 2.229702146639976, -0.8247464908007518, 1.6698708621005836, -0.7998627574210967, 1.096161328357777, -4.593693979262361, 0.2654713097343795, 0.4190497086239153, -1.758486864576817, -1.0809314882747432, -2.761997194492088},
    {1.0898868263856896, -1.088165552858037, -0.06052324807030722, 0.06309823946319168, -1.8053479777164214, -0.8878915382813849, -0.06573456295006258, 1.487255147147069, -1.1973693473730433, 0.4804253558285304, -1.1442596284726338, 0.7479021788344001, -0.09459123126465036, -2.272882571646025, 3.2995445229080103, -0.8875625768613049, -1.6043770649145777, -0.5254649716958998, -3.521108552018135, -1.7788342496543934, 0.48112809670888185, -0.28339414019994685, -0.8182902598092973, 2.105528146034203, 1.89297464598017, -2.258348337905641, -2.167199124682389, 1.2191475720388742, -2.0268369268539383, -0.6105831239553605, -1.5366514642794922, 0.14406689388751318},
    {0.9006492540036213, -1.1033473809327692, -0.00941474861117742, -0.08459228683206041, -1.8828691749681552, 1.0801658037356585, -1.7596515649449578, -0.10984213495956235, -2.3676170854545293, -1.5501031051510592, 0.3224099284775406, 2.515120049349775, -1.0998656447231194, -0.38620478962910687, 0.1378643175284449, 0.9595269577005701, -2.6017251866306417, 0.2378541003005615, -1.2663749546767917, 1.3650962219703289, -0.9484289580634087, 3.72625707507869, 1.1622395941353207, -2.425504383351402, 2.824075224672551, -0.18909072955733658, -2.2865559281717798, 1.7597939082354248, -2.4239398983823777, 1.411364363340665, -1.9759692094198162, 0.1471211480021863},
    {1.5010403551450218, -0.427632229688859, -0.2563063378135165, -2.373366161266492, -1.4388142881453234, -0.402065537196555, -1.7305394226109927, 0.6491644524052618, 0.6457399336062547, -0.06953137364457443, -1.389727381215022, -1.5777596488789716, -1.3948612207295163, 2.3997312042377494, 1.2814465026775435, 1.0353199101547808, -0.5220152526538986, 0.7475037100000491, -2.7065783583145957, -0.5145385049490125, 0.8504572757017586, 0.4498981055619713, 1.6835637077423837, 1.563957245286935, -1.8586412232634306, -4.035642783759938, -1.0273057131167607, 0.3111181270759618, -3.2696294070446505, 1.2977459540561773, -0.5517699269790954, 0.8021903979918262},
    {1.185714141852972, -0.27178657790885247, -1.292925415400077, -1.3347242814503812, 1.1501264566365332, -0.4543264179951989, -1.0076331996154753, -1.7462641386947702, -1.9177228993651592, -0.5844489518391083, -1.3051800405863982, 0.03269297434679403, -3.312227134894025, 0.5385485730093493, 1.7879657622332847, 1.0299585281019572, -1.4631936868155513, -2.211847509598236, -3.9983655797630218, -2.7081187353822522, -0.849551346788248, -0.1990367121192565, 0.45538204062095444, -0.22927313930708915, -0.3505046784595369, 0.5333775414651604, -1.493672545403252, 3.2400430926497394, -1.3582941110238027, -0.3228662976531805, -1.5469847148924243, 0.344777127863996},
    {2.3860538255321413, -0.985816270513007, 1.96068593591745, 0.939244809017076, -1.5506664387537714, 0.32614101663555806, 2.3189582066856893, -0.7785367774930256, 0.4182922498411177, -1.5837604776114116, -1.5924665929998492, -2.920260542135499, -0.625924648402625, -2.899920312872508, 1.8447846189335355, -1.3104101810499595, -2.241438580022301, -3.6961872294765517, -1.9967189111463717, 3.6584381104521473, 1.8502145950911697, -0.6805401477012262, -0.4041816188795009, 0.2799609920717198, -1.1426670897534514, 2.5724623958062054, -2.441891057722504, -1.4506216174988877, 2.6611768982383825, -1.7240654652451148, 0.0543238301732434, -0.22983951858184726},
    {1.8810091622806298, 1.0551215836381185, -2.2785548704736907, 0.3036503454761456, -0.44005383467771053, 0.18428764738527342, 0.35147873435375254, -1.6314881454300698, -0.16363858612958912, -0.8222326097216702, 0.04385627383328694, -3.4914563257117908, 1.22356400634405, -2.555792606029846, 1.62233209473277, 1.7686341703281172, -1.6577800832287768, -0.6628013201473727, -1.612544136983879, -1.7319914908188414, -2.7912482270482806, -0.4651142500713102, -1.4016604453551713, 2.15763333839061, -1.9968562802731396, 0.6663184464642058, -2.163325939709391, -2.032784632107891, 1.7534721805900586, -1.0193835889279963, -2.4597043617783605, -0.2655061116168464},
    {1.9087913692730893, -0.2883377737231557, -1.1088056812905338, 0.18139408720625566, -0.181243036152662, 0.014132094878426617, 1.8244759048504207, -1.2884697397827605, -0.7938319299817217, 0.03894501377328966, 0.07466421895647016, -2.4194766979998494, -2.20556817205982, 0.4156235164481729, -0.7420669067919261, 0.1223477784734982, -0.38176391113106123, -0.17027468245368926, 0.3440109516451382, -1.8514796148549688, -2.605875187868088, 0.8671371474903419, 0.9969927557836531, -0.13986272994832932, -1.1747190771322666, 1.2576253039232799, -1.6237380991105264, 1.2195660407628286, -1.0639419682537252, -2.09791208524572, -0.11250507232821975, 1.7142342567094198},
    {0.16861668422220918, 1.3050231906448038, 1.3539019560470718, 0.07232814259112226, -0.6827680673522064, 0.44676459478682995, 1.8432100390111332, -0.9624050903116391, -0.05331975975550754, -3.830850389371301, -0.40105752386140475, -0.6317843993279662, -0.7753830959370437, -2.6034174441280387, -0.015869986223752835, -0.6661212668089953, 0.5235127193153076, -0.7833765345401172, 0.49304240351755263, -1.856769661022335, -1.728592563225801, -0.44485525331872466, -0.427444315523358, -2.0213454270666964, 0.24284186864695415, 1.8213693628215581, 1.035474570303974, 1.6035198444006777, -2.0090117837857444, 0.5693137598108434, 0.775982034193436, -1.5079476517369454},
    {-1.3613932147636705, 2.133303077710826, -0.08728342781548398, -1.4694049013198294, -0.898620652017133, 0.5442734047793023, 0.4826309934558988, -0.7978682426139185, -0.8905842317735287, 1.8275690348272238, 3.253168635983622, 1.8648944402294925, 0.8873385380672851, 1.5035068062319201, 1.6485399664248568, -0.47179782280328575, -3.5317179908129375, 0.5287380169201267, 1.1105665964033262, -2.562890643980284, -0.27809855595680233, -1.6951108381642914, -1.6206846583100696, -2.1343517876605107, 0.22947708255831667, 0.8969108572552276, 0.29264844135125, -1.383793236837864, 2.075096887173931, -1.3041319859153657, -1.339058690129853, -2.5531926675659764},
    {0.5264795889307102, 1.3777894917650844, 1.188069450335871, -1.2588500985811555, -0.7636314380534954, -1.0719954047957594, -2.316770036931592, 1.0986794106871458, 1.7616977032384449, 2.0337836108283667, 1.035977189374454, -1.9475915741517564, -3.5062239629521326, 1.3804454270934958, 1.1762816987976765, 1.7140512794508604, -2.2047579064686067, -0.1735336754937697, -1.1946010237271303, -1.2059432317659262, -0.22395060105649192, -0.03671938054005001, -1.1360177807366125, 2.03861616639494, -1.2222033516217894, 1.0026799070098287, 1.1580572459081946, 0.8630143770697599, 0.6801611071720096, 0.3466759305131205, -0.025260533693994655, -2.9400487698001037},
    {3.7162219705386064, -2.3974426892459904, -0.26702602626853006, 0.11677033069984295, 0.9757714053207407, 1.3164778146315241, 1.6923587251176033, 0.4049604001061169, 0.577801299211812, -1.1817189844580571, -0.261041240763324, 1.701774409842711, -0.41062521053339046, -0.037237669442969044, 0.08815011428764057, 0.031183642147881812, -0.14133308490768048, -0.6702525616589675, 1.757337123678403, 0.3069060477468494, -1.6655665982751708, 1.6533292617077961, -0.19312874858629134, -0.03784293690871287, -1.1438228836427593, 0.14914032793470355, 1.3706458857098922, -0.23466878997044682, 0.3440290194854084, -0.2689087353783648, 0.859975240646524, 1.1133586067048784},
    {0.6230294306074121, -3.161623241192554, -2.924557976789293, -0.06441339484613172, 0.4765794581240556, 0.08275807623033085, -1.6421040410058494, -0.015457734877724779, 0.12581162411562194, -1.6964240248219455, 1.738694799627606, -0.819072823526205, -2.343165774822662, -1.7490801708511443, 0.06787274608444102, 0.047080844320394076, -0.7770646076951204, 0.09927592715871875, -0.8589221000401203, -1.40927285596399, -0.7871286884559614, -0.34769093712817356, -1.8703834039022595, 0.62104640757499, -2.369175962739673, 1.7582406596847109, -1.4559345144753537, 0.33613627771210614, 1.1984921027372668, -0.27792946054008744, -2.1331792864274726, -0.2216880921300319},
    {2.369112660973456, 1.6139996558581537, 1.0173280292980595, -1.1720381177162158, 0.8989501372788482, 0.7120049939702097, -1.297893641628805, 0.8758470013791861, -1.6683587402894005, 1.2277751704116577, -1.8718986117833738, 0.8865778392789953, 1.5319493963017106, 0.6343770196754321, -0.0557780688992943, -0.12083367371818415, 0.19243492616381355, -0.810892196223222, 0.2742015853227897, 0.2439255650481801, 1.180949306391232, 1.1922725133045053, 1.7722762505793654, -1.3657750892730052, -0.6328238647019768, 0.10267905239747349, -2.3092393631955512, 0.3980865282834121, 0.3874420213425245, 0.27454264183782695, -0.8134910411863625, -1.9795638117123797},
    {0.8569091353563015, -1.0225779272932247, -0.789618578844931, -0.08255774477065482, 2.0223191345879132, -1.0218138337067812, 1.176444196988517, -0.49735884055700375, -0.38669965285396124, 0.13800620550991582, 0.45860194865106135, -2.365837215838922, 0.7093617208194548, 1.0432844638796528, 1.9712547528098434, -0.30324702875349857, 0.9850537203025236, 0.944591440103084, -0.21422095295830612, -1.5241844365438564, -1.7214271083229076, -0.6527989551733947, 0.32077819865607465, -2.9094693999568273, -1.5453461591422326, -0.09838456122149708, -0.8567743572782266, 0.30964532445239573, -2.109443036792899, -0.8656494935976999, -1.8434400940462632, -3.2207366642553636},
    {-0.5619126180587858, 1.5508214708210735, -1.3249104743723195, -0.0008473110565185751, -1.7272557335455334, -0.25589852043038436, -4.244393867609119, 0.743992506748908, -2.1562199408608396, 2.778485207617332, -2.6891477757964255, 1.1897876605876554, 1.0392188741967303, -1.315995755774749, -0.38146779390266217, -1.07411580761534, -0.0690088238311973, 0.27846064194964376, -1.0437475318079683, -1.5538324942314277, -1.0127635829650878, -2.5551014182941376, -1.3015673060975341, 0.7767780883436061, 0.5229849793292756, 0.6361191767450666, -1.3257199743393386, 1.8201898692733172, 2.3903090094013986, -1.297143952232574, -1.7097647988269442, -1.7684505689095495},
    {-0.015204932866395128, 2.0506108440830895, 0.859364067295507, -1.0662877226243435, 1.4240687285973976, 0.89858294491419, 0.031848529775089944, -2.909690308306713, 1.7625298798297495, -1.8457590659829601, -3.255090932264166, -0.15851211959543515, -0.8265256009371239, 0.8564654363752855, -1.8494567275848255, -3.8842333147245593, -1.3124578623073042, 0.5488347493153093, 0.9736126652494275, 0.1104446649677658, 0.30503113395074866, 1.2483158995049828, 0.6476001765103522, -1.032269319161921, 0.49644359677106664, 1.3028234419473637, -1.5500455089467893, -2.885490413009321, -2.0906648049811527, 0.6317852874487381, 3.166029794353378, 0.42774534025849403},
    {1.3265150482787318, -0.33029188931597814, -0.27348670860600655, -1.0336608978412496, -1.6538371620386811, 0.17289910510814815, -0.6480367247773211, -1.220835445013761, -0.7925202617299543, 1.3538528978761664, -1.5774510198714595, 0.9621195948452163, 2.3029499301566965, -1.8386654550729224, 0.5655284502164379, 2.3330081046316375, 0.07409806494474384, 1.0205441417378511, 0.1433877575836884, -0.7215300720433996, -2.5646699188165973, -1.0093464925650877, 2.573307023578241, 0.785249594831369, -0.6311891344688788, 0.22924889173980406, -0.1700254756603651, 0.021643082097584344, -0.6868330712441447, 2.512316024453282, 0.9394298814538057, 0.8975068783509532},
    {0.6881204806300503, 3.0628874257240795, -1.421419238745801, -1.8953694194210402, 0.7381348388410034, 0.47567649989397265, 0.7698191188542799, -1.0708843385751339, -1.2692636352778108, 0.02594282115152058, 0.8088955186291378, 1.6503612649104524, 1.3753415109876355, 1.1820187878687705, -0.8874516277641781, -2.783381590346918, -0.11782865312455625, -0.8985092418572719, -0.05066886032648282, 0.01445183630139505, -1.1792141077506026, 1.1171071258605803, -1.2026607005901016, -0.35811945351832036, 0.8187734762945815, -0.509756495397722, -0.6876803694509565, 0.9273126367817347, -0.09217090643014168, 3.2755712918599498, -0.3170933428595527, 0.5897606384973041},
    {-1.167467985331876, 0.9371078091625781, 1.943336663678339, -0.062479164333749164, -1.9021250262938398, -4.166652766259237, 0.10084908270801178, -1.5889571575807873, -0.05155820274518994, -1.7922347720168512, 0.4350562666443216, 1.733658924598068, -0.5087801126925688, 1.3171904254268223, -0.7888820522473275, 0.8999485907992685, 0.7487418318819483, -2.9071943819313852, 0.8932826631042347, -0.5001003160241277, 1.0883842132523345, 0.7114866631724139, -1.047494703086349, -1.3247709450212033, 2.8977677080231885, 1.2409107920663456, -0.5311001253939936, 0.34583091823575796, -0.21278597693795878, 1.1972212368174286, 0.6392437387274026, -0.8438327416466486},
    {-0.7246912299167217, -0.03932913828447685, -1.0686361389594567, -0.20975720349025595, -0.6956950513017084, -1.0963343562424943, -1.3916636780037577, 0.17352993283720755, -0.18571778903497702, -1.5022847227462894, -0.053245014937228725, 1.9111127620497508, 1.2675480961985697, 1.4412051615592438, 1.0065885275143103, 1.3874968534790222, -0.07982739191906217, -0.8845570309180288, -0.2829718019927104, -0.40064484208553514, -0.49727279202138763, -0.6910017650944704, -0.017025345010638814, -0.5510359894806698, 2.26090691157161, 0.4223574569509624, -0.4059993284285066, -2.317066591411285, 0.9757970538749522, -0.8632524504409292, 0.3274850645686717, 1.1413464234519897},
    {2.513870854438136, 3.09304544215393, -0.2000436257044768, 0.08827509252569268, -1.9935599775296462, -1.798167995238677, -2.8969607325923854, 1.606835409717654, 0.3765170210211835, 2.683896412110206, -0.2757444400633377, 2.2968153293588776, -1.5810732861173082, 1.6698453480298145, 0.1531553168142825, -0.645061107820527, -1.698994060458286, -0.356053367233819, -2.0736026992002095, -2.7503736857213315, 1.7671563396772143, 0.8912738788603113, -0.7616627059855593, 2.9607113459570664, -1.249183544381273, 2.156844580911581, 0.8852225183096909, -2.2754472695625823, 1.2361546515969841, 0.3432338912645579, -0.7831393252587711, 0.06178602353736452},
    {0.8581010499108122, -1.1163618590388462, 0.17784023466371773, 1.439177827090416, 1.1862222391560193, -1.0867090729215028, 1.387649311337346, -3.2401914479331264, 0.4532232857620023, -0.507874318968592, 0.4617938134753928, -3.4567637969071225, 0.020563971887231018, 1.2499488654771862, -0.6557433070473733, 1.85991411425777, 0.11568370801005926, -0.20782999495887133, 0.9428478093520888, 0.4075990096663047, -1.177535885797362, -1.1173565321389836, -0.42728829612357044, 0.06648865520401159, -2.378163192850961, -0.795812265661582, 0.2302149731460115, 0.2877785700376769, 0.5858791233751037, 0.16495040373293857, -0.4095643860905743, 0.12831186116531093},
    {-0.697146545628842, -0.8438123751063209, 0.23003128178733198, 2.21619993516936, 1.3195008734439457, -3.2803965966367126, 0.6803889224405615, 1.9801494183470658, 0.766563871974678, -0.10211232568649499, -0.12073192410227832, 0.6931891872073552, -0.1329974187264719, 0.05475572583892865, 0.7931224689660014, -3.5854429749988923, 2.51097253726764, -0.8180458991566443, -1.3909322344394104, -0.8217786752363264, 0.24888652618743026, -0.02138078043505323, -0.9417050616003297, -1.202479369056086, 1.7673755789467864, -4.280228657483404, -1.1165951721952936, -0.9259594645446262, -0.6999695530662169, -1.4963348852057907, -0.855055988513493, -1.5652463372029706},
    {-0.11421614159790017, -0.0576825482736527, -2.852023846744376, 2.168125052282124, 1.1510809121357912, -0.6270905238798227, -2.346054611392908, 2.2765589743462384, 0.5080768960245002, -0.6805738622594759, 0.8283834660599456, 1.3725065321292274, -0.8494831977567379, 1.2512034728383628, 2.330759988219124, 1.5972515326789058, 0.30316282067466954, 1.2242303005646873, 0.7709369031145964, 0.46001479828534897, 1.7074486669541573, 0.9003035351878005, 1.4546773876381414, 0.5787651157645, 2.0842469608144683, -2.6733032728265114, -0.7419574986213567, -0.002715841495623458, -1.6677862379220316, 0.5317170677977092, -1.5947300468242818, -1.9688223686221122},
    {1.4383447957557942, 0.7952734785417249, -2.1913255495439423, 1.9639205506120374, 1.502845812985037, 1.0743932525890014, -1.4997716889614419, -2.7047029220081784, -0.14187872135077184, -2.0170667464826044, -0.36263358444917904, -0.971548662190688, 2.645750214292221, -2.682159845297018, 1.8317225469820502, -0.8240030334054875, -2.155350304737228, 1.509816295350483, 0.7466307400699594, -1.7739403573786328, -1.8979176161241984, -0.24723179402578116, -0.2481144798257648, -3.095680907126291, 0.5701657147671618, -0.2370698382337239, 0.27035282458027154, 1.583303727229854, -2.554564700150889, -2.0293623850722295, -1.01929370854957, 1.5974365862571394},
    {-0.6967860097426468, -0.4522753287043683, -0.2562005666426668, 1.5359049638013225, -2.0080828049219903, -1.0480619297609222, 0.1804775913403659, -2.4834407078205105, 1.083936224827721, -0.4587572221524912, -1.8563033341450412, -0.7940249194590854, -1.5790223711240075, -1.2848003134581576, 0.23231095926875234, -0.015892636289819222, -0.5764178833761889, 1.69138389210908, -1.425279088372978, 0.19555375928737417, -3.804015249617256, -0.02425341651099954, 0.08103222339583514, 1.0490111143324523, 0.7737734818751728, -1.4184491813589888, 0.9008176339434405, -1.3487826455177663, 0.7135472419065695, 0.7051327148071638, 1.2692611711325057, -0.7614969950680359},
    {2.154718097966121, -0.7556745375715705, -0.36628180116478826, 0.6908752113140336, -0.7366604371461749, -0.14675371707713328, 0.824806781574033, -1.439488340961731, 0.20666807456689082, -0.6180957108870623, 2.381822560678607, 1.0910228880731994, 0.35362078358380594, 1.1617905019559966, -1.2853777952962218, -1.198490881766877, -0.3407167334533998, 0.09845879668079915, -0.9767015404095349, -3.144128519963082, 2.4305247089114186, -1.9191949507295887, -1.4451603255322047, -0.6224670844837598, 0.2286915222590544, -0.4277139378388024, -1.8106413316597576, 0.025584420566134757, 0.8391674334219564, 1.7410270254212208, 0.8544760881319505, 2.0039304837760716},
    {2.8141550336731074, 1.182657129571165, 1.8165908624203289, 1.4325029200211246, 0.24196746507197708, -2.9802336711531874, -1.9358149889234204, -1.589914163851912, 0.5972416951152254, -2.666332710273681, 0.5093391479915867, -2.4241197153274614, -2.3242261529331145, -0.6728129097886334, -2.030223150172278, 0.6027042707935055, -3.343100086431089, 0.8199840012416676, 0.5518004368110684, 1.642195302879383, -0.994397553951999, 0.5542432686360831, 0.9882443891217771, 2.749806292755641, 1.7337323799634001, -1.7501053635836363, -2.2406904972333725, 1.5108412415843695, -0.5965257733256666, 1.9249682342953331, 1.3850122946075567, -0.10709026846658465}
};

static const float b1[32] = {6.111098356235625, 6.451407324371289, 6.4832952374896164, 6.6296538729192855, 6.7437241310518745, 6.460101437559196, 6.060024844203978, 6.521698888304792, 6.302273752625917, 6.593731956799188, 5.25594818416874, 6.667062955650057, 6.28217775060272, 6.6817402107031745, 4.8218720904073225, 4.962940248680108, 6.7171599671775315, 4.344932400439757, 6.857975357068123, 6.678625025523926, 6.387227495341935, 5.650506968924257, 4.3114845091875, 6.291586994195028, 5.586738601447486, 6.241758191743223, 5.8802445214885495, 6.262613874015304, 6.540680446980154, 5.2690851801900305, 6.088328836252284, 5.082024304772702};

static const float w2[32][16] = {
    {4.930142038511519, 3.720375057662686, 5.2477735483345365, 4.853046659362098, 2.245396339659209, 6.874453268536969, 4.079634655461234, 3.439908228758581, 5.327225004044947, 2.6948151694255746, 3.02619117191094, 4.69836020423562, -1.673382834633237, 5.258195281822023, 3.479102823375762, 1.8051584855571896},
    {3.7076552526091264, 4.488898016840866, 3.414984305930544, 4.0729026112744044, 3.185311786080642, 5.378926472482474, 5.828981034244754, 1.6209571370398608, 5.378254791075972, 3.3593433697946633, 0.1347499537953739, 5.854645201757445, 0.4414260649972529, 4.3504846482859, 7.343273493854957, -0.48865322982725223},
    {3.5522085454910948, 4.624992504947236, 4.43677699073046, 3.4993490974646764, 3.843182459498141, 5.694373168762453, 5.356356418118182, 3.783812136256137, 4.459488375667208, 2.691733999584568, 1.8056831586082187, 4.4401835113891, -2.0127436519206143, 4.991818229123002, 4.382854435052567, 0.7679218623843725},
    {4.112667750681368, 3.801539156940306, 4.671114853543434, 3.967959227719205, 3.5888176480851035, 6.281419886858912, 5.433575440722169, 3.0205155493880067, 4.849591650074079, 3.6036146756454146, 1.3535483166964795, 6.408663128976201, -0.46198810470274326, 5.797495135389384, 6.080975987218625, 0.2447485152052738},
    {5.0992863252942415, 4.902829049154713, 6.232855642615193, 3.761839331994161, 5.07027494761692, 5.670091951862009, 4.168199043619762, 1.9240082826260858, 6.520142714612688, 4.499838997343598, 1.4381452146888691, 6.318470622316666, -0.36170908272434993, 5.018922360653353, 5.7662934434145265, -0.6935172693206813},
    {2.4739474142472773, 3.8900182302115853, 4.81790824073999, 4.098248725872579, 3.8998963540714797, 4.603328042946719, 3.409016118724732, 1.2639781878785101, 3.8164051098885863, 3.307665030352288, 1.0640199908031, 5.942083406613018, 0.3288957292125997, 4.838799958075784, 5.610648373113016, 0.15271568277530465},
    {5.022514282304817, 4.244149638533813, 3.4209705055383313, 3.139531761028321, 2.3269249477939704, 3.693187994675905, 4.513301850697611, 2.657276029410958, 4.8397281857602295, 4.32451449138675, 2.3606353963056574, 6.035091221744959, -0.0764712507761556, 5.916514075076145, 4.1733372475373045, -1.4968045576955282},
    {3.034947382092995, 4.221783557667186, 2.4924358853771946, 4.0316123499019225, 2.235106036490648, 5.668223062567627, 4.966350944663548, 2.7773949615061992, 5.011942422777314, 3.4552034508350555, 1.4807569107871503, 5.9189372242159966, -0.21368042016243105, 4.403350325762718, 3.9198342558990213, 0.08559295775550033},
    {4.260234781557501, 7.52118640609004, 5.759990829429816, 6.446317279093512, 2.903337641811094, 5.595829503982605, 3.9161097664097837, 1.9594608580881994, 5.698369363342824, 4.867784906050799, 1.4023290446625187, 5.374996316647307, -0.6908710691448653, 5.549845557731745, 4.748077690945925, -1.347708544283706},
    {4.208237249522079, 5.281100579901209, 4.9653633536317265, 3.4096898088435275, 4.597848791798931, 5.736896752867333, 4.193139386254057, 3.2558232374463967, 4.826626622216797, 3.4226388939937773, 2.707053256298295, 6.630452806078297, -0.21974666569884332, 5.597842561396106, 5.134213645312406, -1.4181790890812391},
    {4.598302135521716, 4.17055455417176, 2.4955436098186805, 3.315291860090008, 3.206858237172584, 5.792294863573994, 3.382097568185857, 2.7651933808491878, 4.551033513306092, 3.989818345838814, 1.893101230810852, 3.053391043447779, 0.623853904417364, 5.02783257972671, 4.476872197601984, -0.4114392472342628},
    {3.301974136862223, 3.225394962878072, 3.4761939499514796, 4.16239623134251, 3.7819820943275584, 5.525521437200817, 3.8520884532105755, 2.4931435089268956, 5.083577982337001, 3.3057564458785658, 1.1857650149297845, 4.957842721330934, -2.2871515152777993, 5.270608031415015, 5.836181191949541, 0.5288326167953136},
    {2.468069175546965, 5.122902732568901, 4.090842572602209, 3.0025332157565807, 2.476307706520722, 4.881401478616515, 3.5278989805645593, 2.463168234170562, 5.149099130103682, 4.8800779092717725, 1.6712951308735793, 5.5320212141339935, 0.342750430284964, 3.489339862667232, 3.5176574848723585, -0.9068520615190208},
    {4.398514824754662, 5.184787216129743, 6.725885547647283, 3.2293417650923475, 2.848866575946214, 5.502327660725775, 6.101817564164358, 2.959921358583968, 3.3043828804932653, 4.026176865706258, 2.0621406781915987, 5.298486666110602, -1.6422926061384018, 5.578065567351432, 4.248687172857967, -0.8953369786371604},
    {3.9766440835571095, 5.611362899074727, 3.9264361233738194, 2.8816706842362474, 4.192679019465868, 4.24283987967582, 2.595341448699077, 2.0444785991829324, 3.9160991633873268, 2.604102534564321, 3.4436479117990784, 2.682349340103165, -0.5450503078844506, 4.838094477926132, 6.3222541311938905, -0.502267710201166},
    {3.911798140276659, 4.121021937830207, 5.9932698235793245, 3.944305437675335, 2.920977937739651, 3.9911303322806106, 4.534330626213037, 1.866583662713676, 1.8982438037327962, 5.313667617223735, 2.796735718890942, 4.308945788289424, 0.901741097570931, 6.220215347404291, 3.8582979566711546, -0.46379896200034987},
    {4.683742108547002, 5.871532955055983, 3.5980745886164525, 3.5811470716391103, 3.838162197929002, 6.222520156014262, 4.884804735356758, 3.565134666212679, 4.479774118805708, 3.083349518514127, 1.9414380651085494, 4.915337144872317, 0.18935347334446334, 4.847098381709667, 3.3971870827212824, -1.0771452891141253},
    {2.8016959522144576, 5.3773788802214515, 2.877021199965116, 3.1410328152665206, 3.351420753786233, 5.032808705610711, 5.052764873989598, 4.495748799472243, 2.761077595350757, 3.248176112447299, 1.7098307650974758, 2.308070740328158, 0.6800407009111047, 3.240292444920063, 3.3976040069116555, 0.15620540826021118},
    {3.8510003813977383, 6.374049689695671, 3.1967260721891724, 4.850821117661271, 5.327128214688963, 6.136735414759865, 3.966216667594414, 2.868569748835007, 3.5251104341914195, 4.1122956406496876, 1.2630270677615103, 5.962857033418048, -1.1180618298407543, 5.169841496497371, 3.8823877113121528, -1.0607303377462565},
    {4.153569085183963, 4.437457611522868, 3.2430570325239305, 2.3975802501139043, 3.1585647951748865, 6.121310088573817, 4.296679376387092, 2.476015514436574, 5.2450621543934375, 4.368487043907539, 1.0105970443525083, 5.846646932406101, -1.0624593124638881, 3.973922263936366, 4.380527627606414, 0.8481946456446511},
    {5.017958195554644, 5.061499526343268, 3.253174987326735, 4.184848014503879, 2.639343313217933, 4.591987069206334, 3.707059622098423, 2.235997998784197, 4.4963284147029645, 4.419356164202109, 1.484871882274371, 5.095859435159913, 0.2582678339465532, 4.71123080308271, 4.783293494597446, -0.3584290522580185},
    {3.3884665939730723, 5.560383803005398, 3.9714217796797713, 4.007439712792477, 2.7941498501220114, 4.726469739042503, 4.915913781898241, 2.3254847849351092, 6.103203682401182, 3.962297642287144, 2.1821965547867985, 3.726352846441416, 0.2265789348307835, 3.344199628728897, 4.794627090714063, 0.16674871216360015},
    {3.65413131687477, 4.078876122316581, 1.4358001010934023, 4.0052927567499275, 3.697724017739988, 2.4661785803413014, 3.587341441059224, 3.8288857684248963, 4.723630648229322, 4.012696918673769, 1.105312325573325, 4.508245574907685, -0.2278297143262546, 3.9194817804654014, 4.719727213459905, -0.8094984300041719},
    {2.9608333693347997, 5.444534185581941, 2.8704109175922867, 3.149623592761955, 3.8186314337069414, 4.3998758496544506, 2.2270232543257764, 2.1840717584638565, 3.835884312874469, 2.910405872191955, 1.4785380521421965, 6.6957375889159785, -0.23793438695930821, 3.6112710889364843, 4.684600567275844, -1.9852076436274333},
    {3.800420190962356, 3.6261001650704223, 3.3018020150505034, 4.590657363184267, 2.424216748452758, 4.8824328623455155, 4.387166073334511, 3.899020638953418, 6.23542443782042, 3.204056236758052, 2.427727917670588, 4.475462966766348, -0.799385532279384, 3.8595009012857457, 3.2187850003029266, -1.3109907661016562},
    {4.211896239744899, 4.445497287634694, 6.252984229025863, 4.299705660406531, 3.6964750743193067, 5.752005759499929, 5.947239765763542, 2.472692712720585, 5.192492491154293, 3.557521262445499, 2.7526474811200865, 5.201317593511128, -0.06263981053599087, 4.074735662232127, 3.445162613416115, -0.5842195652673494},
    {3.702179415315713, 3.528425003583515, 4.999429807374832, 3.4716401708721305, 3.3762918670437645, 5.304624871894322, 5.39753878640288, 4.028024237941069, 4.538361831820141, 2.231004611980073, 2.2238645084866433, 4.186638449113895, -0.6709719193024275, 5.637317405792719, 4.1923413059595775, 0.8708705776073912},
    {4.664534026983472, 6.511753730450263, 3.7747341112483297, 5.091124006018521, 2.3596068461590907, 5.151046552215431, 2.796617649008432, 2.512209017505734, 4.399223694158435, 3.383892703818422, 2.3103249593906785, 5.820588554571566, 1.516837160914278, 5.046816320455211, 4.981420697900972, -0.9873642054681453},
    {2.607488956450088, 5.317240114298488, 3.484512129890382, 3.051173662145182, 3.8528644192671813, 5.93044907083167, 4.048683974934515, 2.219982704285252, 6.004439606667763, 3.182642641526425, 1.1800489988695766, 4.119349593416348, 0.029901238285584403, 3.907221925100056, 3.430644462431717, -0.5266611476684152},
    {4.949108256983988, 3.17579774162558, 3.747938331965897, 3.309963899401983, 5.254099040043177, 3.919685957579743, 4.46499930691323, 1.7145177179134072, 3.208947956361217, 3.9922221596972953, 2.1661620293270243, 4.969710996907605, -0.20146093621263966, 4.880087432347214, 4.749760373953161, 0.8212524374963703},
    {4.500996634702285, 5.774897440213128, 6.323047652534422, 4.513265037298432, 3.927033187969408, 4.623577509411442, 5.25078202090705, 3.016432887905507, 3.730146334069876, 3.214492794508634, 0.8025900076093213, 4.707443317593803, 0.06049957804633989, 5.237634483718804, 4.7261729630027425, 0.2612751294128943},
    {3.046304772398984, 3.9100175978642335, 3.159254180472446, 2.005890229727985, 3.441123464086208, 4.7425649321497865, 4.8995176601726165, 2.8639719453463863, 3.9428112142864493, 3.489697055436182, 2.920622095874126, 3.0336027346314607, -1.1619867301056743, 3.0659359386165983, 4.662581957454091, 0.16702380175302417}
};

static const float b2[16] = {5.014645366783559, 6.031273052229099, 5.387924980852386, 4.494434498160598, 4.555850535495811, 6.4821942120340825, 5.64048510530699, 3.043940126958368, 5.9851963398872945, 4.351405816132859, 2.5639820510280664, 6.110692923500741, -0.7563328372082894, 5.574910067671606, 5.6818052358743465, -0.5410854036979407};

static const float w3[16][12] = {
    {-3.9168153948617856, -3.2984970120026222, -3.9932343008061095, -4.208579581945035, -3.8361320724632995, -4.207760698148758, -3.203673881334609, -3.2270860000057313, -4.3409580897544355, -1.3426050746739464, -3.441416767429668, -3.2279214430349135},
    {-3.7624546462592465, -3.592947897030366, -4.509647280824269, -4.709756458862455, -3.3773711176701595, -4.2148685300185225, -2.65112447504921, -2.651255900005717, -2.411774637516668, -4.3331309384184316, -2.9986274047006987, -3.356403676747962},
    {-2.656295615931886, -3.6342842024147664, -2.6438428240794805, -1.9396386568406165, -4.703530884922564, -3.1222788164782984, -3.7672894066665448, -3.9505672517496575, -3.3318988376489758, -2.433887005570167, -6.213027250785373, -3.4449655190438953},
    {-3.052372527515648, -2.565507732287613, -3.4726768883977583, -3.76418382482103, -3.232534540262992, -0.3368897655172654, -3.393995563515328, -3.068022807721336, -4.7053115027970005, -3.5713083790998206, -4.809367573698057, -3.770342278400004},
    {-3.5385865244394545, -3.9171089968477135, -2.4409135588932447, -2.228292678694646, -4.304318134322419, -4.383066336641114, -2.7443561608245814, -4.737580174996779, -1.9817224467198142, -2.2951013023302687, -2.2007365401820675, -2.732145186286875},
    {-3.0286587982916413, -3.6383565767675115, -4.7069943528946485, -4.095455565615395, -2.459130786452351, -3.7958872490523294, -2.5110569527118956, -3.9823622876154063, -4.131675873642055, -3.7571169894794387, -4.406239920691352, -4.705713120105829},
    {-3.158016567490518, -3.4754588332751086, -2.6590070001473354, -3.8483569952047403, -3.3673834935523383, -3.319667008979006, -3.241537447672621, -2.036607546390787, -3.5547557145600357, -5.62443777454446, -3.946609886070751, -4.295157452553586},
    {-4.1584552414916764, -3.179942896846404, -1.3616005180769153, -1.6249275671422458, -3.2994250509900724, -1.5440784744512126, -3.254491219533445, -3.1193626846228186, -3.87165230904584, -1.0226896498704954, -2.2041777641196734, -3.060091125372672},
    {-4.564286523031295, -4.0961691723006135, -4.046882610739677, -3.08844390265228, -4.842406137413186, -3.291241782320389, -3.366126499693084, -2.8852157807335077, -3.204983730093593, -3.841783906080293, -2.5383433339513988, -4.513955134546661},
    {-2.164696266816438, -2.421872362771326, -2.306463383212398, -2.14261775789254, -2.126897908091658, -3.213545358829098, -3.6643940057831546, -1.9947332128575437, -3.8518093645838847, -4.162632375428941, -2.540538047085555, -3.6667084241194523},
    {-3.0247400502217427, -1.8173742828674362, -1.4196075266706791, -3.046589421092448, -0.47924526885021945, -1.7148949588772329, -3.1176631328682487, -1.581144916150682, -0.6916001677361004, -2.3714292928208875, -1.2896191980317782, -1.340264609421768},
    {-3.3202727088721797, -5.017387903241231, -2.410108495270487, -4.7867420608077325, -2.6835721908830608, -3.567444956866554, -6.0088330850838085, -4.790803917977874, -3.575535413892414, -4.113892990847711, -3.9909003338808615, -3.65542125002843},
    {1.0774309719329496, 2.145281874083298, 0.2681716434491949, -0.4125011885763007, 0.3169676735141857, -0.8963474464062176, -0.07900943736703171, -0.9978185044845356, 0.4064829186354926, 0.21085934375367246, 1.8119951332400552, -0.9478034824019711},
    {-4.360062909143902, -2.5620531658536967, -5.403175268173901, -4.030623568277435, -4.13754389145253, -3.8577864906499473, -3.9058457415382186, -4.565212498409483, -3.7478298475954173, -3.9579102071069876, -3.2510364553841926, -2.005707369045705},
    {-3.2097850595171504, -3.3847078004576043, -4.040090356467901, -2.869712696104792, -3.6470923740208048, -5.503035323041921, -2.800321315235729, -4.017605181792434, -3.2134071571574494, -3.1362138357460476, -2.3463705709686122, -2.6682635693552945},
    {-2.871393070236318, -0.9531399463764796, -0.24173471092933624, 0.6164385266566675, -1.529931527880284, -0.07423041747370801, -1.5670988228835918, 1.861031013488086, 0.41845726285207485, -1.1337024307141015, 1.1630258087554903, 0.7513088055385095}
};

static const float b3[12] = {-2.5029548447927437, -2.807776661842437, -3.0032466500314197, -2.544639295092053, -2.6940084393999033, -2.8474552679960943, -2.8466331241958858, -3.0252167276055433, -2.455436413405636, -3.001584472415993, -2.6114323749960766, -2.7662923870048277};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
