#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-5.751458314719422, 1.7308324361014649, -2.910215972701864, -2.435620032375472, 0.9878555878464859, -1.5505000404441678, -0.9446667703012661, -0.6787506538732475, -1.882563824143437, -1.5992221031712872, -4.6632492962178915, -0.7056013246119335, -3.2114822102299283, -1.5314890327884574, -0.03014595940710303, -1.1096554845082474},
    {5.816917083119512, -3.5794127738343735, 2.450431229881745, 4.467525121970881, 1.1461030803381793, 0.43762455194065164, 0.943813616519252, 1.7585757038795615, -0.7487844979267183, 2.4195207247184154, 2.7459238986651475, 3.5639171479601472, -0.4378919942047889, 3.8834154570485064, 1.5137922253340754, 0.718652612118425},
    {1.8282152504725304, -1.1929930961825002, 0.2046169005402875, 2.209847723522929, 0.8172798293164415, 1.7729172507550128, 0.7935412717341881, 1.3296748355476569, 1.2690516063957322, 2.096977845512172, 2.3814749239920787, 1.4103293451759908, 0.06772604388966125, 0.9758740597017332, -1.4718255552057473, 1.0627834354471273},
    {-1.9805453748439719, -0.05654039270834805, 0.19621911799197408, -0.8343848627466525, 0.0039225275203063955, 0.69145254078532, -0.4915054981073854, -1.7410183293455759, 2.1293002105493777, 2.897928399997063, -0.06061939014908818, -5.0251096322274735, 2.6479550464043053, -2.0243424655279383, -0.6665375765902669, -1.669870618764576},
    {2.4981352114552036, 5.331731106523855, 4.130215475296774, 2.162684796809242, -0.29721108961081916, 1.1440325533608677, 1.8165230849759741, 5.106587606794276, 1.7982629498237357, 3.551082967686222, 5.161534358620323, 0.23457869027147657, 3.3015053409880744, 0.025726129777756172, 1.273786238410146, 3.9082398913114536},
    {4.522036191278855, 0.1364411295803037, 4.063172080881856, -0.4905876842195206, -2.391222317482494, 4.219377771809786, 0.18941097557686662, 4.345062160878474, 2.5549624835701663, 3.0074165450810666, 2.01025825231368, -2.627286550702557, 1.8301265795932207, -0.7166682560770027, 0.7987908988781229, 4.3298719104681345},
    {2.0048168625812495, -0.34598479249838787, 1.6143179330960626, -1.0652836738690117, -2.4241063340884197, 4.688895453464827, -0.2560152600500476, 3.5827655609917315, 1.9206459762842294, 2.8917747076980587, -1.5042428390334888, -2.259918071524131, 0.42902477140629025, -1.5391627465433502, 0.06375164341992123, 1.129039393472277},
    {0.2681302268248999, -1.165905056065158, 3.096075412273453, 2.073092935202659, 0.14979775879000665, 1.3852953244183397, -0.9171593604582975, 1.5706238872810465, 0.714617945675323, 2.7114294002227743, 2.028467553112501, 1.227604907608241, 1.249679580539087, 0.6484835347054105, -0.5133957965625402, -0.9056489317210792},
    {3.020030164900743, -0.3515693865205094, 2.7378912043346992, 1.0380965141591472, 0.4269436324711199, -0.9444734204009451, 3.8402903660974723, -2.8629354509283425, 3.9479540724377187, 3.4335094144296834, 2.822124260047103, 2.99454565962169, 0.6081398426083084, 2.8352597337788925, 1.1684423528160124, 1.5103096546946857},
    {0.9707591467417344, -1.6291599613515797, 3.100522512777847, -0.04350364008799282, -0.31859422712350216, -2.0479694004858535, 1.1380439158584466, -1.9301884438431638, -1.0321758913418366, 0.8004330899863953, 0.10610358145964471, 0.07873384892986254, 3.5574598987428345, -1.6818397826740532, 2.4557486030402456, -2.1933957593691207},
    {1.2375342873699362, -0.9544524337258549, -0.5409462092511647, -1.1279839474797164, -3.0093321085123086, -1.1617962913182107, -0.08364266330313537, 0.8814022987931529, -1.8559038330993798, 0.9062544062160657, -2.4408020097294987, -0.9910777294457711, -0.5699318290781002, -4.3001480229736, 0.1599902208871668, -0.7931843344766534},
    {-0.14704707481410584, -0.5678343801544776, -0.26870341889439303, -1.5995962199774627, 0.13038384145141357, -1.0655910899340322, 2.84481069094157, -3.192305755076364, 1.268381797238557, 0.07649986017751965, 1.8641433026325913, 2.608217005686144, 0.5330691774991229, 2.3146867846964065, -0.3232315495663254, -0.1650888081773371},
    {3.739494717988891, -2.297605974639213, 1.2073425786596717, 0.7224599622233475, 2.5134855594826297, -1.0434949692900173, -0.7567952686758921, -0.6983167350437474, -0.8949630513251792, -2.9912073819453813, -1.2034988557921562, 2.3530165022804814, -0.34357165012769036, 0.9422246147276897, 1.1089692948268062, 4.161170788632043},
    {0.6594131938383833, 1.3309958727469313, -2.5150856986825216, -2.3306526560000296, -1.0943498267907876, -0.9793336070497086, -1.6997728538591985, -2.7995115334127316, -0.0706570487891484, -0.6103863318855859, -4.467065934149064, -1.8799573951662492, 1.0351610699488367, -0.48084436490464033, 2.334534223909866, -2.2226404553808243},
    {-1.9814235015672779, -0.5745568869274569, -3.182819188730979, -3.2205694498224413, 0.45526900718481805, -4.84473430784859, -2.056610100048477, -2.1148045515657916, 1.2114200626726999, -0.6303143370471931, -2.087688429568136, -4.96126612321301, -2.328344103736336, -1.9420122618309243, -4.431008492934304, -1.9698674362358453},
    {2.2602936940060996, 0.23056033848759966, -0.8631454622616707, -2.38390694074374, -0.5212076540727524, -2.1040881491351415, -1.774070092946647, 0.06988547808268286, -1.0514557152532076, -2.865721851764829, -2.2875936920474436, -1.6350411061438417, -3.026686167822519, 1.7536540906028677, -0.6382352022498443, -0.2446522675625978},
    {2.9185141648872133, 0.053444105502958646, -0.5212847214317405, -3.43362404004377, -3.9551582365160947, -2.579166131117302, -1.886550003338548, -1.7457977423223825, 0.7669755859806294, -0.939319511706501, -3.008009146514665, -2.89002796889422, 2.4451923088716594, -0.06642974356084748, 0.24032135848001204, -0.8621632387388496},
    {-1.619814717543218, -0.24111584407437012, -2.6284600283032717, -3.9408526905359347, -1.4717596607427028, 0.4197436237709303, -0.5961386920332401, -1.6638319014285314, 0.9569275409735388, -2.1332599553571643, 0.467275895299573, -1.382944472711571, 0.4544408451960065, -0.515612853105089, -0.6215208025883293, -2.8830870047810553},
    {-1.5056731233097658, 1.2921837997125047, 0.5763333982836352, -1.1822278400290693, 1.4577452432555986, 0.6838374027258182, 1.816698986840479, -0.8999413454482695, 2.362720362942552, -1.7947537421197592, 0.8773814343735935, -0.3087040185212086, 0.4497586981072406, -0.14128612399213092, -2.5077359291897596, 2.571365722902193},
    {-2.269365677368566, -1.6093491074278037, -4.54063831770606, 0.06080865880258738, 0.11611037984859036, 1.1208342236507447, -2.103070327849442, -0.590910857103809, -1.0344313078804996, -0.0802275530319833, -2.7344062876935222, -0.7088370495429819, -0.4348363330940577, -0.8440818492835349, -1.0835786362319217, -1.0613841049431316},
    {-2.8913438975759247, 3.188603886106255, -2.778606067470762, -4.251339930841605, 0.7548515713080176, -3.109300253021998, -3.0595078471296255, -3.067088980527539, 0.3548836567249629, -3.0294782907499846, -2.2316524526115673, -1.9484220065156053, -2.090110981709761, -1.9978274470338793, -2.892691452620768, -2.7822407549809305},
    {-3.941941170221427, 3.2254711979016726, -3.6685448984852056, -2.7460395306752154, 0.830652641265099, -0.6311298651708974, -2.9796853318658965, -0.8317724671494449, -1.5695992100561367, -3.2162584334123134, -1.5764509863650322, -4.445900050175411, -2.1284459211041256, -3.8580751638320834, -4.1654903615384145, -2.3262418129628735},
    {-1.320263630868909, 2.091058034757068, -1.3108585751326909, -2.6545728264103974, 0.1114958634069716, -4.224540258216102, -3.1584204002347054, -1.9631509753105263, -3.5086466328293913, -4.399085465350015, -3.220798914844405, -2.5251412379219333, -3.3442822864923154, -1.5427173130703913, -2.1436982642655438, -3.8865816953351753},
    {0.6603149726917562, 3.09243760933966, -0.7601131338911131, -1.6210005177000175, -3.068658168856568, -1.6839057915093985, -3.0252744836932726, -0.5121258323394576, -1.9089169322172437, -2.065187951355831, -0.40356436101023113, -2.1379680989463545, -1.8549374164312444, -3.874595339079119, -2.706917842443325, -3.260953335244114},
    {-3.219325485556559, 3.224788634797549, 0.3474338034056366, -0.6893947305339523, -1.567059004746047, -1.903944381650552, -1.2879400295889578, 1.1432391714382222, -0.5638946614994875, -1.034043936084609, -2.775997355755829, -3.230461479961128, 0.798319474428181, -3.696733191270059, -1.09204765884228, -1.257413130036022},
    {-4.333310900675427, 2.4063536730371897, -1.1129874914858628, 0.7015763093099138, 0.6913878395484698, -0.3592518636299443, -2.780221636582862, -1.5603401901345015, -0.8181867584703842, -2.3609049473014485, 0.7899890161140616, -0.5108201136606975, 2.770239467069452, -1.2119354697432734, -0.8226864982619527, -1.6412548404769842},
    {-5.704373177470977, 1.5195251808546197, -4.713328647053121, -3.2686695228929032, -3.0449540344873145, -2.7814436775596403, -4.602131580179037, -4.8287514734914705, -1.7205100196573992, -4.0673421645411505, -3.1121130993501493, -4.31055514000915, 0.45747789724685, -5.108930571099083, -0.6606737637589477, -6.147420985324882},
    {-2.375187889408188, 3.0694364670098535, -1.3637423011727654, -0.08776647973769079, 0.29111388125558, 2.349284798241262, -4.150541011936724, 1.8532030823127708, 0.9253579679639767, -2.81262034994195, 0.12552546179663615, -0.043369849112273144, 0.12756863450448497, 1.0879357954313302, -1.613379216218032, 1.5752912190613386},
    {-0.5256964152538904, 1.8686456236013358, -2.00636040586842, -3.5730708053426263, -2.673375279278722, -2.983681996862731, -1.5451509667466496, -1.931274613868249, -1.2315561345622228, -2.190832326806561, -2.3071084062807485, -1.1498575910331972, 0.2465680545457904, -1.323379710113281, -4.133669176059029, -3.9013135601900593},
    {1.2104552060630085, 0.32917736416976984, -0.8694027655792773, -3.824242269198313, -2.98413169395475, -2.101130317255018, -0.11328699642863356, -1.0430497179236404, 2.059303865123831, -1.2247221556096561, 1.3452159842794222, -0.25775047354638037, 4.099352947824844, -1.4921493615706558, -1.0721770159217863, 3.333917113465662},
    {-5.245591321825877, 0.739232002167186, -3.554920292872771, -2.4264994856165565, -1.131879335928184, -1.065448564318088, -1.4587463090489667, -0.07216274674538158, -0.0262568740643356, 0.12985355603806356, -4.633200647033608, -5.069066923916882, -1.4451433734928998, -4.229929123423268, 2.418484028755909, -0.3424648476598558},
    {-2.913023612138309, 0.08311404389082752, -2.027132677404977, -2.132181393605477, -0.10684168772202715, -0.5357505803971189, 1.8702897317228075, -0.9632932878824495, -0.9961775409766108, -1.142860170771614, -2.722807776101654, -3.575403598977552, 0.2049376775283351, -2.3214926295792577, 0.5294606857416634, -0.5576420586203824},
    {-0.19523079978964197, -1.5023100574095893, -0.7268092733763603, 1.0850083257825542, 0.41477222608170106, -2.9440182411609226, -0.615574210768906, 0.16930449102174477, -0.14142944599462834, 0.1967156019021333, -0.11311167954850627, -2.974266901520002, 1.3277062722945656, -1.3841540857780346, 0.2576198891408851, -1.3071027011863},
    {-2.796836472258149, 2.9871227886247502, 0.8544310554272739, 0.11425634032839939, -0.12375863816138909, 1.7005167996595778, 1.169893711962831, -1.6983740176024547, -2.213856255520697, 2.7334810756691104, -1.5192169634031591, -1.731379883568402, 0.9560838243214057, 0.11192742824946215, 0.506276039868291, 1.8409861485036103},
    {-4.082191097169147, 0.42262241538547995, 0.1375866273431684, -1.5001239413088256, 0.8340785264208294, -4.715375358841572, -3.5148324640838764, -3.792698844213088, 2.185059069808451, -0.2500916710112652, -0.5673966473464377, -0.7579358440643779, 0.44266071202892016, -1.9747517168125843, 1.273586448028703, 0.6601089243159431},
    {-1.7213717440359948, -1.392722557057719, -1.141145249873854, 0.49778173278248744, -2.1527172803236487, -0.16931435494037875, -0.33975264565594815, 0.13759976459474663, 0.3199673628195896, 0.4850907749496798, -3.0889709713921922, -0.4871499293507131, 0.9376879294484036, 0.35225191787646865, -0.001475150106127993, -0.4839340479980658},
    {-1.0266073896586607, -0.14563047516885763, 1.0743952570181787, -0.6136735269265933, -1.0533385116591936, -4.118951620994725, 0.3667086779597576, -3.5951795960877235, -0.45012102608939675, -0.687073382357288, -1.875090641729933, 2.3861832201097215, -0.18318923711312324, 1.0758509461253394, -0.004233809035221089, 1.5887274451409839},
    {-3.182359018808375, -1.002096162437238, -1.2228781111732343, 0.30634607266166397, -1.0989354519109078, -4.494196711781953, -2.9688229181600843, -1.1512358687736843, 2.882666127328374, 1.1087959531943008, 2.1216276950184914, -1.2856532811692083, 1.4766083632603977, -3.18476181256709, -3.892029499682137, -3.1825049022913365},
    {-2.1955528707093563, -0.6859133357025441, 0.38463433899104915, -0.7502551307310424, -1.3576123003497862, -2.12253363214638, 0.4055177553481626, -3.028701074416677, 0.11896601392624684, 0.11551598264657377, 0.5014679984607636, 0.3998169233122257, 0.32516698832630564, -2.0755123959421495, 0.4533818174120664, -0.8901936010135721},
    {-0.2984823086882338, -0.356652203047088, 1.8129506102319304, 1.3795310791910307, 2.7045237509478888, -2.237274963148878, 1.4221279029546372, -4.640807640304398, 1.3483258447184652, 0.8798640614353705, 3.2820092321558825, 3.0523364031416573, -0.040685236927951514, -0.6749827643744087, -0.9850928491644421, -0.5804842821092857},
    {-2.5679827791660172, -0.037358072219965406, -2.0282913260478193, 0.2814462908417035, 0.8741057106280421, -0.5569334391189152, -0.5866771975004009, -1.2952543414715745, 1.9438970976349428, -0.5761481800209532, -0.6482649746868788, 2.4061180636954673, 3.085282984028441, 1.3256305183757509, 0.1595165157720957, -0.11914062601535663},
    {1.5709578167006992, -1.0701956585071593, -2.259175039852128, 0.9700329057811807, 1.4201523711602153, -0.04643903219652893, 0.3093047287084022, -0.9846656527775989, 0.5796108082198267, 3.8151257976293356, 0.25900353861245723, -1.0977612760526636, -1.7901986411700257, -0.4694137687178404, -0.7247320110707729, -0.5900519673466621},
    {-1.3733090640328052, -0.4425825837241028, 0.5051610728967878, 1.0233346945266186, 1.2469877283707245, 0.6707585444224928, 0.17363448199682385, 1.6410750687009497, 0.5690553743525462, 1.0524240702244094, -0.7325177266806633, 3.0984053581829047, 2.978192207861373, -0.9205137332504446, -0.11442595627648162, -0.30595438366552546},
    {-0.34193401741151813, -2.0338258558799907, -1.2587490364757545, -0.4973810514139352, -3.501198030763484, 0.894398421196739, 0.008743855681841717, 0.4925823973180085, -0.4101831217172078, -2.770778294600046, -3.3748496932388994, 1.6636086601754152, 4.014775962856687, 2.0060143339880416, 3.2185402031954724, -0.4815568059766792},
    {1.6299523920605252, 0.8380497276562181, 0.6279688820050624, 1.1180067625825767, 3.619606588616394, -1.959777819549451, -2.2216599358218367, 1.521636948336886, 2.2262176716669075, 3.5696079870990904, 2.8053815572761263, -1.3605450642702628, -1.5882356374733562, 0.6195434381877915, -2.4710078319899895, -2.54916128545945},
    {0.2343386828835634, 1.7407352435081378, -0.07286906289777234, 2.575615942793361, 0.7276942351441905, -1.977860363130589, 0.5911196182886469, -1.5056264853203103, 0.038475792893346676, 4.510903044889953, 2.313418909523472, 0.38928801120582823, -0.45530401085529726, -1.0590299380202346, -1.0504767542171456, -2.647639571116491},
    {2.8666713774459374, 2.6354523574811886, 0.38044612481351847, 1.1027327935884055, -0.19416559565428368, 2.1018620085444812, 3.6069933045675096, 0.6038621894023251, -0.8554800211054826, -0.4803008967782554, -0.48109350659971817, -0.8693389407269575, 0.6777762615885032, 2.2192453272648454, 4.439704307933418, 2.867467931860876},
    {-0.7406980340275483, -1.6572643679456227, 1.204861194007743, 1.2795963449746328, 0.2217251012900178, 0.9113951904999057, 1.396798148937977, -0.439327584490018, 0.9555984733920333, 2.8419244368227554, 0.6712480185824702, 0.43402085422555414, 1.2239294521492978, -0.732309832796646, -1.5702213382839498, -1.8024527897570173},
    {-0.28538904504568796, 2.2108110191956447, 4.779469962328466, 2.3078572878038663, 0.8444422961361757, -2.97415298913137, -1.3546883441209145, -0.18053072922728194, 2.291415738041539, 3.249031651953425, 0.4086070266086234, 2.661902820010667, -0.48879073212203844, 2.7313149187755092, 3.254401996545865, 1.1004691159198154},
    {-0.0880603348099266, -5.435584834098726, 3.9142249317526487, 3.109153842411996, 3.5540890234673275, 1.2746902927938113, 0.3584261728248805, -0.4684585342441401, 0.38546643801864683, 2.0443019839251924, 0.6598230613918008, 3.7197491379652026, 0.13069055315026562, 0.8617184829555524, -1.3648906717138187, 0.7157357308852679},
    {1.1952885247293445, -0.7421868146386521, 0.4075118825836788, 0.6499106244909095, 2.3388646480960267, -1.4267399135380212, 3.4156441733575154, -1.5951729676165447, -1.8662066230694103, 1.054701124886925, 1.2102153548899444, 3.3160111840768263, 1.7676655535285513, 2.426938055219469, -0.3369573978945029, 3.756083184317223},
    {1.717920284048231, -0.0008331953338279489, 1.4516671193607467, 1.4689380621972388, 0.3084880472216311, -2.7383988501615755, -0.1697609985568205, 2.005815724159992, 2.617642541935691, -2.899118566188141, 2.5402907996217543, -0.19396607175575445, 2.3427923925561402, -1.9307861345896862, 1.8437408462253486, -0.520873646478714},
    {-1.465416760078732, 0.08489041057415293, 1.867920854714833, 1.700636950179377, -1.1639671866526042, -0.32409840561802605, -1.042537939056654, 0.33300810252456814, 0.0536560547002761, -0.8460788181920621, -0.10335018530987364, -0.8175570558570279, -1.169634336868454, -0.8423309199110672, 1.1518506177298535, -2.7248427382295963},
    {-1.368719426666454, 0.2794544568002143, -0.5281487915203136, 0.09184154989724856, 0.7615649797278029, -1.7893534204508548, -1.3910855498190766, -1.3665846727380415, 4.261645009669098, -0.6668128318388638, 3.094243596673675, -2.656745891614436, 0.7492772761061689, 0.036782391034609396, -1.2983769964338545, -1.1325423366164695},
    {3.6638983966733667, -1.9078418247605737, 0.2823860090968569, -1.5512475864162314, -0.8280042863533101, -0.6905399607641347, -1.7856977062680068, -1.983930432639147, 3.0130701438670937, 1.4101778960937728, 0.7277331309350186, -1.1423501352381664, 1.5766779093974421, -0.9188299561402188, 1.275439855702518, -1.1461997756698874},
    {-0.6108073001735442, 1.7961834592949621, 2.4786293443906806, 1.6710643812531114, 0.3239551141688377, 1.1002187396560648, -1.5079307159024842, 3.418597458992839, 1.5089283872121506, -1.227029141523055, 0.3784330221733546, 0.26050805280660744, -0.06294174888494213, -0.8109757697046686, 0.7115394196331645, -0.7802677817065308},
    {-2.2465559437668063, -0.332984233990531, 1.6089551705758722, 1.1172321020636813, -1.2046706229288218, -1.4022878598665756, 0.2453957068628015, -2.273210928240367, -1.9634801560937145, -0.9782814199719968, -1.766574460422934, 2.7774704932366863, -1.2116157582210128, 1.4309584773537087, -1.3949370684877038, 1.4834406695936635},
    {0.08140012798486569, -1.9192494216959504, 0.15925834442833825, -1.4349628167145356, -3.6089795406449485, 1.1064168666100764, -2.3430047399512763, -0.6569538800679547, -1.468778884919816, 2.370576498115346, 0.21618184826531756, 0.8555019795686396, 3.2237376413420473, -1.405150666748546, -3.180579484658785, 0.9066957976430385},
    {-2.2873091606059393, 1.7076912413743632, -1.2028581430746024, -1.7822789376810266, 3.421684233974876, -2.3618847245365773, 1.072785242668684, -1.9219522446871338, 2.4207542329597422, 2.055303792862858, 0.7850783164511821, -1.5080343423148597, 2.063177595437582, -1.4826158522457094, 1.973109932774718, -0.9260885530303874},
    {2.556967920805432, -2.014493356736066, 0.5952650316662542, -0.615292217399422, -0.6978725479560856, -3.7023161085609124, 0.02246620566975978, -1.2630782349763727, 2.6405088004151507, 0.45117840792017283, 2.5107188877372044, 0.689179309862181, 2.774321874025009, 0.001880512477429291, -2.0308318282206286, -1.0439646332617827},
    {-0.8429881696315242, 1.402270768891797, 2.3554454564643508, 2.825331363995665, 0.6787796845202075, -0.05076857399101251, 0.5897351317422322, 1.3657173509857952, -0.9361654190065071, 0.5169008995800167, 0.7812510650213946, 1.1889154981688446, -0.8021229739870632, 1.2424656294111818, -1.6955268135040227, -0.9545018510904328},
    {0.6765735081083503, -0.14448001154158638, 3.907303108074243, 0.23273508010467997, 1.073231410879273, 1.9059169480888802, -0.4668842594861635, 2.3017500969123867, 2.8195011765881604, 0.09267506809047096, 0.24549110970237975, -0.23433235194304128, 2.982891254961471, 0.7472130338270689, -1.636673141674124, 3.9511009479376047},
    {0.10853360684714791, 0.6518024191738961, -0.4688516005550189, -0.42039899159049543, -0.7838597853682556, -2.6751773921335418, -2.4594034977166093, 1.489909600012695, 1.096923671288561, -1.5044394505743999, -0.04984789780890831, 0.36209740133149376, 1.0414215883870224, -1.339098467703107, -0.6232019072119319, -1.262907436853274},
    {0.5146429898859995, 1.2580280269054098, -1.754508101408498, -0.6682348338767524, -0.6417832871782204, 1.4749838555480386, 0.5401005239498018, -0.6760944033897343, -0.4416503251188992, -0.8094529614127006, 0.36777775822246017, 1.0346256340188569, -1.1687358558957812, -0.41558988394497137, 1.6253009114349488, 0.8585879059445013},
    {2.0289532303587903, -1.6969920384097228, -3.2430201678096386, -0.899025289687351, -1.2318693361665354, -1.5566831530201553, 2.302767147255836, 0.5457026346884167, -0.18602345627393618, 0.7715010658662623, -1.711319182357086, -0.8813139813476574, -0.06855388801904053, 0.48348823509822736, -1.3945193117794525, -0.7148267316748166},
    {0.5127932909303499, -0.1902157296422788, 0.33461911175718967, -0.3491907447860292, -1.4774243479113693, 0.6386639581927283, -0.6224158233156396, 0.714205592260405, -1.1745617700852198, -0.44240631228558686, -0.8474894748260552, -1.065437442197838, 0.2571468311616082, -1.8460568873441268, 0.2752691284888704, -1.3823347352972042},
    {0.9976254346091671, 2.9520883093580346, 1.0219705972014599, 0.08933367017539869, -0.5132439714568694, 0.2861653003174728, -0.5368345890823923, 2.5741669288661218, -2.2836777013966776, -1.745657068819843, 1.3747903415434455, -0.5918096163961526, -2.668411512628257, -0.33868780235441215, -0.3114631511395574, -2.567733738950908},
    {-0.016441717299100007, -1.7367409897206267, -2.1546542273411378, -1.0147951394712402, -1.2533419101940337, -0.28019299766465106, -0.5255170244382168, 0.5713260527538775, -1.9876741289793127, -1.3085933243912335, -1.2162021314690565, -1.2672698722195956, -1.657461139178862, 0.808853768298295, -2.1144590719505385, -2.559828013046273},
    {-0.8784831723889339, -0.9993627087210569, -1.393459370279022, -0.7409240250156286, 0.7405266611119907, 1.0612154656339738, 0.2508593862403115, -2.1639869177744577, 1.0467818311532728, -1.8268627050544777, 0.903846086854619, 0.8842128743803183, 1.1176216268612869, -1.3278719091086522, -0.5822801130595763, 1.498986980608293},
    {-0.4051979598792492, 2.39578610585209, -0.7521495303493569, -0.793212148305854, 0.9761974393209012, 0.018602952564064357, -1.9509943801513783, 0.37144873472014894, 0.7709745245597085, -1.5392420762297243, -0.051341838541429374, 1.6822159367152092, -0.18653041781363427, 0.510065269618107, -0.2027867355701768, 1.7798287770838868},
    {-0.4851277324354708, -1.0897897707489843, -1.6701424938552474, 0.32168997233997204, -1.820973865553235, 0.3391019088186455, -0.578244035356533, 0.12807709434805387, -0.428075457351662, 1.3451231986935377, -0.5425541867270995, -2.7342064761135596, -1.5631469105900364, -0.7731845993416749, 0.05329644151996315, -2.1890584653013456},
    {-0.468836914904836, -4.8318492660750065, -0.7836772359653104, 1.2221103116991014, -0.37724999038136936, 1.6142783215212826, -0.6180139897472597, 0.37033279269817676, -1.0404706543896878, 0.6867188698473681, -0.16754818321252668, -3.1168320132359515, 0.36890292527125335, 0.7864928365515217, -0.052869204974084316, -3.404111593516068},
    {-1.472972700890585, -2.980860890094686, 1.5556520496150636, -4.091413126813693, 1.847496848826389, -1.2122427901698107, 1.3540789722315756, -1.088197356981427, 0.4972447474654845, -0.7674156855969634, -3.8063782040846883, -0.8469435290016964, 0.8543066675861799, -1.5003687126899716, 1.2094225443651294, 1.5229525394342727},
    {2.087354934547395, 0.1818478379246651, -0.1819278854456948, 2.064985763967447, -0.4888824717286634, -1.6076417516873154, 0.9021116974016418, 0.9631199438915192, -0.09408972202209936, 0.16245129782799564, 0.2909713705697612, 1.8705742282613158, 0.248000617776575, 1.4777555153359814, -0.5948279574644625, 2.0976661777980197},
    {3.308154810196765, 3.376185120576261, 1.610202287506297, 0.06906492389666873, 1.9388659761783338, -0.159139134347783, 0.5424643195277018, -0.9792315109771491, 0.7509881372531764, 4.481766945931012, 1.1174918225475547, 2.911716379368161, -0.08875834160592176, 2.5471022733427175, 1.022337812340695, 2.1349382071740983},
    {-1.3132605747533808, 2.1225303134706777, 0.7446989349299844, 0.8663426804195052, 2.632376655123739, 0.07631144568511877, -1.3885113534154248, 1.6738324206455997, -0.23422174702562917, 1.635388334042406, 0.10647277134608826, 0.226299693020616, 0.6852762947572546, 1.4245100085520026, 2.0502515581261913, 1.86287493219007},
    {-0.13291393742428945, -0.6029882508341718, 1.3531896771241516, 0.6675038114076695, -1.6332409758657418, 0.27178242344200204, -0.5592317979555051, 1.8368624621858056, -1.5769640970404926, -1.1278528061698367, -1.62466126595235, 0.20672137862154918, 1.3163989709607342, 0.18134835461788074, 1.5784614844075713, -1.5393980639417646},
    {0.21731148279895748, 1.4660148675159068, 0.13996039881685368, -2.5673318630499145, -0.39058060614627843, -0.038505132664625, 0.5885754031966388, -1.1055778808680419, 1.7929853124880726, -0.8849810757691317, 0.9376310878320469, 0.2541237920785754, 0.25338787126965195, -1.2763742039644181, 0.3292936515240998, 0.36558741462007116},
    {-0.564335739615753, 1.3018682108744404, 2.187306307000229, 0.2847736185205637, 1.9175747585238558, -1.2836624753738355, 0.8159260665560847, -1.792672727311138, 0.9263849773536538, 1.3536071325033734, 0.6199068401392288, 1.3261888563302917, -0.43234575260008623, 1.9673967639725398, 0.25876184830749954, 1.218169322732164},
    {0.03900077724818646, 0.450321407686748, 1.484285950545259, -0.39768827419071223, 0.03783136805583093, -2.276021308906731, -0.5887141386369479, -2.5368878482631523, -0.3565606462085744, -1.1987809751622942, -1.2512966457219243, 0.6914572399857043, -0.1723270211423054, -0.007965697306467297, 1.7681358792419926, 2.8961495654719056},
    {-0.0005621078671970379, -0.7320494526169877, 0.7244394659416765, 0.6735928901248042, 1.9890855058156576, -0.30296714097226163, -1.56615444857664, 0.5451237538314863, 0.3658092051616333, -1.7060300926378622, -1.6229430476155111, -0.7350784586537104, -2.210035314955695, 0.22423908235146564, 0.0008894560841711016, -0.7427038153001998},
    {-1.2993865678242533, 0.08321301068570015, 1.3349532204859802, 2.0355808080376767, -2.087013830265135, 2.3157772019619753, -1.6970190465498267, 0.9007552501484699, -1.9756339055389094, -0.7342613382482954, -0.8877606507489914, 1.4609931006519115, -1.5137763760084513, 0.8576930020061864, -0.15944012864440849, -0.11665434384918619},
    {0.15970435529618932, -2.3742044896743875, -2.064738207162128, -1.237892197064677, 0.6029649683838503, 0.8157402181450896, -1.7361594824948463, 0.45310912369396106, 0.5113873834001564, 1.122330433269774, -1.0520618433716147, 0.06402688467259672, 1.9240622944308652, -0.41898701825676865, -0.003092972580474331, 1.790344393315753},
    {0.26875660523639266, -0.82325537524933, 0.11791160328819328, -1.83259676969709, 1.3754150456226877, 0.5137281068313289, -1.9732260787270717, 0.49044948376353104, 1.4653886466948687, -0.47140120662866486, 2.080487017624631, 0.3471764133733296, 1.2363667575988158, 0.7197801111556198, -3.5334490496737536, -1.2422076109926308},
    {0.3053985851991414, 0.4421850977768828, -0.6137091405540206, 0.14017679961281476, 0.6162224683987151, -0.787246420690026, 0.04873947994807402, -0.9257308541487058, -0.6269837074828851, 1.2428056456890535, 0.08835821084564376, 0.41803128816795293, -0.564683275257084, -1.6472996745836281, 0.2029091126140953, -0.059427486423390394},
    {-1.5325392904765516, -0.1719519900308092, -2.05119396181346, -1.8879782925556075, -2.5963806349636833, -2.4240528248655124, -0.7086365747743741, -3.0099494632746815, 0.08285037924047042, 0.8169689310141988, -1.4478335273217147, -2.635511252248746, -1.2667445978777123, 0.7096200707738349, 3.0051173535489806, -0.17821769799642434},
    {0.5212265644330898, 1.9757930946511426, -1.3926260532613954, 1.2369999845146133, -0.043277788537546505, -1.9300017904137508, -2.3670109731094597, 1.1911349583569844, -2.0349395651311544, -1.1176281311391651, -1.4090354502296347, -0.8967370270978278, -1.764562911725953, -0.21745943779880053, 0.2104234574366078, -2.642935629404647},
    {0.05117578619458451, -0.2224448450665325, 2.4906890254147966, -0.7332060538408632, -0.3323623102166211, -2.1117185808140344, -2.0736931957680875, -0.7188407207661016, -1.09511770682627, 1.321039998089152, 0.4194460543179233, 1.7981476929551277, -0.13345340930721378, 1.0093459771168236, -0.4151802870655075, 1.2413756415750843},
    {-1.2644454519269217, 0.4657376201620947, -0.14836257468153055, 1.4837999479779072, 0.8747025646248159, 0.32531940667343084, 1.6538149898686036, -2.2705858342163237, 0.5203167114049666, -0.1711811951256214, -0.6083487787601431, 1.3285721061797913, -1.7426423253064383, 1.173898892459823, 0.8210059585735417, 0.48734528943003474},
    {-3.246302992975693, 0.04041521649892805, -1.5487147564048807, 1.6520464652884594, -1.333677894176792, 0.6279474716437772, 1.300833541885318, -1.169015674174017, -0.5417791119285114, -1.7666729103456973, 0.9573609808091603, 1.2857411428923273, -3.1003619371894717, -0.49189868865932584, 1.1866809996358838, 0.9541314665390364},
    {-1.6376572432388457, 1.9490399781632386, 0.48531464362419025, -2.5980793293141753, -2.8890097850603205, 0.7687095608633909, -2.6090487573574164, 0.2865521231740532, 0.41051380522993375, 0.4284325518492091, -2.0919409410705643, -6.18153061789597, -0.8959464875878915, -4.670954411857982, 1.0320175824515054, -0.6120083795689256},
    {-2.235216941147794, 0.41230819549907743, 0.2166272823858475, -3.3349514167001946, -1.4613986519358109, -1.1623887490812712, -2.4868359605999606, -3.3074650934561247, -4.3246047215631105, -0.7398231235799854, -2.4591738661176685, -4.476374626118438, 1.2518843271113322, -3.8243164597701313, 0.4066495585494739, -0.2548588821401314},
    {0.3269357595231703, 2.025819957550722, -0.9207138327102562, 0.3556888643698293, 0.2870108700716304, -1.3200233005852071, 0.03148955154168905, 1.6839834352117486, -0.9677653243679163, 0.6260560838631983, -0.8535402082443798, -1.101847870796534, 0.4783827452245414, -0.7639475759257996, 2.383089472272882, -1.0854881597224826},
    {-2.524207303864246, 3.0705119456796974, -0.5657706710334791, 2.0000484623612627, -0.18467282979250912, -0.0021224258848064168, -0.10628857114618234, 1.322824115919974, -0.07050117097234893, 3.884122434480743, -0.42500077959467836, 3.17283541509688, -0.11705996106412252, -1.3663527670597613, 1.3452178893780196, -0.5837868682238592},
    {-3.0429672995225254, 2.720403069524627, 1.1856859734341023, -0.8089830620285352, 1.0912106422790244, -1.3195656212108546, -2.90418974434672, -2.371281205194556, 2.3259494886316503, 0.6462143443687542, -0.14579073665510112, 0.9128999464120496, 1.4526762088355416, -0.6644672577355794, 2.248025337203755, -0.019676438600493253},
    {1.8234594359522345, -1.324053004980577, -2.788991986891244, -1.874433830859503, 1.7369456821797562, -0.006439169620723626, 0.6413436817538278, -0.6341206489222085, -0.16361344168375325, 1.6792962122232535, 0.0524625095480959, -0.47588404751104135, 3.0008217369931574, 1.5067320474195076, 0.5960768873235273, -1.306008460291507},
    {-0.47462760744603716, 1.4090692724874876, 1.8755213858630908, 1.1871174340792334, -1.3416646146900315, -2.78442951831198, 0.04512321308120022, 0.032949048590880194, -0.6316717958566511, -2.0693176268830284, -0.08999176137700327, 0.5743419815768228, -0.6525315801140985, 0.36100332677029645, -2.0995270041968817, 1.1470345822697472},
    {-0.9490586313433317, -1.3495975315703763, -0.7828255442102117, -1.3093669439869104, 2.3891875975393715, -0.9715464118539524, 0.20391561650373502, -0.5690890496376777, 4.349483414719186, -0.3112329097449291, 0.5327907811340684, -2.00013869866277, 1.4765537056643878, -1.436062886099941, 0.12014284827555842, -2.8412748962259564},
    {1.2088814665670333, 1.2959067960081934, -2.232720609398713, -0.2944226681082898, 1.012134692188221, -1.110037250277276, 2.0389011155152357, -1.2180377768321644, 0.9056789057412716, 0.7333494076474082, -0.2504876139865296, 0.27744459874120114, -0.41789507404130705, -0.5643199616143424, -0.7839375990620617, -0.39744838330789917},
    {2.8845557507636386, -0.9691007136940503, -0.10289256240144094, 0.629627851636207, -0.8714368788171772, -1.5230188001699352, 1.7290604089496877, -0.3603943160298957, 1.3617346172556273, -0.23595193840083648, 1.6728405121856054, 0.004889250025133583, -2.223065578581274, 1.0839669713377555, -4.301635855825618, -2.275838015830746},
    {-1.8650007876587242, -0.5087470063148222, -0.6767814303231089, 0.6408050163886794, 0.27658432732668375, -2.23620252713579, -0.795560616380354, -0.05590585198113383, 0.4150878807968229, 0.23780964744040906, 2.851224024789404, 2.468720812847416, 0.314435713829692, 0.41907111715188977, -2.3643699637708866, -4.240892666422862},
    {1.856225074121281, -0.945194123063375, -0.9738276194282736, -0.4062426903242939, 1.9685504442041735, -0.706164796907751, 0.5725203738202757, -2.5507352180537923, 1.0730555101170993, 3.599224168987411, 3.5779035506665253, -0.20240321325536223, -0.8541964993256878, -2.3235881552339204, 0.08190901569250073, 0.15775182506741373},
    {-4.903722518775789, 2.44015397297282, 1.1108485796888132, 0.4868582112895221, 1.3217376446192368, 1.3663455870753818, 1.2833958079710113, 0.11439663991463624, 2.5341905985878412, 1.3741310718124775, 1.9991929497208578, 2.431835046149581, 2.8263999979838665, 0.04882369345635714, 1.5017422795850723, -2.287307952410859},
    {0.14773734954322093, -0.9285443298905609, 1.106809014541768, -0.33519632464121396, 0.39329248260294347, 2.7213441222262293, 0.9649933181643443, 1.1506236232472369, 0.6885633145181926, 0.057118665898064254, -1.6191856047250528, -1.0220068797249313, 4.205230485414112, -0.1048366545617645, 1.7794145263794416, 1.3778892506254996},
    {0.870153047632279, 0.3692818866981395, 0.25370101677789836, 0.9618958639720916, -0.6888164611293789, -1.727046965472476, -3.1852761901859417, 0.44352218472567184, 1.266629661144409, 1.275791794339997, 3.5411247315871703, -2.0018161389878455, -2.9128773294730057, 0.9617365008576731, -2.3509011556715897, -4.366565161373889},
    {1.7226693458638438, 2.6354214985630184, -3.5090824579301674, 0.32860250304096794, -1.539144474912751, -0.47912758410532336, 2.4435445541901406, -0.20119427135985737, 0.2976505982936694, 3.177750724553683, 3.219257410351702, 1.1660339693639044, -1.5802846762466793, -0.046898317018192005, -4.4857317314516205, -1.611731688886061},
    {-1.0832538121036346, -0.04208439426231642, 0.28221526643856193, -1.8243554400796986, -1.5949658473421808, 1.071529465876175, 1.253642774724367, -0.8563105251071336, 0.6201232784055537, -1.755114946449257, 0.2611197896860569, 1.8636183767249515, 1.4417934340519036, -0.25043102175316945, -0.717335101908795, -0.03792096245402298},
    {-0.9154176744528093, -2.192321157493287, 0.5302289477233456, -0.3255090037503135, 3.06809238286982, -1.5463899399157282, -3.013588113195878, 0.1297675702846198, 1.073756876468691, 1.750453416444776, 0.863689372412809, -1.8570114518564305, -1.0469720465367336, -0.08708253937608221, -1.9480017424166116, -2.4062934578902975},
    {0.668334925146839, 0.38270239639598064, 0.47688530672610924, 1.3859419069749386, -0.466271052661804, -1.5126787373238082, -0.8598644662272693, -0.500934874732745, 1.2310649443439938, 0.1423474036928836, 0.8829920024756466, -0.5322253678952071, 0.3077976527803253, 1.4684796976769952, 1.5630874024611368, 0.43475235273997687},
    {-0.9680111237159107, -2.873026626211481, 1.859988230086301, 2.7898131173835625, -0.3050045430418988, -1.0245713336081956, -0.5125568640066624, 1.2011760203456892, -2.7633909552206726, 2.24559370183763, 1.6672168432452952, 1.0182725154560226, 0.2809628866725138, 0.564219559661375, 0.2075824269490651, -2.2099856726009466},
    {0.6452466863384243, -0.3185727427204572, -0.4103578068689389, 0.23620724410040647, 1.10562732182026, 1.0677241338297045, 1.5234774863853597, -1.5440142178271066, 0.883201326365579, 1.8308923412495586, 1.4852453979179008, 3.8611951588411886, 1.8541363315182922, 3.020969049444318, -0.3285502361737725, 1.5456337401093705},
    {-1.3818843053985608, -0.24063818054812144, 2.987805943709796, 1.3111362664841544, 0.593634295926709, -3.1431752039687266, -1.756337736780916, 1.3879143141488899, 1.0940233261846901, -3.3433362854571795, 2.505262360783237, 0.7730357408404116, 0.8077086122051218, 2.620163079518223, 2.2461442243882335, -0.9870572012190008},
    {-1.9613336813697788, 0.06253086380182127, 0.06109632361043253, 0.722907285765733, -1.4857562119127923, -1.7101352501774227, -2.531442835082919, -0.7847698101790646, 0.9982128524799471, 1.6006324274968677, -0.4743299925105631, -2.2390203442839827, 0.04861554253551678, 0.04082396147606116, -2.276462485450565, -1.8476897772046408},
    {-1.6980688902236547, -1.828429902059522, -3.3861226607648645, -2.1215327123114207, 3.9978957996291324, -0.24882770389886577, -4.630994041931589, -2.9850380774132033, 2.575713184244898, 0.6533553820842776, 1.3183839528532573, -2.7864806648272507, 0.35248033024456055, -1.4727082097869082, -2.3340893169714505, -3.8268468827945488},
    {-0.17366186662474722, -1.6242512288556283, -0.5337653968446572, -0.364224073951282, -0.9130853883164308, 0.718288770662693, -1.4248400651545283, -0.4434141454585356, -0.04438391806166237, -0.2875856181855119, -0.5500327264300041, -0.7966033076211543, 2.7699929245538226, -1.1936354263249067, 0.21579176793812843, 0.1030317181114958},
    {-2.2432199804926207, 0.26033584798163084, 2.1610686436996014, -0.24397540159181116, 2.0784763291796393, 1.0600249140789728, -4.221874499423057, -1.2659777796830947, 2.709452201900502, -0.860565245075526, 0.9429380600646893, -1.3255834009910552, 0.8381164081157444, -1.5019566684098993, 2.611751485746276, 0.39098788584693195},
    {-0.37982364811508057, -2.662305108615225, -0.5985315919018601, 0.6861628798306474, 0.1530027601638511, -3.4348023171784035, 0.7428559519121114, -2.001191506353448, -3.3573101201384614, -0.520378754276859, -0.10004513054637575, 1.029012421382967, -0.39902705270241795, 0.06300880200874656, -0.6105256561333531, -0.6003855416704743},
    {-0.3981728783197337, 0.9713550463363706, -0.4152666907211325, 0.48175019852322254, -0.6043365626631265, -2.024235959542621, -3.4192323547657986, 0.1896547095432598, 0.5730616788580627, 2.0803336178644507, -0.36228176866278694, -2.0434783569282993, 0.6195970901446953, -1.2524884019609661, -2.403668697546641, -0.1506334327747236},
    {-3.2762256714548, 3.2589794328278865, -1.6548999541787035, -0.5109485607796044, 4.7149956097035055, -0.7654802289691649, 2.997305605222555, -1.5556896769933009, 2.4729396752414425, -0.17935148920155236, 0.8649999748769018, -2.0293508362623465, -1.4609793269052755, 3.4759942350493405, 3.4615808282461917, -1.9424200450252904},
    {3.1650412093442535, -3.429310766202361, -0.7261684216007158, -0.1635651183046875, 0.42751673516338795, -3.3988111130563774, 2.1240806740787295, -0.8372278983958036, 0.14502688085172932, 0.02800826173482826, 0.47051292962090413, 1.9768954293881307, -0.880704106660267, 1.7588481042364892, -1.4981335090987689, 1.3444665667448226}
};

static const float b1[16] = {7.6198829673741475, 7.7687222835014085, 6.653914937692258, 5.487828153912909, 6.39541044174516, 7.523437622195763, 8.112018855380924, 7.651678462316529, 6.126375234124045, 7.674342992478417, 7.753070072797355, 7.153434699786755, 6.446012659626925, 5.469544496891839, 7.276734364987872, 8.183787317546754};

static const float w2[16][12] = {
    {-2.7513515803421167, -4.16021041844805, -4.361614788069658, -4.0264979109550065, -3.881669476721223, -4.101276728457063, -4.570734571149919, -4.3610662793880275, -3.1054487205188117, -4.463781905954481, -4.647068473162631, -4.099008413762682},
    {-3.7490904397939966, -3.7964231254103016, -3.122943041026072, -4.623807836976399, -4.155090096272675, -3.807658212764374, -3.7140671467902893, -4.1407510607771725, -3.0767776824030584, -4.270690544368338, -4.408500092197599, -4.079746654481581},
    {-3.5712771327909243, -4.957915211445412, -3.6185057686919913, -4.256608780114627, -4.786131637007062, -2.748451836540773, -3.328231903961718, -4.658611360637511, -3.7081701566117777, -4.7286854988126565, -3.5535541507820336, -4.470144350243097},
    {-3.244651362644586, -3.5254679490578518, -2.7141568089973402, -4.570920665268138, -1.9439203289080897, -4.442988510019497, -4.680458427190595, -3.6092533397065125, -2.6269426849790873, -4.024004695319109, -3.6753007493500776, -2.831783237025316},
    {-2.8716932673534976, -3.822774531710625, -3.6168074832318284, -3.82690150973775, -3.7221623304275657, -4.3966104852366374, -3.7446302094312425, -2.800254027608323, -2.511547337624165, -3.0936358588015525, -2.89737879442135, -3.995156164243654},
    {-3.5523442191115375, -5.4194475701524025, -4.655081516387503, -3.622802012558246, -4.620843144968644, -3.596299054473883, -3.6196175882275994, -4.344376633901696, -3.828308276086544, -4.505108930846248, -4.368396633561307, -3.758502936631704},
    {-4.886917797053729, -3.4407029182656323, -4.128962533323524, -5.778566733860259, -4.266623740844798, -4.243504028003398, -4.305505298170461, -4.68861406656112, -4.575854457369956, -4.783892693712555, -4.611475430176708, -5.373596150582889},
    {-5.15929240507107, -2.7505624112447973, -3.68896996886383, -3.489561333754781, -4.374433073020058, -4.7337798560793845, -4.221826853108867, -3.8196039053466087, -5.832054018251167, -2.9491395572932246, -4.250242214503544, -4.74759890055925},
    {-3.4970266312239637, -3.6875595412161717, -2.9654791191424064, -3.8103521629240813, -3.2855605695695798, -2.952111252948526, -3.305768880801097, -4.086523279477199, -4.299179529336938, -2.8971962496638244, -5.233533822091461, -2.9836110439703476},
    {-5.185957420161372, -4.2247602143886285, -4.457598690553175, -3.380079248701377, -4.136545889716444, -3.853822756818334, -3.775406699578928, -4.323450930153816, -4.50500070298679, -4.167946213999675, -4.842410700662221, -3.9759897334295635},
    {-5.258236346152469, -4.031005383073642, -5.7506604978540565, -4.297591931622697, -4.347832035682065, -4.475669322106917, -3.9614882815741193, -3.982349131468463, -5.154017709957658, -4.49218446118425, -2.4357964475560014, -4.324933967764566},
    {-3.928633230658481, -4.03590818704505, -4.513484362101067, -1.961728900556068, -4.444855090079788, -3.68239039901878, -4.001380772692011, -4.0160070019138345, -4.2487385998112845, -3.4360927979115115, -5.148909980050941, -3.8565779775628033},
    {-3.363927713845076, -3.41670157986883, -2.883636484376279, -4.638352183492854, -3.6240740438739425, -4.642977941710627, -4.20878821963453, -4.011351780032423, -2.737074894492827, -3.971757110225468, -2.6938054625596366, -4.088662020535072},
    {-3.4430740883248676, -4.699781560512818, -2.6561899360865278, -4.152781626516402, -4.2134559756587215, -2.8417662208115546, -3.047609410411829, -2.841309218804311, -3.6816379468276894, -4.281269188296465, -3.134484912932974, -2.9562879028917433},
    {-3.6148846513790933, -3.0635082721261724, -5.128261036146546, -2.5560410789382906, -3.9947450275662937, -3.4947794570485815, -3.9807561302358203, -3.4215435834638117, -4.564962160318546, -3.74075819407995, -3.339102007604212, -3.408816338921384},
    {-4.961243894299644, -4.461708723444138, -4.890246025490613, -4.8348803381465135, -3.4988776451008596, -5.133660486763061, -4.165411905137916, -3.7181717342865066, -5.2263217002081515, -3.132091091925628, -4.224693355907868, -4.03912026515746}
};

static const float b2[12] = {-4.718041191409933, -4.585276897977895, -5.401609706115391, -5.358103112876902, -4.857680976568648, -5.079343993484616, -4.679268913050687, -4.919132261062091, -4.019832826119123, -4.673005340976079, -4.785999697739377, -4.706335109872193};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
