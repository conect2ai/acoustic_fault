#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-1.0869039731256234, 0.9211428999285226, -0.6644679761445518, -0.7732146299687935, 0.12313265776283217, 0.026854215650756776, -1.0251213988939847, -1.0067818059146771, -1.126629990947849, 0.38641312313197435, -0.6522079383791209, -0.1528552982432673, -1.0280371224906149, -0.5270479625642318, 0.301984513398049, -0.7626452842303405, -0.16331840698934608, 0.839241154821344, 0.05035087579760767, -0.9133144255025019, 0.18979540592678054, -0.7427792414723462, -0.30787388500143137, -1.426940076542704, -0.8313419151763551, -0.27356585250832127, -0.9476218074280011, 0.008995921764610348, 0.351165696828409, -0.36109890546830625, -0.03700570010812556, -0.05251194260907563, -0.04256777462185995, -0.535428166375237, 0.7968710488992088, -0.42205530976416505, 0.18137976074315734, -0.603675450865468, -1.25536221230668, -0.24528311098007938, -0.6928492781912629, -1.0010875098048222, -0.29986982289693853, -0.2885303098516098, -0.9561553294294848, 0.17236608701625017, -0.7049819888131099, 0.4398721899409863, 0.7105890919747919, -0.5616100392149114, -0.975862720159775, 0.8074040855959401, -0.9939190798295454, -0.840569204288219, 0.14623673200531664, 1.0154617041857628, 0.8780476196950295, -0.5464290496174053, -0.31887617066633, 0.3160516047738537, 0.9257331125391256, -1.268546947443885, 0.02127754120888359, -0.8476200773546403},
    {0.2834617949550212, 0.7227833009176603, -0.3823411283558881, 0.3411553143506486, -0.5252757782151867, 0.5299929583046559, -0.478160342133181, -0.8434511475329498, 0.44237815991713275, -0.9020108317828199, 0.9477029846251063, -0.4220106329913239, -0.569186966057748, 0.20280689928741782, -1.6086696077462264, 0.0820797314284041, -0.023858287555559788, 0.6652942793691569, -0.06446064822412301, -0.41258571545179107, -0.9617948279842827, -1.0434570442494024, 0.024381044795925063, 0.5859990962124573, 0.7115886882383973, 0.42919003078093076, -0.11767845203806872, 0.0991495662961721, 0.7264537097272714, 0.13298459093083323, -0.49461867583170427, 1.0279027114749255, 0.4315040458011731, -0.8607109141752477, -0.8455161497030523, -0.7264682700136982, -0.798159936187569, -0.8094061655158366, 1.0582618065850098, -0.811754449128538, 0.44971124151423914, 0.6386534696161782, -0.3156463884889396, 0.050975949269563656, 1.0886786918926923, -0.7146065562539532, 1.3898143826618325, -1.3752468417548318, -0.6355188188861886, 0.1392436879627816, 0.6233419848637028, -1.1941055945699603, 1.1253391041689385, -0.3776182795099526, 0.26302718118549157, 0.8036945280959897, -0.775796041742893, 0.3294012072666999, 0.5208704144713845, -0.2128431981552578, 0.9732346925572217, -1.126854978567741, -1.2666513912996678, -0.45565110125456965},
    {-0.17773784483997312, 0.6825220840651125, -1.1635754494226962, -1.2603662371539797, -0.777063338757602, 0.5741629000749503, 1.0848932076538371, 0.06435500799597087, 0.9223583051521156, 0.2632398108954697, -1.007467929210996, -0.3676078246152292, -0.8685524372999334, -0.7456250671436732, -0.4423721682581918, 1.1256147225464381, 0.9987488671048148, -0.2844259528274636, 0.6716680755243108, -0.8797551292610492, -0.3903304931934241, -0.8098961179615843, -0.09069557283389718, 0.06908399108150078, 0.3894406306152321, -0.9787176475469345, -0.5496072137154316, -0.42246683292899734, -0.32526889808618137, -0.9561523873499438, 0.10707686462713008, 1.003213785095782, -1.0538650266671152, 0.7227342761733734, -0.3258063038320037, 0.34087780771289355, 0.46242974722798436, 0.6693339458905952, 0.014782846857051687, -0.8186999505759783, 0.8804837859938222, -0.25716528042254744, -1.3898305222856706, 1.0375776798925367, 0.5765474485050706, -0.9526932397389528, -0.9170096085345609, -0.7516160407326985, -1.0151327922780107, 0.06422047673958925, -0.14873772660329254, 0.44514325649793035, 1.144196514462422, 0.7589794663748348, -0.49968071628397254, -1.1425651500245027, 0.39289370814607955, -1.0421167709213082, -0.5612444390118082, -0.2280144257936507, -0.18065490188139022, -0.6093610023713772, -0.5214263827764962, 0.8024079151378919},
    {-0.7476788436911957, 0.18065426394625977, -0.8431717971557572, 0.7336086190653662, -0.8236349598039957, -0.7591688483586708, -0.27056454222854825, 0.6182533900526512, 0.5692399377317452, 0.34974799227969744, 0.5935791555865167, -0.18857888795502975, 0.37436564935096045, -1.3129403352275022, 1.392524510066514, 0.04339861058191306, -0.5751958921099259, 0.2578628845767767, -1.003080921621981, -0.9602690337941467, 0.34619840448407435, 0.5647624945069741, 0.6133735628743021, 0.25797408114304077, 1.4134958389700882, 0.8387315698569633, 1.1269239150869568, -0.9736638222832257, -0.0540022149976929, -0.7690625609666989, 0.20326346363343337, -0.25974988116280495, -0.2956153859091149, 0.10462651878215985, -0.23915724824216777, 1.3770043843379909, 0.6100563336050113, 1.1573213031292462, 0.18339869781401924, 1.4342989963264694, 1.4986478357496098, -0.9695803029456243, -0.0376613768285463, 0.08746197358813836, -0.42318913900574695, 0.5831117096019152, -0.5860944274544826, 0.4372071335891051, -1.216448457120469, -0.910569806190331, -0.9561735104162183, 0.9144104570565175, -0.8094754848298039, 0.3482308334909886, -0.3193677528684447, -0.06562717377057993, 0.80072753606491, 0.10465100397157073, -0.10863483730361244, 1.0332703069775828, 1.0526086256387537, 0.12046454085032532, -0.49595282122919415, -0.19052108021661768},
    {0.9886032744545218, -0.7704561724083856, 0.3294947119835496, 0.10492338852188152, -0.4874162963048332, 1.0444346671210105, -0.5591804582154554, 0.8479031018974743, 0.5188358283306379, 0.9969973458222162, -0.44980253444713486, 0.10255829897326499, 1.4188088473777845, -1.3101829729905925, 1.3198187570047686, 0.8017382961202323, -0.3306491418355886, -0.46139120010071427, -0.41087128964238184, -0.10246001212341213, -0.8925577348852681, -1.1373368491556828, 0.10379665238267563, -0.049932336817375605, 0.7124401033139944, -0.1373617348641019, 0.6113764064856874, -0.9329734222981332, 0.1566770855099538, -0.44047126213066684, -0.9525821442076133, -0.5543682190754127, -0.7687332467727439, -0.5156888229816807, -0.6666434866109544, 1.2857008755677508, 0.20619491582303676, 1.3588155685556182, -0.3356958559167649, -0.8934593544333613, 0.7406310861813811, -0.03834722622226547, -1.1430464839833792, 0.5592684055205929, 0.5626053668929023, -0.39178132260292275, -1.370668505176125, 0.24844439034310833, -0.47775711693923856, 0.8556336136205553, 0.7751429790836051, 0.6112752019396319, -0.07882707232711722, 1.1003281509405534, 0.5544795831179522, 0.6067169361048044, -0.6506670798091408, -0.6671362217174437, 0.63369557125474, 0.5269939191676819, 1.070751483579746, 0.9027644452497771, 0.6740008926542176, 0.7024707776344654},
    {-0.6286363448684299, -1.1875154637113252, -0.19085034295287376, -0.8095247276942291, 0.6596681404663626, 1.021097912912284, -0.805559973481636, -0.3802433340994415, -0.7614926087540349, 1.428019897999093, -0.5195957894358989, -0.1731931295003825, 0.5784940754037655, -0.025703061439891775, 1.2131513827313865, 0.28207382949447646, 0.7728983047497251, -0.27675980259266036, 0.6046931399218486, -0.4360360688743656, -0.7099644213444967, -0.9775494602156165, 0.5043526738562872, 0.8018177545230216, 1.5372174776326297, 1.3832181378268436, -0.39058846782158313, -0.9041642399805744, 0.7984861920583564, 0.27914353635938616, -0.19152171637606402, -0.6620043811175647, -0.9912292872712645, 1.1578831251900488, -0.7452216736000943, 1.1002244566809631, 0.6207228684274508, 1.2947454142143286, 0.9494188691768237, 0.13796948038140902, 1.3948626943899742, 0.4572321890523132, -0.9744439285193651, -0.27687769902241655, 0.5879350987325402, 0.4637999780156004, -1.1434844185439796, -0.3797436774792336, 1.0953080621654026, 1.191553359370603, -0.0284392324778274, -0.45658408649022447, 0.3409481767739568, 0.012996038891386553, 0.013541063362759544, 0.15928140341702035, -0.7701932024958514, 0.004351191102705801, -0.7172256504802166, -0.018516070240223382, 0.5812894508856497, 0.32157811777562995, -0.5313360877657647, 1.658809102595169},
    {0.7780577929807144, -1.156795883954562, -0.4744239841814248, -0.1716966565343999, -0.29459466772350873, 1.2090858781579839, 1.1254903997958787, 0.21523133301568584, -0.07696856927215301, 1.119529039065589, -0.9919553400753991, 0.9297868741291799, 0.788363237632573, -0.38874730543453045, 0.7593817472227514, 1.2562456537956614, -0.0888451858603303, -0.8981374155100257, 0.515391995673826, -0.34005865076951625, 0.7331479156542358, -1.0786141732834444, -0.6713347944761178, -0.46514072530082445, 1.3092790067279392, 1.313953712649583, 0.35668332091506494, -0.4379920995225027, 0.42824691279560406, -0.9140208185254689, -0.44834566349290367, 0.47107312700457254, -0.3868803165025248, -0.39806384100769776, 0.9653033100405982, 1.3506454718941154, 1.1318731222857354, 0.8698019137823682, 0.5933286084607461, 1.0254451588524283, 0.24674226745637012, 0.026373026567843565, -0.4472484790550062, -0.2678631832771155, 1.3518403938405155, 0.4370613807766684, 0.5546775031954454, -0.8191109664151288, 0.9080998010262581, -0.6948252643578392, -0.9494383767408675, -0.3799982015504678, 0.7834508322316843, 0.2871168983139518, 0.3530108504372286, -0.8320713870909698, 0.0767661914384527, -0.40185867537355985, 0.880436154789472, -0.7409454886724118, -0.36279023931482823, 0.6407275251649598, 0.6733208953963963, 1.3312770401823821},
    {0.3433809951275514, -1.1840377268250026, -0.9177177233957905, -0.8866943118397451, -1.0357696453221241, 0.6890410785247444, 0.36317136329273997, -0.20062270208561928, 1.168996203581079, -0.9831211833354278, -0.0314991911295599, -0.7329028902515107, 1.1204927596127867, -0.11529760970171882, -0.06885210211641397, -0.22872724379010134, 0.022926207932011118, -0.8814276097202253, -0.9944593263762008, 0.6337673807863471, -0.5450740838612451, 0.6599354315129706, -0.13094247378592547, -0.3451341419295307, 0.30165549619179716, -1.0489183327061877, -0.02836673919199834, -0.42892312133822136, 0.3976847549557275, 0.9115341590566577, 0.5885826982172356, 0.26119770036198997, -0.9379981109081992, 0.5036049543687162, -0.2533441367753217, -0.9788517902149895, 0.7931127861116287, -1.0057935752048077, -0.6868332820299287, -1.0046040107375271, -0.6532128539354657, -0.48627656228821775, -0.61708652188704, -0.6336049904671187, 0.07726072485534927, 0.4792711749865593, 0.3873162709695995, -0.6106214966983908, -0.03703834135895413, -0.555461988986528, -0.26388829430046223, 0.6683339902433143, 0.32932673563866305, 0.15532417471161444, 0.18743220723218781, 0.10450353996374542, 0.22700379015903505, 0.6721412356573384, 0.2786497247852909, 1.0253536594870662, 1.1209097418530722, 1.2277779130239057, 0.291891929930191, 0.2498678978093414},
    {0.28489214875162466, -0.5733681183424021, -0.8166434125582505, -0.1904334675997484, -0.1494161300555206, 0.41898622653602186, 0.5197367097934694, 0.7810057655237899, 1.1125602121217024, -0.9387613180934289, -1.0612161535999176, 1.0576715498729785, 1.193267565842609, -0.7155586254051729, -0.2250364989761792, -0.8069549743713302, 1.028209076742563, -0.5017437817146416, 0.019539235799415865, 0.1969156752408405, 0.2347164414549918, -0.7649083069378306, -1.0268916200109004, -0.4153306664501672, -0.6993908788469703, -1.1315842372790754, -0.5328078856821451, 0.502937217696415, -0.32672662788627377, 0.6248945952180984, 0.36739235429798295, 0.5195891719864171, -1.207820856287387, -0.715835492311883, 0.8601774766444121, -0.33514979552569574, 0.44730390354593524, -0.28004208027866584, 0.5524655522740812, -0.765735555656446, -0.013670500492633951, 0.10948367876800115, -0.07858097519587767, 0.4655597470961238, -0.2537746507845183, 0.8854655241647926, 0.25721689368499656, -0.8027483579938637, -0.4381534064808432, 0.2992644244382406, -0.6662877212094795, -0.48275981494575765, 0.5796182578982011, 0.08160463381142492, 0.9968586729110958, -0.12911788193199825, 1.1088859591550622, -0.06054691606435031, 0.2036241936639068, 1.0428544639692299, 0.9019209371139415, 1.175596666204252, 0.3002236289157307, -0.7625189323834545},
    {-0.9936205023921275, -0.7757048038050448, -1.047837244542312, -0.6973783647371923, 0.7431305896499755, 0.10553263782591332, -1.1117073293333375, -0.23618845316348472, -0.3226547017691968, 0.7115136534737259, 0.5577605733151456, 1.1712705454615238, -0.1149355335805597, 0.21783361596439332, -0.9596034432457843, 0.6696271585323162, 0.8777602133855985, -0.6214544554759907, 0.9474526405953629, 1.178285753871538, 0.24592932857598293, -0.010335074642309431, -0.7616516799331994, 0.10208856312237707, -1.2035662219320153, 0.5657521251169181, -0.8269528516043962, -0.8698026005227368, -0.24261558813162004, -0.5482614077667148, 1.0559326009075425, -0.9607340656162469, 1.2302992621627833, -1.3884445058805994, 0.3989739802592508, -0.9933459964788857, 1.1663635105793548, -0.9343891141002031, -0.19854144268810836, -0.8287941448643488, 0.13982240101889754, 0.5031427140112973, -0.42071366463506565, 0.4900304035686805, 0.42769056887303375, -0.7551896047232615, 0.4037558065844071, 0.04032079182678751, -0.0073759328743754835, -0.3037508963024529, 1.080962203840483, -0.9748015428252857, 0.6921801081111535, -1.1671339628537802, 0.7667475932779797, -0.7891222472282465, -0.45722581719576855, -0.5746736994984425, -0.9546777378446624, -0.6224070102277008, -0.456480880972889, -0.6191152339273821, -0.9554926944104191, -0.5211506730658588},
    {-1.0518175367958702, -0.1721676821837521, -0.5334301686412131, -0.7240491073590919, 1.0670567821963561, 0.07441994181057023, -0.4292942079135717, -0.7203803933520344, -0.053025370865544375, 0.15663944903871807, -0.7956030550889974, -0.8616662839928786, 0.8743201628088935, -0.5392006848923061, -0.2434511643856887, 0.11087335528757276, 1.2364489247559636, 0.3125973813445452, -0.9426666986252918, -0.08059448357978623, -0.7193938936571802, -0.2602891087845192, 0.24594561876238527, 0.43577102716724514, 0.9536183994149079, 1.136892843357804, 0.8355695327612725, 0.8319020457000849, -0.4394644259623283, 0.9349328747842127, 0.3414835042872917, -0.47953189220167547, 0.5114147738542422, -1.151689012384434, 0.48641766965799693, -0.417274360002449, -0.5636282431423908, 1.1767779622203176, -0.837150843958011, -0.5737589864138858, 1.3367338850065111, 1.2220337685375986, -0.1588043269818036, -0.24461354717540731, 0.6787834158430713, -0.7685757751283243, 0.3605437690607852, -0.5200488622948521, 0.961811902287593, -0.5091628345526436, 0.3551425429637862, 0.3486951275362298, 1.2174030571531098, -0.19480537097926234, -0.22135970789457804, -0.9154523214134568, 1.0805781871343005, -0.008241137508155591, -0.6049346146888612, 0.4914872920606537, -0.6544529333184869, -0.49719726566245787, 0.8105056716449647, 1.3429644885766479},
    {-0.39363868553947506, -0.8631222821420554, 0.11897504857488551, -1.2390481877070894, -0.46140080817797646, -0.2919253374306116, -0.791607481344236, 0.11881739795508334, 0.698129950247329, -1.1605695731921721, 0.48268264741281924, -0.9910948899421915, 1.0461885470505539, -0.13820900621152923, -0.767015226630994, -1.0733043974515952, -0.027394365142688712, 0.6654342759250205, -0.49543919034810374, 0.46677129826175917, 0.422473807773552, 0.8556696789795493, 1.0621810506107068, -0.2630493910063578, -0.8649085655719335, -0.47132552336855726, -0.1776304560708535, -0.015828571565211377, 0.9357782001531982, 0.3689053786178388, 1.0701064916616687, -0.15688911636183497, 0.5151370380115537, -0.9458892954383522, -1.1046290331629887, -1.2317551342468827, 0.8020302639578081, 0.2804064434482603, -0.5561303356944064, 0.5128292341850756, 0.05653348359979255, 0.15557948565131519, 0.8506624660434784, 0.05536950630508744, -0.5828325215012289, 0.5001737430945568, 0.6997149799205994, -0.4061660564686615, -0.8614726552576307, -0.4544147866559072, -1.043083151017272, 0.234957357343167, -0.3563352054667436, -0.4735691901112957, -0.7186662960507962, 0.6325794037101249, -0.13071951150615335, 0.9328129588099071, 0.2890674615748283, 0.5350320374323153, -0.5439464410330684, 0.9258534339954287, -0.648715789071328, 0.040894668198731395},
    {0.35553849510664615, 0.30821219312047926, -0.14327505611987915, -0.4291692514911884, -1.1671021020062275, -0.4180186421019122, 0.8703415223283663, 0.6373984354416237, -0.6904594537711621, 0.6509492272766232, -0.13376591857364167, 0.1091969538004041, -0.8560351414715305, 0.04307750618793796, -1.026554468290131, -1.0557511366234273, -0.11668517947394193, 0.3100951857924836, -0.5606175635192253, -0.030402301488760095, -1.0397362605531772, 0.4603004183527757, 0.8799407182581529, 0.08644801211886241, 0.5070615922821468, -0.33358220611124434, -0.6832306282870877, 0.8495492918439427, 0.8949527660291983, -0.7733704562000399, -0.07945017289974726, -0.15275163743123715, 1.2294512624192535, 0.69767947603394, 0.20602401190421427, 0.4465065571990856, -1.3536811210040562, -1.0201824305418563, 0.024850502075104197, -0.36466545877235823, -1.5461405273840227, 0.11548186285129446, 0.6897979459994199, 0.10500503725355369, 0.3594589432602736, -0.6022060798457798, 0.7561438040233297, -0.20084247877378517, -0.33389540480195956, 1.2898019556942197, 1.2045701691429078, -0.7599019651887524, -0.40352444238358537, 0.7925357472704554, 1.1808273316417908, -0.1819218980252899, -0.5564905688588832, 1.3910548604901236, 0.5117290660150512, -0.028087424935524876, 0.44739109879559585, -1.3770339598267411, 0.43285666522559185, 0.15999548320899448},
    {-1.2302965313013765, 0.5725813934547239, -0.8547566221532743, -0.22710736413601532, -0.8698135754043885, -0.7587670375799223, -0.9164631000333873, -0.8058297438304974, -0.036569443305335174, 1.222672686189857, -0.22308594135221746, -1.076053636557186, 0.8015971353641013, 0.5785441641726635, 1.3602559512545969, 0.9445754802284865, 0.023986513936966578, 0.301127279764816, 0.12312823531862638, -0.7965012550516, -0.4978099152602729, -0.029665181503784454, -0.2893643598368873, -0.9158061501049033, 0.8720871809093625, 0.7729304778526148, -0.7819332491393901, 0.4154952583810444, -0.8951802120026922, 0.7035589065138057, 0.5093476342802921, -1.0107228979271345, -1.2067909728492905, -1.3620096802660553, 0.5117510625914823, 0.8862763639594046, -0.5204927597444281, 0.10832149897098735, -0.5223461461648943, 0.06642201219259428, 0.17421006418224635, 0.3939097089009048, -1.0082810583056578, -0.7351723999036661, 0.9118511556800888, -0.6026705260952572, -0.7540064716181188, -1.2701910997013883, 0.27806337167532796, -0.7389685825434225, -1.2020176589043894, -0.0689064009837621, -0.5936468966948586, 0.3814645501470865, -0.1211649772334381, -0.08754953564394981, -0.8801204423587551, -1.118696716507728, 0.4575433418468906, -1.0664657255444676, -1.031812748795784, 1.3839398707735384, -0.7016613696742935, 0.4048083759751372},
    {-0.5648319330014251, 0.5840602561489986, 0.03419324000894148, -0.4754269025661399, -0.2854717771923692, 0.5390945833618177, -0.8995433171948365, -0.7746545663433018, 0.8186229122631673, 1.0289523975686967, -0.8938057834874933, -1.3217536720401517, 0.7261411689810707, 0.637870535567568, 1.1214700195996137, -1.1699031142649363, 0.6980024442704533, -0.12738557490298488, -0.7109472274063287, -0.011577123532123902, -0.5490898872940189, 1.2255410779176275, 0.5937725823279802, 0.5541406861482349, 1.318875215420412, 0.43399820650705273, -0.36072328126139797, -1.0798652483725388, -0.8048035991040401, -0.8381736103473927, -0.32106296853801075, 0.2524062183543765, -0.9301176156996905, -0.11336942854695735, 0.5459584258944022, 1.4798613121687152, -0.7716271413084715, 0.11007391869603095, -0.7036424185400423, 1.3297405967908158, 1.1329330246156126, -0.06502363041813798, 0.05630602351328897, -0.3341714029006174, -1.2358157683944722, 0.32847783860069374, -0.9547914800499643, -0.6532619382877924, 0.5024267556790103, 0.2092972721435843, 0.5884013273936013, 1.2555777657468454, -1.1445612453679916, -0.5805420810809953, -0.40115318661403737, -0.08540451307482416, -0.8275801640780024, -0.02956459551538492, -0.14267001461322323, 0.11344223324996887, -0.5568045721848357, 0.535930175166015, -0.13649370038365896, -0.5554116546562963},
    {0.09765539948693347, -0.700864236721356, 0.49243502551528173, -0.76881192231425, -1.1198748862955012, -0.2316753071674573, -0.9655742907517901, -0.7883184393440326, -1.2377384922468777, 0.27607262894970475, 0.0635716750255115, -0.10966074468806693, 0.7627646997103262, 1.1829017938288504, -0.6504577932086651, -0.7082768558668139, -0.9625188574384409, 1.0802365585680709, -1.0058101897088974, -0.42096614724783304, -0.8366002292219851, -0.09873480254339438, 1.079925019084906, 0.039523522372185746, -0.5381064802613843, 0.40931696767591474, -0.25254944012302133, 0.9463861260029479, -0.5459418961462479, -0.3457100225934421, -0.6977551687446052, 1.4165063229224633, 1.1689857014296734, 0.7728245686381978, 0.9814230767691167, -0.3350501042731859, 0.30731577268431254, 0.2372720049445942, 0.25125498712935534, -0.6646182556625903, 0.8364818379291138, 0.49799763833053523, -0.016899504594813347, 0.9183098294963596, -0.6402737113141171, -0.5146179640030484, 1.1115728263227516, -0.16500815317575918, 0.48764617317452763, 1.1497420059575107, -1.0427450407648098, -0.39185720005576574, 0.5645408076182299, -0.3914945261545979, 0.982713204575287, 1.0474727508205401, -0.07035516561867408, 0.9111735500326382, -0.8881989507395658, 1.17757023549061, 0.3624006993684934, -0.18759562344436892, -1.1321594125237124, 0.32233461988339235},
    {-0.13650730761567045, -0.321307964030618, 0.26747860038741295, 1.1571032431118424, -0.26936651952819324, 0.8230834510459298, -0.15295646590041823, -0.5003321900549341, -0.5224102376588666, 0.02726844001604764, 0.2230862798962696, 0.854672916574005, 1.4240431333116033, -0.760079482056041, 1.5291629252778067, 0.611261809416987, 0.8751562456100879, 0.19130422236016062, -0.2857930458316297, -0.9353302355487075, 0.5145367155028578, 0.3077128775739902, 1.3043159288294992, -0.145299410872424, 1.287941212360841, 1.1057046916245157, 0.6494740530996186, 1.0439253738408727, 0.16553353114739788, -0.5236767176084212, 0.9146924160273426, -0.4480202635324906, 0.2868946541404662, 0.7889456113105099, -0.5856354350494131, 0.4711358861910732, 0.7956384258858206, 0.34242506046468973, 0.07298753462182168, 1.5213934024090316, 1.248165210240121, 0.3816412493109081, 1.1297868369943591, 0.34940304802453803, 1.355374648193049, -0.038953065979280374, -0.22851432559321816, -1.0799861251858152, -0.795266734412596, -0.8683577108566471, 0.024085206975335685, 1.0461529578836601, -0.8410263252881518, 0.5302607541147195, 0.21592997132500974, -0.6652252937750504, 0.09947182335090916, -0.25938774733477754, 0.5855697447185964, -0.6011287355045158, -0.6400127547631016, 1.5750588183978402, 0.46966826764630015, 0.12807361723167945},
    {0.12039493987376271, 0.26669449424900177, -0.6007264666329256, 0.5151077896850201, 0.7693571941522491, -0.7629316172066538, -0.9459675264583134, 0.442241040495414, -1.0049443399137543, 1.3746460483936198, 0.9398034240518571, -0.26944329961504915, 0.17189692930333692, -0.645541356022001, -0.28342260129939384, 0.8774009145888778, 0.582852750530314, -0.3539736108510756, 0.43310550550532395, 0.9367374722611052, -0.33041562181271833, 0.23299136866325149, 0.03808501167266552, 0.42040195218975607, -0.5920013726321929, 0.7363811592282596, -0.854325243302469, -0.1880928898205029, 0.9883434237473411, 0.3524003300869926, 0.5330767391349117, -0.632485965456978, -0.26445731259880473, -1.0710971961517406, 0.16587942376072312, 1.1560518791368468, -0.7656091463399229, 0.4549399004049849, 0.656695368468573, 1.0052939816699995, 1.255554108745064, 0.3832455663228542, 0.20213641340064076, -1.1452590754701972, -0.8328362142166299, -0.5838497882553136, 0.7748285424950173, -0.826311318853311, -0.31646470568496043, -0.9979557786479858, 0.033625651461409785, 0.6354250069127587, 0.13693527474306985, 0.6872775710647789, -0.027928988798482896, -0.16280811248659047, -0.9301707815753182, 1.0224842899764977, -1.1833625680736466, 0.7956160985066131, -0.5995668935910214, -0.6707096436253849, -0.03956262512877428, -0.585364828437909},
    {-0.1745787492858579, 0.057807770085863006, -0.2524156917109293, 0.3836560380860955, -0.6889023250128563, -1.1695405408643533, 0.597166524226494, -0.43315605960126835, -0.9844691884635294, 0.8532977373822702, 0.381352378452169, 0.4473911915522294, -0.9152234326207045, -0.6338232223082609, 0.8760000356019599, -0.07649017386960148, -0.746093936596345, -0.06500180581864438, 0.4988961176642963, 0.7743736328383338, 0.6357707037843174, 0.2937506284066271, -0.10991417512343273, 0.2449804716959994, 1.3245024984182963, 0.9982613603367932, 1.1073087591804633, 0.421880033196528, 0.6865363677586035, -0.7799609136067484, -0.5823514339844807, 0.40366967424309985, 0.41074057250317175, -0.7002312732741148, 0.723051390072495, -0.9119914065828226, -0.9243071364556755, 0.7681618301057048, -0.551339371481751, 0.07874385750772521, 0.7088592655940856, -0.366221585883032, 0.4119552747220941, 0.3623114438540326, 0.3494463025465833, 0.19754336580299106, 0.9004484158983855, -1.2568639935428783, 0.6740981946828016, -0.621562826315596, -0.6045847144830602, 0.8279221074185947, -0.19526210207571967, 1.2311386477154125, 0.319895260076225, -0.08846451500514213, 0.8252470665618269, 0.27685814882808885, 1.1969294727139113, -0.7285332531019122, 0.07961504034123361, 1.247728972946575, -0.30022559645263863, -0.7977828308411196},
    {0.056707747684751245, 1.0592617220407192, 0.5386100664163844, 0.6005678341035335, -0.10912026374657711, 0.3211183459749906, 1.0695258330940471, 0.04192007941326323, -0.7379310491303966, 1.2417246058275175, -0.3865260709796749, -0.2822957464607726, -0.8243359315485629, -0.6773847556705486, 1.2386202804137822, 0.6290541015607227, -0.0320790457626279, -0.07879758811247843, 0.6235177015154894, 0.16498526425416943, -0.7089439610656693, 0.0656707728746585, -0.8695610941541649, -0.24597024471931117, 1.1160279347896709, -0.5662865190822013, -0.7020916874073487, -0.9163641652648103, -0.934339555568298, -0.26218386046624303, -0.6917516451998188, 0.1760557619081602, 0.6840015882829575, 0.021298647652560253, 0.3739945466566916, 0.9262694360131651, 0.6951292791250273, 1.2197696178316069, -0.2511848190210328, 0.4992612699303046, 0.976082084532844, -1.0455296707593602, 0.29956482844979143, -0.08064593939114016, 0.354862343474782, -0.7574059579471338, 0.19100481342821937, -0.09885014228425328, 0.3872362329255138, 0.3126734103570635, -0.11202174055929613, 0.5677073268864202, 0.10074446412156043, -0.04840202850230096, -0.13734257170807526, 0.18691658516338716, 0.11143685220400247, -0.0508538480997009, 0.09704467832502833, 0.5474861579891063, 0.5950383330239618, -0.9390869643481337, 0.9362990512162143, 1.030058806222489},
    {0.41137147628991033, 1.1759677484768747, -0.12540673410130748, 0.5239992260847832, 0.09898265673172232, -1.1636155441112683, -0.10400124359021347, -1.0205185504873588, 1.1061181678336816, 0.31184840097939565, 0.8319886546158101, -0.10571329556606207, -0.8914196606442043, -0.9512350015552009, 1.042628642219694, -0.14523259514959935, -0.13382229141980084, 1.1134742425433082, 0.2788483142413689, -0.6356330646199838, 1.267383722131725, 0.5297614005328093, -0.9396955470589807, 1.1238407849431071, 1.1799632587510247, 1.2325456358470932, 1.0498353372136195, -0.25152729087240033, 0.8256375390933866, 0.5621375113729337, 0.4066857979463214, -0.12524348104486863, -1.0515569837117393, -0.28798388087751137, 0.6976389283423474, 0.6925665378553849, 0.8055742439147868, -0.7274417221037823, 0.011162197299129423, 0.40546904118746085, 0.4424795263517108, -0.4957841256659648, -0.6913820664239962, -0.867452886822087, -0.17214958720510928, 1.002942349605858, -1.13215472770621, -0.43326216911168675, -0.24899772975672574, -0.4231201402747306, -0.21744901108851775, -0.5826166744824827, 0.3201636008009647, 0.8663493834933524, 0.3363165588983165, -0.19759351597104471, 0.6270127111223357, -0.8695677592856863, -0.19766075644772912, -0.9175533876528297, 0.08205841126063793, 0.4890218507914637, 0.10791254492773569, 1.0027133411548708},
    {0.16233347993929131, 1.3043364726347484, 0.7141045707774444, 1.144444807888057, 0.7641488570257183, 0.3648584320854583, -1.219295460806517, -0.3394791019282659, 0.13155215168911358, 1.2366506576649807, 0.649738843103932, -1.2144365801503942, -0.7966910416392663, 0.6831759421162085, -0.35534007374350873, -0.24607456576026054, -0.24703239385422784, -0.5865515357880923, 0.5384854863698448, 0.8308007194177747, 1.1632256362611944, 0.46647768582390814, 0.03718541887587342, 0.7512936953550364, 1.1100895273900164, 1.4617074569361221, 0.6655452286978248, 1.2767711273643416, -1.0194542412591174, 0.4026532871294047, -0.49149287532245617, -0.5312364993955427, 0.22804082776776718, 0.5174251838928039, -0.8211271984179485, 1.1683343098376224, -0.5105867608076063, 0.2548314501129899, -0.2171689500717157, -0.5100224178519854, 1.3400720839309126, -0.6508855615995317, 0.6158346998961298, -1.1597257059713948, -0.2680295487838641, 1.283508005718601, 0.5859623820124266, 0.5623083722274892, -1.0659969200453987, -0.6158128874731271, -0.4204587166855181, -1.080653667128249, -1.388786550864156, -0.30439346509353954, -0.4007724809259752, 0.8940986049637756, -1.139050023899687, -1.0590188467196722, 0.5422719903271472, -0.05783459540062126, 0.2309037083471375, 0.8045053032087776, 0.9210220274090626, 0.5342841289863245},
    {-0.8299824618219562, 1.2615762380521607, -0.27969775077588266, 0.8827795353214122, 0.01630060571590769, -1.0603464967927323, -0.716856917315201, -0.9013147245164851, -0.7655407993303045, -0.21790802958935448, -0.5067397304947184, 0.06436971552913699, -0.4510130089537728, -0.5706470044260686, -0.37048862010189015, -0.874139480100811, -0.7862431847263862, -0.6859731364073565, -0.621177128739747, -0.9883874465451057, -0.448220974610078, 1.2400720140140613, 1.050888447868436, -0.868029095626505, 1.2065985822938388, -0.5775457522952224, -0.5956993397841563, -0.33319252360490953, -0.8533939875277736, 0.7393391754195379, 0.09262622956754447, -0.05717413048341979, -1.0933398935839942, -0.7419388835091932, 0.13562999823750144, -0.9356919675336866, -0.6245089007767333, 0.6703481672372001, -0.43701876274118034, 1.327372402217746, 0.5911994483035967, -0.5034644294264555, -0.206550569885355, -0.09583296141635737, -0.2579028709848377, 0.5664538155952306, -0.6279655239812825, -1.2327274798087977, -0.21414906931275848, -1.4067457140876238, 0.023992398995667557, 0.6113973512597075, -0.6271068296929887, -0.05398904882103254, -0.8900706877660918, 0.8813153683350979, 0.672801305120603, -0.714768947864561, -0.03204561894560711, 0.1985247747272749, -0.3515042151519169, 0.0864804219872938, 0.7205240498399345, -1.0969650759509102},
    {-1.2182460167432554, -0.037718403677208814, 0.09696631662825109, 0.6991191970362255, 0.3416860706255005, -0.25048911829397025, -0.9882709391208042, -0.9844167202717782, 0.6024577907947325, 0.48573126549385687, -0.11174040287415284, 0.6928100486695788, 0.8270460400535692, 0.2834844415142953, 0.8819270463119331, 0.6927957007761888, -0.760546322703478, -0.6372053524353232, -0.4657233251444309, 0.7976019027599364, 0.1941253434674494, -0.899331951858805, -0.1141214369227837, 0.328799041102588, 0.2359430391584355, 0.9781267383129059, -0.6726466929095007, 1.1890653625412941, -0.9644081824625462, -1.016138475101726, 1.1591755894219111, 0.2837790795489009, 0.2282828962117587, -0.8554147748810277, 0.5640069978594127, -0.9156050130017844, 0.574393019076108, 0.7064393053724012, -1.0237044371851003, 1.2985763221280313, 0.21045440146974767, -0.46228057946978435, -0.17872439206443755, -1.455424393010148, 0.7730324864572782, -0.46118219984208686, -0.44723635336814355, -0.16002331543188392, -1.0321816885901762, -1.5500248298190817, -0.45212000845544403, 0.8193033894839101, -1.009516977783769, 0.4790657464313911, -0.09231812925393744, -0.48181129898444464, -1.1904942113326062, -0.20741632845782457, 0.9767590410824376, -1.1293375233567338, -0.9422416713693609, -0.6197813363232997, 1.0624260017726377, 0.3042680878068554},
    {-1.510548901961107, 0.3627765709847506, -1.092335801926719, 0.5298083009866474, -0.128060889153719, 1.142375136311118, -0.028948344946723947, 0.6019497437078128, 1.1796891808329144, 0.11973907623780218, 0.2996054227174637, -1.0835720253897632, 1.1521777772966326, -0.6372029449424415, 1.109821038820311, 1.1849712905727043, -0.8140299962071519, 0.11091447754332995, -0.8497643077859237, -1.3229704297067015, 0.5116112506039746, -0.8458040259425273, -0.1839553043044982, 0.6375418641661385, -0.48371346508805735, 1.1646953924140788, 0.14358394172303895, 0.8901135135333335, 0.2959206138585021, -0.060008377115487205, 0.08527315746733936, -0.836249879790915, 0.6472300072532386, 0.3967536580619914, -1.392390592748947, 1.273044857873, -0.6862339359525026, 1.3846705989449828, 0.2845927297829743, -0.13809717671391894, 1.507250604939824, -0.8049348813183037, 0.9922660818005257, 0.012864864449712174, 0.6310047449988669, 0.691358418703864, 0.2611736490623639, -0.659925345837419, 0.08083974196204517, -0.3757539528308403, -0.7286793375821631, -0.8089068163803498, -0.027784464800982917, 0.7102819359833578, -1.4775989222828652, 0.30832283306411906, -0.09289114874814168, -1.2452449929067475, -0.689027776246726, 0.810400340564917, -0.06819680385732438, 0.9170150125931761, 0.20384926966223277, -0.5402186590049587},
    {-0.4904830150430484, -0.2991509159754926, -0.018366398550128612, -0.8701298499302335, 0.013068983539438686, -0.16487555019985, 0.9856475568733531, 0.8896379786932426, 0.7916611578628678, -0.8611884836642424, 0.0940346207405079, -0.1404855320290585, 0.6339776008912077, -0.6103378554683186, 1.0434740569227077, 0.5591475262170014, -0.8924484367894253, 0.06128671293264022, 0.7659014868117237, -0.6239207635393866, 0.5945788878094392, 0.16985089748990706, -0.945491330161398, -0.51311400534845, 0.8557464447288559, 0.15108169215218054, 1.0102282089309753, 0.8032612200716979, 0.7582658274022526, -0.05694899011872962, 1.4540416052827836, -0.9717244175733252, -0.9473274139582576, 0.13003224949381068, -0.4464908648653488, 0.5322632152485944, 0.9934476637578668, -0.3397995702316556, -1.3472704239260744, 1.1718602905689608, 1.2038759494457716, 0.6429413723319787, -0.5051484516992633, -1.0225316595158653, 0.1941424333801808, -0.7307509433538346, -0.19187350925358956, -0.12373697720920074, -0.9101979952518078, -1.1972045159071887, 0.36824591836226, -0.3761566049547011, -0.08443314328250191, 1.096541946400296, -1.2525172623128862, -0.3746239746129982, -0.8031782111879296, 0.6639225914731641, 0.9705088336213442, 0.8464715977569099, 0.6402728749945987, 1.208936324246593, -0.32421209975603604, 0.9167824891056541},
    {-1.305869087779676, 1.0481577231408368, 0.5737742361947424, 1.033863648574859, 0.806513125793155, 0.7805234046956933, 0.8034982616621356, -0.6878058973910509, -0.7832915907650705, 1.062451375348599, -0.2645307814492815, -0.6715459514653065, -0.6971515032986132, 0.6742989836593029, -0.1541504311791969, -0.9201825678116695, 0.5476846951109601, 0.5071373097872333, 0.5117624502161744, -0.5243755500590412, 0.47509958713108175, 1.2964704200225294, 0.9966344550779082, -0.5571554097709271, 0.1792873476164159, -0.575884048100758, -0.667929452393657, -0.1441720489492044, -0.07128888022941966, 0.9288220715009231, 0.09016998012877793, -0.9303340640426858, -0.8198672942381608, -0.3785887389826842, 0.012173174653697735, 0.0026740452805748523, -0.46923789657775966, 1.0369750749124012, -0.03828897353889148, -0.006988677371405839, 1.150523902268509, 0.6615026379813325, 1.3735899220864332, -0.4714406276229451, 0.9946864114017654, 0.10773481375776234, 0.7102385668914879, 0.8788182124641557, 0.036601048033544144, 0.006488396856361492, 0.30145844844095876, -0.5659182117504322, -1.1556505946658424, 0.005251050946789737, -0.8426383876831004, -0.0680566301704938, 0.5765758027257623, -0.9367142223763496, 0.33940744345933815, -1.093031091644042, -0.94963243517834, -0.06966480498395239, 0.728303125030529, -1.334323407678974},
    {-1.118780198351827, 0.477953555484825, -1.1415846142698711, 0.8332704179497417, -0.03256424289894922, -0.16508517963557362, -0.4130773927533684, 0.7199790071675889, 0.11310965745841532, 0.6193037505359767, 0.7158216306863061, 0.007443370191726545, -0.2382768308546044, -1.1870590996317794, 0.6938091906859432, -0.18949915990894284, 0.8391510961351722, -0.7554845696149315, 0.7862293432417224, -0.23130701478789265, -0.6189890738337565, 0.5538405330498352, -0.1401812193769228, 0.31323559201888, -0.76223068099478, -0.5395256806068313, 0.1515678023723066, 0.2871918982227401, -0.9961013258200042, -0.442179743971684, 0.8934214351209039, -1.1561845705944191, 0.0150725453660771, 0.7212619392628237, -1.0209009913509055, -1.1867151058637209, -0.8522306915033627, -0.7919608969277503, -0.8277459174506918, -0.5213432150557789, -0.07495460655900842, -0.24706952797516213, -0.2864686895750152, -1.0562159690860504, 0.40600941508920124, 0.5216378730012926, -0.3139073354249167, 0.5051285764915884, -0.8001000049333263, -1.3891642058534022, -0.6872596050534094, 0.5647300888210504, -0.7515018983949098, 1.0984317680480917, 0.23265388362515918, 0.20807048488502336, -0.5304255254003729, -0.9705005702474556, 0.7450838136094216, 0.8236294986356691, -0.7783783500725971, 0.48794281869887796, -0.8813099169493367, -0.39797416683254305},
    {-1.5200813865994873, -0.10880013609558906, 0.5531353040137139, -0.8691607699261549, 1.107509648470389, 0.05857834040719179, -0.27208613515708313, -0.525798893676903, 0.294410591966061, -0.6384376299335814, 0.2986460338120967, -0.16157468648994114, 0.4407187828303058, -0.8623182351730454, 0.9730608044209539, 1.3427056850794077, 0.007793838345359303, -0.4711841290503794, -0.5118900551125619, 0.14002464488833155, 0.8169880076389838, -0.09432598258115456, 0.3799985287808259, 1.245934405226773, 0.7224377702873632, -0.6702167268513691, 0.3227042502390225, 0.8389491773434513, -1.0962296570635137, -0.7901602736484762, 0.31635199831624683, -1.1740497957856948, 0.2107265949886312, -0.9968851579894072, -1.0876569554310889, 1.161724563969638, 0.7338522369993215, 1.181775070038195, -0.46080035629587457, 1.4123727514790945, 0.5080294485955991, 0.8834013521981641, 1.2629667142443395, -1.1449155494769918, 0.5033522172239187, 1.2732332813264473, -0.496823867435655, 0.1664923198036568, 0.6342098977825175, 0.27595357377111246, 0.7790508714318191, 0.5142751068556948, 0.5707906894244178, -0.8969208945720547, -0.5406094654957643, -0.33185532501657744, 0.9872507199477587, -0.7827399878606581, 0.2781211276970599, -0.7712046639481036, -0.026664034599407894, -0.13260657800825318, 0.4048583973035229, -0.8912286031911459},
    {-0.917282164385944, -0.07948308979283221, -0.4678146356797784, -0.6491519903849937, -1.2068905928080702, -0.9024454253526611, -1.2712468838086026, 0.6271748718932371, 1.0329874277435203, -0.1472466209609167, 0.6204635929292972, -1.0074628763370577, 0.7205634114353183, 0.2980216278938909, 0.7165401810423347, 1.0886006027606627, 0.6448740376224922, -1.0150804744937278, 0.8749257067840037, -0.17160638452365334, 0.3283448246229454, -0.5009431468332761, -0.694173151776431, 0.7345869287366263, 0.45105111622785093, 1.2780157007559954, 0.815648438449733, 0.48070529748307417, -0.39461028893564126, -0.014244241472597775, 0.9777409507144242, 0.1753090639649631, -0.11193771854752271, 0.4514623406688554, -0.9866413768600563, -0.07179343303033903, -0.37085034302908, -0.3057358692445616, 0.2177994560692926, 0.08964127636404363, 1.4681769146875527, -0.5039684041479986, 0.35082707499154653, -1.316771789485762, 0.21909615539147873, 0.8150135168792308, -0.816240719048231, 1.0047343342227166, -0.31430256136858215, 0.18985034198465914, -0.1746647064052222, 1.2844211994060384, -0.9961862974044503, 0.581840862617306, -0.8929171454175837, 0.8653612752657324, 0.9843254529553807, 0.31710047062480534, 0.49960825679339343, -0.004828235216121907, -0.42631530990982497, -0.514495940689095, 0.45110735870366064, -0.7845804110138503},
    {-1.0921238721858724, 0.2809079628584902, 0.29733426717488387, -1.30330909843192, -0.6373670191904667, -0.7436302376778515, -1.1957087740774468, 0.34490605611334585, 0.5023616574959124, -1.1055917857626396, -0.5518556416382243, -0.4390655810238374, -1.1119991005740377, -0.9892451970071289, -0.018868519601504156, 0.04921244798229328, -0.7689455363672322, 0.5803140340187791, -0.9572309000077175, -0.9594003733368212, 0.1654389809531938, -0.4230669774585931, 0.37902120964243297, 0.5147188367990415, -0.4494602531595282, 0.29088443135451514, -0.53782651446049, -0.7313445371305742, 0.8765444508609771, 0.9557052015438967, 0.5191833745045756, 0.16163605541674145, -1.0437214261089256, -0.7476481411926758, 0.31797547207273213, 0.8177001358109356, 0.7621288759388748, -0.37269983357081204, -1.0292359057202947, 0.5093802340797992, 0.5908962636053193, -0.2968561196973591, -0.3624683945626243, -0.9202412107145328, -0.6287867522955474, 0.9172464042849235, 0.31725112150840956, 0.3889846830412499, -0.3800625628494603, 0.07696812701720249, -1.6986920876608544, 0.5328547728435167, -1.2481883963312046, 0.6578056473521462, -0.8551870548569618, 0.6347959534334654, 1.022914468905009, -2.0038446105887657, 0.21215240429263024, -1.4589542531038608, -0.25573032014583397, -0.11865611629478971, 0.05867490806932511, 0.880877588434383},
    {-0.7656421356806253, 0.22601840161866238, 0.8610418292195333, -1.1055096306832468, 0.1232587657211167, -1.0569132918557174, 0.7786452256801253, -1.2234127194668738, -0.38559422964285384, 0.625047244072931, -0.8856881455560105, -0.45699913587855273, 0.6268005550983758, 0.44055647244210944, 0.23977230007839423, -0.9095579613203897, 0.3292178088382146, 0.0716450603828587, -0.5693420309608634, 0.43340599956999093, 1.2090088034892355, 0.18064965416074708, -0.15269905002565806, -0.9668219052472831, 1.1274950369491215, -0.3590871349003211, 0.496973309085481, 0.29317990567620045, -0.0475883001286745, -0.9347377429061576, 0.6089667684258177, -0.13027795366265973, -0.9859454535508496, -0.6099828079815154, 0.49190546610643887, -0.18179338665526526, 1.2139548358075771, -0.24835443715523478, -0.13981353607517893, 0.8812667365163783, -0.8066101631631021, -0.7904845296513878, 0.5033616946619028, 0.3775671193064663, 0.2442193988199248, 0.3139419386593243, -0.9697549210666032, 0.18841715216751553, -0.05679152307702708, -0.7032634798000278, -0.17574686916717325, 0.3679802462990928, -0.4655866152180412, -0.6898265588622469, -0.5898111319851453, 0.6129180813110745, 0.9023654110996262, -0.940349348977404, -0.7797151242338156, -0.030975489313395953, -0.3207672243696809, 0.20196380302037914, -0.25385969121752083, -0.748890002003924},
    {-0.34373197706631226, -0.06897601165316793, -0.8325590189788988, 0.16026630455025342, 1.1525834194749176, 1.1186115377432306, -0.7483472841850723, 0.1643992347759447, -0.4308357055869258, -1.2213026702676668, -0.5455938913543246, -0.047277153215111174, -1.079572630433434, 0.21191328524443373, -0.6190639356795625, -0.18004161026861262, 0.27641310917735273, -0.0932942075226302, -0.28234425264806456, -1.2321721942390622, 0.5392400873540422, -0.3001370346800429, 0.2157237259154762, 0.0011594186854303348, 0.2340630190275259, -0.38049397808342095, -0.8048671300314509, -1.130138547507919, 0.6699069047980106, -0.6591989118560019, 0.9646668088469256, -0.9583515423030637, 0.7835896229368414, 0.04788769665995425, -0.7827748584532555, -0.6746219420594678, 0.7124221947734021, -0.5793612140528515, 0.2995062813585396, 0.8488178244975602, 0.9419689285078409, -1.1090696505061854, 1.1533994352605201, -1.0375910293770347, -0.04649892739149645, 1.0964981381255574, -0.7118372233091027, -0.48475421695580645, 0.3355355054287157, 0.392204352644575, 0.2543619927557654, 1.079845310445742, 0.0797769715020332, 0.24816929314116393, 0.3815124504228662, 0.16144387383749378, -0.4413572911110847, -1.0891173763913289, -0.5377762244855575, -0.034937106142935534, -0.9952202600826835, -0.9309785969868283, -0.95876997363212, -0.3575962219541319},
    {-1.0883368836787308, 0.44555926709375393, -0.12309351829775142, -1.1270665462590768, -1.0052724719438186, 0.1876980871221877, -0.0849605913108325, 0.2797192491585564, -0.49304237719021016, 0.7189523600689074, 0.4278707602477503, 0.5873331140805985, 0.27875846395992965, 0.954708881995649, 0.8712940726765078, -0.8859999928316248, -1.17591465092892, 0.2807644086119699, -0.48607033513492925, -0.3557391226655406, -1.0385861323639787, 1.0259737447584778, -0.5175585798873423, -1.078469286423453, 0.4523564393121849, 0.03225652172731924, -0.8799067347364974, -0.8166849728316732, -0.9590179766612074, 0.5985646777486652, 0.1998034265186927, -0.044638078178332576, -0.7691340915797777, -0.5415093799536819, -0.008314259117427107, 0.7679081999828787, 0.7080377178060341, -0.9942332277658421, -0.34562300689587233, 0.24750933318511906, -0.9180390738831802, -0.5876829290051375, 0.9320915425919202, 0.1890020058937092, -0.22494279725208227, -1.1119201097583793, 0.7408187030717664, 0.5025469647137318, 0.29231548297504417, -1.191761654580326, -0.3171548163284341, -0.024506769388482893, 0.8018716613967483, -0.4263546876882761, 0.14004077304834014, 0.24989035164847614, 0.08115073638575945, -0.14368637437836457, -0.23483732499517065, 0.7199941601092384, 0.834144945328785, 0.29167529187556784, -0.2597003565384311, -0.29165102475303906},
    {0.1407545911253522, 0.4007330225109564, 0.19617243097056933, 0.5358257915236488, -0.3218985241915563, 1.1096985729024387, -1.2099242211991885, -0.3609571047802056, 0.27640471023593755, -0.08789035381076499, 1.0750415363376364, 0.6052420329929065, -0.4473465396272531, 0.7545589311543088, -0.37291529425232134, -0.9994855875060492, 0.04780973461698533, 0.9493921970033915, -0.20246485892808327, -1.069968583441374, 0.46707941932323754, 0.9954394842217157, -0.32736872741139883, 0.7447037519759564, -0.5752854930735074, 0.40463291976657945, 0.6233878466617154, 0.015130930410854681, 0.9856025547086182, 0.11836724635318059, 1.012868570074241, -0.06242673122779971, -0.5663210208564176, 0.642702151873866, -0.32249711080737553, 0.5829837517963494, 1.3100954996653782, -0.32546440401719523, 0.0076877986269247075, -0.6824495780878448, -0.5592303394713722, -0.9345655899042322, 0.9121397226884561, -0.7300279043367002, -0.753611250285487, 0.010884354818459696, -0.9827772948893087, -0.42070643176979766, 0.8927173192467942, 0.449461400578833, -0.5348135282900799, -0.09632583725076409, -0.8362424431378931, 0.344399655129394, 0.05398479040571153, 0.9244804424028683, -0.7517865313646851, -0.87915417573627, 0.6316463988258246, -0.8450875336989828, 0.4596782317926349, -0.9882420184121564, -0.0607828432334502, 0.42740878894367956},
    {-0.09453827342930829, 0.590410875914014, -0.6992329475964472, -0.9567606728899395, 0.22241219223454128, -0.08416101929290724, 0.19437282091662433, -0.6010480488751437, 0.5552449623953151, -0.19718378549623267, 0.145860304852636, -0.46920469983003094, -1.1715656083571082, 1.086400648182703, 0.1738524458246096, -0.5864441210595542, 0.018297869831797764, 0.6431182751390366, -0.4533670426226738, -0.5193783243816097, 0.29882248359984037, 0.18229896480374147, 0.7165227234454399, -1.1708677643309415, -0.7871580192783586, -0.010166763796095392, 0.43842070450987825, 0.6117846401290395, -0.03614061173691865, -0.12800472050006562, 0.8420865927688896, -0.5930177624354358, -0.025300045155676357, 1.1397517919811047, -0.801985496501686, -0.2517954527755512, 0.4084747875561086, 1.0549727284612351, 0.18950437589938893, -0.9278061990738007, -0.5216264258545406, -0.3122715253795781, 0.5802315509831404, -0.4011882730755301, 0.40367624484356, 0.9846623599223853, 1.059899559629849, -1.0663651233591396, -0.08858551787750078, -0.47142461591260526, 1.0972442369768718, 1.2412727655992601, -0.47727556521351494, 0.38546156104244367, -0.3692295407693977, 0.7766672764053646, -0.9397209202857544, -1.4846432980459388, 1.0667486221992535, -0.3500333138296981, -0.8806325706118838, -1.2015551587694604, -0.4529265730821783, 1.109666105256069},
    {0.7867792584783532, -0.699520821997088, -0.26223224301676223, -0.1829542738426052, 1.135148406863902, 0.9285425937803694, -0.3035136834006268, -1.0658272761421623, -0.8992772299415432, -0.33080481329003225, 1.0486624445170134, -1.0056240714774536, -0.7701407819521309, -0.2762521890336901, -0.6254810272709564, 1.0412827216331888, -1.1309296691761501, -0.38654958902595266, -0.2839733962530049, 0.25393456452071794, -0.4204901495123667, 0.6123163728092336, -1.0285364309188567, 0.678747519440513, -0.09946158825259946, 0.3246920308611007, 0.7228897036243881, -0.5584497614399618, -1.105696506050826, 0.32536260483531965, 1.0290585915032375, 0.644525145269427, 0.3739660823970437, -0.023929205708674222, 0.9974902475517962, 0.10237359488050206, -0.5156682949653615, -1.0846812975984148, -1.057777573403254, -1.1560162521814812, 0.7173971930540484, -0.03948209038744329, -1.0405125597874851, 0.19653440446111217, 0.06698775241283168, -0.443240444626617, -0.0187495714806235, -1.1870199648596467, 0.32216148186819615, -0.9610338698097993, 0.08207022764423717, 0.25703495766730805, 0.5712562574024266, 0.45697769018634127, -0.6071256223172609, -1.0144577800993815, 0.49091303243316076, -0.8595199901928355, 0.7443640006985929, 0.25733613379842696, -1.0848901735988443, 0.40634159737567804, 0.8393347174871266, 0.8865319204591205},
    {0.3267106024435498, 1.189847650466606, -0.9214243322476143, -0.7195535012238659, 0.666855416903575, 0.7527462272505823, 0.7261770329373288, 0.44868760786490747, 0.1282728625192985, 1.1340413525397879, 1.030137439901196, -0.6552041572252836, 1.0126498929003784, -1.009589964813453, 0.6445063277866694, -0.3718098054005637, 0.2019649529093742, -0.3798300061496839, -1.2101237232953779, -0.4280966533721155, 0.1256713714662321, 0.6458616693230527, 1.1285640526721374, -1.1676591427872278, -1.1195362116131822, -1.024712295356793, -0.6950555220141362, -1.279027221119118, -0.3328165957029339, -0.8376047691417161, -0.8016965890554195, -0.05876349794059097, 0.5544101689100138, 0.32461723290697975, 0.8179155143108323, -0.2895997800804868, -0.4695610964684514, 0.1807123440634408, -1.5207853636965745, 0.4345110170078711, 0.051838069259556196, 0.5836928040238303, 1.1317069466869725, -0.8990426922330237, 0.6576047417113086, 0.2842106988449764, -1.198968393402185, -1.048268292207131, -0.49955000748842365, -0.5586794265101858, -0.45637789078446084, 0.19564732398699422, -1.2392928096639604, 0.8845945551531672, 0.8735650339242682, 0.995640448619501, -0.4019847762063819, 0.02902041991607519, -0.24069132219864794, -0.33322600204283614, -0.016992255363784764, -0.5219132100187698, 0.5970654572174273, -0.936384683953979},
    {-0.47463056911288926, 0.5119845649792363, 1.0860868182805534, 0.31237164348477714, 0.8075429997851744, -0.8538381171581647, -0.8427396235688162, -0.22780781151706292, 0.9275454777804423, 1.0502648000401624, -0.708899310896993, -1.2971592491447266, -0.21896061220287438, -0.7546269618560789, -0.18183073037847308, 1.0709843767212237, -0.8550272172596015, 0.6397212148479219, -0.9028799895813072, -0.5556135109926071, 1.0495484586997172, -0.22228334551539278, -1.155205073430605, -0.24881219883468786, 0.7633445344223991, 0.8322141403247119, 0.22025145868399132, 1.0713602310454324, 0.558407251849659, 0.9130307668936414, 0.21797428225295676, -0.0347449022489334, -0.912577196115333, 0.2893470425411816, -0.3287014717116996, 0.45330554773452275, -0.8576842389652513, 0.772458411561096, -0.32312853397554164, 0.5753544043927628, 0.20794474209621533, 0.043003494679113186, 0.5932766407474453, -0.5252096888169465, 0.6372547830954863, -0.46461971291807974, 0.243721143702587, 0.27302007766819514, 1.0112357484482488, 0.868764239831523, 0.10442756663337883, 0.6892846457773786, 0.5790926355306387, -0.6987517612648052, -1.1364204628274546, -0.46215361217976836, 0.20643530796965717, 0.20470207565422213, 0.3740156212182405, 0.3780294567596437, 0.17419386281837354, 0.9463230335243801, 0.5541421350982444, -0.6804856647045967},
    {-0.8613651004932477, -0.882436024968976, -0.8286954829829216, -0.9964410645833985, 1.0447194667255775, -0.7828058140687552, -0.6854862033093713, 0.37617499536929044, -0.9714427424356201, 0.7271825005838826, -0.43896653524234325, -0.784077620435746, 0.5453837063899406, 0.31543296555982414, -1.1914045223023961, -1.2602393005193384, -1.1003125205205144, 0.07812613034002937, 0.3811267173247181, 1.1091706137099313, -0.07336272351443268, -0.017303926052392525, 0.8247766346554677, -0.8061094615292324, -0.2974583991248931, -0.2588687324259974, -0.6378708361882525, 0.9123541182595944, 0.6533548211072302, 0.46280368869271604, 0.030787013636060713, -1.0884618756293194, -0.3563709297111203, -0.6195409798245126, -0.11477101281923788, -0.14093013325156742, 1.2101886310657557, 1.0463324583337064, -0.8599577601713294, -0.8060952128666458, 0.05613844286940561, -0.46473679099960924, -1.0590183622789842, -0.7472419602177803, 1.137561307898407, 0.39282921806447285, -0.0652488371671219, 0.1343367305072648, 0.06481776590271787, -0.04220120339088217, -1.2209942794948878, 1.066049211929021, -0.7732842400028549, -0.940727202526599, 0.39247797655072225, -0.8680320150283213, 0.6734695616365433, -1.1639529744281356, -0.331088708457341, 1.3376532263026095, -0.6521535133581433, 0.9624609060368265, -0.5915112954446443, -1.3064991094540743},
    {-0.8936425878248478, 0.5375356007905394, 1.02417976424945, 0.3928408747349597, -0.09889514700218789, -0.18023920913282931, -0.9105891960028482, -0.6849910535417992, 0.8439867855512707, -0.8105549562645374, 0.3513719099995122, 0.286472068656265, 0.9713302066292271, -0.5922020142141308, 0.008637715785441242, 0.6040644247947018, 0.5868248549725541, 0.04467676190163594, -1.0595461867585259, -0.9630838787499468, 0.5359266442545659, -0.07482339037979355, -0.6672637855933896, -1.0211100492338812, -1.2396453962011935, -0.09974542711554932, -0.1431908188736098, 0.25581013344568376, 0.5387742862458605, -0.5633970473567548, 1.0749199751604612, 0.4644735715594141, 0.0038060426855175827, -0.8857765530229521, -0.24546568093648305, -1.1699407533495771, 0.7021599754311254, -0.5262950670976024, -0.18385818402689183, 0.21550723983507364, 0.8619646784868796, -0.12795605853148484, 0.02240976617750167, -0.04336874572705552, -0.7280190533070033, 0.1736421911725806, 0.5241700726077229, 1.0350327447132508, 0.7283931386227611, 0.1692158140975238, 0.32216423414039164, 0.6136033264756321, 0.11763906158533274, -1.3018523701363802, 0.3379156975487601, -1.0319642871519779, -0.380074484261342, -1.1810367106810353, -1.2503900451885304, 0.28112992043644935, -0.6202974121589734, 0.6220512170667089, 0.35498615359793023, -1.3549316833952183},
    {-0.052539196746105334, 0.3329171593569245, -0.8757440274550444, -1.1358334258662373, -0.43383605034991024, -0.5506546322873118, -0.5108869700767744, -1.1802282684794145, -0.2662532419803816, -0.8130710481303202, 0.081251702134611, 0.9899739278717148, -0.9653022146866239, 1.007172267760495, -1.261196623518308, 0.07008535538475527, -0.1775467037528568, -0.003705356998062835, 0.5480349213264688, 0.05849303989209366, 0.7313248543877533, -0.1752931585636032, -0.20149164420165125, -0.5973682327347082, 0.19396063422636495, 0.8194314181423558, -0.439949631498274, -0.14456881057750298, -1.018606300994995, -0.14878110654265225, 0.36300258929150186, -0.32996932347438485, -0.6262788014412602, 0.6351521014935626, -0.7380483740376922, -0.8350582671477166, -0.1852437657943059, -0.9993468928615133, -0.939820080760202, -0.6967267819938262, 0.9470820188231639, -0.8925628960521986, -0.19392501202731235, -1.0007768036520512, -0.24104000514881319, -0.8535817723766481, -0.10386691215810152, 0.4449232125239433, 0.9818309174549132, -0.8681751360712135, 0.8884375592881909, 0.9843344727057416, 1.0543624410558803, -0.27913987318225864, -0.531339246767244, 0.7058316030838211, -0.4634614161181753, -0.11148320698788997, 0.6018359821439639, 0.9294899846017308, 0.3675850351058564, -0.06015372702965828, -0.07686826338106044, 0.035172411299678366},
    {0.6680618184872061, 0.27712716424626155, -0.1123508529201366, -1.122893742697848, 0.179100623591408, 0.7742206016224267, 0.33961148801131885, -0.4822129605644086, -1.05411877551364, 1.1485986744129097, 0.019056253917197872, -0.6653577575736566, 0.9420761009429052, 0.3386951518678816, -0.0315431146266651, 0.37027368570716035, -0.6168955948311111, 0.3196429222975186, 0.713871422471878, -0.861987933110544, 0.712894387380282, 0.10071215108037226, 0.8153359418915396, -0.5112855824741996, -0.5622935842496006, 1.2046929702918836, 0.8427319322840062, 0.8152120669460863, -0.7363012753472283, 1.2055304752025133, 0.9611610478515655, -0.8051309013870981, -0.792503127070732, -1.1551626255947416, 1.0743162702754818, 1.3596512779166492, 0.5048316569330568, -0.17919553588500864, 0.46299891174028823, 1.2904161656783222, 1.193752295783004, -0.3800856188812524, -0.8943037172417736, -0.5274893554207373, 1.2046638326042691, 1.1293034848015842, 0.5399356120975485, 0.33678409117353425, 0.26689108758444546, 0.23464524105535323, -1.0263849654895574, 0.4146082660921198, -1.0286555988612653, 0.3810664850203499, -0.9214384137340779, -0.916101232142554, 1.2447654616998367, -0.12538986948706857, -0.2355783128046444, 0.8782873541233346, -0.7921255412085542, -0.16741438642818257, -0.47503037065615616, -0.6998363514815414},
    {0.9790273689187347, 0.2325536992153584, 0.400904327619403, -0.9764480064615539, 0.7530324045117245, 1.314629125986045, -0.03639057146978978, 0.7432047300569915, -0.3066131705527309, -0.6768020399199285, 0.5559722036062174, -0.154885803988169, 0.8492649181665095, -0.5576025548086803, -0.22906714376755458, -0.5684587956017235, -1.1790074126268213, 3.3626430299288036e-05, 0.6284758989932736, -0.11699258199324755, -0.5974853571926274, 0.7498062272902194, 1.1635605426987654, 0.22301681053756228, 0.9074298514869201, 0.623549263999623, 0.06270844012291668, -1.1758123848191313, -0.6516917942419825, -0.47805563599148426, -0.5247244817439213, -0.5172025306016825, -0.36230283503916194, -0.9499362623885458, 0.5720472922403134, 1.1035482778325252, 0.4712998391805311, 0.6041795522206165, 0.6893464149890451, -0.4919518370037507, 0.4817962603624329, 0.7767688517588925, 0.11614463695350465, 0.34123487357160087, 0.20112562208991475, -0.5022692894543324, 0.39957260150050417, 0.8108381930780573, 0.3153771838939678, 0.248119622364146, 0.04499487803841739, -0.21656206241793363, -0.8420272865827797, 0.2682488817389239, 0.24177782247542762, -0.1003359850974677, 0.15709940674051018, 0.6354223758322588, -0.19549707828809945, 1.2390987186447862, -0.8999531895786453, 1.0036288039621777, 0.25227958122501926, -1.0205546743722465},
    {-0.2561020398622619, -0.637270108545049, 0.969784147129194, -1.137845389025039, 0.4942601985295664, 1.0638248585756616, 0.0894301136297265, 0.6605806820524739, 0.40119376263659257, -0.8044501337327845, -0.1652822103179904, -0.981416738503068, 0.8020302260949622, 1.068217041252901, -0.7935313770660168, 1.0390167511379256, 0.6780999585402412, -0.3813046678646793, 0.44537571984205787, 0.04217439423356197, -0.8400871259682737, -0.1407089959646419, -1.1209007403558342, -0.9759757354866047, -0.5618388444356596, 0.3596140206971542, 0.9974884365064465, -1.2332116183679769, 0.6685980155754105, -1.0296291896241976, -0.037566909939165026, 0.613727367845783, -1.0264238194533182, -1.2175114440908636, -0.11450088479945533, 0.8394861644234545, 0.07426486175304817, 0.9620241569394813, -0.47379591369520396, -0.3249730147030481, 0.11602325230888516, -0.2639975583097607, 0.12043254870198235, -0.2347026082407409, 0.6566293758878217, 0.15195714650980044, -0.8803493761446739, -0.7592122953656741, 0.45084605019916396, 0.2456304955548679, -0.4446937292329139, 0.3148131767743233, 1.1923017896725823, -0.06812821855492528, 0.3884377429608777, -1.0306570786307416, 0.6508651681476681, 0.025293816009696296, 0.007091965445071742, 1.011293652475213, 1.1288958911775475, -0.8594526738763271, 0.605435017963389, 0.12558377323048392},
    {-0.49135584103565616, 0.4229630060880752, 0.6109427980447368, 0.3250033913949177, -1.0088033014138167, 0.6257323535579842, -0.15001997126984665, -0.7649663522691119, 0.0837117862225713, 0.16297255286909607, -0.6711856029937149, 0.7028440932391294, -0.3161574753154128, -0.7999649510479538, -0.2596616374028058, 0.7874315371192667, 1.1562067213582723, 0.4660899404547888, 0.3773804758315951, 0.3692042304202131, 0.08268964419033938, 0.0026653838009914462, 0.8945843472555621, 0.9884955048044382, 0.5206315303020107, 0.9611483417837215, -0.7082693953412845, -0.6555857259467434, -0.7144487787746209, 0.06912615350180058, 0.7809063368780998, -1.0209457168725233, -0.7574941857683459, -0.30748468850786453, -0.039845319566201486, 1.2906285406516385, -0.4994629684563741, 0.790050411779845, -0.37490054116941646, -0.2917749252330596, -0.09687369405900163, -1.1612711014118287, 0.2969832401617149, -0.7183062549886984, 0.4348437440981535, -0.03643186768305767, 0.19599392431696674, -0.3152998390469183, 0.24386955874234584, 0.21572465989280723, 0.13531387048223928, 1.08532292195416, 0.09520598372718227, -1.0254737215612821, -0.24003014646400944, -0.044308510521162046, 0.21454292332910377, -0.7094145476247067, 0.23638816317532332, 1.2724598931708047, 0.6062327893740301, 0.14276139541718208, -0.21949866948703564, -0.6987053731019791},
    {0.7227382794383719, 0.3354039022955191, 0.3455809176672901, 0.33614439728700624, -0.07550964165182482, 0.4543448931376446, 0.4414913258944984, -0.661015541790532, 1.0779028371546986, -0.49418691378856966, -0.9540757293379241, -0.29848853278185167, -0.12284607392422796, -0.75534475154501, -0.1360164662414194, 0.506727741700088, -0.4601658996363401, 0.14570720538778278, -0.3286860537710138, -0.0868494583606307, 0.033082634488451744, 0.38706272528464125, 0.19891099915849667, 0.8616621390323036, -0.18093613862883004, -1.0593217171132845, 0.7395216157651102, -0.512642842305696, 0.6152663121910437, 0.6382326603391189, -0.41506695859798953, 0.6047201600056009, 0.5614568162157896, 1.1534885649590834, -0.9623536444062967, 0.4212097870958249, 0.5723859054525348, 0.5923584209405457, 0.6913425403504668, 1.0692822258494419, 1.170160910620663, 0.3597024583172508, 0.6694106293390113, -0.34495576189751104, -0.708409674486627, -0.2920439039581202, 0.3585849676317904, -0.08523469357108693, 0.8268878419438742, 0.5037670603245283, -0.7084455348721254, -0.43344059824134146, 0.7936949009537566, -0.10025014673906527, -1.1019727165662634, 0.056996985133293404, 0.23195073229599694, -0.9389774963893882, -0.1555721734596645, -0.47005590244382167, 0.02485644549177358, 0.5678044551796084, -0.6936453159188133, -0.029487201991744927},
    {1.156774070652262, 0.12729618708122273, -1.1587628614714003, -0.9197843005684386, 0.4368132086640224, 0.6077237927533137, 0.5188584516863854, -0.4451680561399355, 0.15764273364255663, -0.29700890342666714, 0.4371758563534902, 0.6597439761908972, 0.4757977505298084, 0.09854795069268307, -0.3376989235613848, 0.1255227800135704, -1.1645325701601117, -0.7115688356006691, 0.6585836837270521, 0.9024156086200725, 0.11191802740624972, -0.9402298193538846, -0.3890265672332325, -0.2936843764698444, 0.8777268983308504, 0.8557208246998284, -0.6951896354698399, -1.3005952433544299, 0.42341212867633193, -0.7374488694135234, -0.6179868837858018, 0.5490381096690821, 0.9825326326249932, -0.08937324297419698, 0.9533562122006272, 0.7056780377513499, 0.1910572689694221, -0.5268262549522338, 0.5569947010971202, -0.16633121207352947, 0.5598395441394428, -1.2486974352186175, -0.7310795712957749, 0.9461333881856878, 0.4101543311745826, 0.8415047515337946, -0.8666495416868631, -1.0496117355293992, -1.1777490996301705, -0.24750696782756784, -0.00015437423250755234, 0.4429217496148061, -0.5037881930624678, 0.25237769993940484, 0.5447636125764347, 1.1573090970715365, -0.6263827429873433, 0.15838201536312704, 0.2499613077019514, 0.05019792685210297, -1.019535714389153, 0.18534973381401187, -0.15019442513582026, 0.754497063553811},
    {0.922390844238131, -0.10136526277987834, -0.7579744281035111, -0.9915028382005501, 0.7683506229285673, -0.06157425588210973, -0.9009673721764795, -0.2103825095784193, -1.1160535037970836, -0.44058355517190323, 0.26425243512087454, -0.19068891022402837, -0.8534875329530535, -0.49163899579683384, 0.9694635745457872, 0.41633568592190934, -0.47071391622122916, 0.39733899789133537, -0.7770929226834897, -0.08712063238071374, -0.1579146355515917, 0.7292740093324985, 0.8375999438003852, -0.9572569998015424, 0.6911586207265701, -0.6202300372411506, 0.44439297116824783, 0.5881365851186335, -0.8500724921962415, -0.5600176085234865, -1.0338740444124395, 1.0439368133085727, 1.1671047640591956, 0.07189586191141517, 1.0165182786051419, -0.4788441944362502, 0.2146519825764157, 1.0603517448825945, 0.1792676507365408, -0.0790374640212308, 0.8115934045141613, 0.05326491978163475, 0.5710019269552623, 0.14811335948862323, 0.03801962567034186, 0.2161035931174581, 0.2222288317804138, -0.26632197212422937, 0.8137239990758466, 0.7321007710293989, -0.2928486755030295, -0.4754291486680236, -0.04993046568077971, 0.6752862442536954, 1.3434932006850833, 0.23817953594592675, 0.3420349312081854, -1.1971020164401422, 0.7885360719368996, -0.16718622288867582, 0.046747279013988924, -1.0040683664167385, -0.13096564307465464, 1.0153808191773104},
    {0.12363788336599381, -0.8818185613564969, -0.6530161252513405, -1.139804617468267, 0.5423651926300291, -0.5904725185495233, 0.6498765717692053, -0.5261172422596888, 0.6171034797427496, -0.2906491109907536, 0.4529549028117478, 0.35282412681022957, -0.30161787886029295, -0.7549470985231739, -0.10153801157952443, 0.5063241112269904, 0.915272130431894, 1.2212146108858164, 1.132006845077523, -1.051299365857549, 0.3731734130134146, -1.2053575853079426, 0.5196333650567748, 1.1799580938194347, -0.13155970373391535, -0.8468273131136986, 0.6061470474941498, 1.082009061667352, -1.0035750297841664, 1.0588932448941262, -0.30336188394072167, -0.4087037989461628, 0.9694135311401912, 0.8243896260234097, 1.278511535613169, -1.0092592380013166, 0.018672599400495888, 0.044220443877951904, -0.08049093867406872, 0.9214549296516837, -1.0085379213487948, -0.3436705538296053, -1.1590091116055778, 0.26102749619293475, -0.2162407699668137, 0.7277974967984229, -0.9054936654128991, -0.3530013347680845, 0.7448948638489228, -1.126991517278843, 0.5417339997288529, 0.22642700688228456, 0.08052437722818653, 0.15053767882643815, -0.8129457775711424, -0.6120436328557921, -0.9281623794558493, -0.38400664390434636, -1.296937757839044, -1.0024358148682126, -0.5350469810458142, 0.6025044854562503, -0.47824190606711203, -0.4923077910211744},
    {-0.887196370479231, -0.25433748232496406, -0.8271388551405023, -0.9053501430893275, 0.5821822325693029, -0.28747999178516237, 0.4150367137592572, -0.4745049603593464, -0.18034414033041096, -0.42139588686100293, -0.08611730127279621, -0.17120724409603102, -0.7527900747546417, 1.163356466924085, -0.6409664287857557, 0.6166783716262763, 0.7719651798405595, 0.9471880682438314, -0.022186246781859528, -0.47311355332834343, 0.4895478395942694, -1.2528757270644906, 0.5067765186372212, -0.8368710367756979, -0.5761446221367768, 0.2525133399745797, 0.9170014829929195, -0.9636071041101509, -0.5326503159511369, 0.3125801836630671, 0.13554218097059034, -0.962306572152824, -0.17384073382850865, 1.0339732687440109, 0.9535849280885238, -0.5073055722202676, -0.645723367987144, 0.8473388316870094, 0.8277947494838064, -0.5396179599784744, 0.7359985776908761, 0.011425093342821215, -0.4544194274308899, 1.0899743595631768, -1.1800620245237292, -0.2843918535699998, 0.20758132342433833, -0.7282219972795803, -0.3020748368787508, 0.6517423578266177, 0.6546511862699829, 0.5480392922756201, -0.44015131489203685, 0.44812339072316665, -0.906013671789679, -0.22064189626569844, -1.2201405487893693, -0.9460929871953272, -1.2924936833223226, -0.24807021662791123, -0.019402052998372717, -0.4726002290018069, -0.271016989172489, 1.113971789529607},
    {-0.34049250017766614, -0.5758595325640928, 0.6189291865699083, -0.6021811699502754, 0.25828470190805586, -0.2948342593581862, -0.9266217826549853, -0.7104919178951142, -0.34173284326760195, 0.23228215552987902, 0.032513841544651055, 1.1693766016537368, -0.14624325851282088, -0.8613830973501578, -0.8022099251714786, 0.302133860411437, -0.3530924482099718, 1.1729349802890234, -0.557436605852585, -0.6468529991859395, 1.1154729022650627, -0.007767662624357649, 0.1551290103900576, -0.4319644394892327, -0.44530015639685994, 0.8916121624489513, 0.5718908673404042, 0.18527908424277495, 0.285758604465663, 0.28751801373821556, -1.0430290871723953, -0.17652050091324575, 0.545265063809137, 0.6712580504719965, -0.1841413325214699, 0.9192450506389246, 0.04942546249001214, 0.9717551514341017, 0.46593252246479083, -0.006159088052071646, -0.8135836668302643, 1.033768458545722, -1.1942772163166244, 1.0874408408977685, 0.16677958767796203, 0.7371244735690314, 0.010363643217227912, 0.27588589245687917, 0.4990041458092148, 1.0421941143903977, 0.21578126000993977, 0.24601335969306293, -0.6428038555593868, 0.860258967242546, -0.9631952443349249, -1.2466156659328846, -0.8109975374795003, -0.3219124370871445, -0.7485826045721229, -0.16835678746931063, 0.7322712187516188, -0.5637044515498417, -0.045237073404353616, -0.5515692562664648},
    {-0.5219923096621996, -0.5608836347234532, -1.0737268385652416, -0.4937813253302552, 0.8953076587635824, 0.851473201448542, -0.9071261708865485, -0.249648691140239, -0.935110883782862, 0.023559518911256305, 0.8342130667227801, 0.8480789863963717, -0.31566333649858086, -0.9516223175454271, -0.18690715677807354, -0.28292694613309516, 0.5578248712227, -0.26040770909860705, 0.146491488391292, 0.30251360133422284, -0.03148122902122388, -0.20153079381629044, -0.7072841714077013, 0.3950885198901701, 1.131315622060539, 0.9139779472497938, 1.164258008691154, -0.8491421162906282, -0.29224849622619403, 0.3825029185865281, -0.6737869847389744, -0.5606106170749705, -0.2975493340784791, 0.3832147672658848, -0.7311978621237377, 0.44000060743849057, -0.8870638508313518, -0.819490196279549, 0.13884479204210232, 0.0787100830678421, 0.7109582801610776, -0.08179305006491132, 0.5738582855455379, -0.009928718886024309, 0.451430557036605, -0.29732796823415003, -0.4019948982673174, -0.4308620124332908, -0.0031602495055683836, -0.32703996321554335, 0.7016398807158056, 1.2027272138790415, 0.34579726462897625, -0.04887655550807054, 0.17348768909810217, -0.7877572868222436, -0.7416478767754373, -0.7276056881586317, 0.4348294296379812, 0.8880199776106543, 0.34913088110214796, 0.868947691109488, -0.0888070785924581, -0.34467050892650125},
    {0.903767900493554, -0.4174643094906576, 0.4168537677454114, 0.07153062076173787, 0.03449102713349319, 0.9501355732939006, 0.36013185200227316, -0.6949655666698014, 0.46881194738818704, 0.20378624996813346, -0.4803114690090276, 0.3687527026297641, 0.6383310189100574, 0.590345982617333, -0.300551577067902, 1.1966735515094826, 1.2378424523141662, 0.1892741312194411, 0.6051719417643902, -0.2561328304046478, 0.07480730590838143, 0.3587125595149166, 0.613789310438005, 0.7500496901883671, 0.18912031360194692, 0.47620626295468527, -0.4281479160130139, -0.02988544595801828, -1.3783732865908378, 0.09496462582115556, 0.35916816892267167, 1.0580102968188614, 0.13193376617666455, -1.2250111610204069, -0.9494709971817447, 0.268907123894811, -0.4660264970700265, -0.4592667593181115, 0.026693603328248935, -0.19042564515715302, 0.6401095625106498, -0.5239474765867288, 0.1346124894780364, 0.9282749680815651, 0.3172100904854535, 0.7847182972678336, 0.22689929623035274, 1.1481769186803468, 0.666270679514767, -0.4740848245653884, 1.1436111709673191, 0.34914154926213764, 0.6389574665272144, -0.27664816074493825, 0.5241240018757012, 0.9632787514543519, -0.9819685728546531, 0.8600629112355843, 0.8870994395782402, 0.6951085483806396, -0.895301258752441, 0.27414846078859273, -1.0012483412913817, -0.6785867484893017},
    {-0.8639786653572448, -0.2845107243653616, 1.234044915974756, 0.11760246369195251, -0.18759680509304769, -0.05240727788678236, -0.45984431495236144, -0.6177064352401779, -0.28783412407193204, -0.9683279993176395, 0.08312889202601809, -0.434427635512932, 1.095321836917094, -0.524644740266092, 0.6924591506970138, -0.9269200256610753, 1.1333994222056563, -0.6515235422194415, 0.7345828517788529, 0.4278955905712773, -0.3441229609606136, 0.6981846352878018, 0.9439607542431988, -0.12956996184962702, -0.6748775435802412, -0.7765785105785958, -0.1948020767607895, 0.009998331742621486, 0.38272860343647075, -0.8575550544924365, 0.43644040761860287, -0.5244839171195678, 0.5464682267265578, -0.9567964287713111, -0.6316780683351583, 0.29432900830754727, 0.3721456493322674, -0.6343123650596363, -0.843216414840544, -0.2214578810030085, 1.065278387890272, 0.4071400707923018, -0.48561253747359306, 0.6991193651752126, 0.08740637697802901, 0.06932693488384906, 0.588642178895578, 0.4864546234723881, -0.830915432767403, 0.9521770702987977, 0.8855610232380332, -0.8846299040747183, -0.23241416318651162, 0.048043786305073145, -0.8497785330832976, 0.20225500733372356, -0.8890565556742936, 0.23558433086744465, 0.2672877532945463, 0.8046516169392819, -0.531402836508856, 0.3723688195576259, -0.37323225545771144, 0.8027812353150674},
    {1.0076064026981582, -0.580354387338763, -1.0258982362148787, -1.2930782735585598, 0.7538782341313071, 0.9132264909175938, -0.8923041086435101, 0.43125993793644285, -0.7197574484948064, 0.030243157925245078, 0.11233784041331259, 1.1055711351986228, -0.5714495358327342, 0.26350804059299865, -0.9464829112229097, 0.27852149060841885, -0.2450085511590625, -0.6976167112077012, -0.762814825611178, -0.7533931434010244, 1.2386039313232564, 0.21491105684270242, -0.2266861370491327, 0.36108979123843443, 0.8234730078737442, 0.7340856516424009, -0.16146837678317946, -1.0839990188176696, -0.9654852278619126, -0.2655536086353964, 0.8214066818821983, -0.7861653839086575, -0.45492877759950484, -1.0617826457506587, -0.6222874936475153, -0.9723858401534405, 0.6789206723860968, 0.7097601380969022, 0.5657463616103149, 0.9397533146413071, 0.3307356489085303, -0.8793602587092635, 0.052853721001542384, -1.0601493631870178, -0.6950229662196532, 0.6255143419448479, 0.233771746259196, 1.0271088652242741, -0.6988088970349876, 1.0292446374427469, 1.1834941206007437, 1.1801328236987663, 0.5281004050181628, -0.17817779313979454, 0.3413857022391465, 1.012032854278252, 1.104111722945903, 0.0084206668690185, 0.6522658223678548, 1.1267948636040899, 0.9716299662946657, -1.0117535571373972, 1.004872366410558, 0.09697161975072675},
    {0.5031639821152452, 0.5917586607212327, 0.7840350657150531, 1.219771981593348, -1.1117249151357296, -0.5989839155337043, -1.1825023613493386, -0.010206897651418474, 1.21467651865627, 0.16951253876167774, -0.6913352335883025, 0.026795603441311426, 0.18462077221077164, -0.04083680152395818, -0.09150193791186208, 0.42152587221532195, -0.38915189114578586, -0.4812499370958599, -0.5265709638373283, -0.4689810114594744, 0.01710654053791523, -0.5462606038128698, 0.0957590938484882, -0.01633439317925292, 1.097299722025252, 0.01031843263256265, -0.1800644262789761, 0.11365917939359033, -1.0918277564494132, -0.6868810185538246, -0.22300970119813118, 0.03201754848398973, 0.6354742799932018, -0.13468274051717943, -0.728622809151944, 0.01660550720768671, 0.06533109444036772, 0.28676600606088637, 1.202740697495328, 0.6294621170330459, 0.44579967832057943, -1.1047551523514616, 0.8061062377634512, 0.36356221550813567, -1.0709504642609147, 0.6811658242392982, 0.5527214430430424, -0.3527748900462065, -0.5720505869207526, -0.8729923606076984, -0.5734979288366336, -0.36326754736406075, -0.21494893936943785, -0.08164606679198241, 1.1231409894750606, -0.5618864509679229, -0.00045258102719354155, -0.49386671975102214, 0.43907892471041166, 1.119329588695553, -0.4019778495327249, -0.15687837082583536, 0.4425849566699463, -0.7058746177623049},
    {0.9485265840116113, -0.7750641701375683, -0.3180664205663014, -1.0553983158166689, -0.10253560852356204, -0.602799924416469, 1.0501588121421812, 0.13880268201675697, 0.9362904385479639, -0.8058917472210306, 0.9652186369891903, -0.06128631386034575, -0.5003439509438203, -0.9350540168866434, 0.8987114301027449, 0.6742322659969006, 0.6887578494660453, -1.007977953267706, -0.14566385515717067, -0.45412174291016305, -0.051954271851627265, 0.47279142454312334, -0.223619245691106, -0.2660800524240284, 0.5592907434185639, 0.8376042039394003, -0.1964087981604933, -1.010920495807443, 0.6560581221129339, 0.424305685410025, -1.0311577587353085, 0.30380347789294476, -0.9237273433337491, -0.02334680509863935, 0.7454205973629652, 0.6033278167100984, -1.1317004353003643, 0.7123552023940977, -1.0799091019481666, 0.1071198882110372, -0.10046957396447748, 1.2943615182360824, 0.06807917889568962, -0.45709457451021623, -0.5461919584376305, 0.6374070641555707, -0.7162811495663731, 0.5162051367800898, 0.9182654768981922, -1.239444982378295, 0.3977765347214232, -0.08033842834114581, 0.9140423776124545, 0.3588346295420108, 0.5078031655539624, -0.7295964310473567, -0.5798475015924865, -0.9631406807888796, 0.8700572053989793, 0.2578005352964559, 0.5751447594347713, -0.05451453213141323, -0.11106862413017972, 0.6033791811668511},
    {0.0016209325525035657, 0.6894964803617157, -0.4993841002217901, -1.067255581972041, 0.8952632701444924, 0.6375094006783486, 0.025027754970784483, 0.9164529494197726, 0.3809704691931368, 1.3339805500060067, 0.08663452776298078, -0.5655938404875136, 1.1771600129576283, -0.1716339896303162, 1.10295740104934, -0.6870508037802118, -0.8353345240612516, 0.4158360264472022, 1.0420567214287293, -0.5949955270600555, 1.0692841790946042, -0.14662527660801836, 0.020282801241845005, 0.455849362103201, -0.18549594899920804, -0.6384322940452801, 0.692008138001249, 0.9897810173283771, 0.08747207581390229, 0.9679109829776625, 1.015813563118908, 0.39609867215177585, -0.985426866201668, -0.559159386467322, -1.0032475664636313, 0.7200245322039536, 0.8030959367913807, 1.1941275857144964, -0.9446491887904419, -0.7561787135024836, 1.2694311569787817, 0.25281875584278374, 0.48756579103562775, -1.0049979060740066, -0.26828529411618374, 1.2891477723524363, -0.6504770180538435, 0.6879412526905125, 0.18253661902310075, -0.3092751914753429, 1.1807239248922972, 0.8468933824000806, 0.498619205897702, 1.3006145822486048, 0.7665749725580042, -1.0591179397389114, -0.2773730410726138, -1.1155391480975863, -0.8648914375570533, 1.3517931029298262, 0.018140760916254342, 0.6303934160549598, -0.01591959662052045, -0.17168554507010092},
    {-0.5780024278679881, 0.7875729532248766, -0.21251662387952075, -1.0864880394882015, 0.17973767459917078, 0.7508326744733488, 0.055479656072050146, 0.6422283094000715, 0.9912137235696562, -0.2026959808779816, 0.4001577915808879, -0.7973717874140648, -0.858180129172461, -0.8296040846807311, 0.9345831902488844, 0.033860047163184866, 0.8842208076415548, -0.5095950694505933, -0.15567283394021195, -1.333498814675175, -0.465872881784285, 0.01616744697969087, -0.9982991088016978, 0.17766050131595434, 0.05726907173676633, -0.8444652091377622, -0.042925610501276856, -0.07355788608890869, 0.08280522859715617, 0.9903280099042618, 0.17765300454146066, -1.0219370153298735, -0.4162795517406662, -0.5962423611688873, 0.17721031437932627, 0.8005945727830467, 0.014814222360887534, 0.1169824620532386, -1.1935764834372158, 0.47802875162726627, 0.42107556223129045, 0.07704333176793937, 0.2344015444944893, 0.6473989314849914, 1.1260921282537149, 0.9767400501765493, -0.6764791134756178, 0.01855590665566456, -1.0696224086965584, 0.6695566374383908, -0.6386849850101007, 0.4338025395145557, -0.6383739753731739, 0.7481931720937913, -0.7460666607898842, 0.5226209423493412, -0.6545904993964865, 0.3208932933145152, 0.495914003025528, -1.145671438561884, -1.082236551549861, 0.8428984137626444, -1.059050779219914, -0.7970851098511131},
    {1.084313736134638, 0.585580248445968, -0.128035696814271, -0.0674174665393821, -0.30271541993687556, -0.8520817096337333, 0.2192264242720497, -0.8234715604021671, -0.10687537030587509, 0.9581612748437603, -1.118560841968368, 1.0111866404728616, 1.2077518084891499, -0.3531853107739503, -0.5740196996132714, -0.5301921725987553, -0.1489516350274334, 0.1387037388352132, 0.40278670684086076, 0.6994255033777227, -0.8927355285256812, -0.023347851087270523, -0.1609917638954538, -1.1422774830874711, 1.0887586019443327, -0.8034600515497233, -0.1982457472588749, -0.22892195034316118, 0.22489928436224474, 0.0642118984229756, 0.24734068047212535, 0.2667032080205006, 0.9588896436865413, -1.144431316323044, -0.6626261603522552, -0.9998266252235352, 0.5382213509310024, -0.4341294677627168, -0.7128330443753189, -1.0270519606579644, 0.8083742049964353, 1.0015478768109047, -0.5034973749104429, -0.2921888634925261, -0.12624169032523508, 0.6383353204251495, 0.7770469611804437, -1.1282214589607011, -0.34879786985430733, -1.2210770162780094, -0.9606999084514981, -0.40699612781854133, -0.5727178085251823, 0.22847499873993368, -0.2872432446046579, -0.704057607930975, -0.19741395348305724, 0.22875832892490547, 1.1497723640300173, 0.0798233273751382, -0.011877295290701589, 0.9207603101999384, -0.6914748990419914, -0.40457697528255926},
    {1.230166542745526, 0.54184978685233, 0.48544846802507713, -0.2664720821247943, -0.7738049619311215, -0.19504542738309263, 0.8708248913517735, -0.4853433272979753, -0.7597072443623565, -1.0390817437252555, -0.8735778310133766, 0.6362782549276019, -0.32372105660671496, 0.7387220926538666, 0.23806900445145668, 0.9123902860453701, 1.1777832894511668, 0.1467866886246336, -0.02362694904715671, 0.7296584005371841, -0.4242501017759319, -0.4189553893338511, 0.5769512585467671, 1.109630320496252, 0.4212548979893243, -1.0768627512617421, 1.0227181725259167, -0.6343426266736971, -0.770111946045814, -0.04521895726980392, 0.14095246419566496, 0.8266582922752211, -0.6216554432624287, 0.02699608632517511, -0.6958204729754878, 0.58879843229059, -0.8932870514708792, -0.3224059944407291, -0.10833946589465572, 0.5670041355410171, 0.500083793072595, 0.060993663833137035, 1.122105555642089, -0.841102259951125, 0.47391940388981724, 0.5803528416068359, 0.025612953812844754, 0.04732816074160364, -0.8502084495379373, 0.76806351485772, 1.256799796110804, 0.5428509369967848, 0.43242194100293635, 0.39859072721274785, -0.2840259870380328, -1.0533520859717234, 0.7883971436754608, -0.5408139923800273, 0.5720719707174498, 0.019065351445291524, -0.9413961776089288, 0.8213795960380263, -0.947142656008803, -0.07064841380533889},
    {-0.5673399753642522, 0.08858494232697499, 0.8577009567256725, -0.37424404442142484, 0.7953376112725171, -0.1401176575491638, -0.5988326520538456, -0.04853373204740854, 0.8196555410801153, 0.05424853172581043, 0.014590742659283572, -0.3853503372885731, -1.135860482132592, 0.8040274899931632, 0.47320002750010676, -0.30947992887541953, -0.6987879780022996, -1.0913399725048138, -0.7679009434548864, -0.16979246524852673, 0.7081731867536543, 0.8565100839050315, 1.4101348835551881, -1.039789014467045, -0.5714670152098366, -0.6287546933264155, 0.7336350358198329, -0.8253007832579226, -0.6962663392958295, 0.7706464614439392, 0.13881937580113887, 1.1638581121643679, 0.15881485495223147, -0.4970872300736993, 1.166805824130276, 0.1279600090894282, 0.22996252061796343, -0.46808844993157944, 0.6451534365105323, 1.036131722689709, 0.053239716789505585, -0.5182703111090358, -0.9131254289317129, 0.1913676436374979, -0.8547429532073194, 1.044151667523112, 0.23102637438850876, 1.1813967633945603, 0.4091327029704919, 0.34803662138797287, -0.17242282007623846, -0.6945723114329587, -0.16903790905332544, -1.0437904640726035, 0.23257505003015078, 1.0613416792557824, -0.8145234067967, 0.8836585430069787, 0.04730386295944941, -0.6645261939120467, -0.8939557471759424, 0.23904653503962117, 1.0927249421931562, -0.49470043166963773},
    {0.564844181619354, -0.5732565833851712, 0.11608092600334889, 1.1681451048480371, 1.2394352349403368, 0.49912859046828395, 1.1237674996347826, 0.49992717868661407, 0.9230134277714512, -0.8978684104775281, -0.3087429603846556, -1.062623871246078, 0.566596939253077, 0.6351701712226511, 0.8969699901968363, -0.27894926349168686, 1.0497250262216138, -0.9763100642054254, -0.11903939249943714, 0.2782461195271281, 0.2532557171305636, -0.1010749151667865, 1.1859072552917367, 0.6402571216232863, -1.0073312732944852, -0.4847997236084792, 0.9132831308787699, -0.4052054927413638, -0.502843715384722, 0.9611186216144223, 0.7345280822708099, 0.8335823033674885, -1.038111463866235, 0.9016628718227239, -0.05064867175451349, 0.4261331943501778, -0.6412215624469877, -0.617373242521555, -0.48890764954864113, -0.4827292732178671, 0.6172052805526966, -0.9777463480246119, -1.138596914403699, 0.15055454332083196, 0.8236719291796353, -1.0230227880686051, -0.8364006983187842, 0.5122419646069595, 1.168471177367205, 0.5622256652919189, -0.9042213446129587, -0.060173536306984625, -1.1331704556501419, 0.7193623911667892, 0.0932490370492305, 0.8096667065218262, 0.33437779275990737, -0.9914502864651988, 1.1852712803834362, 0.7574079203605939, -0.17069858174373323, 0.16936760048933144, 0.652448848900908, 0.3663668334172305},
    {-0.782746773965024, -1.0631966024972421, -0.28628884690239836, -0.918877914624774, -1.0446121705712856, 0.9139333019561745, 0.7564883310227072, -0.27809828404486214, -0.9106798718961331, 0.8221200250838719, -0.20896385948612525, 0.6983963625248477, 0.9999920565839204, -0.998457838830518, -0.35112268464718266, -0.13759262392523594, -0.8335336880713824, 0.0687431266539579, -0.3250621056310417, -0.07882802910537913, 0.10378749848051368, 0.7309980078724558, -0.7461702811936275, 0.3788306928840018, 0.29203755686706956, -0.5145290784824277, -0.6665801426177005, 0.5663100909111484, -0.3691008855274925, -0.4975851259795318, 0.7277649863833878, -1.0250823111988143, -1.0875024062117353, 0.26134892857507486, 0.4452905029833569, -0.20242542754988913, -0.23992886141748584, 0.035720588399934895, -0.051740816809357215, 0.17713475610110935, 0.8179127717020365, 0.6640028175109605, -0.8848966449594219, -0.8658382449996898, -0.9874581061499518, -1.227253516447714, -0.32782098183640895, 0.5725046791457711, -0.06671214032478465, 0.011002643614199, -0.12945744848453428, -0.8267390438755653, 0.8663412732375466, 0.3213474032957994, 0.561182322532692, -0.9506958684674671, 0.49375905605846176, 0.9402703638102496, -1.2658790572233627, 0.6842652646270502, -0.4565408788684616, 0.9705644360092017, 0.08757438094667816, 0.8367295788174485},
    {-1.265955696220544, 0.8192816472869994, 0.2953200727771733, 0.4995065123094609, -0.056490921922859844, 0.5285600710660201, 1.0182030351780302, 0.5383476923517789, -0.35395811234499786, -1.073522300577362, -0.1374442322880388, -0.5118464685520253, 0.09135323306106213, -0.1248975229378623, -0.27460550080748747, 0.301717745900681, 0.7847116209167434, 0.8636296830031261, 0.6297527099636083, -0.4425858284151268, -0.10729263019620648, 0.16395625595297392, -0.8023027006178528, 0.9466333941064834, -0.9768637074587044, 0.0014551776940812573, 0.6257079508240301, 0.5342658416353296, -0.9043498243995872, -0.8615274216334093, 0.742977455512442, -0.47307339686792804, -0.8465620119969244, 0.6895086438397464, -0.40472913778275865, 0.7814599511187484, 0.2824841644161161, 0.8746474948896644, 0.597161634902501, 0.46750928608263737, -1.0484720351628207, 0.07731610177122294, -0.6151090392947082, 0.3965719530486313, 0.5459510156681942, -0.39468925405269134, 0.8622419170066742, 0.768075094495305, 0.08300054157427615, -0.1799115237376504, -1.1265953186366249, 1.0031951695598313, -0.06919891201129366, -1.0372694014537651, 0.8924570305787299, -0.29602677107091074, -1.1589260241193517, 0.46383188617049476, -1.295659514687777, -0.7712888462498411, 1.1512009686374471, 0.7791655100375205, -0.8575746224043701, -0.19319759558173413},
    {0.13742513473003565, 0.7704902194493323, -0.7770422572037172, 0.6198053618756999, -1.1684312061346795, 0.3897394331150943, -0.7637036561970346, 1.1128552149811515, -0.15371525819565496, 0.4655810504189282, -0.3311929018014996, -0.5744739548545463, 0.06826644623940384, -0.8430124321853576, -0.6074853780855657, 0.241737710665452, 0.6768729118210791, -1.1144125801896083, -0.8497910613452756, 0.21934541613430855, -1.1501659148028915, 0.5663124971811199, -0.8722915528405785, -0.08715306677921919, 0.14538085320199517, 0.6943845490733132, -0.7668777978276216, 0.46565362276957356, 0.2624133628413361, -0.7609818110821002, 1.1468425004656704, 1.0842824288605308, -0.9575923535458722, 0.34957451214131285, -0.21702389448736506, -0.9410685829863451, 0.6689834061309672, -0.04142543878328725, -0.12564981385152507, 0.5330074882398735, 0.5820870103354726, -0.928937834563748, -0.04424367722765163, -1.051602064771484, 1.0466010715311276, 1.1879818616690614, -0.26247806405844276, -0.648868444852521, 0.8923907991046524, 0.9646793954003676, -0.19878160161239988, -0.44349288476832877, -0.16643097047001348, -0.5312633145631595, 0.5477094697404542, 1.2439246263286075, -1.2178803969060354, 0.10367639995833443, 9.086239064774703e-05, 0.46392740985269787, 0.9884319951419971, -0.06268695127886025, -0.2061298062113737, 1.2432589329208694},
    {0.7781425512480468, 0.14015093054553487, -0.08303442993571762, 1.035933430700744, 0.6620030511811836, 0.25169479845734016, -1.1442005332830893, -0.6652718918148653, -0.9245992069653035, -0.5265499256277059, 0.315484654577524, 0.8244845473274692, -0.5106265258253586, 0.2539449467461267, -0.6977968774989876, -1.0005046711448322, -1.0089131017232449, -1.1729238413206144, -1.2883200559300407, 0.5174457168916063, -0.9650372184904618, -0.855827844859697, -1.017934215685479, -0.6996818312842876, 0.35902579544800706, 0.6234142021591973, -1.1053106498137983, 0.5897284676250258, 0.16118307519296723, -1.1478105662253464, -0.5286795809988935, 1.0298810595295371, -0.9974071597754585, -0.7730219225500152, -0.28823575765911263, 1.0943525217555576, 0.4635026000792838, 0.21323712911675824, -0.6761319036856891, -0.6142809673256137, -0.3021510814376809, -1.2826536742498487, 1.1430210962852627, -0.6884488019098578, -0.14060117991916254, 0.9828355828318138, 0.5494500686520315, -1.2224876329026635, 0.24148200813875506, 0.8001757052774136, 1.2054318614238915, 0.6314267504380237, -0.8784015039928265, 1.0012340859084097, 0.9423420968615062, 0.8755866543913132, -0.2218508532888364, -0.4811891923972948, 1.131541973894862, -0.08367358587293054, -0.29584921012277715, -0.24124284363204665, -1.0183609864995216, -0.41916402814617715},
    {-0.5155726759537091, -0.3348272825876443, -0.13948211234238528, -0.7147241916584471, 0.24459082245319266, 1.1360436219823684, 0.0011368702306860325, -1.0626631383380118, -0.4525957795087111, -1.0236886946828152, -0.8650323836151255, 0.6225515935590035, 0.888486716891038, -0.3133897203464848, -1.1899376593108144, 0.7194685446264941, -0.9069816028784083, 0.5863317270089975, -0.039340195454002774, 0.8462674198358574, 0.8105150007786049, -0.8815556263792788, 0.03950347562845657, -1.28886601453231, -0.6303842862134378, -0.234153126409611, -0.08564791590451806, 0.3627495206435082, -0.2228152535701721, -0.25931024924722573, 0.9577459813585562, -0.9452603810206613, 0.16671437986716958, 0.34908386233765437, -0.8835642976312279, 0.4244636811514004, -0.4293230075590468, 0.1648689310033167, 1.0721331704091728, 0.14557539954229548, -0.15404070952200113, -1.263585755360554, 0.8670121584387847, -0.35758059771734557, -0.5087966830934203, 0.977947758501359, -0.3309496304136552, 0.7184119620113353, -1.0424863294020168, -0.6981650328045855, -0.5773346134442011, 1.0949540420829689, -0.5821857809166168, 0.5112974782440781, -0.8954868588791423, -0.2860242642142483, 0.8366550168600684, 0.8087788655235815, 0.2217994416125602, -0.1377016858854657, 0.22002842441404458, -0.06579459117934079, 0.9703505144950229, -0.34445694780762864},
    {0.09556397601231663, 0.5781273302626594, 0.02947484965987272, -0.803499107387317, -0.6728289690582145, 0.15271649379507865, 0.33910097960075014, 0.7845023992850637, 0.8365417758966432, 0.8248330883768394, 1.04946795719774, -0.1492684135896788, -0.8901454571042294, -0.8291036903782227, 0.9215548627489256, 0.06568614292835001, 0.02699765414695782, 0.6816979329584933, -0.10787459383533238, -0.7864396238721865, 0.027498338502139702, 0.7529123349202973, -0.022437682440512398, -1.173316993951751, 0.07839462571157818, -0.34643218606913206, 0.9114742280522805, 0.8101872872561514, 0.18230050151457838, -0.11873774788894943, 0.7219511288883865, -0.7862757427483379, -0.13291461828089088, -0.6928823887563376, -0.07839694572068735, -1.2289229209669836, 0.28705733176117854, 0.012825445925950899, -0.6898107589668692, -0.003926044569955154, 0.36765135536145227, 0.2430995251830901, -0.08581127059930863, -0.6258259351608242, 0.6789772600359872, 0.8944493405624228, -0.1071333328178257, -0.46074111447734245, -1.133241018945894, -0.8950756307522248, -0.7351714272336133, -0.7904695227230802, 1.2056861435965163, 0.7023105456244281, -1.1204527970092204, 0.009895757604443188, 0.505689095575131, 0.2985052998968854, -0.5514672207952035, 0.26961732854676773, -0.4641666575800736, -1.2324828435055715, 0.7561876684400177, -1.168749819845057},
    {-0.39872978944952536, -0.6177428636986626, 0.34178789078122057, 1.0126099294909776, 1.0430698295294398, 0.8229564658119516, 0.05472222452329276, -0.2434617193011751, -0.5410847453573584, 0.7179505688364867, 0.5094366531507343, 0.5584798762726229, 0.31618437756522655, -0.5705029264763107, -0.34491947911601367, -1.1145859819190234, 0.44006835978673325, -0.12644664258324614, -0.13669448613862575, 1.1687385802009373, -0.6609869171075072, -0.6065605654384943, 0.1290883684482705, 0.09715358922272689, 0.5946300012991046, 0.9860999377976867, -0.6443402058133056, -0.8188273490011051, 0.7636694861488968, -0.36234825336606524, -0.3332173771566843, -1.1123634336633277, 0.090928958069481, 0.3067345321740464, 0.7317763495908838, 0.41533540685739223, 0.9673864942647576, 0.2855406909656418, -0.877708974531457, 0.5326213350923706, 0.7341392459909771, 0.323530808284703, -1.0719547058116186, -0.5140607048388237, 0.7985261784447812, 0.4597347805272548, 0.2639311015770729, 1.0074327440773843, -0.26873096797606644, 0.5865016399508846, -0.5683359781715009, -0.17994287661770758, -0.9920388201090782, -0.6237111743354558, 0.0051742539918436916, 0.5393268149440129, 0.9408651531934015, -0.2608981300851101, 0.8522057594732625, 0.9187087159435827, 0.6028753627657047, -0.4270600147030454, 0.9577245643601072, 0.26448258752808135},
    {0.19550222209508747, -1.0102437659653891, -0.8305788522839327, -0.10567099207374711, 0.6513046333576114, -0.39030579653274555, 0.7227277845071358, 1.0530713650074066, 0.09895651591241876, -0.07264361279145506, 0.8606861182956915, 0.8435656019407488, 0.5886911614959969, -0.22293858516268364, -0.9853340295999728, 0.909102311430309, -0.11977340003982354, -0.18211758675034057, -1.176071728998072, 0.4298530925585027, 1.1726917665239913, 1.0944829244703709, 0.323204799842745, 0.5550603646095108, -0.37495820098249194, 0.8275200008426862, 0.9514008313448874, 0.7921298271101161, -0.4149953182633009, 0.7450613175379905, 0.4303460442968535, 0.6837850707201363, -0.6603295111806993, -1.0045243977141518, 0.6930091848494419, 0.12038539255771759, 0.8991822869760799, -0.4833934843885394, -0.9171846610299855, -0.8824780469434782, 0.9268200169979744, 0.1534743769373681, 0.5581238202794501, -0.09417545796176165, -1.0979225515952595, 0.8064392065805083, -0.3844455168407662, 0.5608283419497965, -0.8212757609706978, 0.647909009131889, -0.7877055727457517, -0.11221973047893158, -0.7757092438782572, 0.9015221818093281, -1.1130852243210894, 0.5704925860257827, 0.5786819232566777, -1.0136979424973473, -0.177402199703423, -0.8606262113274522, -0.677789149427665, 0.32623145760732225, 0.9427589916961003, -0.6462451836950881},
    {0.5636577314495907, -0.4015372459232564, 0.37579805077446726, 0.8428586848210314, -0.2069498777600367, -1.2580628583357751, -0.3914224506106637, 0.1189590293411685, 0.4722509539943562, -0.7262613103968215, 0.15495845104100042, 0.46043859706575474, -0.5903870339998301, -0.061181747252955915, -0.7293571170422226, -0.6775267052797065, -0.3018611592692989, -0.6656243050252582, -0.6009754665328887, 0.18957455168600781, 0.4925658836466419, 0.6848067630719744, 1.0569822089500218, 1.1710602440269962, -0.4365633807699661, -0.49403107917122346, -1.1510083748375448, -0.5623936180734026, 0.6571536891973093, 0.11641087159488016, -0.31127569592962434, 0.2674804358300787, -0.5945027900068391, 1.2119891975421195, 0.6838256982226856, 1.1853943770902917, -1.047262245935392, 0.617226982540546, -0.36883694204532835, 1.1029649806792676, -1.1426811062006603, -0.19065682120799274, -1.0013792149197405, -1.1355790554951528, -0.8741894170956483, -0.052723023778933356, 0.12905898550347056, -0.8637179496317454, 0.18489139909995012, 0.915465359421788, 0.49479340692484186, -0.8985445495415135, -1.1486216630778565, -0.9401793714820385, 0.12365953401825247, -0.34327832613939036, 0.12706624107129008, -1.1456769157416864, -1.1656662054467128, -0.988340084486409, 0.9917747242624543, -0.7340785077742582, 0.5401036150237098, 0.6039648089303593},
    {-0.5523873340740325, 0.6831474906375378, 0.48887225536453727, 0.6695644683872883, 0.7043085584443343, 0.05842576284009952, 0.285813249391334, 0.029943636684678022, -0.026511648196528854, -0.06834856191524265, 0.8699451959919355, 0.6917035130318889, -0.8374448166186946, -0.3252512509129452, -1.045330654106259, -1.1812092414053001, 1.1801287986126703, 0.3866779688985235, -0.7113895043352483, -0.46393209202138536, 0.642981754367594, -0.8020880582515605, 1.0081064748880648, 0.17052750629502553, 0.8799162075640115, -0.7030359936279637, -1.1922499702678144, -0.582297122456626, -0.7093589982753383, 1.0423297870754602, -0.6061279611768167, -0.4642549106809976, 0.6184077506242082, 0.35323771764671735, -0.9262258767704277, 1.1591851386028313, 0.23553652635151714, -0.2587934657872927, -0.6793536525215462, -0.7859682426277232, 0.8111899521268641, 0.3625826073014758, 0.6996935805219401, 0.2726194054623951, 1.028243908073903, 0.8533766972918485, -0.5545025502937446, -0.7472032282849582, 0.15707065707235815, 0.35618752977014123, -1.0058208975552148, 0.8059223812255689, 0.09907949413151423, 0.1073228540663457, 0.744030998516162, -0.5333433300829553, 0.7722959909361113, 0.18117696361718785, -0.6118421496060271, 0.20806291793917875, -0.09496743442687233, 0.9272958230937074, 0.8188163535258081, 0.6512083024483665},
    {-0.25894372920549846, 0.7492820246275144, 0.2372658195172545, 0.3804683812841253, -1.098874293589492, -0.7659718379291219, -0.8521071868519916, -0.5608912775980079, 0.9440660229880004, 0.31481564877124285, 0.4418295085292311, -0.3061570093675864, 0.1282408018448747, -0.24957958923116677, 0.08931418710967072, -0.847885709690404, -0.05661761368089972, 0.7365747740438717, -0.48736412389692213, -1.1693784827590894, -0.37374280199733556, 1.142914276068092, 0.7830395405889977, 1.1065968507644266, -1.0678322507312186, -0.8422500985601732, -1.1629981343257891, -0.45612730622066483, 1.004335409736516, 0.9291099349595741, 1.1232619256549927, 0.7443276609008554, 0.14258847136621602, -0.6542513089197615, -0.7513071983047773, 0.7591146577478017, 1.1379494606490257, -0.9610861466527179, 0.46508710136657455, -1.0841286912094934, -0.936398367637704, -1.1816355241030483, 0.9357894098175082, 0.8057581423468132, -0.0308909512682416, -0.3522682187053236, 0.19786170342837606, -0.4373400882680049, -1.1068789416884957, -0.7459088067778052, -0.6910258550740318, -1.0001201117344451, -0.38709403928102565, -0.3653531916678219, 0.52781897659906, 0.11774776137130238, 0.15974698526818085, 0.19465042847290132, -0.14992260333417054, -1.2233985959613303, -0.6961746363323912, 0.45636766591564915, 0.6166030271408289, -0.7028740782828787},
    {-1.1664109229620052, 1.0556144885961272, 0.922457491314659, -0.2708939927466261, -0.5036288425811225, -0.525858158955832, -0.6029390075470973, -0.8785953145201374, -1.1194562272259299, 0.24996577519367666, -0.5237780066605727, 1.056665923665305, 0.5595315013370804, -0.10086767021467036, 0.8364083422177037, 0.9273308409524237, 1.0746582915974177, 0.30606212982536424, -0.9766396021202115, -0.05935440723525321, -0.9979610423460069, 1.0518911435273646, -0.8520331749158756, 0.7575369671342946, 0.40018523909333203, -0.6055127611568235, -0.6579060584641696, 0.8649078296096967, -0.44729966622296136, 0.5059885708142265, 0.8573929652716997, 0.700213777736838, 0.852180974953986, -0.5257261803207438, -0.8889688284126975, -0.41975513456136465, 0.875234437501755, 0.5154750062525081, -1.0544129779020686, -0.9987542455217955, 0.10588901228800918, -0.2653326490261502, -1.0427125493826432, 0.7450950207044986, -0.780676195687392, -0.4225318855678434, 0.4432856934809105, 0.5728065838900375, 0.6979288936199929, 0.15274445271006767, 0.2685772541788967, -1.2609570085992352, -0.40813553488340243, -1.0541669582748772, -0.04330529182656714, -0.39135242828919153, 0.7574388826612865, -0.7941208508352481, 0.5904780553084641, 0.40489412005449776, 0.5865756451776318, 0.13846162304806464, -0.27974792972925894, 0.982348194973846},
    {0.05132065598923721, -1.0048666472108623, 0.3520707608720348, 1.0543966885594669, -1.059532906447211, 0.9821010253774154, 0.6985820205151166, -0.5457417588441573, -0.5574193985786898, 0.7008717952198593, -0.22510921112899265, 0.34505582113799727, 0.3219623958881252, -0.7040524457885343, -0.518800543074198, -0.1468394862535925, -0.32566861294515786, -0.008361525499569622, -0.5085961960142382, 0.7910831665675493, 0.6624473747669052, 0.6269618636461636, 0.7054915698512645, -0.03839432619317709, -0.3231148546051278, 0.06533933116968997, 0.344972368702333, -0.0750844092152664, 0.7779089327932044, 0.8513949732657041, 0.9755831075916469, 0.15131224390009507, 1.081279941169706, 0.22783449060803823, -0.8336825186910368, 0.5005873564006508, 0.09157565800301777, -0.6902182239478482, -0.7896659844535925, 0.135650710717497, -0.19863624646328382, -0.4056222397915235, -0.8021018128684463, 1.156229686309018, -0.63445539924037, 0.5913576789562184, 0.4561222904690065, 0.7995264400479928, 0.15892028236072103, 0.8521268512087821, 0.9120186211849061, -0.25151210268407054, 0.3507425340826849, 0.6841673698366431, -0.01760379502889251, -0.4169574906560753, -1.0367169787750996, 0.7804673493511941, -1.1666346117885233, -0.46908585397608044, 0.14401378951504576, 0.20511238560755807, 0.5953293699188502, 0.9042745196658097},
    {-0.7846487762336207, -0.20261757380110446, 0.4563893558242136, 1.017839151426038, 0.8379239353870862, -0.9702564778079034, 0.6400226362912274, 0.7807187696224053, 0.2681369520761228, 1.0300467258905346, -1.0211529330954692, 0.5754401838285363, 0.15186564245062095, 0.7153178593085896, 0.16932838850786008, 0.21278276850924271, 0.16046634966580575, -0.15113228080116273, 1.1033141942451465, -0.7318295045757842, -0.6075284636803682, 0.12213830311454796, 0.21438669060740242, 0.98328309470157, -0.3186337528604892, 0.46484029377406605, 0.8123841135069537, 0.729061898275911, -0.35380161677675614, -0.3230364824534442, -0.6490581869638564, -1.1354226415025814, -1.113302681741757, -1.2002824834373014, -0.797434209135242, 0.4915685047191397, -0.7376094256983433, 0.1349648881194604, -1.0460213835238108, -0.5025015910401213, -0.5772246626523443, -0.9826391646558614, -0.7137583728444972, 0.7862784661699642, -0.12060582700590089, -1.2387179560066777, -0.9688584789680296, 0.32040753848776027, 0.6617339583514347, -0.7829361301754357, 0.458364281146681, 0.8238055896549751, -0.9181537648263156, -0.5003619701693305, 0.5608800512173905, -0.028799764332577783, -0.07627905838674219, -0.3849235436686407, 1.2617915698516058, 1.3096028957060657, 0.9473829771980394, -0.4012295375642516, 0.9052627049613344, 0.9636341143162207},
    {-1.0041637042772105, -0.9919498440349174, -0.3309141239469082, 0.5065985404743827, 0.858747394054976, -0.5955570139226064, -0.24132476972933736, -0.872419396269684, -0.3642084198650212, -0.1217900871267826, 0.574481595242892, 0.7704991092022778, 0.3424585862874722, 0.43307634854348037, -0.4302745488467237, 0.6137078908020194, -0.6880518670713804, -0.29772158894172307, -0.5466701310534325, -0.6967381958193769, -0.8938973052206055, -0.7036898135401571, 0.13712991325257215, 1.3188524713952612, 1.0356651073394716, 0.5499807568978874, 0.2235273644327433, 0.4596130552459304, 1.0506704268486942, 0.1581872477655206, 0.003304301950559672, 0.17503068388348572, 1.1183980618174554, -0.2683949278019676, 0.05271036754600975, 1.0013920591488663, 0.8217453093883205, -0.7743622422000414, -0.6523405552125802, 0.26943096231716057, -0.050559498970546846, -0.07976520762934192, 0.04139665413918157, -0.05705566222465234, -0.5007088288227034, 0.1369254703618125, 0.898693490189216, 0.92023599242933, 0.2765674240545715, 0.8434431566342951, 0.4067385315430154, 0.9693503677324565, -0.456724244091987, -0.8770417993472255, 0.5451932452253175, -0.8551098373552932, -0.4514720442839317, -0.3426558431796466, 0.9617742033852862, 1.2470303869605484, -0.5679538106092, -0.8894457756811452, 0.4503736895654836, -0.5897465593398744},
    {0.10486820814369376, 1.191750486924719, -0.8135330024057823, -0.9627707719895242, -0.26927084088352177, -0.9467476802983436, 1.2182558110800585, 0.8581603747989206, 0.7211617323547899, -0.15925118627204937, -1.0905890216000194, -0.7005594944733597, -0.30377908584906954, 0.16786094587493144, -0.7919092542907985, -0.373162354992373, 0.6280190917762576, -0.45222306050227745, 0.8588662582858627, -0.11652615735918127, 0.6110447840787375, -0.7215430597656133, -0.6164208846436879, -0.01263882084309435, 0.996144582364182, 0.17594784793430954, -0.7650230365027181, -0.3252913573689082, 0.22945659836341326, -0.4118841767171962, -0.8113686164422438, -0.0931318584209034, 0.9877315027244439, -0.8832207437466849, -0.6414962821179676, 0.5124337916641147, -0.32558398755684514, -0.148705057901593, -0.1880352551167147, -0.3904245591048956, 0.9852787748234448, -0.8518346706589609, -0.26528370572822557, -0.04147222173156972, -0.5031399573801398, -0.7069450782004838, 0.23057617657026883, 0.25735958818814403, -1.1882663966200775, -0.9428688730477454, -0.6099532773201317, -0.1702572744442932, -0.3008032862985163, 0.26648835695219597, 1.0342131172066267, 0.5189899080486906, 0.27089445611134005, 0.3176464044516363, 0.6979936334161551, -0.11234422770599874, -0.8400492302998032, 0.27347182901752654, -0.40211255352640746, -0.2828111176058231},
    {0.9535455192601163, -0.8973097785090008, -0.7826809254288726, 0.20327857498735222, -1.0867684910213846, -0.329024322968197, 0.11544783995275931, 1.0995353322208072, 0.21733738094254593, -0.3957149254052536, -0.8643278541179112, -0.7515431690470539, -0.3797961937625042, -0.06316539261724802, 0.27953924085057413, 0.1386854423456526, 0.4514027403745757, 0.8217258325184256, 0.5055681612985606, 0.06441095572847043, -0.792561586379196, -0.6594206598411582, 1.1151259975889245, 0.4009920175251867, -0.6779361486671481, 0.7380691208016468, -0.7277803103305633, -0.9609660810182677, -0.46610152573189634, 0.26270625468183784, 0.644108818615938, -0.7351892775683148, -0.6782087485589062, 1.1137539333938185, 0.3186654862773861, 0.24602811540072386, -0.40253307697123797, -0.6982996180849261, 0.430899086577494, 0.4233048352948589, -0.3672434964689746, -0.700247297318673, -0.48232762586688366, -0.42524634537571965, -0.5493054329177014, 0.4968979022526562, 0.17505056954147027, -0.3715641379410077, -0.5228307834111839, -0.5786651875677868, -0.4340387672411261, 0.4607320989161949, 0.507573758775748, -0.6910787684965385, -0.5127454659166159, 1.3581751395884347, 1.1916378041889821, -0.11074566794784318, -0.3441506730820248, -1.0817037546999495, 0.05954820371166524, 0.8102412388664229, -1.0738112846047128, -1.196584911840399},
    {-0.6147453930735077, 0.8097480786704515, 0.10569410064171972, 0.6611663857915874, 1.0106795381581795, 1.1330016970922623, 0.6883308352293385, 0.3685907653175806, 0.617136821352427, 0.3021315549159073, -0.8189154792095262, -1.1156761030400728, 1.1490384852425306, 0.9940510206850032, -0.3753807699408911, -0.28866401045031165, -1.0383335236213247, -0.19402774339099577, -1.0900138631994902, 0.7542019204250072, 0.7819403061503202, -0.8116625476364285, -0.28188099526205007, 0.9712348287353523, 0.6275661206446388, 0.3069714862188097, 0.6303670781765798, 0.46829112420817515, 0.02023577110678392, 1.0428431069886928, -0.08592241741574543, 0.8228447038042053, 0.052706668838372446, -0.031052439559806914, -0.6313876995648285, 0.6499483777301949, -0.7832510319217113, -0.32633809581650325, -0.784206418115166, -0.8469111103618788, -0.44034688507251396, -0.4757897129643833, 1.0216127159739898, 0.6747703033418894, 0.1032747212484301, -0.8472020924432087, 0.07692554480326802, -0.9658656879520503, 0.8256570658080795, -0.37487977290575925, -0.1768903208124434, -0.9901728669480525, 0.37790701237877, -0.12493414431862913, 0.6749078400724651, -0.5269745546706749, -0.20256564353097706, 0.5297051946468715, -0.9672275279190029, 0.5606765358264226, 0.37835661980943913, 0.5737908955873403, -0.3472862221828239, -1.0750022495834188},
    {-0.22040579513905814, 0.3274746072013827, 1.116757923461366, -0.8401619901548212, 0.8673297055347763, 0.9991570573515738, -0.761614123218303, -0.6833452034121958, 0.5075223989538054, -0.1529356522543201, -1.0464438726210714, -0.28438930074476176, 1.0686804083267158, 0.5118314295818566, -0.03779967700204554, -0.3274864394615409, -0.9588442640114865, -0.19308024385189174, 1.1836407240882398, 0.9647838459059932, 1.213933262269741, -0.11949446838799739, 0.681544198136712, -0.3203708622713549, -0.3973248997491126, -0.19683379422035313, 1.03064682574153, 0.6631883140364087, 0.07229866242654498, 0.5823666621006012, 0.6410842055010397, 0.5716782702339174, -0.05963278305069402, -0.8425718844192549, 0.8389948954606978, -0.49818654680732477, -0.33060199050556766, 0.7443074834655716, 0.5377997760435269, 0.42890435422881024, -0.5267660460692166, 1.1106566543923504, -0.5693178246215226, 0.8482192402595732, 0.4427036907026372, 1.0305328817087516, -0.11630723180974205, -0.08268078074933147, 0.8765857497400156, 0.11045919321998063, -0.8353375308054682, 0.7562409039115534, 0.182100361792889, 1.0244808427054344, -0.052871476580052694, -1.212704753896361, -0.44642871789135585, 0.4130358684647566, 0.3797327681428303, 0.056780984235133364, 0.4088906243978081, -1.0489418397892178, 0.41670981926327316, 0.567781210734317},
    {0.5747936909472904, -1.0913370195561714, 0.21894668433442077, -0.7954811344423296, -0.040654940526006, -0.4544519255844259, 0.9080357508247153, 0.014049890002681406, -0.4900741247129071, -1.0897952363977403, 0.8495791576982598, 0.9160470159616088, -0.31565395984231337, 0.12670225462132834, 0.1692961498049017, 0.8142382009865147, 0.9437647574327733, 0.018088885709093217, -0.3986971828688513, -0.3641440866419691, 0.5674702228604984, -0.9324456029511767, 0.6513804975921555, 0.3796878032140765, 0.37950586834650984, 1.076471742427427, -0.31260392331369524, -0.4834081186121025, -0.5688017459865574, -0.5616537953720682, -0.05191671996806036, 0.24365357689559317, -1.0576062115121116, -0.0197331983448774, 0.3831888088389373, -0.1575805516843522, 1.059954213577862, 0.7276680763151454, -0.5388812663170489, -0.4103480684762995, 0.5228497304872798, 0.381986270719708, 0.12112014173524525, 0.5512206922419403, -0.2737693462582021, -0.460792749716097, 0.7015465918037452, 0.23455102347298534, -0.5534636732668299, 1.104068050196834, 0.4856862309559075, -0.6825567076045048, 0.14197001857631153, 0.35470626193116367, -0.7994181470836681, -0.8723614002868514, -0.2943973085854143, 0.8532543116720779, 0.5568147978955809, -1.1280214258283676, -0.16474754923961643, 0.9053178703899671, 0.6796490733371746, -0.19741951357931864},
    {-0.7485984331433059, 0.21967613587605833, -0.7543287369259676, -0.916687949171507, -0.5237988328037183, 0.6633302472765651, -0.10804879289848975, 0.5122397508780565, 0.16913639605666814, 0.023036519733584605, -0.055554111866329324, -0.4470522239589115, -1.0898499307044522, -0.5008169210343099, 0.8378438081786164, 0.6367111948338501, -0.7840077106240075, -0.7565613840613078, -0.7776753966408055, 0.9375965985078002, -0.32193973583707214, 0.6642945581751452, -0.47659177549767084, 0.23154718035029687, 1.1191549563535559, 0.03516825914241336, 0.025244875243571253, -0.38567685321973233, -0.9509458048635154, 0.6898781977837436, 0.6293629814019934, -1.083991865253519, -0.5076077877339512, -0.6133918974424784, 0.3898262912583752, -0.5473699883788926, -1.043625087880595, 1.0292441795780307, -0.6072224992148836, 0.8514863515928094, 1.1092286534171845, -0.7747747201236249, -1.0033533571448119, 1.037842302481026, 0.09737196047021919, -0.8186424814436982, 0.9103594264818491, -1.2296219876042978, -0.2491934145643885, -0.9288550694072639, -1.0479879344645822, -0.4732285107835853, 0.6492894962368096, -0.6975035301072192, -0.6717501513830374, -0.6459447740815994, 0.3864736802765786, -0.9238504067733304, -0.44474282035092205, 0.453477302201705, 0.8936773362334224, 0.5389754163811442, 0.48134696523507137, 0.3341832349829318},
    {0.41397421855161676, -0.30240688174087377, 0.6491230779589842, -0.779370828254435, -0.7366618576072174, 0.4852368590421631, -1.3143706333857268, 0.4397813581481908, -0.007033376612008942, 0.5631634232707685, 0.7740971782923858, -1.0674406067012157, 0.3409492632676215, -0.18217179938406322, -0.9005042990284575, -1.039610766237235, 0.7135358227109984, 0.6976480181356333, -0.17923916721152133, 0.04115658428767349, -0.9479943848628667, -0.5780794964952022, -1.274802614546518, 0.35464149996096184, 0.22280607320447318, 0.5882645257863438, 1.0119656024441037, -0.8435555102156073, -0.23181277408516565, 1.1543181555096735, -0.40449891559663986, 0.32894704865419866, 0.45798038744237535, 0.11974768558887552, -0.7537267097063031, 0.13981001893353315, -0.45326663231459835, -0.4524913164940523, -0.6734158617828199, 0.4880749517814667, -0.14465328470979108, 0.25124020597350494, -0.26791400286003747, -1.090000093491095, 0.16867412973158494, 0.5689844334711753, -1.0897301443357061, 0.6764153978675919, -0.8660587949887082, -1.2071280468831074, 0.1901819741689588, -0.9997858793114466, 1.0053705478220025, 0.09705760636861789, 0.8411453850348912, 0.671442725411579, -0.12076531393021443, 0.6496471814906178, 0.15010620064160085, -0.9367711839013034, 0.0012778547002466948, -0.5969905765142276, 1.094073890303195, -1.327677426963946},
    {-0.9932467292690359, 0.8099187780979507, 0.7072553981404076, -1.297031362338001, -0.5779156890424495, 0.7822296563498687, 0.8176583965911228, -0.9636940604818098, 0.5282604165770889, -0.6717576186820926, -0.1807154705292752, 1.0685357943113782, -0.5240103058004894, -0.26556076353749464, -0.008078647697960399, -0.6476957683385162, 0.6142098110450939, -0.5686018945910682, 0.23819194621462983, 0.15299280911893262, -0.3026782201433369, 0.23085208126476867, -0.3719104418595902, -0.3830889389414297, 0.6139352618916337, 0.8140356701498084, -1.1201762734231666, -0.10924518808474015, -0.6977374381328543, 0.5608737104549651, -0.7756941444022433, -0.9978552220343544, -0.06463637499237926, 0.8077039628993942, 0.9492987042615231, -0.01488576652483118, -1.0789267613440194, -0.836394948713383, -0.30519617231398016, 0.7281778052351463, -1.086829228545137, 1.076324894525518, -0.68411556828365, -0.30157328717556076, 0.90940952867642, 0.9143252580446962, -1.1605415489923936, -0.18100147973929054, 0.40544921460741706, -0.12496417100117269, -0.5175563301295443, -0.3076984163966963, -0.7777436137733832, 0.8270417135134155, -0.9685987815655392, -0.08538644229955801, 0.2551575583986852, 0.1990489617900218, -0.667250918653221, 0.8263739268458723, -0.33965226877855537, 0.04350922332984606, 0.4423771103297095, -1.1332090651952755},
    {-0.7700294062182684, 0.08961391029630851, 0.6868340173430834, 0.4597653162234113, 0.014418990272252382, 0.9390543749424864, 0.538949504080526, -0.8642875926020169, 0.5410037703530616, -0.30438229393036503, -0.2689681299929573, -0.15792432766783293, 0.9392816166861462, -0.2469057157499974, -1.0799270243161694, -0.057695732135858636, -0.8635002661325014, 0.6230941010442037, 0.41401112019691844, -1.2719180050719252, -0.7908429650742277, 0.308476153757822, 1.1194889386167088, -0.6364826697823097, 0.9954635531837789, 0.978278505273504, -1.1525896650769687, 0.7595290722206876, -0.43016759113778424, -0.40214816361489303, -1.1762262165689046, -1.2237766062104136, -0.38434195862435167, 0.13012062620553488, 0.6493349806695227, -0.43948338392957126, -1.0283392823060504, -0.46257555330672634, 1.2572570846872182, 0.14437159169764305, 0.40084998818663137, 1.1443923967180465, -0.06910383094240158, 0.2252549129502537, -0.8539875648525882, 0.6544057808111128, 0.41194669064284745, -0.9373897457812587, -0.996892936212315, -1.050855039066691, 0.8328516709078173, 0.9461717877428989, -1.1254721829422196, 0.7320158349937715, 0.3847732557816002, -1.121983040309576, 1.0798947023748928, 1.0179051508398687, -0.4077897340238442, 0.8074972319172337, 1.0232060400506935, 0.6337329151367587, 0.6155055098180536, -0.1730594722289677},
    {-0.6769231508407347, 0.15719099926661032, 0.15865601855124897, 1.0129783619613395, 0.009992846222947348, -0.40845772307992206, -1.055323665462443, 0.8999760187492192, -1.1423202129285657, -0.7148248435772383, -0.7193874027401242, -0.4535455319525951, 0.30773509841550933, -0.8714671283906883, -0.09581458254780129, -0.6862673519921715, 0.8740335776521144, -1.115809624320489, 0.80228678570414, 0.2219027585533837, -1.2310332788701814, 0.7592452376367781, 0.8200204134044177, -0.6693591498945581, 0.5182085981101472, 0.7098599435974852, 0.5561409417186054, 0.481356123295196, -0.6032588132914839, 0.6242110132781465, 0.10839274321121461, -0.12476754877664527, -0.9901793089939377, -0.6537343231216427, -0.18816711949169673, 1.0776761453332169, 0.22396783864745942, 0.5231844925461985, -0.31547605744029855, 0.8718001701796738, -0.38718225984086485, -0.9223994562169129, 0.2802172972837456, 0.3888952904081382, -0.1402657350905519, 0.34440997346525337, 0.9553541379472024, 0.9196176689883064, -0.14177168218787822, -0.5398146363228077, -0.3962062579375511, -0.38443164914044303, -0.8582281081694054, 0.2778779942152439, 0.4616417686852311, 0.4219013056824366, -0.8933675333200446, -1.0659931751284897, -0.5730640067218751, -0.5435932023030292, -0.8145827708436427, -0.3807068988247681, -5.714990525200324e-05, -0.7226771290229247},
    {0.8879211088663886, -0.4476836162599908, 0.1312197558936051, 1.0915727878086325, -0.8931746706073039, 0.003914330772793868, -1.0644264597378825, 0.8960950727971808, -0.034979977746940186, -0.8863978903045537, 0.7541466843620391, 0.12343857128117626, 0.7513596495610765, -0.6941378993204196, 0.8689046542530157, 0.39328267032999964, -1.0243599846717462, 0.8955858828712626, -0.9580583693809335, 1.1195996403506987, -1.0167048993904442, -0.1450471227679342, 0.08872533480640789, 0.3830470069979508, -0.6118183835257964, -0.3492498331526554, 0.57952507378553, 1.0837120493835415, -1.1511324766237516, -0.1928329521277221, 0.8150030555839614, -1.151668735418318, 0.5655502920985838, 0.09756548595192521, -0.7869217868905282, 0.15753192918186865, -0.12885969819355828, -0.1991441719634166, -0.0713098856966469, -0.3897373337884666, 0.7581320468258202, 0.9287394038067724, 0.8455797604554434, -1.0068753789043983, 0.4191554155465075, 0.0660123226908436, -0.11812701328085937, 0.4617510666445674, -0.8888940930491681, 0.391903499484913, -1.0127164503203891, -0.046297160975040795, -1.0762540114334318, -1.1324156838454877, -0.19429192090568584, 0.16985970535506312, -0.48393845723346246, 0.08436779834694248, 0.8531841215086643, -1.004797794086312, 1.0797739906764223, 0.861642752509947, -1.103350424935318, -0.6601295368078772},
    {-1.7007653716807265, 1.1433976978194402, 0.513322279259237, -0.9922161264028141, 1.0285882770945072, 0.9539380025972318, -1.006991683569098, 0.9006733218740351, -0.600546339428108, 0.23241693085236118, -0.5392684544086874, -0.01566532262676649, -1.2534177469837804, 0.39592942478312687, 0.020816851536833866, 0.32400543336894094, -0.13485187208829486, 0.8725513338639047, -0.33312677723296125, 0.34702050695410436, 0.28623993628896865, -0.3952982614986727, 0.9770751836417221, -0.533907128400408, -0.4895176409829247, -0.19778908305220985, -1.0346165166170105, -0.9771649388851223, 1.1008310991817638, -0.7453616161175706, -0.4031136336985816, -1.449337195894926, 0.32134640492242544, 0.041600063527605244, -1.3043387778937037, 0.607069937669246, 0.6689808040439049, 0.7660747176817599, 0.11638114583109714, 1.1314130169222358, 0.882360645505217, -0.3972664315923335, 0.4054699788109989, -0.3231001634205616, -0.730246927542128, 0.7027158395742233, -0.7864299785052908, 0.8902941958406658, 0.9597006814065311, -0.1035158773454258, 0.39892356748390173, 0.09680913163919783, -0.28335355733204565, -0.7224785463206118, -1.0288029503005427, 0.9003043314841596, 0.7336516324675482, -1.6506189201968149, -1.0949330370075534, -0.9274978683232582, 0.6694979834528197, -0.07083538192049617, 0.8497199228340612, 0.33628936496536654},
    {-1.2409402037888813, 0.3261429667637713, -0.7118771744033565, -0.4073382933543252, 0.8993733592248668, 0.3154952253888271, 0.7001789542544438, -0.2847125014932852, -1.1005518328478818, -0.699492639395177, -0.6893103716490161, -0.30576308963853505, -0.36738408953054774, -0.49364156969534706, -0.7101264562257888, -0.8956498470363387, -0.5299326258893469, 0.0207740156154807, -1.1295924082458668, -0.06464421767678265, 0.8706814888699346, 0.8249846076916351, 0.7353605733370612, 0.27977080924956915, 0.9976732360913265, 0.7679457190473696, 0.07912508176048794, 0.2687961519038851, 1.0016330285266648, -0.4613941507376314, 1.210821086286048, -0.5871387191567398, -0.4688489100507984, -0.5436443251805796, 0.05226421717845072, 0.5679423890145961, 0.16501209920909507, 0.5023076840176595, -1.1376000516364404, 1.234305946279269, 0.19297679795586692, -0.011364427662118195, 0.4754875190740171, -0.7660830168409921, -1.2700514479852247, -0.6386750604531878, 0.8735579873429091, -0.5919556970209189, -0.5236133747872842, -1.154480036608706, 0.6461100732079017, -0.22802149086726384, -0.877925869824901, -0.768420652985966, 0.18353506273684694, 0.938794972985528, 0.297695393985911, -0.8582699119634876, -0.21890816584318168, 0.4185744543816547, 0.5995808146761951, 0.15544096620826625, 0.7550817743190327, 0.644095675167705},
    {-0.3982576482285704, -0.6903893439819025, -0.4392297231770306, 0.700898882986442, 0.1321099609682313, 1.278374370126128, -1.3367151187813577, -0.3393737929990463, -0.08140709721071207, 0.17565238742869949, 0.5245991617079464, 0.19281103123317958, -0.9808529826973207, 0.14877733400597767, -0.9483391250673259, 0.6420794121483521, 0.09094197289481766, 0.36415910145319313, -1.2062927546478455, -0.13451872682764085, 0.4452124700347905, -0.6081624227861868, 0.9122180981871589, -0.9731521262074259, -1.0533283627366543, 0.7207323832519956, 1.1252324419991822, 0.15042776575507572, 0.46977011114200035, 0.9989396138545561, 0.8066287292105587, -0.8091095138337714, 0.08552610783724728, -0.7803373215243541, -0.9938238028949034, 0.799519960771412, -0.519519986590873, 1.0218385292897194, -0.8785358920271032, -0.1133913312789683, 0.026485438794286748, 0.8451106876784812, 1.2805668182131964, -0.6871558648717735, -1.1613855121572227, 0.15196274333519286, -0.831781900306826, 0.7215083875972024, 0.20951393917192945, 0.010582594429071914, 0.09721861618479631, 0.739502291496667, 1.1004086063539438, -0.999816612556863, -0.16759917037456715, 1.18519874205142, 1.2058532720119788, -0.6397103358788211, -0.423924472194139, -0.40862127480886856, 0.23431286591460548, -0.296143878307262, 1.0264334650763083, -0.12976617254720782},
    {-0.3170161314269772, 0.3279453540799945, 0.5731846162601169, -0.6936657238451753, 0.9148036405623702, -0.40774818151385017, -0.7256775001872949, -0.5871706988293861, 0.017359903173460745, -0.9817866652138452, 0.17577263228567994, 0.050938304643002676, -1.2275136027365305, -0.6566659080699079, 0.6046695996365851, 0.977970115165708, 0.013298991255627782, -0.051225390281092575, -0.6884674356978437, 0.7114409717210493, 0.18766798905133927, -0.5718415784667953, 0.5679989303361368, 0.6331321148836009, -0.9220286767308127, 0.9635601593465675, -1.12610185199035, -0.25878399691343396, -0.9312268932459248, 0.6967309800360109, 0.3665530567907637, 0.5893215732217327, 0.32200959823592723, 0.7022170510234148, -0.7209253651559565, 0.9633832217636498, 0.5196362964234564, -1.0241374239266368, 0.5536604520503272, 0.12864034669994306, 0.5611789559930865, -0.5955333351357905, -0.1074355265047604, -0.04331423124059804, 0.5225069967018476, -0.8383252915907041, -0.8465284388570234, -0.26100635041051296, -1.108032481640407, -1.0387266533538226, -0.437731937808061, 0.3558643809168882, -0.6287046279993415, 0.47837975049975634, 0.12155135579425526, 0.12767128894767718, 1.1581997691014447, 0.3176172994054711, -0.35713810836843257, -0.030988779257405834, 1.1258962075843288, 0.6534921422702932, -0.7559493390968769, 0.4785114674791872},
    {-0.6869714286716133, 0.14634594816962457, 0.038143655981294274, -0.009417028186698553, -0.09099498887022991, -0.8432348685381803, -1.003577431816668, 0.5501231109219238, -0.6206820056089697, 0.15813607452278702, 0.10859197513672178, -0.6384160654726675, -0.9097698106749917, -0.007429108793728005, 0.6338060072252735, -0.8952425779853651, 0.2817618550619894, -0.4593618998425108, 0.8865491089767298, -0.7069247378689067, -0.6984018624448398, -0.13832580790176913, -0.3451603457352689, 1.0783420202988776, 0.27941631010550083, 0.9004680247304879, -0.915722465706932, 0.8000330101730576, -0.18791162050717847, 1.0766411895409442, 0.050225278082911995, -1.2970929366301984, 0.8544209149675459, 1.2582349452048325, -0.03806927230406197, 1.1295350180394048, 0.46141548659149684, -0.9487371688857604, 0.164720210937118, -0.4811029738277678, 0.8351731921239526, 0.1665357587327593, 0.7871607513957755, 0.18493868227498522, -0.15770963832214174, -0.42942628210990186, 0.23688699010032432, 0.865623590563336, -0.6135542120429822, -1.1601194368725285, 0.2560445304244125, -0.35540560852127445, 0.8831107405167505, -0.813206739832145, 0.17452971770405912, -0.8503667865767829, -0.06236141263204616, -0.09189337363948893, 0.6483331595272401, -0.31771902711505057, 0.34333738199536645, 0.11552046222595254, -0.5929354810381932, 0.7288020615241642},
    {-0.40061823523695883, -0.615715561841756, 1.138791555444598, 0.5831023383058326, 1.0152963374964323, 1.1418501831226613, -1.2457609246394694, -0.47660359585238454, -0.32674058733490197, 0.5205839211300664, 0.21046639574035508, -0.5022857535965659, -0.2050268954817419, 0.06424800606792651, 0.49399674452793263, -0.09775691641302897, 1.2094081681030637, 0.7343556869944535, -0.47417114905402236, -0.2981307519530117, 0.7900715866552559, -0.15730643879478393, -0.28447276951837847, 0.3333387615887459, -0.14352943206048546, 1.0753280150919484, -0.3985074285440872, 1.0154596920895582, -0.017796875123096776, 0.34128534152874146, 0.36617810195306894, 0.8175191951036876, -0.6211096515423521, -0.7430592894683353, 0.619075023438912, -1.054126005674571, 0.9642690961811886, 0.12132202486829122, 0.7335903181535883, -0.06562168039344986, -0.33851379747898575, -0.7480048673425225, 0.014871129735229372, -0.05047706773919342, 0.7218643033845782, 0.5549537397749579, -0.21842585742327694, -1.2394219140596638, -0.4867548187971029, 0.018893535555537563, -0.23581106563705023, 1.0306496392399747, -0.693142227166378, 0.11641906440155156, 1.1785341871828292, -0.7039980027275841, -1.272324823895366, -1.430258639321311, -0.8912101579869245, 0.6350160009550939, 0.9463003814013189, -0.46280741116757895, -0.9098168930842815, 1.1836911576152822},
    {-0.4930368259384064, 0.5125865428665888, 1.1384861589914075, -1.1839911119059592, 1.0969223242172017, 0.685864032645114, 0.9043677754326956, 0.43106177855112554, -0.4694678531598125, -0.6472698415387765, -0.1952699808919525, 0.1847959782047695, -0.1664727089797002, 0.21591982040091923, 0.7852594100093395, 0.4045210174090766, -1.1024481027186825, 0.93974934158003, 0.45091948688539, -0.36959227128857436, 0.49319171688115615, 0.4448890972792193, 0.09631267443911164, -0.9088540772544351, -1.1033578044320653, 0.7193280849654868, 0.5807131063919343, -0.19457427032782962, -1.0207168909866273, 0.3140196317350894, 0.9802660262429899, 1.1130410999821647, 1.1866559195600739, -0.4582655014481111, -0.3180612472348756, 0.26325431525729165, -0.8421791601701157, -0.10742512654434937, 0.6035789439584591, -0.18742490066705592, -0.07519290924381113, 0.4521877405935278, -0.3859721196634406, -1.2124338576357216, 0.5741541275459147, 0.37237031573786883, -0.4900397804834393, -0.17417107590312567, -1.207505377627181, -0.11309685543368049, 0.2681842190947981, -0.664180673507799, 0.5268815159202291, 0.6632287533554839, 0.7421324807690814, -1.0362042696397604, -0.7691975519402198, 0.36200942424817306, 0.4674616651313711, -0.351667909133829, 0.17705920978943074, -0.4828976739604589, 0.6041524099857851, -0.25429605095555047},
    {0.3224964942477394, 0.6120097617822299, -0.19459848033970925, 0.54681346569145, -0.3143038596771824, -0.9639413128552642, -0.283357062828283, 1.2050071904329516, -0.12144634346953788, 0.8595776249041823, -0.3022127912078019, -0.9707488390062555, -0.364392918121219, 0.10929283452685144, -0.032425326778154885, 0.8118741848638888, 0.00562077721629051, -0.47151356357152757, -0.9380945794576793, 0.8420542901171646, -0.815515758470526, 0.02254963727218322, 0.3788646593468626, -1.175587391423426, -0.10379082655340073, -0.11750420047901323, -1.002740177013301, -0.9514461320292965, -0.9488388675785572, 0.3797479033569113, -0.6096864206594262, 0.4727624275657648, 0.7358089355647918, -0.6306208696283638, 0.895408205772627, 1.1268495501514715, -0.08570019106710208, 1.1415383221821862, -1.59495346728592, -0.009039028651982169, 0.44103681417783636, 0.14557741940381302, 0.6592651798015805, 0.5095151496977116, 0.5896071189592552, 0.59302914011653, 0.21933241568614725, 0.6750725942377087, -0.724503178721163, 0.041550026735846506, -0.80590979825775, -0.9893246766029437, -0.7189132341900583, -0.08773358715798178, 0.754704305816324, -0.049258083754676774, 0.4419843705564407, -0.2885159816111983, -0.16657925917137542, -0.502289032887444, 0.8039018814884531, -0.5821333082519449, 0.11003523018584019, -0.03600668795926081},
    {0.9504195085999848, 0.788069402738406, 0.7222919094955519, -0.39547261784939786, -0.5631283889026657, -0.2975581881140034, -0.1911919126642815, 0.9089182937189764, 0.19760325903547954, -0.7135406892187165, 0.4776346309480406, -0.9323436016185346, -0.9980556243658305, 0.35364524271414727, 1.0298773686122231, 0.05466894300660447, -0.3476614454031468, 0.34843855055840095, 0.1363466046099798, 0.7472744786304899, -0.4274560011451944, -0.30956118734444776, -1.1537318922985609, 0.9055654107290225, 0.8791902638632524, 0.6419687985083382, 0.44620662838676917, -0.3762950524347494, 0.9771601416503115, 0.735444390807805, -0.5984237545397876, -0.16717439270612056, -0.15646184174927727, -0.9147659266112556, 1.1156395198342368, -0.6012953064766514, 0.08159058095971794, 0.7092875831999608, -0.9206408788060079, -0.3920312828679834, 0.33968292201136985, 0.028844530926248783, -0.3157892891867847, -0.932221948166919, -0.5995706299493476, 1.0342594725000953, -0.4797620599985117, -0.2401692284638674, 0.29352549035703934, -0.7887809152527502, -0.44078241502012944, 0.7213947416172557, -0.1394463684021617, 0.9015980566750239, -0.8392984565765347, 0.5442927798501703, -0.529406235656307, -0.1253476042041481, -0.8649669357898806, 0.6545127593208887, 1.1677589107450286, -0.4204572430572441, 0.42146126102221176, 0.16904180421082052},
    {0.23867327350637005, 0.04799588107747288, 0.8747756429236916, 0.19560586701199947, 0.21989800159487627, 1.1744401265642088, 0.20401521633645145, 0.36646455137483985, 0.5985532541280739, 1.0806703794969195, -0.5613385668587951, -0.568531163385177, 0.2866542176269768, -1.0320234101860013, -1.3230743143969088, -0.8638455660913458, -1.1325588955205486, -0.6832470043168117, 0.9974167473034914, 0.1660152970858984, 1.2178261602258007, 0.9365487199971059, -0.8830009147337345, -1.0815614120804211, -0.7779676813632876, -1.0253702516459133, -1.0359222090586597, 0.47876632436617617, 0.7654685512803783, 0.42710518587530755, 0.4778189839436928, -0.25127160884939725, -1.0452537184435968, -0.49900447509481416, 0.6339947722739829, 0.3073400850631681, 0.01601868331228807, -0.48665741943487817, 1.1411074732291582, -0.5295943304563377, -1.0772687869499327, -0.44831472994807886, -0.8427212276845271, -0.6682291859167382, 0.8744041108683421, -0.6578848129304368, 0.23317525895976873, 0.4374516720902976, 1.0466715000953595, 0.3294775140901616, -0.10988664220962378, 0.5178799382817271, 0.4447584333667019, -0.8821111511362805, -0.14987965605295564, -0.5278851371999697, 1.2185874871760631, -0.23994925089499283, 0.3930580509857422, -0.27046492721051885, 0.7546559087774033, -0.32813340821864856, -0.6545961023573266, -1.0575266272762474},
    {-0.8361604242374657, 0.22592339158803498, 1.089232542543754, 0.10147063533408343, -0.29429807832752763, 1.0542818939977174, 0.7306850882067171, 0.8829092079102349, 0.05208687631545662, -0.948748135531528, -0.36843218876891115, -0.5359208507248411, 0.36270931541617146, -0.08789405103710753, -0.30142847753803725, -0.9685974098645174, 0.7146310260870488, 0.17856550332188048, -0.792610250217654, -0.38459286075544374, 0.06906323692366988, 0.6996241519865699, -0.8449879011220806, 0.05851079507965022, -0.23205887515559706, -1.1437016346811646, 1.0338501933060928, -1.0592604070732408, 0.892961642810943, -0.39444244768134146, 0.2629926486037393, -0.36352662518343276, 0.6860656592815814, 0.5546205069746512, 0.2878234683391025, -0.8471851680179209, 0.4529418994090754, -0.6514778490183099, 0.56235711211385, 0.514879289961612, -0.2730775295110946, 0.9960659410620661, 0.8256052850665478, 1.1053326176773584, -0.8431424852238212, -0.7223678238968938, 0.08328585573674431, -0.48701346243866034, 1.2615892003175535, -0.2366634535125979, -0.9546613670502344, 0.9534723687937146, -1.0005192621486476, 0.4766044221129558, 1.0971167277980192, -0.47852733384570395, -0.3724660352803585, -1.2489811326168054, -0.4131877659905684, 0.14653806126345428, 0.5214675251554182, 0.7316712876076662, 0.6979157760683969, -0.6808445655835677},
    {-1.006560143616339, 0.9809059113902601, -0.5315410888311589, -0.7221299940983981, 0.00047690974654831744, 1.0077339402334684, -0.07994888857554223, 0.0715114135961388, -0.9079426410778562, -0.30341041191331564, 0.9248577598555098, 0.6472008418434805, -1.3018677922316129, 0.739883505884774, 0.5227116692409433, -0.44030280080634365, -0.7010837601621429, 0.05476355058620876, 0.787430806137247, -0.7089401930243581, -0.5876680871695131, -0.27885698082497, -0.41112298258378255, -0.023148573259971234, -0.4080010815764773, 1.1789519297009217, -0.42419145781469153, 1.140241647563857, 0.9885652101024734, -0.298834093690687, 1.1334620613514732, -1.0862764017196895, 0.5493530728649217, 0.6510599776290215, 0.2643748640316058, -0.3615495692039589, 0.8952805478332055, -0.7850530228012769, -0.15258041109786324, 0.1630331125520015, 0.06763906015075376, 0.15870739917754892, 0.9387687920790728, 0.2085148186272565, 0.8588660550821244, -0.5378861465842278, -0.0038054345798022044, 1.243890488366228, -0.2627294751345869, 0.13332654738643376, -0.8955177670432023, 0.995114377374789, 0.49710265252098873, 0.5935502308966792, -0.32789292369359163, -0.9100581757761564, -0.5465057628461008, 0.31528779000786444, 0.3640432885876857, 0.7930618082251244, 0.2171958650617087, -0.8082962765058888, -1.1331452002502207, 0.7667857576384136},
    {-0.1688245881468422, 0.4889169551598284, 0.036110073211899525, -1.0546085756365615, 0.39428453123935286, 0.037643352583138376, 0.40223132690029095, -0.9983093242421404, -0.8929162905336562, -0.5022396007978743, -0.9944725359260111, -0.6304001634306247, -0.7290565490633389, -0.16515008725147023, -0.07287669109334491, -0.43195936161854465, -0.3131758060483623, -0.5734853995917081, 0.633994501393374, -0.9128206717482208, -0.28809143196805836, -0.8469573273033537, -0.26534472081917726, -0.12519061733961467, -0.5451123709897343, 0.3018173296035683, -1.0972733345925578, -1.0875227780222005, -0.20902130320148468, -0.5280499904048963, 0.2616236950104926, -0.5658758637365708, -1.1897561318811958, 0.22843554069158603, 1.1034764903087801, 0.3250287244123943, 1.3798487048993688, 0.4158202904657824, 0.15576184881133684, 0.9681631844183508, 1.0030685507422663, 0.19634468098823724, -0.056719113250019444, 0.3567524788941006, 0.15107279439400895, 0.8943421452521698, -0.4393497581728419, -0.9926462960195747, -0.20890974314866578, -1.022833973958878, 0.29828902051572415, 0.5460426970906912, -0.05448075376513225, 0.5827033180597264, -0.8223285127817772, -0.9347097705251872, -0.4628226497289659, -0.9568871853193809, 0.24930831177814403, 0.08061182943959429, 0.7910097264459506, 0.18756524706410266, 0.5314655273577388, 0.9377872123456104},
    {-0.7101740173688983, 0.5878770042891204, -1.1499047184664868, -0.7084108043379035, -0.3492495138964523, 1.2192258321441156, 0.06758606502040142, -0.937018009913254, -0.49465259745543333, -0.5431420156774266, -0.7953122922018934, -0.4595531587849714, 0.5776272158807715, -0.20764591115385103, -0.406363328501962, -0.5322748791236779, -1.1785408123320005, 0.6234601635984366, 0.7171957694774249, -1.074454374062031, -1.0597846044404846, 0.7346178774019534, 0.41316592191184864, -0.8591798904526942, 0.04302234915380536, 0.979692557427215, -0.48500686098340506, 0.38644340097823704, -0.35842921332289046, -0.4335216662281913, 0.5160996110640291, 0.7977223954453826, -0.9135999438332916, 0.564598783486633, 1.0881123995494866, 0.3586280883782919, 0.1014879602787636, 0.991262318928588, -1.0864949403856698, -1.0447535252775326, -1.023403249275968, -0.6494785009153927, -0.9961020797311779, -1.1255460053995565, -1.0317017762617773, 0.19326581161619688, -0.5031161385122295, -0.7995271607257556, -0.8068510964408655, -1.0885897065773367, -0.1603032482320833, -0.1192212508677635, -1.1173649660355012, 0.20118783236045218, 1.009915334129626, -0.009497470021737139, 0.876278814749365, -0.8221818824814551, -0.6812207217280503, 0.9188389073500433, 0.25254628196086726, -0.5107510769879067, -0.08827126248391035, -0.5916069793803165},
    {-0.9809681884585695, -0.16206279757232114, -0.13194108027630244, 0.43889744840990885, 0.9472417530406418, -0.2299148454437345, 0.104805263713698, -0.782924844426219, 1.1070047229315871, -0.6087448012840248, -0.8262247775923036, 0.10981619086886117, -0.7232281117302032, 0.2579032787607716, -0.8767380127912713, 0.6084878872524119, 0.25434557688480985, -0.5971059602981864, 0.19938604626538536, -1.064493189405472, 0.8746712446039695, -0.5143352867738664, -1.3256622064659518, -1.300723182521991, -0.03999893274658579, -0.7948586373823472, -0.2373032758291896, -0.7767933091372431, 0.0052956799335969786, 0.05019717280065203, 0.2349346409041395, 0.47010585626189644, -1.3812417193332536, 0.028894439046958622, 0.6406948851717249, -0.9697617786431535, -0.6640663744750059, 0.06824167991240102, -1.323479651635331, -1.0748776883425344, 0.4373922485386229, -0.7798212178617936, -0.6342507813758769, 0.7139182108496246, -0.633523799839718, -0.8017770149904849, 0.842453335565583, 0.6223759948399189, 0.1856573337626445, 0.32157219747379207, -0.8749484288590971, 0.3303538614451382, 0.8670055864149159, -1.0259558357958198, -0.1026116198486559, -0.29340150366998674, 0.5558969511411173, -0.5494003949311481, -1.1826710556742968, -0.9339541739723258, -0.07364143353365048, 0.9654922870425312, 1.0802081780291568, -1.1936650978487575},
    {0.5219142003951422, 1.4104640016412535, -0.8199929204691695, -0.6925233228130284, -0.8499819893831164, 0.5451245250997302, -1.054073129140184, -1.066484200641162, -0.6982379060107182, 1.10763862348481, -0.00027333648477798864, 0.9349638664369565, -0.8922848814899139, 0.7667612238699624, 0.7584690296370131, -0.44044295551006746, -0.4073623599924218, -0.6853014385273598, 1.1089032629394624, 0.03223052463762034, -0.8073889302661411, -0.7291444867169639, 0.0729106477881707, 0.36214114120027036, 1.1083709943774014, 0.28176453316514055, -0.4843325254363239, -1.0119501407858396, 1.0691114256707164, -0.8357479674278621, -0.30802527334357555, 0.279987567216871, 0.3027969233749608, -0.5348788886866849, 0.41561728397722003, 0.7506515640129041, 1.1237987067827702, 0.7857008642323333, 0.8888104806994779, 1.0566358269430611, 1.1145793386497898, -1.150789290488091, 0.6098015637810003, 0.7655512747688192, 0.36346250862410046, -0.5759085227040137, -0.42694358187433484, -0.43934302075563675, -0.15802015130794142, -1.2862605941545735, -0.3106062397795945, 0.9673990174953186, 0.7391869450797937, 0.33323301866147603, -0.55810540823418, -0.8001298306552529, 0.017845779739510726, 0.19380998530204407, -0.8480692549101505, -0.452669416338073, -0.21667553421955682, 0.08473107336877654, -0.22657177206857454, 0.9535852930464979},
    {-1.0700220426329448, 0.10257044210080998, 1.2162062249684218, -0.36763882197672887, 0.18096565181447946, 0.7867596108812704, 0.0967578723217402, -0.6071581945643058, 0.8093407676681145, 0.08344171972446733, 0.2730376013642212, 0.7299065213532157, 0.8814134458407831, -0.8212923730337605, 0.5235087050362579, -0.01317683134366913, 0.815819233676842, 0.5266376628347322, -0.03157735087949481, -0.19366503193335913, 1.09078957043565, 1.1485635478666478, 0.5794759850137816, 0.2033804440906583, 1.1360331560857098, 0.5166825055433548, 0.6370792970858324, 0.4036367613363024, -0.7613666514717112, -0.5184498411119712, -0.8671353935409256, -0.339007110762699, 0.525645153145085, 0.6542932416984024, 0.916893981248366, -0.7755629570812342, 0.1090294968924194, -0.8642455386824073, -0.4118272875089781, 0.33087178374285736, 0.4359289328209929, 0.4429078961803925, -1.0938646071145235, -0.6292116660014365, -1.3442564136953714, -1.0351926925017307, 0.26746063424602096, -0.6506205566108278, 0.2201308827841582, 0.3678324960027747, -0.2284418482247628, -1.0331075584825808, 0.03569429412987214, 0.31847978013371353, 0.335807528480872, 1.0411047991501292, -0.350916638533702, -0.7888353665796821, -0.12748482725472432, -0.463057383906567, 0.416927932588609, -0.759836555042229, 0.8721608127701997, 0.5369189446837307},
    {0.4056658822565252, 1.205238416942187, -1.4119799808458615, 0.6354714546191026, 0.602097192386684, -0.6930438371914179, -1.129104684679202, -1.0613921942622329, 0.35348716372864053, -0.28349287283782837, 0.3157603704261637, 0.9133430606381627, -0.9454855581481749, 0.35100189124204495, -0.7065326294094857, -0.017678963955722472, -0.8211284696910072, -0.8909253593966564, -0.45509332941520514, -1.0588917395676842, 0.7874397931102688, -0.556004510245999, -0.6277203897887612, -0.520983604000916, 0.7703187408292826, -0.08608515005400262, -0.8411607672872157, -1.2724757523194357, -0.7347431700774358, 0.8724414873155728, 0.14335202660463656, 0.9342135332477696, -0.029652734885604777, -1.0821616687757971, 0.42734740651594677, -0.942994005800397, 1.0729292518572495, 0.17706109764152722, 0.798180238581989, -0.06080461982832627, -1.1978828215990784, -1.2362271356352368, -1.1237315395944625, 1.0987976550141618, 0.5756237310387967, 0.08122513608782868, 0.8893948268756351, -1.1256370538456524, -0.3953213842718259, -1.1565849072736474, 1.099302818018948, 0.7104485236780007, 0.9809114650791616, 0.940274778702712, 0.15318098797086005, 0.2542546692189068, -1.2472641260718293, -0.40038673695655985, 0.9103596192625977, -0.835435318123438, 0.24744062766944552, 0.13590763981270934, -1.0382444293847954, -0.2547120687219834},
    {0.11941345062039238, 0.554842406497699, -1.0905183195237333, -1.261745084662643, 0.6369504320587822, -0.4683115806552873, -1.4145939335057784, -0.5673081753436743, -0.412946731080987, -0.8113930743942774, 0.5691532704303821, 0.5083301873305629, -0.002942715083540318, -0.48343417433196917, 0.6173070654737397, 0.3666578564804021, 0.026972403239846704, 0.10042514640843969, 0.1884097654622307, -0.673235914654927, 0.6253818257128098, 0.14591696828192446, -0.7694364798752169, -0.2840175131219895, -0.7193623787134198, 0.07888223461504304, -0.1090379759391077, -0.7181343852856281, -0.824299731974876, 0.6349712082123128, -0.42468412802787053, 1.2252414031270864, 0.9546842647723099, -0.2404551783016534, 1.187268370427254, 0.15285763662163307, 1.2363665810996969, 0.40447287583288166, -0.6477159108465155, -0.8988620929690556, -0.26692302035640103, -1.2859500346769162, 0.4748907699267527, 0.9428712273892165, 0.9002874147434554, 0.37927179025281615, -0.38053353606956175, -1.2474538573767364, -0.5731407553115111, 0.1259315965094652, 0.0009425385812997704, 1.2132851083355054, -0.4390564204516819, 0.1430159405675092, 0.959664144592272, 0.17564604030975503, 0.245872841134057, -1.407910797981825, -0.04824799361823479, 1.1168162748461006, 0.34953335776149547, -0.026088939507179738, -0.4648026153836355, 0.9648950533584727},
    {0.5572763378931131, 0.6584602115681771, -0.7517837629323275, 0.6317236435153952, 0.7051433753549634, 0.7358219512064261, 0.6337870988138272, -0.8267626385492995, 0.32164776806200035, -0.667713806121191, 1.0958789015664863, 1.0923612150096096, -0.9078552355167614, -0.08557635272772632, -0.375294270327003, -0.1402417802341247, 1.3446705130298648, 1.0922022255955646, 0.2508748216337019, 0.43936179782392343, 0.5644186623193209, -0.5219073665830134, 0.9231678629257989, 0.6982313488161938, -1.0035044468415182, -0.5728601310829448, -0.6810294788582124, 1.261684899273349, -0.6950423185528753, -0.8383289052596485, -0.6293374048114059, 1.0382018084985758, -0.7738302634124443, -0.9121021410588176, 1.3456894291066237, -0.29286409673708685, 1.1118708361547665, 0.702497871706724, -0.011797467153849318, 0.5779675712170496, -1.1632600205698496, 0.2472505057315261, -1.2041575072375574, 0.5481360867255168, 0.8364137982387311, 1.047665935928642, -0.26291604875377816, 0.7975289999042965, -0.47427205390309607, -0.33139858462877425, 0.9663385165709865, -0.37515961715331086, 0.6384440030748392, 0.7298618011676737, 0.9636926586054717, -1.028415708685107, -0.9168815715227334, -0.13370800956661164, -1.0445328439664057, -0.543750170818283, -0.7474072415883112, 0.2709102878919873, 0.5742088605195301, -0.16016611943524417},
    {-0.673113689582032, -0.49855523086759745, -1.3449788901172424, -0.42848438571783143, 0.09799546029265621, -0.30542972166199805, 1.0516716066915437, -0.9957166761588917, 0.38072940298257046, 0.42208963868032956, -0.9334503630136077, 0.009160158747177016, 0.7119446963717276, 1.2417212387031284, 0.2650541659785154, -0.0903498204028514, 0.1666434655471166, 0.5714686968269267, -0.9855473586346101, -0.4231766644810406, 0.6507038493279711, -1.120695348318603, 0.7517795429185163, 1.020846822052512, -0.7643155016456648, 0.3075902580086713, 0.19295001438820608, -0.20502418298140418, 0.5287933370697666, -0.5578687594459458, 0.27907985297461546, -0.051579172995531594, 0.5091593373657257, 0.5765261111833924, 0.682861712963539, 0.8124477347409597, 0.625062296749508, 0.8500051815531441, -0.36261360622651356, -0.6292864519667375, 0.4341663361759963, -0.12419507987707099, 1.0151650494198419, 0.4918417575915329, -1.039780105102223, 0.0774579985151376, 0.3313063070857916, -0.3179384820586305, 0.39386896589834147, -0.33108555247464677, -0.9206107595538728, 0.9459790878696861, -0.5230951385124958, 0.9158944055181486, -0.16835008466831003, -0.8355333511272396, -0.08509046955811034, 0.3573518183540627, -0.6799859924182614, 0.12679842450392997, 0.1834607510569351, -0.2984277670817303, 0.12095760043701699, 0.8878471140095109},
    {-0.6737062769874557, -1.025652053668964, -0.7597587197145418, -0.39553491957235987, -0.4359527379608182, -0.006516577527048818, 0.6280449705640293, -0.19179580781931754, -0.9784037062784064, 0.0934337995588438, 0.23027464589785324, 0.39831985528165326, -0.6506679538330779, -0.352733929547144, -0.9126797829830937, 0.7384340372001171, -0.10688036908783141, -0.6668256811518481, 0.34588690574349995, -0.9523340789639912, 0.8457600901903375, -0.6402372211447015, 0.936187549823534, 0.7553776998104701, -0.18291799590689858, -0.636637060022385, -0.9315873912444292, -0.7383126725380785, 0.7923810574783424, 1.0772057329301463, -0.2142341468651035, -0.2276349543122223, 1.178234495174799, 0.3322650147810725, 0.9253455932670667, -0.5798908568241112, 1.2082729649539803, 0.858732806215808, -0.15039565144808625, -0.5110792241325607, 0.08931624108655828, -0.30255339165042433, -0.9767608497909196, 0.5382964082802085, -0.9816106277234597, -0.2681666812178956, 0.8374884080105861, -0.9818932806431342, 1.0208171203981262, 0.43319498851158306, 0.7833975325024555, -0.8617862891651227, 0.19083667353194894, 0.40585432575159447, -0.6130189924957216, -0.7885237651688076, 1.0873442325264235, -1.0643935403097833, 1.0206344048023546, -0.15754581205266666, -0.29273941872285886, 0.14222721270285693, -0.5659878406467757, 0.0728295335833578},
    {0.1878851864831624, -0.9401687585929467, -0.03014005600698621, -0.9490611482804884, 0.6545177346384009, 0.03648847337304784, -0.45549102659653923, -0.9706489788442132, -0.7063600900985668, -0.5655980950010217, 1.018005201846676, -0.2936558645180728, 0.7167947209307303, -1.020545522631725, 0.09348034796821691, -0.612416258430826, 0.6846391487013497, -0.7094371386225593, -0.16240408641323578, 0.8711135910255837, 0.4105076132815176, 0.8649873720075181, -0.5021727091369769, -0.901774463694561, -0.15775817004773518, -0.1908915433186566, 0.4668641680919547, 0.6157418945700848, -0.8037471598793305, 1.0060170616880963, -0.2731453730469538, -0.7235351150038882, 1.2378848176973842, 0.4864904755705048, -0.2550986541753067, -0.5247322370678696, 0.1803417568608602, 1.0273955463585867, -0.20733990764979546, 0.5180893773290971, 0.067657527046678, 0.7751791396599595, 1.0564792205417348, -0.16031943530185733, 0.5449872593534285, 0.6670199567692161, 0.443355940687167, 0.17999101399173068, -0.8243117385003891, 0.723825509710017, -0.17812486906454783, 1.2015353782805729, -0.00010244741712356902, -0.44353008654740506, 0.6739873420176021, -1.0935187986815507, 0.1412491520272571, 0.08710352810538574, 0.8955328733417006, 0.7964773252583566, 0.6192133946600687, 0.1736408745960903, 0.34494869051755866, -0.2429924146918699},
    {1.072578376675832, 0.9120845633150346, -0.42435112485593535, -0.8647408960300483, -0.23623338787680498, -0.04889900690548477, -0.27032546069333, -0.9339461324811321, 0.6621525047555841, 0.44727878844792196, -0.30266665351761773, 0.22223592173303874, 0.18967962553852113, 0.45033896919140276, -0.7359844032537223, 0.5103500334760713, -0.577181770071222, 1.0442873387941494, 0.9070007824125044, -0.5929214093563218, -1.1244528225678387, 0.9701802757351814, -0.25346871922994674, 0.6122869160945941, 0.9015721875540711, 0.23899718647236207, -0.9881098614374911, 0.8382078678054744, -1.1484410549378314, -0.7048785149187351, -0.5033614334547416, -0.10772449134642069, -0.49477375555270353, -0.6473243597931974, 0.9719309328531462, 1.1126053799033309, -1.1327727515021535, 0.06475732140685923, -0.6955590452980902, -0.8751972291408084, 0.681467123020468, -0.5269124665876591, -0.8964260689564625, -0.7164252367006512, -0.6801558656818435, -0.058966816438148814, 0.08918763199208045, 0.8327931701233093, 0.9962115176293365, -0.3491056936756638, 1.045709926347383, 1.2079185175941463, 0.9907483263442713, 0.9482932099048964, -0.7065501465873737, 0.9664945265958905, -0.46386442976020026, 0.5609180483595257, -0.18968192027290548, -0.2100644921767602, -0.9280451285658843, 0.2870149211984163, 0.5709655728516158, 1.0468824276404483},
    {-0.9013170408908984, -1.0097893033569199, 1.0467376603697478, 1.0769049243113722, 0.5865187933079363, 0.5639466072125675, -0.8517100670607041, 0.3443441479607039, 0.14490090191467955, -0.40494654124981405, -0.21769659985227777, 0.7115013625742046, 0.46369291716611283, 0.06895905218921654, 0.41258506439608983, 0.2988266942751649, -0.002426361572758708, 0.7392762682420877, 0.36782401031901646, -0.990476970775752, -0.7845414814240653, 0.17852232255154568, -0.002714612959139119, 0.18717451184697387, 0.6321684779601686, -1.3607401377364947, 0.695845824550915, 0.8350600449667193, 0.25762560935674833, -0.6760451140615937, 0.9176204559752764, -1.0418661503894402, -1.099800577601833, -0.16760633584726492, 1.174666780063246, 1.0288024371240263, 0.4220843445530128, 0.6959938567804317, -0.85041903963814, -0.5474362719987429, 0.9283647101637227, 1.017366358456834, -0.974816455162564, 1.0198594211212333, 0.2080440616234387, -0.43876760318185887, 0.24359598869313176, 0.09890559403103394, 0.7549467115494591, -0.5148959240066268, 0.5451922978997908, -0.3381909594239455, 0.8402367881225743, -0.403141237765689, 0.3297144283684792, -0.12186658450243418, 0.4943176055713057, 0.18953777177951164, -0.32172370952297397, 1.1445662799107046, 0.4392215563841526, 0.533095371001139, -0.28971164732599547, -0.07977472497174146},
    {1.268113180549351, -0.0973441717512202, -0.4303758354999009, -0.582231871549365, -1.0829538604400657, -0.21068655612432335, -0.45324329054674595, -0.7660162622317671, 0.28394210483097115, -1.038865639283942, 0.39242626797623154, 0.9014213179225874, 0.5557654475655346, 0.4796537110679931, -0.8996316981322522, -0.9892818332030398, 0.9338206653173036, -0.560183635499988, 0.38573395903600316, -0.19188451404123105, 1.0427103460095986, -0.9119182333249195, 1.011440730902366, 0.6743864191729657, -0.21664172583779398, -0.2209519971886739, -1.1965782668207792, -0.9930344716319043, -1.4105442185517574, 0.043149862642094264, -0.760815682798602, 0.1252029367740198, 0.948302329521005, -0.13231031540403362, -1.1697561192784136, 0.45771941952053646, -0.9796420478925021, -0.26933747153707455, 0.3313195296017424, 0.2859570231235991, -0.1795755971403941, -0.522257944077401, -0.22062754456110603, -1.0967944785929178, 0.8453289205857804, -0.8161383104708831, -0.6082557211624009, -1.0071515182796722, -0.9906971332949094, -0.857951708685702, -0.2191798682250854, -0.9304437505008795, -0.19050096352065962, 0.027027698324718925, 0.18198086974035887, 0.8631968815635509, 0.6103742056911867, -0.6912780180292144, 0.26330481419155016, 0.679078617390903, 0.8288250187285525, 0.6240737589959836, 0.1454093755683449, -0.4534809260725123},
    {1.2028551175640978, -1.1107602404699894, 0.9700118734731153, -0.07771468192596967, -0.6970523361887333, 0.7697739806493686, -0.9682277723227047, 1.152214770674757, -0.40721170988288197, 0.0846837929983796, -0.3260754049092139, 0.750769524029489, -0.9812666186678233, -0.6174703881303595, 0.7849411425850873, -0.4924205828616873, -0.4681509261263469, 0.143920220592249, 0.09872117177523602, 0.24350050892819788, -0.5504008575342281, -0.5198148392192966, 0.6394782705487772, -0.5019928013174475, 0.6879749106978701, 0.8936100150263012, 0.35343203987634086, 0.3319441100206468, -0.08539300193713542, -1.2068228172241229, 1.2793889911675154, 0.701478723967429, -0.16912492594049008, 0.10270637611948787, -1.0814738346675663, 1.0065751459901306, 0.056561306629975876, -1.0107923392545175, 0.1370908627280196, -0.9044980022906939, -0.46140275781559587, 0.7042440024671631, -0.725233479358622, -0.8027123696707742, -0.883563123950386, 1.1816254249954645, 0.8915215885311744, -1.0392459945104895, -0.06426915054207116, -0.7366876975069933, 0.4868753012317871, -0.1257023158620066, 0.6365002880930872, 0.7565481601551423, -1.0429750573672256, 0.24074823022014538, 1.0476282436884752, -0.6571093668045273, -0.11229834815143024, 0.5394042584172586, -0.28535038898263265, 0.12243999410445583, -0.9861281360395109, 0.851526694967607},
    {0.359501155400285, 1.0680690355892017, 0.6901707077576535, -0.6861213697392474, 0.7468606006953286, 1.1029601445748511, 0.9813489837045128, 1.2591783319601493, 0.18473223521698712, 0.5471196011587601, 1.0073780117832196, 0.702529905272554, -0.8916945789094533, -0.6692938515942726, 1.0552044969380638, -0.21749326800222749, -0.32285602957585546, -0.7662174287249714, 0.4016023953952032, -0.5065916421456154, 0.8327412767908198, -0.12208581713542062, -0.9260410115772164, 0.7137095959155001, 1.0924258449708797, 1.2770641646392757, -0.06371804357293843, 0.7717333481088343, -0.6167304224507077, 0.5013585953061138, -1.098480827183391, -0.05566337848391013, -1.0779600566811172, 0.898505461578059, -0.19374042299660274, 1.1368030654805374, -0.8535897337135203, -0.260964161961109, -0.7315535732150967, 0.2646805474756938, 1.143548012491915, 0.7168823983216217, 0.39414021010725125, 0.13875423369189277, 0.016405035988263563, 0.47356119318408985, 0.23550791013787647, 0.5555304944352586, 0.43890671440435675, -1.240718031628456, -0.14019466880411527, -0.8454727743782036, -0.09686939887487174, -0.4078025941645816, -0.3269409090106357, 0.46539420948626997, -1.2038106565259759, -0.34362526962404855, -0.49187652209296184, -0.6781564926136973, -0.5341497799731473, -0.9528251188595466, 0.237512362424181, -0.8397235172199624},
    {0.34435874837310354, -0.5005041688949665, 0.3245870359541106, -1.0734736517408032, 1.1152650245429208, 0.19761618475134138, -0.8617495186172249, 0.4272938769520418, 0.21005816353167145, 0.9924108883845844, 0.2350998308487523, -0.24909816627417675, -0.8805405346898124, -0.423195263366833, -0.8592240695596821, 1.14183789534622, 0.45648513628887055, 0.3276170322753942, -0.8528252448449817, 0.7654230911209065, -0.3008098189346146, -0.5663941225950464, 1.0111320115476994, 0.013158402456224834, 0.42151699589430497, 0.4290471934908208, 0.7048603151656103, 0.9795238297371829, 1.084521201569005, 1.3049796692694857, 1.265582987719226, 0.9296140155816475, 0.08790341912393491, -0.1330188121993458, -0.7251910458426815, 0.7939697201124337, -0.8979152885660958, 0.41800896616519806, 0.7056847496088674, 0.7374743278571579, -0.22101622441434374, -1.3328036248085076, 0.4107676029255479, -0.9210383733613895, -1.0105437959559194, -0.5803922864831492, 0.041879193971888294, 0.4383973344049408, -1.0111855427496221, 0.019383685319678358, 0.15016887968616438, 1.0602437764327928, 0.4272777144465496, -0.27993892931517717, -0.20099799966477294, 0.7320387102081763, 1.0643097362151073, -1.0922053408584742, -0.48511887683448907, 0.12851854827742132, -0.48641231573480476, 0.8345555024378744, 0.8730277189772865, 0.9048733844432891},
    {0.7250480550636214, 0.4470836640360129, -0.8778863092595564, -1.0688149016577928, 0.9820641890317943, -0.19671960511522332, -0.29323726541802597, 1.2102003056804858, -0.6780863293162859, 1.075747614146404, -0.33952735237873777, -0.6173449243342296, 0.07556809889346126, 1.026743351535555, -0.9824725887997711, -0.3487919007063685, -0.0654749300337337, -0.33976800450212996, 1.123553998365196, -1.2383976734550066, -0.6861004627019641, -0.14857948790370537, 0.9396326729416674, -0.43652170401391316, 1.226288331674543, 0.3736842382239758, -0.9259206897939455, 1.0811453950235759, -0.13902837479092292, -0.9822452770230314, 1.248685996393423, 0.6058311929366973, 0.37362412400192757, -0.06364299483678747, 0.6737318178643795, 0.106028035430331, 0.6913942201106196, -0.6713850544421285, 0.4209012772443219, -0.29080850480730774, -0.4165342572862472, 0.8534004973403021, 1.1327802897932913, -0.6877853677764542, 0.32686217963565617, 0.4274628249333613, -0.9568952884477034, 0.38362183812187217, -0.8086629878582966, -0.8132323603212067, 0.6668096962366419, 0.23371772087737325, 0.30288566080215595, -0.7814476702068995, 0.9174408855987899, 0.19859143407805493, -0.8243319361643259, 0.015274563768647918, -0.3212431062915634, -0.6427511811580301, -0.3495592474679215, 1.072318300204876, -0.11046705366213852, 0.9817979604639068}
};

static const float b1[64] = {1.4292449899303792, 1.1982992141662987, 1.4580573342490122, 1.4476371883742063, 1.0960224925683544, 1.4281871132064488, 1.5436350468916382, 1.2006446601954692, 1.101879486684649, 1.3623437855406693, 0.5746960971706526, 1.3031209355347475, 1.4147493803598727, 1.2526977271253503, 1.5262926145909652, 1.0352076936265797, 1.1738205740227803, 0.81997860443681, 0.8780866611322018, 1.410921410209346, 1.4390151316408444, 0.873526211401485, 1.2610793289990605, 1.2220480961757005, 1.4397719532858806, 1.375385459319858, 1.356883276020922, 1.4552024085943263, 1.4746897178226028, 0.9439291159726843, 1.0373561943623784, 1.4254529776040503, 1.3491943274885798, 1.4173704160875964, 1.455953567495445, 1.527770094981258, 1.436238407513707, 1.0375214458888895, 1.4420442534516837, 1.2512524363062034, 1.4696907185471721, 1.4188775451733457, 1.2919134444337435, 0.9479812533662757, 1.4709948559868056, 1.2252258086748025, 1.0772029504687606, 1.4149023815923107, 1.502687906050609, 1.3084257939732968, 1.3124713837767918, 1.4272828818130436, 1.2305114105341821, 1.177471736943586, 1.1639476067762153, 1.4430351752867425, 1.4358141330713836, 1.4746833840221403, 1.4826126193516842, 1.5577124321402773, 0.9695248232733041, 1.3502505080278562, 1.1319518617112343, 1.4998063810501936};

static const float w2[64][32] = {
    {0.8447396852717107, 1.5741563173195123, 0.8546385558977101, 0.12300083096175998, 0.21041302552885005, 0.780902591253521, -0.5560946004303406, 1.1413074064016906, 0.35092306183745964, 0.37199422448605823, 0.08268488736043424, 1.1640721396860323, 1.377790374423422, 0.6360879511227726, -0.13951399908795262, -0.32035656016356295, 0.6771906048354209, 1.1943965890487493, -0.01841892814234843, -0.19569022621160018, 1.3900043967508107, 0.3164923070941379, 0.9842721519948451, 0.42425910620230817, 2.037757390993304, 0.10990749054633075, -0.5838492582962884, 0.9288033598913141, 0.8811257800751637, 0.7219568188219795, 1.9856968582387236, 0.10548462136110782},
    {1.1335617117919894, 0.5611006535204619, 1.5733438731471678, 0.2316093703773206, 0.08812485294489163, -0.10976367998356798, 1.0602948997482273, 1.6833893950521785, 1.9337182576766163, 0.5741992010961023, 0.9400674944522032, 0.5234617928765748, 1.502809268043582, 1.6061398352224978, -0.6514793448995249, 1.4212809297596498, 1.579039356804854, 1.4631938938122067, 0.06110029501613887, 0.3939969382408238, 1.6413488472590534, 0.555224890953711, 1.4595156004258814, -0.08429815885608884, 1.3004551453030242, 0.048054907797016634, -0.3698825199914486, 1.8082183200128434, 1.8101120885421238, 1.5409739611577669, 0.75536242557741, -0.10381727666089652},
    {0.19456281574591588, 0.24768518858804844, 2.127236661459693, -0.11902275422527935, -0.4692926315658938, 0.1751679009939435, -0.19906436126857593, 1.159785748031484, 1.5247393327248748, 1.2222721493556046, 1.0455022649709433, 0.4655610296366311, 1.0591482195619362, 1.0383497995614497, -0.7288048706806592, 0.11273680028925714, 1.542450124308011, 0.9650869142082028, 0.39627298484776796, -0.4657481855708863, 1.3791007773570572, 1.4200849387503116, 0.31667059632026384, 1.432234462451461, 1.2143886041067444, 0.11733506078032548, -0.6310879462690646, 1.3915221176772734, 0.9051292982905516, 0.43957994916341553, 1.901325226571579, 0.7212354233247178},
    {1.021976111360802, 1.1339548090386322, 1.1643753248628355, -0.41404096003601115, -0.5861401644610974, 1.8458951215525528, 0.43398559735490505, -0.11488360393327553, 0.6781644474482884, 0.26667149043433414, 0.11749493763210397, 1.8910349119852563, 1.9961703853335155, 1.7920668786260232, 0.09275148128426441, 1.2531361669723893, 0.16856364342001606, -0.18074782382634227, -0.3673691851264144, -0.19182700050943144, 1.5640858437228908, 0.7329849843215326, 1.2222571794394457, 0.7296504277533232, 0.17038373913123947, 0.08761514361095939, -0.2846253938482229, 1.4702822243983114, 0.3195496572460333, 0.37733475294926344, 0.47119542529127717, 0.7256482246716366},
    {1.6445351918225124, 0.029718714431447708, 1.5967054437546178, -0.908536158498419, 0.6136689924076446, 1.7292468912921877, -0.356041866929921, 1.6395299539913561, 1.4416110490535197, 0.07632152097030578, 0.4602728515425523, 0.8465762180025045, 1.6266943871498498, 1.0626253455626702, 0.6821257341204375, 0.9315330483841452, 1.1333578376252615, 0.7676330322921036, 0.21477250797061637, 0.20640986621993673, 0.43836946872180943, 0.1686426659768838, 0.013451990252015001, 0.4818448497180635, 0.8449262789022232, 0.1209313388634122, -0.6490626651341221, 1.833415833353376, 0.8208309541585351, 0.9032341887406229, 0.26081157295984697, 0.1955453806898204},
    {1.869390811641065, -0.14469221442113797, 1.172115616671781, -0.9557649838363942, 0.2325178409908347, 0.1158477914605867, 0.7067776342866, 0.23643101761276047, 1.0807956286281928, 0.282853657042845, 1.0999674606994065, 1.8087556414731125, 0.5882977543715917, 1.8592650029981332, -0.08581743956030807, 0.06914613467286347, 0.8508036815759962, 0.7375476081809874, -0.15629981537340168, 0.2564134377310877, 2.064756771406506, -0.3837512277454618, 0.5132225683479141, 0.48860976839420145, 0.3812410280232683, 0.12022600802980886, -0.26738004731012566, 0.7795941242155365, 1.2309457107957988, 1.9631690580178902, 1.4009128277632936, 1.6321299996576057},
    {1.4263079111680106, 0.86689473313475, 0.8450251034678303, -0.31307552629278207, -0.6884937153183162, 1.78871917097741, -0.715513762200561, 0.7942735619523955, 0.7466276620150312, 0.05405335136936742, 0.7371296380435534, 1.4306436557002018, 0.9321774654919479, 0.6862927935594673, -0.2360161309755488, 0.7934713487387061, -0.09314497496016523, 0.6853998941946485, 0.3040052731358246, -0.35253559903095805, 2.0458072736832165, -0.30915561501543637, 0.46957239421727665, 0.8265955031871128, 1.3218582945775608, 0.747624114863815, 0.33296141284370667, 0.43908505994663244, 0.8557338841611705, 1.951910258804501, 1.3782037472744193, 0.5832961161892298},
    {1.6798036550164657, 0.5035663875580197, 0.7458022428830144, -0.027302003343517584, 0.508034515590976, -0.032067149944229954, -0.02583364346057306, 1.0883403831684737, 1.1997338290410404, 1.6218685101298842, -0.3204232932719032, 0.3318553464169678, 1.1278655460502236, 1.1333260288915434, -0.9337781729752166, 0.3465549099907619, -0.16987722673401848, 1.1314909189106586, 0.3598994978618455, 0.7317598335843076, 1.3275572074497248, 0.04344216332887128, 1.0286797024674135, 0.010592472478819523, 0.6953265406348724, 1.6000638229144297, -0.7269967133322639, 0.45556019249409024, 0.775836467284362, 2.00122545103605, 0.7514670282572596, 1.534231629520511},
    {1.4042261334481345, 1.0958935306856228, 0.8482658876764049, -0.146442451408708, -0.8897723820497574, 1.7592781413237437, -0.7577095220683839, 0.8354896362492535, 0.2823268713909377, 0.4996954547986396, -0.25452395376000714, 0.25327566938631557, 0.8773954184362941, 0.8152030927103755, 0.8234263308305886, 1.3862466783688019, 0.5471775130078633, 0.19406740679005108, -0.20081438789654885, 1.2980666531285248, 1.2752262605748215, 0.3690660163365168, 0.12382044524131536, 1.4290032742005248, 1.7292737762651713, 1.838754740264135, 0.3455877145722667, 0.34789652189823456, 1.9994747699808373, 1.3266404975950392, 0.34629234127748376, -0.211455153489259},
    {0.5503924654433348, 0.3344533399986249, 0.22651796345496272, -0.9191284622309857, -0.8035467240840969, 0.5986373574566172, 0.5432545941431605, 1.1744484358917227, 1.812706465980726, 1.470350905074159, 0.7465790185665917, 0.7622447384668585, 0.44279970269750857, 1.351066204752979, -0.7951915633333996, 0.8811424941516203, 1.2340435564953876, 1.0191662845187734, 0.34295950839906414, 0.17085134402343266, 1.7920496350726611, -0.21534899244443598, 1.4793283324905822, 0.9232201770852595, 0.4033093271411579, 0.6453359903608172, 0.24920604320000833, 1.5142795007941319, 1.9964632490890162, 1.592766046746802, 1.377658487558128, -0.2124016536420536},
    {0.5085093885659373, 0.257929895423535, 0.40481876996563865, 0.2377693738618056, -0.6659312415080092, 0.6649483855491078, 0.35653659856300235, 1.1747372093980417, 0.5177231038169035, 0.7827374087663043, 0.2551282225640845, 0.6831939486982984, 0.6533479190826421, 1.368649358750864, 0.4461705988077311, 0.0321933538260443, 0.04029009570902968, 1.23342977155541, -0.33117246145825946, 0.1040806820549494, 0.5052790781712739, -0.35120517261203765, 0.47946592081416206, 0.24365686440451062, 0.20733272476595563, 0.061056953764686214, 0.5074717239385698, 0.0685811287620226, 0.35586353615398497, 1.0816429464919874, 1.1170677520664052, 0.5935940485853649},
    {0.1474643909262992, 1.033859943115968, 1.3264405528146095, 0.0989739352864424, -0.11640598350106393, 0.2763362371612314, -0.6391057612782333, 0.537379194282632, 1.38434359960202, 0.1905492630127527, -0.3352017101592304, 1.7217492256882523, 1.7575690392776424, 0.9023955029142029, -1.0566740872490665, 0.14703956479586328, 1.4279992244050683, 0.15083740623653166, -0.9247463305250385, 0.5487676501877231, 0.39576802691350366, 0.8783588387368065, 1.4846376509438775, 0.9033659505697871, 1.599196457194971, 1.6234043709592514, 0.43719786254257154, 0.6609719724841014, 1.1907651294401815, 0.955343070201318, 0.16360273740658204, 0.5435326213681995},
    {0.3237759747722097, 0.5723523216877839, 1.5469317124279895, -0.9699766227644818, 0.4641284052636984, 1.258438467574579, -0.012823720982624336, 1.4086641291646544, 0.836600781164433, 0.7785951509420592, 1.170151779362954, 1.5627487158348052, 0.4024422233515956, 0.7168063645610236, 0.3713300132651233, 1.0742576807480755, 1.4712028830063801, 0.9816773045903954, -0.9722370481461289, -0.05382741719354877, 1.777456248877245, 1.280106764983199, -0.016572396835682287, 0.23609213495409084, 1.8107541401669913, 0.3098955167610787, -0.35181275725953853, 1.1899327849212267, 1.7873894689176888, 0.7674933615394469, 0.31196281422117184, -0.21204527708495097},
    {0.3785108785399449, -0.2643279503477362, 0.29637379597841174, 0.7708967363134385, -0.012323612550256904, 0.4749738874043009, 0.8218663917523811, 1.125919190816234, -0.030884159814834174, 1.1379069367386407, 0.4190345511063267, 0.9865146853410575, 0.4405390726982358, 0.036935078921408356, 0.05232255049782837, 0.38558313077556083, 1.4661660383330095, 0.31706394522925124, 0.3755976199991412, 0.0916908819676109, 1.9418405177706874, 1.0829396712722543, 0.9616251851423123, 1.05126927713441, 0.6112017733379967, 0.6844965668497451, -0.36254201004087844, 1.0932327696426256, 1.107615745092786, 0.27530526694305724, 1.1788528079767142, 0.9484179727348307},
    {0.9328652039034134, -0.12395403934435446, 1.0966986806232764, -0.7024159183782512, -0.5767518018542812, 0.10491242776501808, -0.19220036947571195, 0.2070434845708616, 1.3695168249264256, 0.8540980396204673, 0.35776160498233606, 2.1085466547793854, 0.716380166961449, 1.4196483704291454, -0.9796117684392022, 1.0029813758056645, 0.6173897901339527, 0.6296923279652363, -0.9345972786365574, -0.4287556537758625, 0.5447239961778668, 0.8794009860018811, 1.1267831006018132, -0.015508699475026566, 0.6513893965964037, 0.5951956806478054, 0.4283782002209644, 0.14301913243635428, 2.1860570302696023, 1.1301808570896765, 2.0687171830056217, 0.6472136967332817},
    {1.4840479407267733, 1.2520351713538915, 1.8422891563990402, 0.3239819717247749, 0.5184193543105549, 1.0166010832873345, -0.04705672664855598, 0.6712881364415471, 1.7395909408141161, 1.2099061693110242, 0.5656706231020101, 0.46205738618943787, 0.42217867116305247, 1.66375182081674, 0.2351584545786709, 0.97232370701241, 1.6057545623506826, 0.8205916411496861, 0.6043922229190812, 0.1381778993738679, 1.3512163139632458, 0.10521708754065894, -0.028760818341892428, 0.9582159531844737, 0.6073661229351667, 0.9501826383142931, 0.09475038734826889, 0.9084841298489064, 1.846863242139247, 0.2738034396315531, 0.5550644976233784, 1.5812014557244982},
    {1.3242736938633064, 0.20584073036503459, 0.9492909922243244, -0.7007346955975462, -0.9240979777833788, 0.2707704487502051, 0.08750486581104289, 1.6171694749498184, 1.9046504506145168, 1.0149862183334712, 1.3362146731085043, 0.7515010140645446, 0.505290089012992, 0.8316557527621166, -0.48723150177925856, 0.4381714448828407, -0.0851744268318934, 1.7165817081032546, 0.5341955488975834, 0.7285092708345821, 0.7531444332460192, 0.49189502573107674, -0.35418607384547995, -0.10877770354899724, 1.759802055846756, 0.6008907608374073, -0.6326401280041729, 0.4046245494825091, 1.0389779836157391, 0.9553147048386956, 0.8931426560104967, -0.09310444289297584},
    {0.5751536154356202, 0.910024226663311, 0.8805417451112849, 0.21200837099480843, -0.07214394235605431, 0.10343941453247645, 0.43823624945939166, 0.5647725305274498, 0.8184947583337033, 1.7745673267179816, 0.7472848846780982, 0.5343645130437193, 0.05986062446667274, 0.42618011161655867, -0.2631927720788243, 1.4577868288613105, -0.39009026034699695, 0.410455334503098, -0.41935317966480357, 0.6933189768521647, 0.5557333666597166, -0.11058858820544433, 1.4092697455186327, -0.18105387709210108, 0.20385916416460997, 1.41466699574379, 0.6317442275061877, 0.48236139148777374, 1.8658449744495618, 0.37153106755032295, 1.8347255550212276, -0.32655862242264905},
    {1.3891329030477961, -0.2316946902930037, 0.5987324082874161, 0.043771911408352376, 0.5261806679374158, 1.599422008489849, -0.6656071503615116, -0.13145063800551732, 0.3656520961861614, 1.1261621202946497, 0.12137304803814555, 0.9433297495044165, 1.6435360319899581, 0.35250456009633946, 0.6987817802424824, 0.7190196105496348, 0.08465808419967646, 1.2561837172797816, -0.927448562416401, -0.3532889325524665, 0.5312338601277021, 0.662061949612215, 1.166616828196618, 0.2744165003785113, 0.34246380715305585, 1.816826489350676, -0.5551642973920662, 1.324149075116975, 1.5224526038751656, 0.447533642741317, 0.3011797730945404, 0.5766275022869969},
    {1.255199810675204, -0.28068519804554837, 2.0764833288515896, -0.8234399528838571, -0.7359332187189285, 1.4724327566723796, -0.2090900238916872, 1.1912479169683943, 1.1600354870832923, 1.5289149572672802, 1.1410716429648726, 0.4805623807619607, 1.9480794129562224, 1.0943576188764559, 0.009447113925007524, 0.7248084227043936, 1.4799143520033256, 1.2792742000835475, -0.8632880276777243, -0.5477003789930242, 0.7491307154113015, -0.26886657907463885, 1.4994228524677622, 1.0085104232626259, 0.4597937867920221, 1.779877174197502, 0.6167729265849068, 1.4371760346931501, 1.92617913059823, 1.38473217949379, 1.9385141213410555, 0.9571440617415075},
    {0.4213878780369847, 0.5923038893485918, 2.104503319963719, 0.3176589654404941, 0.06383235535995564, 0.3662141239481451, -0.24988453601051747, 0.14301794297829604, 0.1664191820013324, 0.9055735705147251, 1.3329491896952559, 1.1487003447994202, 0.5161720407992819, 1.5382074162529014, 0.04168004368745263, 1.174036926482459, -0.022143650603076465, 1.4539723836806686, -0.017234520084342266, -0.38368206220309986, 1.850453486471224, 0.8233149904940473, 1.0108705995159522, 1.0980343939735207, 1.2048813020398474, 0.5020284745720283, 0.5307571174350705, 0.3384357039756023, 0.9385295689064251, 1.390017072533845, 0.8483382108947353, 0.3510314483236906},
    {1.2702827683832831, 0.7674034792044311, 0.16232573410170403, -0.4142263791543536, -1.0665771439089389, 0.16798512102838103, -0.057349835682061645, 0.7786520387687107, 1.3334837394726162, 0.18859375142555804, 0.3121094386961545, 0.47583400013484517, 1.1946431518754368, 1.5589354197757155, 0.7474027717357062, 0.74705193711794, 0.09569469451652438, 0.2567445495986366, 0.5196524588685747, -0.3932375915050138, 0.38098529020312616, 0.5999047368549889, 0.7024839244471355, 0.9648817246286868, 0.2573275484606561, 1.6730271080855283, 0.9664591816626009, 0.16903108177693477, 1.2611842532494182, 1.3183169028399977, 0.6412310434980684, 1.5958178246297368},
    {0.18555035076089665, 1.3931684887562554, 0.6464694899133929, -0.43125354282808137, 0.6927087859424474, 0.4378932531083956, 0.7522516764550148, 0.6869987971344512, 1.0030041046485736, 0.9904453893671455, 0.2650135988506797, 1.6958621352474277, 0.9649088950235094, 0.46435878682411996, -0.7546092854674387, 0.7959711259153489, 0.811520013262041, 0.8486307536553336, -0.5506079644030863, -0.6398639524241235, 0.8866947330305498, 0.44895996448551745, 1.2924309880665956, -0.17594020191418414, 0.2680510883148846, 0.9950342002844312, 1.1359489942478134, 0.16221195009571224, 0.5132277056314324, 1.481935740794564, 1.6633436090857694, 0.7163084889217678},
    {0.3010404862748609, 0.11326137397968375, 0.5959287722392062, 0.17412404424035563, -0.8845114822183107, 0.10721359678603432, -0.17192433649786604, 0.9706842527916348, 1.6209951136019383, 0.13708543962611125, 0.9439525549041645, 1.3714713166566648, 0.2108646751807971, 0.6070116842322559, 0.06381663278346815, 0.6114130852635062, 1.466295769659179, 0.3064308637847296, 0.5432977622676364, -0.5709545135138129, 1.6016007489453543, 1.449554331000802, 0.6448399131479124, 0.40505021182083034, 0.4983871023592059, 0.18744505007335224, 0.06585294872093479, 0.3335529703305405, 0.7660055052034327, 1.9116240837018703, 0.5811076168977546, -0.31713466985545474},
    {1.1337861786994596, 1.664814880049181, 0.7213300168420574, 0.0012699864203601049, -0.5203692126227569, 0.6747446477385559, 0.8667051682492658, 0.9066357168449752, 0.15963630513319976, -0.015575446072103384, 1.3972532167461496, 1.9509981561306655, 0.23591789207022862, 1.2756738129653495, 0.5509766435085802, 1.4593971396325667, 0.6770004394204554, 1.538693394899864, 0.7309812724636624, 0.733858535111781, 1.7342082521405, 0.46285074010114613, 1.5911756334745237, 0.06941115580427328, 1.5693092159857613, 0.7038533033066878, 0.7694319242708698, 0.27876436454689096, 0.9676452674014507, 1.095510603629703, 2.000097425236233, 0.9800930220155571},
    {1.50164799019512, 1.2955392845850804, 2.0214205328116037, -0.37787018037982395, -0.16302332747419923, 0.13286709708726396, 0.1678260908193575, 1.19849544872843, 0.49597119057495026, -0.08494036444388345, 0.04028309925100469, 1.877534479404287, 1.9963156613422355, 1.416580302922985, -1.0528515656572763, 1.2011157268749717, -0.11325198448833489, 0.8448396105084255, 0.7018636314313939, -0.43508830711335467, 1.0035016657532658, 0.8299879181211396, 0.47091522541420394, 0.10816143982705562, 1.5235072919751886, 1.7061077439949859, 0.2140878775002683, 0.9106949852723875, 1.0087950345831864, 0.26346812018196997, 0.316195314189057, 0.32551977461779735},
    {1.099287619365012, 1.5130957069196216, 1.873680712247156, -0.3156443042913878, 0.39168589757385874, 0.686150939291122, -0.17622751454926167, -0.021242588250477597, 0.87699408950017, 0.39012190688339754, -0.2467097075403141, 1.0843756492027823, 1.0797449302220028, 0.9732717747499628, -0.05264487785712939, 0.7408863643123066, 0.8367297498882749, 1.2744090736313383, 0.7420242400640461, 0.07702773802878266, 0.7273896046147411, 0.18894256517128952, -0.07527669337624023, 0.8299080081047125, 1.1082559291092398, 0.1781501431589663, 0.6966988200887815, 0.7036448453160181, 1.4732105587744104, 1.004403108648155, 1.1407284914809748, 0.4441566396225045},
    {1.3378248206074, 0.7582416757933588, 0.7861909872466375, 0.2937775953077615, -0.31778680110472834, 0.6755033691049515, -0.8082363300030819, 1.1722020973234046, 0.15052803119392363, 1.0780086194897085, 1.4261464293252404, 1.8028037552771128, 1.5629710501076635, 0.3537139548836528, 0.44653004564712684, 0.5593005390968944, 0.35929536823125, 1.4258957868200592, -1.1276380833292772, 0.7397349491644191, 1.5293130505013255, 0.8187464254977023, 1.443650224058632, 0.3568671947313862, 0.5923508822336044, 1.2967454602578947, 0.7104020380312112, 0.41918460946620784, 0.23944354229724557, 0.46612277659933493, 1.6825617865045321, 0.32019011756442856},
    {1.4284269530827822, 0.9549265368155282, 1.3691471308673182, 0.42911854111199965, 0.46228966870720867, 1.3446596231938217, -0.8685742760802004, 0.37449948051079496, 1.8109261199551296, 1.7561940629470396, 0.10603059871329618, 1.3027972097606526, 0.4159859395527191, 0.5367105650720317, -0.09489599860183587, -0.049323977530685396, 1.544346512063912, 0.9855153494299064, -0.7036066605080653, -0.42811722851776135, 1.724625982336375, 1.300604461664773, -0.1495391525544998, 0.8881555939273085, 0.7184753285643114, 1.9675166802593471, 0.7002959047268793, 1.5508030433966593, 1.3642738362893048, 0.22424568462110875, 1.871137541141964, -0.25145891828953015},
    {1.5724252203742821, 0.44101196721138547, 1.2561653101076435, 0.24608532139867909, 0.13255124592018494, 0.0532924654437622, 0.8305055287337219, 0.4510625321611076, 1.0147981909034542, 1.0923067278544187, 0.6502941515663697, 0.5519662114888392, 0.47131037934438524, 1.035897212846537, 0.33927969426176585, 1.2557803412080581, 0.46196602363691736, -0.17425097751046684, -0.4231429583768161, 0.4097023776012025, 0.29259595141095024, 1.4314042225740007, 0.3692611869240979, 1.0799845935811154, 1.8487163117529841, 1.8406770158137487, -0.7213663216792933, 0.3951388056216818, 1.4256280831744716, 0.19970137978799035, 1.090010417862299, 0.1957352839882702},
    {1.759787328660589, 0.7927325333701296, 1.1550766353169728, 0.08955861844331388, -0.2894818538640463, -0.05060243180549553, 0.9258843681391115, 1.4015322732481028, 1.6949391898688244, 1.4631486908942595, 1.4623676631518516, 1.5337061618913082, 0.3747660966948539, 0.12714454729260935, 0.29031769362485127, -0.11418335575187354, 0.12661751712246042, 0.9336600917515342, -0.01596698604240332, -0.10698212719590236, 0.08160542239282233, 0.20326251918104604, 0.15910990931687147, 0.844819042277468, 1.1158286233444161, 1.461067345877696, 0.4366867221858909, 1.4018670225070748, 1.6608473473601648, 0.38956744795941906, 0.08757627151848454, 0.9688780173542342},
    {0.08666496667665081, 0.1736677250940572, 0.9559617236941856, -0.797903144753771, -0.0067515864490733995, 0.9361281458895111, -0.47508156706796556, 1.198626153042424, 0.8536649938164017, 0.1986397859341257, 0.5900815989349798, 1.364959156876977, 1.0542691051804085, 0.18342982724732976, -0.45994505183371387, 1.2978703988515516, 0.9723777878085312, 0.5728878365887772, 0.010525601797576934, 1.1154204429513772, 1.6304115301361959, 1.454190401608069, 0.577831272352696, 0.5561814473183433, 2.010181369728559, 1.5148716012113352, 0.3893397942561837, 1.2878253436679752, 0.88229992056501, 1.6615982389131747, 1.4583767542038575, -0.05505678655885924},
    {0.06328424672981085, 1.2383347329457817, 0.20444421985877395, -0.5700658745423903, -0.8171974462924584, 0.292625508833897, -0.8889211371212448, 1.1677052155597816, 1.631565282371913, 0.658099010304689, 0.2581919412666701, 2.061612478356367, 0.302464171684306, 1.0512793152383915, 0.49655709833196293, 0.0348949309209121, -0.03449440751461416, 1.342026871624289, 0.12877373137579573, 1.2826144070808965, 1.6678554881935654, 0.8015088190150634, 0.45938202573947284, 0.5663433688101062, 1.337946695440977, 1.1070972554186111, -0.7320453153945821, 1.2117513672783455, 0.269489381515429, 0.8744302916370075, 0.9503234529447613, 1.3522795601590059},
    {0.7118294079058638, 1.1759384298937008, 1.511589387570863, -1.0271522929285242, 0.03587842639024859, 1.1737992003354298, -0.6791883588502233, 0.9059807712793709, 1.7374349182876838, 1.605650919794487, 0.49588621107192177, 0.9184103066122591, 1.5359836999838448, 1.2223221915884057, -0.40702913694832604, 1.241879778135957, 0.9970369515180734, 0.05147724291466811, -0.36024014781742375, -0.3153379004959166, 1.6560690748410634, 0.18052152576483682, -0.2501847847606168, -0.1410076236168728, 1.2422845699615803, 0.19122480276514972, 0.8773955778670363, 0.26675043762008427, 0.9799169931670075, 0.13719179855305846, 1.2754189451575415, 0.399651214465168},
    {1.7474937637398515, 1.5559561253446694, 0.7033762059007264, -0.5489826508050896, -0.9866769587325642, 1.713107332142619, 0.546829186928468, 1.4933229771195429, 1.5390818579295622, 1.0624932979586474, 0.3481889846680994, 1.697877952221116, 1.1507483118356074, 0.18900297927824766, 0.260715062329858, 0.3550174250878803, 1.351329034330908, 0.8581047914837986, 0.23881491137445654, 1.3403008606793065, 1.6240540955711813, 1.0614327666818317, -0.24739906725440947, 0.9938559625470442, 1.128097170731878, 1.5398818331690145, 0.5133767811745346, 1.6978736838818624, 1.2303801223329298, 0.12732345317151927, 1.2573642577199664, 0.09092037719990267},
    {1.666796779931577, 0.4190335987987644, 1.552047150706676, -0.4087779074225473, -0.6983887501471369, 1.18009816204822, -0.43737118517987766, 1.1157754189249316, 0.17932109056453385, -0.15779293479583117, 0.6584556030117867, 1.942833796097737, 1.0042565076551706, 0.5212548293898371, -0.5259591360756848, 0.3490159893342282, -0.10481769123346371, -0.1101460329178805, -0.9592710811034076, 1.3945321158919832, 0.9679655759108058, 0.9395530163754854, 1.338987530363126, 0.48536526299191174, 1.345125936142521, 0.48962737179364385, 0.47095494668879284, 1.0998113035203205, 1.171219198924839, 1.510599900288437, 0.6786589043481399, 1.700799907307945},
    {1.0774071805194414, 0.7634623038384548, 0.6978964457615859, -0.9683006823803548, -0.4365505562678968, -0.06132952546989189, -0.363649829509898, 1.5922795073517226, 0.39787491073631, 1.0994188418534534, 1.2267210686904464, 1.9831711828388725, 1.1683528037944508, 0.8928410926462386, 0.006314065100459448, 1.196449267059592, 0.4233061888729042, 1.1862785924189314, -0.17441465316984042, 0.3815839266764964, 0.9435527309321345, 0.2796046763801563, 0.8406819532042533, 0.009533095400146246, 1.204838751169988, 0.5376497834312176, 1.2102955165701619, 0.7345668507787266, 0.520977401415674, 1.5524923313265393, 2.081217070587105, 1.1578683217863288},
    {1.6429509301597336, 1.0608171395467945, 0.7476912318838651, 0.24474706646882058, -0.7200618771328484, 1.517727745668076, -0.04719837173906174, 0.5130544001944828, 1.5580427444602292, 1.6106505740724906, 0.08574332059934044, 0.3515157981757048, 1.742555440373599, 1.770113407491055, 0.2214201498235849, 1.090474428403499, 0.6040039587435875, 1.5619957954346713, -0.03511246910384434, -0.30815629264224087, 0.7286420935728365, -0.15061539577609642, 1.5467674951290262, 0.7137885130671656, 1.0902081759428897, 1.303318104741108, 0.6226948859137054, 1.6095765458042994, 0.2590811731438904, 0.44817459764572787, 1.057881834354579, 1.3146985167077834},
    {1.9761057324383189, 0.1934619705954361, 1.4082521279855198, 0.6407729115901306, 0.226263681011069, 0.5086530151126336, -0.4446486340905378, 0.10330704401946092, 0.4091732864542786, 1.2361644597690153, 0.44731783635152556, 1.460275627478962, 1.5792043601638435, 0.5432752075471149, 0.4748619988351868, 1.1292429599051401, 0.15185693275472217, 1.3050170596004236, 0.48081761257604677, 1.0048741831069208, 1.7468898479244217, -0.33010001180424114, 0.21990475354962974, 0.8855903945510811, 0.397743128078834, 0.42412922189406915, -0.050433453206466236, -0.04571811868663428, 1.1857608133371964, 0.7425030929713617, 1.8853472384045646, 0.776870281572979},
    {1.4192258259621322, 1.191035229171188, 1.9230669690279367, -0.5309178861190057, -0.7893326638358388, 0.7965997826179951, 0.8266971366696616, 1.8554571993549582, 0.16019594586895577, 0.9662766448613029, 0.441309446579955, 0.35931223109588123, 1.1670433460557856, 1.6688053087976944, -0.8425225546746156, 0.6427250611944506, 0.719550540782914, 0.1689208119306768, 0.21415268870152465, 0.4103856321195938, 1.3328992367930657, 0.4128814049274651, 0.5398211681082, 1.6974901514687484, 1.783086640139647, 0.4022206680256865, 1.0926365120677775, 1.6873086898342686, 1.084476594318428, 0.14174338590631894, 1.0341780566556151, 0.7166361003391493},
    {0.8382773516039443, 0.8788585663306632, 1.926560295843368, 0.7855193906980444, 0.0010895044300625568, 1.0246816509978347, 0.14670436158704053, 1.234487164124708, 0.6320259845340556, 0.6050191558009055, 0.32619936003064876, 1.5924573189598092, 0.5981761752950735, 0.9169627923129047, 0.760116439218352, 1.0175375203420116, 1.660979093153157, 0.40864323459763136, -0.10203388203365324, 0.8692007933818933, 1.0363923181097108, 0.9337906063879302, 0.592049233520996, 0.9623507122732102, 1.4298904706944413, 1.1653833881450997, -0.2173556785150429, 1.702186060782624, 0.39527565419181854, 2.072714912832615, 2.125753947441846, -0.061176063382065826},
    {1.5252169017465094, 0.6878572299853615, 1.3883846964307234, -0.8180822183801594, -0.43772512579261147, 1.024252750359295, 0.825085193339505, 0.713228513919243, 1.638953458467339, 0.6739222299550982, 1.2718569779155906, 1.887857535388719, 1.3701894295325445, 1.9658082200056002, 0.4906906666051438, -0.37625378148837746, 1.4813175634287292, 0.8456933964782216, -0.6991242473568986, 0.307893128369501, 1.6842921882160218, 0.8111824946510494, 0.11978339158997921, 0.6639263377785524, 1.1040125064031374, 0.36967602710496034, 0.5903672869565182, 0.4549671078241305, 1.5160050765923223, 1.5131164957666998, 1.0827315683292063, 0.5640229305870931},
    {1.7035234126407228, 1.0804871340280802, 0.8499816163931597, -1.0868849179375906, 0.5463089937972653, 0.8066414628038243, 0.49337553496150555, 0.521828188960421, 0.42440152319928254, 1.5160761871982995, 1.0079744430716948, 0.3472118133660787, 1.2583639900578407, 0.941739481432213, 0.7360892889558, -0.37559821839306207, -0.22735528930284205, 1.009511061103609, -0.3845287655074147, 1.1424832161151586, 1.8260990964479618, 0.5937850697593843, 0.7852666763732497, 1.5439825403410943, 1.0976726598404798, 1.6755619684962035, 1.1218998446762432, 0.39551454544012665, 1.1566544265089709, 0.7859515105104554, 1.1258773047453383, 1.2817196475317172},
    {0.5535860952526561, 1.3720584088497132, 1.0630110102558226, -0.3570984392139691, 0.3329253283510396, -0.004099465481558872, 0.5350790902323301, 1.2090360417900445, 0.8455302226166863, 1.525736377020783, 0.26799730597794935, 0.5437863903531263, 0.5266348344610638, 0.6914308015094028, 0.6886611903785755, 0.9994569882782685, 1.3400206400803325, 1.4482041075676937, -0.06818092587580118, -0.5253966424858777, 1.280178138137576, 0.8075198142115602, 1.5146868482301339, 0.6446004812336255, 0.6626744339474313, 1.6958648697826668, -0.2537202188562435, 0.43284711862315517, 0.09857811960085389, 1.6854790759400824, 0.5423991616352056, 0.5499125140359765},
    {0.6852971061731299, 0.5456198738811715, 1.5118708055617232, 0.7413428717261533, -0.8005688738051238, 1.274882206794139, 0.3595574483858651, -0.0454560696862228, 1.6408390484675648, -0.1696376607465763, 0.9717197839952832, 1.5117404750262413, 0.5506042390496154, 1.8652155306332523, -1.0068880641738958, 0.417423014211642, 1.3413680242898567, 0.7260424458800273, -0.7000450195591152, 0.4519995896306099, 1.031309222898348, 1.5884994681424967, 0.707909803143005, 0.2470068568264584, 2.0670758603370896, 1.8763258388810826, -0.10733613867003786, 0.3423643534185793, 1.4080075599892894, 1.1237508719206224, 2.03006083554663, 0.09370524968098626},
    {0.9099604325910263, 0.5568959761621495, 1.0298671479480461, 0.4173131691424772, 0.22350363452571267, 1.591825345734377, -0.31635946101030465, 0.6277950601516566, 1.187429638260933, 1.481679002010187, 0.5436905654523467, 1.5683232820145443, 0.4129856024859657, 1.4449605874672935, -0.39275398591270544, 0.29907234030743235, 1.0272259629127138, 1.5349589283762088, 0.6071413278250279, -0.11182307169715797, 0.5292936103367699, -0.06198595906886871, 0.47789474366445533, 1.1918588881119243, 1.1638103765212091, 0.7623870069119999, -0.6702760713293316, 1.1040593136568613, 1.4086045453538067, 1.5413749830760681, 0.9637214584591443, 1.1417304875214744},
    {0.35228245500007743, -0.18274318555658217, 1.2676126050575747, -0.11525709511982468, -1.0739593754079575, 0.3654440639732786, 1.0515505325874586, 0.9638128074949205, 1.6237451658434179, 1.5168333266829521, 0.3446512882949463, 0.9647876475099981, 0.24699144824471364, 1.5111487816837479, -0.7738205276332817, 1.003796852426683, 0.9349540429820903, 1.4014237497209605, -0.969234214349372, 0.2547408334258371, 0.8739233396892483, 1.3769428445350682, 0.7670658070752051, 1.1123346356721786, 1.2330449869114952, 1.2199316495640244, -0.5919100182890582, 0.5581041232286902, 0.4504182334518507, 0.4774937255604308, 1.1758338644390802, -0.11645581573612385},
    {1.5240004199886996, 1.122425062971058, 0.18878723848259366, -0.6944668344474708, 0.35535755711626515, 0.9837891848001334, -0.07595121893036819, 1.5592607265859777, 1.5383274352451188, 0.8545035027945422, 1.0913860120329624, 2.0314949951137886, 1.1334054887552065, 1.103724655979279, -0.6795116887130264, 0.2955919536771946, 1.2378345697160025, 0.5138990542741748, -0.19456098589042314, 1.0555670251351519, 1.5163940744252709, 1.1625833626266748, 0.9511429586333648, 1.4315522127651774, 0.8045530299413207, 1.8259956333633314, -0.7917067825432812, 1.720514249210763, 0.6008723675105905, 1.7035334854953912, 0.4576601792855644, 0.0635130560314585},
    {1.5642309781590118, 0.13578206901955608, 0.9560511509439845, 0.8264891023887259, -0.19512394068976785, 1.4435434754121341, 0.15908522100242725, 0.638744670817857, 0.32104790572366304, 0.21319401480279807, 0.5131237372925754, 1.4011646366374997, 0.23621524506415736, 1.613503160673161, 0.2055663973508496, 1.4215484099706333, 0.2867522379748261, 0.544789103303163, 0.1655747368960142, -0.06961276865225811, 1.5495404449953443, -0.34279334856371213, 0.3481126161894148, 1.0494077440470873, 1.2671096122322658, 1.2895350635853167, -0.06278457765870947, 1.145548852765595, 0.8742265873548238, 1.891773554456832, 1.9728281539266888, 0.7229813592870034},
    {1.2420808551513258, 0.2476109411274245, 0.48858441019407745, 0.5722079027390602, -0.014837942636288955, 1.3856772213778288, -0.015126540288486121, 1.6457532786247222, 0.5724607987916042, 1.0902096561454315, 0.7798171251851129, 1.112108617716204, 1.6667966728059997, 0.7633455290329516, -0.30480765733514115, 0.32015025018442056, -0.20441974467074747, 0.46589121264708994, 0.3839739916559878, 1.2706076215471833, 1.607908802334338, 1.0081134808575698, 0.7725571926129416, -0.09852437920175461, 0.20146346382363775, 0.2985748118649109, 0.7681278815620607, 1.7160974228445747, 2.07589452930746, 1.6865814519188094, 1.1162498059126325, 0.03840867478486582},
    {1.181903770634982, 0.47920857071987644, 1.52298020548283, 0.3461152450697852, -0.16768388558528133, 1.595863683032289, 0.6703337643853868, 1.7237949724381192, 0.7492548093186945, 0.7208265069663177, 0.9430670682264666, 0.7005799970497245, 1.823915994740636, 0.7448438163087947, -0.323860051235258, 0.02541716391454935, 1.421331252995495, 0.09427359557676, 0.26678206953885153, 0.2423184438292371, 0.7969904918249259, 1.399542259198885, 0.5638423212893374, -0.1134136900774895, 1.6714642217327342, 0.43470545957733814, 0.20228911688063198, 1.676827799998814, 0.4958988624220624, 1.5025310828683076, 1.6029303971941193, 0.15347919000687713},
    {1.2536322965406608, 0.9275441127387153, 0.5978961691750052, -0.21879789484719067, -0.7852078250058205, 1.0029046710037335, 0.5638128203895699, 1.3965153403035415, 1.3856628849009451, 1.0302311205992696, 1.2857610493646554, 1.9619114278125929, 1.7140015016820196, 0.2300624781662943, 0.7677780177872481, 0.4666581961510873, -0.2434150502689561, 0.0735102730024993, 0.43075592229252957, -0.3103402501016211, 1.7258405086314348, 1.2509089178199264, 1.341838390686858, -0.2022254176653559, 1.0736729082836713, 0.9715347367676965, 0.10256391020376787, -0.07213930778273414, 2.057684668336411, 1.685523294920543, 0.17908819698993234, 1.356430083694422},
    {1.8576768274785986, 0.8103161742771176, 1.1888375553722699, 0.0036305273057810937, 0.29208614891123774, 1.3719420947647707, -0.6187486501641093, 0.8779460055441085, 1.420108868920352, 0.8301252431549431, 0.590882352468116, 0.2574770338049762, 2.0296382805095683, 0.23408617460130263, -0.9570298327740538, 1.0464211937030696, -0.3281997774402418, 1.2885839868452016, -0.4553376497714503, 1.1892907151870045, 1.5730302026544496, 1.503215926834642, 1.4886085356279628, 1.1529482679117125, 0.8063106719325346, 1.1914454044944618, 0.7815335746414294, 1.1790321878220595, 0.5011741403081347, 1.769953387800508, 1.1892900705574627, 0.119655157178125},
    {1.1497976842158582, -0.04312106106434743, 1.8549575142569783, 0.08419368668488608, 0.47671790394522995, 1.1470108463188382, 0.4405728018353509, 1.119510640130843, 1.7039344108675776, 1.3320856264788377, 1.0309981140775721, 0.4625870780939504, 0.6513506944085861, 1.775007440466468, 0.6416151181119567, 1.4391101953063414, 0.991752603647787, 0.46018763038240806, 0.387274627202251, 0.508323815611121, 1.8598607374220573, 0.6624750393146497, 1.0979814232839693, 0.9608906054200163, 0.36988147968633045, 0.5147389167312101, 0.5471061009003225, 1.4057004759553149, 1.0799426240138998, 0.9309202610396186, 1.2323515694078027, 1.5952704607858956},
    {-0.003003418558012762, 0.6810545380988411, 1.1530616357454517, 0.5977791530806625, -0.9911104388916693, 0.8696340847374158, 0.8463288988131311, 1.688341551949908, 0.08959820938988218, 1.7988716750550084, 1.195643677728326, 1.155919127125246, 1.4558185561758488, 0.9484809911826027, 0.029149130100117382, 0.4708613510934234, 0.9714431791195078, 0.2903696483764755, -0.5868225026820882, -0.04845533656100578, 0.39664733408464015, 1.0461360891745184, 0.2259304450785878, 1.631995869685254, 0.12415611607753436, 1.2889621839547218, 0.8658303737536793, 0.37000070539544244, 0.7777908876520061, 0.5428517942158276, 1.5701055036414, 1.2042302826710378},
    {0.21595785937464623, 0.8232909755251632, 1.410340739472093, 0.2812542365145303, -0.8547822202645589, 0.9660484111498053, -0.33927373567902025, 0.15287294667517137, 1.2519355869816136, -0.03498090018302761, -0.27772678262356204, 1.6965237216453106, 0.7267446968119906, 0.9878247767808047, -1.0651814544190987, -0.4395910090722179, 1.1995915336183203, -0.07753885817012851, -1.1528572610688104, 0.9513335600092652, 1.4676518458550518, 1.000691694317257, 1.056662334471436, 1.1579657377942105, 1.2442420779030299, 0.9622343282255782, -0.4656143612798153, 1.2892487426992911, 0.5677224221931453, 1.12284167385479, 1.57692454649275, 0.9499034081267184},
    {0.7335696066074313, 1.6787748702114749, 1.3076250763556632, -0.6311857829502767, 0.3868756748427602, 1.7898108660542325, 0.27000193193302435, 1.0353458357342986, 1.5851204927936038, 1.2711692624053117, 1.0988648611665979, 0.41334117937063464, 1.7139434253264074, 1.5746880603474886, -0.9858231694099403, 0.4619820770559723, 1.1049044387705589, 0.34870454762469255, 0.2981879943507456, 0.01213743893115355, 2.0253270650264517, 0.48770236264631445, 0.7348444474099879, 1.4552569957832966, 0.9884786889642153, 1.904168883752905, -0.45507093347805205, 0.062382650453461724, 0.6567042214414981, 0.7453742676459918, 1.1644415179858068, 0.16472812867556322},
    {0.6336351823620511, 0.15494456662251685, 1.8305999198834544, -0.16687658456642, 0.4580328394544596, 0.11916050558143242, -0.6256160704645661, 1.3104018381064784, 0.2224563534905798, 0.3925212072150169, 1.3535223581951423, 1.8969403094216999, 1.9115066010181683, 1.098904642071506, -0.7359903544656273, 1.014831702028672, -0.04512267885817983, 1.3915948477922733, 0.6225519110668819, 1.2249302255544277, 1.725396539389479, 1.0827879182642308, 0.9551938766955235, 1.319275650648397, 0.9095630759206482, 1.6210388792188422, 0.6621632886688814, 1.3756685166334366, 1.9821279378386552, 1.5333963385223222, 2.1145970178240057, 0.8562089978216842},
    {1.1134205608921042, 0.5087487392876693, 1.8381037881271967, -0.026542978072504893, -0.10692970649568528, 1.7247815973636924, -0.8570009927967883, 1.1060801714579704, 1.2209648265674995, 1.188937220100466, 0.30239880862850493, 1.3990969566152123, 1.9678594440379016, 1.9383454154605972, -0.336666573564709, 1.4524828111111119, 1.3538028617930786, 0.5943187013504532, -0.007150918994320376, 0.06475198793466268, 1.2804236935979727, 0.3547390025175557, 0.4968342193000711, 1.0016548647197179, 1.9780744111868118, 1.3758474554450688, 0.23387964638572972, 0.9471476319199996, 0.7961689694022637, 1.094496382778885, 0.7898373121995926, 0.1481582886335792},
    {0.6933608448824514, 0.4358466879603059, 0.6510784131813084, -0.610342801291625, -0.06092972383577335, 0.4316456439154191, -0.10982597739822836, 1.2509839691650653, 0.7662863017872986, 1.0069744519381199, 0.027625476503342378, 2.045815125711394, 1.0595463409656831, 0.6655669764267537, -0.4440115956763799, 1.5337616255645006, 1.2231445457383454, 1.3371296864876536, 0.03001256648844879, 0.6297175623176373, 1.8526386010333662, 0.8199953978758711, 0.323243121775977, 1.343399318816441, 0.9042772309005243, 1.5680611022397921, 0.46402014428126326, 0.7130113311062943, 2.0381449559604254, 1.8112957749298502, 1.7583173964649252, -0.0969100089004423},
    {1.8528405791508977, -0.010787732204738939, 0.5896332332865968, -0.005395775494771166, -0.896588483422446, 0.5552883324619572, -0.8333706580823044, 0.050317706724629395, 1.8287007482990612, 0.7218700594423082, 1.398859242671523, 0.985418731273351, 0.7381264319415718, 1.5184922675806751, 0.6643063308997045, 0.3575355488240732, 0.7755519746932963, 1.309357068540132, -0.7815472517516573, 0.3736976997655248, 0.5263167432863822, 0.5265572239259037, 0.00648964500669519, 0.24553147354765129, 1.941540504950622, 0.30761306450330334, 0.7269065134665216, 0.3359018154135394, 0.18145877686593584, 1.9019352849087678, 0.6044895000410573, 0.38434209412778225},
    {0.3501897144198935, 0.487612706924972, 0.5678328689800158, -0.7137545289625803, -0.9896424586620988, -0.06276489445238466, -0.008514723415526337, 1.7347205753031099, 1.0561825469074106, 0.9290922206955703, 0.37550219773899973, 0.9938120124230961, 1.534026237336336, 0.6609598542194779, -0.9029778731032388, 1.2156894935143203, -0.10184752475051943, 0.3451842808165537, -0.6315805731444265, 1.057483159910189, 0.5370542562636539, 0.9387411190569063, 0.28784758469647503, 1.5244855323533584, 1.865313329327278, 0.22231757062849336, -0.11341670709022901, 1.0906089861817498, 2.0755377270366706, 1.5848718005907603, 1.955115090493217, 1.164952012180624},
    {0.30289828263099106, 0.8832857267397554, 0.3338365903488466, 0.6015621141290051, -0.08619208234809876, 0.014840038165491646, 0.006444719066661379, 0.38568663665780983, 1.2627845560300335, 1.0785547072615826, 0.9726298480421827, 0.948105790260016, 0.7482102016737668, 0.3991573460735853, -0.20347963638710717, 0.20548767037332524, 1.2986249632973978, -0.12661189271753928, -0.5363533337788889, 1.0055329775094568, 0.9475678670450731, 1.0997710485013292, 1.5793221824500054, 1.4458299688890777, 0.6520250267128517, 0.18989946965400947, -0.0843281149177053, 0.38397790539383764, 1.4942647067685617, 1.3692381272480791, 1.8521690371654687, 1.3344216428906974},
    {0.07484375709874767, 1.5912052999712714, 0.6624334074099995, -0.20815447272542636, -0.1913523565771303, 1.6456015267276016, -0.835449164882441, 1.5607605425622049, 0.37695332563035544, -0.10384380300501747, 1.1602364332632424, 1.9078977270403736, 0.7723577038409342, 0.8792841597884264, -0.3867613727630284, -0.41511752189559903, -0.03288051686943483, 1.1366936081498957, -0.9338338301564796, 1.3214494414240094, 1.71947576960044, 0.5266916498815374, 1.0924138108378556, 0.010445213563143268, 1.2321080398805204, 1.2467197121248261, 0.6067380130583403, 1.3572457578866777, 0.7956021395050561, 1.6317423734406287, 1.602319746766888, 0.4929998071812893}
};

static const float b2[32] = {1.2563083678416873, 0.8997011113333214, 1.4240258380984845, -0.24263772165965933, -0.27552801915669023, 1.123838450153499, 0.1622913109466102, 1.0886627343321498, 1.2387857460592693, 1.056904345424011, 0.7707100772096158, 1.471338987946645, 1.4242136508949963, 1.287446495062847, -0.2544306229339028, 0.6243453549729217, 0.8488642218076702, 0.8928061434182489, -0.2362028296694207, 0.4362037760061946, 1.4873514610566756, 0.794861786758675, 0.7900383699071297, 0.8924567033899445, 1.4761413587052614, 1.3628291922215325, 0.3015374406592583, 1.1144824664635642, 1.5132772765132354, 1.33411423930251, 1.4709658907596395, 0.9204246626206408};

static const float w3[32][16] = {
    {2.271718607752904, 1.4073772466060688, 0.576185202450143, 0.672860331270537, 0.7546781045640276, -0.6918836778809592, 1.286337612655385, 1.4858199884030945, 1.8192903097442883, 0.024959605492361862, -1.0206360145739157, 2.147283770613998, 0.23860503851549067, -0.06586574012579274, 0.5232338118519171, 0.3195631690380138},
    {0.9230241084934723, 1.2970691512869466, 0.5654807561332619, 0.28109320256498116, 0.5368674232706394, 0.45952364603758, 0.34374104902730573, 1.3077727716742575, 1.3255191169015128, 0.9648888343591483, 0.45495886009501574, 1.5544843816618128, -0.5801398367429406, -0.5430462913730582, -0.589393137243522, 0.8763451037389737},
    {1.2915965291039395, 1.7788590486105513, 0.21883638935128719, 0.8765444451453035, -0.707117242692004, 0.22654505286573834, 1.4318201302326092, 1.0884530764159384, 0.9639438094422212, -0.4065479470253996, -0.794005748433093, 1.7105844665579535, 0.16854965727899854, -1.039474609837764, -0.662031640087504, -0.9081557994072442},
    {0.3878446767388885, -0.37557006213545224, 0.2697673604520036, -0.6404542367169107, 0.2858391912698951, -0.20106046583681494, -0.24871303923664947, -0.9381119921134241, -0.7533079897667263, -0.11333171460621713, -0.7178300227999206, 0.6491775804944199, -0.8870050189767762, -0.0036842530430204984, -0.6402946202578365, 0.6490515600691227},
    {-0.6050075423635557, -0.3305070806344105, 0.6299054748047176, -0.7643937418324653, -0.0751021458013701, -0.8858836324367211, 0.31344841653027666, 0.030578719000467137, 0.20207285665562458, -0.4838550946666967, 0.12479198460901722, -0.14584373694103112, 0.7176126735004474, -0.0027704485348474623, -0.1056421712977434, -0.06081268895359898},
    {1.700617110891181, 1.3777288499961702, -0.05473186924122973, 0.990157653097418, 0.8917801215483548, 0.7845658879136774, 1.663954227791702, 1.6038050910258321, 1.784485302858934, -0.5941798610259372, -0.4448763614654753, 0.4872904187716365, 0.682686342416889, 0.4526349065713903, 0.04925691489671646, 0.11271310459172022},
    {-0.18800873482498084, 0.38729078077687035, -0.32179779117241913, 0.24402869043563805, -1.0189144815247946, 0.34201073431568296, 0.9655013531517408, -0.21726383255836718, 0.6996135639505522, -0.7044273582844303, 0.9205300715322943, 0.7302223527464371, 0.7646120649589517, 0.6812235865848425, -0.7283834540444393, -0.21259689099370874},
    {1.041009561989248, 2.3817782676017254, -0.011828206562992842, 0.2777812839832718, 0.42898635092519793, -0.7936546593326815, 1.9313828109100304, 0.3467341361533898, 0.9350425968839028, -0.5325034613867148, 0.4466154678918167, 1.6329324387045352, -0.38508890783085775, -0.3109383006884196, -0.9016674902332549, -0.15272474345960899},
    {1.8956196166870465, 1.5005199296868585, 0.4657923234630163, 1.7419446057425834, 0.46446869974899774, -0.3244601456138342, 0.8493846838167157, 0.5406294827982066, 1.5137102309612946, 0.6647260035401749, 0.4656040500167272, 1.1985009083810851, -0.7036933831668151, -0.01526454251356294, -0.26863915574842845, -0.10650645240328058},
    {1.8144746236594338, 1.0365034700764597, -0.9725649640211792, 1.7373050943385913, -0.5464870779359454, -0.7834947196106029, 1.9642258178719767, 0.6189194747007415, 0.30900498650849756, 0.06703150454550677, 0.5608448188787735, 1.8666051221923778, 0.8156023258098345, 0.16580940645739653, -0.12326312369098355, 0.21242593034821436},
    {0.7512037009638991, 0.992768035831938, -0.4470204725776845, 1.3401168134422128, 0.17338994468576932, 0.015465808082128567, 0.20809872311326288, 1.714720561715722, 1.7411960001645215, -0.892113325966294, -0.9895389632561494, 0.5848190255033364, -0.3774461252104914, -0.7618385785231921, 0.31431399693229306, -1.0064048133292405},
    {2.480897488141576, 2.148890211763195, -0.3252676778557889, 1.4677384840855288, -0.889291049414104, -0.292816638963261, 0.7554057971893694, 1.8369329690658298, 0.8616943667020963, -0.6923976767987838, -0.9702810979023054, 0.5780290586543199, -0.17861550507448903, 0.5129730951603083, 0.6427223666491574, -0.8725196435234389},
    {2.2222483784858342, 1.6022007303466264, -0.29508220612011055, 0.5649956909065266, -0.8340272422655316, 0.3013846436646978, 1.6364568742883105, 1.9520032445672044, 1.0434555844602775, -0.5475927733708754, -0.5846892770230704, 0.40003618898692556, 0.5686947474491708, 0.5716931892285855, -1.0801673152877749, 0.19685258620831136},
    {1.4863652157031895, 1.9129636160501884, -0.861485562539044, 0.37418811070248237, 0.3818895363356098, 0.27045795754221114, 1.860257793635942, 1.0675670529784465, 1.0710491460911673, 0.9151702759642092, -0.5143569410286822, 2.0277249189794175, -0.9692426690042896, -0.9787695349505922, 0.23924381855060586, -0.4924754950321549},
    {-0.4230900539425284, 0.1970455298559439, -0.5104036800479304, -0.20095839949693278, 0.10271204022157755, -0.8426270457177661, -0.8263562143244556, 0.574129778251399, 0.9497935672173364, 0.6743277688538013, 0.5746904402085984, -0.102263182399298, -0.6906659327181931, 0.8855513909257111, -0.7303361976842712, 0.5427250826836388},
    {0.45074475953759974, 1.9660822818052464, -0.7631923025188374, 0.9173615634807099, 0.8460146285180666, -0.9035525572357072, 0.8091353399606762, 0.15728851152777246, 0.8908151814045961, -0.8845138724655864, 0.8225499518707678, 1.2537971546556856, 0.5270720467238814, 0.05174248881108186, -0.9269088352526533, -1.0342914015330693},
    {1.6349131360970028, 0.5007378043116647, -0.9696454500796068, 1.2747700794015384, -1.0037860427511345, 0.09900017350115203, 1.549127687845694, 1.7229330000626533, 1.798982088461574, 0.4581397563018283, 0.7582387670979619, 0.18138969594924825, 0.19933629435389386, -0.6150553547444556, 0.26419331500776716, 0.5504364442410798},
    {1.2922757497035904, 0.8928532523565059, -0.8511284305518717, -0.09728602964715413, 0.06621247985722077, 0.15062928241310203, 1.4068632491725621, 0.09901426952533507, 2.0959996276648734, -0.052777647642646454, -0.8609912685026869, 1.5512584871376536, 0.8119256718069273, 0.49552448516040254, -0.2288244962864492, 0.7379043185906763},
    {-0.23567932945795494, 0.17728496806679753, 0.6875178118604105, 0.5347764582593115, 0.7913422020036467, -0.1806689816727835, 0.42722896365161317, -0.03295794560464315, -0.18695308103470032, -0.5112030983367156, 0.18328321958484925, -0.341923560624059, 0.902170243160394, -0.4692935927919821, 0.6768481903120741, -0.16203018968405344},
    {0.09223263349183697, 1.4183723742469212, 0.7521802555051428, 1.4371719790865232, 0.7495458839166625, -0.9247938490568026, 1.5284739577303226, -0.06036358226083512, 0.36980073902835187, 0.47061419623619677, 0.8919718098403089, 0.6051289467415755, -0.5696220153181908, 0.25807450973919416, 0.3772675024128311, 0.809478155201337},
    {1.8076521123557434, 2.2409891069215715, -0.3456180404539114, 1.6405835378275095, -1.0663082867861355, 0.12814017844781947, 1.7236195041185245, 1.8518155507914755, 1.7526616725985271, -0.9147787639317999, -0.7661714047235241, 2.183705217188118, -0.20359270959349351, -0.9590171315346946, -0.5095323588254232, -0.530816527570251},
    {1.0587746532894433, 0.28378069208915446, -0.9638068066489299, 0.6654653141996666, -0.999576745729994, 0.390758967522659, 1.6615268960385132, 1.192286008515664, 0.709580662955119, 0.18091407221197991, 0.20742177066532425, 1.89703538409102, -0.5740767866375824, -0.11110744775352227, 0.4472319015606418, 0.31785109212931045},
    {2.4720691579996044, 0.49219276909127146, 0.3711423311121756, 0.6666568256496228, 0.7893492472045703, -0.11003336666494869, 0.7763530656501713, 0.4096632154461655, 0.21965639279803276, 0.23919643747010153, -0.17561726910882056, 1.4926570580810377, -0.256012465945435, 0.6938026575681048, 0.09214588720567836, 0.1459205732776181},
    {1.9109765447335065, 1.351612324488652, 0.5006348669929223, 0.014801158928684954, 0.44529950002675206, -1.0080342674274723, 0.937404425172776, 0.09923569583674872, 0.8933055721574013, -0.44276752432238353, -0.4769845971343501, 0.23192873005300546, 0.016542976315030558, -0.6610717799359928, 0.5887931605719928, -0.2574671205421946},
    {2.3288341497610294, 1.3579067716987072, -0.7006657134753566, 1.0605184836344137, -0.7421174050159227, -0.5870810090556069, 1.9404035948907483, 0.6354451432264188, 2.1328825624003755, 0.3302384400620507, -0.4743984248731554, 1.1968636894989493, -0.21858358629556932, -0.7927179824232672, 0.18676763919751155, -0.8326601689250145},
    {1.042414788730634, 1.6449824050766937, -0.6810569619691739, 0.15675864818688384, -0.3117229589897053, -0.8089386802238157, 1.3065825039495915, 1.5345777426516483, 1.2310915212272606, -0.28063017735757295, 0.5130262526784296, 1.2396410623353569, -0.6832559756200964, -0.6974393037104395, 0.3441893642003572, -0.6610851663592842},
    {0.8685920423762141, 0.3508899663459579, 0.402513294669649, 1.0230235141341673, 0.7053773733907168, -0.0786936101813141, 1.2276306023024104, -0.5072256641578629, 0.27203421114052606, -0.8931329715709311, 0.3724492128832792, -0.0030840352769352453, -0.47640690188553897, -0.791184405063407, 0.0746918479884473, 0.4087020724990057},
    {1.2559224410555268, 1.3021407695905378, 0.012542748131777711, 0.6836411275216229, 0.467101749368334, -0.14185875920833751, 0.7073924908686599, 0.47664032265317124, 0.8847863744820752, -0.4487313706795219, -0.7728444632086635, 1.9981745245514937, -0.9590156220339239, -0.9761024016388795, -0.8598917803680545, -0.10343302231021899},
    {2.0565765371493243, 1.5598493536833262, 0.1713624436052225, 0.9457614259620143, -0.8090199114420004, -0.3842375901560514, 1.6621336233904356, 1.493447475728382, 0.7780846011579532, -0.5391991000083197, -0.07756606670432478, 2.174798290324556, -0.26444002929797444, -0.9418867400831884, -0.7444139038554864, -0.36286639451854613},
    {2.2403780800665336, 1.5368329483441312, 0.50992690030374, 0.5946521684751824, -0.10346098281876714, 0.7643357005670482, 1.987083264674951, 1.5764901969122336, 1.6835748706510272, -0.7914947101275799, -0.34519687639199936, 1.1256381798460735, -0.07420736792938393, -0.24262546595967002, 0.7810693099951289, 0.18828256480874436},
    {2.155614091243841, 1.6536847763468407, -0.30291798071463866, 0.45295000639580585, -0.07378081271180555, -0.47901640949801555, 0.6047079807624178, 1.910309237857677, 0.39672472652120444, 0.6262781996299092, 0.359161366076042, 1.2727489948217086, -0.5173429678460424, -0.4655619478546816, -0.020195868130730807, -0.604367319540899},
    {1.5643489086763098, 0.730878046281527, -0.8943639037671482, 1.2118395274694536, 0.3842468088722777, 0.5104008340463193, 1.882626464719328, 0.6039715939327499, 0.4801399000040795, -0.684924042388888, 0.8027855734421077, 2.012428108795213, 0.2240234245881594, 0.10341016736750862, 0.7704488311410785, 0.7376720048917229}
};

static const float b3[16] = {1.210965256426911, 1.0596186863339976, -0.07239530508130114, 0.5280257127195197, -0.15594201050354192, -0.07808307085577591, 0.712438580269872, 0.6580700916227122, 0.8445028334497516, -0.03664646003033351, -0.11934220953210581, 0.8636974347132582, -0.12250260048671721, -0.09373219275447792, -0.16970095665256935, -0.061537757967284425};

static const float w4[16][12] = {
    {-1.5685769453430087, -0.9951948889201916, -0.7553136091314717, -0.7436309143339762, -0.8880375088369106, -0.7653080480144967, -0.8967135381667527, -1.6047066378903039, -0.8901037578088767, -1.621137405141412, -0.9187040583474049, -2.0727036932761074},
    {-1.2142515285785358, -1.839796180688291, -1.3059731743244727, -2.1112136410146527, -1.6973982964437986, -1.7394749271801464, -1.6046246206181467, -0.7931997397050419, -0.4446387250975787, -1.8076126768991496, -0.9619914808133205, -0.5234177118887142},
    {0.22725434470312178, -0.36905186185975847, -0.40901377394922594, -0.8340565020104794, 0.10522725612428786, 0.7749627868031209, 0.5667810930925068, 0.8369397164055742, -0.7557825110616538, 0.8923915723344801, 0.05665334689187158, 0.8153917781241011},
    {-1.5656695179208944, -1.5904660710106318, -1.2878650893040067, -0.8615467998406323, -1.30581872399662, -0.9842346385866543, -0.010926242483062782, -1.4515301138401746, -1.3547002530020176, -0.2552349106947768, -0.35812943716067785, -0.67826722198556},
    {0.43649870609234886, 0.6400918494935127, 0.022413584881697642, -0.2455991961498133, 0.7719552528196736, 0.8673541338231914, -0.9744708765103823, -0.7093854877055021, 0.5084909894612085, 0.6055624266682872, 0.11430066662923259, 0.11823575122837271},
    {0.7347437686609646, 0.518461720190268, -0.3573593104584227, -0.08394386254642695, 0.895193652991764, 0.5319888414361964, 0.4077485059690133, 0.8614843231021994, -0.010523339327164255, 0.2416109386468214, 0.5048265613067279, 0.3363510254560126},
    {-1.298983536257464, -1.686219689482051, -1.5625734087112089, -1.0168650080372086, -1.3161855924920083, -0.09409848331563812, -1.759050273793126, -1.3642456199025217, -1.5337518424748044, -0.47145797159792724, -1.5985871769686053, -0.5514351147612699},
    {0.10579958452630454, 0.0988544582925888, -1.2046397539080944, -0.46475492549542696, -0.30954955774402493, -1.6990467803829827, -1.3176113296094525, -1.5183191257389383, -1.8769312356841876, -0.6118349406349514, -0.6408033503571751, -1.8412435098467053},
    {-1.3736487968867745, -0.10187106143510984, -0.8567479571252803, -0.4213935628228991, -0.4301290895933941, -1.6266655555160807, -1.0741404053743644, -0.761625493666547, -1.3332834548528332, -1.6142745717673668, -1.6080774228803827, -0.722176421397085},
    {0.03308718537749985, -0.5417057770274859, 0.8750018487220602, -0.4517370111134508, -0.6502071280182402, 0.5278065142450576, -0.9350301468592056, -0.06315415354298218, -0.9812065939254178, 0.7372608459163376, -0.4895844641872835, -0.37304012006592163},
    {0.922146946358733, -0.7623493460924634, 0.22166390874167913, -0.48804939986899687, -0.05189943813235956, -0.5423236412521082, -0.5117431699247574, -0.6569394703535427, 0.46732313282123594, 0.7419639117341967, 0.09484209562154067, 0.2951021996549263},
    {-0.7175137860764816, -1.4473389697608987, -0.9042383335128303, -1.830899015743546, -1.6583483408113207, -0.9129802809381674, -0.7137667274961407, -0.3757507806896308, -0.6807586453298671, -0.8267971883789869, -1.426070506373224, -1.0865438875244358},
    {0.2568336003732924, 0.650839040671908, 0.5919896059382834, 0.8434525185927442, 0.6395083817207323, -0.09925165941907677, -0.5836351034655096, -0.4430919716006243, -0.06982504485550857, 0.5658541503974668, -0.23154833040461803, 0.48608220505746125},
    {-0.020381253776313748, -0.06611977600987741, -0.11253309836741225, 0.6524311251625262, 0.6224767315910832, -0.1350317763782587, -0.6719940660004504, 0.1593255758683908, -0.5989642198275019, 0.633695135141594, 0.9016926661467257, -0.019170663038601043},
    {0.8006173147415974, 0.022981052549838767, 0.012022841923415038, 0.13531619424330374, -0.9219388614467208, 0.8422811112047921, 0.8134284809360116, 0.5439519525414778, 0.7530392406874064, -0.03034838525078518, 0.6047308185333037, -0.6839949150545978},
    {0.5790179087006291, -0.08851408477744935, -0.2477283507656786, -0.9416446005765197, 0.3181595957162036, 0.8950817109788368, -0.10144033699710558, 0.08605425342984445, -1.0186204353606634, 0.2749581419242458, 0.9668121265887473, -0.6818528653960042}
};

static const float b4[12] = {-0.45145325279083454, -0.43546958820311615, -0.545491613318821, -0.6331471669662788, -0.47724173837365774, -0.3931771739938288, -0.5525226084681076, -0.46071168689333375, -0.5545436538572266, -0.5979817057782848, -0.3934338549515952, -0.565010075207596};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
