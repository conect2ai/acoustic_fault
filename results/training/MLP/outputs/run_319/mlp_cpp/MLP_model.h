#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.6432497438847581, 3.0216661078800313, 1.3061556053183188, 0.3430663980025478, 0.7868046879299323, -1.2971097285978432, -1.3411547063855622, 2.7211472024742487, -0.16475806897580503, -1.4327641991661326, -2.379686660776904, 2.5878290191209374, 0.2067928775236413, 1.363214482217201, -1.1234322916713562, -1.236176074882382, -2.0187798848659457, 1.3297758593386735, 1.1157532610407357, -1.8099286522464682, -2.584028785093534, -0.44193656223160965, 0.6290128746075314, 0.9900099132384975, 3.385074028578847, -0.0825784391349885, -1.209696005979674, -0.2257682672566655, -0.5357653638772979, 1.435633919509122, -1.6223145060327484, -2.207688830383509},
    {-0.7445951808229804, 2.7348775414091966, -1.3458053541151236, 0.7522882667141679, 1.8294209444732639, -1.6799574458174003, -1.4838493273311684, 2.393049834016626, -3.5680862661744372, -1.5999242332869692, -2.0060947304162795, 2.563692574404323, 0.8663380004499119, -0.9743010996196116, -2.187308198771792, -0.692986553365496, 0.762061426143609, 1.2736476389752776, 2.046651777513537, -1.198633734010622, -2.819925737251507, -2.2599879882101663, -3.3778200588641174, -2.918669582113476, 1.5975302157503037, 0.7363037411721012, -3.847329433844735, 1.1580372474004814, 0.5460067032352005, 1.4800420032854853, 1.1825138339695216, -2.5994683477564733},
    {-1.7927377122039196, 5.397961985544277, -1.2455052806698614, 1.2879493753268856, 4.557448675469343, -3.1586582312222227, -2.6470965966025832, 3.3076812205918773, -1.292538557260771, -1.2911680840654844, -1.4173727859012686, 2.540010162712683, 0.7510857092712506, -1.3313241897696633, -3.053599732854768, -3.430938942975742, -1.9684979098091324, 2.4099821956141594, 2.460300188567899, 0.0761185351552544, -0.08796461491309593, -2.191563068197064, -1.9217553317597078, -1.2758019004948835, 4.119571844815167, 3.2020269000637778, -1.9393126201817723, 0.1645386208881107, 3.754864792422455, 1.8301021495044438, 0.4598647515775262, -2.817451199088068},
    {-2.717470717837131, 7.144872943591702, -2.4974649800089987, -0.2204217450239462, 2.9325935431132115, -4.850747713942221, -3.02852163131823, 4.060893434878497, -2.526744599473984, -4.555031020026448, -4.282216152740845, 0.6318630290855941, -0.5321823298523316, -2.3732976428964374, -4.038925835160632, -4.122119465334954, -4.180422587770442, 3.513848091139028, 1.9311738943910317, 1.1550173308740794, -3.417269217974256, -3.3862284893790946, -3.6718410835378292, -2.6202393760819604, 2.0335323867954838, -3.06467348308611, -2.423821056067748, -0.5374928112807388, -0.520238119976409, 1.6527742974023791, 0.06440534076923599, -1.7007535405345318},
    {-3.060142550042908, 3.859463098408033, -2.8024699308569865, -2.6868318596437155, 2.895407429300923, -3.2713929582058583, -4.64283511856296, 5.316586868634233, -3.4909276471903663, -4.3040579885294505, -4.95913619584063, -0.12060486479749401, -1.2135056333384389, -2.9430340448362586, -4.301306969613957, -3.095461269193525, -4.348661192725204, 3.3838075330891817, 1.3885379791711066, -1.340462271625868, -3.888600601924132, -3.8884982173382276, -3.8923067608919077, -3.583139160144116, 0.6098743869989891, -1.3288789240477887, -4.6612677152059705, -2.1407370987160443, -0.9513938141914331, 0.7332380652028946, -2.926556031717215, -5.402431301583532},
    {-5.4817609934436735, 3.1330564693664806, -3.830194683694858, -2.678147316738647, 1.06989190025918, -6.919966388776979, -4.8696583344056945, 2.042330090392401, -3.1461255431407276, -3.7550359907697946, -4.584014383760192, -0.5140914192455835, -0.47313047555901355, -4.555082296655771, -3.839238543722923, -3.133776632922409, -3.9589437144296076, 0.8364776929354751, -0.20557482870470034, -0.0810672473356231, -3.520917768157201, -4.340603699191243, -2.9520790555877396, -1.3814608871650855, 1.890910609606989, -1.1908459476400683, -5.2472910292102, -0.13561488777981112, 1.1701667910499516, -0.45488004972161933, -1.606907474950688, -3.6135573381317596},
    {-5.2745880498621345, 2.7878679483852737, -4.215990950904696, -4.234241045326169, 0.7902584527159905, -4.011472609386209, -4.202316589817975, 0.6091757569525531, -3.7159674341476365, -5.317577153751555, -4.692061723822485, 1.0065417442702684, -0.0962994114669823, -4.926196033229046, -4.129892798833342, -1.5555669831406287, -3.637669720890603, 0.9800079549669272, -0.6992487467001238, -0.9105181285907538, -3.34417158618455, -2.6694801645995225, -4.48500810491015, -2.929384854823178, 0.7835921924836587, -0.6438244875985071, -3.0673779974276045, -1.4276654458046478, 0.8460227074635254, 0.5027552142875668, -2.018876816454639, -3.775760289584137},
    {-4.393570989738216, -1.0268792498745865, -2.9962458534812004, -1.5390207870499655, 1.3488344002050148, -4.8597027337507415, -5.426866496475069, 1.8169551422017483, -4.5234111207353065, -3.2463903253097017, -3.64148646079808, 1.0628676531036427, -0.6274037732391965, -3.8215653738640625, -3.2556275375184467, -4.183932522916977, -5.289757293570901, 1.7550241752166365, -0.09818164420992943, 0.15444208863825526, -3.2043963523357304, -5.051174114605877, -3.8815607848569, -3.5453389900064587, 0.5300414511799539, -1.3266945907101826, -5.651795282104971, -1.3063764234523019, 0.9217450628436384, -0.5705640335996645, -2.8971204949391463, -5.03343912495375},
    {-6.001294126773508, 2.521078055089757, -0.882979584639686, -1.7199931520921194, 1.1743918501008515, -5.0804614085277855, -4.481774842695336, 2.6789363511823354, -3.5563800974308433, -3.605459187153874, -2.902856369319429, 0.8511396856105633, -2.4712207153267913, -3.1833669793810295, -4.230584035373594, -3.2206565212154366, -3.3566771560240776, 1.1729029724743238, 1.2240580224470547, -0.4961174495362967, -5.666166597689657, -7.165323687535342, -4.47304487107993, -4.467449701188568, -0.13905253890751448, -2.924016382092601, -2.190527299996208, -0.48669400339623997, 0.6954419309412555, 0.43445176480174713, -2.8473904829359356, -3.6273919453312726},
    {-4.122577040335082, 4.1008627175536345, -3.351191731233783, -1.76764181995068, 1.488422497859132, -4.309013108065428, -6.677789093918772, 2.557768755546649, -5.607636527458793, -4.162138906382443, -5.00355336505476, -0.2488986884871048, -0.3126064800896562, -1.5387518145710535, -5.1645483898767415, -4.440192184545878, -4.383346128825446, 0.8213832592408802, 2.6926309807251902, -1.6927882443138338, -3.5180466008378994, -6.174008656155207, -4.41276361198648, -4.5545262109213525, 0.7725569685727055, -2.8951817165229854, -6.315504589553567, -0.4606896374833387, -0.022878039174350683, 1.189410905206734, -1.449655082748698, -4.140916396205012},
    {-5.277003446330286, 2.604590919410636, -4.573230318206643, -1.202292416310823, 1.2892121579906253, -2.830715436301262, -5.296410603259074, 3.4162350172852904, -6.213629631586243, -4.2768799785122775, -5.785184949503083, 0.3901919358422128, -1.750366500092966, -5.064781472445177, -3.453202546123622, -3.1212086037873, -5.873053084625075, -0.03938619749193999, -0.7068762431658644, -0.15379377477904393, -3.5221950377093685, -5.465253333301472, -7.204278327866458, -6.634012820926688, 1.1358392092492002, -3.1300269310527558, -5.834470995391955, -1.7580720586104008, -0.9855249127535629, -1.4177278549108479, 0.4622156843586799, -3.5731460708264606},
    {-1.0282425803323532, -0.16452454599529295, -4.185897266521136, -1.6839461611018198, -0.701266056912938, -4.472238244225787, -4.040832428953757, 1.8291559600979486, -5.529348853758549, -5.111709834305368, -5.01384034722418, -1.2906747411798836, -0.13867531412120956, -5.067242426553843, -3.2528563307493634, -1.6389804428966808, -3.370115250413342, 2.1354766124766758, -0.4339510414828317, -2.2923366474085225, -6.26715206409322, -3.045107115940814, -1.6086342797941346, -3.0056919268846367, -0.30829528858343336, -4.011080473320546, -3.9926640866846914, 0.10572752371871519, 1.458842927732943, 0.10732419666697646, 0.5917704887485279, -4.390016953202659},
    {-2.4024794022538023, 3.433662842513517, -2.351278697076203, 0.689567934902958, 1.6187413672237132, -4.289157062551189, -3.8667497097020993, 1.2019638119483649, -4.677584033025901, -4.45472558466768, -4.313482826877812, 0.5458582987940616, 0.9272292800706267, -3.8408182619896185, -5.684277917721993, -5.000096262933508, -2.6629814467973754, 0.20538425119941134, 0.5919566532269621, -2.5178501579952486, -2.478673560224169, -3.8278028466418803, -4.809515624576269, -4.272985647830805, 0.26916368174199273, -3.2061669194001947, -4.3347048146797045, -0.6791653997936986, 2.163137446531098, 1.4122485110499088, -1.2375102538275595, -3.14227562287566},
    {-1.2508541886984301, 2.3636069531341444, -2.1687733431868352, 0.12859414137723496, 1.2747209589671986, -3.426605753912761, -2.551370136144036, 1.9487360020258826, -5.378564826259857, -5.311088220804099, -4.198735313696987, 0.7666623670208458, 0.011438995349441969, -3.792068205501551, -5.190736446097041, -4.086577977772733, -3.8142119878274334, 0.3202396114801669, 0.008432204964449842, -1.3228182099609933, -2.6379620106072017, -4.125265362484842, -4.261267274887049, -5.405280991951081, -0.6963599555290217, -2.1633170610068126, -5.516906683818348, -1.6886235947485924, -0.35404792149034475, 0.7299415667881026, -0.29523859333115315, -2.991147817254615},
    {-3.749826781265945, 3.4763524318998438, -4.361988579440439, -1.552167094760966, 0.272506718454423, -4.657065635205726, -5.522801936224819, 4.044930701234497, -4.50757242705753, -4.429275025098907, -2.3686559097290703, 0.36367012047697744, -2.668588929781802, -1.5606915726683892, -2.9201723402573685, -4.377173686262868, -1.445564094917399, 0.3528535383500352, 0.7635528496005048, -0.9324204413400972, -4.130221189481373, -3.539620034210499, -4.373010099536105, -5.412981706210874, 0.30295348325088717, -4.0773422093162495, -4.698099079590369, -1.7769340637857782, 0.2653912554251405, 0.7561450305650913, -1.6354202652053185, -3.2079711667897786},
    {-3.3814895799104834, 3.5455701892356566, -3.8999963124471755, 0.8981964211087078, 2.1937669471015404, -3.638835423751808, -2.708631185971867, 3.674038942463186, -2.3352875287994124, -3.0905556958220575, -4.7522854837468165, 1.282600434810356, -1.1381812928682007, -5.375428954094854, -3.424779363724565, -3.4531340751220547, -4.366405331955416, 2.615731483148756, 0.17025118480435517, -0.0784130423074502, -3.9412110393568014, -5.277588394047202, -3.0861145347678582, -5.906022747699245, 1.159745398858474, -2.3213702743494435, -4.705131057725549, -1.0031894257723648, 1.0998447808153433, 1.6355433707380491, 1.2205434511525808, -4.503377599841068},
    {-3.513174573148357, 4.124110742614595, -2.4183571209028125, 1.20006380308189, 3.212304116167752, -3.6480283922388725, -4.513471714439232, 3.6326809325055183, -5.048760602647709, -2.66874085300777, -5.348193202408044, 1.7074556300629178, 0.582351326473548, -4.269603204626428, -5.136351272431242, -3.2666579008518655, -2.5846902623774217, 0.6170607927817331, 2.3427699981431407, 1.1525447171277605, -3.4962043618800402, -1.817108813764014, -1.8178172908545926, -3.335990180693758, 2.581012445072424, -1.6790832294709364, -2.636111085340495, 1.7683520511350475, 1.3122011712473158, 3.9396719919877783, 0.9542197237046403, -2.3050087144327494},
    {-1.8562955604319382, 4.4594591374449974, -3.6117904933188494, 1.510957522723758, 1.9796583765017681, -4.321269730341935, -2.1601088210759314, 4.653666229550651, -2.689448498446608, -2.293219115868648, -3.625951358456619, 2.1855446615212313, 1.5871868854855073, -2.880577143780168, -4.255282274297917, -3.955777445249988, -1.2590511784173188, 3.667483277125066, 1.66676287077147, 0.2416207886255162, -1.2980435179914263, -3.578581332000079, -2.0056375880657353, -2.2607390678317945, 2.2874368595268324, -1.4689428850529425, -1.5729512518119018, -0.5316095284288922, 0.7410697922527608, 3.8582638184648355, 2.393197157823047, -3.2495507902054506},
    {-3.982320765473598, 4.0385772535348705, -2.2124004165176947, 0.5656223582384775, 5.167413241715821, -4.788826826296669, -2.91103762276697, 3.4200153375487155, -1.3472592490791337, -3.567717435468869, -1.585460330960569, 1.3097753201308227, -1.0985052936124367, -2.5188388790752803, -3.8008494191891304, -2.1854735851269242, -1.4057762204746371, 1.4161649834610828, 2.390262257019041, 0.005729844941658133, -2.961151637566505, -1.0175962135162022, -2.588237758096562, -4.106755919031686, 4.010669549061844, -2.5741449722309153, -0.8320274297426373, 1.1675592213557702, 0.9115276427335861, 2.0873949413212696, -0.4991164829806157, -2.59755857951759},
    {-3.595360892266127, 4.679353342571181, -2.3356759863336882, -1.2503204605267217, 1.5251312523884106, -3.8268820696926986, -5.372476539342065, 5.4762633781534795, -4.072954925543447, -4.057320381316642, -5.311854444283837, 1.2373624175718647, -0.1881491270268233, -0.8629753540908571, -4.520814840512023, -3.2708044179316813, -2.477532663632678, 0.891512778752774, 1.0389521658975307, -1.511400263040976, -2.0664963403532886, -2.634183049655007, -3.2408274632400027, -4.64417654157125, 2.636629246664886, -2.562273760553377, -3.537507170446714, 0.14496727681682345, 0.5237206201376616, 3.239753638552057, 0.4069383143866232, -3.8489628143447985},
    {-2.3602442194450455, 5.600147366984537, -0.974277541564836, 0.46660840927886327, 4.5222317185473875, -2.9539315391678653, -4.7003360735954685, 5.465471090767345, -3.9222342075918637, -5.0472554971654535, -2.9898733183465223, 1.8032525783928461, -0.4505477689391707, -2.2204302864964, -5.689720431831196, -2.2821095119513144, -2.375790843302919, 2.904919915204335, 2.8080408617902477, 1.0355726148173094, -4.603554703542224, -2.526320429947053, -3.1988219970853793, -3.748462449813049, 0.20545959501710032, -0.9898264218510715, -4.076146987267824, 1.5588739013101622, 1.510350156140985, 2.302007925643658, 1.514296622589691, -2.3187452338565726},
    {0.17203360407829743, 4.95586402660633, -2.68336781450973, 0.9519080272839541, 3.093900148426303, -2.9452421201981034, -2.0310491543903058, 3.5615861262423048, -2.7307039441782277, -4.904358428592693, -3.2966264966731065, 3.1532805091327893, 1.4510181366022845, -2.495966272382944, -4.44791375035308, -3.954026884598585, 0.004245291832223615, 2.6316634294661423, 1.8226687736758598, -0.1006980683456048, -1.7939202833770385, -4.2432712210621135, -2.713091325724116, -3.0624010558447976, 2.086932213220363, -0.21170455423163118, -2.444951886407125, 0.4609645984193981, 1.5818116624383407, 3.0387695497838165, -0.5204383633494829, -2.307419085883924},
    {-3.577103231000042, 6.479320447568482, -1.2380835238939751, -1.7839489958669352, 4.842400201856961, -2.4161974420340093, -1.6363450361021001, 4.349094362079369, -3.6737134523096406, -2.0458896787206378, -4.082238894439529, 4.584921231723347, 2.079724404634319, -0.8706458421271902, -2.251845871916449, -3.297484544823792, -2.3060431154823235, 2.2302196069074367, 2.250194868311694, -1.1140328862536077, -2.7953878196527655, -0.10568617350738804, -1.0102201566083833, -1.7489506439199856, 2.938389068753923, -1.0992012469585384, -0.4264742239384676, -0.6899616265180571, 3.1063616883053777, 1.2857605763596482, -0.2926040223235566, 0.24718974226250096},
    {-1.8565820524583787, 3.7741906011456448, -3.843257802481583, -0.8632184309845222, 5.344670284302963, -2.525010084631354, -1.5257114495798716, 5.954351178664417, -4.350445558929947, -4.334984634879257, -1.9497829022880082, 4.36812352144937, 2.395157919775313, -2.332466700542868, -4.645176209761189, -4.581557994149439, -1.4932457179652276, 2.5608945825226197, 4.443959759179453, -0.19531666294722205, -0.49814040043664504, -1.7211987458601816, -2.123245117112022, -5.842459806256407, 2.522652910021618, -1.4630157854312669, -3.0405805501849956, -0.8182484312588864, 3.5753550494950566, 3.8765155697597575, 1.6131422124094696, -1.201638450380752},
    {-1.3444283776342751, 4.365846623380239, -1.0669172711932864, 0.6630816317981699, 3.0118113880496664, -5.142428336294533, -5.553385033104671, 4.375996019429354, -4.269974935607583, -4.834115705310476, -4.940399110977186, 2.546743054981077, 2.6378555777400385, -2.888708050624655, -3.2146999729024994, -3.804942163492201, -2.2438947288028803, 2.269244702653415, 2.527127193512516, -0.034203453146742745, -3.4953211644818656, -3.8076356418923583, -2.0189940718807398, -7.486288829352508, 1.1177543642733743, -1.688343353901062, -4.316727960015975, -0.2643025550384657, 2.673842771806746, 4.52694165121172, -0.38334072020184623, -2.69158610453153},
    {-1.4445067391548982, 4.3959267338581265, -2.1895766123613245, 1.7940437942595435, 1.1409206105569567, -2.2590581715374176, -3.679434748633525, 4.631179846797265, -4.500151390553934, -5.1288494861717915, -4.156286729578121, 1.6701319984250442, 2.7744112605393907, -3.5628074937974366, -3.552099486408688, -2.3672998184142284, -1.897234268840273, 1.4271484143144209, 3.3803299025564515, 0.444273003800476, -1.3875252332615176, -2.7574485251913576, -1.216564059988682, -4.169828001449863, 2.836824516429939, -2.552584909998934, -3.8789315200254326, 0.04269858919836517, 0.5061354880149448, 5.159604885320579, 0.3291806198946979, -3.5290044973488475},
    {-0.9152222239760739, 4.521857755271417, -0.8569998045003765, -1.2866406392292162, 3.575382564552778, -2.235716624971756, -4.1613086597792845, 5.405929772360639, -3.6490000033252907, -3.470748061031713, -4.614964025363159, 3.422340953458925, -1.3477016824417587, -3.93766374001046, -2.976468643265643, -4.252433703860508, -1.4489137316873892, 1.836257519794512, 2.9214392124814035, 0.10911029971178, -1.923442851581703, -2.8433181455450067, -2.528496167322205, -5.134442287403828, 4.305893564249632, -0.5302078288230765, -1.871020837921034, 1.203457970461121, 1.7680025271734725, 2.927376828416183, -1.4309642467197168, -1.8145405889447894},
    {-2.7813175969105908, 4.234545802563251, -2.5294391497813926, -0.9720085113743838, 2.139844609193644, -2.2360090649437865, -3.6659870966943138, 3.6200320303032467, -3.271950939153137, -5.3634955117038565, -3.0670377173621413, 3.7321083072928127, 0.5240821137939293, -4.2113279286037315, -4.284704225866902, -4.917249833387872, -2.2223210028663165, 3.0162485670708357, 3.558766659565409, -0.9965958399016498, -3.6767335935982977, -3.699897743609558, -3.7346822757044604, -3.7420987727755195, 3.514205272814322, -1.0966524538738704, -2.817028257852591, -0.540683154026703, 2.625905561238966, 1.8372173222168453, 2.1383567154257905, -1.5557846908306732},
    {-2.4285665474696043, 5.331950112658943, -0.9912788939677901, 1.576072220825116, 1.6630369482183935, -3.1667201513600713, -5.148919193163401, 2.7778859565996346, -3.338460464055724, -3.9503208281760416, -5.388804774876292, 0.9632834306662338, 1.664275253141406, -4.107710996257999, -4.510123432944954, -3.45020552620541, -2.916956366314646, 2.907990575846683, 0.8737138996183599, -2.198551044623046, -0.39725212552175926, -3.1417803064257157, -4.460237679692674, -4.4718901406699265, 2.2060296667054082, -2.389756754651407, -0.5803689168164529, -0.4307012986191801, 1.1212111252866919, 2.4115889219557873, -0.1687338287367833, -2.552464765009607},
    {0.3750392377125805, 4.98295438964762, -0.6505270055088995, 2.2460279674513104, 2.29199776113659, -2.839110109874978, -2.694205219691374, 4.5910537181669335, -6.571271297081361, -3.5736322114724235, -4.267768467909178, 0.4554901219502507, 0.5000244135922536, -2.5168766172405284, -0.7408139034820221, -5.252905646253325, -1.5072142076610726, 0.4755246662071784, 2.6817490603290497, -1.526500158654919, -3.486791132473075, -3.808469474201125, -2.9500283470337227, -3.769380188811697, 1.4849406763918214, -0.7086851426409411, -1.4999746125866547, -0.9237602507551774, 3.8578334276783, 2.888808901554348, 0.4108941660698848, -1.8983913168818556},
    {1.7667428212165996, -3.320227512737503, 0.09550705978075831, -2.2898320429845898, -1.4595682533918457, -2.9192011218674616, 2.4649990023174757, -1.7255520556725372, -1.0092776884397465, 0.06400750995874337, 0.7755779734258708, -1.5494463154776967, -0.660816454971844, 1.286826273361425, 1.1846765151082574, 0.006285125933936368, -1.8469087574592846, 1.812756281025245, -2.8025947960276762, -2.519908071995889, 1.217899125402775, 0.11027474590225848, 1.7739476025789926, -0.4530599274534992, -0.17818233311416193, -0.54896746528473, 0.010839113928892884, -0.19099881762553367, -1.0557881205702915, -0.2581976371966865, 0.5491288698793965, 0.06625905844534921},
    {-1.0682170761660894, -1.1250548581226407, -3.448214811021264, -0.7354765852642967, -1.1706641735821837, -2.304913503228616, -2.791776183262568, -1.3716310041780284, -2.7720004027590526, -2.5251842314765622, -0.9228943007695295, 0.24548949932370265, -0.7879289302046436, 0.6160727564627153, -1.5447044769667178, 0.32753575798014734, -1.5900565510521298, 0.619294574478752, -2.036081460099087, -2.9395658401925364, -1.3206179131318747, -1.7371085252247573, -1.5844198395550795, -1.2965675329563815, -1.0745313755873942, 0.06720760149651155, -2.3210723192417904, -3.5402418447092874, 0.9803907714731159, 0.11061407414664232, -1.1788862034718648, -0.35177186164048735},
    {-2.781992059783099, -2.0971996394291086, -0.20646122598061475, -4.693313618187807, -1.7958679125083659, -0.6763798403709729, -1.8406978360674247, -0.12174105582403687, -0.854505205351145, -0.7874940132520213, -1.1162690420599948, -2.95600326258833, -0.24757544288391412, -1.6779384586331358, -4.65604932368168, -1.706707402061683, -3.6827020229614513, -0.029393457385271295, -2.962278550422513, -2.827860964973666, -1.8068192591486953, -1.5546699467081382, -1.438258962986578, 0.5100663807191328, -0.4024589612813622, -0.7669184360211176, -0.4853677399840047, -2.4070038106024065, -2.7082546346476946, -1.2900938704078835, -1.6531057124532689, -3.1550062328956656},
    {-1.0359221066055135, -1.7210622407262968, -1.2511428981325874, -1.4130821951969033, -2.538983429568144, -1.1910221248852988, -2.785080057201592, -1.1873860951775554, -1.397759580092471, -2.2324621863571963, -1.3450124551100884, -2.196761938529024, -1.8536364754175638, -0.648510125940321, -2.5418528639423013, -1.118678367864732, -1.121866024206442, -0.39326356315656874, -1.664622554651345, -1.9917803100695606, -1.3574635521760983, -1.699529413306425, -1.6722962313371426, -1.2984634737255174, -2.6444743990753468, -1.8432121638883934, -1.3927434455383236, -2.3398323966827976, -1.6580702455042542, -0.5311633144129653, -0.5467003358364046, -2.10817374733157},
    {-0.8471659855582585, -1.0857062518736476, -1.6067069629905144, -3.769079612266985, -3.320826406123565, -1.864675026696387, -1.183246217513986, 2.5883117224954537, -1.111180546779396, -3.0586610425960736, -2.4187949120292163, 0.8076039455037721, -2.4894476775432723, -1.8337962938468735, -1.9146059163131564, -2.6847955099232523, -0.3570571189129361, 0.41720625452334015, -2.7099905002905786, -2.307081879174162, -1.539685446170372, -2.2588723204288708, -1.1990373037108844, -3.8039617921177, -0.7743459291442307, -1.0007494487660087, -0.5777757987686549, -1.2038875858518787, -1.7101682632534176, -0.4646954824835386, -0.8387403352643393, -2.275561819668904},
    {0.1811017453047515, -3.156461552412405, -0.23837651383250943, -4.166766473219942, -1.2315621462267126, -2.760304492423743, -0.3047113405040998, 1.6293168385879941, -0.8264767926102995, -2.4984834956318114, -3.6766756875569184, -0.6471325201141838, -3.7674649660948494, -2.8345327315992246, -2.2267890263768044, -3.044948102000841, -0.4652723229733047, -0.912590991579549, -2.7888657154701013, -2.9487607130754685, -2.5819643607628926, -3.042436676103478, -3.5449207185360905, 1.0061486714087111, -0.6165343550143522, 0.05931470928555835, -2.546236892933646, -1.453456635720815, -0.9529225091163751, -3.3980038502323002, -3.5359415421414373, -1.3699564364700272},
    {-3.208861698489586, -5.004385391101053, 0.2703011611433545, -2.138122792026214, -2.4956980407677714, -4.20234684317011, -2.3778519881551823, -0.5193091091820368, -0.14630400555957904, -2.1184467767750874, -0.8733330276780235, -1.9160796210153568, -2.618895496748268, -4.431798257039308, -2.1595242546201883, -1.5010064245216777, -3.7784657000518913, 0.39635143174001497, -4.920793191370765, -1.4192332788820339, -1.3865740552828454, -3.13300824527027, -2.0253014515227954, -2.821632061436025, -2.24713890803494, -0.5284251776723998, -1.4161686395281177, -2.264452203624172, -3.1193608367866936, -0.5737169808827691, -2.702616003909509, -2.884502566104311},
    {-3.2849195611617565, -4.374984600949302, -1.5609488865262278, -4.217969060091168, -3.5821626065152437, -0.9830772256927381, -1.9437069328682501, -0.626431994913365, -0.7361615027129269, -0.23787322167201755, 0.16445061638806596, -1.3977570878369565, -3.1861011056893287, -2.273421223897558, -2.734574560737966, -3.4815038146546353, -3.551111965213852, 0.2030943429207277, -1.4234540805225169, -2.0127546830336387, -1.1674767258586072, -1.0264485195379895, -2.0553682565370215, -3.672452919153004, -1.9525091246424708, -0.8494599141357562, -0.43226703339670164, -0.8007521301019782, 0.682042238063846, -2.408790391297895, -0.3019621662898482, -1.552476555639062},
    {-3.8542376178565974, -3.5506946998826185, -1.7888221372223785, -1.1987796720066233, -2.5005057029782964, -2.7741127299069315, -1.8074222870472554, -0.849216881742127, -0.2324923747382654, -3.154883920160416, -2.147915168247718, -1.0646480076442493, -4.1127876523514955, -1.4970435221196126, -2.7325112040241395, -1.9404913129213641, -2.885131102055203, 0.07389348928594358, -3.767793438664018, -2.8079004501966414, -1.1506167044080602, -3.5058529474554163, -2.4850099855149788, -2.233441403769274, -0.0834199174661446, -2.4586604098255354, -3.318770758918726, -2.5894237576334014, -1.2947292785262676, -2.28073041359708, -2.280453231962758, -0.5200832084903767},
    {-3.0666692241123803, -1.7557676349171876, -1.0658595469021084, -1.5074537773189738, -2.77802893478133, -1.5769924208058084, -2.501560864329767, 0.07662318354414917, -0.9309426872459579, -2.429168489531865, -1.5254661293443375, -2.6789260894911897, -3.0554264216912825, -3.0913673965931108, -2.768930898338199, -2.9304005773158828, -1.9058526823734778, 1.9748840875544196, -1.089371829019703, -2.1031188347771224, -1.4709307953512796, -1.423870560205737, -3.2899925331658912, -3.253890301960687, 0.15533375757812554, -0.8683936827315988, -2.695272778168768, -3.596865123170957, -2.9047925544010686, -3.276420840654986, -2.278363011298759, -2.8854192073692526},
    {-2.497952778469662, -3.299235957224617, -0.4206446871094626, -2.223843196279704, -2.9780896980365275, -1.832481880192831, -2.128541717439624, -0.5281069516643985, -1.2720019886394407, -0.859591491197513, -0.5787456707838674, -0.4678178856008192, -2.8416050465282328, -2.18745718757043, -2.5006185997261503, -3.9166842208909483, -3.897510889825974, -0.7486763308933929, -1.3461836269891732, -3.131101725257037, -0.820614286963547, -1.2203877983764386, -3.0921725776002664, -2.1228597532522895, -4.014972827291944, -2.2036506860122254, -1.298191358493249, -1.3406660951812435, -1.656377825610212, -2.0047735136680314, -2.532997272598358, -0.9109532253011721},
    {-2.245749295748955, 0.02869749803432803, -0.3829491338777322, -0.986655257527955, -1.6439794744476293, -1.9138690364810338, -2.905785034689204, -0.08658165568816537, -0.020717884811742415, -3.9092661309316377, -1.8442097807126396, -2.8602267806096418, -3.4661087281658465, -1.344810292322308, 0.44508864540741544, -2.4767514829035515, -3.404718819476269, 0.29308863507701555, -2.623189160845073, -4.687100846860572, -2.8240628199120232, -1.4590625737781484, -4.515001110711253, -2.0838707208641463, -1.2709976213164984, -1.8386908722127029, -1.4636147512346767, -0.8539121611567809, -3.4867360897391775, -1.5272635926933613, -1.4447554847594513, -2.2702925938859098},
    {-3.134781381764603, 0.032358283464069444, -3.649058977318555, -3.251775064544336, -2.306643520116924, -2.523009734703804, -1.7915086910662885, -1.4567372682102866, -0.6454644424542005, -3.8915739326716094, -2.5751981608670835, -1.8732917364867345, -5.717315499454119, -0.8682375838975426, -1.9482163764761802, -2.167143985224124, -4.494543066272005, 0.20206294761372534, -2.932895204668882, -4.771980083969113, -3.0925439311140677, -0.41515459135979166, -4.863531374036074, -5.485078415051739, -1.2936172288935412, -2.4955365037446717, -3.2978793846445074, -2.975334028304107, -1.8727418272858898, -1.9173017710396028, -3.1588556290981544, -2.26691849723468},
    {-2.0280326399000614, -3.8471180262887104, -1.6273822054923945, -4.0423967549751705, -0.9226097001940669, -3.5658083588438925, -1.0869168964699905, -1.017098581471208, -0.8995844009904768, -2.4338120138061368, -2.554833396211566, -0.6146611810909032, -5.205245208716459, -3.3610468826990143, -1.3486290623012722, -1.4888296330569866, -2.5919128344628506, 0.9581179389607982, -2.1454081915828875, -2.846881395473819, -3.2535767877390707, -0.8913474916920522, -4.0487374385875405, -2.807662574403328, -1.2552693795160108, -3.472279577956514, -2.4261097639410734, -4.054329631193166, -1.8641445459580475, -3.345760464149736, -3.5784474371488293, -2.221395215799807},
    {-1.5252966780013884, -1.262290098229581, -2.3228175014158166, -2.0634304678045745, -1.2550918295686018, -4.599711411434938, -3.2973620319503447, -1.9716251208223778, -0.3288851117374293, -1.28243684983259, -2.621707984750041, -0.9717360477379421, -3.6721095340388015, -3.409227555328656, -1.4335420527252758, -1.387350931639763, -3.091760752486099, 0.03278191881048032, -2.363370925437784, -3.7726625304217114, -3.0311574113256206, -1.917046027919651, -2.671027221834306, -2.29408968402164, -0.06222338864944962, -1.898436944175594, -0.9925924418516122, -3.8571113427565593, -1.3068912940696404, -1.8316816721621094, -5.694720977199369, -3.370978839350233},
    {-5.104749541637619, -2.302029405413131, 0.007107896843048522, -2.4618541559139495, -0.2552131503331901, -3.7625167757711644, -2.057619160184589, 0.052970683135057046, -1.3376328663052124, -1.622325467579747, -1.4830429231524174, -2.229469032910201, -3.6719992727306177, -1.3540565502346478, -2.9135351063155746, -3.749266589936003, -2.994953412407376, 1.3627601331038333, -1.332111877772252, -3.3385622002507414, -1.6977188554153744, -1.0669915926654694, -1.3189247309817087, -2.8500816748825923, -0.9821141536934767, -1.81972271271084, -0.8925303097447302, -3.4889741304929744, -2.9666052736186876, -4.7257129130191755, -2.4950530681265874, -2.972285072864186},
    {-3.285550127077837, -0.8028081169974369, -2.1358676527033054, -3.1165109587376647, -2.4165420658430254, -2.370812060028382, -3.0606273791628147, -0.8864356580970593, -0.6772340856423469, -2.319937932179285, -3.4711585517994368, -2.254063957155794, -2.3735893451705463, -2.577197732071551, -1.959603479359264, -3.361763637761434, -2.1246088653345194, 0.8430737507294466, -3.9193738059207375, -4.060707165255822, -2.3090519231179183, -1.549856358480751, -2.4576537185216862, -2.223580987066934, -0.3627307525623172, -2.0454976728505647, -1.9952164830585988, -2.663134379950253, -2.9059692675284636, -2.0844486011827796, -1.8168340036647062, -1.2316843177869756},
    {-3.1992420389552243, 1.1131813819661394, -0.8545032006940959, -3.2196559426669773, -2.2260464845920307, -1.8055226235735098, 0.17253952718555748, 0.8995437924218496, 2.3284339624738872, -2.1376858007217194, -1.9942284928275311, -2.081929641582102, -2.9058694546382466, 2.0651743234976396, -2.055846833369937, -2.3975222911803877, -1.0650334431462443, 0.2963515393046809, -3.411554032924762, -0.7228489659387105, -0.5329653170790227, -3.242115990096947, -2.6244890433175416, -2.289999325855948, -0.16691095376580797, 0.9112058472584459, -0.10887333048411033, -2.131310996997308, -1.1205409100370443, -2.0232223719584117, -1.4344018472598152, -0.716721406834581},
    {-0.3692456869795253, -2.746028183711642, -1.1888561418342476, -1.7257788308235216, -1.3660599776918994, -0.7091666148986508, -1.243194440979631, -0.9103651787205569, 0.02306318148956097, -1.7283847241463177, 1.5767241797253402, -2.8101613652414423, -4.094658089597739, -0.9614275619991208, -1.789325037823086, -2.162767716896721, -1.0345518537943128, -0.8442764705202981, -2.81977770976956, -2.427560055170183, -2.8050384793077123, -3.8309672582643732, -0.27068147161134476, -1.1255832655975486, -0.6705371939018664, -0.7187401030000635, -0.41942257823362805, -2.8470186151399366, -1.9980551848580153, -1.7294795127514426, -2.144711943596152, -3.246150427063201},
    {-3.345363950730172, -2.12165175786564, -1.7285316015608825, -3.576570765510026, -2.5160750002309085, -4.5739879104157595, -0.965440785685832, -3.0220974845259816, -0.704584371539275, -2.570836803762449, -1.6710397796718097, -1.6872043494364475, -4.116460864418129, -3.454452559592085, -1.5438318997435494, -1.043218573982188, -4.303581879105998, 1.6937880998645258, -4.186320212108435, -3.670972294612298, -0.2624120789711868, -1.2549616577679863, -0.45987182814171623, -2.9610270066329165, 0.08942227503309767, -0.44118392646700316, -3.017382807398929, -0.9501892345939889, -2.249941799112125, -2.726751849690726, -3.2296356122726033, -5.818309124742585},
    {-2.6638694481606406, -1.8570955903190767, -3.124361859055235, -3.35069369949049, -0.9701452238663917, -2.2529611493140407, -3.358827897156686, -1.6425966494843194, -1.438204983912226, -3.8735358692300323, -2.9398841679243644, -1.3391545719081004, -2.674733859170226, -4.220637789046943, -1.1575491680833456, -2.939529071259491, -2.1874654838769407, 0.8586710533584425, -2.1382026854743055, -3.6150126666754416, -3.3767210046887026, -2.143666963084099, -0.41892550234525416, -3.6796803942075127, -1.6085328843099587, -0.9179966407299338, -2.8372899003656364, -1.8880890983816208, -1.6229175436554166, -2.515699853621278, -2.6616832603581044, -6.062519457897911},
    {-2.6611952986181047, 0.5242789493122995, -1.1164580871747827, -2.177282243178772, -0.8536676273699955, -3.553380448195489, -2.5530892418464135, -0.4438898631595206, -1.8760050216928046, 0.362434893225542, -1.586063814284319, -2.313029109393821, -4.681283453024227, -1.4606605714074659, -1.5550123114328471, -3.394663217990242, -3.6680436369663325, 0.13874866445350179, -1.3274795501511987, -3.0675205926753004, -3.2824099380154323, 0.19215073158272564, -1.649957250110037, -2.067220675217243, 0.5251785701073132, -2.005960295513184, -1.2214921383264, -3.964442264913785, -2.3957283762962778, -0.5531338411775071, -3.339074979674081, -3.5936341648666716},
    {-2.180110315959658, -1.0980004816988076, -0.4283474451440525, -1.9836175465081498, -0.11617176014337169, -3.6674682873438975, -1.548597238103271, -0.22228133810995876, 0.1501532279884246, -0.22013428759287615, 0.21045595641453832, -0.8001997872266564, -5.073447326253004, 0.5383391693464658, -2.726102496370345, 1.8138745926733921, -2.6260354482209722, 1.4207435086132056, -1.162127687081102, -2.4445007904866376, -2.8861062713777534, -0.3670318635546865, 1.126634078862643, 1.5599832876551096, 3.269519241460604, -0.12340043815393896, -1.9450978104382046, -3.434094859788387, -0.8308507821409127, -0.7391545460047089, -4.5176600956831345, -3.5260422404480236},
    {-2.922919984822675, -2.007326902925605, -0.37888649558512294, -2.322719181631021, -0.44360825644295454, -1.7011023809288122, -0.8172525156876297, -3.6742564577451287, -0.0030467601412473475, -0.23175951647557388, -3.6420739959602537, -2.771233439143741, -4.2188107325287545, -0.8168698789677611, -2.06580712698483, -0.4916889136393332, -4.6725738683584535, 1.2094137306736328, -2.861610019054864, -4.46590852730398, -3.021444754077412, -0.5388353568080426, 0.6823237794391643, 1.476533036438103, 0.10959037735655185, -0.5181963090628884, -2.0967608805866704, -4.896179785497391, -1.848872368940982, -1.927591054229775, -4.947564237459782, -2.020305071247274},
    {-3.441260586840628, -1.5345582077041344, -1.7410836035578106, -2.735244721232236, -1.9607686147109429, -2.4900874629899135, -2.7538241935038603, -1.9851302100082793, -1.0496891702758668, -1.3926293647590224, -2.8820956919981526, -0.9297325708418264, -3.8883405420656048, -3.562070378512009, -3.542877251845016, -1.5509096497360042, -3.662672318447187, 0.2469771436049106, -2.865651658788169, -3.6688333916237013, -3.4756784701689263, -3.2293285568711636, -3.148488149542347, -1.293517755606395, -0.6104171729673294, -1.3734890493121383, -2.115705138151882, -3.779209178549173, -3.431484060839074, -5.2814027867145175, -2.1585785458255278, -2.419530733912222},
    {-2.851486644182278, -1.7541722403801587, 2.1504353931303175, -2.380905666926344, -0.5768059359314887, -1.8307312694239037, -0.5965295471520224, -2.4947666153123533, 2.1215573574185673, -1.6385075160542268, -0.6465213388845603, -1.1380167420958958, -2.2887632989003737, 0.6957180312531036, -3.0346274799206148, 1.3040584645692643, -5.224980417552895, 0.1413795280786602, -3.304669523384228, -2.1158932179610503, -3.0278448590047407, 0.19131405826677284, 0.5907714907004677, 0.8690653050691545, -1.9349599917520348, -0.14759322765203683, 0.8795649026582335, -2.135080219826734, -2.0751545469339514, -1.636443372873714, -5.138957242215083, -2.8786475202700275},
    {-1.7697186810611143, -1.2862639046706579, -1.7622292566344233, -3.5289723259440136, 1.441518098452853, -1.750111812649211, -1.0847419000480645, -0.608863917549314, -2.2852021717994213, -2.5219712944975066, -0.9472057840863974, -1.0600402316859725, -3.4281893846806235, -1.8018062252048377, -1.4364202514496454, -0.12103890408659727, -4.403738434213305, 0.41660694332772535, -1.7814237465164404, 0.03126391101692082, -5.424545427504195, -1.648976672588039, -1.814947965142897, -0.5256732785918629, 0.07391689690264859, 0.5681574090372971, -0.090651681481472, -3.4123537469826686, -3.863477627981046, -2.1205038323046628, -3.565411458579686, -2.981358454446308},
    {-1.3947197866010723, -1.1278827040847095, -1.878363501009313, -4.24692356119733, 0.17053192870369216, -4.923303404282559, -3.8098222800688255, -1.428693680924955, -1.1607952303713551, -1.592147802297013, -3.232468473474271, -2.626055933487784, -5.580247180757019, -2.3789960215247117, -3.151062943649033, -2.2722324765530972, -3.2935420050234785, -0.9662284516276173, -3.3783062720317614, -3.193560542920371, -3.0416905164704344, -1.4056189646782906, 1.6077177500108137, -0.3309622061057828, -0.9270244086666113, 0.9001330496659523, -3.558324576991164, -5.891461533916079, -3.7902514975226436, -2.4041576060314434, -2.5003840221225175, -3.654194036374133},
    {-1.67807378928994, 0.7244219825787197, 1.3342140729270837, -2.0422447145629783, 0.1819911965222965, -2.4734698474071557, -0.8136520328350401, -2.509675733154111, -1.3606229502127882, -0.9779543657322006, -3.4335834928920135, -2.7582878212356494, -5.180799152777532, -2.0167553943541283, -1.6084056683587815, 1.483062682556886, -2.9935077317665426, 0.4409817927764134, -2.524438784213828, -4.954323738393325, -3.948559390511111, 0.11640521173514728, -0.06066963205816824, -1.4323188176115962, -0.5730552384086324, -1.407123378193253, 0.4512964202471328, -1.2312041430793959, -2.0039722570363008, -2.9696605514832197, -1.506639438556512, -1.9329464576581192},
    {-1.4341023752937343, -0.9316984253375927, 1.3398984271741834, -2.71523417490826, 0.8155797943504872, -1.5065396427843907, -2.1256209967187876, -0.7811275044930072, 1.7079433735649021, -2.9067493869426992, -0.9264099991532777, -3.418378219352657, -4.958447069805542, -0.8519691616577625, -2.642510356818169, 0.23540950383717418, -1.8627874561243243, 0.48942462851725355, -5.5301642150094015, -3.365271160846647, -2.1063511721942074, -0.8522266089432058, -0.037947385376517984, -0.48297680475506444, -1.4062922587059468, -2.0359539148480152, -0.20002415677433905, -3.721145635081184, -1.9963960853617602, -2.05741609319372, -3.724231509096115, -4.208726076711503},
    {0.6733355812437027, 1.9725872838096616, 1.1215357330946527, 0.6721410598190876, 0.567335450096023, -0.12179558957853956, 1.2186781878595592, -2.0926013559246113, 2.335291450491124, 1.9185345165926226, 1.256711597772528, 0.6009823311413726, 0.7945429011715254, -1.2899012614220553, 2.6076567706732305, 1.119670848866677, 0.021921755977588712, 0.49428559474745626, -0.6274829070423438, 2.441437645506819, -2.140101898578828, 0.07213623236946312, -2.3253113393933424, 2.477198141357561, -0.0775085765228983, 3.4216424618131995, -3.6412192710010896, 1.5644271970543864, -2.0841062946126345, -2.90245255866948, -0.042510249048784775, -1.423134892471176},
    {3.4274706915969126, 0.38083448270984127, 0.07671972075409374, -1.1726523724213802, 1.2132367719327863, 0.24029391509849063, 0.12001483503441375, -0.10167866741856357, 1.5357094393266877, -0.28982991296585414, -1.612498424360356, 1.5092855506950658, 0.03095342329286245, -0.06603883857694165, 1.309008504363198, 0.5968435569958915, -0.8121192678658651, 1.7195375594172921, 1.2986202237708862, 3.201596876332472, 1.0502766762071891, 0.8460985469162097, 0.2572925319549543, 0.25255363975586215, 2.133539541169429, 0.7618050482512461, -1.2501066768662275, 5.530418697633655, -0.14583836224596544, -2.933041790016613, 1.454590604351234, -0.4155253135265915},
    {1.794860574749256, 1.4889658364321245, -0.746101961076847, -0.9748771750766411, 0.5313038761189159, 1.333257860690753, 1.944877664887644, 0.24195945162887936, 1.6846816294837723, 1.4548657018967586, -1.4758227257013758, -0.08048998014027847, 0.5538816253768003, 0.38832256859873726, 1.9590821330965795, -0.7415001663341867, 1.2420464149910313, 0.5276132561036976, -0.024348370352150556, 1.5144404079047937, 0.5479972091769555, -0.3473905657811532, 0.9788416536341015, 2.2561122297468894, 2.2969788144918097, 2.855934095976806, -0.5683623757798928, 1.1332904426391834, -1.3239751375689095, -2.812537493574563, 1.308037265502765, 2.803895137289525},
    {2.105471206775889, 1.4799130179460218, -1.7101096946459502, 0.2966573278170891, 3.5266045741903924, -0.39152805239323435, 0.881616814917056, 0.02834391777477341, 2.7387439024627342, 2.4038395302930344, -1.3230451184132177, -2.004523358692845, 0.40509360819760637, 0.18119492657837252, 1.3508331832979574, -1.4925499405951275, -1.505738839261278, 1.1370388369545261, -1.7470599535928515, 0.653813889365143, 2.2935778620555554, 1.594982012712545, -0.9584040137727088, 2.06909648189377, 2.9399091241583397, 2.6791926759691784, -1.207408990112194, 2.0570068365611247, -0.3439984931800248, -0.1707551278891382, 1.1029620028593374, 0.5278202360504238},
    {1.9225897264769076, 0.21638281141225477, -2.7876498266730447, -1.1762290719610267, 1.5101755967232011, 0.35626260328931364, 0.015779964860301827, 0.3060850005014045, 1.7382640877958635, -0.7120517559214694, -0.4159414307509384, -0.8711382682450001, -0.9087082800947577, -0.6923864625909626, -0.07556156232143887, 0.4661296275449188, -0.34387203365161684, -0.704968657827917, 0.016121665728159033, 1.9892687730188465, -0.3954151920764537, 0.26093574265891645, 2.611717582954893, 0.5903953840343056, 1.6887579494307305, 2.324970158615829, 0.049500787024979474, 0.6221970837128282, -1.1821459723586893, 1.1014126216398588, 2.1981862848381932, 1.8243922275137663},
    {1.549113994844202, 0.6018765169023716, -1.8054953552925759, -1.3825615975572731, 3.820561143135008, 1.7253714753646925, 1.0874386466592705, -1.838832488700146, 1.8353111397522652, 2.8906110611882254, 0.42682442091052003, -1.2287753118187825, -1.4087213030641759, -0.4875658511080798, 2.048047760746176, 3.4943041463103657, -0.9209332935431348, 0.1416609765977842, -0.8338326166258112, 2.318669389511546, 0.11421258820215316, 1.9603622602856656, 1.1236339153964665, 0.7823863845360849, 2.8871972844973173, 3.380975699887501, 1.0580601193304688, -0.4025954603783259, -0.3326373601571996, 0.23321349403368502, 1.7614590379583477, 0.002532235785447536},
    {2.1740938971747696, -1.1993201810428906, -0.3044167714377207, 0.7004979496080465, 1.981801624838842, -0.034416099121846816, 1.7547565424895368, 0.8822252959760795, 1.519702133202825, 1.2100652745584488, -2.4019612482258954, -1.8298252996540862, -0.5610502185268977, 0.09511976107128958, -0.37466936887465785, 1.3513215212168999, -0.9999751303592571, 0.8357332713080623, -0.7856953964768822, 2.1422592891964314, -0.6105845680403896, 0.9876206011729982, -0.9198046379294812, 0.33522898415522573, 4.701256840881953, 4.319773359107358, -1.8644739441230875, -2.4555238331095133, -3.242079052904255, -2.9071111116954818, 1.0112485184187445, 2.7681790783296316},
    {1.601521072175704, 0.2083764486452354, -2.756628141743014, -1.4481000723938344, 2.328620925187374, -1.8007333148621465, 0.4755967735997421, 1.715627492826005, -0.7926446595150254, 0.9912235719288861, -0.829230501761352, -1.9064704739826515, 0.43055373614405346, -1.5775947340393663, 0.7240649516353875, 0.6234656894173145, -0.08028046330449132, 1.398378443735821, 0.42794291827906794, 3.1807049651686783, 0.07123280936541132, 1.577644884269137, -0.4658327237467164, 0.5071255196089745, 3.1700449660404955, 2.543660508088617, -3.3794736822687286, -0.497194755375855, 0.17021903191507093, -1.5607794389062724, 0.39754617124810004, 3.190381358400348},
    {1.0679319806410723, 1.307227513701721, -2.5992756884117774, -1.764795683923878, 4.128398320114721, -1.2541697794815332, 0.4294106506741805, 0.07247553181471499, 0.009759207942070117, -0.7963750322769835, 0.5512310871419139, -0.4604660248715753, -0.47693807962907847, 0.2423009652315522, 1.0948994493729425, 0.9619167311354209, -1.357861342601015, 1.5190984435950645, -1.0262566384405605, 3.3136334596139667, 0.7167059694403201, 0.7800864587842012, 3.2081273034088866, 0.5520834304551294, -0.28517792559048083, 2.3819888099692577, -0.5015365486509794, 1.4991520181010565, -1.8542790375802767, -4.99093081269708, 2.7701224232671016, 2.552411449338068},
    {0.10096456457235266, 3.34000167110614, -2.7055300523960644, -1.9125071888685143, 3.623878853626195, -1.6974539098326455, 1.1760479039550154, 2.7650293871917233, 0.9549062845817482, -0.42779124826966947, 2.04220219796733, -1.2316923616710436, -0.5809865748184472, 0.29783964995700496, -0.8871923627759466, 0.9055134208449914, 0.8093726924913357, 1.9196932273169658, -2.039051846152111, 0.6069000732617985, 0.486338432783743, 0.5769945904524933, -0.004570838171764159, 0.8917070438940116, 1.6803731710313152, 2.1949824502883066, 0.11551562802907074, -0.09398500369314926, -1.2487540387447382, -3.1070300160581605, 3.2842185085868554, 2.682707760936069},
    {0.11042624684507259, 1.384540095642236, -3.7360356596611086, 0.14812453552579258, -0.023939941133845403, -1.6598743399782552, 1.7064156768941166, 1.0629516617783195, 0.6526537824329829, -1.2034821921320318, -0.13480782081353415, 0.038006528874233565, -0.8298556127844894, -0.24988569676757788, 0.4681596114000601, -3.295972339902814, -0.39544234834445186, 0.8752933966384305, -2.1854117851029184, 2.1178184812888805, -0.4943768508884554, 1.43712331571255, 1.7801287604248572, 1.6206406822658577, 2.1151261651739848, 4.170993374671833, -1.6220963601130178, 0.836833800321479, 0.009306671140404807, -2.27153099491212, 1.6882204113408357, 0.4447896114236124},
    {2.7574769362365057, 2.095274681000729, -2.5094819147780494, -2.5722346934971982, 1.7431124737810682, 0.1723946241283148, 2.3240442531002716, 2.3336318866790084, 0.3866682425626989, 2.04069912578146, 0.17973012708401762, -0.9834812705740057, -2.540041994721889, -0.5387208972440124, 1.8902316537373423, 0.2681446949140047, -1.0045793390462299, 1.2438051093135745, -1.5425018864909474, 3.614217181217505, 0.22348015240152608, 1.1875649260526822, 1.235084647187857, 1.5652116537098548, 2.129826433255691, 1.7854661261988793, -1.6222066144936416, 1.6503158381989693, -2.4733272211433657, -4.298530460813835, 1.6051641694794085, 3.429635836289116},
    {4.017037919585646, 2.1542116186720777, -2.8345647665908413, -0.08725253771576333, 2.774982242129668, 0.4664206465651264, 1.7004245878803996, 4.403470381076951, -1.4334675713869909, 1.503362367297396, -0.1105183014254299, -0.4924742989461744, 1.221685177950803, 1.8706249289889256, 0.052465981552351916, 2.5565118266368954, 2.7726304723524735, 2.1603980433129006, -3.6774912434443108, 6.38449082313711, -2.2824708026809244, 3.1917698990853594, 1.7708267417326173, 2.3068735896998738, 2.702229040871746, 1.333785177886786, 0.36482458466648854, 2.114025855520206, -2.3188811479452602, -2.3561612489700963, -1.7225793572639763, 2.6833000542629843},
    {2.9071826068312023, 1.9316725158921302, -1.5906297003582535, -0.020260086907103767, -0.11061734051485676, 2.1262539641720712, 0.8588450598215935, 2.1203533860561934, 1.4304970689083827, 1.1445051545045655, -1.0769871096801178, 0.9744823087333272, -0.28384279828121806, 1.2333003290918356, 0.3844774704239758, 1.0836711735291666, 0.5594574576815866, 2.7223345943865307, -2.936172562684275, 3.6512674362418243, -1.652234613894372, 3.0590481286288447, 2.9547511223722154, -0.5996646004120133, 0.6721872824319707, 5.085184051261298, -0.5173636167546268, 0.19925397595578004, -1.9325566592061865, -1.9153600043319166, 1.0774060674301358, 3.8422580809151743},
    {3.5228881342144978, 2.1078342288244345, -1.354340656058732, 1.600401138300679, 3.5619952930872905, 1.0813240897809249, 2.712759333827109, 0.7139954167838582, 1.1166437794489512, 1.1084847767907835, -2.969272867236733, -0.1326970443489377, -0.7667969629049846, 0.7958328339497565, -0.2737528767264188, -0.8662299621318204, 1.2818343681028483, 0.8800462593449381, -2.9319335325731557, 2.504787487038996, 0.2874010747292629, 1.6140879191938649, 1.3134500803536886, -0.20018904832233242, 4.657053643811751, 2.8695743231653634, -2.220501725237699, 0.40913560568745344, -2.3660471860193995, -2.6809068955902533, 0.6355606161273645, 2.5470227624517627},
    {3.0876907671608613, 0.4507429136486693, -1.4152538411885955, -2.051292460879086, 3.2085936222366005, -1.9645202867127036, 0.2156924532952727, 1.4089779017058581, 0.5720792029225322, 1.3135667288450592, -0.05434256156405187, -3.458501285686538, 0.07809451032082071, -0.023587861562204705, -0.5799861478685878, -2.0189383181558256, -0.42643095014229904, 2.7084602365481896, -3.0261448977960597, 1.1367975027930628, -1.0217766929090453, 1.6216092450210986, -0.5466576107233811, 1.1710512928225543, 1.677992332671363, 4.754234046382288, -2.104850577158453, 2.0196391975367893, -2.5976882622941124, -1.9263988769410538, 1.2276769987478333, 0.8733358255654835},
    {2.353623648592605, 1.1569548753253742, -1.635896754906622, -2.9219332195611414, 3.152262957021144, -0.7654285724763281, 1.7555075297168188, 1.250266764842852, -0.4835737332699421, -0.3925193134377567, -1.7093273178156498, -1.0371708089589842, -1.2287999039971578, -0.36161960678352323, 1.8845540591682788, -0.6487705068713497, 0.8919978782962756, 1.7235535527156867, -3.3119564866505082, 3.445618707864954, 0.7572881416159589, -0.004813976414424722, 2.208070454695814, 1.0353216749334069, 3.472011166014089, 4.66184407628375, -2.2949620554677326, -0.524941810806327, -2.326074347500217, -0.8193693497664055, 2.2314019670701692, 0.8249740352123999},
    {1.8654357512841964, -0.533081112830228, -1.3210108992001361, -0.7789984302666253, 1.747272919049306, -0.5855523597429556, 1.7871596400766228, 0.6022891572618909, -0.8581599712221513, -0.06543320330888527, 0.6510890850452619, -0.5489209044368445, 0.3539487336848602, -0.43716500798119956, 2.1079775574460915, -1.08140722743191, -0.8454485937163283, 2.544332905928418, -1.1105887047985323, 4.36055948716843, -1.5246086507572634, 1.1035941012335515, -0.6645114625306963, 0.8398796866806693, 4.287725257261606, 4.226561304064391, -0.9357911060871477, 0.7272269542269557, -2.114398032066616, -2.834646506654411, 2.096579078827569, 0.6213748224044549},
    {2.1458092904184105, -0.44158782550873166, -1.3233240694289237, -0.11147499879561781, 2.2572604128270823, -1.7807859360100087, 2.229830719490427, 1.8761348109364657, -0.12483344191043315, 1.5261611137237983, 1.2108546204857311, -2.2397732151237792, 0.5615273383789102, 0.27040764614628254, 1.0756014783853798, -0.6803644467135547, 0.06335712628387846, 0.3735232112857342, 0.299282815806122, 3.4973438718269443, -2.1875166584983554, -0.28681122017036537, 1.4727155187269283, -0.14995544842869826, 4.356345272446, 4.031382074758003, -1.8001882241328317, 0.305962327330331, -4.8553796030625636, -3.296158355149282, 2.7858079082718263, 2.4096671840002535},
    {2.829116606455747, -1.47519369132923, -0.980242044825342, 1.341583133706182, 3.162839076293989, 0.3505156057633258, 2.744583310902369, 1.3663104848869922, 1.1086127690850902, 1.3106924381942167, -1.2440377300794874, -1.2079743916469958, -1.3242503078265782, -0.5935942903168169, 0.9445931175746709, -1.2526204488523682, -0.2071646100939268, 1.318782276008055, -3.7811549347760427, 4.29685975487994, 1.5139602643318382, 1.4114951252623973, 0.17816357603669578, 0.06374743528087103, 3.3010483968985693, 2.6341060668306744, -1.582110958804233, -0.4213026665235051, -1.7644736398294196, -2.9290056784196343, 1.0923422058085142, 3.648497084351262},
    {2.463878047399672, 0.6919927837574348, -2.9306422408291, 0.027293795512705995, 4.254299144658694, -2.403325510792072, 1.4116332013249957, 0.0010623379733527567, 1.2885642340687868, 1.563987179419448, -1.7428919398133669, 0.26341666490975024, -0.19037414254467266, 0.3054206032539286, 0.9530293223901711, 0.15079978027535618, 0.5048138426040196, 0.4416691138841211, -2.420281035987046, 0.5165751395853416, 0.8347779075474149, 1.8389663155716605, -0.8461478302191113, 0.8500259067021224, 1.0257735552339344, 1.9145219628817072, -1.1203942471597799, 1.8216818661028593, -0.9256010681290929, -2.7327015108487673, 1.192992968664477, 3.894674079997479},
    {3.223251971375627, 2.3348031103888935, -3.7213795468895268, 0.445643257422774, 3.6510789840720395, -0.8438812798422225, 1.3017256058562392, 0.3338143776409417, 0.7250623581534451, 0.6351141985574659, -2.7547070017310484, -0.47025352349570715, -1.5871174576246372, -1.5355799622383373, 0.1287741922216736, -0.6550693809813365, 0.1491857527647588, 1.8580725237208329, -2.0763537533181675, 3.2297516651805434, -1.8127894935259872, 0.4596412464071243, 0.19952815611169636, 0.5990457723121568, 2.5899611913488534, 4.397777226600605, -2.9847893081747534, 2.528007377701121, -2.6192937266400635, -1.887928121893223, 2.787846878724348, 1.4165435575479046},
    {2.5171130099758434, 0.7174632650359763, -2.3650361931667794, 2.5663023166139407, 6.38495566726503, -0.0074596394803760815, 1.9863486914757233, 0.4536210013093895, 0.0747844251840333, -0.06303691912150902, -1.9043445339595646, -1.4196365843780445, 0.07397556769027232, -1.431963491319385, 0.5934288002492223, -1.8155079083011454, 1.8165789163279817, 1.4348616291180118, -4.432164737756422, 3.932802699568738, -1.862541485385361, 1.7730459043526556, -0.3543388801374146, 0.4592351606392031, 4.128456893650538, 3.655692937600627, -0.6015310720244398, 2.6974821181588027, -1.7950583111360667, -3.75538643593451, 0.5771484842423781, 1.091546074329924},
    {5.108672531879065, 0.8830407377495296, -2.605127824194719, 0.6609190300058513, 2.619086013712257, -2.5415516572161914, 1.9888184627243806, 0.7618843915437784, 2.7437084630575326, -0.7698837449911863, -0.5143027080921193, -1.3797815564912923, 0.18452597248384164, -2.6653343605454496, 0.43469683557441874, -0.8279354865186782, -0.43286416017170615, 0.6826026281998302, -2.92007406200952, 2.587111089472792, 0.09330129547526665, -0.046262022666958835, 0.8707176637397426, -0.36145607083703696, 1.833082151458597, 4.142667131120992, -0.8721641148170689, 1.6787974200002953, -2.6123802216656986, -4.400221934255828, 0.5495335226080607, 2.215016528441089},
    {3.613908256620775, 1.5230840528459253, -0.7532245589262705, -0.5573467104271289, 3.863875674285614, 0.7998738776245671, 2.110550119470797, 2.288914436010377, 0.4200160933996314, 0.4721270466475343, -2.358327930413829, -2.1332219307811298, 1.836725854578999, 0.4610520748961526, 0.3401745445587082, -1.3267842026342804, -2.5096740608065033, 1.348474497365394, -1.4664202862952544, 2.705099109890165, -0.9485664610921126, 0.25581685691123146, 0.8939974752293203, 2.2293778488098464, 3.2533798974713464, 1.6323488190421345, -2.412144703298528, 1.3342446162587045, -1.9500188171066732, -2.1387700695634244, 3.236763841792629, 3.9602948238625806},
    {3.8815448580096925, -0.9310169083994065, -2.362233447204823, 1.9238888508618182, 2.0589332260387088, 1.4945186152958088, 1.8407624549526367, 0.6134180190432297, 3.5508043533018183, -0.8474103782517739, -1.0721955816150406, -2.64835574473106, 0.2253796208283693, 0.19364715326564744, -1.880026855388866, -2.1502555665937355, 0.25867483475188097, 1.6835404303775985, -3.103211288116353, 3.246559234964703, -0.2811859958786115, 0.04224193197427065, -0.5158492030958566, 2.4927370152819384, 3.0229719415665817, 3.6530358703561387, -1.9214947699034168, 2.0354706706928876, -4.707767772122617, -3.424116772326252, 1.9150628605208577, 1.6641940561898068},
    {0.8365790072994922, -0.9335721617369312, -3.2711719439370444, -0.7884535932331644, 4.6316167138072055, -1.5545821753467999, 2.049182048419475, 0.9384266171848127, 0.8513529292285574, -0.7088024804751573, -4.542361820459938, -2.9702873963402925, -1.2056144482449918, -1.4368352485966345, -1.5377052859425524, -1.218282029179779, 0.4954856696937471, 0.11777243745541516, -3.15815320755019, 3.1328618456133595, 0.8905312184429036, 0.9356266028235738, 0.5842102138429555, 2.176239222781522, 3.1265985895525854, 4.438534550754598, -3.6123833230844635, 0.1345003963414258, -2.3304629795220952, -4.201257404561048, 0.6957106781243321, -1.4736364490744756},
    {3.645293780813468, 1.132808993375499, -3.144834287330556, -2.298730166709848, 4.247200564101858, -2.414097212479741, 1.6518189693079648, 1.0725490245236045, -1.3345682291340515, 1.9533853604568685, -3.157610553360059, -1.7805853336976962, -2.129572699799701, 0.4035007671736326, -0.8632757662277468, -0.4187340757125918, 0.4537912990882108, 1.4971572626989524, -2.6207322211242037, 2.9459952748991873, -1.0437723593114538, 1.8715556861174691, 0.7158105186032239, 1.208273945133074, 3.299942241567427, 3.5544528920063776, -2.5359723426057315, 0.2619353673055591, -2.68021148812939, -2.1364298810395805, 1.8943017525373942, 1.9731620909071632},
    {2.287373975807438, 1.069112263718112, -2.136475849928001, -0.19504530668247425, 4.6986009552335775, 0.030457040067501204, 3.4072602102740874, -0.9939358745037845, 0.07745985473959267, 0.11811013899161661, -1.987178277924737, -2.63142522124216, -1.1397557500338353, -1.5028324736571803, 0.8839910267576141, -2.46763831891278, 0.17087757306736076, 1.0577456505524314, -3.153540215327137, 3.6321089454641866, -2.489657615742884, 0.6810318042428543, 2.193704568284252, -0.4984684761402208, 2.6928502176126097, 5.4664039534386895, -1.7381644872847355, -0.965343529370623, -1.267871088032953, -1.5201676506999706, 1.69163725033864, 1.2898100842100133},
    {3.463326873238682, -0.6249603601227709, -1.9148909101794127, -1.3452026527020873, 3.4318624687972004, -1.2414242311558694, 3.9311615258152037, -0.4583993485943852, 1.2346441882884216, -0.11527491179791602, -1.5207900438317645, -0.8101089058479343, -1.6156447326602348, -0.03678584839275486, -1.164292907983306, 1.071385341486661, 0.9703289893930096, 2.964943939386965, -4.39019309609502, 2.3265048825823165, -1.843903584494911, 2.2156924484504112, 0.3754841319082614, -0.017161916551107007, 4.1521756748618035, 5.684945851567569, -3.428418333499924, -1.5848670875981072, -3.3052544785072584, -1.7657979390119203, -0.09564176272074743, 1.0452319005194244},
    {-0.2778968686268028, -2.309907027860696, 1.4089515017508818, -0.5417542465497139, -3.209811535871071, 1.728960511736412, 1.6968339028864434, -0.7403651384405048, 0.9803907760629756, 2.320239708211577, 0.5907746249532765, -1.7913250600342534, -0.5641580757983029, 2.7472276283133823, 0.8107076318538874, 2.4099619289395213, -0.3338784623600416, -2.385223367450849, -3.472644812569733, -0.9496764589276959, 0.8597428964585249, 3.6408816833244404, 1.884286908353185, 3.0157382187901334, -1.207031064788182, 0.33589949010270825, 1.7983759621988853, 0.05299733871013341, -0.5116384885253671, -0.6254671216412796, -0.43038898547544646, 0.6476439159898951},
    {-0.5385007657876532, -1.0847392896756278, 0.6638180726881017, -0.6066519643811586, -0.392940622038621, -1.359869029032937, -0.8458838634073047, -0.60158688522154, -0.2666048455177702, -0.11722823385232443, 0.8767829584247745, 0.8605023539503193, 0.1938766975639499, 1.2059529377131295, -0.25239756069754815, -0.9949007052093879, 1.7165992689289635, 0.7103987738111529, 1.724153810055241, -0.11249125244393894, -0.7342981842090541, -0.720923883961355, -0.30387548089340166, -0.15394631723136015, 0.9404344942462792, -0.6383617322182141, -1.453246614258445, -3.336052318002814, 0.57240685943053, -2.7855454469183787, -0.4144250490137986, -0.24856752097597176},
    {-3.235241547826177, -2.4286990830198723, 0.8870771124559912, -3.9088723186171843, 0.3261400205049743, -1.9723154808430106, -0.44326823799806503, -1.1987510007611684, -0.8211486893596053, -2.6355530121877515, -2.334086914617902, -3.1858871787781786, 0.7021221873282396, -1.4732214296485744, -0.7285916800426964, 1.9421114572472329, -3.3061781976408464, 0.1450097966460801, -2.8472654038244745, -2.0879491971365516, -0.3597179163162149, -0.2925709851378048, -1.3039320859008947, 0.808030229160977, -2.2494773677851536, -1.6484717466615864, -1.3938737250992896, -3.597968662254744, -0.6403339922488698, -1.9624214448200272, -1.9157226779305832, -2.9832733803495044},
    {-2.4919380987159663, -0.8989819493659307, 0.0035964419871597746, 0.0609199432606403, -0.4185961098226912, 0.291668224205591, -0.929101624405528, -0.811715603891229, 1.5203497024962689, -3.030318985389717, -2.4485517002763317, -0.7872572839398381, -3.7091758129522328, -2.0699562886134304, -1.0598697327501414, -1.1031945662420015, -3.476984477772529, -0.25913616429058645, -1.8229263151921098, -2.100150394843594, -0.14480519105996795, 0.033861779349799094, 0.8166814019912135, -0.6345881599578929, -1.0771661324284716, -1.668299878453292, -0.4768884227477746, -1.4228424348600386, -1.8992933719692315, -1.6381517303789803, -0.9145022284403531, -2.5737780491446585},
    {0.06043360929177319, -1.711921605356867, -0.7425550655135104, -2.5742032802765182, -3.0217709469156566, -0.6450932842332673, -2.7087969128084173, -1.2119653744692729, 1.023546636631174, -0.5308008496383737, -1.8322893602587031, -0.7171940301616386, -2.541713424273428, -2.06229470558469, 0.2051946037552795, -2.150737692588639, -4.038399129258413, 0.8013177223907041, -0.20408096679896068, -1.1401738273946371, -1.3675749140126505, -2.304875164254743, -0.43608198779521806, -0.09093653561457028, 0.8167161925644775, 0.6639505865149918, 0.6482960308957114, -1.2346410028246584, -1.3361833570929758, -1.208691515294675, -0.5200062353096024, -2.0532229236586335},
    {-0.28778328512954277, -0.8839220366823963, -0.31847023324854296, -1.7257486014233765, -2.288393980922518, -1.6239179433191544, -0.6483371855024964, -0.16786120858434778, -1.29107277159937, -1.4473842068515397, -1.049385710402535, -0.4635698040933429, -1.708407525038013, -0.8428048283834275, -1.4813001928912444, -1.9440096769949162, 0.35420632192520235, -0.8480043516157193, -0.21808437317261123, -3.5599442497397993, -2.3751352792040317, -1.693101465099572, -2.7613979372884754, 0.28076363774397134, -1.7024390432421543, -2.989609712088236, 0.5436718206709406, -1.648828448568806, -1.1810169299126325, -0.4385516133790481, -0.6030252785125872, -2.19436420092664},
    {-0.9529591339460683, -3.55464147691077, -1.439156262134035, -1.390117142209499, -2.735210140253216, -1.6737827736956745, -1.7959957135791622, -1.7338783074488666, 0.17832558143722863, -0.6172731024942502, -0.856973231927975, -1.5933899095779127, -1.8386496173196911, -1.6330551417152364, -0.7149940660168138, -1.8228133248337293, -3.3965075211937874, -0.5505899203811777, -2.0661811834753987, -0.7328686782063158, -0.2045212522575268, -0.7271912979599937, -2.1265458236763455, -0.32883438326079273, -1.2235679150924832, -1.8559363807245104, -0.3132564527442511, -2.7583304933114183, -3.5131948836238203, -1.9886272313988693, 0.8206302422945528, -0.5853303292852418},
    {-1.948165973302383, -1.3333152842005611, 0.2488003733985141, -0.16373456410606632, -1.0743710176154342, -0.7195487313423271, -2.920295769969558, 0.1325024900043004, -0.45267535626254657, -1.0435772548763291, 0.4656341198216556, -0.18114820086849398, -2.2045932023527506, 0.20911569074526082, -3.297379331291006, -0.8332498466023992, -2.9761167707974443, -1.3634393504953564, -0.8800134319369123, -3.6414515641574914, -0.2094504500037772, -1.0366476071066348, -3.409464034475217, -3.57122465042188, -0.7929025495387989, -0.5943323777850242, 1.0711236380296079, -1.5019438166156007, -2.0577196910206315, -2.7228008189715904, -2.547661992406754, 0.4634216720348822},
    {-1.401401676919878, -2.0527207983048443, -0.40920032582646976, 0.10227878890209807, -1.1523799794514562, -2.7282066710468107, -0.06954750970005923, -2.6733478344705444, 0.41599318129676216, -1.1013087202938372, -2.3460403046097627, -1.0870721403448687, -1.7628711867094073, -3.4834867261940907, -2.8079746675418376, -3.1033449141220553, -2.8335963676445566, 0.25049368539103006, -1.1266152472349162, -4.363269964194231, -0.7930357503319175, -3.9764614009138985, -2.713639372216843, -2.0709008861387583, -0.4446888448299487, -0.3179717053196546, -3.667022490991005, 0.10958179378846984, -0.29392280596064296, -3.44361573327044, -1.4913622063640033, -2.262213250124338},
    {-2.5520180970215494, -1.7386612042581238, 0.4603940809732921, -1.4245509109675483, 0.12310773231202178, -3.987180090173239, -0.6815101970779899, -2.1145963064030124, -0.5887759617852343, -2.2429637119924744, -1.7632553693512998, -2.620436442511915, -2.5226551857133326, -4.319549976178545, -2.565742054036366, -1.5643558193878626, -2.5943898108448926, 0.2117745049208841, -0.1902041904567198, -3.131411220286936, -1.0339856973016552, -1.2982247510944933, -1.3869449290455287, -1.3396175855682486, 0.14994341773812522, -0.7668728960124933, 0.24393505208391186, -1.364414939098812, 0.6197640998409502, -2.428952287533279, -1.0442660690525873, -3.448659303101996},
    {-1.3245949480672206, 0.4011947263762416, -1.3008573780525823, -1.7619675986941385, -2.66196277789085, -0.70812063083891, 0.5730951066710772, -1.673543826767857, 0.024571007727773316, -1.3227517044850643, -0.797184608839469, -3.7825478463919975, -2.5575850458629596, -1.3141666178097307, -3.0796366028564672, -0.8112953629342942, -1.0504175768903963, 0.5632514182788779, -2.2157081597757236, -2.8694800149342594, -0.472511405618446, -1.9148569899974772, -2.6408732657268748, 2.566414211043011, -1.4609701106239872, 0.3058555416837538, -0.40874414989693797, -0.6917966869699755, -0.5598941450675257, -2.3530901516168052, -0.0058160644332094285, -1.6226122600379433},
    {-0.8234625011539188, -1.0273899604985768, -1.7235372743210384, -2.6712019962745535, -0.01713948023592347, -1.9656611950545673, -1.146724241653301, 0.2646505084986866, 0.24606356957929418, -2.2329715472633738, -0.7934653454570634, -1.2250329529250314, -1.599087962265028, -0.22416236145426852, -0.48196587870438956, 0.10259219475631932, -2.841021745066788, 0.5999642701128257, -4.357682194465659, -1.4049560395489633, -0.9854981680963742, -1.5650119726728158, -0.9757071604468158, -1.2007008656679403, -2.170950541618989, -1.2081641726867727, 0.05768353116312222, -1.6358083152935086, -2.629992022527986, -1.0473284037981792, -3.6789371910425697, 0.43035332656360054},
    {-3.3000279323112958, -3.001835141095729, -1.6362848950353466, -1.114283161815044, -1.3477762513592297, -1.6563074852422799, 0.47284626547630887, -1.773524268332337, -2.101817189376566, -2.645718194252927, 0.3599307149481239, -3.5095418082788155, -2.0618502865553054, -0.5599086202445415, -0.6969737610979925, -3.646301726670432, -2.9226952881258903, -0.11048719638552419, -1.8141482726714482, 0.11822729500768663, -1.1006562052648574, -1.42361939868789, 0.18777498153738464, 0.5535276327571743, -1.263990132496193, -0.40542835335936844, -2.36226170912723, -1.7437015865361438, -1.2871637727492449, -1.3034896171309354, -1.7059015607527537, -1.0020732873591232},
    {0.21376717670391004, -1.073730136339419, 0.8848321051897478, -1.0874890055350503, -1.1478565458974068, -2.1929852863475423, -0.7124953819396713, -0.5630670213636525, 0.8482729186562312, -2.4285840295751733, -0.19329955811961808, -1.5088346112761701, -4.78597560384605, -0.5146759013289686, 0.26027148748979384, -0.7696482853063846, -3.8988216523965584, 0.5143324468009336, -2.69105239213564, -4.562175703102151, -1.0838352971489114, -0.025611176014620946, -0.19900288983151718, 0.24929592548507723, -0.35752350378840114, -1.4385071285233892, -0.9007483148288123, -1.3717434430968807, -1.1333255403845173, -0.6736825141046274, -3.001278215005594, -0.8312740725984052},
    {-0.5169980925977832, -2.3674351546635886, -3.39067498110102, -0.08352188121459278, 0.9539356175293109, -1.5535452026711314, -2.93685817680923, -0.20784149705389343, 1.4437188210551648, -2.48487269307172, -1.0594105647001144, -2.643693875594324, -3.4171892726006643, -0.9282340014943615, -0.9923765159259144, 0.30962304274461855, -1.8906065934014806, 1.3311851066526061, -4.136340120004147, -3.879232449920309, 0.8151111141151719, -0.7511405386265431, 0.11957505617014123, 0.4463370646787476, 0.12468982059546008, -0.6308122129565711, -1.9765954525463703, -2.120171138214611, -1.7985088632342128, -0.6829742231681946, -2.30120457030139, -0.8728408099203836},
    {-4.972285140971749, -1.8449832901454994, -1.6755001193359385, -0.659850246648384, -0.22452223280388037, -1.18768173347357, -0.9385268731065881, -1.6118845801303074, 1.1636956323390422, -1.3574716277006, -1.413514539625747, -1.2474775693397264, -3.271900980486125, 0.3896366407768139, -1.9322445488420954, -1.5585664142343298, -1.5986002667771122, -1.7858005536455295, -2.413377905734977, -4.058746086793669, -0.7801814197098265, 0.4626682196236627, -2.5972418275626623, -0.7789027049418386, -1.4561522730588154, -1.529371364734119, -1.440424604705744, -1.437611393706563, -0.871590551531345, 0.3461747294175166, -3.2406148971997837, -2.584742763277317},
    {-2.143328695319446, -1.154830770724201, -2.454552219795728, -1.0052461363283143, -1.9140532712349398, -1.8266673379509235, -1.2559500652822297, -0.8280388734875443, -1.2647979493773338, -1.8595427455587337, -2.7982421510348696, -0.08787824625443846, -2.6833727134328322, 0.9324394899097874, -1.4672647256707845, -1.6898387287242058, -1.5303455264939945, 1.4573004853183233, -3.22447258667021, -0.6546893770079022, -0.49956336741531226, -0.9869150414290218, -0.337489253016828, -0.5904190298247688, -0.5584781505723737, -2.047862040647173, -4.398743679776348, -1.9985266061120857, -0.2869082699018345, -3.1259036570257206, -3.5913432250956063, 0.18702169263298105},
    {-3.1410159030974567, 0.612295494794085, -0.05572123737104818, -2.6092196748709515, -0.09257911849177959, -3.788849661770269, 0.05896403297119149, -0.6796698970745703, -1.2631383678786785, -0.017197796563681877, -1.4564887206293953, 0.31122282291859066, -5.493956728225555, 1.3089294238608788, -2.9128462744425176, -0.0005818744651004794, -0.8701774928071676, 1.7833841550902199, -1.9032175037497892, -1.4529366947829265, -1.2241814358550893, -0.7033919645156839, 0.07357547074820149, 3.0161013262844105, 2.8467970209351514, -0.7166276794769303, 1.2288791438361588, -0.7147674116536641, -1.2865566941538231, -0.29885003831560625, -3.576433397019743, -0.8645956392755002},
    {-2.5514543483728236, -2.972188543503697, 0.901972740790034, -3.584315680465624, 0.4873378382990312, -1.5409283983966737, 0.9109013184807467, 0.1324998680793946, 0.12355750782032107, -1.8847069333271012, -0.22557142512766346, -0.8208292633459789, -2.95450129389275, -1.8013542530462472, -2.4516874202467736, -0.3856810778493281, -0.370384940957567, -0.3426994751525575, -2.623361474751585, -1.7926345014767224, -0.6318933587279181, -0.31564432858864827, -0.31558360835599186, 1.435924445197258, 1.1979912090840181, 0.003879777999446713, -1.853945560360367, -2.856988122596223, -2.739013660264428, -3.258721660365806, -2.4497983155509235, -1.5210114401062909},
    {2.2981652836228985, -4.788738189938673, -1.3196080621363944, -3.025918072597242, -0.4387074120594559, -1.8206894346166795, -0.9573445544962151, -0.12395086706721123, 2.4023451999375163, -0.25202813932153467, -1.7655324180330252, -1.7145378966779794, -2.905095277215538, -0.9776663748883785, -0.966097134439564, -0.7749259632520024, -2.4150125802822067, -0.12317265510077145, -2.6207121163664326, -2.8672703736139336, -1.7072540111149455, -0.6648534256068271, -0.24939092492585396, -0.21720309626042178, -0.1155217908817888, -0.19328669457927378, -2.1560721586270555, 0.2614534823580475, -3.197265147213761, -1.5316628692130312, -4.581960973072547, -0.11808362395901367},
    {-0.773379752968934, -1.3565697796185492, -1.1535280963408039, -1.8395348865381453, 0.1765779806742714, -3.6983361498271297, -0.6659785459636982, -1.4820573343831984, 1.2777547907149747, -1.5659045322205258, -2.788373736940964, -1.728498275738535, -4.0030355463270455, -2.1395203336056956, -1.024513720366339, 0.5970051858993228, -2.6596149255121455, -0.8042481948250237, -2.815724212797788, -1.472393844572148, -1.2732139757786725, 0.1953596702291613, -0.3796464266295873, 0.41675784250046033, 0.0503163448672124, -0.720922874314743, -1.2187830596266882, -1.4506055451347988, -1.5033277191254986, -0.6808898135537784, -2.7861194120168986, -5.117257333107976},
    {-2.7335794657314034, -2.5574397669810685, 1.369208423135196, -2.690471021842822, -1.8122740935094914, -1.2949206168958778, 0.8571132543154149, -1.5311086778459022, 0.6844186879475159, -1.5454846531849156, -0.9483296572203267, -2.0183865984227016, -4.223647711546362, -2.608913455795023, -2.185484672882289, 2.0777880685332684, -1.1424778729827896, 1.8595452804746668, -1.4888480559186352, -1.8808853492330686, -3.4265496445107657, 0.9880664987915851, 0.7797227081664686, 1.146323346859638, -0.25051840799623115, 1.0616389911957416, 1.7542817101269117, -4.484644184129463, -2.0710327788897387, -2.0021440755117883, -4.901614864998081, -4.0187120394952744},
    {-3.135195818530143, -2.6209918736669455, 4.7363800807898615, -3.432019338852938, -0.4550715772944389, -0.9853194363651961, 0.521025233854334, -0.8202954256878675, 2.172985552851176, 2.6473619598547717, -0.08679604627914383, -0.8397570308956842, -3.866487065113647, -0.1868433587136112, -1.7455279256791976, 1.8007105308676241, -2.5174163522589397, 0.20842587317308175, -2.9973587671953212, -0.6333796649125677, -1.5447487788838263, 0.4811901863232958, 2.733231604928271, 3.2915891930423054, -0.5545712783242481, -1.216474871943571, 0.888377796483456, -2.341370396392922, 1.6097264119810955, -0.8534982378015277, -7.548839189615204, 0.037000739058332954},
    {-3.3983206917390896, -2.363079903204656, 0.98663724919945, -5.243578485048628, -0.10416466900226307, -1.8943044273638001, -1.307287350737655, -1.0820037473713207, 0.7659881863864108, -0.5362035921893599, -0.9756875926333356, -0.9728922811686815, -3.067712349526315, -0.011943468195117936, 0.25206197319364776, 2.9690152548981583, -2.6268823078033217, 1.3172995346081748, -3.878234275441747, -1.5188674365923927, -1.7286956277432737, 0.46807700762646137, 3.8834380595058566, 3.713295143480733, -0.838751705413206, -0.8120590636357011, -1.0727434332060937, -4.340547711580128, -1.184109847681253, -1.6734908588810873, -5.5193053358922795, -2.7202340966522356},
    {-1.9036821414082437, -2.9691331823536267, 1.8623867835914536, -3.8263058054665207, -2.175022721160828, -2.4129809974197367, -0.48837790636394873, -2.9530292283908564, 0.23271798619323256, -0.7915035763557737, -1.3002127316098133, -0.1423183940200806, -4.1358710849704385, -0.4557602010088496, -2.656144695240716, -1.810282068970546, -2.6580571259218777, 1.7820673343346898, -3.1234512892328112, -4.069813932416703, -2.388986292115769, -0.9755762601022901, -0.4997269697608157, 0.8372929920695938, -1.320249032499958, -0.06574479162911498, -0.6752096094469974, -3.362586250897219, -4.433993582369789, -3.3182104655472235, -3.705030025563935, -4.177031120618567},
    {-3.7931296089677593, -3.7167601140896283, 1.0535630620010097, -2.5340859778582194, -0.009511819167236918, -2.467510273799451, 1.0180788242012666, -4.680027153764, 1.6963476550712528, -1.6959575587117501, -3.554783730148017, -2.2977899902152696, -5.993352129253621, 0.7119655542712491, -2.316066354787794, 2.7198641069980627, -4.298530990395273, 0.6042858991965006, -1.180637382526273, -3.7663997447540565, -1.8809546156556294, -1.0617295000524039, -0.44873987395737297, 3.174383616318084, 1.507356556314449, -1.7324078767352604, -1.6222865003109967, -1.635703526163397, -3.2315410707098233, -2.212777722712218, -3.94336957091629, -2.408343128209989},
    {-3.3320462849929298, 0.7710544225190757, 1.8524048736858008, -4.5890860730368965, -2.299002178091272, -1.5949933596916124, -0.7522195412484354, -0.9094373575352709, 1.3157612019249767, 1.380551758508785, -1.9170135951531946, -2.117083337003712, -4.336745467542314, -1.8151525687060157, -1.4092571869825763, 2.8164703995864575, -4.7954655622246145, 0.6180798209509656, -0.7860815089401512, -2.9111905931781195, -3.4028581511499336, 0.7857817463046367, 1.006819700372782, 0.8267819757967794, 0.7617849930226557, -0.8224596823603813, -1.269705687703858, -4.4066069644353805, -2.501843387435584, -1.8818169314984474, -5.707777349795996, -1.4548199494385845},
    {-1.967777387777091, -3.213003756578645, 2.068933155582167, -4.171030012592532, -0.5731756718588, -2.2463001763060673, -0.9160994923641781, -1.8952836269419522, 2.2666024699655396, -1.26872414459009, -1.1651935719816684, -2.56381877183058, -5.233598530124828, -1.0261181154416315, -2.9639574799262713, 0.17193802281819273, -3.489984778387238, 1.0255787253357804, -3.275761590371081, -2.308657358472923, -4.827637135384197, -0.10642002017624543, 1.5900986949347455, 2.5733590470243977, -0.32727509096283197, -1.1795636703306336, 0.4915780349434898, -2.3304635786037746, -0.5398812762214958, -4.183199374999914, -5.028360111570493, -0.5117274432207548},
    {-3.4016431149965918, -2.162903650144641, 1.6825363319107636, -3.5832607803602317, -0.3734800563271875, -1.943227344317373, 1.3613970480335138, -2.844893119544513, 2.361782947127768, 0.11399729702897941, -2.4485983881821967, -3.7346504797342366, -3.9249019354570542, -1.4037142485853322, -2.890446709910272, 1.54659650947603, -2.537593702659178, 0.2275475115796659, -4.034263073249556, -3.1732704341838134, -3.6924143911004306, 1.3414496274124275, 1.0621876429991015, 1.542732221198105, 0.03709181568191193, -0.17288911960684988, 0.9739378300025814, -4.04437057040067, -2.0736243668387107, -2.0797532554838023, -4.204514098620846, -1.0576369045086131},
    {-1.7691828211820477, -2.507661843716881, 2.7354974499084928, -0.44979033934532586, -1.1229054836151995, -1.0063072132226314, -0.019382974439149575, -4.3517262414203906, 1.8865049886793357, 1.1904008613000465, -0.839324951973393, -1.0315041699238832, -7.564004551170905, 0.28522131069648204, 1.31631671428166, 2.0973134094076156, -1.4755407222241514, 1.524942072623432, -2.264367431837044, -2.726880117049013, -1.6711143183850201, 0.52976263541716, 0.7646853394567333, 4.355947232036061, 0.5117805193411885, -1.964577663068646, -1.008299192973035, -3.35326425215078, 0.00024660933258339914, -2.961838185468887, -3.0751961250047266, -0.9856323480389767}
};

static const float b1[32] = {6.706031179956177, 6.903197531008229, 5.9319697358551124, 5.945903580124116, 6.353173217183073, 6.269480621395554, 6.001335942620467, 5.543073556932457, 5.623103236452707, 6.0505019724485685, 5.865541372219238, 5.60556592675537, 6.541302232654195, 5.835501319520846, 6.005935838260854, 6.508763571175744, 6.546633364055953, 2.1186093435336026, 6.343958817056365, 6.989670398800957, 6.020847674657691, 5.718025477764448, 6.641763466225094, 6.557184160289083, 5.499614112829152, 6.139144880438359, 6.285336612646326, 6.941874951514473, 5.781177099444359, 6.799475954339135, 6.319957354864306, 6.393530643588116};

static const float w2[32][16] = {
    {3.937844028715357, 5.962650827834967, -0.16821334151948322, 1.888415580218335, 2.973762623343493, -0.038901999156296135, 0.7072395062691974, 2.4542324718749478, 6.93881567759388, 3.808606861814179, 3.997560838792894, -1.1025369496539976, 4.805456643119053, 3.2745261601792697, -1.5908396661141588, 2.5844537924159297},
    {4.12654007369837, 7.400711863209028, -0.6226441246699886, 2.6473790374772106, 5.356771188754868, -0.19915477755439875, 1.416569470331049, 1.6230627816152425, 4.619058739618915, 4.170218278723958, 5.668165751398778, -0.6178121570338515, 5.211579099886294, 3.377576251788463, -0.08390207147538598, 3.1941303219013353},
    {3.7136806881138393, 5.768225062499269, 0.6067464114973468, 3.148853725067979, 4.968317459646329, 1.8862254617826204, 2.6289244683361552, 0.40756714700119867, 6.061933727439551, 4.818475875154355, 4.623970027425429, -1.3033907963606153, 4.064413446971034, 3.2032041522918826, -0.7920819733276315, 1.5942141165294297},
    {5.3413540568339615, 6.950159963951526, 2.2089748133076044, 3.5159253628693548, 3.5472814923476625, -0.5201520767675537, 2.0748390000903996, 2.2957958707485324, 5.818668321285569, 1.2715930113288618, 3.51032819960251, 0.9894700415374003, 5.078198060611525, 2.3419114362518876, 1.7568289855182335, 4.3830330577095},
    {6.023062903728952, 6.031805646280958, 0.11528247674874344, 3.312381478517735, 5.012265824640617, 0.7126610723002724, 1.585056747543232, 2.7243921761383616, 7.438602962989704, 3.914624448552622, 5.264143630514617, -0.3179822808725831, 5.386867899386726, 4.65697519067906, 0.6536805206414578, 3.5053351368391716},
    {4.593371254935675, 6.728189870588555, 0.5985615226851067, 1.2629912029315704, 3.4893600291277926, -1.108821052778227, 1.4685081905104809, 2.433801365773053, 6.61336822201286, 3.6041711827849627, 4.188585350658658, -0.6806236617715111, 1.9784185444491282, 3.801331684054373, -2.215894197663774, 2.4367713211147084},
    {4.043156751998539, 6.775933660006698, 0.6417472653429278, 3.0223568647497148, 5.239844798798479, -1.3166249614127403, 1.65085515932914, 2.363753304795797, 6.830136132999372, 5.088190334067572, 4.034887424762194, 0.5009524576994646, 3.071506962274883, 3.1498109391976863, 1.2689728558442526, 3.05411681631608},
    {4.420673049766905, 5.347712515258543, 0.571391938456788, 3.6235358168894733, 5.7956790129165086, -1.0130322105846066, 1.613481218833296, 3.8097282672999864, 4.247672374062228, 4.145306613307534, 4.14962896812716, 0.85641390558735, 5.028259966932854, 4.804278031131093, 0.6790362870898639, 3.8828124274500606},
    {2.8172187292671564, 4.762215196706029, 0.03824695024864023, 1.6987962495919977, 4.487493238139196, -0.36339689078222936, 2.4305330921045987, 1.0633184665608433, 4.519350016985592, 3.843741980180447, 4.263330047034458, 0.611750283639145, 4.389127636883094, 3.2519915745469268, 0.9863954418681455, 4.2422868692068905},
    {4.1834452554116055, 6.155001137995551, 0.38887562731966335, 2.8049773038480432, 3.2989244125318424, -2.016241377924388, 1.6962063535021925, 2.1695350612688977, 4.9686222082868445, 4.179903177727786, 5.806156582711304, -1.2270935319126686, 5.391193062061821, 4.993531338310475, 1.256835440519917, 2.9758498377719462},
    {4.057642868101895, 6.568719013612071, -0.9175772547987686, 3.821356365931541, 1.8057176511751571, 0.7034010052261961, 1.1079000784592017, 2.1421281269999803, 6.87442999281908, 3.6618609920462104, 4.362370217301546, -0.40602334512370325, 2.5393938104166973, 3.4856780426874843, 0.5280440069609744, 1.6403846213968347},
    {5.791372191071092, 5.100430025565072, 0.05967388537314067, 3.340668019989885, 4.678594876188558, -1.0012142554905208, 1.451457134814583, 3.30058593239783, 4.586327454728356, 3.3075638130276372, 5.2522426727339155, 0.2425354087571064, 5.436910309790601, 2.7145733723680836, 0.17515674303316786, 4.79669491511953},
    {4.066281360939802, 7.251763616553272, -1.1961903514657244, 2.226508283815563, 4.77988486801119, 0.15798796092348208, 0.17076621766536962, 3.6980057806107984, 4.962894442110124, 4.670629089801159, 4.941490841116991, 0.23444092026330593, 4.138520379285326, 4.155163187217444, 1.5732531577315094, 2.0606352819447302},
    {2.2089727525188514, 4.761794482341104, -1.1746597482258339, 3.4760237458394685, 4.032811344289622, 0.844190071928915, 2.4301505567045494, 0.29554363953887985, 5.533063539206044, 2.3932169225478583, 3.9486925132484023, -1.2059745118774214, 4.434285239995517, 1.593814012197168, 0.8698866210300386, 3.516528093323552},
    {3.452573588835351, 6.296364397383891, 2.429694442465865, 0.6780483845770069, 2.8494617442462546, 0.5467057862892686, 3.844056562293066, 2.0691916612223906, 3.7479611725006374, 2.560570829310695, 3.512964470349152, -0.6367032567385735, 4.230977735933101, 1.8753380626890304, 0.0714495719540425, 2.5920489995718996},
    {4.727522258090826, 5.631103399473194, 0.4117847801791877, 1.7210071060387697, 5.0575262675049135, -1.5080298643716408, 0.4522926686052256, 2.657378015631621, 5.11693803298774, 2.383926864727386, 3.187243885324052, -1.0033085788548184, 2.7211221472973492, 3.8502973993227383, -0.4482585034186891, 2.583413269925035},
    {2.6084185372089266, 6.913815181876752, 0.6775634326281862, 2.123326002836714, 3.936787812806338, 0.7733237069952604, 2.234610664072578, 1.7388777987893067, 6.385060781719678, 3.153481978677397, 3.634186840540502, -1.6879313988280993, 4.555395481126819, 3.2730969286935028, -0.0119324580236077, 1.2118269250591405},
    {3.0970899294603034, 2.460239661567386, 2.204380290929085, 2.954267582449744, 3.203045708478544, 0.10876912563182417, 1.965491637579696, 2.2131899825373638, 2.8921214831585575, 2.2308112504048134, 4.21104278556433, -1.1068607001890503, 2.7073302089750695, 4.0253260102537824, 0.9224882848641706, 1.5053258071564048},
    {4.744370200558002, 6.342101527564007, 1.6337640930539044, 2.8781755891461587, 4.916311490470251, -0.741816841145097, 2.5170192694431663, 1.539062759163575, 6.44895624758836, 2.77426403452299, 5.096474453523514, -0.5008873464317681, 5.922437536552786, 2.1609727989241683, -0.3633122883713273, 3.026554618453726},
    {3.5240209019364603, 7.637017737914699, 0.5935060138306077, 2.475271586599677, 4.037474646570157, -1.2669228354211908, 1.9710592987252389, 3.1698465926821817, 6.294081725930822, 4.057646925075197, 5.694711119321389, -1.1307584170276834, 4.453586028609392, 2.9049114401344296, -0.8556769280319065, 3.2991083218557966},
    {3.3614639252160967, 7.115329181210426, 1.8969778221802251, 2.8722483213815497, 3.584014778209863, 1.0676200927443555, 0.13378256895058743, 2.9696534190761854, 4.885796659978596, 3.770300781624828, 5.996116389766761, 0.4535805898506264, 3.4840465189140373, 2.4846968338950917, -0.370172004911068, 2.3577555306508224},
    {3.8545415953930653, 5.226054253596235, 0.1415318947797286, 4.2570730604902485, 3.6432245757087327, 1.5134657022965732, 0.40557299488708665, 3.3091472567234343, 4.323702752467223, 2.8908095237090956, 5.591166629521523, 0.6203382821191656, 3.7118163336732093, 2.9949126207412986, -0.7830345569183472, 4.2530013058481915},
    {3.459823424157724, 5.718146642628731, -1.1713333527726144, 1.7344405913531964, 5.195881820011178, 0.645013429752321, 2.3917025227967934, 2.117527960809998, 6.043017062777177, 4.868543678013534, 5.128124517665172, -0.5865707745878191, 3.926404634267674, 5.1574171727114635, 0.7490188509615897, 1.4933780431661046},
    {5.1838659858410265, 7.961871127249961, 0.9891163892170272, 2.2653448865325165, 3.775906313704397, -0.379156383672192, 1.1468684116118004, 2.7934292166470454, 5.085325871199177, 3.746715747893719, 4.284942719737833, -0.9898928664416285, 4.942855857029187, 2.098853433776444, -0.8695581930478795, 3.249627174279066},
    {5.344051353193654, 5.241872335185837, -0.04567450796878838, 1.7522221250895593, 5.171314780514335, -0.13869602714424373, 1.4546100317442838, 3.240071121527492, 5.007024945332099, 6.4953521963484, 4.243815072215434, -1.1682639974832216, 6.726148708091556, 4.6878059464802755, 0.06675073685181596, 3.6672282491805483},
    {5.117688914281522, 7.12735337041692, 1.0762678332364515, 4.10650821625986, 4.386267116820864, -0.3548464713204481, 0.8399716588938887, 2.5083674951734727, 5.262638320911918, 3.071844751421832, 4.388156176306943, -0.6328660323995293, 4.656137008214649, 3.773012527901636, 0.34224180858769604, 4.472523142497369},
    {2.3427558951145038, 6.389643337081161, -0.09611513226865662, 1.0678690334109935, 2.9982971086214247, -0.10113785306359176, 0.1468063176072984, 1.2486097240247125, 4.672796909179427, 3.2797359575705154, 3.858167128631584, 0.04906673912718837, 4.638835283818664, 3.332688168934195, -1.4370956155644723, 1.4006108295324278},
    {6.224049445286337, 6.079562660266913, -0.4239319819575816, 2.2162761756029523, 5.159735192693231, -0.46018822589124064, 3.1543331592834205, 1.686778986017989, 5.766641260334637, 3.510508432701511, 5.174331238658512, 0.9869769669915621, 3.9259301786662877, 4.922723823418554, -1.3919013387311543, 2.0931907332885973},
    {5.246520369493516, 4.697918947108115, 1.3191452087923357, 2.2043389195610446, 4.8217226575904855, -1.0150114900847094, 1.5421395348929856, 2.429615628662803, 6.052194643342106, 4.146313809496364, 4.054659930798954, 0.26975716743811895, 3.1242084145451163, 3.9786454816184014, 0.33922448516711695, 4.1738988999347635},
    {5.224359583838976, 6.018795490710308, 0.22377470921501771, 2.6414861113647023, 3.160290175179125, -0.6515770058849898, 1.9112523508373416, 2.4444284755046377, 5.465032803840186, 3.6167448865132656, 4.1431741516748115, -1.4773845834824377, 3.949610554733808, 3.020834891328704, -0.9742358734998278, 2.430186104468247},
    {4.379134018579652, 5.381406614647745, 1.1091763236319108, 3.429963792321375, 5.2531377268439075, -1.3149044166715325, 1.516169700915302, 3.3225372154301382, 5.6467156572288495, 2.292853492494383, 5.079551739198772, -0.09428114957485607, 5.656570729877641, 4.373786800319721, -0.5284244571072348, 3.936119991010191},
    {5.189209046298012, 7.5707592953087435, 0.6668816106529366, 0.8998378210155872, 4.525228526736155, -0.19025417994018906, 1.3582923454899158, 1.4613566000111355, 5.806509605757718, 4.192178881281967, 4.061266856741026, -0.8958454325667508, 3.2706792798051927, 1.8120535475494284, 0.12660629332349033, 3.7334793218721796}
};

static const float b2[16] = {4.979395409486176, 6.2863263576488215, 0.15031000626675084, 2.883744860906559, 5.353048227332889, -0.23078918359465733, 2.6291967784656043, 3.279442810965678, 5.728398641849572, 4.376165411440219, 5.3471552334230905, -0.4368863935637924, 5.167057530905226, 4.402931645571076, -0.27061620367049966, 3.508038366019475};

static const float w3[16][12] = {
    {-5.557831181286955, -3.841793250977851, -3.9739677943106737, -3.212991667039284, -3.3143874199549384, -2.436587323521157, -2.4979727297593235, -2.7601396072027793, -3.8714616380034883, -3.210194792932039, -3.8347886229777304, -2.314434082340502},
    {-4.7518505144494805, -3.9118569620474624, -3.944521987005324, -4.305615813380649, -3.455394444242905, -3.7745478705351396, -4.4060013736233525, -4.7177543568927085, -4.441499470250215, -3.9494269634684107, -3.597904952149066, -3.3034153521567244},
    {-2.7415503560029735, 0.6710332594991332, -2.799886739425272, -0.4197912863146014, -0.2946114882390161, -1.6260008411121492, -1.3749060611092638, -2.5461603569804367, -1.0142968198526516, -0.2422950923942684, 0.06131371898321131, -1.5624975604815179},
    {-1.854163628397425, -1.3290369410333551, -3.2773125120603055, -3.857383181633438, -3.514396985061901, -4.467151085616, -0.9362671455292143, -2.946260103896294, -2.4286887544381397, -3.0238654365929425, -0.6333108902938477, -1.1371105167700335},
    {-3.8424436110172833, -2.343240846839254, -2.6854048930520134, -3.2277544819743897, -2.468078340080536, -1.9569466482590485, -4.0565064235061365, -2.5129534904403763, -3.2419196424825723, -4.158316658552601, -3.039630866178005, -4.161352355749826},
    {0.10020883302033975, -3.324719669927965, -0.14723628000450584, -0.9439397817113543, -0.5797916004511192, 1.0132152518675865, 0.910462420826635, -1.1775458058900612, 1.4435839734975895, 1.561743038963807, 0.08392647154472498, 0.18133835200190304},
    {-1.7105496620869614, -2.8569914367374936, -1.2971054091931922, -1.5459692572265626, -2.404099878570443, -0.2568620811155268, -1.5538867157342193, -3.296335466859696, -0.28322217725885607, -1.3642720834164008, -2.832507993847828, -2.497121547878584},
    {-2.3574201025681996, -3.0195722822647966, -2.456167784857579, -2.1617689925653787, -2.1133112653889237, -3.3407981147959074, -0.9426316013740195, -0.5249826010000295, -0.9528380002589315, -2.2651643464270834, -2.87182468232609, -1.1501162250778576},
    {-2.669835006694194, -3.4127045191226544, -4.230279526401106, -3.079079465929681, -3.701654661218085, -2.9942544666836746, -3.035345414622858, -2.91302656546632, -3.2312038409935693, -3.801199912147169, -3.4089225931091005, -4.285957061396204},
    {-2.4210676439981382, -1.8699720748130595, -2.3862047531054986, -3.291436734682946, -2.450981159974261, -4.2143206426731705, -3.6733472024061933, -2.3868023916333483, -2.9663183179382893, -3.1041704990256607, -2.184604193708733, -2.576800168987203},
    {-1.9688363717803776, -4.818321065792912, -2.6992117916110043, -3.0478182595146914, -5.3646362002818035, -5.234714720378349, -3.6814357902309784, -3.2942468346952416, -2.1785143297119616, -3.306011377507736, -5.305522616845103, -5.131711500334355},
    {1.5396801656550045, -0.6876666231835767, -0.3209742587677188, 1.071774932503552, 0.03654668541235264, -1.0220786134205648, 1.3087586654924641, 1.655054943505741, -1.6249963051702485, -0.296223411707219, -0.8207408151653685, -0.8126104333297142},
    {-2.875549771901903, -4.6970321367027505, -3.5275138130484205, -3.989411962005464, -1.7168118399123364, -3.977059596490853, -4.234476098809885, -4.325642946477223, -4.823785819594556, -2.8769918642288936, -3.4796874514799008, -3.2228945405036113},
    {-3.814238969343604, -1.7931641898186355, -3.0106121967767994, -2.8519518970593825, -3.1093692687079715, -1.6695691641870456, -3.7042878142391267, -3.189484692859173, -3.3367064100128188, -2.6324353619556695, -2.474438750776135, -2.8736899126803173},
    {0.36657596331126485, -1.405863699793734, -0.6006539688173911, 1.5915742367421546, -2.2769398641735226, -0.885055075355711, -0.9404751209208805, -0.09607984771756761, -0.6249405939951119, -0.746522276702916, -1.263597533808042, -0.08882827580806603},
    {-1.715046548885395, -2.495996039628561, -2.2621469751331604, -1.6919066167264891, -3.6544730098384512, -1.776165103636801, -1.9870457957939405, -3.4620751231156888, -2.8695749796262273, -2.150981010515056, -2.532634634623675, -2.721760705043581}
};

static const float b3[12] = {-3.136476751654413, -3.1620281145173474, -2.6364526979332448, -3.0589091398227666, -2.603283391243828, -2.586249569137151, -2.810532048486754, -2.590154916366262, -2.531358661714661, -2.9389525821830222, -2.6588560657746196, -2.3846288067709143};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
