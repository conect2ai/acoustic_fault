#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.1684151194095187, 0.7993677309358044, -1.3074069773293002, 2.3244764109114335, -1.377169404535395, -1.0467592294274384, 2.919836527581717, -0.3294260771362993, -1.368690441944919, -0.20710235760660123, 3.510369031268505, -0.8976060304948773, -1.3581108018146155, -0.07645795848591484, -0.7187774114981618, -0.5758795955636496, 1.76641034786945, 2.2282045798750767, -1.34090897239294, 1.0543541104261969, 0.006572294876637278, 3.0360654509246796, -0.07383298778249557, -0.7349515935618496, 0.6902540259816792, -1.056104555818437, -0.726096461129019, -1.6542635855845569, 3.2440968187542425, 2.4963440793854335, 2.3001818889725887, -1.3213552597957345},
    {-4.0421112444465725, 1.5087367320064222, -3.8991067219225597, 2.5409411332308443, -3.2630496221843996, -3.953187899260826, -0.9451534198326725, -3.3246905002509015, -4.089943025602096, -3.1600380836055773, 2.9429693693570496, -3.805941813567743, -4.3281241538381865, 0.7639316041360383, -0.5798734521070809, -3.5082692510625253, 3.1828299707813574, 0.3733081629622692, -3.9033612440190506, 2.5272273351228307, -2.608441932218582, 2.689649093846821, -2.589222911098746, -3.6237542868716965, -3.1970542158529187, -1.436325868466336, -3.5364004494727985, -4.030992516826903, 2.656720188345898, 3.0194701668407276, 3.392463422872128, -2.0904421226391885},
    {-2.2604480807990823, 2.884292178067324, -2.5089766015257395, 4.416368767115173, -2.681615524489256, -2.491507841212408, 2.232672066987286, -2.154304144634393, -2.8453336816903363, -1.8448957046972598, 4.924269923781532, -2.265035209048632, -2.3992842826818452, 2.024134718740691, -0.1402717750520616, -2.2686966689107604, 4.471550259287581, 3.8633762536564693, -2.621617242366081, 3.5191174485702548, -1.5199015029029836, 5.304722531166306, -1.4606650903003593, -1.9254619717306047, -1.2449595670594589, -1.266675659538628, -2.407047880385212, -2.897049549399764, 4.505178928104003, 4.440196000558248, 4.520080317744178, -2.2222755782684747},
    {-3.6682912748602416, 2.0716252119346668, -4.027129614695199, 3.9885012614787794, -4.1570418592278635, -3.63814239042082, -0.12971568184475674, -3.369805092691679, -3.9324870860884964, -3.1142651055832116, 4.720186367949299, -3.840076912755625, -3.698318454916173, 1.1434072848740617, -1.0971372632926608, -3.3905681354663506, 3.9146119014902805, 3.830954890288404, -3.802634346283307, 2.9481761170386043, -3.354100117297341, 4.892629785607157, -3.0671539343132674, -3.637970547471501, -2.821314454106846, -2.65656397783292, -3.5257351042785623, -3.6443204754538403, 4.578993248070841, 3.79294990937948, 4.056470942386789, -3.3641086595983842},
    {-3.517189377494467, 1.4263963492969471, -4.081483222495293, 3.5599997614269188, -4.093627053914058, -3.7810065038494387, -0.1078765829942088, -2.9045504611028985, -3.9133120541662483, -3.2703154360030733, 4.479113448990752, -3.921206448012437, -3.6872447692445673, 0.6463295047537233, -1.885359625648924, -3.3281330897191443, 2.93107605871924, 3.5784214797340135, -3.8040023088748915, 2.2692939780047627, -4.01454936720904, 4.393537015313376, -3.4761313077186355, -3.8295617484492985, -2.5925009243160817, -3.4826473810566867, -3.5459315277990227, -3.7373925318517696, 3.8436603762415262, 2.9153074648413577, 3.093895121203902, -4.004299038117949},
    {-3.5496123568903726, 0.1846319951852749, -3.9223933342091706, 2.7044071959128373, -4.165680655925421, -3.7929701588896947, -0.36168900475726706, -3.0624246846540633, -3.7504219550457645, -3.4645650498142997, 4.060110900490444, -3.625718639563111, -3.2628303967271717, -0.351004229998456, -2.3055654705891535, -3.3595680534568935, 1.8261543725348361, 3.28795339940348, -3.805854491288243, 1.649663873951654, -3.959734355253202, 4.264483757913242, -3.4487213235552705, -3.9132811098305607, -2.2577399886870877, -3.6492424414365585, -3.8584082674294873, -3.975612230120015, 3.4670967862951043, 2.157748546660473, 2.102285452902761, -4.234735007556421},
    {-4.062416394299353, -0.051089276538443036, -4.076815545391438, 2.63375688578289, -4.453374364834554, -4.3206048770488445, -1.2542989792315682, -3.6716637417284876, -4.395740664829786, -3.9868340059041656, 4.154909851177828, -4.226026572034995, -3.8747620103793157, -0.3411449623497263, -2.4084105317457554, -3.7651483711683036, 1.5257968293119304, 3.2464272732006725, -4.2068555240478265, 1.1705635723891148, -4.310810878543846, 3.6149348783577286, -4.164849813449709, -4.24904585428996, -3.11080758729294, -3.6709133475440874, -4.172330007391184, -4.062594143751323, 2.6931112580878858, 1.8790002355953708, 1.564294352534885, -4.157806235607188},
    {-4.506826224715647, 0.4093787809636272, -4.5612425724384265, 2.580777342648213, -4.5957484425375466, -4.244653981178171, -1.7974233592617699, -3.736912996397761, -4.4589772568105825, -3.751127190167222, 3.738128265219152, -4.313144460339192, -4.231343706946501, -0.06801585725116639, -2.0905020958208804, -3.996498422821277, 1.8890494634826236, 3.3625992871299437, -4.38879862484977, 1.002211967973033, -4.178007420300872, 3.9641987364488296, -4.146966063102606, -4.312325245161577, -3.0590197135978547, -3.736841228533987, -4.131870819215761, -4.639475379270241, 3.2434655986869507, 2.1918352749132755, 1.6312485225918267, -4.259419799960422},
    {-4.655589566817723, 1.4102922808423177, -4.656766231251552, 2.848114512406115, -4.339140280518971, -4.503474851509134, -2.0061784037907064, -3.7543624944210015, -4.487757010431926, -3.859565769294607, 3.954820028714857, -4.223709908034312, -4.372849545282342, 0.49235601997298173, -0.9270719073637493, -4.116132774858359, 2.4505527571949997, 3.2543773733990995, -4.53081933384223, 1.5470585480806862, -3.839355458385683, 4.027719898199822, -4.28959935442922, -4.17362265921572, -3.460411115932281, -3.5673003253700126, -4.0017553856916415, -4.374567992242955, 3.732637157891004, 2.986578590613737, 2.573267928352334, -4.008592000878193},
    {-4.7703843286936145, 1.3537880462966707, -4.905199390842638, 2.8714137782312763, -4.60417074769423, -4.545693010670775, -2.0200535118123133, -3.88351220214125, -4.6601744332477955, -3.646527195441161, 3.8993962986858755, -4.634582226837055, -4.490788318279106, 0.86831986136449, -1.2807028920120065, -4.192316573388168, 3.002827014783469, 2.8272029981091515, -4.714138092160703, 1.8064793375079602, -3.911753005603652, 4.1281295874819275, -4.099332259827208, -4.13081903389932, -3.7601983126700884, -3.3172388613103228, -4.282952524720304, -4.7965550280621425, 3.615494646895294, 3.1647142548736045, 2.9770831078647295, -3.9629904344429945},
    {-4.823610104764179, 0.8493877671427551, -4.552732597869153, 2.103660763951901, -4.491259214077065, -4.780907222095114, -2.4692297273770696, -4.246289383879407, -4.8865200118822, -4.35648206671904, 2.5758925879369436, -4.476333878946953, -5.004270469526281, 0.14826340982556116, -1.9432299851107282, -4.615047657563088, 2.736272773873675, 0.6296356676793015, -4.880942119657845, 1.1865458426762285, -3.9124089329477987, 2.4656663193058845, -4.30391814299907, -4.242065373138138, -4.202593012241248, -3.3082018812926974, -4.54861182913547, -4.581724484616725, 2.2888771609323255, 2.8823986585165366, 2.8749418952374426, -3.6097213714775243},
    {-4.613055097040445, 1.003864077041156, -4.6568337413383825, 2.1355367325089576, -4.499977256822935, -4.730276894383829, -2.490957509764249, -4.360525304490234, -4.587117294806689, -4.244747562591624, 2.03345664931811, -4.329781270160413, -4.747270167457166, 0.25269803350285014, -1.433313181847386, -4.538916490717745, 2.3584812230808865, 1.2032901383766084, -4.770631686092441, 1.420692786773069, -4.037635813221246, 2.2807936382266383, -4.300140402036626, -4.335328743348175, -4.148287986400043, -3.0023097367040066, -4.341623995633545, -4.601110860296842, 2.153175081154708, 2.732143655750428, 2.586640546406707, -3.4002396270249684},
    {-4.512097508186904, 1.6434224031013673, -4.566465995665059, 2.4423268241738643, -4.602860278221801, -4.581051652621699, -2.114552789144373, -4.158293328388343, -4.478796022290137, -4.069765481426282, 2.3528349852883164, -4.3693267832210365, -4.215197523915788, 0.8292636272973833, -1.1494302899552755, -4.287449487918817, 2.94879054844619, 1.5158024728195127, -4.500435810815767, 1.967187093864877, -4.088677822928466, 2.33644627260807, -4.008789726744184, -4.206083568878178, -3.8347135200040814, -2.725262267150526, -4.2798511372938455, -4.422538760303885, 2.5077288699426235, 3.021198668036283, 3.0101221089658523, -3.4140469728161964},
    {-4.511745780365956, 1.8479898151044996, -4.434999882116473, 2.772401915447826, -3.9554663735221407, -4.4270301752509225, -2.144933662342833, -4.249173514901771, -4.5038595337751035, -4.08830742574056, 2.8200101416299006, -4.330833687599425, -4.414685597641387, 0.7878381700116512, -0.8672999801912634, -4.27270013936982, 3.0336955359662445, 1.8352041030646424, -4.672687129185565, 1.9682248047783373, -4.003515821646588, 2.846556336864407, -3.900666143456161, -4.279490629709364, -4.061484051333963, -2.7109615186614824, -4.421926600739969, -4.441303568373206, 2.5220643381230317, 3.1418730942243123, 3.39192540720249, -3.1457216148831626},
    {-4.531377029542891, 1.990578167657084, -4.564514756302072, 3.1689426284731796, -4.154113413189347, -4.262700490510067, -1.843282363383111, -4.342258257441092, -4.202001531967613, -3.779769468940622, 3.1323004362522986, -4.186087975149411, -4.3689482258265695, 1.351959611989366, -0.3851221531659179, -3.9156516498543925, 3.063538138036604, 2.5439231697745956, -4.661351575037581, 2.437076427451144, -3.643034741477073, 3.112185142007212, -3.742364656991755, -4.053678789485927, -3.5239758473029443, -2.386802428496524, -4.148199297741254, -4.713401807776756, 3.033071097840464, 3.496545135994963, 3.558387577538283, -3.2155326898688066},
    {-4.543676130647092, 2.0528886531457293, -4.574152863169159, 3.3766578512491146, -4.440857011247192, -4.480776266228363, -1.980992544311015, -3.9196818745202364, -4.309906615874662, -3.5496733146896173, 3.915727029001119, -3.9340512546139657, -4.472038476948961, 1.6689964712543566, -0.6985505612564864, -4.1011733107238, 3.434358346359467, 3.3346340952720355, -4.579552980467418, 2.4576705290409184, -3.79769444843628, 4.225627721389769, -3.9864064740137355, -4.145534134599666, -3.4302080765807537, -3.0018633285083887, -3.9963726814554956, -4.539897511696051, 3.9156227059414013, 3.5925987010037272, 3.5520275152135508, -3.6319534190195912},
    {-3.6496945411101946, 2.8072586925392, -3.887504793692632, 3.8956245205379347, -3.856042484769697, -3.851609027960563, -0.7170572324862315, -3.339322853237224, -4.044915946801031, -2.7480144178095616, 4.62938401206768, -3.573592138106311, -3.9441345866683455, 2.286852960207609, 0.3140700937440677, -3.716907293401399, 3.944358178721279, 3.8775717460553096, -3.7131153783866853, 2.975189319172478, -3.1181274762027833, 4.606022157521439, -3.5418911377381734, -3.628131395873091, -2.615972531914885, -2.167301142225336, -3.713470438392122, -4.034439663399273, 4.49591205858252, 4.205396471743961, 4.124031217992527, -2.865001288657605},
    {-2.3300388233449474, 3.0219830972410806, -2.839971054153355, 4.7635365494432635, -2.562110902636672, -2.8087655007565537, 1.4964578973079354, -2.3409596004698474, -2.8530363822202225, -1.8812010072283296, 4.785877748413874, -2.6324711136974805, -2.9229565115873197, 2.72846625191458, 0.8189511175839779, -2.518932759311869, 4.422835760867565, 4.44557792747967, -2.8595682926760038, 3.6695644232653146, -2.2048195973396627, 4.827127304063466, -2.4778274906565847, -2.272045763761933, -1.254477220376016, -1.1477997578757682, -2.4804224065559732, -2.805612985643873, 4.8376959860259685, 4.427325213916821, 4.56604067865952, -1.6712563698203624},
    {-2.377885202603646, 3.006894370565978, -2.788070504681223, 4.365303195227593, -2.8172768505269583, -2.3192031099849015, 1.9552848824757296, -2.149025489652404, -2.5808277960249937, -1.7660928491662242, 4.578376903325498, -2.5969949543378408, -2.4836291206994083, 2.4455841795500124, 0.4150921070612254, -2.3198724515434255, 4.207790102009572, 4.260783154432022, -2.389615288106837, 3.524198482286036, -2.2307581674920307, 4.719755633024625, -2.1671611203868406, -2.188779244838717, -0.9368474385235624, -1.8087699981764214, -2.4820451759663187, -2.6222432287226773, 4.455283881707447, 4.113416403174883, 4.3522204927712105, -1.8469577357592653},
    {-3.8594181401094634, 2.8150120096452897, -4.061043571801816, 3.986021309497614, -3.8639474449383275, -4.180026708292325, 0.17424014274208033, -3.4812423427906727, -3.7060380518283047, -3.2554232493133135, 4.56424637215193, -3.8663580470498964, -3.735834551792368, 1.7206614940916998, -0.7598332990408955, -3.5221691545694442, 4.052539232035566, 3.582723693503615, -3.624697081040483, 3.234919256604203, -3.3294989112114326, 4.692132519098233, -2.8974826706477463, -3.522981721486714, -2.4611657957840363, -2.1502562535447147, -3.563295985555448, -4.044042014719035, 4.654564850441198, 4.277050267783246, 3.9658422631104226, -3.096200169474701},
    {-4.2885930371325305, 2.8236119837616247, -4.169049427988741, 3.892504532114031, -3.947706598421057, -4.2908930000035825, -0.9110062600670396, -3.7406939445362615, -4.201932283131603, -3.1234392022088096, 4.269796585197952, -4.002453952109906, -4.437667193992598, 2.2172726931823554, -0.16814292512605805, -3.9325639797995664, 3.9087069791884446, 3.473746030039419, -4.31359168255204, 3.3905923557505835, -3.6699990312580115, 4.393021791052847, -3.401367848593202, -3.8216248275644285, -3.3291115703394465, -2.1130689862079484, -3.8631883259742827, -4.0615911144856955, 4.304268824701638, 4.259555553713347, 4.356727483581711, -2.8083218725468995},
    {-3.5895099498171454, 3.311851026028622, -3.357231665536243, 4.542636716747443, -3.0039713961683376, -3.2389927851685743, 1.6250598526372826, -2.838789778266967, -3.50690769271442, -2.203403313377057, 5.0990286708323485, -3.1231863433509797, -3.488650332572536, 2.4966837978613854, 0.373255917773032, -3.0974412042659645, 4.597902541388121, 4.08033854875475, -3.7122516937476466, 3.545843396020669, -2.2249773054145523, 4.87158546746114, -2.3697488888136107, -3.04944077786367, -2.0819304403500865, -1.112614661615709, -3.423905208627238, -3.679207395771384, 4.7733442815534275, 4.75559489081634, 4.724752563425781, -1.8375369752810737},
    {-2.585409607530001, 3.7462426234641546, -2.38096421792582, 4.66442287557389, -2.121394517555656, -2.486776575049011, 2.0699745972948764, -1.8951355946525845, -2.6498295391510442, -1.1440683839556285, 4.714246551739419, -2.216741521847984, -3.0318074017757795, 2.626771608113786, 0.9085085801905354, -2.2987478454634522, 4.86083262788879, 4.15190950059381, -2.638615583516761, 4.1248657911306585, -1.09310514931352, 5.119559740890125, -1.4612439292232886, -2.146885217222353, -1.2016575251323283, -0.7014222021471446, -2.200633706196185, -2.540883308484654, 5.147782592257875, 4.856689395200794, 4.894655132536171, -1.021975363313668},
    {-3.0684837502918856, 3.5762358715656144, -3.2538863424382614, 4.177667503363544, -3.2759927486704963, -3.4009807545414414, 0.6697663536257646, -2.7919331548452564, -3.549890861178064, -2.3989938051219735, 4.363486872939907, -3.0687223491245095, -3.410251603968407, 2.7574339652913644, 0.5619261840014125, -3.159226383386909, 4.2206601835007955, 3.506111719793767, -3.7088858735152233, 3.7505110895316625, -2.3212118116640923, 4.542957377738081, -2.6412829675527725, -2.9355559879450674, -2.146289486659662, -1.262646902107696, -2.9003095370804988, -3.2932762733033774, 4.485312231913941, 4.660854832687804, 4.644824095968414, -2.0236575889658908},
    {-3.8080312781852803, 3.153311348241871, -4.26139426440608, 3.887556279771136, -3.3979844043345544, -3.774054213977398, -0.6223197154347001, -3.3166359965834316, -4.301482427906766, -2.9796325435213276, 4.065528962311189, -3.5353136540832804, -4.2596649169822625, 2.2889599331713564, 0.2429735665787526, -3.680154213412444, 4.196618895348444, 2.5332389264945814, -4.252283356697882, 3.0238649131125195, -2.86457875835836, 4.190411096836155, -3.2044018934745226, -3.5160664437689575, -3.176488833771075, -1.636677923406637, -3.746046123422566, -3.925156458448696, 4.066750552939377, 4.402084093891606, 4.333010004106766, -2.4724182764061444},
    {-3.4813688796020843, 2.915901596914123, -3.6246920608109763, 3.9924608003929802, -3.3499806539074433, -3.7242533068311303, 0.17830211838153762, -3.0631746288576664, -3.712278576628775, -2.8699214781424307, 4.306634951354702, -3.446031604023797, -3.765533978776078, 1.996928098009736, -0.21455330894148303, -3.412987513888683, 4.071886388634315, 3.5544718856557145, -3.5366423747012314, 3.2835345075076527, -2.5724806745050897, 4.579127779739038, -2.693661236096024, -3.15372798684121, -2.5908680165490967, -1.663360653721128, -3.4733155506802107, -3.665569088478315, 4.464031161742388, 4.561065975070781, 4.429152746869207, -2.349142364653715},
    {-3.5621603468239247, 2.8909544735766466, -3.491672561184909, 4.304196274662715, -3.2620290480000764, -3.56371630056161, 0.6930384563178741, -2.972044170021504, -3.8162774861695072, -2.6699918420829216, 4.566315145131585, -3.054898076554043, -3.6908065486032804, 2.2171157037150815, 0.08143230724690823, -3.2738197133182783, 4.706900753603008, 3.2370727297950377, -3.880496795853562, 3.6336984094866422, -2.4465664675105776, 4.892166901515323, -2.4696973099459782, -3.0635548262384127, -2.37296221063126, -1.5779229272399695, -3.3508954175794115, -3.5822369678737807, 4.649837502312684, 4.573793605857451, 4.6055761277519816, -2.1442163707569315},
    {-3.623167284489449, 2.8284980702410887, -4.126667278593158, 4.386761938393633, -3.664978669409061, -4.183724061024204, 0.5375805899992836, -3.2178090875972427, -4.276317171106752, -3.0745632141847534, 4.473754446594019, -3.4389975586818897, -4.1175950980129, 2.2246461170809515, 0.0019376120195257246, -3.44101285396226, 4.220528488096955, 3.396049219101987, -4.121571302224708, 3.536562283380863, -2.9256372018658836, 4.695536870751088, -2.8625735745400105, -3.2359548660857462, -2.7060435232940927, -1.672939600606332, -3.5412460718066896, -3.7704440031475324, 4.5591664118911925, 4.641249414335232, 4.626285687407714, -2.54714400454789},
    {-3.6066282061305937, 3.0541738487890577, -4.013719927300986, 4.205766406276025, -3.1864496400899522, -3.9174430842191237, -0.21520659135535536, -3.431615873910622, -4.1231369756893255, -2.858699077586488, 4.132803808495981, -3.5807417826596253, -3.874388902987748, 2.181992531317154, -0.21632741304527606, -3.7309011488128414, 4.500904875044294, 2.536451267975832, -4.069559641287825, 3.393935557001742, -2.646893609854574, 4.3968383811357326, -2.8810557549805798, -3.3181736862390268, -2.93508048066555, -1.549469117516221, -3.6878515062130135, -3.9160576359957213, 4.40549875645146, 4.637164591111644, 4.292042989013708, -2.487221312954283},
    {-3.81158002270178, 3.0150732687105593, -4.133110767617183, 4.245390986990346, -3.525104238925649, -3.9123681701246897, -0.1262329385238608, -3.332288423550446, -4.223766389718586, -3.152162716961554, 4.297102009824537, -3.5124265110612067, -4.2838633437058204, 2.349601841209847, 0.25671184230544497, -3.4454162040288283, 4.591982440733095, 2.8673068874793564, -4.105523672545063, 3.5540192798651904, -2.5665689534255036, 4.478339222710639, -2.5710407222825125, -3.239082752970861, -2.7303295652824793, -1.346892927929916, -3.7592204763620916, -3.960748174590725, 4.521016411856812, 4.176617419135746, 4.826065958460064, -2.0717960702163905},
    {-0.1614320579910961, -2.8941413434905203, 0.17487055026816856, -0.802033533295295, -0.13108599820844297, -0.11108018016869996, 0.9324052782072637, -0.24436083469285771, 0.15381738680257034, -0.5953244826499584, -1.7116614859715003, 0.3558379109207427, 0.1721313123869562, -2.366527221653596, -2.3782984476577105, -0.19496477005168486, -2.5821786730695684, -1.3847379042893302, 0.36947134364491413, -2.3101526234061107, -0.49688710063033936, -2.073795715259069, -0.08520142780327125, 0.014187094015123016, -0.08747495783390655, -0.5133477354182793, -0.11938967083825827, -0.06676598580530131, -3.2218142401319394, -3.1426729363229065, -3.1543805362863138, -0.2888447500449406},
    {-2.68813502831737, -1.0287559685517274, -2.893783601381182, -0.34603708562876234, -2.700127088374947, -2.926570219913032, -0.11211835007551806, -1.8944319388130604, -3.2507496738136514, -1.7964364261801153, 1.0447428802774557, -2.3551644820109914, -3.3721627605648696, -1.2031806462639663, -1.992055138671721, -2.311679578878095, -0.7562269098877266, -1.2030369816616058, -2.9878691563122217, -1.2262671345518876, -1.3674206447373478, 0.7549580752061021, -1.877882329578003, -2.1960565627056057, -1.3918126398448558, -2.1495752473586665, -2.1862250944034836, -2.8849041428663718, 0.13309304321669138, 0.23399251797392595, -0.1778391375284955, -2.068170738306183},
    {-0.14532190518615543, -2.7621167518785996, 0.5994292275445828, -0.9838247446901254, -0.8029269452547633, -0.37325038441880454, 0.6184166368954517, -0.38689665266793916, 0.5136297560275561, -0.7660772538991296, -0.9719381155902346, 0.07511964721934297, 0.7943136773374548, -2.709089704610927, -2.4483260252334156, -0.07261247499003713, -2.8883876474466894, 0.8195799533070096, 0.9673698794090724, -2.4029404197609376, -1.4460863658671335, -0.852118596729539, -1.3430760427401218, -0.4545961464252651, 0.4798038898901224, -2.0487966627276717, -0.06226107929269727, 0.10193637827543689, -1.5907756755418734, -2.072848929866456, -2.7001655865338234, -1.6123418260428661},
    {-2.1926029050123135, -2.7888989381370104, -1.9643348833899512, -1.827506824681015, -1.7933358927437801, -1.630569128489971, -1.0095364895800125, -1.4818874831446995, -1.3035402501587006, -1.9867507406856146, -2.334127710453897, -1.7422071735536147, -1.7914732816165937, -3.0106447428660132, -2.3335698376353533, -1.705146261725875, -2.875893467554829, -1.052963709727053, -1.4289268764304006, -2.833346574177364, -1.8715353571761524, -2.2814445022085486, -2.0956461234853614, -2.151359516232286, -1.4968090011974993, -2.5359284895700385, -1.432619217781138, -1.6268828339191692, -1.8711443339479648, -1.996151055568692, -2.0665040636761827, -1.9672665626110313},
    {-2.9962649882288717, -2.4152547890654734, -2.584199060371578, -0.4044546319654145, -3.058216713499176, -3.155647467671138, -0.45270787570460824, -2.70206820450955, -2.6725320486049053, -2.51196917957899, -0.16771701221507582, -2.845161370741389, -2.7535152463655708, -2.6783708801912165, -3.202823604075294, -2.625743142437731, -1.4956547524982688, -0.2392617287676622, -2.6475687159047863, -1.962516011330984, -3.076592324836047, -0.44104823519845265, -2.7910864508248405, -2.938746274936249, -2.192417904705924, -3.2102330942299515, -2.680682038761118, -2.6001305382118844, -0.4978716337503791, -0.513094831960022, -0.7313811065072349, -3.0316436962704616},
    {-2.1518848441092246, -2.8744343041265097, -2.3256509419207925, -1.0152359834053946, -2.7544635221397993, -2.69374267463078, -0.2491082076381808, -1.7944844772333528, -2.6418383454173218, -2.107199841813404, -0.25015517485538397, -2.6218102061833113, -2.022917617954354, -2.888821421536941, -2.9080028903868937, -2.004831230189324, -2.381878488525208, 0.226959138847463, -2.6850967133707826, -2.7635367530219423, -2.4773123359013702, 0.13582811504959175, -2.7159476786906933, -2.305279228896598, -0.783095803017491, -3.3525940768467386, -2.1429554590406426, -2.292940323098842, -0.74703889717407, -1.3844733313393565, -1.9562455466479987, -3.2134458128876564},
    {-3.273583335305916, -3.204997988391601, -2.9664548922457805, -1.5489553260090714, -3.0286226127186233, -3.0817348365893737, -0.7079876966190798, -2.9468724530022263, -3.188190417710191, -3.0560372864369083, -0.4908994200716638, -2.9787803634814813, -2.7642392077985876, -3.2807301021163653, -3.541970549911422, -2.9939881175193768, -2.5433740676669045, -0.4597815915291732, -2.918148470357422, -2.8932792701979637, -3.0677661172178143, -0.5179856677554084, -3.0547524846426026, -3.0251388895744284, -1.9846956861510323, -3.664951057596939, -2.934587002561615, -3.0199720295655457, -1.6887056962381706, -1.996111422748505, -2.113459939880635, -3.175753994709527},
    {-1.966003804493674, -2.4122719672131696, -2.1535840218186757, -0.9459690782299262, -2.3776451066866113, -2.567134188118464, -0.46503291099458877, -2.1195363178558964, -2.304145123205037, -2.2283947257696344, -0.5801970766486664, -2.326011483234973, -2.2792102481686918, -2.8916014818448392, -2.6803635842760833, -2.1281932788077187, -1.5559161565847222, -0.464639006545279, -2.276862631567675, -2.7873873374646347, -2.406627815208241, -0.5893018536445254, -2.799886545865032, -2.3181047909965815, -1.234731643329357, -2.75695655269074, -2.0481060347829008, -1.9675454024090275, -1.1894016202906013, -1.0863691814322258, -1.2518958550941466, -2.666721666980107},
    {-3.0025205122509213, -2.8706870567292397, -2.797938901759698, -0.7948300267165136, -3.0884180432826014, -2.8822698551651893, -0.9564530295011242, -2.300858746111512, -2.3934478333461358, -2.4963039619670924, -0.35132956925438646, -2.498570650507365, -2.39705989242187, -2.9344732142262453, -3.0619015229201842, -2.091092528482511, -2.1955598541118757, 0.15790806325801063, -2.6573033195604974, -2.546759100243582, -2.4688701271287994, -0.12039172072435497, -3.1757724124978455, -2.5350752324103114, -1.6303834695706239, -3.4983957014826643, -2.377911050226171, -2.573799487012912, -0.9654986547350253, -0.9277836259362869, -1.4745810647068793, -2.991844798696081},
    {-2.7582557474203586, -3.0880221853493217, -2.9944946345595853, 0.4254632903817098, -3.2806476070042128, -3.1238328079283972, 0.46230157556037277, -2.588732296290353, -2.817422235558869, -3.0498550334370425, 1.1453327454521467, -3.0693812794746247, -2.50584226453315, -2.7957177885921944, -3.1255817555175236, -2.736982450825531, -2.132814039932284, 0.7195250260284598, -3.075138086537311, -2.330426071172128, -3.0380782183144923, 1.2402789553078095, -2.768429299021308, -3.019442084202431, -1.871673950961206, -3.4567748407853585, -2.8729268051946923, -2.93692784099492, 0.030395404367288555, -0.6573692780906728, -1.4546121952051307, -3.4619937899224538},
    {-2.9670875714816014, -3.2701964364831553, -2.888628771170239, -1.2726545112994396, -2.8268050457098615, -2.942506629243887, -0.14520708659878165, -2.7479095642286095, -2.9034696923714467, -3.0920908800149234, -0.7089836142488167, -2.96773363596116, -2.5893288842524185, -3.2034353124021977, -3.484445551769609, -2.824039433338305, -2.769479879803474, -0.7959537492063206, -3.097220738203573, -3.157247594897798, -2.9706563318852464, -1.1049469410496415, -2.701027131508254, -2.8424332858244634, -2.0880286345299455, -2.9175079176208603, -3.0305133823233166, -2.819035564859748, -1.6084273294731377, -1.882251856610113, -2.4187093023495345, -2.7994083970408186},
    {-2.582411926541241, -3.0495902116043214, -3.090841238761977, -0.89050975705625, -3.163783679396138, -2.819376117521088, -0.3052574120155201, -2.7213971793575866, -2.7661677207375504, -2.911086410269403, 0.19949395875986894, -3.1072117323971904, -2.714094805124241, -2.965332824546067, -3.2454760881609483, -2.7379268164575774, -2.186922323996512, 0.08705132436513191, -2.9205206494869627, -3.0764378379363415, -2.881128157636583, -0.16537041943895306, -3.105976170783161, -2.873273793811962, -1.3725098354868135, -3.1538903496610557, -2.772433031400798, -2.739718840546405, -1.1628849900951743, -1.609924259627438, -2.0225863883798323, -3.553100758021044},
    {-3.4988771935520555, -3.242172076714381, -3.5701441911288962, -0.9137236625041364, -3.876524957350434, -3.554477249338755, -0.6309024572000105, -3.208335184743265, -3.4928424955624844, -3.4757710846752574, 0.06396076199024356, -3.490618525016632, -3.0331213551026326, -3.6512114890154193, -3.602583477393016, -3.270888838746501, -2.626690638826876, -0.3499928114664428, -3.5479559081758048, -2.931809961804975, -3.6140668599343075, -0.24874449864770187, -3.2295077030253267, -3.2775450986959926, -2.082694811529501, -3.575411727938292, -3.583577293481372, -3.2745873158172776, -1.4751505972562982, -1.5412137252828995, -2.1006868043569913, -3.722871710381524},
    {-2.9627913826258587, -3.4812343351296695, -3.3752093717939267, -1.1405380799368725, -3.4896393080103802, -3.1787725217556044, -0.7557333254224539, -3.0052449104438503, -3.2332211773087867, -3.2642063066058786, -0.11844137491511238, -2.8657182078507883, -2.8427561154184704, -3.624926866504101, -3.669930039603148, -3.226143216183636, -2.9311134939356296, -0.0015062002809900935, -3.099882460737596, -2.9174361521753513, -3.2307793272558984, 0.3300905071598341, -3.520233658235655, -3.197350105139146, -2.032285042250875, -3.7851462027186304, -3.3047513559118316, -3.127128218055858, -1.244608553335789, -1.9648125525414766, -2.477643146600163, -3.587666675548826},
    {-2.389572787068675, -3.3324231197464234, -2.5477741119323896, -0.5250229585376857, -3.1718879773664708, -2.875139401585254, 0.9049849688811743, -2.258491966126753, -2.5377092627719082, -2.7580322883251673, 0.5657394579643905, -2.4839701451519707, -1.7252520677868022, -3.3679578201242846, -3.466224859446088, -2.503221977628136, -2.8136242708076575, 0.7442271788476567, -2.0390361184581236, -2.737504361850347, -3.0401902197081845, 0.5498528013591178, -2.661360573529922, -2.6979418633438566, -1.1499647231057093, -3.318411684249764, -2.5925771499387116, -2.5576997178098955, -0.39932360176977966, -1.7866080628865373, -2.7275190317740265, -3.2488222423540347},
    {-1.9643681559597623, -3.5872262631506167, -2.1043659487141264, -1.0207125443700298, -2.930828662673651, -2.106260793107743, -0.08575799097979896, -1.584239071894177, -2.5257931069671518, -2.166017051641938, 0.3576410435279431, -2.20584035979097, -1.696033097700947, -3.677574874435559, -3.4231915707852765, -1.4424549361707961, -2.8431005712399386, 0.4359920117721223, -1.534005023314798, -3.234034794378396, -2.3595328637435014, 0.14825536420376736, -3.1761200151436313, -2.1719644881540776, -0.5066529217471295, -3.5937967418643675, -1.9004175052301537, -2.395902094709455, -0.8928156071675665, -2.3328654244006137, -2.8183884577255225, -3.604095983072714},
    {-2.133304131013601, -3.2360040238318724, -2.051022854882539, -0.8771405573596748, -2.7481749158997344, -2.2556702835851854, -0.19886474576826907, -1.8617606093674597, -2.13217167424925, -2.0243495112364425, 0.07645504825377167, -1.8065358305964405, -1.6176356449046436, -3.2000856500091626, -2.8939547462002064, -1.8118133951752147, -2.6491061067566233, 0.31535040912266743, -2.0858298019847332, -2.867687931784077, -2.345862678808801, -0.1541156439981735, -2.6337072241144415, -2.1199698088004366, -0.7729693353920624, -3.3272514533314403, -2.0124283307327224, -1.9181814560858925, -0.09980859127720162, -1.4739791638231625, -2.026080022661386, -2.6718014320133303},
    {-0.8177077500520238, -1.788858033302725, -0.8408138443641545, 0.3637746591485235, -1.1381213845570515, -0.7952669131307123, 0.5358113897095009, -1.1904995759784973, -1.1104885099030055, -0.6646952141368825, 0.9812343588908828, -1.1858200123430336, -0.5578118521125924, -2.1928212944585255, -1.6381155010690343, -0.6733590057216423, -1.0534942660160826, 1.3217250163904823, -0.8332857303391599, -1.6171331358783845, -1.0860462934047868, 0.9140791730555902, -1.8251762352261556, -1.151619609822072, 0.4880897036498528, -2.4789737602106454, -1.099221607680411, -1.4659806769415589, 0.9724005389522778, -0.07417861067982005, -0.9420101045986645, -1.9045920544764827},
    {-1.1508595994523287, -3.655472355837984, -1.3761119025626924, -1.3132846968432481, -2.0001042755904113, -1.4068371431232682, -0.0030267109525555034, -1.9980235908068167, -0.9316066930155009, -1.6500862333730237, -0.4882278964697532, -1.7617864557445253, -0.9709747291194015, -3.401108919993969, -3.2249563180060714, -1.4213118666753255, -2.868466794016172, 0.008920948208533508, -0.9703477109419056, -3.2071077472430005, -1.931999996757503, -0.6224706709400798, -2.200604308365228, -1.5287012533447382, -0.12827784124982655, -3.2528273526289544, -1.5237300711500832, -1.536170520976017, -1.0131842395352848, -2.276666996432669, -2.7639652564985533, -3.1141164411914195},
    {-2.9736352160985136, -3.9995508740712635, -3.2306662993067747, -1.2426618931928641, -3.4289522026641843, -2.904077303812356, -0.33216168113949046, -2.7715493014976467, -2.7377039342797795, -3.3154531989668032, -0.18045425836953313, -3.055810782099495, -2.6228253559817016, -4.230203739528406, -4.088880297929682, -3.0029921759227634, -3.2721129246383214, -0.5014352701462427, -2.8790133125767423, -3.6602314121313686, -3.516647426356515, -0.4198112833663896, -3.157314341957531, -3.1941339098927113, -1.39034471360303, -3.829282791412153, -3.0085989987604322, -3.1529160797654314, -1.5808519975787527, -2.721870293608563, -3.1425116189731463, -3.6667591765873646},
    {-3.5512643583787495, -3.0921439708535985, -3.3120760563501412, -0.6221596375206958, -3.716663187503283, -3.2188045763839286, -1.3043677795265918, -3.1917470024924928, -3.1785163636860676, -3.8001515399877834, 0.41662383817557813, -3.1696435264831657, -3.0043054988542055, -3.2938670717701304, -3.7389648925269414, -3.15457449366635, -2.328627722394851, 0.437693353562711, -3.3763337052162115, -2.775496377418283, -3.5951964047739646, 0.045725842222652045, -3.412140671022861, -3.708251909444095, -2.2063853509666287, -3.8471174352152873, -3.132217299539419, -3.3313369591095197, -0.5769638918839054, -1.744340979720158, -2.1247525171309825, -3.65121309446566},
    {-1.7701529794980981, -3.1097381224274736, -1.775201192494134, 0.9953411047303226, -2.9344335991385475, -1.6131675359241544, 2.0579421150812944, -0.7789044140797935, -1.9531887123744145, -1.6434788563453815, 2.8789641156063817, -2.057517708189431, -1.325004935644091, -3.270366560325007, -3.384424578937245, -1.2242146024193823, -1.7905401815232322, 2.46162749720422, -1.520082419708738, -2.1473776861634497, -2.3307769590576823, 2.4301763953495876, -2.5071234172515346, -2.1370263687674376, 0.442154991293321, -3.323214223611279, -1.3137214842302878, -2.0050620625699027, 1.4339209917710627, -0.5578119046680701, -1.4083549341991357, -3.5060239701002454},
    {1.5466077534376994, -4.169569828700139, 1.3549631981732213, 0.8089671993444928, -0.7775952507657014, 0.8949634634204041, 3.261362420796478, 1.2759051164222304, 1.2576336187170187, 0.08080892119397447, 2.2711563927132565, 0.5894383721781508, 1.7226333024935583, -3.62540537374337, -3.349344210300432, 1.0183385745625422, -3.1515077844653483, 2.754596988561344, 1.6949419205762841, -2.5142824163898276, -0.9485712532880038, 1.9666115240300415, -0.4209612199839749, 0.23563775251672878, 2.1862384507255044, -2.785020385550149, 0.8771913858457034, 0.901823917172793, 0.9226010331920645, -2.1691500376204376, -3.0747110341517896, -2.4944507599392525},
    {-0.25584556782042855, -4.239456144604158, -0.7492463002721715, 0.13087993998615075, -1.9134291052246812, -0.7028296704821828, 1.9212722688763486, -0.44399564794868185, -0.3009685950546522, -1.6746468983487743, 0.7472192383597085, -1.2217741759573362, 0.5772569614250059, -4.37195282328989, -3.793622070263423, -0.23455664631798948, -3.8389720076525493, 1.7409447782681757, -0.061383229093562745, -3.4997084690288727, -2.4878211291265355, 0.44567971597560246, -2.0194367500110153, -1.6856971638138427, 0.5012886690224112, -3.36676012575274, -0.6519744216469368, -0.8651706643091467, -0.7004061220693294, -2.913562487472275, -3.8639318178553266, -3.5073463261037956},
    {-1.9101411421761476, -3.849726761537874, -2.466710638387269, -0.6479309690047659, -3.0897652499113697, -2.580302073281243, 0.5059248031992956, -2.5862790853331075, -2.648554123769179, -2.9844724309662616, 0.09426500779797199, -2.417839844188855, -1.8730298585492295, -3.9582709913764518, -3.769391628499122, -2.264240881302605, -3.3431455305868014, 0.30838211905407786, -2.47152373590867, -3.121044345876352, -3.233410953226235, 0.0827268804357931, -2.880264906852954, -2.968595485317049, -0.7956427535219012, -3.785772180149015, -2.6835151474781482, -2.3920548976347513, -1.260519263549026, -2.639271308981235, -2.837747276652432, -3.9067466547976006},
    {0.7904287916626126, -4.572163123677246, 0.2567509721875769, -0.6704704097848188, -1.0283985620609963, 0.558194377654708, 2.034306349136259, 0.06207667299021156, 0.7883267097342241, -0.7573830201801305, 0.3983795736306203, 0.08624692073076362, 1.0424245321869008, -4.335422992508049, -3.561612743696411, 0.6235776997079848, -3.891605259265477, 1.3766624320261587, 1.0377242238674445, -3.4805821666591106, -1.7463027680435375, 0.27206924337259664, -1.578049778601085, -0.7984514561749196, 1.23797458701066, -3.2490245314992197, 0.26420087086641353, 0.28865682587109487, -0.7785579838834592, -3.2631842958363384, -3.7693253978606247, -2.946164943676136},
    {-0.6071733339726939, -4.1682862627966975, -0.9681711676990293, -0.05221523251287258, -2.1297985671867794, -0.7373961529067496, 1.8884423132321906, -0.8723185911537523, -0.6341425292169937, -1.7925823722888927, 0.9967550759967205, -1.286893892042897, 0.03722689432268678, -4.0491872917357465, -3.557986347380269, -0.4516466491844549, -3.3922032629544177, 1.2658466639261354, -0.3628543804719617, -3.254573881595223, -2.156592532865982, 0.6154542985956457, -2.18124217701345, -1.6625966190252464, 0.4321429350993873, -3.891399631400736, -0.7987811354827067, -0.7019261378885785, -0.4398220595420473, -2.71659342837893, -3.458829256504291, -3.5322702083629887},
    {-1.6684030764681554, -4.205577180040232, -1.7439500528959244, -0.29264558170718064, -2.821980052445981, -1.3456258421262177, 1.5209445661599077, -1.6103413278262193, -1.6018198929400538, -2.518083083648541, 1.076004981865778, -1.7157660950609286, -0.9422295306101826, -4.369291321082514, -4.244944892541934, -1.25748631686657, -3.5002297691018356, 1.0569555842149265, -1.108831226413538, -3.597007938222238, -2.7363247181834325, 0.5097345838074456, -2.7277580093005125, -2.326818412557779, 0.1523416579413005, -3.9768546978776333, -1.4959693715730664, -1.6773867981114323, -1.0608922182799065, -3.212478197129715, -3.4360520093804223, -3.638774078409596},
    {0.1193944827578794, -4.247317480602653, -0.11462674870646884, 0.01665987505164987, -1.669391396055688, -0.262430720176176, 1.9029210529975917, -0.18718882467487202, -0.12870125038597025, -1.079567779347916, 1.0306758429190481, -0.8607557672797007, 0.7820098860409479, -4.105760759947045, -3.583102864678731, 0.04414538444657502, -3.573284390959315, 1.194889662296694, 0.45223816537093875, -3.725874859200666, -1.9439764805753195, 0.839783578934314, -1.8174499146723924, -1.2683787066596248, 1.0247870252380904, -3.564958818752847, -0.4520896108397535, -0.4748891382218368, -0.5048824757237592, -3.0487349390066494, -3.495911989869555, -3.4119214353737424},
    {-0.21971374395547633, -4.257958572094765, -0.6157689901213453, 0.46955959792632385, -2.177607636672285, -0.5757408653677925, 2.146229731975408, -0.36071661695269247, -0.910998100621855, -1.3673870129487924, 1.5854519036162957, -1.0474322268048508, 0.1768170630433843, -4.109255273448619, -3.9253459579826226, -0.3705556590277481, -3.6367857267012362, 1.7883669464406418, 0.1681673634551877, -3.162371304719916, -2.161798533985904, 1.1206210378408916, -1.9583512228306765, -1.611459922962108, 0.8584856150149528, -3.438681665456915, -0.8946759838734342, -0.8009496536590034, -0.4636234688527389, -2.560573085809386, -3.3332309099124524, -3.358387294301827},
    {-0.1609545497159138, 0.5785918660221178, 0.5587091769759385, -2.3609074024959495, 0.338151337991857, 0.5262600011034313, -2.4617517288547526, 1.2411680264716087, -0.5500412499681342, 1.6560918392803643, 0.13278167635867935, 0.7550103039996834, 0.31407579075375147, 0.8522119164157969, 2.077377856621381, 0.8642363108012532, 0.1522808812388148, 1.7423331727409113, -0.47341880963669164, -1.7186411437981608, 1.3604743368574295, -0.007411656045342658, -2.755970814972293, 1.3522856309210272, 1.3840354590172268, -1.3402690420829269, 1.0283350111589622, -0.02027807573888458, 0.9376359751409536, -0.66087730151564, -0.18017439341438515, -0.8510485266234307},
    {0.6793347242802038, 1.1193438406581375, 0.7788468629445501, -2.2877266140105164, 0.6148702161786159, 0.7958851510480522, -2.048291341280573, 2.337245853499003, 0.417761879868695, 1.6974005744069638, 0.916404410480379, 1.0214329865237244, 0.7720762910677974, 1.3648353161208824, 1.7401311306555884, 0.9036970483627318, -0.16110662681983404, 2.006097090108565, 0.257641902298993, -2.2200155167307996, 1.7353181249491996, 0.018350062694938364, -1.832871005110768, 1.2602437780224534, 2.3182856824553535, -1.4666666486749833, 1.3830859880632473, 0.009403290889659532, 1.363427643798478, -0.6058218903952917, 0.2030995416396905, -0.7384344743680035},
    {1.2149906733385245, 1.3232834738627115, 0.8932102198969696, -2.7642917934742637, 0.9830878180504026, 1.1319197285796894, -2.9810490962179146, 2.304000126438978, 0.4442428730218447, 2.273739416831712, 1.1444766564919155, 1.351374973918632, 1.0689387200112384, 1.1091556000897596, 2.0585037315229715, 1.6940303660662197, -0.38321070621502834, 2.5476729875925903, 0.6752802418538929, -2.922795241480621, 2.537339276336205, -0.31197071712620006, -2.1787156159661296, 2.182168752137154, 2.8251765773419284, -2.3772366858443394, 1.8531682824719398, 0.41261995468432994, 1.4127016086523014, -0.9822080875438342, -0.32779411675085934, -1.2799307915887135},
    {0.6543944238141808, 1.2474332104186425, 0.8739362095072939, -2.470504606411313, 0.611530904784059, 0.7551362459747439, -2.931890060717534, 2.4385835184980027, -0.018493991735932767, 2.274594651031827, 1.1292588362098266, 1.8230472835252585, 0.9540327546738036, 1.2508325747881968, 2.027362230010157, 1.7689268572764212, -0.03989871019885173, 2.55482729909468, 0.3144116713176782, -2.2804340161861156, 2.308200209198563, 0.2316625554974912, -1.9351393767332405, 1.7183608395751813, 2.474575423427931, -2.3451521856778363, 1.6360002148362744, 0.07037002974706515, 1.8624431392657144, -0.3690827412513062, 0.27215702980487433, -1.4064056908194615},
    {0.6218307054807232, 1.2667321519459316, 0.21990593817940537, -1.948300921592432, 0.6162264541545276, 0.518726879293701, -3.1767193810232643, 1.7218414381755247, -0.25755433751591666, 1.5386055074378486, 0.9606905386088593, 0.7554384490093651, 1.0379034204311768, 1.2718275936252879, 2.41967254663016, 1.1961545805713285, 0.11745636776735359, 2.190476877819448, -0.13311184998589845, -1.94691763036145, 1.6039253518340815, 0.019332046609749746, -2.0025283990829403, 1.1331561687667415, 2.0452133658210894, -2.1985645198643105, 1.0909207177178273, -0.4068440063815656, 1.1698915008872766, -0.00703385361749768, 0.6066490016987467, -1.0703802122374164},
    {1.1169180035930864, 0.7945719117199521, 0.7627323987480646, -2.7753227977109973, 0.8917149874280732, 1.011512120143644, -3.7372504581983654, 1.9164197887320065, -0.1454800922698757, 2.1718600376975257, 0.41743516936810865, 1.234836470247027, 1.2770780092433027, 0.9562887539087287, 2.019911586339677, 1.5182420562675376, -0.45228252778052036, 2.2585969579716716, 0.24759954628206937, -1.9085017781977698, 2.166121696080516, -0.13699259747970172, -2.2597553430584605, 1.2785258132382167, 2.488673804188543, -2.4563900207588376, 1.7432847886847738, 0.38437897939285, 0.9653287594443797, -0.5172909369448883, 0.1121613841209576, -1.2306129795993492},
    {1.1316207166516599, 0.49667143619185594, 1.013497234256905, -3.3182299792001064, 0.4770395423851079, 1.196501218886383, -3.7240720771223215, 2.4994404483414954, 0.04104383006474798, 2.1361891692108363, 0.7713558947032736, 1.6194040765567579, 1.3461475368110218, 0.5303534009372802, 2.092286834746057, 1.9121094728978132, -0.5193011543401144, 2.188444586996687, 0.8671800059343012, -2.840671379001833, 1.9386053034295916, -0.3999468093570348, -3.2393390123489736, 1.7469632370664496, 2.6553980906606025, -2.670862393453187, 1.9702725635404812, 0.5189052548811142, 1.3660141483255925, -0.8714457112778804, -0.17326079483959173, -1.7785624878619342},
    {0.9233575416560625, 1.2553603041614598, 1.5593393891007388, -3.2451947380622674, 1.359064871714991, 1.7775100642648896, -3.764075189880354, 2.512057828395459, 0.3027733549224134, 2.572982665863512, 0.9691122634362691, 1.8474204437880184, 1.490086298712067, 1.361061980949913, 2.4807555240040595, 2.001381302264068, 0.591828235209496, 2.023483579273151, 0.6824296671343458, -2.975272917137345, 2.3100520499192396, -0.27053729877209576, -2.862591803640187, 2.018948628833088, 2.7187046747030155, -1.9348354922020434, 2.031363971720109, 0.6877297650605532, 1.5995139187167622, -0.7198195185517843, -0.09644926711941079, -1.0064655509773912},
    {0.7691140103199201, 1.2904212145441618, 1.3792035157584583, -3.2527045436201507, 1.3071300356635716, 1.7437922684906206, -3.956349209093265, 2.928875978846531, -0.0022908358248882365, 2.8080184597253344, 1.3807848601755366, 1.9628031096061056, 1.1248576175953788, 1.6941477331058203, 2.482224780932328, 2.1240320835668145, 0.4994489986259456, 2.7352693655174307, 0.2963785128155917, -2.5603146523836164, 2.3773967751816842, 0.1990224308688238, -2.846778376188151, 2.1309655915723864, 2.550170050345258, -1.7267970895538265, 2.1766910818490444, 1.052288115988691, 1.7988599368517832, -0.5299962630028279, 0.1763038523708201, -1.4482457954336982},
    {1.0354936756435322, 1.202521162152684, 1.6536163699487165, -2.8064381686493602, 1.2404360228936222, 1.7800936003189134, -3.6557848199468217, 3.018437816585007, -0.22399892150204825, 2.923971114936389, 1.3863341102924347, 1.9181048273082097, 1.144847172400214, 1.517826603416546, 2.376018575092923, 2.100163630912256, -0.22810917011287113, 2.76432380472535, 0.5673514624185675, -2.3681585050396237, 2.6968231137078353, 0.2379439176844774, -2.6900047603105834, 2.5989286469329507, 2.723304528501264, -2.3357483902805307, 2.5013103191923167, 1.1949481383265435, 2.125522953950213, -0.5824598885424529, -0.2853367710422889, -1.428781738369544},
    {0.9781368521336864, 1.0432915871729909, 1.1715985977208099, -2.690482418688847, 1.0770062769185695, 1.283288529492334, -3.2283762525989426, 2.6690013705443945, -0.16589035241185981, 2.509184708433024, 0.9719130625260426, 1.6004587706897848, 0.9674224541624767, 1.2308830868327811, 2.565704584110223, 1.779126346673618, -0.08692067351413467, 2.365969001675729, 0.3317385921903401, -2.2724356228788802, 2.726550185771436, -0.11176405658157293, -2.271426692520628, 2.0944554016926227, 2.762525572933109, -2.4675445669758123, 1.8765187660054254, 1.1312095618241063, 2.0478318341121833, -0.83134356665085, -0.23327454796115246, -1.4421495594536902},
    {1.6919965666368346, 0.9176487694773569, 1.6021591813440965, -3.087859539564155, 1.2458881194777507, 1.6651496416965892, -3.723027942529765, 2.7964662719954787, -0.3527043693853521, 2.468717737608018, 0.8126250027921743, 1.9774813449975635, 1.1711479155135898, 0.9350838519569744, 2.382288121427874, 1.9909994598473129, 0.09283958432951273, 2.1990879161687307, 0.5798014972138373, -2.9048469254047733, 2.73512866353014, 0.08253096403740316, -3.094734078383991, 2.144319415306351, 2.994727039436659, -2.589867833239228, 1.9819051829208654, 0.9776855699515208, 2.091661428798266, -0.9158803660177238, 0.15455970049735251, -1.8379369863639217},
    {1.636362949615163, 0.6465666176789302, 1.446625279181942, -2.7146658016792133, 1.5043743593469479, 1.6316699860339567, -3.5638884694979795, 2.4381524317169845, -0.056443451019858565, 2.6182806201501347, 0.8202680928613305, 1.6384990170215097, 1.3577745245499795, 0.7067541796047375, 2.5124180342892966, 2.3288264675934465, -0.21172715347835344, 2.6684634347580727, 0.24893266573793352, -2.6622194714691365, 2.7703219261764644, -0.3332932898004204, -3.3183945356386317, 2.2410531115246224, 2.633265965957546, -2.954156129225179, 2.2054670175048985, 1.0065145848924357, 1.749019350758281, -0.9872289348766331, 0.22255652252086264, -1.1960552638773547},
    {1.3140001684374458, 0.6637644084992014, 1.925062887175046, -2.6231931494865113, 1.1705558013568307, 1.562555632252771, -3.324669294555634, 2.5138042854742366, -0.04109557669161234, 2.7162339943120517, 0.19669875247854565, 1.9181569634735525, 1.8223168613153193, 0.5137102314659824, 2.3180085725945427, 2.5104605455700386, -0.38613290981497406, 2.2984582223935264, 0.4410867763738636, -2.6571844549295287, 2.4493256968499084, -0.2782023960919811, -2.5204614023348353, 2.368616398999755, 2.669280902089282, -2.3715429971775928, 2.3106473141329174, 1.2223334404171806, 1.6345214631758815, -1.0966382676301683, -0.21661035819278013, -1.0464354132209395},
    {0.8329978165140912, 0.6566340295246933, 2.0451557489218235, -3.2312491324568176, 1.589560781148212, 1.8793928109877525, -3.885507765097448, 2.6511121972943683, 0.10578384153611751, 2.9314645938377293, -0.05130022143232533, 1.9420882521149283, 1.2615290792768088, 0.0722887963351571, 2.0659361560111122, 2.422985758561111, -0.6552160104356758, 1.3911855691836492, 0.5552024746875623, -2.895586977610013, 2.4095866039105185, -0.7681618256598038, -2.8758828128163145, 2.917607411520606, 2.817467531396865, -2.7167275893367604, 2.38090683035832, 1.5791122931331085, 1.5626921212434048, -1.9062585585169574, -0.5687858088050498, -1.2787507201803825},
    {1.182432096240322, 0.9837636805575294, 1.0151783228212643, -2.9243026796737346, 1.1046049270927192, 1.2851200834929675, -3.481962845359038, 2.3411675246387436, -0.22230506279278744, 2.428460713255315, 0.6319770799267963, 1.8103038596625414, 1.115691628536607, 0.6707379514609553, 2.149381823094813, 2.0862720757207214, -0.5166371928976317, 2.1134594621920924, 0.3220800441201837, -2.979311393390796, 2.3607505155257913, -0.07239871224370108, -2.858542374699561, 2.2866601234642254, 2.730961664258822, -2.7271461895444475, 2.238109747319658, 0.864836820374153, 2.115495076182194, -1.6040954149867337, -0.46440065983853757, -1.110993630013259},
    {1.0815211687172173, 1.582026059679984, 1.3613880440353126, -2.1600382901679254, 1.1011218423273725, 1.9311403796590871, -2.8554075638609264, 2.4729437446835734, -0.4527852419984238, 2.750713703808643, 1.8696438434772245, 1.9105933930669494, 1.1466658302494008, 1.630485252043387, 2.47125658543558, 2.1848710433448293, 0.5005674106667486, 2.9651661312702124, 0.31924525722352104, -2.1259575188896163, 2.7630249111375678, 1.0819125972042987, -2.482336626916276, 2.3968807927144447, 2.8879559050418093, -2.4266697566592397, 2.2454722374571854, 0.9675272645290108, 2.2983535986105, -0.3835861055925505, 0.8130259748080177, -0.7051919886162572},
    {0.8865872445143845, 1.042608647550387, 1.2749131939482448, -2.5569333603433, 0.7895463146990074, 1.827451083006611, -3.3089912960574623, 2.7263538693168567, -0.5909141062424598, 2.8188891199616317, 1.063816746019008, 1.5784815637137526, 0.8540213645770275, 0.8199916965592188, 2.5554196535500298, 2.4547450438294103, 0.13245955805301457, 2.658714617597247, 0.41903340241554776, -2.6645076238097443, 2.4401221724209776, 0.4263122228476708, -2.6339758244603075, 2.3818751362191874, 3.0840130960478054, -2.300058097358763, 2.2900754471736935, 0.8854133570172543, 2.0818633544243603, -0.9533413814159041, -0.10138993259924593, -0.6506511581804532},
    {1.3860485779853544, 1.2482421924982643, 1.079571756106703, -2.6658557030231647, 1.0817336010893759, 1.5586515082356271, -3.526505535893063, 2.6192813639842467, -0.13280450059796334, 2.664098513358556, 0.6705100847708461, 1.867762853956283, 1.3879726381572641, 0.5754844367179528, 2.636279182428757, 2.269262159214671, -0.28523951622874344, 2.6670453461377264, 0.5445259449050389, -2.774196745226635, 2.9354301320984306, -0.4489208792119129, -2.6849423086873085, 2.1968113872072563, 2.9301911600730954, -2.39651071052559, 2.1031994965035143, 0.9584756683533605, 2.251856519288788, -1.0323631447211552, 0.14194481823356875, -0.8054326768294948},
    {1.8471399674597577, 1.606084846041928, 1.901158618066691, -3.0825597351555634, 1.138090034451282, 1.8284701123242428, -3.4791966170084616, 2.853686616041105, -0.16052016392283155, 2.8384225446073756, 1.1268375976668028, 2.177616295803157, 1.7459425665777513, 1.0535886266529835, 2.5829182727931075, 2.3822202821735994, -0.09641048760054102, 2.9522238523708526, 0.5317542381172194, -2.8226833396984374, 2.9388473535519095, 0.32385211043635714, -2.1701170322058294, 2.60322267901777, 3.0170532639203302, -2.5348504202399447, 2.398189544695986, 1.248183771298114, 1.9815909268806615, -1.3245748576596386, 0.4449005409981849, -1.0985451003051427},
    {1.3044155508126816, 1.4336907017803997, 1.4260318967146302, -3.1378817562916197, 1.0555921396377668, 1.5832907261357962, -3.8284330390661294, 2.650396201339157, -0.18482583343347955, 2.9696047213813284, 0.93679052263557, 2.0420107717972202, 1.2916669611314682, 1.095834150678244, 2.677007854024602, 2.4563457484381113, 0.2871566672434555, 2.7472040248754386, 0.3710264608963112, -3.0495635500304874, 2.7705984465829165, -0.07548539298784766, -2.813189725653762, 2.387378719971972, 2.8442872635545235, -2.519963544185432, 2.3964275279079432, 1.0296070063159133, 2.176666868768974, -1.1093644043564148, 0.32987818718831446, -1.1642283540505285},
    {1.3013166996863648, 1.301128342684287, 1.631558007823948, -3.0021805874329845, 1.0307114295132314, 1.7098731001990135, -3.0707956726047554, 2.7932078678682033, 0.22180564721795862, 3.4074356684108227, 1.3828721591236512, 2.0286770457223247, 1.6194266589822244, 1.1272369360996357, 2.8128122029973426, 2.128298689199006, 0.343405333098566, 2.624481116733287, 0.6042354421087794, -2.7286393079011173, 2.8900118924061613, 0.30729805563631735, -2.9612203428818478, 2.6557763620173205, 3.048138692677192, -2.5478445432092296, 2.369601747001294, 1.09419216028388, 2.4258437837986278, -0.9231759810668438, 0.395345569388857, -1.1569951914260748},
    {1.2705350489438618, 1.7066886915679198, 2.0479937046870624, -3.3611821521794236, 1.1318813828169945, 2.0148521378358115, -3.5669246075183656, 2.9894956231267638, -0.1923960084363217, 3.1916259040033648, 1.328419590876075, 2.264676467632998, 1.8975221046424362, 1.133428798536836, 2.9459920488893623, 2.1298459063277573, 0.008331684616793086, 2.487995057491473, 0.8019564270451659, -3.3147343056585097, 2.6290876165967725, 0.25086394367675485, -2.9226037212728615, 3.0689235093314875, 3.2878800883800756, -2.6818259737180825, 2.4265752084658163, 1.2131595603151453, 2.703362625437433, -1.2483312001812132, 0.20763564125134554, -1.1448859999049539},
    {1.1279090966314058, 1.2493160433338006, 1.7960213887249086, -3.313083957259695, 1.2523715621922291, 1.720449198839236, -3.3653372604051666, 2.7714850089905645, 0.19241362223619024, 2.935518380776898, 0.9743169328823194, 1.9719354625063499, 1.207803236927114, 1.172811002031902, 2.9075236090953003, 2.455030677232873, -0.1807926087050506, 2.895846267694867, 0.8375181461585701, -3.4518947280770953, 3.0066505618338533, -0.20786884291594865, -3.188627400611707, 2.784090391878589, 2.780941894416788, -2.7901004130598404, 2.454296190393442, 1.501518093044026, 2.177050681283849, -1.4973397593987796, 0.43757065451477833, -1.7660923033713578},
    {0.716753031967335, 1.0906348959359513, 1.919620331912733, -3.1055045356853124, 0.8935932457095623, 1.7679890368395028, -3.6154858685936455, 3.1625841225717757, -0.17939321109456613, 3.3390622269778976, 1.0350018971922732, 2.2740426678883026, 1.3030361267413664, 1.2404274859568665, 2.8013424120650674, 2.6036379661967697, 0.15770275595711788, 3.1683762192606335, 0.9108720754387466, -3.160852396171028, 3.073362427261837, 0.2987655394335712, -3.6161971269761573, 2.3383279316482835, 3.14146203701937, -2.457545192679345, 2.434853920177321, 1.1210281371526651, 2.3576670495440206, -0.8816083918706762, 0.5540579228546302, -1.796890628524967},
    {0.9526433567947133, 0.9552897021349797, 2.051451528459159, -3.3823231887182, 0.6898319300460546, 1.654470378470673, -3.787890691226031, 3.1608304100248135, -0.4710960688974466, 3.2356483933621916, 1.0712464942679312, 2.216415312501931, 1.2628258923395745, 0.9625159650598386, 2.565463173765212, 2.53334496239199, -0.2001174818161698, 3.0627714058316133, 0.34564153141169096, -2.9647082709418227, 2.825951137112509, 0.09225753401609404, -3.2149125118554065, 2.6920275575332577, 3.170418868415147, -2.890792892098665, 2.5155871171627187, 1.1054573474797458, 1.7393641007097775, -1.3888264548403741, -0.12382338599428025, -1.411350469948575},
    {1.0826851757057028, 0.8562026655542251, 1.6151657438765328, -3.522695327759497, 0.9904735002610366, 1.5388338921265603, -3.399399280019556, 2.894001880420772, -0.265877761375366, 3.308195679845997, 1.1943514228105665, 1.9795940872355269, 1.6708200306248462, 1.0597586404462471, 2.8432085318836138, 2.5356450822971173, -0.5085296840790792, 2.934121262245945, 0.7361347235878616, -3.4880569780567914, 2.9572406849263895, 0.31240246496787916, -3.0118501315475004, 2.58718431138833, 3.214816445570638, -2.84158445843233, 2.4926183910469613, 1.000743668884531, 2.308798670282176, -1.3463720544724815, 0.05940955314903294, -1.2852359951230012},
    {1.1863109525984785, 0.6476083692074706, 1.9483075750923071, -3.6616612918246045, 0.7489571455194854, 1.8945275570601219, -3.595254858970495, 2.748292043470657, -0.4934247290682214, 3.0332274795451806, 1.235305848937933, 2.2360839954927108, 1.646895410058273, 1.151634165598404, 2.596415657062602, 2.7567677732585607, -0.5488171479756633, 3.0061477091628697, 0.6284974397706566, -3.4855709755084514, 2.7790613300815523, 0.3640181133159764, -3.371880942411631, 2.6350387609675354, 2.8339724463167566, -2.769789453304523, 2.3936341559858723, 0.916167584901683, 2.303342794706506, -1.6945122900521052, -0.22692136416424072, -1.712149777146423},
    {0.5991376293498394, 1.1731756753686184, 2.074804547966013, -3.396386084445466, 0.7620100867533325, 1.481804131280346, -3.5184438302653507, 2.8056184005309515, 0.012926705439643676, 3.0614984657043576, 1.055013755540801, 2.1898796947535293, 1.1038634255166735, 0.9084489363092617, 2.7656747082154225, 2.5265641299282087, -0.5275693736502876, 2.9188970919250874, 0.5145528070416445, -3.430460348880688, 2.822829524568642, 0.0633137149290557, -3.2375396234935074, 2.6204975956002303, 3.1946106645945767, -2.9331295555810795, 2.394078005248296, 0.9286269010298064, 2.3225749769478847, -1.826962694650113, -0.5253924275308913, -2.006727973769476},
    {0.8735926297645448, 0.5960079085824636, 1.7181116299051076, -3.361550896440702, 1.0173889097605116, 1.2123827352227174, -3.695599624716388, 2.830463578075855, -0.27420142353178795, 2.8371445199573593, 0.8938736473662032, 1.9305455870238843, 1.3463004472944577, 1.0559344214439195, 2.7514828861161718, 2.5995771275156594, -0.7969576296384923, 2.8249581896913116, 0.235216275126805, -3.26874252209022, 3.0033218641989508, -0.2566182388514662, -3.226459013334585, 2.8722965408965444, 2.911686702874608, -3.1135756409474777, 2.203284838799812, 1.1795570789817067, 2.346470130744078, -1.8356872522825043, -0.6564058734829047, -1.903206273195789},
    {1.1133066984362905, -3.3200989679102584, 1.5143543169966898, -0.7840209835346281, 1.0361717780251927, 1.5227003054406325, 1.368835071498713, 0.7281131775684436, 1.7472143043778512, 0.006002283128536634, -2.2627933265163866, 1.289301305638088, 1.782712178088153, -2.9166786451084734, -2.248044121528531, 1.0818754099434258, -3.305662008272913, -0.13358009058131898, 1.8952948091384454, -2.1083012299268864, -0.6336549108754026, -2.5542521157254208, 0.8817396461930541, 0.9950453599389364, 0.5784562196897421, -0.54789189591846, 0.8497982970982055, 1.715655942290635, -3.123434609852723, -3.22451317723539, -3.446188472112886, 0.33070530849334334},
    {1.5095066832567003, -0.6764086678310374, 1.7489370692633932, -0.7625864154678095, 1.5077571250222648, 1.4931205799803273, 0.804227860003608, 1.103142503061557, 1.13902716006812, 1.197961650113762, -1.0957071645760579, 1.7412865817838676, 1.6503901565979309, -0.837728358998349, -0.6214301420800905, 1.6999959817882695, -1.1071097426967127, 0.020664856873144094, 1.7904488836668826, -0.7499869178960715, 0.9705495279680435, -0.9094214799524425, 0.5589729300996291, 1.4746379042099789, 1.201909616076437, -0.3302778669093494, 1.5085454327379348, 1.8673288689626522, 0.1967160275100441, -0.10749694648861145, -0.43972256197909565, 0.7915522633069418},
    {-0.8400906415212387, -3.1846621486143682, -1.000296915110697, -0.3081772241966545, -1.777815455891011, -1.0699025467503616, 0.3660290471964709, -0.9206932572326408, -0.6941253929244517, -1.6275489571107766, -0.4394713207012175, -1.0002484715941156, -0.4128258483519762, -2.809156126369671, -3.0356905876435136, -0.7050337309988041, -2.947075936582066, 0.8434246048955464, -0.20651409422698547, -1.9199004070530072, -2.273890756962036, -0.06430825377280848, -1.3784882385202584, -1.4218817457775326, -0.12813719957328998, -2.0986446974316415, -1.1323497013020691, -0.8128853629776515, -1.7126619450821046, -2.238204475987337, -3.1458834455019646, -2.1121205638930767},
    {-1.2327901293719188, -2.6263310035350376, -0.7924543264437253, -1.5759593033628847, -0.9271101113906752, -0.9934022061605853, -0.6292341717245968, -0.5586033028289441, -0.29533646194652813, -1.8861912471819984, -1.1499919978575448, -0.6694979490719601, -0.7283285586169865, -2.893271975826526, -1.8970411870378712, -0.47391363397757524, -3.057526675159155, -0.018551126406078703, -0.4550878375411767, -2.3120220076657656, -1.5182235365927954, -1.4175138726388752, -1.4525511268880182, -1.1384983187473092, -0.2540235328348946, -2.1534762761774826, -0.626939773331885, -0.8024179625170589, -1.7819072438784305, -2.2006469769565054, -2.494157672249598, -1.6360765414989242},
    {-1.0521593751619347, -2.2698836093542893, -1.3998720629051145, 0.32011280494161976, -2.242543080025468, -1.0724126531341303, 0.04091136248926611, -0.8710294610257474, -1.2346268411859178, -1.550912237757876, 1.0191789606630723, -1.534318967672178, -0.9216717492619046, -2.5980202506131223, -2.669614827477255, -1.1164931071049191, -1.8580841631472271, 1.2401090914973985, -0.9941170728285151, -1.648312651732918, -2.0165458666754046, 0.9323215177597076, -2.1281556241764017, -1.8078732709890484, -0.0717092331318022, -3.091959422141937, -1.152133037687395, -1.3340615226273185, 0.5915788382919328, -1.0841508850227266, -1.1151242709219562, -3.01617937537194},
    {-1.0861214080265948, -1.8662136613826974, -1.0277008734122366, -0.6062904675061882, -1.7458623091890573, -1.3512640933980022, -0.014758043000345814, -1.0629753324583318, -1.8605104128743657, -1.2738389857664019, -0.18120044801040683, -1.6861153986474988, -0.9634062041818332, -1.8358971772387687, -2.265235205139595, -1.0937880930703103, -1.7393218890544055, 0.4075320266279263, -1.5313392197576685, -1.4416309958783005, -1.8048497275351432, 0.5156230145545434, -1.7763732821441045, -1.5536288528221331, 0.01132336567238431, -2.5992572646279655, -1.36220511242505, -1.3041200427729978, -0.30931971484275717, -0.6600632509272224, -1.6254131294860423, -2.5089387696293954},
    {-2.0657832816828385, -2.577720431588343, -2.0850143097004032, -1.2305530675077192, -2.304680558221596, -2.3812506564401734, -0.7489215441262022, -2.199844029519528, -1.777066737363486, -2.3104226830073746, -0.7460100659952846, -2.019159572237045, -2.0808785852290983, -2.8111648068210506, -2.891069157669742, -2.170418071568169, -1.9413889103811124, -0.20337185638050403, -1.8597497894308819, -2.2535687986521387, -2.513608031839213, -0.7356290639450307, -2.7417162055353272, -2.4462509888237256, -1.3528736170179874, -2.7901970935940925, -2.025489672673421, -1.568592960396224, -1.4309427038451208, -1.6810522300222621, -1.7906941880061682, -2.8848609314419615},
    {-1.2517501629413874, -2.3487032047583583, -1.0048251635467875, -1.039019688060899, -1.1727426440063673, -1.397693679886078, -0.020219022047458002, -1.6067653773437358, -1.1186979741925678, -1.2329266501079794, -0.47662585615335723, -1.1094723185468494, -1.0819149699308437, -2.5136378988333963, -2.218808354465266, -1.3327604719839095, -1.7261146304351613, -0.365174684391912, -1.1825200019874003, -2.1007032451867347, -1.448749301081286, -0.4739473191310313, -1.8301697747780963, -1.0882214390431755, -0.6628780925487597, -2.155742162818818, -1.2449683027187157, -0.8169776513219179, -1.3700767095032684, -1.0889113995867672, -1.2953330440994357, -2.0877749091806796},
    {-1.728288587755508, -2.5883753762439983, -1.8420312962111416, -0.4919871481499169, -2.2982325992109054, -2.2060186601590512, -0.4764894736798083, -1.3577858127781501, -1.538976189125538, -1.816157850242237, -0.4120858090998107, -1.7545961299463437, -1.4403400415751302, -2.592928844280755, -2.393017690958662, -1.3729139779970931, -2.016446984510616, -0.006431697899714774, -1.4093158177160452, -2.117268436850857, -1.6729111320194203, 0.0026400370515120117, -2.3217867826276297, -1.468970098829207, -0.9323076145472128, -2.5724948938138534, -1.4429293600275903, -1.4583051299596688, -0.790487847823607, -1.0804753297978607, -1.3846119495849907, -2.4284052762029757},
    {-1.6404685922630602, -3.129078090889525, -1.784503729131094, 0.7458949509402378, -2.228949343240164, -1.9321059984974815, 1.0052980043548878, -1.3012710471578746, -1.549275054785757, -2.3222661109658334, 1.1114262133265476, -1.9097924164241806, -0.8589716825706912, -2.5168393869099672, -2.612642633192387, -1.1400313308270529, -2.2441509162943847, 1.2034432283230836, -1.7397212190596456, -1.9056976021122545, -2.351316300737137, 1.5534844546056144, -1.5040255822848638, -2.271985232654233, -0.8657560351320602, -2.4920558445155083, -1.5108375036528752, -1.848521083189977, -0.34749421656499563, -1.076037466090239, -1.7620012851271576, -2.426179134428058},
    {-1.5702585929165274, -2.7687128975194404, -1.2826241305068524, -0.4944970519770475, -1.6828836879511098, -1.0573587676506346, 0.7137069392331167, -1.468126221215266, -1.2019606758282486, -1.8676779745621745, -0.6052044484021937, -1.1868537671135826, -1.1344265495878971, -2.9970166912466847, -3.0356792016154635, -1.2263710846693494, -2.774623819084118, -0.5627370493723827, -1.569591926104278, -2.813340195595295, -1.5562942300649205, -0.9114994548095088, -1.2499887825831837, -1.7691685317916996, -0.945555886621536, -2.175303536036083, -1.1712758680354163, -1.4404660440177008, -1.8110998184931395, -1.9516409799314776, -2.5815068318409518, -1.6767331503136638},
    {-1.3270877906680745, -2.923232196781837, -1.5647147417480758, -0.42576991410795473, -2.06119157197937, -1.4389875441922415, 0.8335255539617025, -1.0449593725998316, -1.6680573561165957, -2.079801264963165, 0.77355847608549, -1.512284814720419, -1.1935758309348563, -2.6351730583064583, -2.843964927665724, -1.493017750898313, -2.2762789547904365, 0.3641468440105058, -1.0921313020149543, -2.5499969181761784, -2.094985422735243, -0.2158850378714541, -2.074457856419371, -1.7795852574850748, -0.42869470802922877, -2.8469019946110605, -1.527207950369803, -1.343412893014217, -0.6515108995704284, -1.6993996670416176, -2.39960310357227, -2.6484556040245217},
    {-1.8607322232900194, -2.8293750217201623, -2.1141244772760324, -0.7922486417499777, -2.2463624212088966, -2.0473130084034854, -0.17255783431384827, -2.0321049266765447, -2.1024785616129, -1.95712518834911, 0.2597718343869441, -2.2190488954637715, -1.422676856731582, -3.2552809351013394, -3.0073131618984, -1.924001790821384, -2.1769477656805254, 0.2512735595756013, -1.7167298949776033, -2.3160739781144097, -2.3225845942614565, -0.2032195150986941, -2.3452305940919476, -2.15443723478572, -1.1364150005273808, -2.6028958934324824, -1.9213228225339196, -2.0165897819040937, -1.3845468608280564, -1.7281406065645066, -1.7905713087365922, -2.540859620178367},
    {-1.2972775645838848, -3.0679661372002913, -1.6289470759104625, -0.8237148889379705, -2.0847296066693133, -1.7367039019454802, 0.139434202304916, -1.501441190792593, -1.3134136532385852, -2.156202283891868, 0.3791709542148526, -1.682168778514488, -0.8534738224891867, -3.016243908953815, -3.1692149697119265, -1.582213813452705, -2.785795733846339, 0.6062052556245929, -1.1809266871893507, -2.43237385531755, -2.079993717577756, -0.16568624694008852, -2.0388670019920494, -1.9777689511535697, -0.7861163063467805, -2.9254235423896096, -1.5396917813313105, -1.3587157737725448, -1.4249703708418697, -2.028673445033932, -2.4070188882599037, -2.945131534210677},
    {-0.27873736685011036, -3.5323303913713215, -0.5087085534672864, 0.2149878675977096, -1.5890803568240697, -0.48218529464217397, 1.914265775671159, -0.2159756221479441, -0.13383628275449858, -1.4985557901206212, 1.23496826084892, -0.5847216683395684, 0.22800278808249194, -3.2374842368703693, -2.9087113296211498, -0.6620618991788308, -2.939546098456211, 1.7011883631376572, 0.360933207862785, -2.174196419695156, -1.9239957750195251, 0.8552648692051691, -1.2756014702647753, -1.367329318098168, 0.3736821407554777, -2.424349683836879, -0.861835423405801, -0.5606055796238559, -0.7028475795766262, -1.6150389275429828, -2.643094683603718, -2.630673435757701},
    {-0.08057698361660996, -3.3212540820371865, -0.6108060656137951, -0.7712936013868862, -1.2744441755208005, -0.7004432742583365, 0.6177812737189915, -0.302367142821152, -0.9156110489374688, -1.1343192923691319, 0.46760772911529336, -0.7950482999568362, 0.1952077794971385, -3.0606167077267963, -2.9310933651529725, -0.27820011557609947, -3.0852613983568284, 1.355530673704427, 0.09305375038526062, -2.883144162011894, -0.951323472781065, 0.47143767849885515, -1.8507015361745784, -1.1422370968559223, 0.2504564070906092, -2.971331931536952, -0.5190530277238018, -1.1104129114376682, -0.8018093138661508, -2.2614416347133584, -2.794209994460161, -3.031748227575962},
    {-0.2711588900650914, -3.4430147680998786, -0.7524608446809313, -0.4489796293381116, -1.6473948018198687, -0.5956715761786975, 0.5197949901764535, -0.9656927583917623, -0.4924798585965972, -1.2524497295606014, 0.008738020731116541, -1.1489483556323516, -0.18752251257840535, -3.333661008503885, -3.1590795658471507, -0.7897139837593926, -2.9626468977999183, 0.885864223901712, -0.22112325550932518, -2.960777304578651, -1.4881985352079938, -0.6421514175414776, -1.7099560694983897, -1.1911706135456217, -0.16254914958213337, -2.601830531002864, -0.9161010121144786, -0.5670600084577295, -1.0215461563665424, -2.442451485840665, -3.007552215390432, -2.8025557319257994},
    {1.0116300596199552, -3.424945882269532, 0.676348960617739, 0.17538195668203133, -0.4860991282041357, 1.0114274481471848, 1.5664494143946117, 0.14827723850566377, 0.7884037323085006, -0.13309411689185405, 0.8384200660572915, -0.005857855204086693, 1.4656710548264675, -3.3471424645111227, -2.2602829441321957, 0.7451460310251963, -3.005960631064545, 1.9102452670228722, 1.2316186516755327, -2.3677495483403415, -0.957214144240213, 0.7051741025153594, -0.8238451591808558, -0.08090354915178218, 1.5833204258848252, -2.7975945667458073, 0.489251974515799, 0.5509084356517612, 0.1433942225267389, -2.2163937197495236, -2.748887859514595, -2.1712912653740495},
    {0.9395827831169928, -3.985276484501182, 0.6947062088825838, -0.47480760997874294, -0.13875807687068858, 0.2151703415105859, 1.1541853467289722, 0.1424430685159464, 1.0646586208547169, -0.24358056567833117, 0.5067575092715103, 0.31288186579711796, 1.2623853857928538, -3.4537507582609677, -2.464959949049943, 0.5027699898959577, -3.1268217370042097, 1.5398512602569248, 1.4975839493543261, -2.90917995663138, -0.9680284473232926, 0.15466784561115002, -0.9208083290891981, -0.3860562447842685, 0.7941549573214063, -2.501390202751913, 0.3944045124410396, 0.22206826748475497, -0.6542096638681867, -2.522678042474609, -3.0981194105043026, -2.1662718390964986},
    {-0.5561070460587946, -3.8760649128395173, -1.3093531329601935, -1.2935796017006365, -2.1291829672754123, -1.0480278379236705, 0.9805329194074344, -0.943032992514696, -0.8359214651270174, -1.686333304624808, 0.13305707010916193, -1.2498060509325926, -0.2416872478645748, -4.069388393140394, -3.5661200270960216, -0.8241032283851805, -3.4704072986291186, 0.7278613530690489, -0.23755535866467656, -3.002109706485274, -1.710465756995387, -0.377918708367756, -1.9714064965386933, -1.2911181214822776, 0.10476280165432951, -2.945087803359339, -0.8990049243777137, -1.0175725163962879, -1.665758406681948, -3.0380724930638556, -3.8732423855189277, -3.2718256104886243},
    {-0.3104111413510514, -3.574408578109564, -0.9377355429148405, -0.5398885431415674, -2.0017994734363347, -0.9924342334858071, 0.9846040908289104, -0.6657827184653116, -0.006134547867962416, -2.0628810806374607, 0.6461327537664859, -1.3531642541263786, 0.2618417929942291, -3.7132010309995342, -3.5706879798845668, -0.5645239087877554, -3.6294310008078794, 1.4574441206086461, 0.27385352374569044, -2.956241208916546, -2.6167167257005177, 0.08572880186638446, -1.8301959112553707, -2.1628545395926717, 0.4377807303055518, -3.178708420670796, -0.8860248367660507, -0.467742481448776, -0.6096469023999074, -2.8206709926902245, -3.264192412459627, -3.1586403649792754},
    {1.924318761596146, -4.515033170947393, 1.693561309876534, 0.2544714386946378, -0.5601695827272454, 1.742754436273188, 2.9559273961957464, 1.7199234115503559, 2.1193157194069667, 0.2639109241141036, 2.161148024248801, 0.9216189863091362, 2.5331925808891502, -4.395452325720616, -3.344284345690098, 1.550112678508147, -3.9917400250215684, 2.7339823181797347, 2.2217690031576924, -3.3656758676307517, -1.3755788346994668, 1.763228861233915, -0.2914170609344972, 0.4462330104069841, 2.460816467662885, -3.1647997957969394, 1.17142733848124, 1.4187478588962685, 0.24659830680348185, -3.078417675663693, -3.9972476743992487, -3.0346227591382138},
    {3.0783396632467976, -4.618846607791212, 2.945680820253548, -0.008560369833566457, 1.0508002016099875, 2.8707609184162948, 3.567073002006634, 2.851056313375409, 3.1457364370949814, 1.5740849096525127, 1.469475592872675, 2.3580904326676584, 3.5190415270570505, -4.656005729045786, -3.335138459929602, 2.6529501759407697, -4.619739142404867, 2.617001807138373, 3.570594653027925, -2.934778666966765, 0.20313551547699193, 1.0936269330015163, 1.1171780164172778, 1.791593967120693, 3.0104136135418735, -2.0684795534677223, 2.5268359181081412, 2.7924769648018946, -0.3744299760372983, -3.944352223732459, -4.573331672108819, -1.3512632790376364},
    {2.1073372824522254, -4.896454041758096, 1.9132211310432554, -0.5880159414492835, -0.1894453810745087, 1.684461164810507, 2.813394947923732, 1.6274886760833795, 2.1383857352740656, 0.2523392788921023, 0.8531973724142918, 1.399348476334156, 3.063776200320291, -4.359510663478605, -3.6422536421855947, 1.9141570216970565, -4.434984152285594, 2.154442173072508, 2.7702660381359827, -3.3585456697341742, -1.0915523053537188, 0.27643943810800137, -0.4256209965034353, 0.4337710736129745, 2.3240039912947035, -2.6089355194404473, 1.329532555437735, 1.7338336478874625, -0.9825448261148607, -4.007184093319076, -4.771231810889962, -2.4534119361170346},
    {0.5972261009680356, -4.469518789738237, -0.035938975691721456, -0.8295271015905595, -1.572279633342366, -0.032509645527205554, 1.7357176729040025, -0.24982089411402353, -0.039317802856047586, -1.461811982141894, 0.6172669515608971, -0.3923561899638811, 1.3794112792051245, -4.2053502433669285, -3.6756864568782817, 0.3769868603008218, -4.279276930431419, 1.2850199604729844, 0.5487699675726013, -3.3738694539771856, -2.576167063807811, 0.012613190505165777, -1.5540367030527618, -1.1814771517210578, 0.9992175291512874, -3.2384974826557955, -0.11420118695085987, -0.36822809650149596, -1.1635370641889693, -4.0096034308924935, -4.493308657997752, -3.508684402768773},
    {2.110500092010405, -4.846806286217818, 1.7337956137318684, -0.7541072021626005, 0.16548793313295979, 1.7944951957339708, 2.4448036304037366, 1.3298421271673806, 2.3038189873360384, 0.30745530677175675, 0.8387157890258411, 1.7124147747233427, 2.749466836969321, -4.7862072739583335, -3.209269169732032, 1.9742468387093668, -4.656895716379789, 2.0297695688750585, 2.7056740745375203, -3.8075294911919473, -0.9803944190086096, 0.09852106887156975, -0.7755183751603179, 0.5357765989735293, 2.200224677697966, -2.894636494195697, 1.5491434575989484, 1.6312422574620915, -0.9174325053140975, -4.220075335511997, -4.594088184489226, -2.220801082559367},
    {2.0904816765274763, -4.777897546404724, 1.8834177688253102, -0.21596485746313984, 0.044495919514900395, 1.8987262108131755, 2.8793935343867396, 1.3058712729815547, 2.4634737762582564, 0.1205956131081133, 0.5405948780411574, 1.526899648364032, 2.4599768561091717, -4.902264636175857, -3.9251720299679143, 1.91966930398746, -4.6723435189441265, 1.957363589759084, 2.4684692181148877, -3.671816729817955, -1.1503158528658413, 0.16252412580714062, -0.2883804005033269, 0.4851656098348184, 1.8126466404255654, -2.982739396724364, 1.393079266173642, 1.8636375554661324, -1.8995135857727568, -4.260827776883604, -4.5574363533492015, -2.547628877693025},
    {1.797495127771837, -4.564742118096014, 1.38672507517316, -0.6075485495447289, -0.18520780374661666, 1.9187040983015347, 2.5997544355973234, 1.1020120484828084, 1.8133116368859823, -0.11011711144658018, 0.5967028231624958, 1.349851430912449, 2.4987453985755965, -4.753100690893531, -3.6815787825098685, 1.7979092971599762, -4.357095711118239, 1.9068247420111992, 2.2427032379244096, -3.7159847726161948, -1.4851031726004011, 0.29104905057790503, -0.6677810564687214, 0.30585229339023484, 1.9821696286340713, -3.3502914434402564, 1.1271925524882076, 1.220766181768127, -1.7102112990448928, -4.027914260673398, -4.821910400137591, -2.9117847605086347},
    {2.2274120018556607, -5.003364146467891, 2.1629869351770257, -0.290047283198322, 0.19819626891037362, 1.9286942320727032, 2.8044737458235787, 1.9433393189792278, 2.3431846206155704, 0.49436203026662767, 0.5732371378432046, 1.4427365430177994, 2.6415552481191957, -4.581152355690883, -3.2244291739105053, 2.0843278908750706, -4.849344693568249, 1.8452328696564604, 2.9704475512478328, -3.48931868939641, -1.0325844038008334, 0.23119637728351136, -0.09925219351381355, 0.7801022313156198, 2.4158848577430776, -2.6071847936809065, 1.5900926311596346, 2.0526282846278066, -1.511625087280415, -4.382690407536808, -4.908212590010788, -2.522957201476583},
    {2.6697474722118053, -4.85691943805576, 2.1476599391584323, -0.5572284307556682, 0.428417496781759, 1.931910976850199, 2.9113085464049724, 1.8112754489402647, 2.3591874310566645, 0.511578004524233, 0.8633182126937506, 1.6966869097801365, 3.2172459063150742, -4.587804003012144, -3.6921648667010905, 2.1164041864180554, -4.751962717014052, 2.1774604619475197, 2.9705204222345407, -3.3835875547982956, -0.5850532621964945, -0.017495236068931958, -0.019828706401559478, 0.44150590973022363, 2.414000362741144, -2.6639944427261226, 1.498082979005075, 2.187260476497083, -1.5284606612209382, -4.432270109893043, -4.79098607502171, -2.4002401431198357}
};

static const float b1[32] = {5.5236319052419605, 5.778272346815801, 5.608123226092747, 5.934355272473039, 5.452151132429951, 5.592120380397301, 6.06826831774678, 5.424695120588006, 5.6603022151097955, 5.504199632276756, 5.861637011976885, 5.3646071600040575, 5.610135545982939, 5.7323056027447, 5.62685214388193, 5.423957514548399, 5.767625692129625, 5.764799156420457, 5.629295407802926, 5.860448880692523, 5.4796344029882205, 5.671135933849276, 5.858500243627098, 5.502754153538638, 5.190188128788557, 5.8374290903012795, 5.303775934648758, 5.513771336499288, 5.776497695431687, 5.512799509867749, 5.706874568988136, 5.621137718159588};

static const float w2[32][16] = {
    {4.047974919015466, 4.804445382304495, 5.287822699541783, 3.9840584465090343, 4.641052468563741, 1.6149631690606885, 0.005300142109235495, 4.5606439884897725, 5.070078558986593, 4.780697298912065, 4.528087909030353, 4.443479679971531, 4.816303129746258, -0.2649125433925693, 0.23984227010959502, 5.2408064346762995},
    {4.852169804818163, 4.714060726150114, 5.076777221210839, 4.405306265754718, 5.116038902469379, 1.95211144909211, -0.025061866700957995, 5.209789279484931, 5.149502632430295, 4.955517974424826, 5.322251837080166, 5.070470945624154, 5.458272865047925, -0.06343317909046808, -0.41915423812003383, 5.189354578799798},
    {4.284823430635124, 4.271807164459752, 4.975467508790529, 3.837662277650104, 4.356427074159318, 1.7649759339102966, -0.37229454360454856, 4.544466796881951, 4.701009317829449, 4.11702852598276, 4.4656387091819285, 4.053000163964002, 4.851303103496346, 0.12905690703342074, -0.04025238036847844, 4.430301694901751},
    {4.745419447844038, 5.3459101739864785, 5.320839308032482, 3.8760900728677035, 5.31645727090056, 1.9792908942092275, -0.10852863872360033, 5.573076422601901, 4.585284605928943, 4.991254329859341, 5.342999297207691, 4.767840145856631, 5.76282932820809, -0.20539352134700253, -0.061645920422162624, 5.174130299002058},
    {4.326408556717769, 4.128553365383637, 5.109528217393876, 3.66742948384465, 4.61296788166606, 1.7556769950502062, -0.12834947207415007, 4.349912618703864, 4.698529157513433, 4.305324571262953, 4.467135832203063, 4.842090458487939, 4.926433951467203, -0.32242818388781863, 0.09404127729408535, 4.451431033706317},
    {4.310761353023871, 4.383401212123607, 4.43531078217686, 3.9494479387263404, 4.707541261071121, 1.905345733574366, -0.5431060609008083, 4.911164959825487, 4.460251942877327, 4.525768124906936, 4.298469524575265, 4.34849210947769, 4.5622456189331375, 0.13081076714178796, 0.23529455128894267, 4.76650514559487},
    {4.964826989916738, 5.227802669448443, 5.832955980850608, 4.286245774811059, 5.723323377002138, 1.9427339940483233, -0.1084879375122621, 5.252365993669864, 4.9471829297991965, 5.010999957078936, 6.197215624915369, 5.296206156459623, 5.572776363533793, 0.0015595438998701433, -0.21867247534647619, 5.154463933765412},
    {3.7529564590741433, 4.675737611097181, 4.699617167385039, 3.894129440149218, 4.888774475243032, 1.6828973513754266, 0.11632453767061245, 4.877529443040331, 4.430287666854018, 4.728559181682853, 4.770848861592704, 4.30270234654945, 4.910185038282781, -0.24876684242548078, 0.19544186791804583, 4.555857556363921},
    {3.9636275575340307, 4.460937426052614, 4.632908863470368, 3.907869762584846, 4.835124803868538, 1.9358998815557553, -0.06751734152514524, 5.321272851394387, 4.580426188374464, 4.716337336997268, 4.791931989093181, 4.679687594802622, 4.7813317913988245, -0.44485292309297025, -0.4971197246690362, 4.801854349265926},
    {4.052621521418372, 4.216627746891563, 4.97949872639307, 3.899834722506001, 5.020622878463313, 1.6876257109721138, 0.22887199215444293, 4.451619203812802, 4.666790921159187, 4.484106839058862, 4.146676588839415, 4.543827236620931, 4.7052405106528745, -0.5559299208794031, -0.21266776075741603, 4.9221473502048685},
    {4.752285279343854, 5.127132944661889, 5.360752091033636, 4.895473127130181, 5.358954461602112, 1.8445530076554033, -0.3828252978766256, 5.120730305246427, 4.675433590733471, 4.7791721639141, 5.254741368724948, 4.0326456503812365, 4.63861634845754, -0.24294162167613384, -0.6598226422977118, 5.1259968342088795},
    {4.07047381067175, 4.16922687968742, 4.810131552106704, 4.019250319394129, 4.581636071280073, 1.7558612094159562, -0.2580779143124388, 4.170993550448603, 5.140219740667997, 4.658453614894677, 4.5740074633409655, 4.333167380140301, 4.793973427492363, -0.03910849017091177, 0.21245511298430214, 4.664574508135508},
    {4.621549850907862, 4.307823539739696, 4.377712408405675, 3.8694886187320017, 4.803974045797298, 1.3320310021581354, -0.26929923256098126, 4.96636538039565, 4.895440945633802, 4.321065423641092, 4.727798637121015, 4.61894107056673, 4.420890129439311, 0.2560977204482209, 0.026603877411752706, 4.610216009674968},
    {4.8313226475290225, 5.194622864003464, 5.6298712825786055, 4.587675638912742, 5.484602586457613, 2.1002051882584674, -0.009105969249274107, 5.043286152704586, 5.3956076538501, 5.879795631287154, 5.306357351733204, 4.719223893693759, 5.47076879936666, -0.13656647933067245, -0.31763311030753716, 5.346632629408791},
    {4.1895796905885545, 4.956584527385675, 5.279749741929423, 3.9798520693427637, 5.410323511870576, 2.3038955984384133, -0.05111209784905104, 5.273033796705996, 5.005366971104444, 4.766415004371241, 4.659317443334496, 4.895452391976111, 4.711599666939813, 0.0793691473205069, 0.31688524202213525, 4.850494771167119},
    {4.141752250723646, 4.414861777862941, 5.104083804891258, 3.853581488462857, 4.62814536668264, 1.8077011901662225, -0.3629308103061724, 4.3278751835834575, 4.7835756866873504, 4.785663999098895, 4.440861522726231, 4.4585405221411945, 4.683912711113349, 0.10233161642026205, -0.3015093686155258, 4.520509943958887},
    {4.071949198061384, 4.906427771023566, 5.398763927711181, 4.331568049698807, 5.229228624302221, 1.7795073443031144, -0.08570365695254994, 5.259470730911882, 5.055006273066524, 4.6043861023765436, 5.53458782282077, 5.185552520660863, 5.173226396156655, 0.3391938133326707, 0.15931968121619297, 4.933350751217529},
    {4.576766852900773, 5.023600718437361, 5.006099979780252, 3.6205527529410593, 5.389242382892689, 2.053854792154979, 0.013960452012619147, 4.880027871514952, 4.84665586466842, 4.964336152523998, 4.928058566174647, 4.989562910006468, 4.900224485539175, -0.48722919807649634, -0.4997902051909127, 5.056291595669861},
    {4.154978330281986, 4.601888189291758, 5.093882904569892, 4.043032681067477, 5.27970317258492, 1.8082006506193324, -0.03215493402264525, 4.6283706709892805, 4.476320613895685, 4.550712359602861, 4.3434087182709735, 5.022474348986674, 5.137299708410116, 0.04826691726750801, -0.2954978005631916, 5.026247268309868},
    {5.186550605950459, 5.327341064630771, 5.808259285821207, 4.916280224722675, 5.106315226453457, 2.4417115093788775, 0.028736043671434272, 5.5192881221587475, 5.3728002439004285, 5.437685382348455, 5.329814960146743, 4.866393284389839, 5.2182287753488525, -0.1342279260011757, -0.06548432524376806, 5.247959116263328},
    {4.194834124484283, 4.153091415654929, 4.735307996338042, 3.8132060588566286, 4.323989734056446, 1.4984620943321278, -0.1911226728649247, 4.711071891956467, 4.6308842278243905, 4.178342464531323, 4.73656761958396, 4.185375230940678, 4.534841625406832, -0.14014424868694889, -0.4413593907863798, 5.144054867467462},
    {4.623500217818316, 5.035708427970548, 5.223727545742891, 4.4482157590704166, 5.130642346492144, 1.3255505849559204, -0.21216679940851385, 4.797034112599032, 4.66825597094311, 4.6409715164448855, 4.821084277456022, 4.990920344208566, 4.708977580768273, -0.37000929126585086, -0.08612743960388189, 4.7425310098940745},
    {4.7835285226461455, 4.811098259446411, 5.643300781642187, 4.324195036471596, 5.404115736273637, 1.8186689371788016, 0.29681860440781976, 5.285003377883467, 5.1048443453248264, 5.075636534902493, 5.012755300597351, 5.444773223600591, 5.1923734759340325, 0.19220731715005313, -0.0020233273331612027, 5.0743084134626795},
    {4.2401241774655665, 4.781706671699039, 4.639728790438074, 3.561526026109789, 4.614607920929245, 1.3602565347764333, 0.22163367773383622, 4.455423527458774, 5.074008098628199, 4.153224113398678, 3.8114100850468637, 4.29372890626919, 4.917685882141795, 0.035023614008246384, -0.295079838791908, 4.592098640332461},
    {4.726228669808296, 4.587523089203418, 4.418973272115105, 4.099469362760701, 4.577206989201248, 1.6610863048779672, 0.12067887109528176, 4.3633043808662, 4.998982635930452, 4.391032678874293, 4.564981143465742, 4.761899862978801, 4.840047912961202, 0.014183568047424832, -0.3801548150372692, 5.0413013915036045},
    {4.617543198311228, 4.971484887537781, 5.280706726536458, 4.532556390419389, 5.196506049687275, 1.9137375564582275, -0.39836134632328907, 5.140299787326897, 5.608247324267619, 4.453572673478352, 5.356900645658524, 5.220407091671226, 5.281078841410692, -0.4788692083482153, -0.36198225600207645, 5.63871148273415},
    {4.14234001015228, 4.460850517374732, 4.564087281523242, 4.037596669637393, 4.444855135897832, 1.9056145673605303, -0.11343268065523936, 4.370281217303031, 4.952716682371115, 4.261157238075199, 4.464916441799724, 4.434564299816222, 4.515213033374559, -0.13190941349725271, 0.25137336434516705, 4.568645888431553},
    {3.9889206400760644, 4.1365289035303, 4.460047834775064, 3.6659154274371475, 4.466790869017493, 1.7175608768767352, -0.4457584626644006, 4.704434335699709, 4.551607759110667, 4.370080365975636, 4.44077586345966, 4.744912179156034, 4.601564717168466, -0.5108366762222417, 0.15407498645549086, 5.112620240283588},
    {4.601777509674383, 4.899559279491798, 5.075040980480463, 3.7658611832838274, 5.28608045726932, 2.112362226488668, 0.07571869047692467, 5.452088397160513, 5.11168016913461, 4.765455607397716, 5.196578022718084, 4.835205383965991, 5.339432244719257, -0.36284333625928356, 0.011919869058942564, 4.5953206361496886},
    {4.631040206929257, 5.174323533805104, 5.120350264113318, 4.302627620782729, 5.270383861760085, 1.858655996012256, -0.16228268777435648, 4.9475226218639206, 5.324840834764413, 5.202612228882433, 4.869017379385733, 4.890049308512311, 5.1825801170236625, 0.1854899062459965, 0.2412689275910412, 4.997366152921577},
    {4.884037072163084, 5.069740915008817, 5.377760361996114, 4.252388891079652, 5.287603604686623, 1.5712810834171331, 0.05986721115696693, 5.252481838425127, 4.9871220162167145, 5.18318123060325, 5.667431233571529, 4.505874118308617, 5.024277196200666, -0.09268274359321255, 0.05266531405551236, 4.798461789635394},
    {4.202886605272607, 4.927762480626287, 5.082511720722679, 3.889019592468503, 5.116817340434923, 2.0490965752045835, 0.020513546864802282, 4.883695188672226, 5.0950621705718895, 4.755341367385915, 4.8910400342322, 4.887881618720756, 4.887892460257301, -0.08874909967667968, 0.5700314418084756, 5.045058835045149}
};

static const float b2[16] = {4.893594586540427, 4.865929907845367, 4.926192679472544, 4.770459800104248, 4.825922631742986, 2.4686488635973483, -0.06860282355595851, 4.489808845192466, 4.776890242053182, 4.839428291664282, 4.744824754426814, 4.766731129506363, 4.829569304596281, -0.09318704360182312, -0.10534486210750098, 4.850647972632705};

static const float w3[16][12] = {
    {-3.492612212936729, -3.3003814428807816, -3.206474808581006, -3.137675034349577, -3.7887104863409924, -3.6800043053317135, -3.26554550661048, -3.6346693522030544, -4.0298193345516795, -3.1672549228072966, -3.6720910336352413, -3.5541468514606036},
    {-3.1914692407282477, -3.391029474871051, -3.585173751949006, -3.856474167099791, -3.938330561368683, -3.8385551648649656, -3.6125691252651397, -3.1839739602828603, -3.563924892292895, -4.060297759096453, -3.2556942966190743, -3.1225421750030926},
    {-4.284093500093249, -3.9519588038760096, -3.640322695882509, -4.026006837698013, -3.548915453052951, -3.747469823818184, -3.380400133312017, -3.780429712059524, -3.631437163511541, -3.9509152945754256, -3.7706911597808346, -3.750955169240195},
    {-2.9692627875556274, -3.2874032414989305, -3.591150446973243, -2.5766383114475486, -3.5277002673979623, -2.659141416450493, -3.734855390630817, -3.3573987812950206, -3.1434567696559808, -3.515688925595905, -3.395326955049261, -3.277200596806112},
    {-3.894409810483375, -3.9644376250789746, -3.775333653368831, -4.189294468060016, -3.993394998219034, -3.7313641727680817, -3.335855042841022, -3.7073933435002475, -4.071602464694839, -4.042357762061373, -3.912676507746529, -3.7009759362422234},
    {-2.331117893276438, -1.5006450544698047, -0.6961542527932839, -1.2823360833072721, -1.0062955821475004, -1.3092845214379893, -1.7439687269048845, -1.8532873519196247, -1.270114400433933, -1.3263348615770632, -2.3105360310395087, -1.8232286459607192},
    {-0.43179200389614913, -0.02446543256100202, 0.07270374527412816, -0.018409075242993792, 0.3897894171820429, -0.181885398042163, -0.03746261167744103, 0.8353650053052197, 0.7568442198535094, -0.21978257056144213, -0.3304487988233709, -0.1305495429813995},
    {-3.5801901930116276, -3.8952387280712375, -4.308279964989855, -3.996203339676358, -3.843218682311475, -3.5654548363110656, -4.201721983054629, -4.626273162123918, -4.5328868260469415, -3.8662999527671107, -4.342697911687619, -4.009094748918093},
    {-3.874710830763258, -3.9263539598476807, -4.191733376904101, -3.3999443588940457, -4.003817343529568, -3.8631674734528723, -3.7148410553445395, -3.7829997291909154, -3.8270751720869765, -3.749139642173222, -3.977305405681493, -3.36843707574209},
    {-4.1225898857492975, -3.643399665692928, -3.9897596682955836, -4.340025040952423, -3.2574100349252304, -3.9058201429043695, -4.527331789455453, -3.739056475257217, -3.6132610825901406, -3.60298148955297, -3.666015513329775, -4.215590199108525},
    {-3.763180420085366, -3.712806331517059, -3.485310368127373, -3.572015240193837, -4.227509907109985, -4.371904118490537, -3.603327879469022, -4.162347088059096, -3.274956179055092, -3.482158673084044, -4.209003601651908, -3.321862997403013},
    {-3.4470480955879377, -3.0645570408807443, -3.3237141678349706, -3.494402528035549, -3.630270824310789, -3.4754276242038618, -4.383289521265686, -3.4456643616669513, -3.848103460542012, -3.6575878537791997, -3.360180948475345, -4.043490955183192},
    {-3.9559394477213923, -4.192968865939807, -3.7003664119415336, -4.375227408925114, -3.847723183626061, -3.9338041633610246, -3.373838814772569, -3.482072374725452, -3.5885060218378686, -3.7620964068512337, -3.4670712246387096, -4.237393451117012},
    {0.6455239366998535, -0.060209883412477315, -0.016335506107146066, -0.2602128559896358, 0.22149359739963437, 0.20463750865542743, 0.18466761483061747, 0.15582291536382492, -0.8216790592202717, -0.2086323311687383, -0.42687492999287324, -0.4371344090431216},
    {0.42526679295611786, -0.26558281198834444, 0.009057170534087673, -0.3323023813012417, -0.1410969033774328, 0.18619456650989394, 0.1108722207373109, 0.3122847987031619, -0.0013421208373234287, 0.5782003644691418, -0.06744018837397556, -0.23864287433288736},
    {-3.752484803749785, -4.423962538022576, -4.307042641001784, -3.6364617805880712, -3.336967239571248, -3.8871158838866213, -3.664065944673641, -3.6913258055629523, -3.6930546069609678, -3.9138748526456086, -3.289103097234269, -4.148392758676701}
};

static const float b3[12] = {-2.1176038159869046, -2.082695926012776, -2.194181483825162, -2.189057539816551, -1.8819421964563847, -1.4774588218697375, -1.7208617246544375, -2.3240644028674997, -2.1172555495715484, -1.7151854232500046, -2.3807458782432267, -2.0239133665467466};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
