#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.2422277865194288, -0.5531784639252817, -0.18934836339522496, -1.0346773202412163, -0.8068888667305876, 0.14937749524768199, -0.8588442661600935, -0.6025748711475529, -1.063802709803605, 0.017839012954102552, 0.5091768054335536, -0.42199979107655455, -0.9015205529280556, -0.6925235827025299, -1.030476681556552, -0.943942196528451, 0.20503981060961887, -0.3177120153338955, -0.289946223465847, -0.915658482179382, -0.04759335742992622, -1.05457224126316, -0.7919724351275443, 0.2760323268566615, -0.684502294000968, -0.9701994642552837, -0.6493438418602626, -0.6405949876569917, -1.1129050093605368, -0.7525484013476842, -0.9048025019240168, -0.46794986482930184, -1.085110058518349, -0.7653573891946305, -0.022971907196759435, -0.7979632831889848, -0.8993120271004239, 0.40833796937431366, -0.4487686676081427, 0.13373334010867424, -0.6263512822153543, 0.659957276913382, -0.8949334869652107, -1.0066239205244203, 0.01350479417645666, -0.24884367053599624, -0.6284327890286667, -0.9097672161696374, -0.7762741400962683, -0.7919171662935267, 0.2826007712984171, -0.05449956369662717, 0.16401004503075461, -0.9169311002875459, -0.4755398862125698, -0.00907915092739931, 0.4079426417181614, -0.9964898095921888, -0.1573790013790824, -0.13532296583029466, -0.11334160062645171, 0.1393965742075511, -0.7184234938865407, -0.6709054738678598},
    {-0.16729975462479982, 0.06914402898153105, 0.03752714784984933, 0.7609357183091691, 0.034772963909746935, -0.10456802869830985, 0.7945597867681549, -0.1757444609125699, 0.07489073693187659, 0.4614303278728781, -0.5798903758285373, 0.05018719370699623, 0.41700530804037256, 0.08283662662549549, -0.1751623623511814, -0.02895769382532454, -0.5586005075390251, -0.3400830350481568, -0.20713597220131863, 0.8619991540907427, -0.3441158601516825, -0.10023190322268617, 0.5165537406269941, -0.7751334218152203, 0.8073866269778824, 0.31091558150754506, 0.07732759379376761, 0.37610958416468193, 0.055251752541868586, -0.46583276003262836, -0.37201951778171066, 0.017067090476265197, -0.3135456287887021, 0.82193752567595, -0.40168193575785643, 0.22983530943147562, -0.08023175003745428, -0.31592806291716574, -0.1379906502053164, -0.0967085596721004, -0.29897249294422534, -0.768477886259481, 0.05401372349137365, 0.2430634384849721, -0.5538682965995263, -0.2857756068538912, 0.19985358264371775, -0.057141882319263905, -0.30319921375585007, 0.9145189582694299, -0.4752744020944012, 0.09596489863373495, -0.5816364272990099, 0.34045998258591237, -0.42177586688029745, -0.41959922254699694, -0.08389508216317333, -0.10384207244849736, -0.5548836120313273, -0.2458288279184472, -0.8873173259284055, -0.30931841469967614, 0.2847764063009759, -0.3384202268286357},
    {0.2533952748294873, -0.28297155179888234, -0.6701246056878133, -0.03808894979418605, 0.4177472130396974, -0.4335878437027232, 0.24924981324721154, 0.06727704021910298, 0.39236055414340903, 0.10191249589065489, 0.3489916237581324, 0.03211087569173476, 0.04533811364917413, 0.2797229767144436, 0.36422375992102995, 0.34996369045686043, 0.023632885355622132, -0.5543900850583505, -0.9122057106156468, 0.32765100389140467, -0.37045636062240545, 0.46564406358623833, -0.0799522198778957, -1.2493054256521658, 0.803719162127718, 0.4009974180215935, 0.040178871362638396, 0.09644519825923487, 0.658971105161618, 0.147073829363954, 0.6009538135689897, 0.6521607756853222, 0.9909157506464285, 0.12672337778426174, 0.33225941775793044, 0.6716226125804533, 0.7116301205817732, -1.0626864035505408, 0.12542219636669835, 0.3966848206043171, 0.7216345245683683, 0.3247494468071914, 0.2449887841673127, 0.5977466831008486, -0.02084735016113828, -0.34948595687815404, 0.0006855125216426831, -0.01869680543558813, 0.4411894321320388, 0.6118430655187317, 0.18287740477569409, -0.06273447628219786, -0.821136105347941, 0.8983593211933154, 0.163896015948581, -0.38575947103264624, -0.4304956509546774, 0.5070226158125372, -0.3449865891469991, -0.5163439297178241, 0.23078275918743657, 0.2470639420602863, 0.7222552478225093, -0.009973746525074594},
    {0.3975111842259291, 0.2406977734377097, 0.21059800908255707, -0.024286115125332047, 0.30894097618830846, 0.0652211835712446, -0.0268885493110229, 0.635542849392282, 0.7127963106737049, -0.3064242911331707, 0.6674034090142213, 0.8776528893370659, 0.5603659173838758, 0.706703238909526, 0.5131079495211792, 0.3968367992048934, 0.6277636110758122, 0.47325588751248127, 0.17928570913763567, 0.16005614479429434, 0.13106231678023764, 0.5935766598781197, 0.14044346571667704, 0.0003795115282230873, -0.16105433653638362, 0.3407909008328154, 0.24411710105571302, -0.07857095633963751, 0.8372214487961321, 0.9129556874723743, 0.9766638824953261, 1.1198358164434128, 0.7364739849329959, 0.47661755341201484, 0.7960480133789546, 0.4492497631849255, 0.6340934944464801, -0.5728702556903054, 0.500992999164188, 0.6842883804555946, 0.9498942262279589, 0.6754840523479889, 0.6104766292993116, 0.7441037848072917, 0.3985190651248169, 0.4424536813502678, 0.406677092183599, 0.7124265838707446, 0.5488158552357667, 0.15324844578364297, 0.8541373561022279, -0.195003725540807, -0.06257818505741376, 0.8225471449095834, 0.4391638907009618, 0.1437501302071358, 0.3244793523389928, 0.5784558519190827, 0.5137869196040986, 0.31707366627063927, 0.7178831407581796, 0.41996189213653984, 0.5555621976900232, 0.6880360424104276},
    {0.3184842900608462, -0.4204423935360194, -0.5937592091302782, 0.41998250042276236, 0.7723871520365205, -0.23972312200432488, 0.822949138134601, 0.7275288972862314, 0.7077195628793206, -0.6299738742862964, 0.26892899169634277, 0.3745140728522448, 0.8957975052245388, 0.5154526465611224, 0.8364153577290687, 0.9356605175663727, 0.45410711991082015, 0.6836988599753132, -0.02981330069457962, 1.096472614801738, 0.33255444894580205, 0.6041308111487674, 0.5555959916312958, -0.4684931529302267, 0.3660318932002315, 0.723842845680146, 0.5409253590610401, 0.20887018040527747, 0.6588628175551985, 0.5590724091141301, 0.8020714645466382, 0.3658859006937099, 0.648472687522047, 0.8698288740880016, 0.6148492426952807, 0.6853855371444604, 0.8436029992854155, -0.23176877170308627, 0.6069215676821127, 0.05408082638536238, 0.47152710145005294, 0.5329813720695035, 0.8085154697592238, 0.6876854609674238, 0.6092076096346619, 0.18755532199114475, 0.4060264556452467, 0.7757565322928149, 0.7643384551421991, 0.8189650417897263, 0.24733459363921664, -0.2516760796539865, -0.5391898213744442, 0.6702782655116915, 0.9436763072780315, 0.18051750226101726, -0.09383907113782619, 0.9329804328443477, 0.2532126406736808, -0.18463228958001174, 0.1570410386245614, 0.5543664524235732, 0.8346158308010867, 0.6032674220615352},
    {0.48791639490692496, 0.2793901739859786, -0.34963349864714277, 0.4662488285795863, 1.246399495164996, 0.35183881973834014, 0.855662534955256, 0.49464049790153064, 1.061806296571581, 0.02487609026556749, 0.354223449779702, 0.9665290491519373, 0.7955559880317322, 0.8215598789240224, 0.79195718328328, 1.2876618706650782, 0.7914558241602814, 0.7703156667392953, 0.5093979817371882, 0.5309664881469691, 0.20211038057617048, 0.8946784461311433, 0.8887349451872572, 0.14257050078582223, 0.6762767996011885, 0.45585218652660014, 0.7641622643552648, 0.5522979198447101, 0.942148239109239, 0.6766579531169093, 1.0669081207033095, 0.6781976434684023, 0.9171207915454739, 0.8767509365881735, 0.405733262994365, 0.9709932172309735, 0.8939729986432555, -0.22343292286324096, 0.6177960048064143, 0.9246975396143574, 0.9941432522314956, 0.6858237329565997, 0.74066282316703, 0.862865727403264, 0.6544306810846559, 0.7521207939205955, 0.2803489941125559, 0.7124744585748221, 0.8245387352068223, 0.5295078548416409, 0.38985183664951534, 0.5123561565757546, 0.27395751360057424, 0.8650261072028642, 0.8294325702518698, 0.6667045028062838, 0.226624028899406, 0.8331020708782819, 0.6538859077931173, 0.27723119852916545, 0.7219747172339714, 0.9695004728045267, 0.7240373732881333, 0.8525909804973726},
    {0.4288889715417767, 0.03509344570385297, -0.30546940923113575, 0.3081199527667579, 0.7117437027235539, 0.18242187859413594, 0.6467721332624343, 0.11527975143076072, 0.9584277708546002, 0.12561991858046945, 0.07143196063713025, 0.9151110757070657, 0.7346967075382719, 0.9172978851524175, 0.6845654323208206, 1.0066492861396732, 0.9761192162687288, 0.632893626401849, 0.6073336321958717, 0.6065505587606297, -0.06435909042800939, 1.0901499748749701, 0.7120419536667171, -0.23757321640866264, 0.8799309088031657, 0.6622433123967739, 0.6424336354565466, 0.24912112809164375, 1.323288978716417, 0.7395981494131909, 0.9648212979987075, 0.6946364151723823, 1.0140290623683774, 0.6838497717051363, 0.6215460135394462, 0.7044099061652522, 0.6812386447463175, -0.3246615547207455, 0.3754311827823952, 0.6512994575868062, 0.8998464904762264, 0.4153341666401629, 0.527672554362973, 0.6515135848339261, 0.7859389519820608, 0.7869629481489506, 0.4238723833415969, 0.7904899710984381, 0.7298333744954527, 0.42144051049544434, 0.4179428062733341, 0.2025603152162344, 0.39441811078090727, 0.8885722259770192, 0.9987827428989409, 0.832354198253064, -0.24480528056004897, 0.682487891299736, 0.47620918317680794, 0.30045703878903995, 0.583290743764309, 0.22001066403185382, 0.6152891197820435, 0.7448034285066417},
    {0.38505262397697787, -0.07430848027257107, -0.49593548331896475, 0.44447869758326936, 0.3737223980348309, 0.2502654249002986, 0.5663072541486268, -0.04792842535153021, 0.5846064644783818, 0.18022283934705946, -0.04384073033074242, 0.6214563903497448, 0.08853443748279206, 0.34578897001490694, 0.5853341591221461, 0.289368280368962, 0.21295861903764893, 0.2358304904062062, -0.1176363185383488, 0.7634986888630049, -0.09619768941638625, 0.5057889088521533, 0.6051615814300427, -0.6067721530124328, 0.714822023374646, 0.45122554199061854, 0.34584467907661326, 0.4334542744431492, 0.6167593639352181, 0.39730887380141267, 0.6174444693189899, 0.1506796514316868, 0.4138134467583176, 0.3665823434266098, -0.21081863612724214, 0.5467179982469303, 0.4683024157914379, -0.9192297718488273, 0.14065255088600973, 0.06992635816294646, 0.3400341731845901, -0.5976896054379381, 0.9038283412433549, 0.7547520796819632, 0.11126513970169678, 0.30346207096300853, 0.6511266414659611, 0.4720746828410943, 0.39755375178822594, 0.5386067302545771, -0.3910751024173, 0.04156599062227757, 0.018291018771870768, 0.8039395939546573, -0.11791781399247851, -0.0010586488996987351, -0.024849015540064977, 0.4896900341292981, -0.10889587873046072, -0.1159581267882061, -0.18877149332207202, 0.05854173130198531, 0.6760825014051377, 0.16038033424620615},
    {-0.0934917195444475, 0.0497775222728705, 0.10584186938038917, 0.3008533551765713, -0.09693229704256781, 0.031105682596595016, 0.18175044371935614, 0.23081594159056076, -0.0074638537989373255, 0.16288416521547322, -0.5056701141237802, 0.2717550368410051, 0.0934739935820916, 0.29963560862906935, 0.21089717036875058, -0.15806381965234131, 0.1031190887436488, -0.6813417284633696, -0.31273089560051165, 0.7236860934434541, -0.40302874027130264, 0.23261776488880587, 0.7171931901905803, -0.9082994040584021, 0.8709554742217677, -0.3236038762381539, -0.05022024511635363, 0.6061401255397898, 0.445190294204206, -0.376617312352874, 0.23050220466323415, 0.0573165104232874, 0.24481244125177487, 0.6688044849045237, 0.21065321108351637, 0.552926100812672, 0.3319847236780031, -0.7397675655102411, -0.6018197326514841, -0.07813742244339793, 0.29410451477072497, -0.4889211423357928, 0.7181982678278319, 0.4487980376130477, 0.0818972351014321, -0.03005879981995666, 0.5991376626721762, 0.3791781811485391, 0.2636953935073752, 0.4567284962637319, -0.7728035962525663, 0.1242365237908, 0.19206463769562893, 0.9131730136178272, 0.3260522122843462, -0.4752764593304085, 0.008310029515405087, 0.23931956341930963, -0.3687676571762519, 0.270041390726287, -0.29479572000131793, 0.33903996459649893, 0.5622626698205666, -0.1884556661090765},
    {0.23370211532891783, 0.555392397091278, 0.8052920119530524, 0.2608032665419021, 0.13201505177831038, 0.739215809104971, 0.7337168018620451, -0.0712570004381127, -0.1378257079667145, 0.7786695747202071, -0.258418225652412, -0.4031895506088679, 0.784300199340564, -0.3901458020957571, -0.09896341020775125, 0.08131143500826664, -0.42508330535547595, 0.1353154597773629, 1.0717547442086175, 0.8173016749309785, 0.751168447031031, 0.19662263165240135, 0.39710821838831145, 0.2192732966324432, 0.8924229002098816, 0.5693653982119024, -0.04198607459796042, 0.050451956374247195, -0.37929586940859894, -0.28865014275939593, -0.3865796656241886, -0.25683600674883733, -0.384426727494048, 0.5847277517546272, -0.5986059898794764, 0.5169858880893079, -0.170079268426093, -0.013717192781018418, 0.1696274774705307, -0.4670540671644941, -0.5807358400391414, -0.6890651985013969, 0.055709148671225825, -0.2483691713311792, 0.2671798213475695, -0.3684059052263661, -0.22107940737411916, 0.1045663273599858, 0.03046670220619649, 0.20786153065608398, 0.05707723119851181, 0.13365954049197604, 0.14870035476638097, -0.26573440956386263, -0.2711156122199979, -0.14675943194789334, 0.5067850872301826, -0.23774496687187538, -0.3083778834177742, 0.233645869230573, -0.8459833174756063, -0.09092738560113875, -0.1166693789531268, -0.35693061780676133},
    {0.0881438072435082, 0.8831850482506773, 0.5020703247603524, -0.1779659640077827, 0.4324184986680796, 0.43373250792418866, 0.5957918063326696, -0.6929800522747978, 0.0990889508730279, 0.46233489616180623, -0.26156245934467104, 0.08429122799574316, 0.7093751159643942, 0.040440230377677786, -0.07366755540990552, 0.35781110818475786, -0.10144588031111194, 0.4203570528936417, 0.7129408872844955, 0.8404040285760128, 0.3799403978073449, 0.1309332898918419, 0.2394327509684419, 0.2578617082249658, 0.45812969256599245, -0.029069553977346535, -0.024258055681937816, -0.11074886544104133, 0.39444896018004394, 0.11911220186164066, -0.02242303016814525, 0.23124495997103747, 0.25791467625780634, 0.2906753182188683, -0.33883323702202867, 0.18297044676286636, 0.12342928739595911, -0.3018456993309217, 0.2868010949947162, -0.00511431836285557, -0.24968324753480436, 0.07843085902444494, 0.3965826285322173, -0.16714759984075828, 0.38173708230719783, 0.4430941639783679, -0.4826300157513506, 0.3971670073677359, 0.2446065974398537, -0.11140812988672728, 0.2866149677531005, 0.27095370028704635, 0.3187783978041896, -0.7619717665027108, 0.2102717884896014, -0.0173382719497056, 0.07362119888382641, -0.11368819012879611, 0.299124586915852, 0.6357527829633626, -0.40020752160398043, 0.22473678293678134, -0.09931126741667895, 0.2799429339860019},
    {-0.07062582939852614, 0.4819141357006786, 0.814583610187668, -0.2196346638549525, -0.5133495775501261, 0.15358163252244014, 0.10240425118513109, 0.04074209221819616, 0.08866638876884132, 0.1634726963254639, 0.17440722928267072, -0.25462385915236113, -0.07158674600749622, 0.35028566592741384, -0.005587302516786747, -0.2636090635962617, -0.04633636712943126, -0.4407306340397009, -0.005820002407027867, 0.21242964890071775, 0.6091144022524879, -0.029053304552314238, -0.15585505603159283, 0.26798291266471397, 0.05646109107845364, -0.03298677320385199, -0.07827312194737097, 0.07332630691845025, -0.062495275803471445, -0.19355499323991932, -0.08038657062247649, 0.3462063804499525, -0.5139533826199927, -0.18909127549462423, 0.5591225762182643, 0.08032444915255352, -0.17095961721736846, -0.45598928923980175, -0.4955822104238029, 0.3147455805725713, -0.12681543988193547, 0.15447297537603671, 0.33482909404479305, 0.2293291823013933, 0.24695986618092283, -0.17415629203450936, -0.4238869934565637, -0.1737662390826416, -0.366380331096284, -0.13637514808208825, 0.42253839581455643, -0.2548903032837013, 0.5898182602402889, -0.11486579873009395, -0.5380458537095238, -0.8281106163845925, 0.2452409606463785, -0.435764795295981, 0.5149530166490994, 0.038378347787102376, -0.36396090037758266, -0.14230540565380775, 0.1406011377645205, -0.0922632098662399},
    {-0.4060537643306732, -0.3442808087197995, -0.6105430577760033, 0.24648991160422554, -0.6329393071185975, -0.10134947110971125, 0.09405856738214372, -0.18954906553102444, -0.30052922715897595, -0.02207441153032867, -0.7231322642305795, -0.47126427405852317, -0.5257695895400439, -0.47841900821096783, -0.3330101056831495, -0.17772832298958866, -0.2990936136471317, -0.38747051313377723, -0.6371238686788436, 0.07685832647266089, -0.154680418040937, -0.22343057703051217, 0.2843029177118315, -0.29313336859254857, 0.48849369308673735, -0.2889045901971095, 0.0055516356107280455, 0.08118971549078297, -0.4598030237954585, -0.34044879124804167, -0.6448790782555938, -0.7003788966368453, -0.3604870234065772, -0.1540775137271563, -0.7618466759720268, -0.40986916795915623, -0.3265774204782612, 0.07538003209413151, -0.6919246865392429, -0.002571625769961548, -0.8738405883651758, -0.5468616682632897, -0.7649730117236244, -0.659942845846643, -0.5098059526228664, 0.11166407275657529, -0.5673866430610676, -0.4548920007733424, -0.7598371085415541, 0.37143981524224284, -0.8147770861674437, 0.4256008500980639, -0.46549827181826225, -0.2639873695658725, -0.49137156362113427, -0.19071455841017385, -0.7109477998464242, -0.006065818684143766, -0.6261414980927796, -0.3189666305622629, -0.5121831460709256, -0.3374613550129115, 0.08619844555265083, -0.7740792433299938},
    {0.34404546515705864, 0.48897451570980766, 0.6917395909358597, -0.027860713934182452, 0.7490318035383478, 0.7046576538160257, -0.19391974319841546, 0.00761007874507849, 0.48631749586617207, 0.06862232006783457, 0.22467417133758255, 0.837527742878616, 0.27301702801061983, 0.7273674217134607, 0.38192209859051524, 0.33282983463496735, 0.6283169341718676, 0.4470791141528505, 0.5863447820725205, 0.5293713283338944, 0.039093421155009474, 0.5836778004319145, 0.6245317552845188, 0.3058545359040469, 0.3085990464619222, 0.3733809941755419, 0.1255791868643069, 0.21406677379083439, 0.6926514690650355, 0.19082397975955082, 0.5211991030375293, 1.0714601620381194, 0.6457825583245131, 0.372676410626212, 0.6876977147479184, 0.08490721897728783, 0.7686302412458949, -0.28446268359577215, -0.15565975402352641, 0.7974889287179947, 0.7963138766709751, 0.6635489778778679, 0.7138355421224993, 0.7663490945658143, 0.29145742605808744, 0.6727214998317436, 0.6435609947212617, 0.7253018366863143, 0.4685600755668519, -0.4354711574479975, 0.7681128000674373, 0.3404309205666796, 0.5424679192557803, 0.6771366635422172, 0.7297901193653368, 0.694365243043534, 0.25841501130696815, 0.6062256428509092, 0.672356568187571, 0.744885813250649, 1.0410020812380498, 0.1240733528236155, -0.2785929422647882, 0.8302295329039844},
    {0.3205224746914079, -0.28982239716287905, 0.22356601652057395, -0.9119401789044208, -0.0759520372579662, 0.14946577893450527, -0.8030410835477321, 0.19464042466382153, 0.4569772796369396, -0.16796538390042937, -0.11379719009284152, 0.8386347520462568, -0.29714939579664373, 0.8109126435777692, 0.39544565420959066, 0.2441262742709789, 0.9101630771874808, 0.6312479748207307, 0.2050991953376934, -0.48610587547544565, -0.49453246281079394, 0.15926883473214148, 0.15352190252322548, 0.7000071703892092, -0.4833683024283411, -0.3734695261566832, -0.04812942501895437, 0.4836892181338689, 0.7150425802095962, 0.5348901504558952, 0.6848941999249437, 0.8042856495623029, 0.6386749175615085, -0.7512361403530453, 0.8177630662231413, -0.4707124230607411, 0.4647634513343492, 0.21184593434849966, -0.3356252097631703, 0.5046584810213226, 0.7878963145110247, 0.6162930043730392, 0.029017188424368554, 0.4485391810003042, -0.13188245960071654, 0.6984050592166194, 0.18475810565588827, 0.5670333697301475, 0.16385026847976342, -1.1386012081522534, 0.5619604393094662, -0.08382881302014923, 1.0838842094114496, 0.7235301215423176, 0.5716006814835185, 0.26107361171173543, -0.42240230016476876, 0.5064056797194197, 0.47955365082214646, 0.2288833762598029, 1.045233865361076, -0.17916009130351204, -0.49312527274839874, 0.7514033865576712},
    {-0.46575481826713094, -0.3970029020006022, -0.05633102300208973, -0.18214710152802577, -0.16268552009236295, -0.3807995187663813, -0.3586941023534844, -0.04444904216938191, -0.2672051391436072, 0.18755632066187217, -0.4611319580879399, 0.03597976520291122, -0.36696211086760755, -0.01737650910266683, -0.49283233613860483, -0.40109401118477894, -0.02668218266289586, -0.030147482296523188, -0.4708927646779839, -0.22271699544410078, -0.9234563864930535, -0.5701129204908023, 0.26640201465605684, 0.5216724210414798, 0.07562307222871542, -0.7439745738013942, -0.4249238075645252, 0.605858463170995, 0.4558133882516794, -0.3543858827248011, -0.14271137378718596, -0.39995878372151145, 0.18546967075895773, -0.3654963792095842, -0.3474339433101398, -0.5707424949533227, 0.3890051751244354, 0.7679622006358875, -0.43056429019954895, 0.371337925850907, -0.07654040895267991, -0.6566678901614219, -0.7021081111361183, 0.10097481156996063, -0.7641620191447337, 0.4904026427067365, 0.2067950783747872, 0.05015313515729492, -0.44102242936099595, 0.05873529508197537, -0.383677342411662, 0.32720875395623916, 0.6928057590213392, 0.008373733327136743, 0.27759163813443455, -0.12918000771324584, -0.7904872999695406, 0.3631235843783493, 0.5477762415129183, -0.3322041019117532, -0.038236494228863785, -0.6301961947651098, -0.4608782416879626, 0.012039076957701317},
    {0.6083342617852924, 0.3691500365490693, 0.5234771426717091, 0.15045868683105332, 0.4511964531755003, 0.6647048923967226, 0.07904111237019029, 0.4001738249235921, 0.9236996675857514, 0.22303770993703684, 0.23159510008096193, 1.1238640577983472, 0.45815069847458084, 0.8272416380496687, 0.5616327484407767, 0.371157625781829, 0.810547564849956, 0.8059378737776967, 0.9148965352272656, 0.275384331781885, 0.06585825539384907, 0.8906121833426228, 0.9140252777046318, 0.5652372416836476, 0.41043813337159246, 0.22404163552539966, 0.6508154559582942, 0.4632774514454718, 0.9324736227867765, 0.8712954112389594, 0.898749205933981, 0.7373189718721292, 0.8516380376314892, 0.6758749811128995, 0.6891266358774656, 0.0802121637442907, 0.9096521195211129, -0.22690940998284742, 0.4565936804409754, 0.7960708103755976, 1.0518085729569457, 0.4307858135271608, 0.4774361135884053, 0.8350753851054764, 0.4634620386117139, 1.0639778309857921, 0.4769729056283953, 1.0528099964871025, 0.7006834775362436, -0.45115915757427943, 0.6391865081683248, 0.7193222675313792, 0.8394704030290016, 0.9240052366472904, 0.5170339185291097, 0.7752057959274717, 0.22598549594375958, 0.6313080877608334, 0.8429586198573832, 0.7463055654644143, 0.9913539444629434, 0.5393040653335854, 0.27231670632358257, 1.0447158001895993},
    {0.022963250017661054, 0.40919867911119717, 0.6235914006121163, -0.2184747061030237, 0.7717995285581427, 0.7236681082700135, 0.22383281833514776, 0.30510189706262075, 0.7217872554995468, 0.3227854649826422, 0.042223793203844104, 0.8073930701982707, 0.24095993510689442, 0.6140452040261807, 0.4933982181459618, 0.6046293386945133, 0.6351881937861006, 0.8473747706760447, 0.5953114046955474, 0.26291748190272923, 0.07980707898303416, 0.4835172769910191, 0.3604928619896527, 0.2549041783553506, 0.7685924279133521, -0.3470760378892282, 0.03919380472654259, 0.579444424732612, 0.5531440892817144, 0.657157663547613, 0.6211394458090936, 0.9268859166863593, 0.6023100027102102, 0.5750948643313775, 0.5041457196157304, 0.052198537811373874, 0.6722558857446651, -0.09610009525423914, -0.5464746757884931, 0.603741731510257, 0.7612249706855433, 0.4373534795381953, 0.17310296265024874, 0.8302618038665854, 0.2304136315026407, 0.7477101417781281, 0.11584560439559245, 0.6608283213091342, 0.6584257149181116, -0.6148646701193469, 0.6173604549685201, 0.6833441350184629, 0.6969181035901432, 0.5876931988261649, 0.6338585544750269, 0.34075189565453323, -0.26202438586301474, 0.35803006645646684, 0.5406713343550057, 0.6219335284442608, 0.8045148950806424, 0.500296249089405, 0.5487749495294483, 0.656488717133816},
    {0.3153177235997644, 0.06024196666958083, -0.04583512136749863, -0.17103766090078273, 0.13374509826340708, -0.18219097314859004, -0.32396959660865193, 0.14327295435338908, 0.2465453775726451, -0.4628862442064963, -0.1281094139754095, 0.3357881059547475, -0.3971653598586569, 0.14376749846611508, 0.27081087657226083, -0.04954657192804332, 0.773020841186427, 0.291085399260511, -0.4596879341699762, -0.5429453006544306, -0.0986828662525426, 0.20850012354404057, 0.4884043564191859, 0.022072578860822818, 0.46814652415692665, -0.47727950732104935, 0.0025638836047596892, 0.7821764329523277, 0.4395716984737324, 0.6181577807788825, 0.6138093844529651, 0.5582390352759125, 0.680932380560784, 0.2999909102560685, 0.35516943318307503, -0.06626912715293302, 0.2293696712297729, -0.21674977180341157, -0.25068773537182015, 0.3562609021642305, 0.7377648095286902, 0.19713720776807225, -0.34507694001251066, 0.2003339297758013, 0.5651187767946263, 0.5013118747794083, 0.5754136221270794, 0.20802428768080813, -0.14523213576746108, -0.6370371301722595, 0.19452758696053993, 0.44569619415040135, 0.4880378735442341, 0.3515944276487971, 0.18424753929867752, 0.008739413384907116, -0.5107857916927597, 0.1343668685039484, 0.27675507890244455, 0.7447337015573523, 0.45963148989790537, -0.4464201653333121, 0.46369445053132313, 0.05300527847423875},
    {0.08122754455800309, 0.5991610892333004, 0.021560633833113938, 0.2205430090723557, -0.32031099839703586, 0.5121543443637062, -0.21672202994473486, -0.4923428385092423, 0.5263386402360775, 0.3162549081548674, -0.2410870829804141, 0.37707738539924485, 0.46721107194260497, 0.24933520012737734, 0.08496445475085573, -0.07082577430504752, 0.6740753306876429, 0.5369861772105853, 0.7734851369244723, -0.2730756803677533, 0.9790621979049223, -0.29544161931667207, 0.2809453118339552, 0.509820067301942, -0.01657830170860829, 0.05259742085400028, -0.047931931912418166, -0.47298398602896796, 0.17332636778490396, 0.20043175155112236, 0.0015987270584478996, 0.6599159558391556, -0.012129924814509167, 0.10233801323621275, 0.1557892935703421, -0.8241746318412714, 0.31883666333565436, -0.7157592387270706, 0.1993101686902915, 0.3925904452806462, 0.3167556471041861, 0.23853739583998812, -0.33393761727546806, -0.14568644826422206, 0.6022291884041028, 0.07831279564910065, 0.026445022173814444, 0.14754690813791158, 0.26383325507506517, -0.7019414503770657, 0.3519607886938514, -0.2500955727313541, 0.5530659508252462, -0.05221889909952057, 0.2823747707786658, 0.5056583793709828, 0.10250371161588012, -0.23341873466570792, -0.19407279920279555, 0.7872855387402793, 1.0184174214838693, -0.5084400590428908, -0.21836840441058156, 0.5369297200729425},
    {0.4747349120844563, 0.2583894215295875, 0.648531324249834, -0.22135981400493504, -0.42083972378705375, 0.07012446647599987, -0.5611382075232286, -0.10989591813449824, 0.28726060277497006, -0.6062558516153721, 0.4091490463541582, 0.5436341021234256, 0.4437676252928847, 0.6873324492256219, 0.09875187323423663, 0.03022649557810962, 0.6424281307570697, 0.6990750617735089, 0.3830998209596749, -0.8974109146492293, 0.021747301017304828, -0.2511202245268327, -0.06502896257780967, 0.4871495822657413, -0.5973520799263627, -0.25976594524852026, 0.1895271063421465, -0.15399856749129134, 0.4187750046642331, 0.5353344793582814, 0.293637414756362, 0.6654044778272976, 0.49442595628629765, -0.24001128424725432, 0.9171102632327961, -0.3358603062962544, 0.24372113835785442, 0.059639395830038695, 0.17556963213312415, 0.45472055403715533, 0.7174766754086123, 0.7070931071923628, -0.12521089822896478, 0.32929307831008275, 0.5694060065503654, 0.26468676688042003, 0.005896500599969476, 0.5945628183573267, -0.02732386780640162, -0.5419578813909209, 0.6056071211691929, 0.2170576085113021, 0.5748738565212504, 0.6095128060138639, 0.2150205496577843, 0.8649762760990205, 0.08069047668505394, -0.5255783178104216, 0.5996856167028324, 0.5480525846062436, 1.0122996170522494, -0.05189338891614014, -0.3623067892939439, 0.6964581882203763},
    {0.09542970097468788, 0.2044030050099768, 0.4951406841341456, -0.08550408171019698, 0.13232800587266477, 0.3893114000933025, -0.6859814634400803, -0.09219986807078426, 0.5786336499809543, -0.491983597018446, 0.27106674492040417, 0.6884404902167693, 0.3139665721731006, 0.8644746075082423, 0.018540247671534532, 0.6485476439023776, 0.6794137557464551, 0.8032403435896779, 0.7770562351357602, -0.02449043628412193, 0.6417106630751226, 0.19808571448889992, 0.13289364454298086, 0.9130327811688064, -0.37289315716284377, 0.611084220335829, 0.16635984659386543, -0.6301669562062668, 0.7592194339760654, 0.14315405656825417, 0.488483794064132, 0.682483783487578, 0.37695673241948774, 0.0567060780367253, 0.6566174543462423, -0.384320947134079, 0.6854341675817026, 0.2703399856010119, 0.5034763989363509, 0.17592746099211226, 0.8707818605807962, 0.5381258392068348, 0.39629854010188836, 0.3597638832906436, 0.6528106491399956, 0.40003070252462986, 0.5536177413181032, 0.7785607811468642, 0.42628946938203477, -1.0809832702943822, 0.6356396517246354, -0.31414167835428014, 0.5491582907966946, -0.1176866453192123, -0.0860367635778262, 1.0231246037405848, 0.6039930263911389, -0.4354885884077737, 0.41588165054582876, 0.6138458434734563, 0.7095233144343908, 0.32782432798534955, -0.6714552401870568, 0.7380853311958981},
    {0.12427158895714152, -0.15737709059894128, 0.3321104750657032, -0.1286621893896104, -0.527651486315233, -0.11791899680577131, -1.0107871732025844, -0.6024894675240481, 0.17277746547064152, -0.8685280281044082, 0.3855844866148064, 0.4783736126160612, 0.09269523735035284, 0.3557800505909854, 0.5644246731320925, 0.16635587691674644, 0.6958455607997779, 0.2321461537569951, 0.3226343414220849, -0.5979529365523503, -0.08925842072204739, 0.30928618169137034, -0.3100570466950823, 0.4933434348936533, -0.8152626548799187, 0.1363518545438135, 0.5621728837345538, -0.26892555909590277, 0.15377518501464507, 0.10182786961763554, 0.7112013288591875, 0.7996349963332668, 0.3130690386948409, -0.4791708277254487, 0.8862418232010213, -0.528793108658619, 0.5328248000516208, 0.15155328314650493, 0.2956144389041437, 0.12175740901089287, 0.7255708498197129, 0.4351151921902732, -0.4731995131521059, 0.3348963089989252, 0.439474083659343, 0.17934810614220634, 0.1995688442819337, 0.4960520631953271, 0.16777919582850523, -0.8567163039766255, 0.5638028106982441, -0.13664636999118931, 0.18000976537377864, 0.1877937517261115, -0.15963235250064509, 0.5402533635781019, 0.018903606290234454, -0.42762415498113104, 0.5734914810072884, 0.367677544043335, 0.7212525644314114, -0.6749501193464432, -0.3751719689423893, 0.32757832012314914},
    {0.30972493552201064, -0.06752368107206766, 0.34012244086192106, 0.39369694832097274, -0.22029634751794228, 0.3437301170198408, -0.260560486960711, -0.4660887189746772, 0.24507342591677453, -0.9003858160342977, 0.2366881459714975, -0.01020236569947571, 0.5590746555942293, 0.2697774364905579, 0.03950686814171361, -0.3805404583962394, 0.11003042358449787, 0.7165973654583941, 0.7989035616893267, -0.2753830321693818, 0.43660508608681, 0.050033762512214176, 0.1368077927018993, 0.34440914425869384, -0.855502976709531, 0.6702302309058461, 0.7055767173808587, -0.7452194112511341, -0.11653782889124695, -0.00316624086597422, -0.11424304838477156, -0.07866450329696568, -0.5088549082216185, -0.2329060714699302, 0.6349680030891015, 0.14313882697165642, -0.27080376869883543, -0.1778814125936782, 0.9195941853623414, 0.11378854135825388, 0.5631046309759312, 0.06930209966242427, -0.45102828793598976, 0.013553365970917927, 0.7125887744564309, -0.31323699417637774, 0.11038803314608119, 0.4761054708701784, 0.5159465715103237, -0.6241541105799848, 0.7996694864386438, -0.4286045130415439, -0.32363178251597613, -0.4312755171523993, -0.1974404215168497, 0.6685854197205572, 0.4997613539393576, -0.7375077921906057, -0.14231907678836792, 0.3744316363632165, 0.25469146352511923, -0.6004413642537367, -0.14710890309336727, 0.18793243593538594},
    {0.6905954451254549, 0.5818640664047987, 0.6428046702580851, 0.0060731581651498594, 0.21225954611816142, 0.8616360061712143, 0.154177484608454, -0.23022610027658852, 0.7292836591813895, -0.496486314141362, 0.8430235113899444, 0.5576577977711724, 0.9154634531535333, 0.7418679333027088, 0.4372025368954909, 0.313258926043662, 0.8662794881449836, 0.4726202702098385, 0.8026424938810302, 0.21759927661359504, 0.7678758835764471, 0.545612558320511, -0.3252932542076184, 0.28068864479993816, -0.5618701211718771, 0.27843852583899026, 0.5734791504335482, -0.48444655177974777, 0.21298562068065988, 0.43693284555442446, 0.49537424184438467, 0.929634358421024, 0.07880277212933717, -0.08427826122712764, 1.0491442976782128, 0.02178508940259933, 0.28732854973997, -0.0008142712189524825, 0.7748750312374487, 0.6080814639751493, 0.4541620173660779, 0.8219320368768765, 0.10752173346037008, 0.6499252652624532, 0.6082356872240314, 0.1462942287697072, 0.5610388523781594, 0.512475871618782, 0.5568309631751406, -0.23127775508541062, 0.9241985568159969, -0.014751473232733268, 0.09433556594075378, -0.13719250011001388, 0.1614208288165511, 0.8555344803443327, 0.592455766826093, -0.5308113051391428, 0.32198054482404814, 0.6571065912204115, 0.8905015204402373, 0.4625839029569526, 0.3622534204402577, 0.6544349243960248},
    {0.5270069961884913, 0.18561339904451452, 0.6947383994272187, -0.46899401245820516, -0.22238849059095364, 0.4818380539939242, -0.5244241907816994, -0.23038239091964643, -0.03992688356481828, -0.5248014386041102, 0.750760309410505, -0.46055803183852917, 0.005638848367799987, 0.18314569552394658, 0.3995072745355346, -0.4797721218714739, 0.35898586857693215, 0.08110052959025897, 0.4515029706387973, -0.7204447345068334, 0.6441430500601627, -0.1118670587491915, -0.7400677870808822, 0.24705041045375045, -0.8621303941463841, 0.5169182320941612, 0.22140542582962427, -0.5556488776815971, -0.30936479005206935, 0.5227678093127451, -0.19276435287444074, 0.2593615042835728, -0.23808007786866792, -0.0846683549414209, 0.5547251803158482, 0.328930644606034, -1.1203964012544638, -0.06807434152750415, 0.8015882745559341, -0.12297153742904854, 0.2618270395781613, 0.7581735270316325, 0.03091924559519711, -0.07333741606343537, 0.6623795963211971, -0.08487378183837194, -0.17411481951449856, -0.37118847101516256, 0.42362202560805395, -0.7174418661633164, 0.6376318394629269, -0.13306219708545786, -0.2219098643175405, -0.31494530479702926, -0.6313718590849619, 0.16308986775559095, 0.6741543450561466, -0.5179643719985505, -0.2123800378882701, 0.7502227297907393, 0.06536767897958053, -0.12835499616072682, 0.050579932865556294, -0.02756719033262191},
    {-0.20057038432824068, 0.1058059044985727, 0.9293284783062402, -0.41675603450926824, -0.7028658930529642, 0.6679369876370134, -0.8510160645123229, -0.4955866548284019, -0.2016771691600685, -0.6115700394865887, 0.030071262760867978, 0.17604199336989282, -0.007886623836286938, -0.08311967275399176, -0.12818060698154715, -0.6596511749223913, -0.0351305947830054, 0.6039224585372902, 0.8103848763176488, -0.8480048503807917, 0.3837307831136093, -0.39118881477533957, -0.6252287335458891, 0.8743845669920564, -0.8734437514720504, 0.3912226260723091, -0.050048976253084534, -0.7268602654492502, -0.555648333828405, 0.060904957116567016, -0.6759288723749469, -0.012349398617304289, -0.6724120807497094, -0.56886919214291, 0.5467512839933716, -0.6381582662656252, -0.6078911426080926, -0.030900782756274153, 0.7325015317340154, -0.3678370343570086, -0.09564746120506552, 0.7059275682443226, -0.6631067477479602, -0.23903803198093868, 0.39434111343586603, -0.5022735346599914, -0.4010267102465418, 0.23230536149277858, 0.012132967469358815, -0.9661354234610932, 0.7064383903302344, -0.5267339833949641, 0.36039024724812957, -0.967855494176508, -0.35411180058289277, 0.43536048030178154, 0.5629946820388492, -0.8121793570142223, 0.38030028977756514, 0.6430259481327337, 0.48524119846848973, -0.4374429954891418, -0.7507677662646463, 0.2139261377022932},
    {0.5639563552567823, 0.1508147601368208, -0.30271069540098644, 0.06805728818308783, 0.06697489123478141, -0.43190510271300797, -0.09144556406024151, -0.5157088802493767, 0.17000581748516447, -0.97295169311298, 0.5160369122762923, -0.13544408637814592, 0.11985544324837435, 0.10886333249043004, 0.7784970640447787, -0.1336393625335236, -0.14630916689177317, -0.1066609967150866, 0.09169899940126465, -0.17628631177304416, 0.29125503377749806, 0.06809129440148759, -0.46364919435471263, 0.013105310851694672, -0.7705659215659532, 0.38882331217382193, 0.49105626136971475, -0.33453106637324825, -0.7032028900007679, 0.1583332985224423, -0.5132308459837981, -0.13511783313825515, -0.13244600491210762, -0.13634872333142287, 0.5675219819041549, 0.038469679439814566, -0.3811644520534585, -0.28387716106711774, 0.5773958912590209, -0.5363489857635376, -0.3272859570466189, 0.6635454776578312, -0.2597587543413223, -0.013818120636595741, 0.3855665281526785, -0.05043433517913703, 0.09043210536483343, -0.21765704701036254, 0.10662342485271084, -0.20043669293570443, 0.27146355809011924, -0.5990940255027428, -0.4806524504723813, -0.3102380677779631, -0.418297693974037, 0.2572931325850912, -0.16148688440141587, -0.29296947890735225, 0.05324060128724399, -0.33874385230935494, 0.40768235546251835, -0.5003721851635243, 0.16552164717965728, -0.15897957613844177},
    {0.5486806824600633, 0.5417929809905525, 0.6496923417136283, -0.38048859612791397, 0.5114437666609009, 0.3769226490672462, -0.2572312400798247, -0.21914110819090032, 0.5120753867314667, -0.7228102501886623, 0.5014719322777306, 0.3178617116435147, 0.5327238232391053, 0.7950118982078359, 0.326929006509225, 0.4803778688606382, 0.4237987230259931, 0.9412672265483666, 0.979412346272692, -0.1020517751396148, 0.3471368069314331, 0.28436969285276925, -0.3728574821663808, 0.47361681551854784, -0.5384969482464841, 0.8096397793501395, 0.4518430506259378, -0.31267651860764173, 0.29362546524472777, 0.7373897680730694, 0.4173626763531727, 0.6826922050362583, 0.44338864523534316, 0.2262841245650625, 0.5500959435128389, 0.3770588977502495, -0.14190604051753525, -0.6068156377086468, 0.6860864583885503, 0.22942325081059245, 0.11918566276445687, 0.655478313071885, 0.21642374067076414, 0.4812671866387199, 1.1593847076937354, 0.5504937048467247, 0.08940230548786345, 0.6060027640952517, 0.41637125781275913, -0.9205778117146171, 1.0014255039303572, -0.1292726058357733, 0.10759192214464378, 0.07136175941434025, 0.29407843434880176, 0.7087416651611851, 0.3386406379859874, -0.35832906467023545, 0.44937821575744247, 0.6859079039280987, 0.4715995379247321, 0.6404219068645395, -0.2853824323627778, 0.2701588128359883},
    {0.3976777609732545, 0.18730294570636094, 0.6069923074498818, 0.3131793153758558, 0.3030119142301804, -0.1161987146266995, -0.4710606910956847, -0.06649849280271077, 0.7987999375254438, -0.9266387359782415, 0.42334626697513805, 0.480150024140959, 0.7446731117086481, 0.6864628178512856, 0.3748707038363682, 0.3831488926749967, 0.18059242493457228, 0.4776850496112879, 0.6777942947694723, -0.023792342235316004, 0.15280745130231435, 0.22168091464933262, -0.07312226463046256, 0.5166788191817229, -0.31949870985586376, 0.8071976401388897, 0.4124796338344969, 0.22826928868893623, 0.22084599902439264, 0.6413849813366082, 0.3349969463647359, 0.4028527485891421, 0.26915948065278267, -0.08664386746731555, 0.8314744942034488, 0.2278275483601598, 0.16031577748720277, 0.1850292970059801, 0.618637134224105, 0.1872865198967573, 0.3809665065018242, 0.7357603588625161, 0.37310872303018267, 0.6342082756652957, 0.3605065034460993, 0.3246434383547606, 0.1000344875183743, 0.2880286665367875, 0.39884086970196087, -0.5257244474543098, 0.6325738004163453, -0.11424317787501394, 0.3096221313910676, 0.01595391455823775, 0.18792817733795492, 0.3325845696918763, -0.19942156034884348, 0.15256507885192716, 0.33116860575649343, 0.7009476679128092, 0.709475055052828, -0.22309104742058683, -0.33874874372482044, 0.3308760894389334},
    {0.12490253991352537, -0.286635881745294, -0.3733883634794947, -0.9209077116270523, -0.8662906757025055, 0.34802210464582395, -0.3606537905303877, -0.9056975206510088, -0.5981567523454107, 0.07156937185472838, 0.3420531696911693, 0.013242589698568138, -0.22150627941495996, -0.54612330524825, -0.49268616337039534, -0.8237993501340888, 0.4466816932632158, 0.08568256316368268, 0.3524058390220637, -0.6746588041517884, 0.3748851462201113, -0.594210314969747, -1.0440990784956432, 0.3868874141424562, -0.6902069509375118, -0.9078903831042601, -0.774365314552069, -0.8950897540609123, -0.9202030827206117, 0.3017929602664556, -0.5604622488462592, -0.5443172227065826, -1.1182902867781428, -0.9395522412564138, -0.48395546932044, -0.5227963255984637, -1.0749408120165858, 0.1121934805580462, -0.42110657390360795, -0.12632143268881202, -0.577618410796945, 0.6579110803220904, -0.544878774396941, -0.8588568177355632, 0.4682224144185345, 0.343140716432399, -0.6766296831761112, -0.9169849660395911, -0.671218190382161, -0.7575703021389654, 0.5117622891905991, 0.06908222740641122, 0.5439555836949415, 0.07819512749410418, -0.14319910001922506, 0.20916796654457853, 0.33121565487114385, -0.7887714135414391, 0.3272002202233252, 0.3333624720696706, 0.06304450726613071, 0.43001470169210176, -0.2524654161002822, 0.23515211262934807},
    {0.5148133936225354, 0.2203303264784886, 0.2733408213901662, -0.7577539455652034, -0.5857334148066434, 0.5988184494160806, -0.25064044851583384, -0.8109553585784537, -0.4460873694494218, 0.47356924973112136, 0.5246275134081839, -0.09189810216553188, -0.3206118545696618, -0.32974223599860775, -0.34270217236150824, -0.6350942589966635, 0.3533631725391079, 0.10801862968733693, 0.2411735122041444, -0.42548949209943404, 0.5445420589393941, -0.3567765464281401, -0.9773801527307292, 0.40035294968862367, -0.7494605386280698, -0.7275013580822584, -0.6598731894312643, -0.6932341633475623, -0.8126763506332049, -0.030702565092660106, -0.4183516579479317, -0.2544206116252561, -0.6865565483735693, -0.9622327655910989, 0.16491028841338803, -0.12327445121054027, -0.9270101038639696, 0.11577838516156101, -0.24924195255355364, -0.2156783015746877, -0.08875493379727975, 0.6080698136265619, -0.4882669230006912, -0.36235917330083806, 0.36240903401565977, -0.23713631982415528, -0.30461145655087, -0.5138874434896034, -0.48826075552528037, -0.7708329803201321, 0.8487443490057197, -0.005018297479334952, 0.601592155786472, -0.05471547094084134, 0.31391230486210514, 0.45207385013556983, 0.6145405643455812, -1.0683173966786939, 0.32199834285372814, 0.42698168730387487, 0.18166361608267398, 0.6073672480229065, -0.0721187872835068, 0.014967765420846373},
    {0.3877471078651357, -0.571061526216159, -0.4975545136856037, -0.6943515965621205, -0.6496773931381777, 0.6760483623240374, 0.100722154572363, -0.7372083660088152, -0.7665698424211679, 0.11877133850210825, 0.7086329304105763, -0.506718035195184, -0.3896907224230986, -0.6962162104905235, -0.10330309385537087, -0.6222625364806479, 0.44532968849301724, -0.40105139400155704, -0.09556473245472895, -0.7198344779423188, 0.09923354236621931, -0.4458760217920931, -0.5364406999600593, -0.07241853444912756, 0.05920218168676512, -0.5701718692650106, -0.7987007651407467, -0.4857170856894969, -0.8132234330268348, 0.2133176210352891, -0.5891793755021195, 0.03976874398962454, -0.5092678854669471, -0.45433806489153644, -0.07230574862979051, 0.3193655065129807, -0.7829439029023941, 0.2639784413626912, -0.6101041426452205, -0.03107141958766283, -0.333822143377183, 0.03803537723094813, -0.40795153366973835, -0.4931632763417753, 0.00027278445600850655, -0.051676064248912086, -0.42851815589376463, -0.8860320600554222, -0.33259269094468447, 0.4038915229944918, 0.9378589833081519, 0.34346560289545913, 0.0822981449376466, -0.21786792178218392, -0.14916392736935186, 0.10731029592102101, 0.46470482663499035, -0.47435575362646853, -0.19272737776971427, 0.653091490722399, 0.08514512537661793, 0.5514124279469831, -0.04205630517802628, -0.30049723930330513},
    {0.5112620997883677, 0.2703240769970196, -0.31260912344991276, -0.8580611938517566, -0.18432083821341835, 0.28879502984451183, 0.2743850393954471, -0.5669754493749463, -1.0706789436055095, 0.5729145360109297, 0.5326011932006242, -0.355983139526512, -0.46486976606078667, -0.8375656563491478, -0.24631333943245767, -0.8114046261034703, 0.5077116954467366, -0.5298512221976844, 0.09638119055559242, -0.26947209595168164, -0.035224669215670024, -0.6323055414925891, -0.7048358983546783, 0.5832912012696816, -0.5560133681305184, -0.6515825493802736, -0.7355190234802239, 0.01375137237859638, -0.6043141283666602, -0.27728836970640686, -0.6180700535872287, 0.2601726982281767, -0.6955612623224676, -0.6679769352903592, -0.022761220791069414, 0.31103438454929283, -0.8767044617749018, 0.41648320702286185, 0.017984231464232024, 0.11854966525629841, -0.5182528025311453, 0.2587851500913408, -0.1866150239165823, -0.48852023208525003, 0.2227151178093769, 0.09838370334620404, -0.41722445170657285, -0.8908655333708314, -0.5092322204503378, -0.44069421589022606, 0.051218235995224314, -0.02707325578100719, 0.480256905188204, -0.021376791881485366, 0.04568960996222804, 0.18276754278264132, 0.6361351149261631, -0.2590543837596861, 0.08628964733079879, 0.31324748161730276, -0.11649756302433555, 0.4813157643583232, 0.0397864950611562, 0.02744124323532244},
    {0.6863718865058338, 0.3506626003849099, -0.07252310385478629, -0.018134343223547445, 0.09259941110786311, 0.8821601106005383, 0.18028653887461463, -0.6447574670275605, -0.7089300565056585, 0.37943294103742525, 0.6244343096809282, -0.20493632564839323, -0.29510837530959116, -0.6904882764209962, -0.44170210522718817, 0.022613868355784692, 0.36776520545574665, -0.002877660313605436, 0.05035756662089447, -0.01047737707016939, 0.5796314882377226, -0.37906009217351017, -0.5979208376660557, -0.015730491244055293, -0.04053702458586564, -0.2263026403663459, -0.19836321713213925, -0.1990167466079528, -0.21833868650884378, 0.6424308216248993, -0.34280034786519775, 0.18440635863425514, -0.36057331143843796, -0.19953850746935864, -0.07777782348326101, -0.1699477259077067, -0.5233173312094733, 0.6048687985783776, 0.20918642455310973, -0.8136347908486089, -0.4417275906910731, 0.2567182876546039, -0.1508732243303824, 0.2011527531864319, 0.35817327909515834, -0.36499705066286914, -0.6829715918616177, -0.6204188760170383, -0.45487179599439553, 0.29687782535336976, 0.3324053812255942, -0.10117306851610655, 0.2974850253644607, -0.42139830714432336, 0.17751737299598788, 0.010953705798159408, 0.14415095894876562, -0.25957844598161667, 0.014952562300542873, 0.46990255970629397, 0.046878571978566486, 0.3764130918193961, 0.5102803539819316, 0.15153670535989394},
    {0.36275300282667766, 0.39439458614306677, 0.12238648264156454, -0.4729421175755235, 0.14199624739808434, 0.5973390633295826, 0.4278910233296587, -0.18439008979082974, -0.21246093397150784, 0.545357082114468, 0.7984911633721208, -0.5978830305463442, -0.2248549627267411, -0.6199146172616027, -0.4579783028212063, 0.14714855384170533, 0.2673076989989691, -0.5615270202963802, 0.3827791164471886, -0.0003664559501782376, 0.7650214327749609, -0.22572529640591238, -0.7196952099974268, 0.13953057624289772, -0.3246893972709982, -0.08914876625077588, -0.7111921682819742, -0.34349596962363693, -0.016549971622240825, 0.453662542339797, -0.020429717423510466, 0.02052885664242597, -0.624765211257202, 0.10722070114666185, 0.18670985226605283, 0.3085353469808084, -0.5495585661997171, 0.3731128700315553, 0.005822696284112024, -0.6262437710235721, -0.09072491391927325, 0.3392337272325299, -0.1932017331878855, -0.19529026846516392, -0.07340381178221686, -0.05541350929337666, -0.9728781490089816, -0.518836241637506, -0.26433705836800986, 0.388792037033857, 0.13607630866326906, 0.18698575579123908, 0.15253998821922063, -0.6552065196271749, -0.1954175196982866, 0.0799928670544862, 0.02879877093318656, -0.04500473453032097, -0.5336802980790591, 0.38856481851065916, -0.022609801109081295, 0.6551072205452504, -0.0385713525732318, 0.18299609181755208},
    {0.2646331304782854, 0.1518751445136777, 0.1366891342657196, -0.5589877473489719, -0.5468578749714244, 0.6606598204869546, -0.10209423772977406, -0.20412942237308326, -0.387567865311065, 0.4369820328371072, 0.5948111916315344, -1.0920364810257777, -0.43604864827811296, -0.04968070944107349, 0.37274221603309265, 0.30568288487026546, 0.040272771476729086, -0.15118220771334515, -0.16176736562162589, -0.35933252248042036, 0.5400534217966482, -0.6995500410876901, -0.749003390899053, 0.6804403003597141, 0.0010127293871966135, -0.6010522995874812, -0.30525535844260426, -0.3128647334298503, -0.24812584514067718, -0.06844840058461765, -0.16991817383054902, 0.017006679463474225, -0.4871570708986035, -0.7955575472823062, -0.17040333186133533, 0.6528366276893502, -0.5335266813066456, 0.33343115405397084, -0.06356914284767652, -0.08012963920391576, -0.5026040422612299, 0.4650078124949513, -0.9846955444610068, -0.28260274130954754, 0.14458937042993553, 0.27987318703795766, -0.7105347691485387, -0.5081063549624275, -0.06110456580368337, -0.057925251159493485, -0.052120963526366894, 0.26408809061071953, 0.12309255284748057, 0.10642929956258466, -0.05487943392892011, -0.07524490528790466, 0.40333082810786314, 0.07006369263251104, 0.5055604352448013, -0.13239863050881184, -0.06112560758825664, 0.33538109189428655, 0.3110162747133995, -0.029515246297176674},
    {0.18931106934030334, 0.054217966915592164, 0.24008281576952706, -0.5470830193640047, 0.3199129264549634, 0.15129801826182562, -0.3865847725021182, -0.16064689407844268, -0.3066520456348071, 0.45571776008501086, 0.44766248861635244, 0.130099291404195, 0.4931709832438946, 0.1705491504930246, -0.2117286669997866, 0.08839565803955503, 0.24433428230476462, 0.10353745346727569, -0.1000257271038099, -0.3203414285734512, 0.19258278243670343, -0.205908165641202, -0.21681237619836574, 0.11983254343021468, -0.07268809276790629, -0.15723086846243317, 0.4073843131108177, -0.09700142846773271, -0.060965508130713636, 0.35754379930759594, -0.11483721835611184, 0.09467749509411232, 0.2654031532366838, -0.34835766944958907, 0.4272877135658134, -0.31390674225873333, 0.11675023119235906, -0.013672839694186145, -0.0883694119324911, 0.345049823847464, 0.14525095947928487, 0.34262929543847465, -0.2425330684783431, 0.17535804829794477, -0.05206591711081713, 0.4179198176770133, -0.2757593262759343, -0.12231545951178915, 0.13601542973518221, -0.17994069877691574, 0.5928922263682296, 0.31590419425307936, 0.614839471926766, 0.038042540514828665, -0.2904953412683911, 0.26965370253533405, 0.1535090765229978, 0.28876587066891257, 0.35895517253195275, 0.15989270281849177, 0.16300663575483, 0.582845627789722, 0.5436244316633814, 0.6275782664703005},
    {0.08393744530407633, -0.017559910310607746, -0.3748644961650061, -0.6156131017370987, -0.4648466388375187, 0.24950987359571344, 0.2185449005384954, 0.03430390956818559, 0.4196743175690271, 0.06931519658748733, 0.2518959464532043, 0.1833468817618173, -0.04225549542879816, -0.7356315755463197, -0.17331832504369288, -0.5680154278664948, -0.00894391664190147, 0.3595142494388473, 0.052434865087963904, 0.3614568073159342, 0.46827194521438237, -0.4984302349073335, -0.3112920373483567, 0.11580622284636174, -0.2697316388386835, -0.13441111913762968, -0.10423883596970862, -0.2612785428901127, -1.0818214197121034, 0.39165688727954806, -0.22465316025548696, -0.24381533814307388, -0.38112488657792526, -0.39007522451168203, -0.23343019466655984, -0.2878666867309643, -0.5327483277522057, 0.003014499420447395, -0.2990214135431297, 0.09222772049309161, -0.41280216756102556, 0.10065369792644029, 0.16880050357193324, -0.20276541328119452, -0.048405744386351285, 0.42531905237733214, -0.15267043319376455, -0.01232257036152598, -0.14338615977817398, -0.03630892501194758, 0.2480817338746539, -0.13695346809366724, -0.09513514616829394, 0.17944968055786636, 0.020483781154080644, -0.07683573604507608, 0.18442419265887658, -0.12775302127278035, 0.5760110917617256, 0.24325470564465024, -0.019140748199486357, 0.016803810446630554, 0.08615055108053823, 0.024528578526422946},
    {-0.16926882635968718, 0.4732343867808194, 0.4839617480551891, -0.845151026103885, -0.020080986209362144, 0.05586746166620619, -0.488429715825109, -0.16010850987558586, -0.4381157316431176, 0.21459989241204283, 0.5593918482258236, 0.07376859952260988, -0.568461742477425, -0.003499724140579811, 0.41593091829333995, -0.1349394858765537, -0.4596189840082719, -0.18960105471247282, -0.14768152101935303, 0.11816716763182672, 0.5288661704051529, -0.4777749967770917, 0.20648646133166815, -0.26986431302742797, -0.25316173206779324, -0.10576467300281506, -0.1451195958819572, -0.5384290499242192, -0.04001500845274178, 0.291195300681402, -0.15965023490557875, -0.07097493371603103, -0.2374493327636968, -0.24825380255280047, -0.20633359059341386, -0.23834612847153472, -0.14727026868490842, 0.03310634319060826, -0.6775192467485379, -0.7355694274827738, -0.02374546845848968, 0.05839476675647118, -0.1812437966040128, -0.32564629359786035, 0.05487090437600322, 0.4655471400694866, -0.14935703130143804, 0.4115980484408684, -0.1849523356901989, 0.33073067269075745, 0.26580305544447724, 0.23921896233621553, 0.27169060021005365, 0.013989204243585678, -0.08765259673591334, 0.12062687841833879, 0.3192628673664392, -0.3656142501393759, -0.010645156034035099, -0.3456138250333667, 0.181458196705053, 0.046183645992124385, -0.40585540089729566, -0.4332059729113558},
    {-0.39155787316175394, -0.04442712236572641, 0.8714180136248968, -0.043953860374283574, 0.40325255113832625, -0.11178154492801186, 0.4423627556350423, 0.18875171623146683, 0.17227073487589964, 0.33423196832107, 0.7677438680443416, -0.4743700102436321, 0.1425475112640175, -0.06722175041314406, -0.46427641553669247, -0.48093557987509816, -0.3758541779965593, -0.05786897317659508, -0.10618137303855307, 0.30148001686911735, 0.32047518512478057, 0.15510883057438823, 0.10206444028718145, 0.49654767633984925, -0.13494874576614777, -0.1591834069571674, -0.7534380221453372, -0.413761788856898, -0.7990442199440212, -0.29195749014601674, -0.09417676606170522, 0.060362906520697375, -0.32644588730148616, -0.12168217790005133, 0.1526335901948963, 0.15367862730346463, -0.28796815990868624, 0.011973226208560292, -0.6210271079995137, 0.50572068792149, -0.4551264020162517, -0.10078178652723557, 0.3268655711038042, -0.519257937131897, -0.12244252225147785, -0.2167417965982713, 0.09907496951903427, -0.168299870791774, -0.056956157717358805, 0.09319564827737203, 0.565546459111677, -0.07400146702010459, 0.5580186758991317, -0.5529335862673485, -0.22353177030906435, 0.22700768365816484, -0.2398367814507615, -0.02144136606800867, -0.22145001706102427, 0.21530353286588635, 0.022664980369602097, 0.109086974718357, -0.06920725643371657, 0.10616405607509127},
    {-0.09754961284226238, 0.12765490462001583, -0.3756483606246406, -0.13437902696843437, -0.4540631574198215, 0.019057208424983024, 0.30009577378405683, -0.04359252448164917, 0.7341578946737817, 0.3064115353987989, -0.44099166169991827, -0.19853508040967646, -0.053399419422086404, -0.436339862232497, -0.6301562272281541, -0.5063433273810818, -0.10106442036221931, 0.005808960532120224, -0.356790833149327, -0.34307760048728825, 0.45634566062294196, 0.04978488803715218, -0.19098494870382457, 0.1733649516179156, -0.13076243540226845, 0.011370026472035576, 0.16724530353228254, 0.4909602561087788, -0.5416088167813791, -0.0966706709396394, -0.16414868457105602, 0.1084833470622067, -0.21901563537925173, -0.5612349607347111, 0.32073240434157635, -0.34998195017066097, 0.08645806871983328, 0.22992732394321436, 0.5687886197296844, -0.15229393727033247, -0.24351234779961453, 0.2746119877812192, -0.328420416869198, -0.06762567554629602, -0.21054816485266564, 0.08830664354329484, 0.027684295568835397, 0.34806332381031496, -0.7084198840755327, 0.2307059730874608, -0.014111050148701454, 0.08482459278502684, -0.30357523785794654, -0.00020439769067990765, -0.2584738227795264, 0.5098591537256317, 0.14960832195571158, -0.4860120086336672, -0.1335413942197677, 0.06211899968778358, -0.08292073950735544, -0.08308439523257974, 0.0008129082117448109, -0.33294595095400115},
    {0.1791311956349104, -0.23500756194870948, 0.1948839790342853, -0.5608515027415821, 0.5080439669266061, 0.3813788226406526, -0.08510714651009363, 0.3149414375314206, 0.06358741122336756, -0.5000107170673782, 0.33434059305721364, 0.1915781689847259, 0.17551682643812477, 0.357223691768457, 0.31740395283357076, -0.35347659949311194, 0.22678761616615153, -0.02094239798573684, -0.047102141067987754, -0.13920620266883513, -0.3907551993615212, 0.40350456951135816, 0.12425879431353115, 0.1355359756456976, 0.2580064322701881, -0.09312213378808028, 0.25542298593610974, -0.41433944842201037, 0.15037495251722197, 0.31299267164325256, 0.366963341856818, 0.5093301622337542, 0.5596947340300362, 0.08466035004241358, 0.34483341789146804, 0.07960866613242536, 0.23745813998147755, -0.27972618789822895, 0.5041961684179851, -0.09629304935843906, 0.3334597306743264, 0.49547312085918677, -0.14750659339368724, 0.49943071482497847, 0.3345962209262815, -0.6209386217128283, 0.5316805285501074, 0.47991165811138525, 0.10712797903325066, -0.17918522344332197, 0.4019830373181664, 0.18693901170975186, 0.3322706793047733, 0.0619203421797626, 0.36401487082288436, -0.18499408047667162, 0.3281423893269943, 0.2624104041680009, 0.20855253320907416, 0.44064767461156257, 0.14552734020957786, 0.07215103042004928, 0.029772635993674263, 0.6881577304549911},
    {-0.30266523647216026, -0.040650990055506965, 0.15160178412010292, -0.21918856555939925, -0.389425297490999, 0.21667196829931423, -0.6052300579168178, 0.7852987856225004, -0.36544536213442635, -0.40387582353903506, -0.24970419146546746, -0.26654313441225386, -0.13665982755794442, 0.21151699320991266, -0.04995262720000659, -0.1819242362425774, -0.4121012880740327, 0.09899559596510904, -0.18222726282466278, -0.09587825116137984, -0.37456151783196306, 0.3257542584335816, -0.22197995936661882, 0.01696818979015832, -0.36459829557902385, -0.1423596176236239, 0.5735417543676311, -0.33751155411067135, -0.3251803384754053, 0.3830298400672589, -0.3153270291787961, 0.5542885729932855, -0.4553834264807496, -0.10649913805121904, -0.1272727720264752, 0.8368039309759535, -0.02117011850574076, 0.36615829556387036, -0.005814464085036545, 0.06122200435307556, -0.11001428933610613, -0.2157343304668488, -0.6044510110657152, 0.1544062008166874, 0.21992277249232747, -0.04140085156245867, -0.41108685891201785, 0.3610719690932747, 0.13027589152426355, -0.1695365858342204, 0.4510028320919544, -0.02568102019652052, -0.11717977357336856, 0.06312172681224795, 0.1322960127042209, 0.49036359212331854, -0.4843674903854985, 0.07220308846326284, 0.39149155858493645, 0.34812062952454964, 0.10945052043534827, 0.4916452430667783, -0.5292358802156377, -0.20387036565012248},
    {0.07790784415310119, -0.4760161936748687, 0.3603081812657001, 0.6672594667208408, 0.23512786349659165, 0.36768048100950385, -0.510701248346432, 0.06559201554967675, 0.5930769076308094, 0.2814452788053636, -0.13510325483715283, -0.3394081945536645, 0.4242083979417045, 0.3607340738481137, 0.47598799474731124, -0.16843823723165943, 0.4872078451915273, 0.18002873093942326, -0.09210168692621189, 0.29600585615089736, 0.0219319905396578, 0.10465898736067616, 0.4946050483987747, -0.6226758386513518, 0.3552644776133533, -0.1471666998982453, 0.559437085601974, 0.12712193966339402, 0.2796336626570826, -0.7734305799965175, 0.4330008666992339, 0.4520793486847899, 0.2925052929761513, 0.034136548289162176, 0.4882414385519174, 0.4881150120729638, -0.15904637326995275, -0.06754332215211147, -0.4577322315241635, -0.23451050167173154, 0.4904119727004172, -0.15984510116235115, 0.030150447165791787, 0.4660433937233544, 0.2131360926640596, -0.25139036657419267, 0.42850165201079304, 0.3426097009383909, 0.4162017041737188, 0.07109885041966536, 0.18650630667848356, 0.6089218023513926, 0.35847979747839553, 0.1679138578293647, -0.39061965226763107, 0.010341939558310474, 0.48013711839595496, -0.31330033836359494, 0.38074884256593206, 0.005590433950129174, 0.18205236204748793, 0.37215459335529016, -0.32894379125725587, 0.02097208245702406},
    {0.05969813205172901, 0.39356138846897154, 0.4723969250873027, -0.1732306742545756, 0.1509277231392558, 0.10931083481634614, 0.4754584576327174, -0.5769426789313091, 0.08089527429461885, -0.3898463657809101, 0.050047720512503176, 0.1488248667041129, 0.5320928601753918, 0.21692619178583097, -0.25230703017757894, -0.7092691987332657, -0.06532067034581533, 0.031309008217191334, 0.30683759775054553, -0.04641573025046639, 0.2667658269869144, 0.015130778077458197, 0.5999749478317199, -0.25246661264262094, 0.02209427997843561, -0.18034706981492324, 0.5336166984726607, 0.12112069722255935, -0.2506664146098204, -0.26274009083971384, 0.04353573057544846, 0.24769484120323404, 0.05124878749248629, 0.3202098958889658, 0.36459260574557056, -0.12655234334520485, -0.2675831305702744, -0.1496590488492122, -0.5392488236891259, 0.3974919349060911, 0.042029810159418826, -0.3054251399516006, 0.1537570301801588, 0.13016802338134842, 0.21368234259483168, 0.20478547008379286, 0.3106511547870005, -0.006866171664179293, 0.1511922259406197, -0.09266106370865326, 0.3046629116854713, 0.28159601075004503, 0.07754543758820034, 0.10193411212886402, 0.11874108046745123, 0.49582386338122175, -0.07382942985100713, -0.6787541600799083, 0.2653374379676127, 0.027120353401898945, 0.2733807160643785, 0.19361307511374132, -0.09582049950216733, 0.4729409543730661},
    {-0.49425505915690915, -0.21606188477313176, 0.31043320678522146, 0.009558198123422217, 0.3211460224525525, -0.4382755808273424, 0.5125129317448386, 0.05966317007612678, 0.03150284391585516, 0.1287121490752369, -0.07694286791439942, -0.27891800077957457, -0.29557559874534195, 0.09727601828707501, -0.1605238447993186, 0.07924114037854735, 0.18037215667596745, -0.3615605021408199, -0.3125036817478571, -0.19672980698287332, -0.3316981641724766, 0.18564812239280742, 0.17382940581288658, -0.1253213972729124, -0.17550072447118045, -0.11371653854346701, -0.40175244035489743, -0.759384701528698, 0.3298351066584602, -0.2198607798975322, 0.06833366316071038, 0.8343730053010716, -0.19103084960586628, 0.14388940844922787, 0.07597498247534715, 0.34129035742210834, 0.2517929483939881, -0.35205526872291537, 0.2939981919790798, 0.36597811709387873, -0.030191382844170764, -0.7191502977393421, 0.17249038217019505, 0.5804223810536441, 0.021247442781895106, 0.5013279118097056, 0.14119484089029558, -0.22345612974635684, -0.1763887428486256, 0.2507685753475934, -0.33986358566231434, 0.25983042514561383, 0.4697794812275032, 0.8419212429072905, 0.2682817928796604, 0.2549875332290008, -0.06760298683049837, 0.1428482682744095, 0.15083154712572314, 0.09510025213776785, -0.2990319235465471, -0.18955263715747392, 0.7834739067577934, -0.41534018182192367},
    {-0.01261245626790912, 0.07981219755692044, -0.21116662447121237, -0.5326558370120817, -0.1696424195649586, 0.1288430231223006, -0.09583769582135954, -0.5676482571461179, -0.19441212006067118, 0.08809344799301227, 0.44888949188119753, 0.08263358094037457, 0.07129331061175385, -0.15628334951090098, 0.20015686400052307, -0.4422230276966319, -0.3838238554421196, -0.8396856968974696, -0.5142411500152824, -0.15374475956543218, 0.43896425176797843, -0.39459400266975775, 0.22308009214802133, -0.025584153240855244, 0.07137270988681829, -0.28624499399401376, -0.3306203085009376, -0.6572753145771107, -0.07995547535811269, -0.19872376998057503, -0.653936180972894, -0.11641774417842912, -0.48450074089193645, -0.2100013988768005, 0.23254775307051284, -0.25220052730789133, 0.06971974419695098, -0.3892073754155102, -0.5517517934933219, -0.6484507192804614, -0.16971499345968039, 0.18921486631189935, 0.5472895142504326, -0.013757424561287316, -0.2508637999853912, 0.009298070299961766, 0.10986560097358591, -0.33831018248512706, -0.16741017026555294, 0.3719789832247552, 0.08694474806465821, 0.3467615667196831, -0.14969971642173724, -0.14768200671534398, -0.014018526647243871, 0.010857061037334498, 0.24803284874054096, -0.623436170246503, 0.19617839745744595, -0.18480115675043765, -0.5203706397941955, -0.0989151323864854, 0.39849512633316003, -0.07650498894984362},
    {0.2734024291449825, -0.24200383057926486, -0.012237402268145346, 0.025095991785704586, -0.4847030930317466, 0.7220344873417429, 0.4332578196178966, 0.19425665244743215, -0.3166715541905901, 0.34786192821433376, 0.6203824220070597, -0.43351826126856285, 0.20203559489886033, -0.48488448224425673, -0.3153119010390499, -0.37756320789401737, 0.4493178667046006, 0.15359044997886206, -0.7366960035695663, 0.423193904522043, -0.0037036322329560365, 0.23858372374551542, 0.70402086221309, -0.563960860992828, 0.8488648401414594, -0.10810307858928712, 0.2635091380699989, -0.35101451716994403, 0.0888665631643322, -0.14590928504923847, -0.12350396013515019, 0.28378734088770763, -0.01556350102411176, -0.16927747074450852, 0.2673496004548375, 0.18189918347264641, 0.044226962865568195, -0.1474809557975072, -0.17208995135482108, 0.5407608069318451, -0.16923626287423107, -0.36292173977620185, -0.037552182529831626, -0.2455099657841875, -0.8164851932065328, -0.407388518840314, 0.1779893035476838, -0.5368927195570348, 0.20256860954475922, 0.5662270544998319, 0.2275624431827769, -0.3663533267937695, -0.24199925971448644, 0.24193260703998548, -0.6483823909647835, -0.5436496403636797, 0.741770557453917, 0.02197508876071216, -0.32942984498561373, -0.25224532771403363, 0.10654513464528621, 0.3293624049457948, -0.07710758572934055, 0.21113322992872227},
    {0.17205183900066406, -0.577699995839286, 0.3584882756024914, 0.06918949826182555, 0.28928431051556014, -0.19131743071858937, -0.11044912211104357, -0.0037549230276279016, -0.02295497838337939, 0.2975038332677568, -0.04838734135357569, -0.15117693811747046, 0.12542733079521698, -0.4048747257104987, -0.11518977955925262, 0.31577217144739694, -0.13430460452775642, -0.8331456073375754, -0.2554666440396572, 0.48890490950253196, 0.06654104333457271, 0.18490031387339242, 0.36234659229379934, -0.3211402404744297, 0.47551633846320085, -0.33769195012606884, 0.35371869290527025, 0.4804059053952582, -0.01761959441785841, 0.09287663702339526, 0.17027745602395275, 0.10067906359924356, 0.04702607572036961, -0.09049368960310673, -0.21785562549156773, 0.10202274434611912, -0.18203334885682723, -0.5413195049533989, 0.1905614225433931, 0.10891639746808178, 0.19463061725784972, -0.6486383987429899, -0.051474665350014125, 0.2365073343553901, -0.2115176598810895, -0.290831063852018, 0.3469823862276573, -0.6709000069841377, -0.00753724851230123, 0.4965583340576284, -0.17251217814923125, 0.6181537686019435, 0.13742394394565638, -0.1489672473899688, -0.026703183013827885, -0.4607009276681635, -0.03917389051682089, -0.13418939646281755, -0.36126954392425314, -0.6462278466655285, -0.32158270228949454, 0.061527365032774985, 0.3199116797763515, -0.3346243340617882},
    {0.5758061270224608, -0.10578530119998066, -0.2692533787579877, -0.00777749555323731, -0.024265635569036558, -0.2951682211244385, 0.23184653016633652, 0.2349874501876077, 0.13883071373846148, 0.2808042007956576, 0.2620115696536708, -0.463810014521504, 0.2321179123349584, -0.021112977182792765, 0.23271596581331658, -0.15207981709061688, -0.0630774332184357, 0.06474070741790894, -0.3255999345795929, 0.2797751597203217, 0.1679197060788577, 0.14569419111996493, 0.037026930387117, -0.046318762735654065, -0.04783532011701039, 0.48640372209812643, -0.33186602523353115, 0.24307122488356447, 0.14100163209612732, 0.2562274022446757, 0.07895296043870216, 0.2037904174324047, 0.6187483484666305, 0.34151171922182544, 0.5137114428595964, 0.263296042341497, -0.1333874498211169, -0.628257143266688, 0.01382512454939593, 0.42438404666976154, -0.0007407245047177458, -0.04912168006457982, 0.2370160385266852, 0.2839369770130087, -0.20814928689226403, -0.32875693435730596, 0.5355708700957088, -0.5210908988670372, 0.037034938233139726, 0.3205676042099324, -0.3303857996764781, 0.8373498751485796, -0.2160172457586355, 0.27226102423172976, 0.11645047459909884, -0.22360210944228828, -0.11844009545734141, -0.5877376932683112, -0.6169892327069747, -0.13664483374093114, -0.030262126368521634, -0.19721637938974934, 0.621329480055966, -0.09024359874007966},
    {0.7438855086254961, 0.16614762946341102, 0.13413932529822414, -0.30919605903024183, 0.49012167684245384, 0.26195170206416735, 0.20618334464569363, 0.15344822489736978, 0.4749131897497435, 0.3173539290236206, -0.16142493387741186, -0.3296937446501127, 0.18468790261880783, 0.12401958979568313, -0.09366753035425915, 0.002519991334191688, -0.23389312098963652, -0.5369539686033373, 0.26450312839267975, 0.28555838886938373, 0.44747018997165905, 0.2449386676802881, 0.35661144329034616, -0.46528396601560307, 0.6599333008903849, -0.09587958972205217, 0.5360581085403602, -0.10981486375619977, -0.20468942375716806, 0.16167030277311487, 0.0475311653417454, -0.045899540421335226, 0.07719376465862178, -0.33322920238544124, -0.17067413412069068, 0.45327021692522246, -0.24170979163346032, -0.32891636299766985, 0.5071736203329995, 0.125317619028481, 0.1356879248396122, 0.31346395121957643, 0.18976950521085953, -0.12172224890266858, -0.5491274832142937, 0.17448320371061438, 0.6063331310584337, -0.17372020710211053, 0.7878424603992227, 0.17029845081546682, 0.1775998266681028, 0.47694419646013003, 0.18227608240395868, 0.4339723567227035, -0.15618959391783055, -0.6019163223340145, 0.32602499302148635, -0.2917824542922134, -0.18031627811896478, 0.27122013581461085, -0.5244590926911176, 0.4121138585050874, 0.6851001925645519, -0.23505178634862003},
    {-0.13700099871507324, 0.29837132996792054, 0.16147317923193827, -0.2087636298219081, -0.1657206686265508, 0.2778814035324802, 0.18682856173492274, -0.20256471818781735, -0.43831485751126104, 0.5658166818615431, 0.2651900461166751, 0.24067202894891465, 0.11976123166822199, -0.12817197413484135, -0.5596090428737972, -0.099131010990423, 0.46327565756422356, -0.354390595985942, -0.3079318591458408, 0.7898728244552187, -0.01138416400179478, -0.5311802595526077, 0.37075181488399245, -0.5549593239230649, -0.047075367482646416, -0.1388230347531469, -0.14636549735324295, 0.5534411413508307, -0.04170982937211785, -0.12285619175926218, -0.02346828129278964, 0.5180420406971102, 0.0903476038736174, -0.07614123701415512, 0.22454681092982012, 0.07485880206957149, -0.5257714176251418, 0.2883802933478198, -0.057866184307904946, -0.07714419137833783, -0.21251266108600492, 0.34940372546420484, 0.022422401481325814, 0.3287723939038752, -0.15342751690768072, -0.35063828902883054, 0.11743092991403759, -0.31409295105348617, 0.7165528190207735, 0.5260632383299915, 0.06411503758095574, 0.1936142213152202, 0.8434864907960632, 0.668476565801815, 0.47906197096841363, -0.38765903857632983, 0.21030160730235187, 0.035433739623115634, -0.0608657482225972, 0.5565119609794056, 0.27747074073631517, 0.10731089903334881, 0.2644554067446827, 0.252468644769984},
    {-0.06126399245811643, 0.6005679543745338, 0.09877462659280127, 0.026133807892757203, 0.5316963155409397, 0.808802890151252, 0.5021518761525661, -0.33727243042741845, 0.06436144002891847, 0.5430969173787656, 0.21656227960408603, -0.010300343385262038, -0.10087484069575293, -0.08215710836178898, -0.5732241514828003, 0.21610233959932054, 0.3757034438109148, 0.3483905772807133, 0.09668206614212008, 0.1975106646060377, 0.5401640490274923, 0.126855551311776, 0.4170484444845995, -0.059868193509484385, 0.24013750064783035, 0.06452389657497364, 0.061255620035668285, 0.6443713761448416, 0.23520713097523202, 0.26129486131273344, -0.4189192822384103, -0.019555956432393603, -0.4288472700199322, -0.4257785046591893, -0.12122601784914397, -0.11040324601985615, 0.05238591106963837, -0.4985204726263433, 0.10539751302737345, -0.1518531445116668, 0.26008897563111294, 0.08987139331151324, 0.023710986874598116, -0.20429824739752853, 0.2035825012683293, -0.05109757357926532, 0.39923656589549167, 0.36736937433092437, -0.23540223339267569, -0.2635004263913474, 0.13362864652341777, 0.31905293509425064, -0.14993173498749615, -0.01890637515638089, 0.7047652294748238, 0.2820808249969512, -0.34895308264063735, -0.21804294125689233, 0.4983739715273955, 0.0829713504222917, -0.1625572498962888, 0.1583459538919768, 0.5355941019650658, 0.8484934433402733},
    {0.30673236374256296, 0.266437238240292, -0.3130794090872698, 0.14584579557478536, 0.6573257506721271, -0.5128431494853499, -0.35458218211030357, 0.02937112554921463, 0.18475984819818944, -0.08700223643224941, 0.32084061873173186, 0.29871458350930247, -0.3445113932959087, -0.06625312998702322, 0.31477948591409627, -0.04201943555723156, -0.14932388467848376, 0.20821212290362248, 0.8816147848903593, 0.375819202204314, -0.28951297175853563, -0.0020702804928533726, 0.3036025467472062, 0.38332538676227224, 0.2916548592985213, -0.439198307666767, -0.03169489568521007, -0.1195881236591538, 0.1075995131496501, -0.11086809375326614, 0.07443529185859417, -0.09872135973546267, 0.3333358407291534, -0.01340923337675073, -0.18505020593586685, -0.4255532211340457, 0.08523807720114304, -0.6183122113591148, -0.007000846443642105, -0.2683862187307978, -0.0836940127177239, 0.35244295153292743, 0.273979325141606, -0.5251493324292418, 0.3138484539506918, -0.37786700256089967, 0.5644491076178918, 0.5568588610177456, -0.17700555645196472, -0.552424788854239, 0.12195099677638253, 0.47284905183168774, -0.21079701637697457, 0.2601177809832264, 0.09069457776003302, 0.018195760779224596, 0.664280115616724, -0.5970577546861989, -0.36852541809130734, -0.6482226297255962, 0.0628823082637697, 0.029220567946152454, -0.3522433356685014, 0.22335515516052468},
    {0.4050441193740727, -0.14092355366030565, 0.5891338899516146, -0.474457485406101, 0.5983423847154832, 0.05474624319564521, 0.20279394602762116, -0.061386243520051974, 0.07807580613702168, -0.5358477081277732, -0.23896038954385734, 0.46542004482321714, 0.1276575390225818, 0.10576588954421229, 0.2416142684210413, -0.6257929282458248, 0.5564323332409506, -0.16704959747641354, -0.2719198728171348, 0.2796447958379732, 0.3913098708193168, -0.4121347819543532, 0.18578204352096536, 0.23073367839359168, -0.07121216089003816, 0.23569411957926803, -0.3468771440621244, 0.2772618326678104, 0.12921974903671576, 0.26412085277584996, 0.024316920968044286, -0.3515407899583183, -0.13341776126791696, 0.21152356565535188, -0.1931967450643076, 0.10630480567935983, 0.13673564101607183, -0.36175123720287344, 0.06995438285397017, -0.5266288078446619, 0.012733956987427957, -0.059377224716409584, 0.17009592814766997, 0.3859861673674729, 0.1685502404749738, -0.1546846996405607, -0.4888469892519958, -0.3407709373122156, 0.11106582552170667, -0.08374706163579498, 0.20453666164827625, 0.30167775803070873, 0.02852712842432144, -0.13527070297495164, 0.10407334844137846, -0.43997623951165693, 0.14721862038032263, 0.2515403105241417, -0.2870394986070481, -0.1500291072952162, -0.025403555859002027, -0.37332506595424914, 0.736998989495169, -0.202963921287522},
    {0.15218865314959862, 0.3592173834484462, 0.48209711187416626, -0.5032863644094612, 0.15487568723545556, 0.05321142272548839, -0.3088971068643174, -0.24773998796239757, -0.2653631980779833, -0.435792977774709, -0.02342988139638153, -0.2993618115552714, 0.003976401081061845, 0.020064719978938248, -0.05337686276383005, -0.3559785929228964, 0.35608569754786445, 0.1191397262042561, 0.7665015527430322, 0.2651554935985803, 0.10770516901175602, 0.047519464754299905, -0.1470349053098952, 0.2652813599523855, 0.44650376803386854, -0.15605137217986328, -0.3978768162381699, 0.16198360164350636, 0.405215375822508, 0.18154032164101416, 0.16111546545572547, 0.4123482534464191, 0.13598887617111877, 0.26488197797141355, 0.17692003579686008, 0.011816805374767276, -0.46227977078461013, 0.20160805364910936, 0.25528824983007786, 0.10159612321194532, -0.09897663897757211, -0.38668505238427886, 0.4190423526196807, 0.17616698638641196, -0.023603973403147755, 0.26226056259243136, -0.008256230713959629, 0.003924718774513582, -0.35708495457872635, -0.1016328274090409, 0.5994672090450314, 0.11441756380656602, 0.4480269224473896, -0.14972845838800647, -0.683350255978809, -0.059652904559701604, 0.27658057315386664, 0.09662567836123502, 0.2835499860521195, -0.21244360599495693, -0.11373984289199747, 0.4307415294163807, -0.30099937789320164, 0.5701473441964946},
    {0.31152771350329134, 0.3929812264334045, 0.8161811423036432, -0.484803926538609, -0.04400815507132228, 0.2603842900232241, -0.4349608853913288, -0.30535520942092365, 0.23434314288392102, -0.12099547748630111, 0.12840171790211521, -0.04777976421850221, 0.5519744250289743, -0.1624940382498653, 0.40273722696938596, 0.3738630207496152, -0.09364036407419062, -0.22133811518133306, 0.25890914206969456, -0.36254612493403876, -0.42873625317823383, -0.34754306546389396, 0.21223961008557807, -0.11764399040496076, -0.048654865547136154, 0.1377436695740135, -0.6447245151383116, 0.20345728823480408, -0.09194169053051432, 0.24123696088528512, -0.15917505667614545, 0.49449765365728815, -0.22745208351163196, -0.6181521533125426, 0.16681870123048512, -0.6973477299214645, -0.19787542799116967, -0.006945543295814127, 0.665316182579193, 0.375853410065926, 0.2907136895806288, 0.12333160375479414, 0.36103535144637483, 0.5221579867571489, -0.525880166476199, 0.19732622592553364, -0.43263668705318536, 0.07714766850576339, -0.030452943321831603, -0.535355153504987, 0.25199570460324977, -0.05395850049762855, 0.12744119125097217, -0.1467361031369529, 0.15142799556449804, -0.05000962572890927, 0.30600087205119314, 0.04271024230865746, 0.6639067639625518, 0.15404758639137348, 0.08990749534856898, -0.16571641588495253, 0.18202571381910618, 0.2942088294473046},
    {0.18851047711188162, 0.09971257362825289, 0.43205524764560094, -0.12124626845740485, 0.0813662531166516, 0.5703392953767474, -0.16217759828227712, 0.18550619601721147, 0.21746569760146697, 0.4702340213682591, -0.12279008815289286, 0.279613298934434, 0.4426328017714174, 0.07717986539862176, -0.088850718142767, -0.02301558131429522, 0.39828024063041034, -0.14923764092274508, 0.38870178518685755, 0.3287708225704813, -0.0015527219266374926, 0.5155168555596821, -0.03502527614862452, -0.37851373727852194, 0.39783067243382436, 0.5739575173994116, 0.2274900335196913, 0.3573013264674434, 0.4870792228193099, -0.5523934573498239, 0.34802086249081937, 0.609147094604648, -0.18728055619879813, -0.01087098234362224, 0.5117766589850895, 0.48285530541987914, -0.1675579155969052, -0.5356201439354875, 0.08343692967140073, 0.40691125288161223, 0.453602950201114, 0.08889114881659492, 0.4996338538998211, 0.14044782592424676, 0.03382999307642109, -0.06575262216759693, -0.017034305671342533, 0.4616632395816702, 0.6045320446049887, 0.06079990067822781, 0.5313106777471107, 0.22422837038047919, 0.35565519290308356, 0.08810957348598751, 0.2898555396622927, 0.0927576042780992, -0.08004237211444239, 0.06404082691008026, 0.520493239689391, 0.6735086035784343, 0.056116949341913365, 0.41914059414053784, 0.3927593139395463, 0.34263148568677354},
    {0.5622487838130891, -0.4875121872268038, 0.41819064890933505, 0.22624432423209442, -0.08474465626318484, 0.6751571993247891, 0.1543521322035287, -0.44230981939117386, 0.2737424512067665, 0.10527105388883051, -0.09738819326572723, 0.2713218623101119, 0.20336478503561434, 0.529072543775416, -0.07099061878964036, -0.310277178338895, -0.2480182698842714, -0.22113596971654678, 0.3229774190943863, -0.7785309187333463, 0.1188223902783826, 0.20126534659018536, 0.4252855924129451, 0.4718288367150552, -0.16761649184528343, 0.26739724838102497, 0.1888999133275328, -0.32881059176733546, 0.20285636269366078, 0.2665292098181601, 0.2912763125723189, 0.32651194298501596, 0.48905871917189553, 0.2963852537583281, 0.45921298011877976, 0.11768491788919709, 0.22815456002673998, -0.08871583870917917, 0.38355994313758723, -0.1033627768922824, 0.32515477824613515, 0.7303668332973073, 0.2470674975663361, 0.31497572424897285, 0.1933362924103685, 0.2511571421909449, -0.0478452938039616, -0.3080645268647067, -0.2567755051192416, 0.06425408970987721, -0.5437569052844446, 0.3783730553021064, 0.1581009034776267, 0.14004636596405062, 0.1308514763579366, 0.13327246691534708, 0.21781451495438428, -0.13984767205495763, 0.48577265174662876, 0.1696852263111164, -0.32226966929478784, 0.46352693267671424, -0.10623061277222552, -0.1471054770847326},
    {0.5478433695013568, 0.7622994639679561, 0.02692303362248824, -0.25064008643771146, 0.6254475372096776, -0.20235625937510893, 0.30420936525056047, -0.10519233344282237, 0.25015979474666217, -0.14707671173912013, 0.11508883243433246, 0.07636190295209803, 0.19766247897073244, -0.06624441157276388, 0.13189556233666408, 0.4556905849692574, -0.2299015749226689, -0.3537242711300857, -0.15007064954274302, 0.008525622457650183, -0.0468999077288475, -0.1216728522317755, 0.2339002927020689, -0.16137220661061635, -0.26057984325255157, 0.08641234659937413, 0.1400520987992584, 0.38796234170663524, 0.5219921792772332, -0.40930526744351925, 0.20356840574508775, 0.09509843081327662, 0.1925986141695518, -0.2146426351336813, 0.07615214316677324, 0.22644271464218235, 0.009604765669461758, -0.11817874266917021, 0.26341287004700953, -0.08727188774169543, -0.01759530504358127, 0.22756021482568484, 0.27692205786200574, -0.07880935791918083, -0.11887595505701581, -0.2263506486889906, -0.654679766655015, -0.00499718548307314, 0.284875798269241, 0.5276311705846505, 0.05441733438677206, 0.2628901844966473, 0.06445380029338946, -0.03688451060270775, 0.1397038284956646, 0.07401567010129469, -0.153794554774818, 0.49949538308306407, 0.3859056129656018, 0.08594017771807134, 0.2720054521289392, -0.05583390345333667, -0.10955103788606828, 0.39821489621249745},
    {0.11364130865415475, -0.05407651580290709, 0.1320287423811083, 0.42206315249050147, 0.050304127630472935, -0.20050109703077867, 0.12524287972372333, 0.058779627038674634, -0.27790476542735665, 0.10598317586539845, 0.26653039999270495, 0.26586649448044397, -0.2868698426831043, -0.3627932429466718, 0.3066243895025289, 0.10163460105744902, 0.4634622296779608, -0.32595282273297055, -0.05037531915774086, -0.20334377787850846, 0.22892082292645785, -0.41013343596529933, -0.25496445779274896, -0.3677745271376316, -0.13330252779001725, 0.13142730586744858, 0.4073464569904772, -0.22524921443118848, -0.04994362810669462, -0.0311978205895585, 0.20656936424244138, -0.28670301580453456, -0.3986595605696911, -0.09559425818050198, -0.7819494263770126, -0.2571183777884762, -0.18524151837216934, 0.24076781493816285, -0.21137628493653127, 0.23002159266957292, -0.2269994416467484, 0.3375122113152571, 0.5486933472667155, -0.3823903094296531, -0.4871521169460566, -0.4802390835337093, 0.38141825350379654, -0.3341104696531081, -0.11531556272712812, 0.12845314587764936, -0.19506387477812218, -0.21908445945945676, 0.01974786954136705, -0.0417453733275408, 0.627971552411511, 0.27954949767161613, -0.49368092798126373, -0.7110679579190099, 0.22183544534508212, 0.19778456017191628, -0.1266319432536602, -0.25531617152305874, -0.31374478928653404, 0.2906328078535736},
    {0.03354336815711222, 0.2612201484346788, 0.16439428546564058, 0.17661200240601724, -0.3853156120087302, 0.1000663500534902, -0.2834896113785081, 0.04535205162331132, -0.389098816622149, 0.0769514520632975, 0.0992902698430725, -0.012590554364029484, -0.05403874696072579, -0.4416914769923752, 0.44820069392729156, 0.21638373216910092, 0.29845693685006064, -0.11664863931806704, 0.1900002224499492, 0.15264908906058086, -0.08578582926301613, -0.23587930850399566, 0.21204159129963648, -0.10078764286153737, 0.3086722157744917, -0.08977268171143216, -0.30873789520781963, 0.2547550494598972, -0.06556416297298266, 0.033704348573871265, 0.05359366296078098, -0.4384410318476299, -0.2260359087099923, -0.15979546421181104, -0.3664888892101692, -0.5022775014437181, -0.10837682960271625, 0.23842152174124562, -0.07256549807263053, -0.28829574314551193, 0.06368930000425056, -0.05355046057330996, -0.09193595211263964, 0.08537025005420766, 0.20757532655369262, 0.09749889025226655, 0.23927169526943304, -0.2124898333339627, -0.4264572799260217, -0.25042296006780246, 0.40110359010136376, -0.11002749722027014, -0.14111114654478374, -0.039412270801857226, 0.060766943176242004, 0.05080002123854778, 0.3890175847990324, -0.22136163690762936, -0.6207334978799475, 0.469036982503361, 0.1580004815218728, -0.10747249196340944, -0.07927935122222003, -0.09986505655132938},
    {-0.29409980421725856, 0.07491978951157238, 0.07620556730641578, 0.1406616435559399, -0.347609436642705, 0.017448346953106025, -0.97652941824814, 0.30962622596463063, 0.03550498694998904, -0.3041534242388897, -0.40013942307422695, -0.14671390830944683, -0.17749580148765728, 0.05538737846540442, 0.571919918998101, -0.3335153349779183, -0.29438233994109836, 0.15609194120874384, 0.1288572692697285, -0.12983411763449196, 0.08108782093068333, 0.0957040634942989, -0.2337402972624873, -0.015199264003596214, -0.2582108173722765, -0.13276099242532138, -0.36066385044343713, 0.1271525504500755, -0.6175625667938782, 0.005824487355747167, -0.06766293451252042, -0.033403389028050214, 0.033424996187948475, -0.15302739749634436, -0.10320194552837138, -0.16279963925983643, -0.45378592213553826, 0.009893520228938408, 0.22342743927248657, -0.39595261452129515, -0.01797952034369334, 0.428767444057714, -0.22412521038396777, 0.0030234521576365096, 0.3657416370126933, 0.8000742957980084, 0.08429493732248046, -0.06143491394602118, -0.35622255437501565, -0.39821983459824967, 0.25053394457279743, 0.16089042314732732, -0.6073605675014091, -0.1849191455733354, -0.06579063848007735, 0.28483908790880735, 0.4122930940030488, 0.2503385946778648, -0.5029638812233891, -0.28068462928836424, 0.09526204634576504, 0.09717452585349737, 0.23393991438053116, -0.5707325152166848},
    {-0.32965009383131594, -0.20966719914072307, -0.19417412865343955, 0.42654594458508266, -0.284926009857115, 0.12376976969620176, -0.1315316518004135, -0.08499331586828461, -0.13022118032842223, 0.02193078215693957, -0.27533465400794765, -0.08600922258333994, -0.09501139154898192, -0.016431932827283172, -0.4783691797187483, -0.4869823513847111, -0.28925315941605295, -0.06003280668107789, 0.32045694020411825, 0.1048259201491693, 0.29888573771747945, 0.04479594844759735, -0.16729319128978176, 0.26040137019686843, -0.043384457023454906, -0.2181998797260047, -0.19410154843534863, 0.05261983626805587, -0.26597814613066456, -0.03614328707182236, -0.17668203980093017, -0.3224617949077466, 0.5012612816295582, -0.2644725343160232, 0.18308805773318979, 0.08336513545947938, -0.2365802606696804, -0.3559743434002788, -0.14453151765589015, -0.2161172296731627, -0.23171774639955578, 0.07747452326339913, -0.6998163559712833, 0.32705813381844223, 0.6669445782791341, 0.438415237774542, -0.18957528730625253, 0.4437908064950766, -0.4714694837724598, 0.009055671274420132, -0.3196623374910186, 0.30931331122375944, -0.3995444006626901, 0.6057965119520001, -0.13403380696112135, 0.073857442093556, 0.12975712185028535, -0.09682492411240977, 0.22017996266464532, -0.32523655140958463, -0.38835555890571694, 0.06413184118561105, 0.17397779505339658, -0.27838738714748645},
    {0.07191966125454144, 0.10639096355683648, 0.18411120087347396, -0.5729223481099044, 0.1279175776960945, 0.04791604591069731, 0.11975134331887738, -0.11691948034027348, -0.0001110659629367282, 0.16506868116475062, 0.09380763010227312, -0.4709075503905149, 0.11851251545288298, 0.4641353366302698, -0.5504144835376618, -0.3158706189724951, -0.06897129912971724, 0.08796103341702147, -0.017763916716346848, -0.2407669454589875, 0.0783650582963079, 0.2741209302027901, 0.3845613152362691, 0.17090481698997248, 0.1656828405170611, -0.06318043856797635, 0.15640641584935927, 0.11672646881835064, -0.12495413625387645, 0.09120172265530062, 0.07961541063470969, -0.3406324555273335, 0.15011088961688468, 0.27441281903191317, 0.697227968967165, 0.14292923921045173, 0.10064347036538644, -0.7036970814040696, 0.2612439893183812, 0.17137316333136807, 0.01823857333784234, 0.06996399890563959, -0.1319449202012266, 0.08385762377823965, 0.46636078160818883, -0.16693676200766844, -0.3981625984224643, 0.3749467458672279, 0.04125158016916967, 0.15195913209101938, 0.11492397607510278, 0.07690782341921436, 0.3925849248752152, 0.5095301700323592, 0.4339657264268867, -0.25606100412415644, 0.2220205732464117, 0.23088679130591053, 0.1753908942854031, -0.1772734690866507, 0.01993964881735033, 0.23925343299446403, 0.2774395843060957, 0.0815846614375434},
    {0.15854272032827563, -0.06705198296559703, 0.16362806328593074, -0.006550217620201094, 0.3926826192731519, -0.19128973150700843, 0.512189897456403, -0.3249894785500932, 0.1769059356676245, -0.10515727778472646, 0.4864139142943375, -0.27564476699671275, -0.27993948238248534, 0.2376903741318713, 0.04138408561929412, -0.21971865138546087, -0.21297907580453868, 0.4386064333297543, 0.08048172362710063, 0.15881895327139733, 0.5646531974495627, 0.40606034935650176, 0.019113158340317845, -0.1575336565509561, -0.13649265352761217, -0.25928902694926315, 0.3812569087936172, 0.13751870545188324, -0.18357938271063162, 0.33971344976394663, 0.29129236972901634, 0.3655649681574565, 0.04579552084821777, -0.261196170299348, 0.3712252216009495, 0.3432126155817642, -0.21011289829143492, -0.27690472702112945, 0.21882541086932666, 0.20584012705023638, 0.2607559703251353, -0.08329528765537396, -0.3473932429601569, -0.06984147422860688, 0.46051959622836774, -0.22251991087844877, -0.22444213774901592, 0.019414790509225094, 0.44724500838348114, 0.25174194175291986, 0.3816444310419133, 0.2083463311476611, 0.4369677388827096, 0.035572269272091686, -0.025698287662186393, 0.09902789557561202, -0.1419801496308802, 0.10782742081078756, 0.16715983015794236, 0.23017691356553102, 0.31840431031149175, 0.48406089418487314, 0.060930567928707845, 0.10884261376480601},
    {-0.008108959176390075, -0.09204239476048441, 0.397512085898497, 0.2594754549858886, -0.20891879446198772, -0.492845265982468, -0.1495311282775912, 0.03588211514531277, -0.4919571281822416, -0.2568154830756984, 0.2265541553312402, -0.26641489341704344, -0.21372912685691103, -0.15844468774496534, 0.1988879987626863, -0.6868796910374892, -0.31579998601926057, -0.03653093768843525, -0.09413236173034897, 0.11080723639074967, -0.2059959601697797, -0.08359387628170735, -0.5106354807038284, 0.17396422195805902, -0.32478915228816463, -0.13300427250788277, -0.6179087991485578, -0.07458587357142729, -0.27159166624270953, 0.12333167367044331, 0.0513439810311609, 0.12053173946476173, 0.5231006727491941, -0.3030507174773132, -0.12398600846387305, 0.012583803070183001, -0.10409895473533644, -0.5032564783164979, -0.3134856498796252, 0.014882074943910207, 0.1550202952973192, 0.13218780753678333, -0.1509164410233308, 0.1836104097182467, -0.05406336787198198, -0.4272142258755835, -0.14167148221895665, -0.33168606086764346, 0.03730283285748595, -0.31995971544224155, -0.1640364179871729, 0.5049255215053347, -0.1426011652357809, -0.38509127804684595, -0.48150700173841615, -0.6676085312269069, -0.0723529111704571, -0.0679818641156668, -0.5076472505964128, 0.17204424978842695, 0.20922214938177283, -0.17251934686654946, -0.34288101286540995, -0.24812590887205274},
    {-0.04824742331611971, -0.17059949137220193, 0.42280558464026946, -0.2239984490594439, -0.35362694672775585, 0.6037557296808731, 0.09397883862257272, 0.6733492623984041, 0.23452892415394902, -0.11052803488998349, -0.11113653114987415, -0.043806079843912285, 0.03801028230976434, -0.2682261977118419, 0.23316367267565102, -0.26074626552418384, 0.006946378503763909, 0.3103875041302185, -0.07346604959840157, 0.5318080240743647, 0.290930710236847, 0.18149661960353985, 0.07106489792474756, 0.5622862729374172, -0.09665560668197812, 0.023925061181694948, -0.04865367010033369, -0.031786741826772526, 0.09097185470718393, 0.23161429651806792, 0.014495931456361305, 0.24803511203423684, 0.19979959157721594, -0.3847448362925394, 0.20529068389069352, 0.33645750934116603, -0.08589926700789119, -0.5524304210076124, -0.3508349617306956, 0.0856550213385067, -0.0057753037119981036, -0.1352342210488237, -0.6087952061137211, 0.41610683682915217, 0.027235552639855273, -0.037595148021975236, -0.0007619222072378258, -0.11076680740530759, 0.040003823253207164, -0.5170579660990865, 0.45467286717964117, 0.49353897247297757, 0.22812613566074585, -0.1566536358157202, -0.049980213709732095, -0.047052648678879774, -0.15487091719572071, 0.4227700095527407, -0.3631293740883796, -0.08009882744153646, -0.08487411611487082, -0.18924938302752292, 0.10769319878426778, 0.42712249499478083},
    {-0.2696486136162315, -0.21488953357800974, -0.11443227212665295, -0.44749910736871484, -0.15625645523014753, 0.01019520571907745, -0.09576804954207128, -0.022648472675801872, -0.12179312603301821, 0.22030798873089905, -0.3086415859691811, 0.21987795073871813, 0.4154945906774684, -0.3574648881222016, -0.3878424849375442, 0.1832580625479383, 0.2689732018362646, -0.12196555826741877, 0.15422794176838833, -0.4881553358170369, -0.008537460792010936, 0.08802508246867999, -0.21111299253719662, -0.15979471700995562, -0.1544929532555175, 0.2576781399611826, 0.06608978207365376, 0.1982488036704562, 0.1665180101392707, 0.05355782091466245, -0.0009718734005122394, -0.09225384692021522, -0.012806271587043, -0.32125691816559415, -0.18660312901785908, -0.5230028293980573, 0.08820956646435896, 0.4428949450024051, 0.4368488307004005, -0.09980843235680607, -0.4210572946958286, 0.559392550390386, -0.473706140578739, -0.06685673455711771, 0.10487188893362809, 0.15987858613742478, 0.3091850025333906, 0.3132081730261492, -0.5403928864510623, -0.5074484781756957, 0.043672872959887525, 0.028921550470805725, 0.28096141952100584, -0.44057583634314984, -0.028735665941029415, 0.2523289844891304, 0.31773335804237723, 0.43420894954128564, -0.05575445272878183, -0.09068897002121498, -0.04208444979548665, 0.08570462001089021, 0.3536528936534371, -0.2228867346840093},
    {-0.7887197079760373, -0.3761400676935026, -0.3455903718747088, 0.18584507811082024, -0.009008758264877985, -0.09549208490544259, -0.5592102657412916, -0.17837383146093555, -0.37831928348340155, 0.30255009326179266, -0.029476329237958024, 0.5105197756970575, -0.5687697712157906, -0.22292000098852605, -0.04541648847134498, -0.21592159099541208, -0.10136391922068212, -0.40908020904337256, 0.1919313908779597, -0.1635129309563223, -0.25309907121383446, -0.09197646983733447, -0.20103839707640694, -0.5753110590126536, -0.13605219429077875, -0.22578842803167423, -0.20693420210175043, -0.4506975443529257, -0.5494763485537199, 0.07344849277868883, -0.6104005956220122, -0.06518601905976182, 0.04374428600905766, 0.40506338240431866, -0.41557591191777277, -0.15274385262797086, -0.1544280836365902, 0.8716027767732804, 0.1449939797807776, -0.05949495673988944, -0.43511369731792626, 0.32782858495618533, 0.059241662523536014, -0.2865074585588598, 0.25653797212344237, -0.04311622527303701, 0.09018663306836319, -0.07177977650230238, -0.5474240026789249, -0.3761006172668865, 0.321584184333194, -0.3730418781679225, 0.09848123655073014, -0.2765642957938567, -0.5035237032338273, -0.2256788993304369, -0.03270466391803791, -0.014240066425931504, 0.03626209198901332, 0.20318508472166608, -0.23662617400829983, -0.5724040732778172, 0.19981553662968346, -0.31821097512962704},
    {0.4053169907088242, -0.7513905925366167, 0.1317184903832299, 0.16775196324726918, 0.19536273550380387, -0.19988814421881754, 0.2659009211972298, -0.17337238053059784, -0.21895895711940055, -0.22983864048988642, 0.03768906540096065, 0.3378892976371829, -0.6008541812185931, 0.15235946519524243, -0.5466849368756157, 0.21428271907950805, -0.18155955490629636, -0.15698097738199612, -0.01248105184485389, 0.2681807454629242, -0.12418197321317935, 0.2873999325226927, -0.2918445747263965, -0.3110683465878715, 0.15941088662911532, -0.332225103409051, -0.006628357569341652, -0.23209872246816948, -0.44423716597261714, -0.15977883204482346, 0.004643880589317579, 0.3326707511109334, 0.0817998224021562, 0.5393037615663369, -0.05484675648898345, 0.21005052828955664, -0.40778815019915493, -0.31359274111530777, 0.06034857554474868, -0.239182959272229, -0.6377287277435398, 0.09182628029284735, 0.026155020476669, -0.1808921561090224, 0.3882262417865948, -0.3349809309746426, 0.21515511919646443, -0.026412593386675336, -0.05818654611999929, 0.35692737083106474, 0.3311637735778025, 0.05695072596882943, -0.3247836627307115, -0.2765179401502036, 0.054797093946689975, 0.14798208213739333, -0.21290424938825128, -0.350246924201618, -0.3778740564030474, -0.050335550699675005, -0.534948379238008, 0.46436840551725894, 0.17312520893456038, -0.27060093133861823},
    {0.13813241649423716, -0.04489324169783735, 0.020509920256981562, -0.5127176285167199, -0.4718111556262146, -0.08894511179978717, 0.22390475473865207, 0.10647547044062242, -0.20199219865808402, -0.08382217700586603, 0.06325191208230463, 0.6117174772649953, -0.09840823204231834, -0.2290591238698951, -0.08425163820716008, 0.6126898956098235, 0.05855547291054367, 0.045782170930034075, -0.004970384968714385, -0.42096351744520144, -0.1835447384249908, -0.23139843819264014, 0.008791465813897009, -0.1382945594738751, -0.02709421393085265, -0.3828896457504902, 0.1764156660833164, -0.24103298257892541, -0.14702077623766846, -0.4454622035494013, 0.2559404388571444, 0.07527012906219854, -0.02823917127757471, -0.06029961930688782, -0.19953942494620472, -0.033527625530102106, 0.22879728124922744, -0.05977069964120195, -0.15208030936542563, 0.07694006934704702, 0.048257605887505876, -0.12096324096952975, 0.507422883047082, 0.09276228299321018, -0.6391924647661689, -0.0807885437472904, 0.021146640162647338, -0.006573149605245229, 0.6510320051518667, 0.12617565796563182, -0.4591599089754693, -0.258342807981359, -0.11329592822050956, -0.03579109448293544, 0.2150206141423226, 0.06850777710532856, 0.041374558564947934, -0.354285331795928, 0.39986861436515675, 0.5910684314053729, -0.03742678484125857, -0.02763133760652413, 0.015037859296389724, -0.19534833832424495},
    {-0.03918512329553565, 0.06914473456224002, -0.11597316727211414, -0.6690179919967356, -0.10170957066689901, 0.13508980277567206, -0.21822885099293213, -0.03277041572952373, -0.10757583767169406, -0.25433761058215926, -0.4327557802936174, -0.17028381543376253, 0.282262728944643, -0.1626617941821492, 0.240261940143526, -0.12870940343176634, 0.29996763810696553, 0.19917030438923564, -0.3323525565981343, -0.32500437681766803, 0.38581386470338863, -0.2542836492265988, 0.10328329703972204, -0.45350253332307855, -0.242418684978582, -0.41402904313866734, 0.3187752999432121, 0.3257566300717495, -0.41597845839094333, -0.08320507358359717, -0.13000939084626822, -0.28929728467276417, -0.5475670586603554, -0.19360361883219665, -0.4725943902865219, -0.45908588745285506, 0.016627074582553577, 0.4170653559094098, -0.2715642148946078, 0.09573395494360204, 0.26960338066607487, -0.42201596063483177, -0.5165361235955102, -0.17114651867017575, -0.18552187803653183, 0.23570928985711273, -0.24078075153393055, -0.09051809228870021, -0.055309417671711845, 0.1356422183173365, -0.262143823884158, 0.42268992549112827, -0.4750063203060944, -0.10958417711958644, -0.04526808683446131, -0.22197732837151524, 0.3293055621603614, 0.07805718756889703, 0.08337241463436071, 0.030466064243771778, -0.28436810733420564, 0.40972736693613765, 0.09428373004746221, -0.04667469317009351},
    {0.40465335164125926, -0.34055753830472885, -0.13375940900646643, -0.039521669024856765, -0.04958224203536244, -0.028660817736133364, -0.03749236718412378, 0.16653967788035137, 0.2835871720029638, 0.11673863015352846, -0.13108667082778308, -0.252360499580064, 0.13493300182701246, -0.08965349924274377, 0.14098278130349567, 0.10676177165002762, 0.27118069220143476, 0.015067065589190477, -0.6361828536095014, 0.19595928158607026, 0.006877104781872621, -0.06596196163865384, -0.03581981874537546, -0.08124408424676623, 0.4776562711961447, 0.2786372437346279, -0.28549465627939813, 0.3550306377509947, 0.023138999961096116, -0.34443498894525476, 0.29387341099925696, -0.15635698628942385, 0.0023794154258619422, -0.20571940040624054, 0.2514105131198256, -0.04744237398370976, 0.08650468516328155, 0.4177606372973758, 0.09143790825028301, 0.02327049185026366, -0.13341862931608434, -0.39232020101251475, 0.3733859388358586, -0.013996619334218408, 0.4906435895833417, -0.055081264310159486, 0.21239609879349142, -0.21873234276947104, -0.02184454245038372, 0.11796295077601449, -0.10107252127167478, -0.195038943756162, -0.46183342477841277, -0.10213001528353877, -0.2802681063326111, -0.17259249361465534, 0.08028060085512223, 0.08454565836063554, 0.050906724289086026, -0.35965936437841406, -0.17047705586619752, -0.320529140157717, -0.19914951407259068, -0.15007337849126037},
    {0.2021153318903352, 0.3230218490910654, -0.02669745378484713, 0.3491564386207189, 0.010288096371053776, -0.12519513433916732, -0.4113601546289928, -0.2302246101453681, 0.10403679047517822, 0.18892954362575193, 0.22451865983683816, -0.2316341861059323, 0.1621025318082732, -0.378011794530633, 0.03692917101577654, 0.40706532622452773, -0.012085846269264946, -0.29427459146873225, -0.12569342911342385, 0.6606076590978693, 0.053309237271423865, 0.4707169821993423, -0.21283025123293065, 0.44209397816257695, 0.17122379880611396, 0.405726446761099, -0.20295864584851242, -0.16494357483052027, 0.02667929567755909, 0.42390802210391526, -0.08461060830355643, -0.1332597626707854, 0.44290516691810694, 0.07626998101396533, -0.08876500363685232, -0.035412788290062655, 0.05621020001046028, 0.4822282068562446, -0.4268893650189452, -0.14698859566785738, -0.7431808060968259, -0.2047897836713689, -0.12748148227349415, -0.4813501046521782, 0.11697690302298566, -0.06290272932213103, 0.6496088431527061, -0.13716768369710014, -0.0984953927376085, 0.09570035616334027, 0.012645981677289093, -0.10427335550768471, 0.0192275482788092, 0.31085974558665774, 0.6244511512586517, -0.09433209758288891, 0.022803134030950526, -0.11668481782986322, -0.5553708491998218, -0.6923435129872191, 0.1945367901315171, -0.19938328753041235, -0.16306652179168377, -0.08874969761064914},
    {-0.039316791645429276, 0.36424256592779564, -0.04016732954346559, 0.19840804568323434, 0.6796184170892888, 0.09203049988450322, -0.11264606666208032, -0.17233813352929103, 0.851842477102058, -0.2623563289153209, -0.11263686307771102, -0.10253961217538612, 0.17544667625031912, 0.17560447237229984, 0.027556438963459575, 0.2902028079827757, 0.025708089423793243, 0.3230021227202038, 0.6369849858259474, 0.4327357887918733, 0.2537560401971808, 0.3243734633774894, 0.8650890275177465, 0.3357661119598748, 0.5904646328602335, -0.11154956070886296, 0.6390247012470941, 0.47005077014940005, 0.5165598069637342, 0.19845276720904662, 0.17334974816307253, 0.33801941073322206, 0.5151828391220352, 0.20431474571273628, 0.40281212696068547, 0.08596790259975914, -0.11791997520097286, -0.6412736830596105, -0.09616722460824247, -0.06924130011075676, 0.04182032557440658, 0.050208874265303995, 0.17630022006595045, 0.19123277551316797, -0.006650940076589419, 0.2825320886819654, -0.19865927776304906, 0.38765888300604906, 0.18369694107973264, -0.2834315626292766, -0.25618190140345404, 0.0255231187714045, 0.13377131880863147, 0.23923009207539817, 0.16261840566319932, 0.3538687535375833, -0.015200432445727129, -0.2553296625997168, -0.4913717198278241, 0.015216661684568778, 0.3896270111064286, 0.08671563274702483, 0.24472041409874207, 0.3562034299367383},
    {-0.3752157638900653, -0.09931008553946613, -0.3368219226949636, -0.15616617353711995, 0.03610582223241359, 0.3768337572106303, 0.2129050922238046, 0.34970657243357633, -0.19425957107078454, 0.24873527055449812, -0.180857337415352, 0.2520598919256305, 0.22922505831193296, -0.2016983274951169, -0.07630716187650029, 0.10447626460187479, 0.33292110872914665, 0.04496820626810015, 0.6080261422762829, 0.1484681564212979, -0.028375132486478057, 0.25374509808021706, -0.07511122567205376, -0.46224343622920955, -0.0014082129161815345, -0.03375295633634299, 0.29665150430619597, -0.3448224438938804, -0.1346102233828574, -0.4462955449619009, 0.13026513361606717, 0.1534469766504691, -0.33939500757932844, -0.1846113051765663, 0.38747252886117833, 0.7538318269009043, 0.3101047313925981, -0.4010187478879682, -0.22649251141036303, 0.032297859667888514, 0.4213533834212546, 0.03281008752059487, -0.41644902601986666, -0.13258748343233026, 0.028855768447864725, 0.6441430850800646, 0.16004730212595614, -0.07826245882887889, 0.6629395381531819, -0.011153736016761161, -0.4644705479084767, -0.39526549320754745, 0.28578228069643463, 0.027478412549850704, -0.11300040489533167, 0.4950307442406813, 0.15546215666817986, -0.1835879467001168, -0.021219129212204976, -0.03842892432554586, -0.0968946563056886, 0.38871452969103376, 0.053854845968594564, -0.012432711049119626},
    {-0.24587412512976262, -0.0495334482031778, 0.27751458194237605, 0.1829191970517824, -0.09893880380714054, 0.245780711418109, -0.05398600519850675, 0.4143398558357078, -0.17521779530490464, 0.17216429496225719, -0.11470362279828705, 0.2586173513487158, -0.31930458844127224, -0.391477051898321, 0.2342596215812186, 0.6446727775471052, 0.4310601359841575, 0.09480282463269157, 0.38753684738498545, -0.5333255649189775, -0.31259531514353717, -0.7012315680635719, -0.018213313867445076, -0.2866189799647609, -0.11780444549970541, 0.14843687814434217, 0.46595573167718457, -0.3135615364616636, 0.21316792491180767, 0.11954579034392047, -0.039384834085829455, 0.27791673808359335, -0.533671127484538, 0.5365704205536849, -0.10851397780403442, -0.028132720927378497, -0.16396518243734126, 0.011772116559424093, -0.035495246130283764, -0.05362948219881893, -0.19815301254298218, 0.12435744793604643, 0.03030866356152223, -0.5650699365303282, 0.4101839738614612, 0.3767361292403773, -0.17560240005013325, -0.4805508653259716, -0.27105544297103784, 0.09350572480815077, 0.2134963025300843, -0.48528844048095987, -0.043598520340642016, 0.22778691389349903, -0.2801251621840459, 0.3169985858434659, -0.2049119789572296, 0.29158693337847014, -0.08637688766325047, -0.29909421019696286, 0.3427188919367315, -0.02010901322610805, 0.23326494349699484, 0.2018650742946402},
    {0.295875874309374, 0.15095924860726176, 0.10972516378812598, -0.45173745197312204, -0.050604997068896394, -0.4481004666140823, -0.186432052273277, -0.3401620368735922, 0.525260536226764, 0.28647015292714556, 0.3401431398197823, 0.057826025656408396, 0.7497985023999985, 0.4106690911278279, -0.047761451005169, -0.10844004795884285, -0.028270878663640243, -0.2049291431604117, 0.12467952768223145, -0.30968967720341345, 0.49569003033639136, -0.08100213701694457, 0.1181685189525455, 0.24442846583669423, -0.12791281336283364, 0.23037925218340832, 0.12414200901513436, 0.607245347682695, -0.2270526539284062, 0.11810855768596905, 0.21624665445375166, 0.13836686693809847, -0.26454562378078494, -0.1488420762733619, -0.009093145134277326, -0.9926684314198971, -0.48979889745437355, 0.5191527522579797, -0.1296010514349355, -0.7802759153283401, 0.04658992716841775, 0.004748572163465797, 0.44259376431114583, -0.2626527395000662, -0.30462160549186773, -0.17048634535757262, -0.32207694215417954, 0.20484112637467994, -0.47186837195723197, -0.20676858481111018, 0.2569872525193705, -0.47688052270128073, -0.4361901136447604, -0.05993604335698956, -0.0927410838622341, -0.3344487528486773, 0.14670163309937068, 0.05301830236165736, -0.07765435339787975, -0.17449342569043413, -0.21674719054288452, -0.43047468777567466, 0.037564088110519984, 0.02358910197703149},
    {0.09775974675067227, 0.40648856453207094, -0.31749713354427056, 0.04724224134222882, 0.25599902133721786, -0.04449710908265954, -0.14824470115757168, 0.1847815998562599, 0.0649398527381442, 0.05335606068017787, 0.2549776221532819, -0.06328583475203067, 0.07238035552747549, -0.03952720394555915, -0.5521620321434326, -0.34495495445155483, -0.024966367512769753, -0.003686688170377006, -0.1533824007025817, -0.3344445308532332, 0.2818561617044656, -0.6061028612748591, 0.14714528796651072, 0.37273507437626613, -0.026210581741153847, -0.43517714907138433, 0.03445734371562039, 0.048070482349527675, 0.2526775121975552, 0.12069169574343029, -0.10136018526302848, 0.1057220206513387, -0.19977990666005016, -0.19913224188760745, -0.16704416334065422, -0.32147361489822984, 0.014740263891347147, 0.0827223683940853, 0.021194680557802135, -0.6195006862472568, 0.20772157030980948, -0.1268004554760789, -0.15784375355709065, -0.15087363656815506, 0.004979204773569372, -0.38949809915230427, 0.4541328360934372, 0.22612657957726245, -0.3105733069450365, 0.19449980438231432, -0.11592831259008483, -0.5292293521950066, -0.5304513798636871, -0.6532708552014643, -0.12989608615473874, 0.06493841423633874, -0.3743275598412261, -0.07509280008865622, -0.05168108663546274, 0.20181884223775645, -0.3071213391964596, -0.5388166373096441, -0.13895248616774747, -0.09028856643611682},
    {0.4059822491584279, 0.25925505141366156, -0.14223699482361, 0.03830403053992348, 0.000978457140358725, -0.11217522849254448, -0.23144865826491126, -0.520609173866141, -0.12112996993763557, -0.15348110360498207, 0.10084151800787218, 0.24580851217532257, -0.5459816415774421, -0.052827002945272386, -0.057798291306916584, -0.3882209571234944, -0.28792132221843963, 0.08183637306793502, 0.2739996784481134, -0.01974063140806083, -0.5273172854025501, -0.01479956138171716, 0.3553971581405036, 0.3063356969463185, -0.09436082810117316, 0.6211120816385429, -0.12149669010192649, 0.22355600197461278, -0.013223214057279956, 0.39126969868322536, -0.04984595731287062, 0.24894825128572415, -0.035988987826292854, -0.009634352871883087, -0.06203511586272185, 0.2753161596895274, 0.12867424084435491, 0.05343355288704448, 0.3570565762374791, -0.13053072831688176, 0.24425510253589827, 0.3435474652546847, -0.0522523167746289, -0.22453236279579897, -0.041368100402134345, 0.11306107028555168, -0.17897752218246216, 0.45364877069839205, -0.053253127491684975, -0.14769234167272846, -0.12539031250588806, 0.02635525644791126, -0.6042560856630586, -0.22856904670462524, 0.28548751782709886, -0.4519951261318537, -0.20770180390802742, 0.41548435857262334, 0.16312790017556325, 0.23344090053703379, -0.14157700660400863, -0.18277549048583833, -0.3115444985606627, 0.11462142972967743},
    {-0.0949751987412703, -0.43795504226432475, 0.050860559528339455, -0.017221739993941856, 0.08555173284395626, 0.37526439534109685, 0.23800620378464393, -0.4754032008889409, -0.2793054796421204, -0.003463861595987409, -0.15403679335089218, 0.3671123988894459, 0.44755170366326413, -0.04420063181824034, 0.3914549343347648, 0.21394463938347338, -0.3683120170058645, -0.6483973574699115, 0.1761766420478119, -0.09927294650740294, -0.021239473838454946, -0.018340185366805064, 0.30843767993347176, -0.10130640904110275, -0.2020907095067919, 0.017516533678311758, -0.3914721057982785, -0.3182767959358576, 0.04551966469008041, -0.06650525066485705, 0.16343720234410627, -0.038061176482600906, 0.0021100077875526157, -0.4555310468309637, 0.19863050809182314, 0.22329014044793977, 0.07725107185899036, 0.32329357605728026, -0.035933169003847125, -0.19087900247494954, 0.2882109134842685, 0.06474407972418002, -0.005843544569564288, 0.6401534602266384, -0.24594362525731975, 0.1786797084908437, -0.030370628181008323, -0.03545027650704544, -0.06332927467460722, 0.13789132785964192, 0.34252310773354533, -0.06570973499500087, -0.10424255441374966, 0.3636461236489381, 0.040687671582987577, -0.08204241913819608, -0.5941355464906559, -0.07798801575840632, 0.38803859464450297, -0.10770954840742242, -0.043775610443157566, 0.0009941961653723067, 0.20012444386583433, -0.35935006444805884},
    {0.2553334271086716, -0.6077418159408283, 0.25145440553365883, 0.22694612855376176, 0.2960016654726741, 0.8635555065517738, -0.1373515837107501, 0.18475981793499327, -0.07515621130901598, 0.4615615815984894, -0.19618735062756112, 0.048812168410867635, 0.006498537522975335, -0.348033624533403, -0.17496036946681542, -0.2253165158720976, -0.014517514469228176, -0.35735286848175674, 0.0004685739804175859, 0.23252668993786704, 0.15083990479719844, 0.1734538956152214, 0.17304158887969506, -0.34493230972836786, 0.1970289413028788, -0.27888066538506034, -0.39914076715741464, -0.087652008978822, 0.062168591017513306, -0.0778361313723482, 0.20453689227716637, 0.17848719473723898, 0.15871719638755866, 0.019025085997292242, -0.20078007394287634, 0.24841255654358183, -0.01885307552553638, 0.2440148969312779, -0.2589675311750134, 0.5736893201554133, 0.04878112921388099, -0.32340566164215945, 0.19219187917098207, 0.23614589186201437, -0.41990190399557237, -0.1900418394259063, -0.11853407252051373, -0.4396733662402142, 0.5798240641262218, 0.15264238856575646, 0.0821522929081464, 0.44722409861234497, 0.12582613076587562, 0.1332432724465585, -0.13412652590751556, -0.08389975458163905, -0.17857734634579908, -0.24978060891849505, 0.019388829102934022, 0.12358986015998162, -0.24763682966222397, -0.14607774753984998, 0.28186292913437233, -1.0293054616834438},
    {-0.24666714965168476, -0.0004767976451860129, -0.33438204988090914, -0.09752668030354558, 0.1958291706537589, -0.017587803171496944, -0.2631703475548872, -0.01588463319489897, -0.6168529970038192, -0.011034757901017494, -0.2031771724508632, -0.32840474664277497, 0.23181397458961203, -0.1653670475524622, 0.028993780505671085, -0.21076401192118804, 0.09156323268429786, -0.018590697279394133, -0.05600104761970123, 0.08405229554494423, -0.055485069001914, 0.27324317810436316, 0.15200172259582595, 0.06021937808310104, 0.21340809768223123, 0.05513501912790067, -0.04813572314080713, -0.39477026049896974, 0.2683979805303791, -0.039919973513479826, -0.07409026544116823, 0.22051949274950883, 0.2855571802644213, 0.45594208306371925, 0.003165813683917951, 0.22979206328026316, -0.19187785554839198, -0.6672317923843661, -0.27260215541548377, 0.6696415534210488, -0.28873466128594427, -0.1535073667246795, 0.1939125964800252, 0.6853319008795484, -0.17449037651877217, -0.43663485789105483, 0.06933875425247776, -0.3501471839633531, 0.45037299874091885, -0.5107723575179254, -0.17824269886268043, 0.13950274688119046, -0.10772716962966095, -0.020279382748026688, -0.44960720327140635, -0.28802189166789494, 0.12085735871517077, -0.10250976028244407, -0.30965865474752335, 0.27402607045022853, -0.23823056054582725, -0.26642640930668887, -0.22013103490204783, -0.05926339131078688},
    {-0.4597551351750525, 0.16783329816376422, -0.13061782322474053, -0.3552775332203387, 0.25912473636167394, -0.2569044424416132, 0.2156003196995192, -0.6135568893732404, -0.23525722345927896, 0.5110585705154931, -0.0343794355979185, 0.47049939161850834, 0.3902794791024098, 0.02788233914149033, -0.40619343126162477, 0.05144640118783736, -0.08005831661841621, -0.28380207000571056, -0.148903764263711, 0.44918364250066206, 0.10522931462454327, -0.395158208801768, 0.050607937960569165, 0.026678620778584634, -0.2980894090020551, -0.1574852753927511, -0.33929484947305905, -0.4821740235942303, -0.3165553788815538, -0.471329797306161, -0.5846877932657577, -0.30905107649091546, -0.2506730024615818, -0.17454269027676422, 0.07914132892629362, -0.024286735387643737, 0.02374898421458794, 0.10423045438069611, 0.2569116753129738, -0.20971633868776274, -0.23757151402981647, 0.047093313572540756, -0.3911445287722147, 0.11685425105642905, 0.5998169457743932, -0.20832925305116642, -0.3943230685085911, -0.03552282503109513, 0.06317358830842142, 0.05483165640310683, 0.06959280085377056, 0.06230104106149795, 0.16773724335845103, -0.06504654625738183, 0.10932121267597873, 0.06350497352853346, 0.3014779178273891, -0.3021637555917302, -0.3760270502261434, -0.04884313890465325, -0.36851968072940705, -0.19843664219367918, 0.056358226084663544, -0.13719942300459279},
    {-0.42140643762303515, 0.012641344417136765, -0.16733774184849926, 0.48791275841307746, 0.11363842760386518, -0.0027112012333902853, -0.06672382995262015, -0.16899243630828995, -0.22606256662057478, 0.3182767899249759, 0.35006986305577104, -0.3014994603241698, -0.06795777599187568, -0.2741693672611153, -0.20505834736967748, -0.6087349769200707, 0.12053254691527328, -0.34307010037933405, -0.6191581019787133, 0.0687449928903312, 0.40537107630456826, -0.01830953022810375, -0.04531456689979052, -0.09083956587785624, -0.4184802200594004, 0.16008681304610514, 0.03062379216765559, -0.45310765465580183, -0.23334931507664888, -0.0354517838952475, -0.5006069119115202, -0.3988741898751012, -0.18067651919470257, -0.5220228771326607, 0.44802698528292834, 0.009669025287115588, -0.07538923274108045, 0.19623014267548725, -0.17160636159080336, -0.22368765533412147, -0.34696703186307265, -0.20369565118021732, -0.226675888540801, -0.35304945406992266, -0.48845877468891813, -0.22976961347180472, 0.17766341867871516, -0.7542171878271423, -0.2494103935001476, -0.038969564465694245, -0.060883816684638124, 0.09106722910186235, 0.26131143679086866, -0.11472943776330308, -0.16390867845961604, 0.013138075971322162, 0.08626895391330978, -0.1279673636380297, 0.48842580294922766, -0.06063106244282731, -0.19351299940552968, 0.24509944408895654, -0.003615841050848526, 0.2625449354569293},
    {-0.14602749022266182, 0.3354977699346143, 0.1435811856429702, -0.09968977781600961, 0.08776058789433985, -0.15139472840624366, -0.020452405674424183, -0.3641896832736251, -0.12153422066482379, 0.13785717884166368, -0.016802570411419224, -0.5733353212996994, 0.28292138411556783, 0.18945547678606184, -0.01472605263822324, 0.008750762507721933, 0.160214903771117, 0.40107435742979736, 0.050056226192780676, -0.49032176700839464, -0.3749500059863461, 0.017039569040334202, -0.18718959788229145, -0.023831678589956284, -0.2196288325180708, 0.03660545812947159, 0.29337957936108733, -0.1329549859873426, -0.04064955128308948, 0.0949222603528912, -0.09991352072578823, 0.047157323271300414, 0.04242677001991089, 0.1949947126030669, 0.2880776643449624, 0.06055120918929527, -0.046330361599623414, 0.06164547190293511, 0.07711419122080927, -0.01349605834725131, 0.33682931548101325, -0.3111287957296925, -0.018546136493245633, 0.08885571186050889, -0.15665212684846097, -0.4715918067782232, 0.19620434861608388, -0.11856347887564955, 0.09467086169693542, 0.22544736397571574, -0.5556769478047001, 0.012167060783745891, 0.22378613522430083, 0.3903679370268834, -0.6192936153690982, 0.11480967623997958, -0.026866873354549785, -0.14932999793278645, 0.1528894399755467, 0.12428526348784488, 0.018422306771735973, 0.08796319054304007, 0.0719450579020547, 0.2582152383641391},
    {0.38093468676675196, -0.19144937392384215, -0.05495771970328671, -0.7539023390089108, -0.16050685344757792, -0.09461553387335792, 0.2409049608525254, -0.40395110976411003, 0.17356879071319084, -0.15675362208952778, -0.5019616092370129, 0.0328992256352291, -0.051935094090541506, -0.42571519881115927, -0.4048127239994684, 0.05761325588360093, -0.19391526841270038, -0.18147921109409532, -0.19585401388376517, -0.24208233769592297, 0.08773281065322432, 0.004036929156154181, -0.12878659704389034, -0.1014609082124636, -0.3120424309313968, -0.15310324107964704, -0.16867034279866508, 0.021639556841771025, -0.0822102329686169, -0.023114425515537464, 0.17021433486468793, 0.1725270681605767, -0.03989652899295546, 0.13893318266561155, 0.19475676457582278, -0.17479330498979495, -0.3012585470309929, 0.1996160646105105, -0.2502905706019812, 0.12886637380613578, 0.19591145131095147, -0.2806023204759671, -0.12473348366147408, 0.5435746071718403, 0.3206622672435345, -0.1135268389052043, 0.07331339872515806, -0.1318326811537999, -0.02943628307904184, 0.1915494299986014, -0.0600766520526741, 0.29379001018557455, -0.02554843179557662, -0.2245313115944609, -0.34714097038684305, -0.21780888889515201, -0.16168392836767664, -0.10386310934006474, -0.39217023818420943, -0.10793692455164784, -0.23492317790536196, -0.01366295924662821, -0.40586320954147226, -0.022172510405347092},
    {-0.18633159603991703, -0.33521288841252145, 0.21357556638513556, -0.3475281430354116, 0.26795255681458197, -0.06933278854651248, 0.10636122696499206, 0.4036857332907207, 0.42413577721667606, -0.1404950858076444, 0.4277594722884344, 0.00018098571953194335, -0.17909898913569722, 0.4127238148769512, -0.10409911245680793, 0.31304893961377506, 0.0964591127237314, 0.31155458223078886, 0.24116206283018307, -0.4038867935699851, -0.17802468749580386, -0.6525094345908509, -0.0350704447557795, 0.19943513491219525, -0.22972732419673483, -0.15396579881264116, 0.688463656737603, 0.21244181390959507, 0.16321988556886624, 0.21410627872555202, 0.038106704026049265, 0.05842581470020705, -0.2620460035110761, 0.13338128179723813, -0.2167187391377151, -0.03822835133714317, -0.20508292230536063, -0.4818998443486314, -0.14721864700588605, 0.35451734730759843, -0.18790670198754125, 0.12186827808738374, -0.3178779848555353, -0.20264678753731397, 0.07517580848136594, 0.5113856015721383, -0.5752594564026161, 0.1527042578197408, -0.2618531948104873, 0.3097106536553373, -0.42441468341552624, -0.4262540217324934, 0.22796930375909288, 0.2021000651622397, 0.23523499567096479, 0.15447362534442527, -0.07741891587305523, 0.15622002435625057, 0.20786225401821576, -0.08639159159908658, -0.19303358525572362, 0.3574370169728942, 0.3973190241339285, -0.2842206215264876},
    {0.4612359095623204, -0.25234711496376644, 0.18256561595565954, -0.5939325557257491, -0.25077886444109204, 0.4448468332257528, -0.011420254858681629, -0.7041980200206831, -0.12916548915511572, -0.059874460744304935, 0.34140962970741345, 0.10268912112060345, 0.2954670150783973, -0.5565476194467145, -0.18612010398013912, -0.5918859666049912, 0.6086711640287442, 0.3335553486440419, 0.7675642246985194, -0.3478524250567635, 0.43963593490901604, -0.49585577819578625, -0.6071806369405157, 0.5797656308095244, -0.2676327296936552, -0.5393393456317775, -0.5165685719755808, -0.773650953078925, -0.4124173273448945, 0.5194164588742353, -0.30220691627264096, -0.4420026128399039, -0.9381417694910404, -0.07485440764813829, -0.32098621399351734, -0.10530939763010284, -0.9916448451318488, -0.05956812115625056, 0.06676625711833034, -0.28404430338684067, -0.8133763445311143, 0.7845467438553054, -0.5252397238484185, -0.3953590104463661, 0.09202787449115644, 0.2020068269518046, -0.6762941219898224, -0.42189411224971146, -0.4753863376846468, -0.5885146523070887, 0.5171274961877511, 0.010023681385514195, 0.6786995019721466, 0.10328336416610823, 0.2700316305492678, 0.2245505052781153, 0.6554115090848887, -0.9382157255313445, -0.16859559407047572, 0.686139176136397, 0.2784501511573494, 0.5690989091972857, -0.013800084446794104, 0.008154609863859873},
    {0.05594231865131789, 0.5932280439206066, 0.6654564533116449, -0.822639091850872, -0.549378029877608, 0.8007895341161236, -0.026527096789319016, -0.648381462818173, -0.31840903316000996, -0.009626111929306262, 0.3178834818164696, -0.05858264470984193, -0.14351543540227107, -0.12523701585000768, -0.25168390599982715, -0.5193825010419972, 0.31115447717243006, -0.18048527264370845, 0.33829001804368125, -0.19886118572703618, 0.5100090751171993, -0.5281341742150215, -0.6071195327970318, 0.6877028295572963, -0.3815667049871891, -0.3358271804823382, -0.44632788944107576, -0.9127466454106208, -0.35731047069041433, 0.37995134434570205, -0.46633245420107616, 0.08818819265952815, -0.7152875765700294, -1.0482261158378372, -0.10695622814143287, -0.3436581399820798, -0.6082002730533497, -0.11922400642147578, -0.25841008732902954, -0.3430644031391322, -0.19399086897583356, 0.5995198870440293, -0.5503090462818366, -0.30888435759759075, 0.11645440036494072, 0.16269298983219357, -0.5247598947743126, -0.3687078253141658, -0.6983635134583063, -0.7507777701815984, 0.4396413698577982, -0.14001571393038093, 0.261332606673712, -0.26042113722665716, 0.21568206345085597, 0.48322866477124876, 0.5202760816270783, -0.9312792318260786, 0.08058510148266562, 0.7649567132932779, 0.012041992631484564, 0.5602873403595309, -0.34233043061120483, -0.12689851162841767},
    {0.23100797129223366, -0.29732270464554056, -0.42585153070128456, -0.45946992648022683, -0.6562942840989698, 0.45505231833642273, 0.16862414877173762, -0.6891341328116799, -0.42754134935050087, 0.1158320745938311, 0.40461660921850223, -0.08260980095046078, -0.40203091544032604, -0.409208732532297, -0.028917708717834115, -0.590547896748146, 0.24791845317427938, -0.4341837066852431, 0.0579758886329618, -0.5274356044561119, 0.4724096897810185, -0.3338540009028978, -0.13193071675235865, 0.07209937825121857, -0.190204298828786, -0.8971909872435616, -0.6949529471404812, -0.45643929653550486, -0.8350744967354479, 0.0573697447377715, -0.46773365940278816, 0.12481599416836486, -0.30119728250678124, -0.3371568172502051, -0.6201275974665271, 0.4871204140728095, -1.018083547403507, 0.5962226743930937, -0.6482242875221602, -0.32763578605346666, -0.49476062112863783, 0.08963528630593108, -0.32900025004598615, -0.414703010619775, -0.08150259404467236, 0.385369993160571, -0.6978471980330578, -0.9454114568371634, -0.6844071273186941, 0.267162524449232, 0.551033407276255, 0.07190551144404395, 0.17902951769827785, -0.7682475467409656, -0.1688881279701184, 0.15200112362985257, 0.506423067627086, -0.9620764402056213, -0.25896275784441536, 0.29537405668664657, 0.18259425729169848, 0.1632733195350456, -0.33636367798758965, -0.11061374487260563},
    {0.22552677912253555, -0.16684480965104526, -0.3764103340366662, -0.36065250754004363, -0.0918940434862611, 0.2637408498514512, 0.26352078955315283, -0.6648392038960846, -0.49229052325926714, -0.042247329234340124, 0.5399759427126185, -0.5276749944075871, -0.025058387535864278, -0.5468808833011787, -0.603372395299455, -0.4969761943426549, 0.6170629119034395, -0.40938963168956394, 0.08826905874035877, -0.2541164577831157, 0.3278227794762059, -0.7003907230684918, -0.48910047210717156, 0.6718187040421377, -0.3655958859919456, -0.019237958784982058, -0.3857336645133162, -0.33891920398695163, -0.31293292789251387, 0.192884076428719, -0.5310705225414132, 0.0328555970331551, -0.47706310977780714, -0.6087518720880224, -0.04678208855235019, 0.0840140875919979, -0.3878399299874825, 0.4776352817467514, 0.08582290452256044, 0.00016482731641549421, -0.40988580606990177, 0.18515548713779367, 0.11527798803637097, -0.5751838727351756, 0.21869261524165343, -0.2924588368475233, -0.23552659568635465, -0.9091095122955796, -0.41477334387305076, -0.32684666338125445, 0.195702535400341, 0.08339487548065534, 0.469611749075883, 0.14736779352403895, 0.1906941630742989, 0.4018907569924417, 0.49400856042403085, -0.02124342247008903, 0.38971002699518237, 0.35310718342427916, 0.052272135783559166, 0.6225570182408614, 0.6790599881974724, -0.2734256849518786},
    {0.5237392104326257, 0.23951108933614534, 0.02126194065549279, 0.3738256192732954, -0.30138904399106664, 0.5965388079639222, -0.10589032611830394, -0.742606337627707, -0.5348644314633151, 0.3788171024278565, 0.7676903428978021, -0.11991159438914685, -0.11320144241602242, -0.31626136322142107, -0.3759336642720203, -0.04833301666105671, 0.6553106518299068, 0.06072549154149938, 0.37244809141053364, 0.18864126793694555, 0.1970226283498443, -0.12483748950316782, -0.762212365810277, 0.2259878102388279, 0.08562888505957092, -0.04549147681983099, -0.524995463120122, -0.2476619011432081, 0.038956620689209756, 0.612632059348861, -0.6847616550956415, 0.24861124181089078, -0.498840886221747, -0.13289200413670427, 0.35741149698536, -0.32163743165775294, -0.6460909422997232, 0.7009151847632302, 0.47527859713781234, -0.6780790959799698, -0.3737776284216262, 0.5997254635844441, -0.09846194881858403, 0.39890361854660517, 0.0931658123989846, -0.2525002090308259, -0.36399448656129496, -0.4347855657434593, -0.5025381208062848, -0.07694617058641962, 0.18747830496908904, 0.025758925022051505, 0.26937717782402365, -0.3477985327999309, -0.10728871180014742, -0.12989655656310106, 0.6254805883673767, 0.2970424879564062, 0.27567044357420073, 0.544386435543312, -0.16148977845401358, 0.00951442539540726, 0.514095440370738, 0.2504879977096054},
    {-0.20123035870499228, 0.061419894434115475, -0.3099239499555956, -0.6726124191714496, 0.07067150196244851, 0.32994553661149617, 0.559905107402893, -0.6124555609099976, -0.29056051309294645, 0.2671525931586992, 0.5872085990523352, -0.6787141142080831, 0.06410606268645158, -0.9509671099575485, -0.604935113541996, 0.342630111133185, 0.17795014761728026, -0.5699565036490997, 0.5778012203772737, 0.38133548112004967, 0.5758252928698907, -0.3423439323761382, -0.2167340303641828, 0.45205350780413034, -0.5550884992521521, 0.08585107670249359, -0.5710287916523071, -0.3574407498146578, -0.12153801680730546, 0.49438426829871424, -0.3403712017562209, -0.10650760328746155, -0.6521028719943375, 0.23505799280118295, 0.07245478240304029, -0.3862348453859353, -0.697918523678099, 0.5412086958644502, -0.12145935396288972, -0.5198802472660179, -0.2538265205179267, 0.4243273914605575, -0.6435376177512543, -0.11413200760758202, -0.07324973079014943, 0.2784936879974181, -0.8255574986033168, -0.3674643372213339, -0.5655209009913267, 0.18660681696832376, 0.2912940263222387, 0.34705148731893015, 0.4068428657655973, -0.29755730814831644, -0.35056325179094205, -0.07299880092649863, 0.23510221706578832, 0.03311862306812662, -0.6959895946136144, 0.4318275646518325, -0.3957386878869348, 0.306895688630381, -0.16312719010348595, -0.1739184033020472},
    {0.12227384342976831, 0.02574294361200299, 0.133724198934244, -0.4230819805936264, -0.7828128440065659, 0.6686507594785484, -0.12968351063729153, 0.022962423453478632, -0.3660346097078991, 0.3615393937867397, 0.23546485792811575, -0.5406659221421606, -0.5701102555327499, -0.3533576360570615, 0.2748236985890999, 0.3396823318957859, 0.16595193631348953, -0.10156881936561361, -0.21228508020515505, -0.371173892653474, 0.5674213775086829, -0.5826356047171132, -0.6142789287141139, 0.6816108085302554, -0.1151485395249651, -0.2390387489324804, -0.033154906553277574, -0.04690867373481439, -0.19100317580065662, 0.37511814470879634, 0.06600234503922478, 0.5468682457235015, -0.17026694249926363, -0.19036999861309553, 0.1427695530861528, 0.5573860989980067, -0.004930300832829385, 0.28963631110901367, -0.055578592544243445, -0.035321385747073525, -0.09822654302703657, 0.23920762298117815, -0.5034535741450504, -0.16067190740335058, -0.08743726213477085, 0.3292002545088976, -0.5687689622159073, -0.13599776637246214, -0.36900163293094207, -0.040324465963896244, 0.10203824355719533, 0.008831691324557413, 0.12822811798196238, 0.2541083132003426, 0.18102915360360156, 0.17264651472407905, 0.35430717773787446, 0.4382906739553776, 0.17329324507552846, 0.1883065334543801, 0.38049014851239227, 0.39235987990070115, 0.40787537475766533, 0.005019120228766468},
    {0.08725362814378008, -0.1922566596015446, -0.12339530851615925, -0.46183802881786845, 0.27423194465798345, 0.3543149695161397, 0.23005601383267113, -0.24205065716197077, -0.22320462804770458, 0.5801763666290206, 0.6994098598829703, 0.15002493337455905, 0.4721139280689669, 0.11286713284807248, -0.32008674446410085, 0.07703131608425258, 0.09928695646474221, 0.20539416122356313, -0.2160778329548947, 0.25478486653722915, -0.08515998684751815, -0.38756320632828933, -0.24194827114396483, -0.49049809394085914, -0.08671096344404143, -0.2751765202292418, 0.3322117611302756, -0.2533510033203064, 0.3069598748830128, 0.32576726436379927, -0.0021713655523688488, 0.14635338988795843, 0.11191144622710689, -0.20357338233875344, 0.128196620505589, -0.6429577031524114, 0.13703768490082652, -0.060047349043126474, -0.4000838206538406, 0.13667280365775816, 0.05133254804868277, 0.3862067644749628, 0.1684762327910263, 0.12045747923921282, 0.120317345984887, 0.5311238320263111, 0.1601011343633131, -0.31462447100614727, -0.024597626198449966, -0.18666380718943346, 0.38360602752402284, 0.5656809409345276, 0.479358076259265, -0.3167634481145327, -0.017716916969532388, 0.46290696603897086, 0.3511239482976293, 0.008222083217649724, 0.37111708599338006, 0.48402255851150955, 0.1226515361662074, 0.25291216834172225, 0.341224674890916, 0.20592655710012847},
    {-0.30395993948305366, 0.08242691319519223, 0.1948654926803703, -0.6452133802443814, -0.2375826571635004, 0.43623918442309034, 0.2017777524176846, 0.08766348226093461, 0.19463303875885463, 0.028455926877825582, 0.20983492656126015, 0.30644106187773734, 0.4105161116632714, 0.063502166210935, 0.09205004566591132, -0.6281733620829401, 0.12488527120280223, 0.18149188159695992, 0.18266837883877596, 0.23217382304274764, 0.8125837888891041, -0.3559578458247256, -0.14992976671687086, 0.23758758865711846, 0.1857099521394541, -0.37195476947271133, -0.05148967557782671, 0.04611981124509989, -0.408738496219613, 0.3996808301922353, -0.028585718133523997, -0.030559885450722156, -0.12702143967474272, -0.26645391334176705, 0.29240562401338016, 0.006431989187491515, -0.4807968515810919, -0.08081826603416302, -0.1317851785329619, -0.08537486731035575, -0.09682553969212049, 0.3446258978408761, -0.08627292892584516, -0.1334378037247571, -0.22487479154618906, 0.5938073494169899, 0.060314497346489505, -0.3646848246964385, -0.3836721018444767, -0.06759108315864518, 0.7081309449795711, -0.10422279044549224, -0.4507821669411424, 0.05152347806574552, -0.10872926903276088, 0.05741477108571001, 0.1591661500569029, -0.3342902421409282, 0.20705690662222653, 0.2598562932184673, 0.08647861415986384, 0.36814067236809395, -0.02659317762921495, -0.09222861098777346},
    {-0.16459406233403082, 0.2529444642449808, 0.3736795564745363, -1.0110123464285337, -0.1846930181223851, 0.3903758364746306, 0.158506294837771, -0.41776695885574466, -0.0018427276496196954, 0.39043439807806735, 0.03977669042754787, -0.28426459198965065, -0.47228709461071894, -0.1505336693619874, 0.09109921817633097, -0.3659984485242126, -0.4029688055027742, -0.1907850419209045, 0.07329713122906228, 0.13960859420380733, 0.46817810009566113, -0.7692874410913014, 0.5145264515489583, -0.04673659985290088, -0.22994087770968125, -0.4160296453301014, -0.28973502305760074, -0.08322022651020325, -0.190403715497127, 0.45846667053849444, -0.32637780817464834, -0.07142269531014148, -0.39847067715896406, -0.21634501424158706, -0.2962373905221438, -0.3165567931427948, -0.30986055997787326, -0.3970988129861766, -0.762535392321522, -0.016119122604523358, -0.21093236034202534, -0.4588848179971444, -0.08720711002535247, -0.38220031262985166, -0.09528889342065981, 0.3618961490314262, -0.23410140639664542, 0.43429613676922196, -0.16978352853235562, 0.41270505313780553, 0.20447088129459642, 0.41102952945530596, 0.08543277885813731, 0.15682183580587086, 0.08409871271777361, 0.3120736815346926, -0.22532358694586713, -0.5991713851693802, -0.17534406056207405, -0.14837115747102492, -0.034565774093876754, -0.33379483307712493, -0.457234218373656, -0.33466164041799495},
    {-0.15786936389249234, -0.16517455771172868, 0.39667290919017884, -0.2798576791106055, -0.19509888045515503, 0.12370698952446703, 0.26112271461311787, 0.06969374449405163, 0.2746247986342506, 0.12244220024787679, 0.37717300596933073, -0.4498719273873176, 0.3171402702252599, 0.16986360189780758, -0.21447395077257303, -0.43185554888125405, -0.3057486743508376, 0.12589453023641525, 0.02153629497709285, -0.05126206090315171, 0.3550273721281893, 0.3490686233668216, -0.1626334777856542, 0.30983879158410826, 0.14738481019904512, -0.2573572318719264, -0.5011491580298785, -0.12325967083561895, -0.6005306030402697, -0.45838170834856473, 0.06251433769948923, 0.2819606354293086, -0.21873048595865865, 0.0800212729640435, 0.07059524609714476, 0.1584924058717927, -0.4794903260505893, 0.06729030387937796, 0.036251116072698826, 0.07653429068098061, -0.5923256659025119, -0.04625858526555016, 0.3621798829608696, -0.6514924115120475, 0.15325551238664367, 0.16460803873761679, -0.05121459573663868, 0.10157264032708524, -0.12681881015672544, 0.24425533847776734, 0.8020731054279745, -0.5754859971479813, 0.32365764441967526, -0.50377349594348, -0.3183201147193209, 0.036520869538375904, 0.10638974463593448, -0.030762211775693032, -0.3388350655445759, 0.16170215520053535, 0.16959826858951652, 0.0862706179832354, -0.1987643777529187, 0.6427421844408339},
    {0.29043333392505816, 0.31989903024244676, -0.6822150357323415, -0.08758621492579369, -0.5256383918293718, 0.21253862165528237, 0.37173277056102055, -0.23977825549826576, 0.2999170525492621, 0.252430782235304, -0.34853389750079605, 0.22651353026356327, 0.26413454927884794, -0.44418856904746373, -0.40809385917829516, -0.1560256622908929, -0.1971341582575002, -0.07022547993282638, -0.3330491380226455, -0.14557304943383315, 0.7223105569807307, -0.4338366007839192, -0.04579044017160243, 0.007037286361768378, -0.26746477345391806, 0.1769599048310799, 0.3134731767118171, 0.11956605939235802, -0.295143068144103, 0.22335135002896278, -0.16762337392894636, 0.01553974698067909, -0.2776533565028794, -0.44907176351335204, 0.2494002636352887, -0.5108826721040639, 0.2133598912084573, 0.20567310949665318, 0.502031426868517, -0.14963519915896106, -0.21088388591097482, 0.3525882760850986, 0.019213902962677075, -0.01663973612917403, -0.06829960791589394, 0.22700321578644506, 0.22371261327094125, 0.12586138083699078, -0.7645670983950269, 0.06870454506553293, 0.1866138695915475, 0.16397599340855573, 0.34911869927310824, 0.1558165251078709, 0.4026526344182872, 0.1346565226869153, 0.05537685294937717, -0.19963684136457516, -0.008436069517946385, 0.037190527218506804, 0.14983603022069636, 0.05625710078507634, -0.0489212141943712, 0.1989300619160592},
    {0.0794581891715911, 0.48696462243048666, 0.25154069486954, -0.48870840497451795, 0.26326874908683856, 0.42758684278286885, 0.335988061084606, 0.28238397072453986, 0.07257565252868386, 0.052887805223105225, 0.47872703869007843, 0.36314509498853986, 0.22318333786266545, -0.08557289196045767, 0.44932734351571363, -0.12239700651955539, 0.0629736737381562, -0.14967965324053947, -0.019691325803641697, -0.2597115212012479, -0.12644261986459668, -0.101498495756008, -0.04096982737914368, -0.05980599655544734, -0.04060230555022671, -0.4683559654614535, 0.4277245276048418, -0.3390342677512402, -0.10952012614413549, 0.1427483514728187, 0.34622155885043887, 0.20735397230423996, 0.13571654046017034, 0.034278376862203135, 0.2921336515234363, -0.0702226425305425, -0.12662768124200718, -0.0955713908198296, 0.30003528779314553, -0.018461461879439003, 0.1650453492216174, 0.1603633693962247, -0.17504901752764015, 0.057862430898141574, -0.08813972709944791, -0.12985662271770185, 0.06195259997672277, 0.5794622628423087, 0.1618743564645469, -0.7051304001106239, 0.01420388520602728, 0.08018865599297484, 0.4200479748605776, -0.05981580023204164, 0.2788021065117166, -0.1067006404184397, 0.825278494909811, 0.05091547259236082, -0.2417566585155912, 0.15552724242763757, -0.032708987899080964, 0.2881309371678897, 0.2592242539470782, 0.6533970082357884},
    {-0.3097756782170357, 0.04256672327951878, 0.2636644426090301, 0.1975861047695821, -0.4909695112258518, 0.23346260652341666, -0.6526126339889223, 0.549975062971486, -0.27002682102117426, -0.3492114780038501, -0.016299041082566416, -0.08521478857674483, -0.5399499928283841, 0.1969999245384038, 0.11151324856719179, -0.3643071660250692, -0.24306581262224014, -0.19759240980975123, -0.3111219043773266, 0.18750160990845693, -0.3437463588763268, 0.3242691695873616, 0.057786657600356686, -0.5154811341684172, -0.033719702036996625, 0.07315033530301669, 0.6089903417043392, -0.6067580655559189, -0.78475619077158, 0.37829116824013115, -0.3706441317376679, 0.2967663880491833, -0.6538068105613708, -0.4157035087789453, 0.13643524457982562, 0.40131727368818854, -0.1652229849910237, 0.08916294728398762, -0.1981281704121575, -0.262468712822664, 0.1000952277236694, -0.15613768854382257, -0.35460672583188535, 0.28304130669999744, -0.09559608938757543, -0.1498341608079657, -0.6415469058832604, 0.13540448490023463, 0.33105450192783964, -0.032684246759420624, 0.0009584894830121288, 0.014848600655576935, 0.032144411016253, 0.004738533425433711, -0.11711355343618526, 0.2983030853251667, -0.7512250905321524, 0.2048582256369988, 0.30485697840228676, 0.1692492593516089, -0.03718799130382366, 0.5447758816666255, -0.5362134558360612, 0.08506610857673515},
    {-0.04923675097664587, -0.14117809222711775, 0.23183672730524554, 0.4058384110818971, 0.3028519897511484, 0.40453083560088454, -0.4836936210572973, -0.18646621966965668, 0.5086999785383585, -0.09714660867237246, -0.12231556155641922, -0.33390386019569845, 0.2256481695424323, 0.03839260796137503, 0.03081367309483344, -0.2504898570778233, 0.09556549125300726, 0.09917584631707058, -0.3000732877264316, 0.16333734771687894, 0.2664967595923273, 0.08568580836947745, 0.19012614085509383, -0.4253059455051246, 0.23010972554935177, -0.05877046055087838, 0.20101919241153218, -0.005844336253711622, 0.4819140454564336, -0.9667299021477674, 0.12789112421421442, 0.1481738798847481, -0.047423944561273315, 0.15032775216514505, 0.14898128883076, 0.17733116248903585, -0.38457368385664115, 0.20955899826135144, -0.35044400850284757, -0.1843662692390764, -0.1627669016329591, -0.5712205958343729, 0.28593630479918464, 0.27100744347098926, -0.22281402644851414, -0.2909792062524313, -0.1070343489212767, -0.03623149706970173, 0.3265542747582604, -0.22782414713186383, 0.15184328245491624, 0.2993437734852511, 0.2812419586802412, 0.01987703864597211, -0.3024958056481537, 0.0804371185765513, 0.8324355450029268, -0.3931569667857814, 0.2503695112889007, -0.27983898226804094, 0.20129810918578092, 0.2362304868161682, -0.4506872686527044, 0.5083494250424029},
    {0.4665073202555376, 0.3773974349248957, 0.6424888070735056, -0.4578076626559218, 0.4190848122798561, 0.11986306522416866, 0.4268198486047216, -0.699138510882387, 0.16479398222637076, -0.4166914079651051, -0.026103985113068377, -0.03832116019296732, 0.28738717896703675, 0.0832320903926997, -0.17749834190429198, -0.20024177856408795, -0.2693296299248137, 0.384790718954359, 0.31513593818344415, 0.02484608900309816, 0.44258867271249813, -0.04189186050432462, 0.5554540271190697, -0.127528067394864, 0.1694689054051152, -0.21669300984077436, 0.2255789049826959, -0.24403867222308956, 0.025262012429895304, 0.23109345545896584, 0.16189318421597396, 0.04117867226983644, -0.24648606724284758, 0.26903561881990135, -0.03234997205019764, 0.0025703499897468075, -0.003891998020672911, 0.16682219972711537, -0.11393409865230142, 0.4093858695463782, 0.2004799856538655, 0.1199604140596454, -0.08421730747900619, 0.1343773578273051, 0.06377821716044207, 0.27914678251747616, -0.0218759754750988, 0.3194094844870429, 0.018499997469620742, 0.15660391287609404, 0.4420265636588205, -0.09373255364699042, 0.2624297341257831, -0.31476050881131157, 0.1576488666924167, 0.45208045453943063, 0.25218830808395903, -0.2300617517656359, -0.044822679891500294, 0.05897113438304599, 0.06588383476238663, 0.2518761332045699, -0.36310183981478705, 0.3734820765490385},
    {-0.40991690857303437, -0.17971236891019815, 0.0003065811165081795, 0.5447773712383511, 0.019988325030679464, -0.2981948691649136, 0.12477725909346711, -0.14858700941529168, 0.0036330470403411206, -0.38576831409170664, -0.22572329405784533, -0.617593212316721, 0.3205265913977519, -0.05581453244409231, -0.2074416308957463, -0.35099062783362583, 0.13429051551122767, -0.40964124401191276, 0.10096678665840594, 0.10153057443792127, -0.43245069203201936, -0.07918154260684857, -0.26196505580130536, -0.005893048270892144, -0.2627280588434517, 0.27425442848329523, -0.31782302574726934, -0.8788111859866816, 0.0991710179477112, 0.17466159788535077, -0.3449840979253056, 0.3397179701692105, -0.5444672930798212, 0.10682089013885579, -0.18630148939566696, 0.401621730723273, -0.3878836377398305, -0.26013049797349713, -0.10065083645288965, -0.2163869342906493, -0.36103170520005334, -0.2641559531060605, -0.13650082483494258, 0.1522403610186041, -0.10834103376757415, 0.079196873936034, -0.5456720100030925, -0.06371072006500392, -0.1877173524176703, -0.49454523066430395, -0.09505547215002742, 0.014702390079582853, 0.0457499025980862, 0.4043684211839477, 0.28171972764999376, 0.4066723317081753, 0.26133250396843477, -0.34613314697130565, -0.40118374170205534, -0.18641773920565985, -0.13317045828617852, -0.2186982118834408, 0.5242562188581844, -0.018064377240138235},
    {0.008047167448824335, 0.4665992891037833, -0.15872971552344786, 0.08799940360556509, 0.002133895034777856, 0.2114679901873485, -0.23008095575592785, -0.6079432694724662, -0.038147596275647434, 0.06982751009475761, 0.04586183773800812, 0.4133966907053728, -8.451322921651764e-05, -0.25711978770816313, -0.24394206775267493, -0.6692895375089427, -0.0982967384639451, -0.39447702812299734, -0.39124287250649425, -0.011397208726945786, 0.6413532418466796, -0.41555071109723224, 0.1849402828299039, 0.8037206213730756, -0.02721415318100991, -0.8329292013187265, -0.7355971142757617, -0.4209665559429428, -0.43998745522533156, -0.23121009723871133, -0.7486420996947607, -0.07765265340745138, -0.7111768997553979, -0.037957232806932, 0.24552076461067815, -0.7174748010449082, -0.14534489228013997, -0.4996886546095822, -0.28180794738390974, -0.7643349105321912, -0.6655199037069542, 0.06848012621555036, 0.5012486603870944, -0.09033689959830271, 0.24567078476555715, -0.1813219605375255, 0.1183263923230385, -0.47501369306112756, -0.31379888537549955, 0.30572838423824034, 0.08932996373898694, 0.4477010173305064, 0.2685385761379692, -0.18367634768883762, -0.21111004233815936, 0.06476950488013382, 0.343795834910635, -0.36008356286115856, 0.056523144336496106, -0.5723312892677533, -0.1754179536168256, 0.05981159085445685, 0.4451780546895509, 0.019672939755053725},
    {0.12433997677589902, -0.4718527687904339, 0.12408542934699622, -0.09074306946893865, -0.47754798566184803, 0.6225767242765847, 0.3652880999958287, 0.07364885780246405, -0.4254974246391684, 0.3328938499229731, 0.6763335584121464, -0.2633942775443614, 0.42400572615740745, -0.4182157059660411, -0.4203988571641171, -0.04895390280641664, 0.5761642325397796, 0.24336409018532185, -0.16542110379031114, 0.11730292803130357, 0.2482096629118564, 0.03567375873786442, 0.5396053747293731, -0.14187868291500788, 0.4054401233353871, -0.12645391879293832, 0.4515594313489052, -0.2921927618618974, -0.28852749572769854, 0.10343078668237637, -0.09229250949791447, -0.07983195637147945, -0.0943433832605303, -0.17780785585921288, 0.5687053132499619, 0.17406466696310247, 0.187255353753723, -0.5334297549222641, 0.31341888112749466, 0.6344849294753292, -0.0442305608391818, -0.11758389505546396, -0.0869424353378491, 0.0572048940334867, -0.6145430618568947, -0.05151218261688843, 0.13081767319335758, -0.39133483934793045, 0.03590306725279247, 0.37404476936145103, -0.18283799514102458, -0.5527651819750032, 0.11413930852268858, 0.15702193223765418, -0.37752599585990865, -0.2598821168939609, 0.7178454184801512, 0.20004203744076435, -0.15843336143460554, -0.09725369047447016, 0.45050910769307556, 0.27942880463278574, -0.02365717725567683, 0.5902676370423543},
    {0.5343069613113292, -0.5375353929901847, 0.4002694990417433, 0.5501662680319879, -0.05265450519092055, 0.23030261349024098, -0.2557035595139247, -0.19830157335007037, -0.14136007950032295, 0.435817742384522, -0.0244518432421509, -0.07655179592800722, -0.13256187264239294, -0.8473686980395396, 0.0799704163802217, -0.02461245139666548, 0.024523552667289093, -0.4859616912133706, 0.2307040995294749, 0.47439416706503446, 0.12176413285270433, -0.00037460496456650556, 0.466871807928219, -0.14576449457108653, 0.08536004746583206, -0.2824968978954641, -0.039622791216618956, 0.30324678635903674, -0.43702463100367656, 0.21412698983960893, -0.27362487273066777, -0.4189010150771728, -0.2432543545274432, -0.1321955229600133, -0.2907258849121399, -0.4809549888636882, -0.34480347019413216, -0.6243287744772865, -0.17396045428111198, -0.08955939573257171, -0.33270978611226404, -0.09240077274831388, 0.018730887738360225, 0.04863043007868251, -0.6465168636703703, -0.12341717355953338, 0.13421167360028402, -0.2149574191690565, -0.6226961654681956, 0.22269735048971287, -0.07490855231667697, 0.16822037525094707, 0.11337605386286992, -0.626860496396952, -0.16822002714669, -0.5400745406734441, 0.17088783659847137, -0.12802907041492573, -0.6416794404885044, -0.8268059201661776, -0.2141619359635916, -0.2832540173560351, 0.18682564742537058, -0.4874039308154134},
    {0.5995628284391955, 0.14180930737073777, -0.06015146856393642, -0.031843206087943714, 0.07313643444387162, -0.26664824365191725, 0.286583528733228, 0.06549417589852398, 0.060439391496566616, 0.028910674458803114, 0.3804568835150581, -0.6595983811042339, -0.02739644861476421, -0.17496754147717614, -0.13367538459334835, -0.18767425708896907, -0.22659614798319183, -0.19314339444828213, 0.0992266862388571, 0.44353224851032413, 0.1598885447227008, -0.017782261756873797, -0.2265421825652649, 0.3046021582431149, -0.04396166605850549, 0.7494055995606651, -0.6047715322164023, 0.39696542723739664, 0.19940879126743552, -0.026983287944403113, -0.40482724054458563, -0.4717901249763148, -0.016124096288754372, 0.2046319196874436, 0.4396846484318629, 0.11490344652704469, -0.5138981211178204, -0.51452778952096, 0.33258254550656674, 0.3419676515406492, -0.3070940338472076, -0.0618516579743644, -0.06863236175045653, -0.25918615719310595, 0.07769879836935951, -0.6626446403812624, 0.08258758054531858, -0.4053522520377909, -0.40594008233069767, 0.3073226976913722, 0.05890872299156674, 0.7582394014763205, -0.6141522554485267, 0.001029181749997173, 0.3587934540241674, -0.3281778108164012, -0.04887228911628849, -0.07773744248408662, -0.4794933985475174, -0.01056636492982041, -0.6284641454282275, 0.10427555115193521, 0.5777321774784145, 0.1665955403364051},
    {0.6480330437438674, 0.18669550208734487, 0.22774776262170873, 0.07341989642558015, 0.22014269971949205, 0.33929924267545614, 0.8129166698693611, 0.4889355336427398, 0.03221882461813646, 0.3235441981182395, -0.1618872302199292, -0.16718117974929234, 0.22064726037297178, 0.038505531535635906, -0.2395338885561214, -0.21444135391572416, 0.12684721477486702, -0.5337424938327492, 0.019791855012122873, 0.24843726904233487, 0.9028236001179287, 0.1382855443096294, 0.6890024310974809, -0.19032094452756934, 0.12853965180004015, -0.3864396812425474, 0.3259543044989643, 0.09667263317010005, 0.06389795502043873, 0.5459795346580252, 0.06893356365118879, 0.27660189104174787, -0.2803332389174208, -0.12329621859072988, -0.38744002815816353, 0.6236313462254905, -0.3219248122356134, -0.495389068535779, 0.8564557545919466, 0.01851747669155445, 0.14168901978864085, 0.3989352654983176, 0.09728635176648699, -0.0969359055805499, -0.24341103762414654, 0.8983916160643987, 0.1355911738752383, -0.09529026245502915, 0.6473069472935085, 0.3005437810865775, 0.141092382993586, 0.25500319752501993, 0.4925267444899596, -0.010665975245606803, -0.41948784113562515, -0.5580818062302751, 0.2621281116926254, 0.09542442602339488, -0.27761215843841147, 0.3356845904366794, -0.7262859400871375, 0.5981405912177574, 0.4854783766347832, -0.01618275061884401},
    {0.08638912218111447, 0.2663843625603427, 0.31871475214730133, -0.21827030139097192, -0.23409563046852278, -0.025187042365213557, 0.21164431501822528, -0.36371937919952574, -0.09653973708678586, 0.38044149015366874, 0.29556783566330924, -0.16260138914286262, 0.14333376959329625, -0.4548161184008725, -0.36295861711918065, 0.13947558647881397, 0.3193822861466793, -0.19503034494247698, -0.26825212839198714, 0.6410521633383384, 0.046226680986367015, -0.35082221780666967, 0.21887261619602438, -0.5661602834513809, 0.19343748100808358, 0.4219259942937128, -0.12451667364743595, 0.5413867351681461, 0.08914869952726427, -0.2714182406710697, 0.21322161434510747, 0.16389101197887754, -0.10211964979860842, -0.028271604721221543, -0.05696271469286388, -0.009925593974956848, -0.6421334761411661, -0.3220303267348883, -0.12849492438781632, -0.3534388434138406, -0.6124243027288677, 0.0022179896329694595, 0.40140903710771336, -0.08062110353608629, -0.06065284948431578, -0.3820040765377453, 0.05837989849930653, -0.5651552560843366, 0.41278168440564805, 0.2823101895282372, 0.2573416816899803, 0.14295359971987978, 0.6871951793798118, 0.24485494519353332, 0.1357648339627167, -0.5638980062364092, 0.25163525690529, -0.08548661644137949, -0.19226563171051889, 0.36599136824256967, -0.07725097174733324, 0.25549138285689477, -0.22761197082057336, 0.2846888391473474},
    {-0.4726667384382597, 0.6624759873938402, 0.09595221044869434, -0.07328369113684695, -0.15681903248268714, 0.49994917354975266, -0.11764975905909487, -0.24267890897612024, -0.28452854036196135, 0.42083456205412395, -0.21039402911712304, 0.2714963203145591, -0.39817022621193354, -0.2498494373441192, -0.5322836152869964, -0.27375375060658463, 0.36214897187900796, 0.4467409506339296, -0.16263995161169686, 0.0660498784330854, 0.2491028309338172, -0.33624495055236087, 0.4377952486405372, -0.621744579050832, 0.16428447102880553, 0.0732516718273275, 0.21685295857141304, 0.011898793520586341, 0.2661441840083522, -0.46683779416307913, 0.02515283654717083, -0.16848747647411239, -0.7103767286711349, -0.6433704230509987, -0.14219778510943792, -0.4886814201001968, -0.17110009597652026, -0.19858454073029522, -0.13932768475593518, -0.2311981920411184, 0.1691232693795581, 0.3275465721715997, -0.03543499910769087, -0.2835425940727629, -0.3168227195475312, -0.12213130491503166, 0.2175360193198236, -0.09366638859161122, -0.41665844324340984, -0.12336261811176753, 0.1352677165958791, -0.04137820300385978, -0.24368103305728794, -0.1409477176697998, 0.18242034527484244, 0.279722554694974, 0.034147790863880326, -0.5612469430664181, 0.02371178274282166, -0.029405858346656773, -0.5250223170421908, -0.052593369176213156, 0.48270605789766236, 0.5557870166587056},
    {0.3706047737206864, 0.1345929625137285, -0.12860609353167876, -0.3521680448582155, 0.42538879356126325, -0.6468367458582659, -0.003937873894945589, -0.23189547155353177, -0.30390769499587156, -0.08839241634410092, -0.09417497760453548, 0.3853623536661749, -0.7752265771386814, -0.114130165306803, 0.06902328184639302, 0.1554067717902228, -0.41466430771659935, 0.49084415264340236, 0.4147127470045823, 0.37320702152382945, -0.31973714975506984, 0.4772478567771396, 0.22607440393922143, 0.27584757160245355, -0.01158562559685379, -0.16279224125338207, -0.08880626190894327, -0.3105350186162639, -0.2578376090797138, -0.1092767312398476, 0.2164643618690331, -0.08752233186361918, 0.21680243629922952, 0.09557660647230506, -0.3045730903151186, -0.47478439992484484, 0.14836020860897062, 0.05070891902306513, 0.0007213921903791426, -0.4019469183783729, 0.12082744520655112, -0.11958797563477469, -0.3426111982410935, -0.5623046224559319, 0.14630792988292962, -0.6589569445849455, 0.19855235568227259, 0.09747446713675739, -0.25708087923537, -0.35949402675862885, 0.3489229849292061, 0.5135903578814341, -0.4027971863068727, 0.2329436819605773, -0.09203355501061654, 0.008505072275164446, 0.7912745895550678, -0.4025283660618557, -0.2945163737533058, -0.28251806946742314, 0.026249390791395894, -0.0979908335111075, -0.16230269445430875, 0.36421788015821743},
    {-0.06079597523195597, 0.3464165888560262, 0.4420152032493076, -0.0796174888825803, 0.38071918250073766, 0.17057568637998308, -0.05080805647672474, -0.014922847398331286, -0.1346201474167359, -0.5729318271221787, 0.07571495538796935, 0.14751053910241235, 0.11922474546712716, 0.08141929304456315, 0.09149111609347578, -0.27598180523491617, 0.0829586905131086, -0.1723312289321672, -0.406534549034862, 0.4197858543984407, 0.14387047632363098, -0.5428366029018169, 0.4613082984818013, -0.25034356580339456, -0.40295654322768765, 0.40633899282000474, -0.4941605194072131, 0.16807803646965347, 0.15217103847658198, -0.14707139749537698, 0.27164606055850016, -0.29514215564195934, -0.11944567787521027, 0.1995811461029279, 0.07307542968863133, 0.24323388049181327, -0.2900778576596505, -0.6986451188555268, -0.0669285747026225, -0.39616691611212657, -0.1968196235692696, -0.5593913730413465, 0.23673657841779128, 0.18811543381218293, -0.122507712826387, -0.2669838539247383, -0.24467432545516507, -0.29909061389598673, -0.07982342917403637, -0.3217798805588451, -0.3455140697859352, 0.010993745845530457, -0.46105212104779625, -0.5280957986261599, 0.08142589284765187, -0.7714167765243506, 0.3633579565051248, -0.0437173362963728, -0.025589523392385117, 0.40899112716653857, 0.07322685209275866, -0.3412249565573059, 0.028066366507327935, -0.2206288354769934},
    {0.13718704826776154, 0.6137051084486853, 0.5769308898628809, -0.4736412455589995, 0.2169228445529056, -0.16361503193947957, -0.32965882113602424, -0.2958438586415988, -0.3496734186885694, -0.28322937001510384, -0.19854396337986965, -0.13001340800239727, -0.21090752836527948, 0.02595923110460278, 0.12489332790874726, -0.2823877575174376, 0.25161318894747836, -0.19008520451897748, 0.5563347019509439, 0.1814059609579576, -0.027117389895092655, -0.2569759016386405, -0.4146696040726803, 0.5269319134921776, 0.4264674206194162, -0.24809345801250182, -0.17441461387206475, 0.20973443557379676, -0.1286624170230963, -0.4109872544499397, -0.2645335526243726, 0.3478011595177006, -0.2859700902155874, 0.0960324590610929, 0.4019564278291296, 0.055307264177566665, -0.906737314179254, 0.2050568251316103, 0.31747576905815206, -0.29275811943702673, -0.3361847007923041, -0.3824891384024607, 0.43292634878076075, 0.22522483960115636, -0.10990936381599815, 0.1424899162210841, 0.47035792303512997, 0.050556939724225515, -0.04442176607886892, -0.29682678753365005, 0.45545891334256294, 0.04522317926695883, 0.16075797401529607, -0.2182792372688931, -0.6606816505226277, -0.4059135547760861, 0.033566128712216224, 0.21219924527543133, 0.0892467131697979, 0.5467266862338475, -0.3243979031763721, 0.5758041968593529, -0.5647688966475477, 0.4084990104180278},
    {0.16447236056835565, 0.36425602382978156, 0.854292172958983, -0.033614170947796944, -0.06184941035512059, 0.47520483105479955, -0.09431269244635544, -0.6354250224120709, 0.11295988982904402, -0.02304672267889274, -0.09921337532177238, -0.3170513275497273, 0.4788022160363682, -0.21121164642209578, 0.36984574519303565, -0.32713269562149033, -0.23566637080917427, -0.5235956536389258, 0.0802446350691376, -0.48893135041276836, 0.040053908690837296, -0.5013979886523615, 0.22428418748231793, 0.08651708841836873, 0.021528864753896905, 0.44852718714582457, -0.47972730070706393, -0.36088109560452064, 0.051180148840021616, 0.23165160812313257, -0.5641396966097142, 0.0764704358280179, -0.3735970376880234, -0.18087486601268934, 0.3219433926350944, -0.7404453134713745, -0.6143100912777862, 0.14745108020783354, 0.7703264416820795, 0.2821971990599212, -0.3813195763684843, 0.15086674862125637, -0.08712565086730499, 0.18386676430811957, -0.8201804265412956, 0.06927146120374679, -0.2959482443296696, -0.14998064969426675, -0.24777443560381776, -0.21385510331795746, -0.14093701740145928, -0.08404427205690673, -0.5106777157479276, -0.14421974468716933, 0.1773213844300881, 0.07503499793109746, 0.22084208454556886, -0.3844307777390127, 0.28558027776477796, -0.0864886948675871, -0.2970618850359537, -0.43263356274190945, -0.02598738302043807, -0.11734175011992562},
    {-0.13882767131478685, 0.04667708600096906, 0.2062754924171217, -0.24030591414052369, -0.14581132873481248, 0.41679324475679813, -0.03868068698250186, 0.20065072178736115, 0.7336425381237051, 0.5157609990505212, -0.18543670651358984, 0.19444264277138898, 0.5620801294992811, -0.31399928567479013, -0.2320661265179484, 0.10275285354657332, -0.03850729721787222, 0.05876868689472266, 0.030634441951843575, 0.349228872796572, -0.1892817675564565, 0.12598724376957987, 0.09263674564930663, -0.27977351206358897, 0.0683833624996269, 0.3503773469947419, -0.32483221835559856, 0.396687460394876, 0.11657155643820452, -0.40063047932266155, 0.20808843359994986, 0.32503759668964494, -0.5686632947402218, -0.049540168343200866, 0.386916458594696, 0.2045028081291338, -0.35138212581489964, -0.5266706174508939, -0.061508633099914244, -0.056661476002518085, 0.33350134918794233, -0.27155037480444616, 0.35322732771066745, 0.3173750628598912, -0.20019694005075184, 0.04130462125577512, -0.26356026168060354, 0.27123700776015003, 0.29890978214956765, -0.07582422774350264, 0.6499251743129346, 0.0048639308170236725, 0.013090011952505335, -0.10188833753801302, 0.13684139804885695, 0.13570412147126715, -0.508362498396029, 0.17119418655188384, -0.006806546094899059, 0.17411459887733674, -0.17736904775542703, 0.4006478182443495, 0.4954234135313177, 0.2933175347549734},
    {0.6092946648753438, -0.23336833316069347, 0.4684472424079277, -0.06048768848755229, -0.14715595868219547, 0.32520058764287413, 0.44364773352663084, -0.11728784716095514, 0.11008253596128058, -0.09649441468679122, -0.2267728028740613, -0.02009512610789634, -0.09989283008684328, 0.18734105345277408, 0.10076051895985687, -0.12465419550109717, -0.5989158282970074, -0.35744810193955423, 0.1947971081383417, -0.4894923535602244, 0.28121850388623426, -0.1624454430445113, 0.10115317714675344, -0.17099311687342444, 0.1240502950581658, 0.4793778108739903, 0.3368228737429308, 0.021604846693130383, -0.010201768805440511, 0.4905617481319504, 0.09772766093898598, 0.14000923222839362, 0.008116859086904646, 0.3321866962040927, 0.2596092363439402, -0.31347489107277504, 0.16554516595718377, -0.44719179778531754, -0.1682733825325539, -0.42882564755434394, -0.04518363339213271, 0.044981261899222975, 0.2167270348774725, 0.2384290905218362, -0.10997086570008462, 0.17640657312159155, 0.14944698142833193, -0.4718053998169334, -0.3032133579451805, -0.02224574914034949, -0.33262295385104623, 0.3498921851742832, -0.0013909642530361129, -0.4458727204614043, 0.3514283855122623, 0.06631722828987717, -0.09829279879039465, 0.18711625322195805, 0.3423179062278012, 0.028008352941181782, -0.720055511247525, 0.26250985726752685, -0.1453711422095435, -0.15750159273427314}
};

static const float b1[64] = {0.9249248679014913, 0.9555278669351747, 1.148861670269886, 1.190328974291112, 1.0554275238374755, 1.1099161471995649, 1.0653616001732853, 1.1215022255504195, 1.138339517843316, 1.1158912904690859, 0.9962728112318727, 1.1476920961553156, 1.1150749504953894, 1.088313770055042, 1.0619575311913918, 1.0646380439888559, 0.9783036644442001, 0.9952034015345668, 1.1099092392284853, 1.1876530272341608, 1.1420012377613777, 1.0335015502500886, 1.0360597506759128, 1.0923606549308085, 1.0465237532764309, 1.138672567403601, 1.0733899552503703, 1.1390937544863005, 1.142373613755685, 1.077436868388203, 0.9709965831716426, 1.1066354264586014, 1.0975763247800683, 1.0605795164125462, 1.029318983430361, 1.1132269580696583, 1.119710439450877, 1.1831940228861237, 1.044016886113506, 1.06085011545888, 1.0957540279399258, 1.0078944926756805, 1.0774298862020448, 1.0095736201572283, 1.0997707091468558, 1.0914153569611615, 0.9771851118786805, 1.140178556871931, 1.1060085413077259, 1.1906492646331133, 1.1056480416171703, 0.8758778079165446, 1.1510902490985306, 1.132923771071089, 0.9949430666348277, 0.9503589060688565, 1.0485763585475458, 1.0907543101616266, 0.9183180887316499, 1.0350395866019293, 1.0581970090341042, 0.9846640381481929, 1.1142397861844069, 1.053205010042242};

static const float w2[64][32] = {
    {-0.239461557149911, -0.04546755821020257, 1.206499795117881, 1.0069923658730653, 0.7458609011976309, 0.8898737530861678, 0.817259214489474, 0.5408504463559398, 0.8015072312432232, 1.0461369645758634, 0.8650927774945764, 1.1727873598031564, 0.9755987040213265, 0.49849446441399986, 1.0942142778241515, 0.6377839850078197, 0.6719280538537671, 0.6469955658902533, 0.8056167149625718, 1.0447559448890944, 0.7958747126598087, 1.1004182395749857, 0.8486501996318538, 0.8181403513977059, 1.0850108097326496, 0.8204120910479326, 0.7462505563329119, 0.9155245105913938, 0.604898882722762, -0.1026011887481463, 0.9091457930704719, 0.8667695128680648},
    {-0.13742297613008556, -0.30585808275615967, 0.8034080911138125, 0.860986141499147, 0.8651912391456456, 0.6955235853107403, 0.6109112242359309, 0.5532904259287857, 1.039059055533423, 0.8108161215531273, 0.8223265705607902, 1.0565907495894415, 0.9403774918112224, 0.6916336954963406, 0.7712930099622309, 0.7535660584290459, 1.0330433846117086, 0.6952481502720962, 1.0078525913522365, 0.8706794610091892, 0.921632254109026, 0.9954148576683378, 0.4904524488888639, 0.9239525539817083, 0.7310771205788715, 1.022391813549018, 0.9675033221126574, 0.9587654209920325, 0.6602652480350778, -0.21470075495637045, 0.8576881473860477, 0.6665744686317042},
    {-0.0527873770658055, -0.3486204688778924, 0.9307754824478648, 1.1047185090745864, 1.0396173069660537, 0.8149091875708481, 0.7198090623302393, 0.3861310430919576, 0.925285141058913, 0.545966110291756, 0.9244896381597719, 1.228000078943676, 1.417131378296721, 0.8888147855931772, 0.7423929630618677, 0.8449899450101479, 0.9507038178778106, 1.2484551960667079, 1.4523534814815382, 0.6687669922481864, 1.1067917561342135, 0.9751593079848345, 0.4837805176529676, 1.0184610767404607, 0.7883684102842184, 0.8345837945709688, 1.0884627471582524, 1.1589255885384349, 0.428403613029723, -0.39660315091765547, 1.3637760375034436, 0.8448302669256301},
    {-0.05406661536681372, -0.022295660538759306, 1.1451298750970909, 1.2769162208827505, 1.0478014475869402, 1.0924298297551054, 0.9734621129183334, 0.7635808710808616, 1.3108946093118496, 0.9195007919511327, 1.0703197982961785, 0.8540724252670399, 0.7795478383052862, 0.4030936262023043, 0.9574994110701225, 1.127912661192021, 1.092035698229152, 1.0285231418531986, 1.4300110561566457, 1.1408160603174895, 1.1905823685069934, 1.0766513974939549, 0.4457935892024662, 1.036652724209429, 0.9854089153254272, 1.0420527106507325, 0.7208374038911113, 0.7588677277911164, 0.3389038361843129, -0.30755917880966993, 1.2937103011184707, 1.5822742906468552},
    {-0.09891705611902106, 0.28391881617029746, 0.9620659734927285, 0.8415347821485029, 0.7930263603021968, 0.8626328040167539, 1.058780759496459, 0.37790264354070846, 1.0263016272731615, 0.8781878118359242, 0.8372897710865917, 1.0682682489387445, 0.7247296717133045, 0.7806412628258776, 0.9185432352671076, 0.7117095540272135, 0.6893983485764482, 1.0420249729388755, 1.0331135506558722, 1.0862495983975713, 0.563400143221827, 0.8230174095945242, 0.6998072275442491, 0.6642402185540242, 1.0413848116890305, 0.5723298125636952, 0.757616009064208, 0.6472844133264415, 0.33851158017329414, 0.10092387315300654, 1.0622798407772511, 0.9996214902580777},
    {-0.22121346525971225, -0.2683118272649432, 1.1365072571623858, 1.0492880339326343, 0.6643742295630398, 0.7426047442727239, 0.7077178395831965, 0.4023057272037975, 0.892727865114091, 1.0241063057593756, 0.9076345191954491, 1.001349513799407, 1.1160573315941542, 0.8936969202887106, 0.5945421760937287, 1.0367817683430107, 0.9128080227367978, 0.800841162165161, 1.1176228974633278, 1.1570818014024806, 0.7921549122957826, 0.8122190957074261, 0.6137166814661956, 0.6815383553036027, 0.9899569918171482, 0.8778740071751839, 0.7957221129839291, 1.2270440884133604, 0.45121967704322985, -0.05622580770732211, 0.8711361522521871, 1.1648198303207111},
    {0.0802192349988928, -0.182160315129652, 1.0134131124582715, 0.926963544933523, 0.8244863142808891, 1.2683534239504062, 1.1427278405831733, 0.8609495952848389, 1.1667876252267693, 0.8688818876498241, 0.865602482550935, 1.0472322122749702, 0.7525392915474565, 0.7549708460397796, 0.9220547125064085, 0.8763935191822076, 1.070597897767579, 1.2788812295328413, 1.0565899826896827, 1.1517580373463963, 0.7609650189728456, 0.8730941891591903, 0.5101715993282049, 0.7939195302600571, 1.086342274796031, 0.875018338335833, 1.5134882827620313, 1.0861614916399236, 0.1831229799405416, 0.05065599876054374, 1.0985559322402711, 1.2569077977963856},
    {-0.06618305950920629, -0.20702327514480065, 0.44246993683417074, 0.7054241831047674, 1.2393381486007697, 1.206288168568591, 0.9327801102920378, 0.5966820746571788, 0.9778236418396977, 0.9043582111286316, 0.9806143840950864, 1.1951449824190958, 0.9781755528516305, 0.6719111060825411, 1.0051043979082896, 0.9499403872889275, 1.0190602636104944, 1.225723774042018, 1.1154259105688769, 0.9782198518256616, 1.1030530906019864, 1.2211616718791796, 0.6866923597170764, 0.5324680934095701, 0.9660612050443123, 1.0548089621271872, 0.5828946568708678, 1.0792285591565647, 0.4288653802581032, -0.05562293635900089, 1.0977631483115957, 1.0336859410980181},
    {-0.21035548098899515, -0.21018430457846587, 0.9193967913659493, 0.9320916370333758, 0.7191157537881295, 1.1705468508984438, 0.7930278545187526, 0.38186500366523796, 0.9523936940171249, 0.9287680963215722, 1.0465839829069825, 1.226484569203019, 1.1834982392219056, 0.8718476718552067, 0.9253525839289074, 0.4729910572867911, 0.9629426288807096, 0.9265733484832168, 1.0902272038498604, 0.5888549797265821, 0.8071542131083238, 0.968671911490505, 0.6518562416591447, 0.3429115664912452, 0.6521408237253821, 1.0381850286264687, 1.1013089196588084, 1.229365813733426, 0.18809351121383075, -0.508630090592821, 1.2041242152441076, 0.9042833114255122},
    {-0.31746827930675625, 0.0862167210136122, 0.951477464679495, 0.5611977280901812, 1.1192532231294012, 1.045663114691192, 0.9424873657757374, 0.5031494171416637, 1.2266241790864665, 0.9760685773887047, 1.1305743526574843, 1.4193180063663633, 1.265082540512666, 0.8585927742257355, 0.7493155317183445, 1.1733739022443077, 1.209887362372235, 1.1905380094534614, 0.9569307594961232, 1.141247808738345, 0.8143350920693553, 1.23442298806455, 0.8486120341026638, 1.0523584053334594, 1.1112601198756549, 0.7417006411437593, 0.9082930973545547, 0.8223800268481735, 0.3471192795323365, -0.02372523512061101, 1.1254563896241956, 0.6777472811454864},
    {0.12979332153830547, -0.17216223671497724, 0.8973082204991256, 0.713482000754588, 0.8353460273732154, 1.327510256300543, 0.842563985233196, 0.4344078076451152, 0.7264511153806752, 0.8661577624061232, 0.894005511207553, 1.2376576604339113, 0.9727933022873865, 0.9284638412992913, 1.0944499426131977, 0.8406562018140757, 0.8626072409781256, 0.7194324357789418, 0.7928010632661281, 0.8027656506723622, 0.385051892018015, 0.7003417426748445, 1.0416980717828792, 0.6839325813840357, 0.7517980740086638, 0.8947555871275057, 1.2307226077675903, 0.7949249616392452, 0.2979384522316864, 0.22903706812311583, 1.0393572865572256, 1.0432324879932373},
    {-0.22328699031644061, -0.007572739900483622, 0.9273664619157117, 0.8892961094887035, 0.7113348888972613, 1.1093948148828785, 0.6969431950978944, 0.130407926827243, 0.8083509347393559, 0.46531407936557123, 0.6707669037627527, 1.0206000669627988, 0.7886161902651447, 0.735477739912255, 1.0635947153177452, 0.7119474534379877, 1.199163225456283, 0.932885284310522, 1.0206966652550673, 0.7354024080630165, 0.7449639225456056, 0.7293912757227791, 0.6126827331030222, 0.655198852787653, 0.8613507960668743, 0.8757728763784378, 0.9251504772171962, 1.0405466974367648, 0.21601747597686874, -0.08433918581066348, 1.1816123831950551, 0.834043983933817},
    {-0.059987108688866426, -0.14258801347666325, 1.0833989787008764, 0.9610530422754369, 0.9827290451755052, 0.9483479736117427, 0.6794587371187287, 0.3928057763867303, 0.9784404443560596, 0.9935492044767269, 0.6639359652238681, 0.9313502433577232, 1.1220501490284172, 0.506219213591167, 0.6418625252263309, 0.7221346039307536, 0.7239253383372536, 1.0033695498304869, 0.8847556741043661, 0.8733392479199883, 0.927439667572712, 1.0291895034843979, 0.655017057401286, 0.6391329065020422, 0.49825023585756817, 0.8086491704316333, 1.0279381918819805, 0.9769166397019293, 0.3756225587366043, -0.2878570872039164, 1.1391861609336023, 0.8006392151512198},
    {0.09795610038104677, -0.029224557581582943, 1.074854375923943, 1.3222777402279255, 0.9531756378874804, 0.6604840280937659, 0.7082084278804833, 0.37640101989201685, 0.7640467169707748, 0.9538786277563197, 0.5740567333294055, 1.1483420666041007, 1.0763454516642343, 0.633207025538234, 1.00067645255466, 0.6225483583682686, 1.0565479004674583, 0.9997714727851001, 1.0437402689744595, 1.0219345269871822, 0.8044996689687708, 0.7494545773269118, 0.642327991182251, 0.7708054862298409, 0.9499849300519534, 0.8660694467818276, 0.8602204000275828, 1.1641483038792988, 0.2016988920661134, -0.18376038783420554, 0.8095847425430017, 1.0260637256902077},
    {0.021275468352858797, 0.018332357045157368, 0.9000100146186094, 1.0798836134671768, 1.1194236730880192, 0.5408002903593557, 0.6495584896525818, 0.6051003932114724, 0.9244194681152942, 0.657179011403507, 0.8811498467158251, 1.0500688265633067, 0.7373047555543719, 0.8358705606361713, 1.144080745553109, 0.9295877907498108, 0.9906050408280954, 1.3762281546617672, 0.9600259982175144, 0.8009566239024282, 1.085060237819824, 0.8638620175874689, 0.5948692719028758, 0.6509166211806044, 0.5575177689496738, 0.8922191492170121, 1.1416900296020476, 1.047515094173275, 0.3010552938209319, -0.3558427140687991, 0.9462921216575441, 1.1544241178222476},
    {-0.07574122952889872, -0.11453153755643995, 0.9893784621692826, 0.9061057251388348, 0.6983649225488946, 1.0367159979893674, 0.8382669983748882, 0.5014812055380672, 0.9992423853590476, 0.8419378546718498, 0.7541969172468075, 0.9939759676274422, 0.7987437381170139, 0.6548263600818276, 0.7550621271581249, 0.4168976547628181, 1.056783041782254, 0.4264241828362668, 0.9123316120912015, 1.1031897505167745, 0.9748392106399321, 1.327155001958818, 0.5652732256013316, 0.6874362554442741, 1.24357551772404, 0.872533801574238, 0.9716881705342536, 1.012033805318951, 0.3211059875592421, 0.056955453250517415, 1.0284293716639892, 0.8968468950504034},
    {-0.2550892397224768, 0.1554694247739683, 0.5632267551990852, 1.1884561527646966, 0.7434223994530065, 1.2744269642987023, 0.8445200269771004, 0.32994724614804183, 0.7510726421835072, 0.9993259368054177, 0.9433241763104142, 0.897608205900031, 1.2927327542660083, 1.0198680076614726, 0.9592057716795293, 0.7234488239451867, 0.8854359787069186, 0.6047058990056997, 0.9667250161161778, 0.9477845111100942, 0.7457733392608175, 0.8619291604596859, 0.8018788688228324, 0.43722729919994435, 0.8280181830936734, 0.7699690882980655, 0.9401118658931255, 0.7079606926845818, 0.3645042850863207, 0.12331553907714138, 0.9007722025083325, 1.0690567289789716},
    {0.1670671991270505, -0.17703538952736406, 0.9271706300527234, 1.3277316676166055, 0.7038558022954273, 1.0250420682834271, 0.9758630574755288, 0.18101699435245586, 1.0278094903300456, 0.8880031268196119, 0.7584127086317375, 1.0108940272586313, 1.0211265335756052, 0.539876099692399, 0.8252058180172044, 0.8630883662990774, 1.15579998287727, 0.6562071173447405, 0.7846510930477857, 0.6337902570912533, 1.0350472189521807, 0.7533622279378935, 0.398652901326824, 0.798672070331008, 0.7246480189910426, 0.812189000976557, 0.7869178260762988, 0.9500101976945828, 0.2422621800366706, -0.17799341683280018, 0.8397675012404746, 0.645240450370509},
    {0.0105993817360287, -0.08189289139753837, 0.8622234048530248, 1.0020927115064235, 1.0681265333642702, 1.3402727666390635, 0.9062563902721603, 0.4341170640672093, 1.0673281633982594, 0.741306625723512, 0.5863858355572906, 0.9240085166287275, 0.9813828902889131, 0.6729945476842234, 0.8355573139457969, 1.1674422568865368, 0.9646853728580634, 0.5565488690380562, 0.8948348969604677, 0.7909628595073898, 0.6846123849535267, 1.0149458209544322, 0.5425755314308428, 0.8625729195042738, 1.1102074898787417, 0.7485433542853572, 0.9556770931755331, 0.6721622800776019, 0.4219461325031294, -0.5288529661781823, 1.162736228993461, 1.006917409953966},
    {-0.05975047549648735, -0.16769634763085628, 0.921000539172061, 1.1943619119286932, 0.7664438991091184, 1.0584623624612466, 0.7857585280919783, 0.36527638920716105, 1.2159498820300958, 0.6963140871320801, 1.0012903042280958, 1.5460987934010064, 0.8756187697298068, 0.8246602156518437, 0.696764203538212, 0.744210943832086, 1.2608474034217212, 0.5766009887689048, 1.1826479351326322, 0.8824212967211978, 0.9982423098009009, 0.9561349662189759, 0.45479475158329546, 0.6256629648625369, 0.4697438000986508, 1.094404850289396, 0.8647364502833086, 1.153688385810376, 0.32029650620686123, -0.264368872374189, 0.8691919560908821, 1.0568546013012337},
    {-0.20014217545698054, -0.07799741138961505, 1.4425945553303738, 1.0980532089995185, 1.029303792314678, 0.677919272115891, 0.8310921162660934, 0.5863968270409572, 1.0706705135538337, 0.6812665400941659, 1.0491985186652686, 1.066643886121861, 0.9139467545535849, 0.647359320067859, 0.6663047607979677, 0.5287351711501651, 0.6607005809526408, 1.0109688924548357, 0.8608256714482537, 1.1755575120749002, 1.0236340140711726, 0.7215818876951858, 0.6211515570113604, 0.4041928020885292, 1.0908905286185584, 0.757401670113144, 1.1273710515308644, 0.7044953456989399, 0.08409053350216289, -0.13635779810127927, 1.1069004885619775, 1.5011057779873134},
    {0.23238890561087738, 0.024359581963114704, 0.9397592183031437, 0.9887942831748378, 1.0469926517345338, 0.6784501009614567, 0.7436050959417502, 0.22576645517933264, 0.7816673995982152, 0.8938272951679906, 0.872314169537533, 1.2678952676052035, 0.8978922942439326, 0.7058019666014088, 0.7890650633207548, 0.5444430444812215, 0.9292586287182351, 1.234774456290497, 0.9623347377147472, 0.9658138618167763, 0.853309875688778, 0.8562377021000607, 0.5556742113752657, 0.8295792072902236, 0.8939779676758177, 1.0984890637857279, 1.0164123373292506, 0.8222689059095808, 0.11039375390105863, 0.21752594798283184, 0.8277443578040503, 0.9188843536386245},
    {0.02639601448720896, -0.03454568371432507, 0.8505258394068499, 0.8943938215268195, 0.9352766486207235, 0.872779282382307, 0.7651594796437567, 0.7587071241392952, 1.1445482884042606, 0.7842722494312478, 1.2473805661713318, 1.1099407114949404, 0.8885165565274431, 0.6192745655440387, 0.8011483627248864, 0.7641675397027442, 0.8481198536617492, 0.7838135956779337, 0.7653664740043901, 0.9603184010216494, 1.099204855783799, 0.9396307431631722, 0.7450514609873999, 0.9223009543293111, 0.881509691281182, 0.8853797012824499, 0.6838337272452908, 0.956757960990917, 0.300156386350003, -0.07570955180500225, 0.9868796325381978, 1.2341691104216348},
    {-0.11939658123488654, 0.03374333736476103, 0.7302683854169151, 1.0635566489193609, 1.1211927077435833, 1.078616114245823, 0.7363984656821014, 0.6191119032985097, 1.3252964413925974, 1.112589048471276, 0.9102433025486302, 0.9486834984540672, 0.7475565389777655, 0.6354321435929152, 1.0546563477436814, 1.282915506704712, 0.8054419258502077, 0.9735810908439052, 0.893404857434439, 1.1686002764116916, 0.942562111576429, 1.0503254240687119, 0.3823379245790057, 1.014065156394738, 1.3208318122578346, 1.0654436821507678, 1.2943878995800961, 0.9651113595500558, 0.6426890422071291, -0.21420750824367468, 1.250178290974271, 0.6518550233074567},
    {-0.17721797278830154, 0.01429935325496694, 1.0664527558532908, 0.8886615780559193, 1.3217724329380505, 1.151145952995973, 0.7500672012071901, 0.3973526007490595, 1.0212916319562244, 0.8555119877637817, 0.9665125191524843, 1.3195065563686463, 1.102224032459836, 1.0045498011226108, 0.8967165316228088, 0.700249203154977, 1.0923227158925455, 0.9274439342240598, 0.8804014217937866, 0.8769399017280068, 0.9666040451305655, 1.345304557337285, 0.23452317476507936, 0.7742711232455929, 1.1854499736439483, 1.162531250515652, 1.0743564465274444, 0.9528407951380631, 0.4519653139888416, 0.04044502600580117, 0.9233061205418797, 1.1251593500861652},
    {-0.033913322571419144, -0.28044055773976095, 1.0300888347267312, 0.9200116558711937, 1.0255038788128479, 0.7401086315350942, 0.8490960735228329, 0.6733652610011379, 0.7629996772695778, 0.8757203757604518, 0.7464902558411557, 1.065521427524202, 0.6976082105280562, 0.9360245342307342, 0.970641990395697, 0.953927178817792, 0.9571964441554881, 1.063664736370805, 0.8017351357865897, 0.9989390289183692, 1.014837604903322, 0.9892699270033355, 0.7556036440998269, 0.4451921403388071, 1.1496252874438124, 0.8113567007688531, 0.8937409149899662, 0.8671442248192506, 0.5359524288432798, 0.3596558100536999, 1.358117633429268, 1.2068145852008847},
    {0.001744300986769318, 0.23068480418852166, 1.1255546993491379, 0.9701061254033803, 0.8332392965438857, 1.2322139758106072, 0.6121216498459802, 0.26771942871874593, 0.9616495138940514, 0.9312556403446577, 0.9623406411832985, 1.2294990809812836, 1.0171832480407228, 0.5566144639001673, 0.784765143282751, 0.7187655979689728, 0.8080706945089328, 1.108478117204225, 1.2978040877169073, 1.2874676444843354, 0.7510387979503973, 0.8013357537875498, 0.6430960872238469, 0.6494143186400129, 1.0694186349182313, 1.2095476087737433, 0.9099752865779588, 1.1105294955293494, 0.3423328523608167, -0.012180388751847139, 1.0407997580401747, 1.0294094302874712},
    {0.03254189413464637, -0.12050799500073021, 1.0174657593021934, 0.8983518856515924, 1.3644220949562749, 0.925845964466158, 0.8348809911063811, 0.3397985726528981, 0.9059164379130527, 1.1330806536898177, 1.1474554047786905, 1.1945829539655863, 0.8602815971897009, 0.6360218233062037, 0.8724874412780655, 0.7097626776749063, 1.205653629583197, 1.0095208373148583, 1.279612108599923, 0.7439367424175297, 0.9919694372599438, 0.8857746104281802, 0.4320993516331891, 0.9206626192888012, 0.9681107530937181, 1.0782681419306552, 1.0042643100862196, 1.004877150805152, 0.5765842992937099, 0.03984661054784299, 1.0096783873259942, 1.2875137041159777},
    {0.0516126492794748, -0.057041218948731466, 0.962537321948995, 0.8777707097249381, 0.7899197176900835, 1.0903383268488058, 0.47149619970268886, 0.21309247337479284, 0.9802918248355964, 0.7233898461070456, 0.8659269134063654, 1.221014971339031, 0.8655428757623972, 0.5836870800907036, 0.8830721490042105, 0.9770876632595995, 1.0316083723861547, 0.8977982604088105, 1.0342077441998325, 0.6597452815208078, 0.9164296992466984, 0.8020355285114915, 0.5344443655990396, 0.7005124219512512, 0.9318138259940449, 0.9814181279418478, 0.9776561846162349, 0.7643770604001728, -0.019711309097024735, -0.16512286631428963, 0.9805914792967166, 1.0362956604566107},
    {-0.3883843508192312, -0.16591718162601693, 0.9340615731725772, 1.072778037875097, 0.7698757497147055, 0.8364422355970704, 0.8153163716671721, 0.299471723472688, 0.6962966624774858, 0.9558050430362927, 0.9524954649280993, 0.7526737512788156, 1.3319511796801922, 0.7276810761382038, 0.8030665227316067, 0.6592276808103616, 0.8441265157906356, 1.0892148519232372, 1.0987090941258628, 0.7917908714307926, 1.0817878098696636, 0.9136385345695472, 0.5275729637615933, 0.7805392521575377, 1.060757829678292, 0.6247545339891353, 1.1445220617423484, 1.2633024798126808, 0.1575765162576426, -0.023016300778204282, 1.187197238555664, 1.0044857998001104},
    {0.03912001846303287, 0.09364028454313399, 0.7216354959427379, 1.0591482162882628, 1.3283470360975644, 0.9121261192471418, 1.1701923993904202, 0.35533344879341444, 0.8834905473540514, 0.7464177452202273, 0.8383787983977645, 0.9903153885272704, 0.9456717248718989, 0.4939579820496285, 1.2527406811645998, 0.8842636466966177, 1.3467100952496533, 1.0272004729611988, 0.8436603606641553, 0.6905576647320557, 0.5865389645035402, 0.8076237378759454, 0.6059854239706576, 0.7961063767087078, 1.0467528622818318, 0.9677142232748043, 1.114627648940772, 0.8134037575562976, 0.346092375149808, -0.2824460837940697, 0.9372379019274312, 1.05439458566142},
    {-0.22997071043548237, -0.16466398657578382, 0.9448760053259013, 0.8224064221861557, 0.8193114853392621, 0.6205841652365885, 0.36208693262399116, 0.12347310595243005, 0.8806656126142373, 0.9091444592651005, 0.7308779701788216, 1.3468395703808373, 0.9297381718287591, 0.48083164506071185, 0.9897811866453683, 0.7021939618104275, 0.7870331851320923, 0.8520738218568951, 1.0112676265184886, 0.9422436582162621, 1.025087558901632, 0.9937101353304657, 0.7158812372776525, 0.6081795431881902, 0.9770447670407205, 1.040834954641525, 1.1543745065687296, 1.0540554392998598, 0.4201082493596896, -0.032640737709334365, 1.0969887753593255, 0.8472680631711828},
    {-0.4041172200850438, -0.1658311263808294, 1.0016150332562954, 1.2528579361388825, 0.9897785520213521, 0.9382445511859573, 0.8614407696223395, 0.25762765952925853, 0.823051067261168, 0.812041332734053, 0.8502615357093714, 1.0640732338283456, 0.8076863669828747, 0.6831062614234128, 0.8446665721622418, 0.8471764164326925, 1.1599571965679338, 0.858714352297836, 0.8679760188009412, 1.0311664501206914, 0.8251156292610253, 1.0704350687073156, 0.5222016434986578, 0.724627647521171, 0.8636183841787458, 0.8409402076515876, 0.8297478894827899, 1.0662499200155728, 0.21092573456256408, -0.22151938837014204, 0.8745358541570026, 0.9885760613956908},
    {0.00041866633774310556, 0.04105053475227032, 0.9335675625862594, 0.9825393792598517, 1.0042716176908042, 0.8800550685963031, 1.0805367137552864, 0.3410639840982195, 0.8864183941154364, 0.8175958639773382, 0.8980958044663654, 1.2253421503126711, 1.0287297551265804, 1.0494678054735138, 1.0807133949140701, 1.0919541784149729, 0.7810042930198078, 1.0076371328422056, 1.054237499309613, 1.267960940280581, 1.1251024370398768, 1.2003209862411033, 0.8933344187866594, 0.9673226360361243, 0.7925478222512685, 1.0700305689840137, 1.0819067500283723, 0.7063507659086231, 0.5151086722260628, -0.010162068333512615, 0.9827020757783076, 1.2320664583432364},
    {-0.011021679562603828, -0.05436300090027247, 0.5451173345188688, 0.8914437437490647, 0.9579580199978085, 0.881888644270039, 1.164667507455772, 0.3930053927658821, 1.2666737839959255, 0.6547095695809979, 0.9740923313140863, 1.1794702018325083, 0.8921132772391975, 0.5833820022024757, 0.6080265832455679, 0.9074159029065656, 1.0040529454038332, 0.8373203571889696, 1.0371116823886166, 0.9514855226856783, 0.777272495774398, 0.7865503124100417, 0.48811717876001065, 0.763005882074857, 0.9088640506690123, 0.7081128038738437, 0.8541187035552489, 0.918700722906453, 0.3057772334528679, -0.4712707695708985, 0.7504677780389644, 0.6589693831402049},
    {-0.22314873186741724, 0.01889853269112879, 0.9711597840916516, 0.8544798659788156, 0.9439872670751216, 1.1749438912452113, 1.1304922242568765, 0.2681165529140281, 0.905161561360653, 0.5412171089347785, 0.8266521866028576, 1.117342903675777, 1.2734562899589412, 0.8393780046403592, 0.7876202390622778, 0.7388960089274206, 1.0496966019186746, 0.8928117653722881, 1.1096808426587637, 0.8513863438988849, 1.1958276362039915, 1.3275010315269307, 0.7366081719325072, 0.7714379825194062, 0.7398489074952134, 0.9231403630266926, 0.9290668755755055, 1.0002562296049489, 0.43078446949039534, -0.0738633408942635, 0.796711879902715, 1.004101169933406},
    {-0.05636507848666912, -0.06644762288408104, 0.7660477552021759, 1.1441722387220836, 0.9180675572284762, 0.788395824128223, 0.9295865674095916, 0.721569493314927, 1.0697461124445242, 1.1399220450290484, 1.0392990763950154, 0.9164787442517085, 1.0057125313259292, 0.8383493943289354, 1.0206883244645397, 0.9485773822921314, 0.7670536954503232, 0.5407416513131245, 1.3272705399311024, 0.7544041065518838, 0.5792662314428079, 1.2299152492605148, 0.7103598189301489, 0.5398489903477924, 0.8290322082773726, 0.5622884138723006, 0.8544717432974777, 0.8217926594172367, 0.4341315289858098, 0.036262722629153935, 1.2348611861665304, 1.4196819667913323},
    {-0.013356999870143002, -0.0632692779154484, 1.0315934807166558, 1.1366025166546418, 1.3184841448322262, 1.2158146996847405, 1.1744337348194414, 0.6541745170536888, 1.0456340867255274, 1.0289337035903658, 1.2399048402124877, 1.0525237826867546, 0.7300362429564354, 0.6835937199034378, 1.1410999216982645, 0.9102659583360284, 1.2265210149367336, 1.1223509760749277, 1.0275605647617674, 0.8267292466784015, 0.8328398928231735, 1.2785927212976702, 0.6943704184039562, 1.3414306701373278, 1.088694485026275, 1.0678974851015204, 1.0130845316653916, 1.0409407996223006, 0.8720154035429407, -0.2479282194467141, 1.3464349596220753, 1.2298685629656105},
    {-0.19790422582409106, 0.21097261546851992, 1.0287921045479296, 0.9736938685101472, 1.1916619863887443, 1.058475666576544, 0.8058907263198601, 0.2533251528942162, 0.9434697998548321, 0.9621828447973512, 0.8870616693944775, 0.9081948656095871, 0.8133404667099413, 0.9064196733042497, 1.2375578552368707, 0.669427991560159, 1.1078900683664163, 0.9643818862212086, 1.0064383594237296, 0.9316965467338388, 0.9858542811040425, 0.7967445197716344, 0.701803180150195, 0.3812182701727889, 1.0678245183078807, 0.5110643000983457, 1.319424218062888, 1.1317202613387312, 0.617854622849454, -0.05241410322676738, 0.9815436830789259, 0.8969903690724872},
    {-0.34155476421430203, -0.04744183540342481, 0.944860650376026, 1.043435618441328, 1.0212580014301262, 0.8587834325417497, 0.6572267135662474, 0.3109670744688085, 0.6665011571487462, 0.8233810182302913, 1.1868114049219187, 1.0486970114789673, 1.0896706782118828, 0.678478059384196, 0.29217486134337556, 0.8616109584600167, 1.0441201247580274, 0.988148230970459, 1.2087399355592596, 0.8204086111748073, 0.8076299075403282, 0.9011868434834316, 0.6956268626126927, 0.8117342373440221, 0.7272757021594457, 0.8907368055554447, 0.7915210886965218, 0.7466211652610525, 0.274875121455109, 0.06909965960034142, 0.9163137690604745, 1.3213582191584388},
    {-0.19454208263861708, -0.23842031351329515, 1.090910913827592, 1.0778753175493758, 0.5667811212245888, 0.8375281323902076, 0.9660932839488112, 0.35759407588564, 1.0269692162960287, 0.7123331540005531, 0.706887804119626, 0.9902459703857267, 1.0982363969596767, 0.5255653896564362, 0.7263193534106841, 0.6538498264441159, 0.9173036747867258, 0.8763342463528393, 0.6991826557702223, 1.0314521922469406, 0.6410120723251527, 1.1050660001390689, 0.757971084883219, 0.6582794515526902, 0.7543132508242244, 0.9137997475223227, 0.543428773359451, 1.0350717163340137, 0.1097565121659561, 0.4738788541511777, 1.4127878971673362, 1.041533137195651},
    {-0.1652818474319353, -0.05041262839761111, 0.6704412887423652, 0.6194200783812596, 0.754086573764346, 0.9810391821105929, 1.0220624631149617, 0.4725209819326209, 1.2003696182897814, 0.7821503214331971, 0.9194603993775865, 0.6164284457739657, 1.32594752883433, 0.7642001348182, 1.0459579967136852, 0.6496577701101901, 1.4507323934588474, 1.0085862878829996, 0.9096539456056005, 0.6129166229700278, 0.7958044608533761, 1.4957197781234872, 0.6185972502650351, 0.2885611817725489, 0.9376179231286141, 1.125155586870265, 0.9282557226591807, 0.9819766464292435, 0.22408476810182326, 0.1068559427647141, 0.7864450223758489, 1.131836845544414},
    {-0.10819409216600272, -0.032479202670897316, 0.9184488858790993, 1.084020410715587, 1.1490097179080918, 1.2200516209277155, 1.0977913077285812, 0.394307215356659, 1.3277342009142739, 0.6557349746247231, 0.6739509885753531, 1.022061904823702, 1.136663518877358, 0.6846009777460477, 0.9666959141838756, 0.8291597577152655, 0.9428351614517038, 0.95634677947787, 1.1213234219405355, 0.9361653709337759, 0.9184926168635876, 0.8263602125626915, 0.5705714764213746, 0.9500871821270339, 0.5639661249832929, 0.8624867546573487, 1.0643693418882976, 1.1510267783727017, 0.479554970015404, -0.15461205169045128, 1.0239258248242116, 1.1077584375883804},
    {-0.19835773194984785, 0.09069292617427706, 0.8808462858120637, 0.9603474529474199, 0.6121596329031126, 0.6886176262983842, 0.9948019297502447, 0.5279502595326266, 0.8906953755373147, 0.8194957025946759, 0.9103533889294686, 0.9098948017423374, 0.9981263113823842, 0.5053080839979749, 0.8791400183862289, 0.6388618668595086, 1.1211853660888207, 1.088749797397364, 0.8289873297958118, 0.6513940089660306, 0.9588611893074226, 0.8459037881170403, 0.6903318013982268, 0.9816480095052776, 0.8936030940578839, 1.0298205515479397, 0.7913563974066901, 1.0514563359734326, 0.46626971829790664, 0.07595544548709697, 1.0534989571213227, 0.8449930050123022},
    {0.12422135290476867, -0.10187774240051349, 0.8610199953130181, 0.7695572131389444, 0.6867271137768554, 0.8211617415849355, 1.0954280193316879, 0.3787441070161263, 0.8828317700154523, 1.0879727155197412, 0.598211256900047, 0.9120467992287318, 1.0683466908169739, 0.7032915369817219, 1.0610148885666009, 0.7640366472023729, 0.8630962095470114, 1.1541754492590717, 1.166226934970561, 0.7225525268357316, 1.2289722566897334, 1.2750796029450493, 0.6733839528620112, 0.4169298423040285, 1.238869055165067, 0.9701498763673058, 0.9359568053255786, 0.8576399915493458, 0.9818507755830672, -0.21744088772886103, 1.0288045280845666, 1.09942023177729},
    {0.1721343021960657, -0.24925691020657761, 0.5921896506666663, 1.0680445821925286, 0.6768858560448989, 0.9346631380893731, 1.057348323612782, 0.12652321363790925, 1.2160402222324396, 0.9073105192888044, 0.6994316877146468, 0.5253256088791075, 0.9767011455547794, 0.5052057551672514, 1.0454615939420766, 1.1139149981893202, 0.9163119861238435, 0.7520822309341639, 1.4327578419404048, 1.2131639068638, 1.1372919413532974, 1.1633406842118934, 0.3673290168903688, 0.784457086533412, 1.036497826983067, 0.800572284636307, 0.9570198740229736, 0.7995841362627188, 0.7521681405717954, -0.10212601417609467, 1.0057575040611697, 0.8736266169816012},
    {-0.23119147911446064, -0.28313181896575246, 0.7897573405573677, 1.150850853134001, 0.7095686157578709, 0.9056708093377595, 0.7546900750252484, 0.31172309728669195, 0.9441243188437387, 0.5765520675228379, 1.0635076700480965, 0.7891746395356704, 0.9744312020424493, 0.7427586819855024, 1.022786861452468, 0.8491731302251768, 1.2491665585519331, 0.9600866345577235, 0.703505518632731, 0.9405441023778088, 1.090116561837514, 0.8141947698937938, 0.5158734890235626, 0.9339419408757692, 1.1679584365638795, 0.8662709707890357, 1.0013344382694551, 0.9844067885219796, -0.01938589367159509, -0.12483715869708513, 0.9342217069029177, 0.9891064777595926},
    {-0.2273327573331555, 0.14072084797851717, 0.9676942847726195, 0.44184035407939215, 0.6952210886168305, 1.1566593919665547, 0.9276793504797414, 0.1867858163794292, 1.081007739535819, 0.570145074297791, 0.7678174455975153, 0.9601479534617273, 0.5506649743825611, 0.6610546074102146, 0.8241013470643508, 0.7902940709521337, 0.927538975883444, 0.9308669497765419, 1.0632954003519655, 1.0408710608585432, 0.9456916942050827, 1.1306083652891505, 0.22823654540015056, 0.6615291393548256, 0.772950311112495, 0.7147580418378401, 1.1471894185472828, 0.9004116292686862, 0.19225488300344964, -0.08796137251057855, 1.1599490802043748, 1.1766783701344694},
    {0.041274358164770736, -0.04428872811767682, 1.0348424806880603, 1.1720206506694177, 0.7090564323682446, 1.1105334111338492, 0.8048613137493142, 0.1021019356764338, 0.937373722132578, 0.9567823387510883, 0.8896480441896678, 0.9963102835222002, 1.067367446322944, 0.5613119926662244, 0.7691211144151366, 0.9725849535453157, 0.9966598298163323, 1.002289868487661, 0.9912793922352287, 1.2665870459372528, 0.5703734197734541, 0.9338959304350687, 0.6324785844020365, 0.36933658934168107, 1.141671965050166, 0.6083460025095564, 0.9510881010954075, 0.6162161828980501, 0.5018850080458396, -0.012791871159410129, 0.8729232630412992, 1.2334987433941407},
    {-0.03070383650330198, -0.028547186905343313, 0.9879601768843921, 0.680576424190738, 0.7586355422500647, 0.9364729541904864, 0.9309193734615338, 0.3107850596721709, 1.0689166954940292, 1.0264059106121355, 0.6444521114551663, 1.1876559902618438, 0.8695106448160816, 0.5701081553181943, 1.0938145550149023, 1.0661079677230267, 1.2508458527039132, 1.1901448415632312, 1.193632215426204, 0.6346884089677348, 0.8140925302454097, 0.9674626268063758, 0.9129514143809148, 0.9729976134307834, 1.3421374440295954, 0.998151567725819, 1.0718678255923446, 0.9847751014218645, 0.0026508086861704834, -0.059232182524879, 1.0002939351925166, 0.9746134332473955},
    {-0.11388703974060571, -0.34782391353725456, 0.9251296028185779, 0.9909062736261804, 0.599863981175013, 0.9838175844903235, 1.209973829353086, 0.12200439120423737, 0.788148283081082, 0.6492923939493683, 0.6114532129823961, 1.139819853885341, 0.7005804126383237, 0.8198202826300175, 0.8875305105125337, 1.0183655659918212, 0.9180596728847842, 0.9161206554027512, 1.3212617509945828, 0.8136946017895225, 0.5313225148907205, 1.1688261376301576, 0.4224717796053827, 0.5600492649630348, 0.6654648662359306, 1.2300446124058568, 0.8664821875916392, 1.0751436137085397, 0.6527326213246607, -0.09188101148656445, 0.9624899083576931, 0.5676884748170234},
    {0.05757273021919261, -0.04312870831707606, 1.1413085398065548, 1.3382332574345768, 0.8621558805039794, 0.9495466650237361, 0.8481704436219045, 0.32639793744546086, 0.8611287235216879, 0.5378881068432472, 1.0381671168606303, 1.0378808325948772, 0.8887339678520491, 1.0747295916020985, 0.951827041578539, 0.870794697691287, 1.1085029022459965, 0.8127306724860184, 0.7340352387608894, 0.8565423981452729, 0.793369154826623, 0.6433271592117128, 0.5408229783499835, 1.0335663469666654, 1.1593158836538515, 0.7487810069868517, 0.8635863032606821, 0.873104826877159, 0.260074319870398, -0.1630780870455558, 0.7717446724000487, 0.8301562805171155},
    {0.0842305268049172, 0.19909926681539294, 1.0398034687215478, 1.179022975735689, 0.8906816154149808, 0.6728839340806753, 1.0163042768210082, 0.38299821942254647, 1.185081396429624, 0.7575965370142611, 0.6899564561352791, 0.6990991694585303, 0.8856180088356188, 0.9425247139330969, 0.8417256158669814, 0.9753705334181144, 1.0386473181274192, 0.8720356087427317, 1.1597480545390002, 0.7555651826082421, 0.56146469622909, 0.9167867378719584, 0.6331754818256704, 0.9088110853158231, 0.5496907597691734, 0.7130043957586352, 0.9103861965550474, 0.9092805392145343, 0.4640507027471523, -0.08547212929731196, 0.9425656146380669, 1.0385558852700894},
    {-0.12337334895719722, -0.2380605511136289, 0.9698271377256175, 0.9143982868329785, 0.8154101494928571, 0.9835597406997002, 0.9963029651884393, 0.4710274574574531, 0.9879910243459528, 0.8364337854898095, 0.9579343537891758, 0.8590066760297204, 0.7426760500577754, 0.5553625123082404, 1.1528491153382263, 0.7080050625098225, 0.923496542679195, 0.8531799261395655, 1.2507181813489026, 0.9053976618633643, 0.7833457929839153, 0.9450993493232086, 0.7611299753131671, 0.6558139170759345, 0.811508706372657, 0.8842752670388785, 1.044962174369611, 0.9376869924570961, 0.5464213642095841, 0.111870239217379, 1.0143307150368714, 0.9565743938958188},
    {0.2647492353504797, -0.36300199633435853, 1.0933025568494086, 1.0193894817034759, 1.0564312885344989, 0.6174361913934959, 1.0693900429095582, 0.29029955807107666, 1.240020132789983, 0.8123744276480149, 0.9911419132319879, 1.0051950391505415, 0.9955230597882959, 0.8955428250657412, 0.7891182756769808, 0.708636667192873, 0.8959023811157784, 1.171028191503887, 0.9608918977339275, 0.975291794824712, 0.5906987799431218, 0.9337265331305046, 0.6054694569572592, 0.8755058131073999, 0.8967859963525583, 0.8734613031143136, 1.0094485209407096, 1.025623478123871, 0.06564114732568299, -0.016424131885195675, 0.5558296010568824, 0.9487755464399671},
    {-0.2275440413266431, 0.061822440768934506, 0.925552366473214, 1.1713840041477197, 0.7841883456910383, 0.9193822543338248, 0.8642712026367326, 0.30611788569342757, 0.6367275507615953, 1.1017405043606834, 1.0618217140594857, 1.0132925748142574, 1.0465802768960524, 0.9633596257663698, 0.974655430267941, 0.658006693652987, 0.9893309332088437, 1.1610483105315093, 0.962654222174693, 0.7982927138383116, 0.9978668588814096, 0.9503255747197086, 0.6736682147393787, 0.5455768609252309, 0.658717395467886, 1.117912678992286, 1.1657945159420815, 1.0008172123186163, 0.3708137824533285, -0.18985548523093174, 0.7911594886247469, 0.904721468108425},
    {0.1549547568098744, -0.039736331930647004, 0.8758425185302803, 1.0265910419759368, 1.0571857095668549, 0.9938073150413457, 0.8649813126288755, 0.41518763040137624, 0.8878336383751475, 1.1230935423392958, 0.5953819577690801, 0.7226173072443799, 0.7856058702040136, 0.9782679264150311, 0.924278564366547, 0.9336365158694035, 0.7124008576594411, 1.434845488482987, 0.8511340052011986, 0.739724166074787, 0.7290474978382808, 1.0501473467051559, 0.5165589315680704, 0.8426900565649121, 0.787810779416151, 1.1563326670535314, 0.8726367077696031, 1.0959922537423812, 0.31461104739797635, -0.047618215420234096, 1.0683612232520472, 1.0787221586309412},
    {0.0990152650931536, 0.0009749476700555326, 0.7771907765463811, 1.1198697075151474, 0.7874006230802479, 0.6926776147100766, 1.0410260134720704, 0.48692431214565635, 1.0247910417370498, 0.8479170063278297, 0.8491005252476944, 1.2630946354926063, 0.992828683837761, 1.0046993577460608, 0.7517781563247773, 0.9076198972985042, 1.254751524001008, 1.0677989137939368, 0.8792602852420507, 0.9661955363473052, 0.8012817414906059, 1.2490147922632695, 0.9019135070788324, 1.0159898011520847, 0.7934155439380038, 0.6286679447312075, 0.8166071367647888, 1.2071611134352118, 0.1796761840685599, -0.19623220607308398, 0.9319417995772898, 1.0405834205716753},
    {-0.048109058423080095, -0.12210201927602687, 0.7082830013477706, 0.9849684378342728, 1.0014835032454148, 0.8574039085767663, 0.8025043110659082, 0.3598796144047605, 0.7563370228008978, 0.6833773118701115, 0.9446351689943289, 0.8177278073615754, 0.7242991380701433, 0.3663574801981792, 0.9344076727778068, 0.6328776640330249, 0.9887708203135922, 0.972971948898767, 0.8876970059125237, 0.9641621264183465, 0.6232212039071177, 1.0781822766883673, 0.7014106601418907, 0.5817291983088473, 0.6556558403126845, 0.9285361355807491, 0.9583096123024882, 0.957057990542353, 0.18488719662913955, -0.37843169956887374, 0.8290141015918013, 0.9967553160170443},
    {-0.012162544362581252, -0.2237300998451238, 0.7984282013783419, 1.1367174369720134, 1.2474179150931286, 1.2252898349177423, 1.2709264543516547, 0.08233196186868917, 1.0593112201770647, 0.8034757731270756, 1.0217496932771104, 0.9070055225768203, 0.801726514834086, 0.5201423516356974, 0.90713278543051, 0.9166582384783265, 0.9186123561673238, 1.1235476116510037, 0.9063182366449222, 0.9366769552707443, 0.9671873246767577, 1.0549134259841215, 0.4837719676093744, 0.6229158748424313, 0.934271759303274, 0.9055626848520997, 1.0089837037602227, 0.7760079936853735, -0.06526242398063593, -0.5816069075689274, 1.0304135497335574, 0.9955032599394104},
    {-0.2283725396632717, -0.5144926858891861, 0.6231498594124169, 0.9051736850995085, 1.0221184302740995, 1.1179017343612419, 0.8487672236434882, 0.10150433964024655, 0.9980012526834012, 0.7103356397805779, 0.5982654220412507, 0.751663490856906, 0.531553356789089, 0.8126874579857718, 0.6980010264257247, 0.6108231410120283, 0.8932300293241459, 0.9478664363598008, 0.8945333004757704, 0.947752472685674, 0.43926344583121896, 0.8145656023248575, 0.5200544402327051, 0.635874117718648, 0.5919146016224974, 0.8945086540888472, 0.8064188095162577, 0.8925871053672545, 0.21030105798114973, 0.06753449833246922, 0.8721389741757776, 1.4236095542823786},
    {-0.24346686711492843, -0.057184932217515284, 0.9706467857910955, 0.9999544948923631, 0.9449106245088651, 0.9256993193157373, 0.9956173140475851, 0.6054268135230024, 1.163148988788624, 0.8817087304499759, 0.8480236175053968, 0.6643926171319104, 1.0159239325046825, 0.7638449417272073, 0.6702597264343223, 0.8022056436705888, 1.0110062855682105, 0.958825102369737, 0.649397598172545, 0.9660919838883185, 0.9059051283720883, 1.1640873905333273, 0.6651395778565514, 0.9705603400565608, 0.9958389969064306, 1.037083970341914, 1.2519838338571994, 0.9591810714454544, 0.2065646068953766, 0.21045587167206206, 0.8003101172926601, 1.30193465141095},
    {-0.005396140086474006, -0.22405239810589295, 1.1481035060781575, 0.8723793434491349, 0.7463456600328304, 0.7744713563060197, 0.7961316667861654, 0.17278430934005484, 0.9183432111244565, 0.8268227643742742, 0.621713697523472, 1.1055923777043486, 1.0987069522770487, 0.8620100545053833, 0.5812313283567833, 0.8831177479519575, 1.3434042389711764, 1.2245533493218599, 1.0645674408649801, 0.7957374538442653, 1.0859797898892456, 0.8295747674911292, 0.8440002618797593, 0.988330977460932, 1.0508710308228488, 1.0899536749171255, 0.94166507428247, 1.0901123567423503, 0.0929033833210969, -0.11675839718602496, 1.0774912160830408, 0.9366141027973641},
    {-0.12673746464204322, 0.05103645918810391, 0.853026227678151, 0.7417917649373665, 0.745835277598565, 0.9402389008607495, 0.8816255746406019, 0.5069934089094092, 0.8839308801659975, 0.7660569383431862, 0.5689651199692223, 1.0927931224548875, 0.9748998625804751, 0.30246520134513954, 0.8088393276079366, 1.0425898977339478, 1.0321563279942798, 1.2329527302006988, 1.007620643644606, 0.9017790902077801, 0.8897743377340724, 1.263608600829785, 0.532067684292448, 0.5198308774857318, 1.119782482822996, 0.9659449749577531, 1.0418581820352628, 0.8193216331670019, 0.14437628890993157, -0.2239141726132415, 1.1448451476448798, 0.6366351853261284}
};

static const float b2[32] = {-0.20609796589669513, -0.1779104400203006, 0.9493656365872034, 1.0254036849646366, 0.8944301226112772, 0.9560193949452412, 0.8802038365013584, 0.4968315205853473, 0.9326629591761333, 0.8880759722183135, 0.8203992910726687, 1.0285215693540104, 0.9401904133696204, 0.7648064954488024, 0.900025568625077, 0.8827749956055805, 0.9790423809413173, 0.9019998902358431, 0.9958519856268544, 0.8874570463165631, 0.9494078232089253, 1.013800668468951, 0.8034392394817188, 0.8129495301045205, 0.9351589312376238, 0.9342066969278956, 0.9467396689170365, 0.9363329483162367, 0.6042273167491756, -0.12100092005333156, 1.0186340213588811, 1.007343391436412};

static const float w3[32][16] = {
    {-0.4634974164549004, 0.2223885296562377, -0.06308818542823062, -0.3962847000646209, -0.16719857144582295, -0.0041191656561447255, -0.6061621377397867, -0.005914007776047133, -0.09094906497807408, 0.006218360501003041, 0.19334406214993038, 0.270159804390967, 0.013854973929647947, -0.04553382031486614, -0.2481025332811703, 0.046538948119944204},
    {-0.1075909358961871, 0.22478800481844854, 0.07112736409548254, -0.21651922274557647, -0.4143805845859278, 0.11006468929454405, -0.33225927966489405, -0.38997817906156695, 0.21405004257797375, 0.047810114159446054, 0.054707205850901344, -0.12985208602686224, 0.26291455878636777, -0.02915727136261117, 0.05783782514601173, -0.4228530047936968},
    {0.036856739574399604, -0.36669553987678105, 1.056612288359214, -0.14012315286008323, 0.9119178979534596, 0.9320453001470708, 0.8243074442314091, 1.0140825370777318, 0.8716763375370431, 1.0474819936799995, 0.9679619305236242, 1.3087185415105935, -0.19914133911318146, 0.026072051121028526, 0.9570275158848007, 0.47098405968565665},
    {0.13014342055761355, -0.57571551725978, 0.3166567292707306, -0.19626921967708155, 1.4610793188666764, 0.7903005285587604, 1.0187760416765714, 1.3526258600446979, 0.8601137712104229, 1.265976511101019, 1.504308156428341, 1.1010104669030403, 0.08107377952120215, 0.028720743323102278, 1.0472650676119941, 1.0188555551779004},
    {0.17233063378391217, 0.16784516893988058, 1.5152876828445, 0.4993023865440251, 1.0578081558819847, 0.9089243096258559, 0.9243919561772754, 0.7316786470351638, 1.058027629375114, 1.2759941997923758, 0.9434133784629424, 1.4425028955130887, 0.40653392710709146, 0.09054924455091087, 1.1164143394001276, 1.2800495674709258},
    {0.0035730357052917287, 0.12159418499032533, 1.1936871914295002, -0.1674394109623876, 1.1795294205480993, 1.1133908693053844, 1.0691784775630004, 0.6224449354211022, 0.7717150272382425, 1.0290659615849476, 1.1422118812463062, 1.4114241112747006, 0.2238462921980292, 0.08041742586663093, 1.1733838473728089, 1.2969791901835428},
    {0.03163178464672093, 0.42088117214414156, 1.0376820049992848, 0.10669615122145147, 1.0919931035004982, 0.8049702103173103, 1.3056394554116453, 0.9164886408093842, 0.7823723479485644, 0.9426622046468892, 1.020526000443331, 1.2799273118849082, -0.020090588268924504, -0.2561814237733444, 0.9031000028175395, 1.1424344364780095},
    {0.12012112300127811, -0.3777495303051247, 0.8954727093486543, 0.07739083218869085, 0.9276792276531746, 0.3131328173171081, 0.3306151953080292, 0.9312820491551247, 0.6344495197803927, 0.6098653926182962, 0.8592128046062488, 0.7908869681222522, 0.5823201225429372, 0.4459956448379201, 0.530390960632108, 0.22750450902710595},
    {-0.22620719315933227, 0.11385605124633995, 0.8561529537586603, -0.163329885649688, 0.988969134281058, 1.0815638756460821, 1.7018658576064036, 0.6975265460742934, 1.0649239368244672, 1.1240909195618871, 1.438767129003498, 1.1521439056980403, -0.015406720074358058, -0.35372961007508347, 1.1903112737389998, 1.2742234694926473},
    {-0.09920775191065398, -0.32204507651281344, 0.8531311691878564, 0.1809694197748608, 0.7845040647597459, 0.9395237222308352, 0.8863635357345391, 1.2281153063186574, 0.8194446599824877, 0.5812569922633813, 0.9943351021473933, 1.1218168956315964, -0.13244392169993166, -0.23397803635443468, 1.2956814040513287, 0.6450979687058453},
    {0.06157617682152917, 0.16737779263670177, 1.1205635150581366, -0.025115821023756577, 1.0146268004745624, 0.8641295569301962, 1.1776077135903291, 0.6902009799512773, 1.1072953308389972, 0.7701684954061828, 0.8404098587411871, 0.8346711933148363, -0.1097341417884843, -0.005722319605735691, 1.0815120146342103, 1.1897239334529006},
    {-0.344497106818978, -0.10259187468840732, 0.8504090923098556, -0.34884063830076023, 0.8606012298929466, 1.155082361620048, 1.5942987797077068, 0.8732637338870869, 1.0808347934665012, 1.225507491388991, 1.0916158396084779, 1.1871406415185795, -0.09547601690895263, -0.015556558141055945, 0.7118502590843474, 1.0008541448138517},
    {0.5098751143591294, 0.00994732175527228, 0.5814273331408828, 0.03876584404026769, 1.0161961894509735, 0.8510296638144229, 1.1999470158877792, 0.7119501868356278, 0.7811612439506079, 1.295659610805833, 0.8783385505780857, 1.1291283319869323, 0.24735826608376918, -0.08745466788979055, 0.7965126861882598, 0.8431207469603541},
    {-0.02088183498426634, -0.2263188590289915, 1.1154099163433235, 0.256906239141077, 1.051130600321713, 0.8790926322066234, 0.9571066812721333, 0.7484997782244787, 1.1666672013560766, 0.5713402770286798, 0.6565808106697275, 0.828712020594887, 0.7470542171878214, 0.017817674518757484, 1.4050466659348118, 0.8581334966671826},
    {0.1565310426090645, -0.6608387861551323, 0.5914325152649429, -0.06663784601710755, 0.5380597503729995, 0.9954815359440585, 1.3018206077785064, 1.0282281924663603, 0.5889668997935159, 0.7424719150978915, 0.6737089447361159, 1.0289914650573186, -0.16345424824312263, -0.3245354707209121, 1.042534357888295, 1.2240533972934406},
    {-0.5550756186990037, 0.2876454036049215, 0.9989165250435218, -0.2781227686069785, 1.0067039879709412, 1.1897321976728756, 0.9766389993865395, 0.9485371212662864, 0.7687580037932279, 1.14435891166132, 1.0695422221610829, 0.6977274222622968, 0.2141710090753295, -0.3548943294029842, 1.1907367278378496, 0.428854023523453},
    {0.0783782997146067, 0.0988092691814301, 1.2413600584455622, 0.15368779172476899, 1.194159806767114, 1.3657804980901642, 1.2377355866239685, 1.2290512134497644, 0.8596823765559624, 1.170430656034935, 0.9651247176441001, 1.1091396725003826, 0.11361760446647826, -0.019539825798996657, 0.872690114109762, 0.7470500055054964},
    {0.2923913407272835, 0.028805228828981563, 0.948870224860896, 0.23132786025910915, 1.041516738337253, 1.4144985233032286, 0.9226295223601294, 0.9267733125561621, 0.988022375338473, 1.1876695281559397, 1.2727787873999339, 1.2944682010222204, 0.4104616445283728, -0.057446891508701414, 1.3015492678606493, 1.4156007642852027},
    {-0.21582764041827782, -0.06735019455469721, 1.110983486435003, -0.290130750290911, 1.0957949399154856, 1.0794702723502079, 0.965178054665494, 1.1271744026976174, 0.9915523400132669, 1.574206447232733, 1.2558662909886142, 1.4009122357145054, -0.37182804797511304, -0.22246950838090407, 0.9822068769307992, 1.3443509127253213},
    {-0.021292691066632185, 0.22146508083622687, 0.8201345543492174, 0.6180544395101317, 1.1685552336607696, 1.3220983935916824, 1.2735135956502341, 0.893015565675025, 1.652624375181763, 0.5385094761292516, 1.0808872015095807, 1.1250151434291813, -0.3915476205263728, -0.04298854436668469, 1.2807617712225814, 0.5902863573679183},
    {-0.3246434018509046, 0.0402104871845411, 0.7785858559008654, 0.33820787372376915, 0.9469283377503848, 1.5974009907315005, 0.9773902840795368, 0.8941221804897372, 0.9509378904203675, 0.6212658063008534, 1.4982857702841177, 1.024899892453952, -0.11808639881453714, 0.15635490363744414, 1.2359051573816506, 0.8576052414502503},
    {0.034151694536128, 0.11854546200415672, 1.08478193633028, -0.11175182800677061, 1.2108313652459797, 0.7862693284162973, 1.1793914875714624, 0.9304109825868176, 0.9198043515501698, 0.9828699780432948, 1.1826108284176757, 1.0179584923507938, -0.21057640048495202, -0.49453598387026926, 1.1396349886978652, 0.8037900612754268},
    {-0.14414901484672932, 0.0948453786925257, 1.1157782096959403, -0.2730649956909657, 0.6056711597000348, 1.03712074894755, 0.861729029073811, 0.4899761526669628, 0.6209571331741168, 0.6899306047320014, 0.9746980952582825, 0.6931005257946417, 0.21029009305951604, 0.19965914582467084, 0.7743350284561781, 1.352670286400931},
    {0.06427241847339049, 0.013972716704484014, 1.5972623721523955, 0.07147520614552551, 1.0704952762626165, 0.3722840133468442, 0.9369503231092702, 0.8053034666435213, 1.295315285564513, 0.8849702891861788, 1.276823852308643, 0.7743090950419059, 0.51140862328021, -0.27113852529177795, 1.120438516441371, 1.1081220301040409},
    {-0.15221616754068276, -0.30393383204796426, 1.2085235224725852, -0.26300315720023554, 1.0755748016601239, 0.9877648305188385, 0.7623128165819871, 0.7649377495965355, 0.7636737399270523, 1.4251034927702433, 0.8421820293616151, 0.9061113198878075, 0.0019490364130172809, 0.010723745998671394, 1.1627317297509252, 1.5269847128889549},
    {-0.2590226273124267, 0.16136995469010568, 0.6954833472886808, -0.07958480771766123, 0.9658638391309401, 1.3243222882044754, 0.8668230513494417, 1.4784468995883466, 0.7778786756406273, 1.1044863588032288, 0.7437436327628164, 1.0567994991044285, 0.4343485988838029, 0.24443459263812553, 1.4164608311850908, 0.8535673871759334},
    {-0.13962706598759916, 0.03231430702910468, 0.9828715794986924, -0.036817914476721815, 0.9294570645615868, 1.2401747234417546, 0.6920466644065085, 0.8958267904009686, 0.9877416032611432, 1.0807620511056863, 0.7688707080084229, 1.213582252477523, 0.20816379448070907, -0.4151680453712601, 1.3511249839148032, 0.6474173302498156},
    {0.4909503816529603, -0.24663750442474128, 0.9492549627727855, 0.2541427626819134, 1.0230890138308706, 1.0448871273472806, 0.5345380420116881, 1.006108212009714, 0.5835971426468499, 1.0538119004310393, 1.0689142451781968, 1.1950620400003182, 0.13126988774054557, -0.34112954408614765, 1.3843906301124558, 1.160763463185185},
    {0.42365728344716297, -0.41002400359675817, 0.784340389726547, -0.07194353462879048, 0.6397972729809185, 0.6527682631596066, 0.8348287631343568, 0.5053089864052231, 1.0921728284537437, 0.5465180408892376, 0.841228896502973, 0.6583178985028854, -0.015399499188961741, -0.1571972228191747, 0.4988096312302845, 0.4236615883366125},
    {-0.20886379496634017, 0.06712312395234206, -0.06059034710136218, 0.0545932020808827, 0.517397301430274, -0.07250216330549612, -0.4585539119491954, 0.08591556322581885, -0.15702835167459675, 0.0704548632099193, -0.07450935293957489, -0.16771182450624883, 0.0037905372047936487, 0.05774607485318181, 0.0023660764733886867, -0.1978518323433782},
    {-0.32359972397544284, -0.13092513895773072, 1.208902723481213, -0.48075240550815534, 0.7113274831747696, 1.3298124816140195, 1.0829905636367643, 1.2538556126226346, 1.0059252913004133, 1.2246323227475366, 1.2425728442898272, 1.452811888907498, -0.05673244007010838, -0.031301731007810994, 1.1087711814315044, 1.1611802905984772},
    {-0.027098297408014827, 0.08798796426173887, 1.3367099648451766, 0.09295327027663998, 1.0412988517040966, 1.2810332857603937, 1.1938050219512788, 0.6349467587077225, 0.7722947426304537, 1.2191482630115222, 1.3109834957378126, 1.045019913459835, 0.017100230572312254, -0.001193261473114966, 0.9789035858184614, 0.6799976612616232}
};

static const float b3[16] = {-0.00880905021424807, -0.030414399733342395, 0.7582152087745087, -0.07009619443016078, 0.7336440712118389, 0.7488794661242942, 0.7354467409913404, 0.6480554052947191, 0.6127124688026115, 0.6888949238437113, 0.8046363365510415, 0.6731372313969903, -0.015556112736459413, -0.019819999018199985, 0.745170469769161, 0.6231853728883545};

static const float w4[16][12] = {
    {0.35002806145440674, 0.21062887009150227, 0.6130994695720695, -0.08975703743470408, -0.11715001208327429, 0.27078793913754806, 0.002239291728241719, 0.1489536813927982, -0.6951688793261775, 0.20283200297469037, -0.5086196208252634, -0.1849179236701084},
    {0.2612862388832245, 1.151605182699318, -0.2825418771781651, -0.18396028798718245, 0.21707489239319683, 0.5115704041919169, 0.13065862934451553, 0.7993170340471234, -0.7472221802225969, -0.2733620393529835, -0.3089806794369874, 0.3423595004769755},
    {-0.7894226608043944, -0.6110977860584196, -1.045993253614334, -0.6903151945295124, -0.9499982266629826, -0.6029606958170303, -1.2528496946437975, -0.5143681975232027, -1.1094055576401984, -0.45239455953344365, -0.8772430914252969, -1.220619245399188},
    {-0.385993740179963, 0.34851825902935735, 0.261916462565884, 0.590507453603768, -0.26048125033919983, -0.19505852375626564, 0.3030441284594993, -0.6134292308597012, 0.2617670600665288, -0.21894296081596767, 0.4320656990178471, 0.2587501287973138},
    {-1.0084314717864615, -0.9190099714242188, -1.1988998206020482, -1.157608894883729, -0.5135034588553763, -0.46349517020007247, -0.9656179226363782, -0.6934755383837597, -1.174504325327391, 0.04190112052076411, -0.7185776894929092, -0.6977279193158938},
    {-1.512213559753753, -0.4478001129717519, -0.7694225858669788, -0.17487522888942314, -0.9820970366521597, -1.555296500622015, -0.5870121639565081, -1.2915286613313657, -0.8083808233323992, -0.6259849824853569, -1.3807722470413506, -0.5493918090241143},
    {-0.30613847562637225, -1.1801536499330598, -0.645935726090562, -1.2294011994646006, -1.55918837641516, -0.9049573127511042, -0.24868451283768409, -1.1821074479763813, -1.3686125457502218, -0.7390998398513491, -1.167579734421156, -0.7210543019483268},
    {-0.9473553092194477, -0.9189296910462318, -0.831166388152934, -0.35979737247254534, -0.6598097411900902, -0.8087578568077759, -0.7273302512782684, -1.2964026703355251, -0.5362880655994559, -0.6964401598613997, -0.7641723094183038, -0.9367737974598679},
    {-0.8550752479844553, -0.965234942017376, -0.881935590612614, -0.7946245068585945, -0.3705513162143205, -1.70879613568613, -1.3899240313794254, -0.4849133859860067, -0.25112308299577596, -1.3422595458615134, -0.6927120642812438, -0.5909358785777694},
    {-0.9860358121465577, -1.396504525295218, -1.1622125270081696, -1.0023630551722325, -0.48618157181767935, -0.8349542055169965, -1.4767674105672581, -0.7777393496495719, -0.44842393978480927, -1.3241480086590627, -1.1506139188309445, -0.13328396703970274},
    {-0.6114733685198424, -0.811718830194724, -0.8328228144975387, -0.534868319752649, -1.506045145658868, -0.6608239002872255, -0.8665058092031505, -0.8987114023671161, -1.0420795398977694, -0.9756047002608796, -0.7697794498072315, -1.6484544403775905},
    {-0.7684679160315614, -0.8850165641988098, -0.9262301650364771, -1.2179524389567524, -0.8179540946515809, -0.6471800209267874, -0.5511251631133552, -1.1570095051575842, -1.1765266916272312, -1.211708086880189, -0.08301999776981185, -1.229022375351423},
    {-0.20591548136151835, -0.1028552171597575, 0.4412306565883137, 0.10509764068686314, -0.11684511703613637, -0.27075782231847834, 0.2444093709141372, 0.8759301114923753, 0.13489802784010554, 0.49686096001754465, 0.08273796807345851, -0.17020338780359523},
    {0.07354522415015245, 0.49339251254862726, 0.6725987046313328, 0.4933397493403528, -0.44406329998508004, -0.06757603756579462, 0.26160738811330353, -0.2158792861914499, 0.10162276794323548, -0.20099664201860623, -0.016062068279928232, 0.22834417466464266},
    {-1.2273747821743817, -0.4243527413587768, -0.5667614430135993, -0.8575748612152264, -0.8413737532577502, -0.8744077061037118, -0.7153230887251921, -1.0621205362123236, -1.13767512185272, -1.1574335515486975, -1.1804792187131417, -1.1334404057409238},
    {-0.6520402965008225, -1.1810323504856768, -0.7758519126533171, -1.540845516109532, -1.0835727155378372, -0.9107767255729156, -1.1076011138849737, 0.021378059872180742, -0.3601364165132714, -1.127921088075088, -1.08344444138365, -0.7040622362218181}
};

static const float b4[12] = {-0.3137059707140652, -0.30354932749303104, -0.2626758951439006, -0.37099612690266864, -0.3247716521940261, -0.39803561366445267, -0.3027970142112823, -0.32775622618967193, -0.3835014200481632, -0.4848114842712602, -0.2703394540578687, -0.30028728319944525};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
