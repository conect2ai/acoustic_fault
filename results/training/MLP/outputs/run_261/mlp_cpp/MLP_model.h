#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.49543069277236484, 3.4156945423397556, 4.133628149223264, 5.236149506424234, 2.3895774555893246, -0.3820660445090961, 2.1104390066843393, 3.2801064036279404, 2.368743026457387, 5.3358265467534824, 3.0396663934625656, 1.565589051343111, 2.5564875504017386, 1.2005004126035472, 0.9005594156660741, 5.307178085630802, 6.062900026595512, 3.2836315869237525, 0.33990072605109783, 3.036261111056296, 1.3637644771422996, 4.983375821402135, -0.8856681803774936, 4.848867594723123, -0.25032848992183276, 0.2242378523814476, 2.5504915082549444, 3.87363931602783, 0.5846165580716773, 2.2357616607820363, 5.188878285480894, 2.066498301742667},
    {-3.476538439018664, 0.4281571337551202, 2.243704082497753, 3.225475635558315, -1.3990181445466918, -1.9428186937386425, 0.06095049343236547, -0.5105780438720376, 0.6574410256264894, 4.6588529438768616, 1.1610262054942164, -0.8521741152106546, -0.7011497190270078, -1.7113947961325329, -0.8873965629558026, 2.140197154150821, 2.5622483783861165, 0.5610782346179334, -1.775038562532758, 3.8711667200530613, 1.4110613758865065, 2.841918007787593, -1.5107854010337227, 2.986992509362923, -3.498477638675344, 0.10092599815315402, 2.503628338901425, 2.5254148598500485, -1.7507286746151562, -2.440191169357925, 2.197455067480019, -0.5023075629997705},
    {-2.596121534526707, 0.8753588310778374, 3.4917601187286755, 4.419912440684704, -1.7964744239052735, -2.653599654846037, -1.904736536104927, -0.1329083722310976, -0.551251837421039, 4.7505777597055605, -0.14696867151931103, -1.5063775503918078, -0.6915225549987802, -0.9394001528139588, -0.8115598360416666, 4.23028790623438, 4.574899464482751, 0.22736643815597155, -1.4856429897736494, 3.171264832169373, -1.188290044907821, 4.895675877489252, -3.737912708836815, 3.983035499799215, -3.216764922822745, -1.2168574927542575, 1.3975168527324104, 4.589011801530634, -2.718360201037159, -1.346868171316746, 3.6748963588226244, -0.8892129588650642},
    {-2.488802769593051, -1.8995519589542686, 4.665591746382545, 3.8470827245029513, -3.0975949576501827, -3.3330481708520074, -3.570142715896259, -0.29804160648492606, -2.303495609842927, 3.9314435076018768, -2.060906436659848, -2.350985578882821, -2.3444028080865356, -3.5792785443880772, -2.6178765923097123, 4.425750714807502, 5.104548025517494, -0.4850270830732694, -3.5540700942730483, 0.5547175917289748, -2.2443923518973454, 3.3163938497821275, -4.2946964360808355, 4.069123973516441, -4.529652840809171, -2.8803157713133714, -0.44027122336013985, 4.055529906754128, -3.8348218022339595, -2.7736494822206845, 3.5848897623200537, -3.400833211663193},
    {-2.433440571124532, -4.069650253060876, 3.4932687301857386, 1.0662861773725216, -2.2065425979385553, -3.429583679761239, -3.0198318917405844, -1.9929544507599055, -3.429911525941922, 2.1859997793496806, -4.400264012841133, -4.609592393705126, -2.9448709486870728, -2.613217799660153, -3.0470999500348657, 3.9316556769195827, 3.75451147944184, -2.101930800830218, -4.428484729468701, -1.3995952405266359, -4.283810242959398, 1.669228320673304, -3.276709869816658, 1.1526367479642228, -3.3683971856398025, -3.1283134716902308, -2.640560924465196, 2.8490363655074473, -4.801427522671628, -2.0746108717953615, 1.9468918116135483, -4.387340828336472},
    {-1.525952800059546, -3.136925363690498, 3.3321207856283657, 0.2752287227150261, -1.3753352839508006, -4.148442481079041, -3.162093992670571, -3.443721418370573, -4.50225458339234, 0.6679266302446615, -5.181010965539706, -4.231812861823999, -2.8934609443670745, -2.9253977055795253, -2.3266898388005055, 2.4496376814306973, 2.5378962630410826, -2.4169690144966123, -4.904834016509223, -1.9746951013344183, -3.6999475605979537, 0.1466330676735456, -4.661592305182506, 0.9202626849241549, -2.7745769704647367, -2.7932571258460537, -1.9967711678106546, 0.31125926695785705, -6.013749343370145, -3.0652796196685292, 1.5441717335191414, -4.008544263133044},
    {-3.5343639493623606, -4.452984940313361, 2.649700159105535, 0.058277970049354616, -1.8693806678740459, -4.2236326620519185, -3.435294868337147, -3.920316524396927, -3.759228213387319, 0.8948331751507006, -4.46017038947699, -3.5164779601939933, -3.9752556471511453, -3.9637258850677934, -3.4838414669154276, 2.113157367525191, 1.1219408348203626, -2.485911040812549, -4.45731574160041, -1.9885145772049961, -3.3615144302361943, 1.2351892022557922, -4.23552871672843, 0.7091789411010587, -1.5267225943241354, -4.04456270256903, -3.766810103614948, 0.2507715930678329, -5.399813264380936, -4.590418372846724, 0.11937026295231623, -4.702759935409673},
    {-3.763786589423259, -3.7628888047790086, 2.7870288408970834, -0.6101469654970229, -3.1052714742391863, -4.344675171453645, -4.037154787524065, -2.6293865599448245, -4.250606776965091, 1.7156286674241144, -4.955952467789803, -3.956049443537155, -3.1098509086111212, -3.5530432094986275, -2.372380866015509, 1.687956799325251, 0.45049890106949797, -1.4231148136392497, -4.28659131407597, -1.5608425803561508, -4.721436228497145, 0.5888777693340342, -4.804385861146851, -0.4694876492550499, -2.3031511179138406, -4.715140444085243, -3.3716300681525326, -1.1396005952840036, -5.735481871169234, -3.6605706122228763, 0.2135403531541937, -4.132423379424891},
    {-3.4495856217472354, -2.3056886619722277, 2.1620008243991378, 2.113333286180733, -3.264213302275307, -4.192891737688715, -2.3653054829398457, -2.6949820013716965, -3.5360961280126895, 3.03277045100108, -3.657664156383556, -3.276137656010576, -3.244833288677424, -5.022509974891571, -3.24643504506605, 2.5893185885003076, 2.372904697262196, 0.07546268662838927, -3.1948803925765774, -1.472048724863797, -3.290508921990692, 2.0195826963336114, -4.633873621354737, 1.4941657196253557, -3.621736253077188, -3.0743670515074304, -1.061387747540168, 1.5675738660101703, -5.563984682112812, -1.9336512857643635, 0.3725634873698139, -4.385547754919212},
    {-5.0058411076770355, -1.3526334183434086, 3.506804413928421, 2.535042503378011, -4.148084617840329, -2.911045179311761, -3.3661884413009764, -1.0537169007089602, -4.18867379618418, 3.8622664558910196, -2.5126511750078224, -2.78140350773453, -1.3310105165587955, -4.476231989244392, -2.849574425036509, 1.3659864222864357, 3.522078111625579, -0.6917145124936362, -2.8030675286268827, 0.3157005132468383, -3.0309780618966284, 0.8018957618414743, -4.67216430542347, 1.6992787259393995, -4.763035465511624, -2.131866508745641, 0.09619710686865286, 1.183224530309483, -4.416312339979008, -3.372092534775552, 1.1913804047355594, -3.3463984116814944},
    {-4.68240487919013, -2.1985979354977316, 2.18839738405664, 0.8296223424426686, -4.883469204490567, -2.9620969441589704, -3.769491879326349, -1.6863178637913943, -2.8871132580861256, 1.5450354699110154, -1.8685158084250633, -2.884348724019651, -2.8046714035683444, -4.539002100898179, -4.087464476801087, 1.214736329293301, 0.6324886773175626, -1.8228575549486046, -3.314426983440217, 1.0613356993071221, -2.365071256104794, -0.410518388279889, -4.8846532800941755, 1.3166560077953318, -4.617680429130069, -2.826968867576568, -1.2446525219015356, -0.051530930886247356, -5.212171891432288, -3.4381998176960473, 0.07274902312303426, -2.992469089050646},
    {-5.3115824209637985, -3.5223354422472806, 2.117700504765486, 1.400025088584285, -4.437007989190148, -3.687601481065035, -3.999836172766451, -2.005492367795718, -3.6671948930709055, 2.2523228521728194, -2.855676682950103, -3.448480786394115, -2.175714325708787, -4.669710114942885, -3.530344000354346, -0.7827980325701029, 1.1695708423008369, -2.0834736240715532, -3.191009128998917, 0.05941914504968475, -4.085333071042532, 0.3976857029235458, -4.0783316746324285, 0.3327727175857212, -5.2856473997170434, -2.5132493712263715, -0.6953201549943091, 0.8444494843504144, -4.589271805314234, -4.364741554384405, -0.8132971855257678, -2.4659308898955494},
    {-4.80385794846693, -3.119695262845446, 1.4429889511241516, 2.0038275086384774, -4.204627598262565, -2.579872143005455, -2.9496234794058327, -2.8629865951677176, -4.316048514924509, 1.453986185015595, -2.0190516512619743, -3.5857854215963227, -2.1439158756097103, -5.2117891795279805, -3.6589514886851937, -0.48356362638123174, 1.6615832058385804, -2.0070480966592354, -3.6255969988880974, -1.0903933574504365, -3.2277578765678814, 0.36287260973151836, -4.293196996636316, 0.06765769775712636, -4.006814769552525, -2.776541526557544, -1.2740534942071189, -0.29826740796842355, -3.996038007241258, -2.7602004963001323, -0.3419078869529893, -2.4866821109901256},
    {-5.403795915378477, -3.627067491234853, 1.6649609922042898, 0.6678973838537536, -4.100890353980915, -4.812611736504791, -3.727739371367219, -3.142691637682984, -3.6267669616840563, 1.305109529456984, -2.548430561205123, -3.9889291826025444, -3.741229885905106, -4.6773314551198, -3.6119705987598887, 1.0506023727150309, 1.7241196788767448, -1.3270021488802959, -3.720123299104771, -0.4030711986667212, -4.187567365223605, 1.1937272562033323, -4.717038644335085, -0.0015871760224229464, -3.97607289624513, -3.1471642852206254, -0.7468537432180687, 0.22538093177799984, -4.51295825621218, -2.568855469569242, -1.3499359167049023, -4.357688452684872},
    {-4.907483858835555, -1.9119599827977676, 1.4833706558125197, 1.4843728919469266, -3.1386942881292956, -3.6241131809633353, -3.1610941407657327, -2.1417559976065332, -3.823277943588487, 1.7190323172477768, -1.6546401760421183, -3.2488979194166117, -2.434574821653864, -3.780291849393097, -3.8694598623246304, 0.6703877735404914, 2.075513771906733, -1.1333938031865067, -3.4190319931366058, 0.07517049559297931, -3.163321569981373, -0.2092319638189252, -3.3117206559386045, 1.2492162560008009, -5.009618422052412, -3.264759771038396, 0.04124195543282422, 0.0572282028052212, -5.112145006207066, -2.655728272785765, 0.06853281492851435, -2.7143039753426956},
    {-5.227222287505308, -2.7312637878487287, 3.166284619154563, 1.0930042097477692, -4.200479351163866, -3.0036064266894456, -3.440901928369829, -2.04903334746744, -4.482124429191992, 3.5036856324980747, -3.4066868618769632, -4.813544973591343, -3.000432532279533, -3.492148801618793, -4.067729038604766, 2.3964080989596006, 1.9064482770734397, -1.4139884159552651, -3.522157302457096, 0.8958090361915931, -4.16502207348311, 1.4194937123900684, -4.04847143804933, 1.1530551322335056, -4.532867676596001, -3.4407232051268646, -0.9728795438447193, 1.891334627311994, -5.757145255079775, -3.5765630588254815, -0.18914202587132814, -3.1993327616171205},
    {-3.5360244300431694, -3.1014651548552554, 3.39926728944823, 3.2036109389346787, -2.069832592392037, -4.0811179282509435, -2.9384185583376135, -0.3878398316964169, -2.251467263205225, 3.454549182627483, -2.095127665681161, -4.228524720214116, -1.3951834184852332, -3.0372346937677595, -4.0138724926282485, 2.8023071631137846, 3.1388724740836644, 0.31457108332310046, -2.3639728814064664, 1.0709417487165918, -2.82224951833535, 3.520448003375414, -3.6742195910607958, 3.3060796583317362, -3.128437502986332, -3.979055237320826, 0.42864252741526665, 4.159677124715415, -5.054016889905877, -2.5199655402206576, 1.6605585045591826, -3.120239539083681},
    {-4.000877710809959, 0.09541377005688037, 4.757157491875221, 3.321612501409239, -1.1228551323720573, -2.7028181439811085, -1.9856409961975607, -0.5565108052466662, -1.9853933806735033, 5.350484822206064, -0.47054043397250067, -2.456871240689066, -0.3095018639438648, -1.7816306995660542, -2.6187340637481507, 5.058623852305771, 5.311543972577688, 1.0676790219844212, -1.7701772741228134, 1.38073085537623, -1.6094856353958966, 4.127991401736741, -3.9388917076013237, 3.0866472104365057, -3.453948134631043, -1.836984937299289, 0.5615524872373029, 3.6375248692174185, -3.80101063771535, -0.5179332298803436, 3.0988103890337784, -0.9003680118169349},
    {-2.8844999803421345, -2.342894494222904, 3.076992945534132, 2.7327891741830506, -1.3202039313623657, -2.9627320764396026, -2.054297403215672, 0.4426754168580524, -3.200943127425053, 3.4450612451743234, -0.4668018298158438, -1.8254036639944038, -0.24942068693913885, -2.345945021595218, -1.4497598476117988, 3.9293318777355597, 3.615556650436968, 0.6181566849655787, -2.7400973632354675, 1.6309779906067743, -3.160042478065724, 3.615943427883494, -3.210704328359032, 3.1454795758401093, -3.462984357264425, -2.456632331217667, 0.7785473076004336, 4.041879912572837, -4.712765245844257, -0.26649870670232295, 1.420833839802906, -2.0773055339135884},
    {-4.456275049087612, -1.574432653395708, 4.37358904428237, 4.071394902399951, -2.0208503754750846, -3.7762393274524073, -2.650384565565764, -0.10261541333226167, -3.7445548520317335, 4.947858365569878, -1.1726113918493697, -4.268890661811072, -2.8875427552614923, -3.369743426000003, -3.33484222518959, 3.8671234418246936, 4.511128906600353, -1.0522586466773254, -2.5426279792843145, 0.38694029266103264, -4.091384515102721, 3.383098355139543, -4.728950471623123, 3.157086208234472, -4.005134871560607, -2.7223355551049, 0.9506560380840204, 2.953545508120788, -4.221845750048387, -2.3195262135785417, 2.491185933206771, -1.9657258244240825},
    {-4.618039375897401, -1.6144989901193028, 3.2663850235456557, 3.0390148751600146, -2.77165577210796, -4.02000410141812, -2.436740814240436, -0.33407424526792967, -3.4904964282058204, 4.271666840665582, -0.8648013981791093, -3.1917845656848725, -0.8611876458366245, -2.7111232950474964, -3.0821001123860388, 2.436198933037071, 4.955903513204945, -0.25257274849526157, -2.6595446683651724, 0.9425699437533936, -2.5649716835149494, 2.9337385612286937, -4.435246716456353, 4.262809672728709, -4.135517866588899, -1.1863820919767667, 0.27559144670753727, 4.315013995203236, -3.854273478808542, -1.8839568003005895, 2.148533709911022, -1.5419139550791288},
    {-3.1410063516130213, -0.8290261601234145, 4.839002628531579, 3.8954723399140434, -1.8266983446037173, -2.9190416103973074, -2.595341188108987, -0.3715693132853148, -0.15840453137443683, 5.52010847745073, 0.3233878131061181, -2.7339483624208274, 0.15449394895855453, -2.185843637370053, -2.967689012437473, 5.484957632099072, 4.3239448157188765, 0.455062019059713, -2.523438845939643, 3.267696224894401, -0.8498537016104698, 4.931534282812434, -2.5834973901435503, 4.115621159168279, -4.40849026760583, -0.7839681617359526, 1.1643283972161549, 3.9343913695347847, -2.2945597988752047, -0.7874444215087775, 2.5372345429347427, -1.7249986546052225},
    {-2.738331806153103, 0.8548905170923874, 5.371369435898543, 6.034631594688525, -0.6273645092585424, -1.397776617734149, -1.4452309699521897, 0.11160792145849982, -0.4140551585550961, 4.883792951333076, 1.7764464552023163, -0.9516652404221655, 0.17772518153107303, -1.4492287903438201, -2.5208592054115497, 5.368687637165325, 4.63263767771546, 1.4180454656038333, -1.595352776061963, 3.202562277676565, 0.6232428833486398, 4.720703768641302, -2.909519038311597, 5.532550243928679, -4.216025094935939, -1.4438869960340657, 3.687485044349237, 5.634124646728517, -2.1281764001207044, 1.058596439221413, 2.8997876961359785, -0.09261654198877343},
    {-4.494149198576851, -0.07292589685128303, 3.3710440743490335, 5.00926548040211, -1.4293025085162065, -2.796420159322992, -1.6580798814215787, -0.5316160878048583, -0.94816095454718, 4.258331666410781, 0.8171684430638159, -2.744080792728081, -0.7071132387511954, -1.524719782528159, -2.7125456376947166, 3.2974163325463146, 5.066274278361441, -0.5635301187589848, -2.5105863812473745, 3.007700724552648, 0.015410467518775825, 4.603606959639395, -3.2737855314368653, 4.121470684129461, -4.469204711250364, -1.0321752330411258, 1.096094437628787, 3.548254052054194, -2.0505389108335543, -0.384115242766976, 2.439573416836317, -0.5759507925682776},
    {-4.401032712346978, -0.3954840527950394, 3.7013662379439456, 4.588696022163091, -3.318954060048937, -2.336523591160673, -3.136371044715193, -1.236559650647771, -1.8891874521890744, 3.8800455788743005, 0.006596746788593338, -3.682737853529516, -0.8092049496183183, -3.8337147693245552, -3.964955366731025, 3.626235901688227, 4.3836766055996375, -0.16619664577806395, -3.3994515071049447, 2.0971302596647377, -1.3128057368589519, 2.3002326982158743, -4.672309624026763, 3.8366996251952052, -4.845846727850409, -1.0530900824427123, 2.045640193483824, 4.450934530334356, -2.6815175716012596, -2.9061158952660553, 3.1349515582198957, -2.1414209782295175},
    {-3.4230119742990537, -1.4866000359975535, 3.3229020065919586, 4.046494672133836, -3.163510120003238, -2.676491450787811, -3.16577379182593, -0.364096543332514, -0.9491744762464968, 5.116957234633819, -0.279169489142933, -1.9531264409553335, -1.7457491943273937, -3.2421422803371716, -2.1666354409055177, 4.033542678066596, 4.516422581796341, -1.0920778759901975, -1.6686086291832978, 1.6842899003853706, -2.442782303448821, 3.391169483913767, -3.827173954427177, 3.942141297787762, -4.617312764594675, -1.6510223207690522, 1.5156809213067859, 2.786263787557048, -2.1003565375348043, -0.8123802166280711, 2.421792835251122, -0.4677608751793222},
    {-3.5613420256844686, -1.3710401460771946, 4.678117452424086, 4.33969572739102, -3.253494757858511, -2.2715989971615795, -1.8481010844668533, 0.6725623852665784, -2.048174999334125, 5.48489573175188, 0.33545988196251153, -2.88329178672967, -1.3446816088660303, -3.064845311375887, -2.978836312369014, 3.165751426236957, 4.380575367294327, -0.9506339630628252, -1.2960402087553118, 1.2415267841576918, -2.078588164253638, 3.2913548188181307, -2.8850384887750073, 4.072136799156419, -4.576238978984715, -1.2820544343953706, 0.9858267462844469, 4.8422408616074994, -3.387170901030356, -1.1098157554177035, 2.3036860290597216, -1.789761179452114},
    {-4.00428926031716, -0.7042302569854955, 3.7977212234536526, 4.728160076034635, -3.0866641456558113, -2.0717994338136667, -2.719095138836554, -0.12886534541285058, -2.2883679542946047, 4.966922197234632, -0.2950206413429652, -2.5361977510274856, -1.885089070281792, -3.3717719014765004, -3.3761497329208274, 5.034002142221982, 4.613504906500823, 0.6312304752561803, -2.8412227136302755, 1.8514004217200943, -0.9567454321837927, 4.09940960536667, -3.5328866113190163, 4.499040271675698, -5.56386604438487, -1.6925283088171776, 1.7684425054909128, 4.098572490793399, -3.2824563335334083, -2.0356793005576805, 2.2244979182075784, -1.1739016094304637},
    {-5.191578145298221, 0.07298440703382594, 4.170135968146457, 4.467311433033897, -2.125639514905839, -2.1818452848990932, -2.3430088855246605, 0.5218066033906607, -1.5769076849601271, 5.128698888761646, 0.11008896552562715, -2.8539589750931444, 0.23952972311940693, -2.1302330764510518, -2.8993682068175124, 3.394803107147093, 4.919927823369987, 0.11545498910283586, -2.919219206717915, 2.212218652321911, -1.7135841545467874, 3.4197795234775255, -2.8358255748046375, 2.9138708985708046, -5.241035061359127, -2.1130988000238475, 2.501045729460008, 4.977677031807075, -3.7510996914809573, -1.732677248793163, 2.535208257766785, -0.7995432235809824},
    {-3.450026476421893, -0.6608424000910033, 3.575574575144286, 3.6856722696590487, -2.9975976588380018, -1.4494711060446968, -2.100417715512794, 0.38603193645620765, 0.4947160715283801, 4.970556575098325, 0.42200559510493474, -2.4673518493200537, 0.31428192326766224, -1.5577270997301467, -3.7055692068985318, 3.896344491699774, 4.477006864998406, 1.4630725678616212, -0.8936473981444922, 2.8595646601604554, 0.12347361787551267, 4.655276082546967, -3.431710237989786, 3.1549243901626616, -4.976755154357563, -0.39114520701079136, 3.1759297892119767, 3.3951856173603834, -3.057603787824905, -1.2288873366640314, 3.727797271843797, 0.2944481335681551},
    {-1.678754493966173, -0.3015847808339016, 1.0110562730691068, -1.8553452561684354, 0.19419603188982032, 0.7248265656436397, -1.1872932120804591, -0.5181935463581958, -2.0935272588851523, -1.1033612404963682, -1.0248943894973699, -2.2097212351031943, -0.9437924068810872, -2.164837492603857, 0.042223038531178106, -1.9952062853921084, -0.3437294022145531, -1.0038561530052021, 0.5578688331238463, 0.5531218108703122, -1.7329428941177851, -1.004239175677303, -0.8005469645256661, -0.9000884979429534, -0.10860551512101359, -1.042317274583709, -1.1374163760072689, -2.3402087557905955, -0.37011164543319874, -0.984275068976791, -0.01882514672440003, -0.17280276902670239},
    {-1.209813523182861, 0.9911803741154579, 2.355026490759933, 2.2122271449038395, -2.2755133164558785, -1.221813344439916, 0.2708905212516748, -1.2409461176696084, 1.193066529120046, 3.0509151337436764, 0.2732228527688447, -1.353089612872677, -0.7536220085740014, -0.13331636263220348, -2.0101535566347497, 1.810992435776978, 2.85415604985621, 0.3663027645646658, -0.28582347032841426, 2.22991372406558, 0.5118809276607795, 2.2741387292391617, -2.7980775940237743, 0.41775782402211353, -1.9455373543183718, -1.452789364436129, -0.14926201430115796, 0.957905329154058, -1.5291785382539838, -1.3511635011843333, 1.2087383394179356, -0.6281752202346318},
    {0.3685660420113897, -3.5124912193295392, -0.501906882609467, -2.0065824662940703, 0.8685657479952217, -1.0267504410088562, -1.1802405299155398, -2.4943525087735443, -1.1599748261940799, -1.5272074874080341, -2.5457634259945796, -1.734610145332718, -1.3831639887149467, -0.9486614589690122, -1.6803141289021837, -0.7035266433762494, -1.7947000762712524, 0.03023363280852314, -1.4863735015285222, -3.579717957517139, -3.9521711543426314, -1.753320441884566, -0.3984258632880227, -2.3954192393003004, 2.003407036338018, -2.9972452416463744, -3.4713613623446635, -1.3791554501025214, -0.8691409505015685, 0.3294383183792739, -1.8833052239155914, -3.285117958316611},
    {-1.95492536392646, -0.9903575741978224, -0.3484389272465653, -0.6416066543052649, -2.093945119827555, -0.6424047475805296, -0.803510587149614, -2.222283748920456, -0.6206455812423161, -0.646324300255739, -2.7609681468454865, -1.6380496673411362, -1.9389483506735101, -1.433769601683962, -0.645850251423932, -1.2699954199623116, -2.1670472246697567, -0.3776265414165199, -0.883382899430809, -2.554852689210142, -0.5102830908694422, -0.8543481417072226, -1.411530013536568, -1.3277939488315593, -1.2048010739974728, -1.2684410982765602, -1.6414499142766301, -2.6145082483178506, -0.6523343471292928, 0.34829935794192424, -0.008914384613830319, -2.0205148605909438},
    {-0.5695076514360878, -2.126496217367736, 0.8948955193646057, -0.8855011263389564, -1.480877355941102, -2.6728163728325316, -1.5028995370237967, -2.633437222464827, -1.6724698689748225, 0.16942740341016213, -2.959361887793598, -2.5771519404888337, -2.5707530965568868, -1.3525650618140033, -2.221793257669112, 0.2628707072922036, -0.23960717065441473, -1.9422542225671113, -3.1829664218456766, -2.057915683063185, -3.7781437058861407, 0.2702406664283185, -2.488940875412586, 0.0003199438663312846, -1.4432444333514522, -2.0471329459711485, -1.0809131732430626, 0.024324220993001376, -3.4753586073759397, -2.3899959178758414, 0.1363398120097036, -2.49697853356731},
    {-0.9317536814288624, -2.787164968861981, -0.01576326310888199, -0.9579579144445906, -1.199399297731156, -1.1713802499432935, -2.3668101220784465, -1.0256584474240857, -1.646666553947839, -0.6074523208100483, -2.671113011153296, -2.565345279079144, -1.237202066402256, -1.8650894819041284, -0.5993238938223009, -0.7381354160328295, 0.03916120405518945, -0.757569077544862, -1.967411304719974, -1.8564839614697066, -3.022434060861003, -0.3784191023367624, -0.969575544091138, -0.9653834410637796, 0.002446110865046936, -2.272012800685151, -2.237934133519728, -0.06401649726258565, -2.992135211277083, 0.18556645301187003, -1.4396998694719165, -2.194685950163246},
    {-1.5148762147204253, -3.3095475559230234, 0.44516810511441335, -0.4009213119718589, -1.998840882569244, -3.0490541016440575, -3.1194369661552175, -2.052897172171629, -1.030356621213444, -0.154783512213505, -1.4645263950783718, -2.42494276526385, -2.0639830568813546, -3.1199595170883545, -1.664059901430563, -0.8709271353328408, -1.2233513718476305, -2.1893892274808255, -2.2418145205535116, -2.0810780425683033, -2.5118104888398194, -1.0602113868593612, -1.013693220223833, -1.4431898416365687, -0.31122905827063574, -2.946541655973594, -2.9132648167027497, -0.029868971027890136, -2.5404029953444853, -1.437792894471634, -1.0655446836531255, -2.0575562841308543},
    {-0.9719084592261754, -2.1457843484184735, -1.1126474325147084, -1.3370148123745051, -0.7598379477296628, -2.8043670185121403, -1.2627010811021455, -2.8708896156885704, -3.3432203924639183, -0.5097083522138, -1.7574549404634503, -2.736010270392029, -1.2159639389671681, -1.7980996748137512, -1.233837033607434, -0.8749249825713704, 0.09878561527468362, -1.5513924618262434, -2.1002579699953046, -0.7165384112268451, -1.8752835858849446, -1.3447862241287478, -1.5987593432893628, -0.23136784806461963, -0.440374055794581, -0.6955652726479495, -1.9754650114143748, -0.019117679037748202, -3.511801440437047, -1.796538686118576, -0.9324527770279741, -1.6640573557057428},
    {-0.265797030568949, -1.7454565284313168, 0.9588099073437373, -0.29428793437993084, -2.563446530576447, -2.567120940325231, -2.9513375652421754, -3.1945508570200887, -2.7772161117178435, -0.5693026129286901, -3.1198962078074715, -1.8276379636750864, -2.8717441996248025, -1.526475077300773, -1.9398689256989363, -0.5808101782123467, 0.26863264504921286, -1.3096996655348863, -1.1311340522486841, -2.106559091775059, -2.2287690520421806, -1.3447605777237643, -2.41581596572032, -0.3257101853699491, -1.1889623835859369, -2.631255793856809, -1.1245424890136393, -1.9616293672031895, -3.6140356686407666, -0.8550246517862369, -0.9793023182115416, -2.9915529825064295},
    {-1.000036700637625, -2.6067099816388315, -0.27760879808144806, 0.9699834167917143, -0.9058830511492105, -1.3708430487563386, -1.317421795118216, -2.454643332716965, -1.8957355997302672, -0.8135873660475044, -2.3899002051755804, -2.1998549428974123, -1.426574315338041, -2.35789540176474, -1.3322427455488004, 1.0618316295605832, -0.8630653489325729, -2.1330620932195496, -1.7920169010866136, -2.5442538926719553, -1.5711877974418036, -0.1244015858578207, -3.1254628369564283, 0.3000434912030544, -1.383834181472749, -2.9888548626380516, -1.79480319021821, -0.13970536000389944, -2.1591187043770153, -2.0497696492732462, -0.15179959554520692, -3.32358838364003},
    {-1.9535117716741828, -2.0243682025591494, 0.6783580202839252, -1.6908862588879874, -0.6718875514129219, -1.4761583664297036, -2.5003143775151795, -3.495793816244816, -1.0433740406362981, -1.5169091874652825, -2.3962903319245323, -1.3773809100460066, -2.362062114182951, -2.3881015270066857, -0.6632309222354921, 0.28011019882170557, -1.2665764876225842, -0.35395326092899054, -1.394342003759561, -2.631730936147584, -2.9518250506279813, -0.4875135466396105, -1.4358759094129279, -1.9329421308345356, -0.3495331165101015, -2.185458360065784, -2.945946524437397, -0.4376332631860966, -0.7909143501396255, -2.8718521692579273, -1.4665218906090174, -2.079178393732609},
    {-2.1490903497952503, -1.5614285291473309, 0.7147488558555185, -1.442874701448632, -0.7866624608946375, -2.1571346010312342, -1.2052425105575009, -2.4872293369177587, -2.6723556665583983, -0.7173535662046018, -1.758385621946138, -1.6662475788944153, -3.199831736693972, -2.0179735237162295, -1.2430736113922345, 0.1722255471680241, -1.527263543329895, -0.0854970025517139, -1.883433225398354, -2.3362611350674114, -3.656326615626245, -0.058466870136662664, -1.9221087816530054, -1.4208770388830334, 0.010081539068000567, -0.9425172867645398, -2.802966596166211, -0.7215120901392663, -1.705177621824116, -1.2791639088244084, 0.33753046232961553, -3.283440381188491},
    {-1.7310414401762457, -2.869841556026497, -0.35689683505560643, -1.724936084846881, -0.76496291238669, -2.6522407404305026, -1.7548932697415427, -3.013842881411624, -2.2995698172473533, -1.05402566890873, -3.5935357852472856, -2.7501019785557097, -2.9849525822257377, -2.249588467394647, -2.0909300852897874, -0.22334740724480623, -1.2198490696736453, -1.5563695413259062, -3.3882132142707815, -1.5674184481162627, -4.4593880133936485, -0.15895896152050332, -1.6559819383606067, -0.12208935062246928, -1.9403888661751467, -3.4214259188118286, -3.2951783319600043, -0.22116087140807747, -3.696428869515606, -2.8347866794438983, -0.07731341479586928, -1.916693571517008},
    {-0.8106006572797039, -3.8568875414693453, 0.38541209988520103, -1.2793106033311215, -1.5902973023350917, -3.3145594573267996, -1.7327056923739688, -2.3135557574989747, -3.728182567393502, -1.8979434583052501, -2.3782206031651407, -2.489536123735169, -2.7265199878401414, -2.370379483501703, -1.7167217994667827, -0.18863788241382962, -1.1656073106821632, -0.28221345040073, -2.3613084608778627, -3.192349131167658, -3.2631216761083683, 0.14420135007305784, -1.555241450653043, -2.3279082369018713, -0.17292205447292494, -2.0996035659085988, -3.6950681723632073, -0.44686758116784137, -4.000423612044363, -2.1434167393248607, -0.10758205274270384, -4.166473276932231},
    {-1.6130532302014182, -3.3103042490291967, 0.061425109806447, -0.13982591462634247, -1.354293421043392, -3.609363091306315, -1.247510843935216, -2.3067268599706092, -3.219259701733844, -1.014790132613256, -3.836118633807863, -2.2823932804626876, -2.5214446414565557, -2.5013407988048657, -1.8664573009629326, 1.2320012785924506, 0.38552452827339034, -0.07841441954584397, -2.6633162106958137, -1.7278256693155538, -4.101456998747895, -0.8300523833977076, -2.741705488905407, -1.3472861739610869, 1.0564859405450857, -2.5813688706612914, -2.069016173377028, -2.0393224990380205, -2.279594362731863, -2.095489719040494, 0.04454428352464414, -3.7886655286317246},
    {-1.7395428827179538, -2.2342099120786965, -0.38896930251570355, -2.190234480500897, -0.1404970896356775, -1.9980478800752108, -1.1725283211660655, -3.3817802649665, -3.5787392984480983, -0.7465950066989449, -2.569859417266743, -2.516803967214867, -3.9465721362116426, -3.333051530305701, -2.435570116783649, -0.5313876210669681, -1.1105104642004755, -1.7070959219566089, -2.568090670026467, -3.5201790712641823, -3.739912672346757, 0.06575514884829305, -1.889078705748108, -1.6877785397449596, -0.9593816661160616, -2.042712227847242, -2.2064250872767786, -3.0081274195369594, -2.2010299131961317, -1.770226193329379, -1.6719190739972543, -3.845611975848873},
    {0.22552028714383768, -1.8095678526387595, -0.14111674649537148, -1.2922033206654753, -0.2594797133568304, -3.2145966053887425, -1.3797006176910163, -1.1199376282879903, -2.062587428769223, -0.17260715053124037, -2.4357689301761654, -2.7056796518508754, -2.1342830673431368, -1.1716796232489903, -0.6943466969610927, 1.9007746905621052, -1.5669749608159032, -1.5909871799902031, -0.9518191403297582, -2.557750240113714, -1.7061874709355682, -0.6852029073124091, -2.0646512034593614, -0.10544087227506029, -0.24898468193668252, -1.3239376454671246, -2.2244471571926865, -0.8173795264375433, -1.3794459470035232, -1.7283708746516164, 0.2916666991512948, -1.9167359453563881},
    {-0.17120610313756232, -1.248611109298422, 0.5084911242285266, 1.1251640363992663, 0.8561140176299505, -2.426487159342921, -1.1561342808514805, -1.8310086293431063, -2.030905107286705, 0.16160161394909178, -2.7153547308324697, -0.7165945994120003, -1.0501523121086562, -0.1393393921294144, -1.313167533940455, 1.1655187259007562, 0.1732489849551632, -0.9759757399144596, 0.421928170262479, -0.8308728426539768, -2.059986641971055, 0.4585282277940792, -1.766343871570791, -0.623653421269196, 1.1903758421085004, -2.2094333071649874, 0.24112232938744133, -0.5325498834534059, -1.898210918514525, -0.2604794899222644, -0.8740204460025905, -1.8973203247495682},
    {0.08489411280126595, -2.177122703605034, -2.2396516488822646, -0.8617315644647134, 0.10622347370042436, -3.030353647016643, -2.4156975652790735, -2.719544688391441, -3.385126434659898, -3.0584802662242363, -4.828927841250824, -1.484079846989981, -3.0102311345104495, -2.7874950830403415, -0.43801357602088675, -0.6331496666826079, -2.753685501508179, -1.8571122088286829, -1.7113930318912074, -3.782576144672078, -3.4603781515095022, -2.1519748285168396, -2.0093513383629165, -1.9675977282087709, 1.1118997898257141, -2.4151367876948395, -2.1138603228216595, -1.4346694910284075, -1.6260848587128152, -1.3395137088208184, -1.4685995798476663, -4.110541229334016},
    {-0.22093170451873817, -3.7263502571703238, -1.273659101118455, -0.1436597517059106, -0.3366214651685547, -3.5460955086382864, -1.6325204296476936, -2.5423085569366957, -4.176754836535764, -2.651534079980977, -3.173489305240223, -3.7576440267232263, -3.9719291526714655, -2.3323125185946467, -0.2094052484866121, 0.7886783796804286, -1.356750533379091, -1.2192321408748557, -3.1460046699009196, -3.802560662007447, -2.813090601243601, -0.796935860243277, -0.3696738599205148, -1.5363604386994842, -0.21532786712330265, -1.8250233883882527, -3.823559204049981, -2.50613126218941, -2.902833901383337, -2.3239067290458184, -0.4643260988770455, -2.8440196742781794},
    {-2.228331037946934, -3.33424040230321, -1.1389445601695494, -2.133980260188005, -1.8356748357176116, -2.868666933514608, -3.54850740844404, -3.869871198423393, -3.559820569401711, -1.539596893661629, -3.5065914998518086, -4.315991199230333, -2.77331392053924, -2.492684783509036, -0.7601178476241696, -1.4102423380949398, -0.9821279263542466, -1.5906577524598138, -3.1582329694387297, -3.3083785079858767, -3.0457872256448946, -1.618349915746056, -1.0866174977011474, -0.24757348700177315, -1.6686446736586023, -3.448768288836902, -4.396175088227201, -2.1509058073648926, -2.3354894855075505, -1.7143278947902978, -1.0161045741630417, -2.672522796322792},
    {-0.0035762224690415565, -2.369206426698946, 1.0228455977191153, 0.9473794051168198, 1.4829798936583818, -1.1717127873262145, -1.5245432542059554, -1.3657178243050472, -1.5363250090584517, 0.34406102136381617, -3.990367004677143, -2.682724208438073, -2.429463292168222, -0.31705778055138145, -0.008426570275072166, 3.258812092403843, 1.6854225445227493, 0.21444897139901584, -1.688852997235678, -2.3926197287272677, -2.5300558013417986, 2.6600263127353037, -0.9708858749557251, 2.618717914092566, -0.034498031896648816, -2.300207536305487, -2.194502443921335, 1.4867626127046825, -1.201822033116827, -0.35535254089243684, 2.2515154526757626, -1.2587227879585368},
    {1.8657552112968945, -0.16641751358629187, 0.8069141417843332, 1.2843631825660624, 3.512806647263862, -1.9020475770730754, 0.3612085431325349, -1.5724004903683075, -0.5001754629091588, 0.8513278416205102, -4.188488494285508, -1.214315472157824, -1.5466240106012852, -0.6542342856734105, 1.977701678402541, 3.9010920301806125, 0.8404223396521787, 1.0814204973678496, -0.0808194325962899, -2.8267596733087728, -2.5469012519847576, 2.6609636715795713, 0.3545730846938427, 0.8182930839141043, 3.262109637144356, -1.361385737046102, -0.6723833391810707, 0.29647744928069764, -0.828058569584159, -0.40403059592004603, 1.090375962541816, -1.034128096634076},
    {0.521557144078119, -3.58039427417257, 0.1598472973165365, -0.994586803563736, 2.149085320350599, -3.7436832127907547, -1.3120676309681154, -2.8242206058242214, -3.1012840670287276, -2.7012728044807233, -5.404937175425054, -1.8304739745491452, -4.046839955553812, -2.325302947722064, 0.6684869816631211, 0.6549216706521115, -1.3370366007893952, -1.9319308444704844, -1.4458491902740929, -4.3143595554625005, -4.249380556566961, -1.4219391833574337, -0.5547535056322275, 0.12566045402906043, 1.121245630782004, -3.270793014733578, -2.7422999856618446, -3.4968507491852394, -1.9821037772820627, -1.7104385967164588, -0.40775829867868274, -2.7194025537443722},
    {-1.1331636877437747, -3.60067852753514, -0.47501673509476267, -1.897368021256529, -0.6848207547547485, -3.5582614361741345, -1.4949275873684265, -3.287911453183027, -2.5389675543934547, -1.7867381873521164, -3.2303435123297612, -2.737121985421528, -4.109302714724953, -1.3740782858663718, -0.8145488605343459, -0.2958688038029683, -0.4921971652443313, -1.8391782428426433, -3.224367075547048, -2.3006704103878626, -3.9028681862141026, -0.22324146306477038, -1.7424828860926505, -0.7670332521505829, -1.2050801574216765, -3.5275034170340076, -2.220477706978262, -3.1525190619732566, -4.09060805472832, -2.4562344537199983, -1.745975543041137, -4.2225062600816425},
    {1.4341318051146856, -1.6214197802220485, -0.5059982533417845, -1.3861642622097679, 1.795180950414073, -1.10771401328569, -2.4124833556579093, -1.324250911960676, -2.9215225998312, -2.883134716223274, -3.0780458150200607, -2.003269254760654, -3.5404901544642127, -0.5477550071291059, -0.28585427190841645, -0.2660155572039119, -0.20498065730955742, -2.058863252906685, -2.813908366964789, -3.2858232794373414, -4.513848942496131, 0.5074420858378244, -0.6824021286247258, -0.9999869788980519, 1.9043755559820545, -2.4983898604127366, -3.0512906412734364, -2.0972408580431137, -2.827684378914909, 0.20335179875184636, -0.4400156806025882, -2.6353847610433734},
    {0.3940034891126835, -3.336493738131666, 0.833268328690783, -1.454462970640721, 1.1363830099604781, -3.456814755712564, -2.4773047146386733, -2.3085335116032124, -2.685819380133145, -2.275301859033041, -3.8060635086508317, -1.895442769503952, -4.1093587747572355, -1.7421602001773466, 0.26063464511019907, 0.22789296363600128, -0.9423863452333942, -1.9290372866256305, -2.7966509209576533, -1.9342266001144601, -2.972649497740305, -0.09268397245055306, -0.8751078886962176, -1.0614749310618847, 1.286452096790835, -3.728971843569591, -2.4075987701943595, -0.7656360360447461, -2.645655111536156, -0.5126035800283048, -0.4005420137130346, -1.9737947308798454},
    {-0.37246115620195464, -2.260205331471998, 0.4957162643308775, 0.213433148706332, 1.5785570299328304, -1.6033373391633026, -2.8291722518539455, -0.6054622216828719, -1.6732778298766768, -1.875204787710285, -4.6188027744073175, -2.3836529404331612, -4.301017232172674, -2.2531056043709405, -0.26011902157780825, 1.9599246509591368, -0.004775692093102936, -0.28338058290186396, -3.0873156881033528, -3.1310871883458398, -4.452302384041583, -0.941353271216076, -1.4649299864354461, 0.34305022831870363, -0.26954919557755924, -3.102308283980394, -1.848757964663396, -1.5949187047475666, -1.897681761812979, -0.22026678776262273, 0.5508903786998919, -1.9245294999680305},
    {-0.6175580488762684, -1.799399608381793, 1.40450535460236, 0.07022108304219767, 0.83889374099703, -1.7975607483725102, -2.252214431992668, -0.6918855572718391, -1.4591267227840086, -1.585348537611694, -4.944950600644525, -1.9542478608861986, -3.964246320108147, -1.2017177901217124, -0.33601567433277435, 1.789049907555755, 0.7805951777581595, -1.5769544044905268, -1.692692020395625, -2.6274677069992904, -4.830674062106133, -0.3827697722932348, -0.7132783605164191, -0.44779467310692395, 0.953962737645278, -3.518280902365688, -2.090826187008867, -1.7931403095434775, -2.5881059894415137, -0.5737012293285983, 0.9598070506979897, -3.329195621704826},
    {1.6227831436490474, -1.3575847917758488, 0.9801643671939702, 0.9113188617353563, 1.2405997543860752, -1.713069038933523, -1.845133097695351, -0.12236155987357321, -2.286816247323731, 0.15200156107137863, -2.340129195109466, -1.6135546552358413, -2.895619901023071, -1.1596429524494334, 0.9343139409174257, 2.713866425676762, 1.4947206748042674, 0.22924800976236473, -1.3280154568419382, -2.8725540324142145, -3.705248638754052, 1.1517822304599936, -2.2031514685421065, 0.5466206038495913, 1.5119768099916373, -1.944843460114162, -1.5341082223889544, 0.1883398983382114, -2.0508282734177037, 0.821918314195669, 1.3937779520486708, -1.664721011082658},
    {-0.133332611343792, 2.140430590557823, -0.36696030677691766, -1.938589601579497, 0.8842585144058372, 1.501771854666671, 2.8603226832852013, 2.1068942518688503, 0.904900831365936, -0.530263669936237, -1.3055155207722315, 1.618834870563656, 0.9277250079188926, 2.288919894709298, -2.180245893682933, 0.2757264458087513, -1.2972633648361473, 1.7316761713740816, 1.4669215879627784, -0.3424405303726756, 0.23499564218213295, -1.9466583495581256, -1.400172053208901, -1.4763690770311177, -0.1528956094756414, -1.3354355583781439, 2.5702587511066515, 0.945165170714622, -1.819461469254703, 3.0024607706497606, -2.509624328251386, 2.501280626803698},
    {-0.8790098307022167, 2.4426078431014586, 0.10532169451971823, -1.3371543926100826, 1.4046761709366906, 2.4885678903580906, 1.4249850068243948, 1.7283526857144977, 2.0956904799268408, 0.10903969348393883, 0.6838673485741468, 0.21486522620397602, 1.9393637012247582, 1.144282816857168, -0.36537643248127327, 1.2257586890813341, -0.5853756132142061, 1.058040134282705, 2.7748637919699863, -0.42825271234882994, 0.7122067118445374, -2.2765637999136414, 0.04587955347305033, -2.205999952511416, -0.5096369835612556, -0.14685305671632057, 2.830530815537587, -0.10123218024328394, 0.2388214871663069, 1.7584917695474371, -2.6059223275873893, 2.6281376037545434},
    {-1.6427889446626691, 1.6082962583478182, -1.7491754553702417, -2.385574601013907, 2.727482910094497, 2.2601145693915456, 1.1033379441401365, 3.0203946799920756, 2.0115829398012273, -0.7338519964398391, 0.4014796837075219, 1.4641161290713323, 1.6613024153241815, 3.386095613521063, -2.549966176158045, -0.004227676294715319, -1.9362051725937632, 3.103431711005785, 1.3174966813829272, 1.039596749123396, -0.28548726407804365, -3.065199767536057, 0.40918834662675757, -1.8597642791548923, -0.46097306958057366, -0.27751668088909537, 2.5017511443167564, -0.9284131054436761, 0.7475908966457118, 3.661899638638728, -2.432425962655805, 2.0840148192370687},
    {-0.4951652936249663, 2.9513352778297093, -0.5900923099404147, -2.305804532146103, 2.4405083368592257, 1.334432675699034, 2.545153404788355, 2.6938023523211405, 0.23671411253042973, -1.4457250454500792, -0.010051264054431935, 1.4331669801455797, 1.117332203287362, 1.8226363949490576, -1.9589770599859035, 1.1802127727714324, -0.029323789626369893, 3.35336791072914, 1.2844261358613653, 0.7968391177384498, 1.028202728643904, -2.6485268514021167, -1.088952996822853, -3.0502981631924495, -0.7466210230799013, -1.276438435703432, 1.6612149423750449, -0.018872343189160975, 0.8828091692677941, 2.436062167874531, -2.4959528092077545, 2.0932091755488496},
    {-0.6402813861430564, 2.8036140887347076, -0.742554594650211, -1.3449468729497067, 2.4680864101031905, 2.339595523053069, 1.231291031628437, 1.8133486745360023, 0.5583131017970318, -0.20273122736454918, 1.2385647442850134, 2.286803682961263, 1.309378370792026, 2.6974286015663447, -2.793471523041603, 0.04262966902138539, -0.8224488490168808, 2.1404625327070703, 2.167507098860061, 1.469741174407901, 1.044444560848722, -1.505305907778848, -0.5449448332418946, -1.998750870405929, 0.6332958100216253, -0.8037994694434388, 1.077310103173011, -0.7655196849706778, 0.7769087159680087, 3.375204492785348, -2.462554850920908, 1.070637601033375},
    {-0.8616752008566789, 0.8661932063390346, -1.6925512965984215, -2.143175868633523, 1.5073606675685354, 0.1279901870277315, 1.354793537270602, 3.3000007118038046, 1.0849875642522715, 0.2767038080421078, -0.10360061803076288, 1.3937318966398617, 0.4192800533549329, 2.6970254867994363, -2.255981507494488, 1.2648176565871752, -2.2381615322399213, 3.168002435427134, 2.1510741504357767, -0.6186952226693833, 1.668490208998323, -1.4394472890607175, -1.6854833588854647, -1.5803836948417644, -0.3655953798870261, -0.589558620383859, 1.6629779976908954, -0.2632469195961381, -0.9981577032193775, 1.6570300060751382, -2.8421738603077475, 1.929240485992992},
    {-2.240695988803823, 0.5719028509406985, -2.670674693610267, -2.319669433152879, 1.410490125157521, 1.1904506075065933, 2.7310911656183072, 2.9208613532715257, -0.4160565715481259, -0.755598181715613, -1.016803287099318, 0.3198443949334519, 0.6387301933483135, 2.4107567988197895, -2.1154413741129723, 0.7521454233940642, -1.9989621484053683, 3.3189529339581467, 2.383029126187463, -1.0601854041484717, 1.389656407648148, -1.879186394691, -1.148267569024075, -3.0183833690798774, -0.18998389433563845, -2.2281682500626108, 2.696513947749851, -0.2530661102428755, 0.1605491766479874, 1.7585047227443693, -3.1251201908431216, 1.6163872022610288},
    {-0.8401152271866684, 0.8417718982155317, -1.186551020004753, -2.9684976626641624, 1.3721097464688916, 1.3643752311783592, 2.0445202583790647, 1.3167474318798589, 1.3068423997719663, -1.2365452495668392, 0.2802957877859158, 0.6865237618043639, 1.647856183307638, 3.3132848307567593, -2.348741293827959, -1.0189922331286387, -1.7942354200097594, 1.8822709533822382, 2.4180992667335217, 0.053151267762098504, 1.359225124717054, -2.2912768820387748, -1.4876700648037864, -2.832273107815459, 0.45395051541792253, -0.4289466950339016, 2.3296573775651788, -0.9531797911763028, -0.4191615869462021, 4.089077068582339, -2.954941073025438, 0.7976913450045795},
    {-1.0024882223418294, 1.0107512818166815, -0.7472818268681203, -1.1723977270170174, 1.5928001963998022, 2.5833825472832945, 2.537162622902629, 2.981592883703917, 2.032239048453755, -0.45550583076863504, -0.030242966241148476, 1.9554756340589827, 0.13164818085036809, 2.2953078447264885, -3.2431061755642294, 0.9490787218599239, -1.0229359236151865, 2.998661313021443, 1.0970475267613626, 0.1999626164563304, 1.3209738066409182, -2.4438668723604486, -1.2280890311148251, -2.718164916406969, 1.1404730181073681, -1.4925367826275493, 2.4882785317309386, 0.1127543562360441, 0.48202931655674913, 3.9414249800412895, -3.9542809883059933, 2.7045539374469705},
    {-1.0263503497504707, 2.6360041215560095, -2.1606908462409957, -1.7400671920567155, 3.1953986351580244, 1.7909131909528118, 2.584197865932784, 2.663207533082007, 2.1042955729983586, 0.26115946848861915, -0.7831901595282815, 1.8264817152174257, 0.3129123731632482, 3.8513788964772924, -2.1949085064048908, 0.3734598178734717, -1.789095986441539, 3.626457411404278, 1.4681903008346158, -0.33612555086860224, 1.8474163464327498, -3.09299358234297, 0.46869922465650676, -2.2611828249826185, 0.7802828773236029, -2.477318419488536, 0.6100435971468753, 0.8917639168470456, -0.15422870158535598, 3.5305253855043346, -3.8017717166935787, 3.015747650926164},
    {-0.9361924788841128, 1.94581669398776, -2.5010801351468177, -0.5896176403592859, 1.871050240175207, 3.081000082899461, 1.8074204760597763, 3.512794652159503, 1.5103832586931787, -0.8924884251267589, 0.21756206364244232, 0.9741770443429302, 2.0907756809124662, 1.6817896833989536, -0.8819147780694468, 1.3194028507089208, -1.9042452584264062, 3.501226036464473, 1.795269708504355, -0.3069011155692025, 1.6232257421668435, -2.624952865903732, -0.5619965109279251, -2.486647977901797, -0.7288201628196375, -2.0235871475328544, 0.7786054122220288, 1.2634796067270324, -0.7785863837757928, 2.0000723293561435, -3.313174996333495, 2.2345246654790185},
    {-1.651865615917752, 3.643299483905572, -1.7665698554825415, -0.40604498395539645, 2.983411306688113, 2.620228726759317, 2.6421555893228765, 2.6360056161282035, 0.6449206027391434, -0.9786838942882524, 0.3480725818326953, 1.644518183260056, 1.1661911940557748, 3.874709794860428, -2.1398954247146227, 1.0579304500239177, -2.009718081744666, 2.9185091514271018, 1.0068845102008643, 1.1406824826847504, 0.5994564568052573, -2.5295776366386953, -1.4587308451673513, -3.052299878541761, 1.2091072536861163, -0.8650664502931437, 2.236768226681532, 0.31183406165848837, -0.9931476504467553, 2.499187817514881, -3.0894511086797274, 3.1360235680497306},
    {-1.5844294278548767, 2.5374218860299833, -2.4915192614611015, -0.990263965562445, 2.2862836721294584, 0.6907363662509813, 3.5554540808480493, 2.2959878727626974, 0.5367196912641033, -1.1292439441694608, -0.5990171243739186, 0.7262685207918822, 0.35725448141587285, 3.318428885959758, -3.3838006327930206, 0.8797167566619716, -1.2540489894172728, 1.9805131921369448, 2.1016765945293763, -0.30181809648252633, -0.4615900696741617, -2.1155658171379894, -2.1615111835298633, -2.4370297701365877, 0.3652169301355683, -2.05198855263983, 1.7859649998540694, 0.01602577808189332, -0.8642012589043815, 2.130606973374368, -3.9424295804020653, 1.0365663371815717},
    {-0.6688791931687236, 2.114435752612606, -3.091843947459952, -1.7702049102209259, 1.1483061892747275, 2.1765080241680437, 3.5793365043057346, 2.4659874613332473, 0.5591929800405334, -1.1064649075006239, -1.296893102307335, 1.1194205439639724, 2.1097694615782605, 3.031898963828518, -1.2903151796009924, 0.05605589470709126, -2.6794292657224354, 3.4281137882171215, 1.1418753547830744, 0.8786440814626612, 1.0807284690884793, -3.343808744927749, -1.725301680962645, -2.2753986872142935, -0.535580295290099, -1.6528692779932566, 1.9718349511939082, 1.2753101548128338, 0.2583872171720799, 2.9013458698670918, -2.273479711588789, 1.810381273560428},
    {-0.7606856726805407, 2.715850981134343, -0.8209655721121962, -1.8148242426328305, 0.9159978012232095, 0.9064885087634678, 2.514413924127101, 3.2148910952913985, 1.283132240276753, -1.4218805919591007, -1.485856455430368, 1.7305612176420735, 1.9072875553836703, 3.3709660224416904, -2.566430899939097, -0.4821273383546346, -1.8707712815021316, 3.616723503726648, 1.1237944000695734, 0.40082188378591027, -0.6122185788528859, -2.7620402623800264, -1.3727157449499647, -3.3330456773416186, 0.06916883420378406, -1.9813052222338903, 2.9533922874581595, 1.5444741223725433, -1.4279055911546648, 3.835184321650942, -1.9132084252744759, 2.7454057056971433},
    {-0.15884923542951881, 1.732899185089383, -0.8572268988973704, -1.876867398018193, 1.7633644056394286, 0.7415673680198113, 2.698763182077728, 3.508039565175567, 1.2805845666959275, -1.3739922750699831, -1.5710411802965967, 1.7189933399902033, 1.136963794385146, 2.302259746161048, -3.0352648770074673, -0.5972972448999666, -1.9391237296920922, 3.584741743441162, 1.3782861545378706, 1.594888952419083, 1.0353060715840539, -2.2729544202087877, -0.6511080524208106, -2.871456606260981, -0.47652031613100454, -2.8950823376188657, 2.5147752387575597, 0.5119040709606937, -0.8555581499146686, 3.1250338218535982, -3.507586613423379, 1.607770102245531},
    {-0.6624120766610014, 2.9641045268181823, -1.8427411211164826, -0.1509273866249019, 1.8213427395658104, 2.7950044369289153, 1.8444053448347864, 2.17791917705505, 1.7911150090494232, 0.19641357944558596, 0.006794527821224841, 2.9949346286126888, 1.1298256649241039, 2.0800135384204417, -2.8772122348957407, -0.6105807380210813, -0.22742237174521737, 3.632005354254111, 3.1070478875106993, 1.1622005829850197, 0.25031032166643824, -1.499190313026392, -1.4406694691772963, -2.360727119603574, -0.24454360315362747, -1.2053263348615677, 1.931765350100846, 2.01072440977307, 0.9659762759083863, 3.1061427619510487, -3.130128649977806, 1.369170496149186},
    {-0.11414371353958024, 3.653120151742353, -0.8579378776635268, -0.9861566492761448, 2.236693997151337, 1.3696400225869734, 3.9739243095736447, 3.2752546940812626, 1.2188131168995013, 0.19392426388182338, 0.06573312917337115, 2.366371744665805, 2.9689094257541018, 2.906852972922548, -2.013679858555365, -0.4615947179944102, -2.347631204767045, 4.301184499298369, 2.386312423751465, 1.9084357559548464, -0.7407769325075161, -2.073713244708706, -0.1405450782400442, -2.7810449922326232, 0.44002997995367477, -1.2796957930606283, 2.4414435118123654, 0.3779881191345896, -0.28216680438714353, 4.1171307230562215, -2.543183614337488, 2.4015150337780518},
    {-1.766649448088494, 2.3968887453935404, -2.3500951950949243, -1.4878309122830597, 0.9320328297399597, 2.901827707595697, 4.041918546021708, 2.277464176093383, 0.7493722073165925, -0.7794818162201804, -1.9537328320884788, 2.309005011147046, 2.5296190773219154, 3.3298537272574014, -1.660668965880317, 0.7100475311439554, -2.5437387049804725, 3.0672425848997, 3.2138165741584457, 1.8088496999013477, -0.054573627283125294, -2.680561050936696, -1.8713756873221534, -2.72244920739395, -0.03646107973995133, -0.9127727175949663, 1.2580213921232735, 0.7883450316127398, -0.1336292388367228, 3.7641225748969136, -3.5108622708703052, 1.697510064733853},
    {-1.0562112355093425, 3.4910733925475514, -1.1793993656233552, -2.079334129916213, 2.816798072695023, 2.276636698470201, 3.7648541730639575, 2.4335918458718204, 0.604553143302815, -1.0225429683692948, -0.3491280653475024, 3.128159939909937, 2.3367030984507293, 3.0925009223728397, -2.146727257373366, 0.6713035905282763, -1.6207523221167401, 3.2199022225044565, 3.0055085026075896, 2.046975102978614, 0.011694324276323114, -3.834608671561938, -0.7905299348980217, -2.4086807147575775, 0.24084075173982483, -2.1927152700905648, 3.028450240856102, 1.5529963118942685, -1.1440675427856921, 4.187309833184697, -3.0056625523138845, 1.9522303838207915},
    {0.3931697536823344, 1.69871012078594, -2.948625784639108, -1.9975256187754307, 0.6725068471166702, 2.681139832907896, 2.0265231285520304, 3.3923768667504164, 1.8110642023000145, -1.2122037049718304, -0.132614813676531, 2.4910982930741423, 2.6843852725300525, 2.6101346196368995, -1.8254164591409214, -0.08418704398915564, -1.692571942789259, 3.5123202739220156, 1.8011168350620446, 1.1051714110926822, -0.368382852589798, -2.5114855555061184, -1.833686039458522, -2.5503324651515293, 0.581214682989663, -1.481059667606542, 1.4990857632658428, 1.4195213256349142, -1.0636195624997928, 2.776376281541361, -3.4168413931544617, 3.4094354501853306},
    {0.12590053066091678, 4.2428399379254085, -2.5434141171210114, -2.5771842512769196, 0.9714808382084807, 3.3271789233874096, 2.62233394688627, 3.9178371818431392, 1.574479580442043, 0.6831004278676125, -0.4594302321974357, 1.8997069529402262, 1.362441989944373, 3.6459603935278007, -2.514666641041957, 0.13824536319157185, -0.5541725814803119, 3.510382016257689, 2.323317701213588, 2.566731441510132, 0.14288644532335026, -1.1752347415465374, -0.9347855508385482, -3.2666828900662783, 0.7250256308289785, -2.2592271956989913, 3.5723373842794173, 1.3234091035562454, -0.6200143587446398, 3.4878341631467795, -2.8155437546002884, 4.029197820636109},
    {0.040666762419692366, 3.2154256275310984, -3.21350607420839, -2.1157890494404294, 1.3771089940474606, 2.6262968883033597, 3.6719646062557936, 4.183553964637144, 2.126867173775563, -1.8496966007906546, -1.6876408136433099, 3.268909086387507, 2.3338734282355724, 4.128630825939279, -2.8908642589652938, -0.452188445447588, -1.060946968657271, 4.091127348526442, 1.4503317415016832, 2.258067757225918, 0.8595678148442016, -2.273511561497296, -1.1410127901789442, -3.8012282419181047, 0.8330716234899919, -0.7845149401103629, 1.993052774134346, 0.7001104839307228, 0.997965060480719, 4.540492223854663, -3.1322744101433906, 3.714931680245522},
    {-0.7961605220100072, 3.6491295739360257, -2.874010245065216, -2.11098827167113, 1.758853625335021, 3.22602693487434, 3.902615116286073, 2.4499787453016744, 1.4143048540214862, -0.49439629496998705, -1.4428006809533367, 2.86596773036498, 3.4047681725189824, 4.545330733882894, -3.733098970737146, -0.9007778509215961, -1.2056227578144372, 3.9142870095998843, 3.3626330482949522, 0.8766801585802437, 0.05638973258015273, -3.24150788141341, -1.1221698285747492, -2.6829324336409397, -0.30343464143035515, -2.585479105041144, 3.274427470492188, -0.5813718637763471, 0.7846060167651492, 3.1890671948992377, -3.1983633068687785, 3.5537019571262496},
    {0.20138410189945585, 3.858268529160282, -2.659358248862335, -1.2371125108782124, 3.0276510184781165, 1.3752943357669236, 4.4685096212222835, 3.536937078144542, 1.8894633458919088, 0.16829966458424334, -0.8107518811216027, 3.1547847958996558, 3.510144811657404, 4.375147120350165, -1.8933539679139622, -0.36858729106142685, -1.4524976600237693, 3.194123817542957, 3.4633440469445738, 1.2279913222784613, 1.2574243888948342, -2.1683136944008243, -1.6273818699161882, -3.780932917219379, -0.026960714235599485, -1.558841085388655, 3.9001289943017103, -0.06096615299625788, -0.7064142914385687, 2.969425512043118, -2.4602706629931648, 2.1784737494123445},
    {-0.11584194035037082, 2.2179541225300383, -1.9371661690616198, -2.019669365979431, 2.7566181320312744, 3.2973931443296913, 4.0553276114503305, 3.2558097552170233, 1.5744346882690796, -0.5596319738219764, -0.9518000953204839, 3.703001168622653, 3.514161241833899, 3.684935208685831, -2.6236374591535547, 0.9378492351421202, -1.1954822122334023, 4.28801815371491, 2.903344225370376, 2.09391668376115, -0.255060591842333, -3.695295661845619, -0.9113144410120372, -3.023099503032255, 0.5994076581599275, -1.6760629171179549, 2.476123199148258, -0.6254444185008551, -1.1365053614907366, 4.976192798342912, -3.5314891628504275, 1.759522264144329},
    {-0.6608350345462153, 2.4734574055637735, -1.80070341754431, -2.8523587557593366, 1.7700999725411501, 3.390410837818562, 2.7313797607620933, 2.240540152568351, 1.211191995650244, -0.7079171197839563, -1.5910347390328934, 1.4743371573014148, 3.4546016330461136, 3.1063964872350875, -3.2786244268460956, -0.04858580623499396, -1.63171604966246, 4.050802854108352, 3.04486392370128, 0.8912831572324569, -0.23742811029480254, -2.7241419393640474, -0.533826890135092, -3.3139282071541474, -0.5838759630834535, -1.584626909907042, 3.978451474354873, 0.7011408442165262, -1.158369564555275, 4.9074158282227245, -3.364385018407254, 2.3140612374118765},
    {-1.2143803622998512, 3.2165930436698456, -1.337507785766175, -3.2627289972878137, 2.3885953437876477, 1.8297825458557186, 3.3795648151865816, 2.2545957677893216, 1.788397538257418, -1.2029743621583258, -0.921652928726916, 2.71392399793624, 2.898856898093898, 3.0678688628145427, -3.2895434772308505, -0.9159741091555949, -2.763971403569438, 4.297290151861997, 2.59628642028576, 1.343178546446649, 0.21747657575655951, -2.443364218239135, -1.3653012881582403, -4.087913898992805, 0.47896684048152377, -1.7441752553305485, 3.6424931479552987, 1.0039020589221443, 0.38334355028404765, 4.561181481924699, -2.9016750137205882, 2.4164668348801452},
    {-0.9058492543657161, 3.3027495985209865, -3.0335622314974833, -3.415134447606955, 1.6302889050106113, 1.931843461117889, 4.211298456729295, 3.515384796315862, -0.11332484036858746, -2.193918465171037, -1.746120587338592, 2.832856908090533, 1.951303641410496, 4.141713889383981, -2.091617535370291, -0.7233993026220925, -1.5812595560456473, 4.037127552414033, 3.320317075771879, 2.1213440428863124, 0.04835721916354138, -2.106988813617787, -1.4695761812041241, -3.414107948248655, 0.6654935041821851, -1.7283518987217394, 1.602301525246718, 0.014983821930658217, -0.3662495064219367, 3.5891178447760463, -4.0496951336443345, 3.2345076584661454},
    {-0.4705579449176296, 2.3051563012843204, -1.701054993053535, -2.642930919528287, 1.5550538619737135, 3.2665911388203206, 4.331517941108799, 3.4841176272746877, 0.49619591638268257, -1.864262449027351, -1.4472076599053414, 3.066488924431411, 1.6725107795856913, 4.030268010506977, -3.790340365001203, -0.41388529436262983, -1.8580375197435697, 3.9699561325351502, 2.555297208318933, 1.5543063141152782, 0.24978195481580764, -3.4311156643342176, -2.327175878439212, -4.483475218519762, 0.44182407685782243, -2.364544838917611, 2.711811075372195, 1.8079381580068652, -1.0026514619075604, 4.692402036277057, -3.423229114623162, 2.4553880879899808},
    {-1.154595943799727, -1.8593514719869093, -0.4309104472006549, -2.149777210405072, 0.05489132927546057, -0.7998080632417263, -1.2092238818592955, -1.379621772134677, -2.488650394068636, -3.2511572452974336, -1.5159256187986372, -0.07460927997694553, -0.746256175909237, -2.0094111436149786, 1.1173960710857804, -3.22143676371754, -2.624369211695635, -1.8939215071667392, -0.05014958619008071, -2.9306365864756, -1.3652595052700325, -1.6675409157494316, -0.2227513581490604, -0.8912073864649336, 0.5530141066325056, -0.6018835242938892, -2.879518179574134, -3.8331254310698384, -1.5205215003446566, -1.1859780269258713, -1.2064157278680276, -0.6572629358680734},
    {0.9661195199955638, -0.7140171155687155, -1.237264370009936, -0.12126171375936191, -1.1566419629834448, -0.4960921626209351, -0.24733972360157652, -1.3460005000138102, 0.4398686384801696, -1.6046674767291211, -0.9407023360532021, -1.3821678174398306, -1.1699787262764232, 0.7685903799800536, -0.10940157551307617, -1.3208643240949014, -0.20933126326726564, -0.48055363562873454, -0.7884606932494995, -1.4739154225325504, -2.192380694051219, -1.76312271348586, -0.908860513423405, 0.042591187410382744, 0.31955062161569253, -0.7406297052212608, -0.15376728125832329, 0.02810955770847056, 0.31928195497134754, 0.8404493164735637, -0.1494155521671767, -0.8402323525027885},
    {0.5822094626830985, -1.5697570200748137, 0.38441737953884025, -0.6163425484190445, -0.02837856569788868, -2.004184704551267, -0.9436288796867143, -0.25188100087726667, -1.0499320610674046, -1.071001551134413, -2.684313688172946, -2.155769004575007, -2.4500279816757504, -1.3332522789258268, -0.49261714498770187, -1.6175324732856045, -0.9895355585333884, -0.9447149083764734, -0.05735115050844804, -1.877596563594832, -2.9545621027115203, -1.2604962414349048, 0.2548249576447549, -0.183228968628428, 1.5124440807760433, -1.8066341594491817, -1.5618349629536927, -0.6892422983865704, -0.3102446453724442, -1.035661683323635, -0.0005256706420144665, -2.4041731031905984},
    {-1.0383116778700827, -0.009315573660716395, -1.664076094586069, -0.25472647119630426, -1.0631081362885213, -0.6809050144449638, -0.3613199597102213, 0.37136343671459127, -0.44626663796278226, -1.6556502232740604, -0.6279599924984776, -1.7377176568804833, -0.396257840572985, -1.066189297834587, -0.6238299131695677, -1.716906948504491, -1.0842621691289722, 0.5608683575818089, -1.2730836297113084, -2.892199645197279, -0.9293079354540997, -1.7247455717730749, -0.9394935786414942, -0.9243424457207187, 0.023827352115144952, -1.8861147276067978, -0.761120404208859, -1.7338789610437955, -0.5404703890047715, -0.48514838549856815, 0.29594126074696264, -2.1737393932350946},
    {0.04743049329565563, -1.3124807420072644, 1.1015178731319935, -1.1206290523625342, -0.6569191180500144, -1.547329935487026, -1.7825627017924608, -0.013058758512373985, -1.4156838821337208, -1.1811449114915333, -1.3497732567258196, -1.2626671290518912, -2.3650902587629266, -1.4311717265988204, -1.075357497196663, 0.9923881078201455, -0.7243037394078707, -1.4521344482740763, -2.137376182450922, -2.046181515823511, -3.260102641507552, -1.0423339048611209, 0.026561190920685554, -1.2394582090512394, 0.3358277613558445, -2.417126532215892, -1.5829911016360987, 0.7918064050130353, -2.2441118256632175, -0.4280331888222325, 0.33814916222268093, -2.4453542181668246},
    {0.5395235567301775, -1.5492205251238704, -0.2668437794644618, -0.8783151214270394, -1.487013725549628, -1.6319805724285004, -0.20698292548753347, -1.2402034991409119, -1.780158150765789, -1.0466279079103196, -1.8918784601552514, -2.0882795399218295, -0.43049456236322486, -0.45382275370525094, 0.6209397097140834, 0.163047055244299, 0.4816791087680214, -0.5324253981482883, -1.764017564646406, -1.063060435920931, -2.4305255492842788, -0.10963559947328946, 0.17839927773817416, -0.3919226690369173, 1.2384464744740016, -2.654572379857608, -1.3797988817403446, -0.9693365863039582, -2.065095561010591, -1.198886618083527, 0.7748186685490861, -0.9983066010531012},
    {-1.3943982294925368, -2.663676516218346, 1.237361633403145, -1.1204042074393783, -0.20702508494061236, -1.5820601558798482, -1.3183219915879631, -1.3622003253665271, -1.1253885070432748, -1.613769918379294, -1.7216302355914908, -1.6373343612666866, -1.6713169703073134, -0.5917513348359278, -1.4662043731816148, 1.009749527108591, -1.3280935447672189, -0.16980733899059902, -2.5495987290961057, -0.7572516168650449, -1.9474414675065173, -0.9724316393638094, -0.03296506451960601, -0.7698510107131478, 0.5473120126144199, -1.3504951685146103, -2.8666841283331657, -0.18788147009164946, -2.7293949399525466, -0.8694946671308129, -0.10673904106023203, -1.0021549273472876},
    {0.4952564653443919, -1.9136241026459684, -0.17469496252541594, 0.830124130549311, 0.4348674745382504, -0.9286141807036121, -1.8658892139589904, -0.6391644797796993, -2.556241470144169, -0.35733788733000177, -2.3637445374820287, -1.9089776620338696, -1.6501432623534926, -0.677849739996063, -2.0224276956509626, 0.5266781370768053, -1.2352916507719345, -2.3138281623864057, -1.4910397561387372, -1.0616969308702837, -2.4214422291396382, -1.0610017465999226, -0.903809813652482, -1.1827931367073217, 0.095655288265962, -2.13410433322631, -1.8311005858887814, -0.1285737618708934, -1.5077082444108196, 0.18534041203226262, -0.40178428909098973, -1.3318935585247376},
    {-1.128300757755566, -0.4436113774353039, 1.3473685221172145, 0.21417210499688227, -1.572190516646817, -2.8097689240946764, -0.9419980859754193, -2.514081506000719, -2.9851260194314655, -1.1864496066981791, -2.0759533390584797, -2.4289590987163545, -1.379045523847373, -0.8318994169879325, -0.9605529230055754, 1.0230620481358392, 0.9285717539786692, -1.0058596789492578, -2.414824597496867, -1.3975616795677572, -2.4481084779605644, -0.13314769461167347, -2.0004384343538124, -0.28668285863112075, -0.16724684340707507, -2.029300339771841, -0.35859479005226413, -0.6268065187185152, -1.6754507578862552, -2.2318706703725435, -0.9145457526632095, -2.2400763168539486},
    {-1.288862784734253, -0.40054353992762975, 1.6115842640187628, 1.0528442470158237, 0.8580355186576819, -1.6977229174307642, -2.2378342291710287, -1.8058340418714085, -1.704761933390102, -0.1303226697464866, -2.8074571878906873, -0.7602047840222831, -0.392900042484495, -2.617761887108856, -1.3658077332783296, 0.9812664729758038, 0.9917938344853244, -0.2420878131684564, -2.424042522243707, -0.25299110775031547, -0.9380279344584201, 0.3584560854887742, -1.4858440122379852, -0.44748741552711757, 0.3231334782651447, -1.4781034792666918, -0.5590794014004818, -1.457520849653311, -1.4509685783612223, -0.7587336649076866, 1.1150471127165855, -1.3761077964706487},
    {-0.01688056041256109, -2.3870655635229685, 0.14595474978620038, -1.035246818913192, -1.2018236847930255, 0.27528347146358545, -0.6331020889802534, -2.6467937678959483, -0.8813032739418527, -0.23783826138273845, -2.29521681641184, -0.8789568426954502, -1.5643348867449485, -1.186760180056248, -1.1420500156173454, -1.1903355965484517, -0.7575440723887357, 0.029588594707005075, -2.2259132232856795, -1.0959836432518797, -2.5058700701529055, -1.2325735178279968, -1.5684455355640772, -0.283872615103695, 0.07794094435480978, -0.5429825794731713, -1.5260521198101407, -2.0546801751346844, 0.019529266232189268, -0.898701383893395, -0.6866822567615768, -1.648408961230671},
    {-0.5916472069491084, -2.4108259124258926, 1.1606016026119117, -2.0106250943877657, -0.5911288392247382, -1.4673154999600508, -1.9153287221155995, -1.0565337822986791, -0.8140554038829834, -1.365907265227948, -2.706829322377383, -0.5992870212117496, -2.361122955420418, -1.5936420250330932, -1.5185290524186745, -0.537794250801545, -1.4646106005967512, 0.47662602560590844, -2.4461363680711448, -1.3788285645064078, -1.9518868124297999, -0.4628035787464016, -0.7559793430823302, -1.1595591820159372, -0.029971802601230876, -2.6804331931467797, -0.7408440426596207, -2.007502622058467, -2.442628568317144, 0.3492600910383779, -0.36516438625639136, -2.4256601577750123},
    {-1.9474964199976201, -1.6147937835288875, -0.41378312384503024, -0.9019972878505289, -0.32518855527461216, -0.8507522097524529, -0.15822278049567193, -2.617631725630428, -2.7390493759394774, -1.8358900662170239, -3.349314919656934, -1.131140272244374, -2.4781365220255203, -1.8848660169801918, -0.005711056183111663, 0.26214072208667166, -0.19060822911215222, -0.08874805059688963, -2.0942213089251385, -2.704341867885494, -1.8776825476306724, 0.2602308973658766, -0.672348580236735, -0.5327076011350104, -0.4195934896793691, -2.281235500671172, -0.9108471867612153, -1.0052317511307791, -0.9134979716523354, -2.208749465340409, 0.04630087816387864, -1.2075650460193177},
    {-0.19813412730973884, -1.0981659205664278, 0.16281368500218552, 0.20361085686216918, -0.19408735782574466, -1.2060763418494513, -2.362868623180399, -2.0632324414688283, -1.6110720428887289, -2.2325148185939425, -3.5269858273871715, -2.523074046316304, -2.0163958478474195, -0.411226662296106, -0.004717399741651192, 1.1698178792350722, -0.22348441573573175, 0.3706072891453323, -2.29305012613869, -1.984524776307292, -1.8116725903132211, -0.8938409440045622, -1.4298525414871022, -1.564388607074141, 0.11850073610796887, -2.6746516856146725, -2.055362089413961, -0.18660129278386586, -1.4439137663010395, -1.126263005151278, -0.22116132727117702, -2.4125885991948546},
    {0.9466658574003791, -3.043939862495653, 1.5674919196457975, -1.3700944366293393, 1.2812677457215715, -1.9504533602338339, -2.218000868953062, -2.281563057002235, -3.3042246446732406, -0.5246680941027762, -3.09260855411453, -1.529636074342558, -2.678493520141881, -1.6212036610430713, 1.249628763527237, 1.9030372317233761, 0.7401675970420227, 0.4375653888603131, -2.744740884251647, -3.2674222455392736, -2.0911470747773544, 0.4739906742009012, -1.5365926488229198, -1.4204699625062573, 1.9664392177499859, -1.2063666049263293, -0.533737554313984, -1.4259916134447965, -1.6966414619504275, -1.0578253319522255, 0.3411937454150829, -2.2887676376986565},
    {0.5000648392453909, -2.2999138238263117, -0.906270915261824, -0.08952168726841432, 0.3190289563143992, -1.719182909158401, -1.2685418018015404, -0.9643340616982129, -1.8318969853352585, -0.9627296820787687, -3.0456790615489555, -1.651938086854753, -3.2702959447526325, -1.941000213299321, -0.588097904161241, 1.483366366987643, -1.273464290222597, -1.172487678206485, -0.7597089923033087, -1.9032645374352466, -1.9291303108616644, 0.18848363120075054, -1.5701919041464354, -0.9248628908201192, 1.9961782514624355, -2.6602583927283288, -0.7070795814620524, -1.0610842415368078, -2.4929683032597594, -0.19426206180945135, -0.904974617506901, -2.6876709839015565},
    {1.9376590014491606, -0.7929302002482371, -0.4420059279688061, -0.8768459565958225, 2.040847692952138, -2.818288722049083, -2.037135441762382, -2.6867529041991705, -2.993128654518628, -1.1818804246505539, -1.8429805621444852, -0.04292268416942978, -2.0731984352806245, -0.4601858611828301, -0.8187135661355739, 0.9534915023645194, -0.3615867219736186, -1.0027702068846185, -0.8317358353014406, -3.09790725950621, -3.0397879440002797, -0.8630563148450974, -1.1898596302171998, -0.2644983608783913, 1.4425496058757934, -2.1440866350264485, -2.521413268233816, -3.1758097870643884, -2.388524899210457, -1.4656258782298215, -0.3199230115197275, -0.9843935425795418},
    {1.4040301249804947, -2.2162209530508457, 0.3842037053765136, -0.5168453430840446, 2.2983783108392855, -2.2147050570911198, -0.14422944731466147, -0.37805268995747354, -2.226709012134718, -0.5603883334838823, -2.1713743072956486, -1.4543874470829805, -1.694708720497853, 0.09506189697712207, 0.13043570266267984, 1.0037586791553097, -1.0884388143306856, -0.5155799711027732, 0.2549760374333135, -3.694651667553055, -3.1504241278387703, 1.3863790431020186, -0.15529511610344576, -0.9499933977827407, 2.5000401224512543, -2.9598357484234623, -1.9859369156885485, -2.107226479986922, -2.394974827722455, 0.3203948770307171, -1.3942257553912993, -1.4676252032956543},
    {1.426275001207968, -1.5939647315444914, -1.5401257322400836, -0.16699534611030958, 1.2572740748247766, -1.6116620795655678, -1.7698304564297056, -0.8047091398436121, -2.4802775980087417, -1.894605410857583, -4.187282507173283, -0.2833721323806447, -1.1623436800850537, -1.0804636257168927, 1.0036022767659505, -0.43584018046947726, -2.5213850688967154, -1.4400247925656733, -1.329161284017535, -3.6345018788090906, -2.0552761641027915, -0.1960459533498563, 0.0910934385388123, -2.1117164726869104, 2.7250714255828514, -1.7677155178699604, -1.627435838325756, -1.8638270349526513, -1.2357159027735154, 0.12158015975031797, -0.8279800199060456, -2.5914772198495672},
    {-0.42682973991127615, -2.4087699961405216, -1.398849875666379, -0.25278958638160576, -0.2510722456046815, -2.3432938298131862, -1.1843544690083987, -0.9277327642061719, -2.6813613896133055, -1.2698836605429755, -2.69668938485265, -2.170850600055232, -2.528647970777688, -1.872749174547843, -0.7483605723977051, -0.4567614059190768, -1.214583346595588, -0.25499106905812613, -1.9521168469259071, -3.7020596402750185, -1.777275812328434, 0.15302642437650613, -0.08743246481767336, -1.9081994623347407, 0.4647849194762589, -1.0228776870636447, -3.5911295912695307, -3.436621348825044, -1.9142690135782208, -0.7385695397259974, -0.43401776306569606, -3.0311889646042895},
    {1.110576150108499, -2.636378188558221, -0.24037414434983587, -0.8488694700175144, 2.3151776304780234, -2.3813126300395218, -0.5384793104191187, -1.8826668348266273, -3.5291085413951713, -1.7248075120712154, -3.9380471712258807, -1.7134210041604772, -2.3204104833274024, -2.3970644206042944, 0.043764505840655984, -0.08483569827713834, -1.6694971136281997, -0.4796174033740968, -1.0290814682231728, -3.499447290273782, -2.77046577540396, 0.2415824918815555, -0.7431246708560129, -0.4592952499927786, 0.6803132061995733, -1.6279533122927432, -3.575446636028095, -2.609010800438443, -1.8727450122099814, -0.4011772942536931, -1.2385008779604187, -1.8563152890220402},
    {1.582784599179543, -2.69207249972305, -0.09640643432490863, -0.8954184752098006, 3.499969141348388, -1.5629406396273249, -0.5048490265909684, -0.5880525106582821, -1.0430601648226718, -1.4745169039949384, -4.760358319064943, -1.0816753594160287, -3.3504454651103885, 0.34261188639816287, 2.2886112260047984, 0.9302176973750217, -0.21042896315767418, 1.2143979532432396, -0.80520597865431, -3.603444327195165, -2.7146761225759932, 1.620898319199323, 0.22229397352940883, -0.07708619590345359, 3.577745957677709, -3.1444908221468135, -1.8036661258916158, -1.7627313752123746, -1.108847971283102, 1.4892215333655145, 1.0261718125316885, -2.146442344763768},
    {4.208894811328436, -1.0756347654323166, 1.2241952115972161, -1.5229167671410964, 4.458969956397553, -1.0487476994545062, 0.6224845270158026, -0.96083310569763, -1.6445573301692484, -1.4500801577284717, -4.434274171102247, 0.1991512426606346, -2.6762646242174304, 1.1220421821262312, 3.4704885125725515, 1.2399982028535892, 0.7229877552558724, 1.1321987202231971, -0.571337858930305, -3.896755111159046, -3.7152637407936195, 1.2365908479208028, 1.5959120270307976, 1.1807788174523803, 4.8904381263861225, -1.2750183400951378, -2.0215475749098624, -3.0161261724481707, -0.2553083644064067, 1.680213048656674, 0.08642016696138592, -1.0848623122106984},
    {2.494418580404019, -1.4026768962530438, -0.9460491224625867, -1.7529231851988412, 2.861973524873213, -2.1326521968348984, 0.10118739235226024, -0.4490234703659055, -2.679842560978221, -2.8484641199726073, -5.0973700605674725, -1.4312360955301648, -2.3633168974706886, 0.13274082058524742, 2.7932979351132943, 1.405419548363264, -0.5656035031662802, 0.7216714447409083, -1.2421494676027585, -3.328073960116305, -4.623511949747536, -0.6892166155957579, 0.017678066907430585, 0.5495134327093442, 3.506347501829203, -1.1286324600080757, -3.2885732754990142, -2.606975013474892, -0.4590531602150201, 0.4665218282345888, 0.011783284162038084, -2.716447063046122},
    {0.7113667727371948, -2.7967971490527384, -0.8611358497987878, -1.8387540145833199, 2.529859404395502, -2.1111027624287577, -1.6744295134688532, -1.7114837156041882, -3.1844083258170897, -3.0472862366975946, -4.522494947664176, -1.4829012398013635, -1.7596440316228277, -1.5956794114102362, 0.506215438509404, 0.5775093397263708, -2.158382990537214, -0.7740624967681775, -0.8642839796409053, -3.5174229417242997, -2.9097999340594867, -1.8123959946099975, -0.587745635635212, -0.6120236627071431, 2.29983533624973, -3.2459378570375765, -2.3109836266028654, -3.1553498342182156, -2.038216702553642, 0.4883430489731062, -1.2535324526210723, -3.508124769422609},
    {2.5256838742760217, -2.2424485763364266, 0.6041868741288404, -3.109279980928482, 2.204232032181425, -1.2590439317111823, -0.5980781436020773, -0.8678697946996734, -1.4765913449283803, -4.262306874492189, -4.189554332383248, 0.03686356569679916, -1.4894052626861742, -0.03897109455642858, 1.8284984399238733, 0.11724622209332126, -1.3316178672485701, 0.45919582255573593, -1.662511635648946, -3.6103002410541842, -2.606106268200713, -0.8693617033804937, 0.10520588005063766, -0.5181007898306347, 2.839763918581106, -1.3403999315809239, -3.650123608796981, -2.1190653242173685, -2.2555782596901772, 0.11193467838739767, -1.2394394940660025, -2.804385770310149},
    {2.040554832321663, -2.7903240201386152, -0.03928318536339055, -2.8814396709885233, 3.1732607429939543, -1.835057114824393, -0.3469987946840499, -1.3738674506787178, -3.434279795650719, -4.743077265787161, -4.951444662169216, -1.295568634062668, -4.016878999276362, -0.2839382867799204, 1.9414286005457524, 1.0397904305347878, -1.574825606485778, 0.0308058798033552, -0.6807486836601744, -4.4946568668666345, -4.966576181224554, -0.03201210460567758, -0.47102119664234116, -0.8970997562107969, 2.543173638437842, -2.76770184926456, -4.190949776131851, -3.8972939234960653, -2.4624259658708514, -1.109660858376597, -0.9508237611281812, -3.0096149957341036},
    {0.861608397664241, -1.9890328867353972, 0.8416578070308414, -1.6299199288922013, 3.3528030763114254, -1.2264463138898611, -1.3140871183233638, -1.8253285509364987, -3.245810567002235, -3.718558248046758, -5.45205049494386, -0.02552001748549276, -3.3348110297630944, 0.10633203338787829, 2.2055348184126595, 1.9173668874909076, -1.7757455186701985, -0.13856173399260296, -1.7306077037661978, -3.6929198666506764, -4.1071677424734085, -1.3634340659825739, 0.11887765890633539, -0.8428804556272894, 3.255573117906851, -2.3307915843561524, -2.006351310052807, -2.955411089555305, -1.3051100312328028, -0.6722218808243906, -1.261306538674021, -2.711130599459524},
    {2.3365662997449834, -1.9821150232247033, 0.1676428233361582, -0.8121160036666165, 3.027052455680009, -1.1154570884440247, 0.19491136846712243, -0.49663744009946503, -2.9049718946821135, -3.766423739829358, -3.751286947226123, -0.3902208726267293, -2.9762082318466465, 0.39645104154327415, 1.8224987177710292, 1.5547059267006953, -1.4928193787496273, -0.5018570989155264, -0.6714332826394034, -3.1184419728620076, -4.606310596530579, -0.7003583210817438, -0.06275284717295562, -0.7906142363339269, 4.094663347032907, -2.2295213075887785, -2.0134218429032753, -2.2574738812831217, -1.8319938357305885, -0.13957752960312445, 0.10676451949151469, -2.92550491955241},
    {3.323570218081602, -1.3499931740248459, 1.166579970538022, -1.917249617343075, 3.727626169056211, -0.47402442169769143, -0.42881850577433006, -0.3533336914783293, -2.2151899138887634, -3.431034057353215, -4.481071438643915, -0.03650370665310288, -3.56280165723868, -0.4613072904956882, 2.2202627259210437, 1.6482180503860033, -0.9081330910270539, -0.8445937434915582, -0.08618620437873493, -3.864522770366688, -2.0858988805889607, 1.2180699234883956, -0.3671568625247183, -0.006488511880371675, 2.8620104215343884, -2.7875751441928496, -3.257779311573393, -2.715146735909086, -1.791002800970872, 1.1179590415019427, 0.6976515739968777, -2.9380656124878635}
};

static const float b1[32] = {6.572661751970088, 6.684141033204623, 6.451165482873933, 6.49479369009777, 6.652242503181761, 6.446586883986314, 6.458934244584253, 6.400693576484867, 6.599112720877061, 6.5582912389906705, 7.212995323917227, 6.2212257819342245, 6.560664307077538, 6.814680729533793, 6.646398043556248, 6.924789498249029, 6.6138715156599694, 6.8426009731556405, 6.190478935792353, 6.579171116955106, 7.2179977604381165, 6.678406323039729, 5.824966318532427, 7.188876873964145, 6.974872793229607, 5.908113578675907, 6.827520142353765, 6.930633630707776, 6.937031926708043, 6.971383387842962, 6.605618955021734, 6.909188810861913};

static const float w2[32][16] = {
    {4.994853870292178, 2.6224910591810207, 4.244442542408601, 5.197848446942206, 4.835410205498251, -0.42048380629773324, 4.546595049807859, 6.085232832504225, 3.501677144497121, 6.269324019636315, 5.6990143699373785, 2.370749710986775, 4.589412619216592, 5.834099447874112, 4.684171303441441, 6.187690941151507},
    {5.872861995192331, 2.753737864043298, 5.2558768875633985, 6.061042628872055, 5.504954041406254, -0.41733473742959326, 4.782195685271757, 6.211261644465129, 4.211670996628635, 5.020647485930518, 5.3539882271868, 1.6025553351122972, 5.20650555300851, 6.490401771994434, 5.4246171484086325, 6.846669403499718},
    {4.438227307028553, 2.1981022651450424, 4.580071774238323, 4.216814284852771, 4.614048083553549, -1.1068990606165001, 4.3430671580148745, 4.523787914986203, 3.112123923058687, 4.80436257556823, 5.437647333053114, 2.5118049892350345, 5.037138414625187, 5.001092993389231, 4.962980747344154, 5.19588185211573},
    {5.204271808202016, 2.880261124392527, 4.087568137336678, 6.016484392841043, 5.21172172109498, -0.42242305522521584, 4.780045880610967, 4.771125104015056, 3.703202105844162, 4.9924691545757645, 5.988257726465916, 1.5087407638097927, 4.518138097130617, 5.8437342893366315, 4.589107125524968, 4.9710205823835425},
    {5.9384590699109445, 2.992364789111068, 3.5944180428738646, 5.8360523555992465, 5.428921377132783, -0.48858146706857314, 5.429035191078176, 6.220842302217955, 4.225747658166197, 6.467618501230996, 5.04003084252082, 2.1076417778723946, 5.724909993699774, 5.9951092734015425, 4.9004450665018044, 6.360683841974192},
    {5.450515288126851, 1.7292693979564138, 4.963805424030914, 5.26142117260996, 5.680253468646537, 0.5846007798746633, 5.359315681674771, 5.003215859823413, 2.6757418121799224, 5.414906689756034, 4.427634665396183, 1.7356138695063799, 4.629797838026421, 5.21438739365813, 4.984187936588698, 5.882799721908448},
    {4.8532096667515985, 1.8718918386489145, 5.065023595932209, 5.143747170158234, 5.633161441049307, 0.24710345182968235, 4.761970189537611, 5.985803663728037, 3.101911657252196, 4.684675742696138, 4.922186190647447, 1.586236423235505, 5.3489549733510335, 4.7729632405316655, 4.756335250787612, 6.224924048968875},
    {5.906418284368445, 3.372522796134814, 5.340031513969103, 5.14461376909041, 5.009134480550828, -0.49554277633275573, 4.825640556445393, 5.346953699461661, 4.795030635311692, 6.203409726752346, 5.87146058935532, 2.104768035132773, 5.288831590202537, 5.038340684217093, 5.1341165847657155, 6.425714510106056},
    {6.052432588743921, 2.1110765851367943, 4.630739135812469, 6.2692902187389885, 5.697017892336811, 0.4276885637145393, 5.65275715974663, 5.039574658119333, 4.75528089915678, 5.772868316227474, 5.747987318277289, 2.928952266263366, 4.721440844066847, 6.254235280190716, 5.534728288571601, 5.407315211701259},
    {5.0940488719103865, 1.9164406043270164, 4.19403300501037, 5.210891484762398, 4.961589073543717, -0.027485595681117206, 4.839582397749996, 4.783640918784695, 4.865055068730916, 6.157483855872156, 5.77073183169462, 2.167161034704923, 5.039568681463729, 6.022599680457009, 3.9053242110691215, 6.693391556171121},
    {6.202791086141526, 2.399992922443201, 4.2010125795091104, 6.011376028551756, 5.426732993518024, -1.053847077703043, 6.340678917818432, 5.947265684560678, 3.3714070697294156, 4.827034233228998, 5.801045414914474, 1.4363215303949042, 4.403818245069977, 5.433547456742433, 5.1698286165990694, 6.706748763043702},
    {4.508046647406936, 1.4861452802625033, 4.090883496943328, 5.334699097493459, 4.362695248647782, 0.3130967243536952, 5.9129802264471785, 5.246348834097995, 4.172393314838237, 5.2107906920888105, 5.060154169256386, 2.461327104461539, 4.267090925119608, 4.911880641592875, 5.044594522365667, 5.327965750287649},
    {4.714051699770557, 1.6064536717516467, 4.243298898309987, 5.495750205116851, 4.541818440088716, -0.08184851322835604, 5.004409527040587, 5.632782973796949, 4.437753241106155, 5.844421166413026, 5.815977711056157, 2.149965331238078, 4.771104747609563, 5.3356682133549125, 5.828291750535568, 5.162084647888053},
    {5.128711585225554, 1.7642479717197286, 4.803273947228506, 6.039724450994109, 5.31174836096552, -0.7735308890481184, 4.763067357528176, 4.583451486061212, 2.751649430647438, 5.781440965288628, 4.5402449865220875, 2.0663264739817424, 4.066223556859018, 5.648526421405777, 4.07528800453567, 5.706053571843314},
    {4.98285155552103, 2.88289587036156, 4.277958965369455, 6.468821451878541, 5.214339130410844, -0.3210603966296365, 4.336093309600797, 6.28106876451292, 3.6760827737836816, 6.079999479918233, 6.161662079898344, 1.554007978074767, 4.456497866491145, 5.89820197076828, 5.484689906236589, 4.85156072557753},
    {5.613171668562832, 1.2624786969944743, 4.7108835121560695, 5.174947042981767, 3.815028703708368, 0.2344439827895189, 5.378145910903283, 4.856467497159361, 3.1415815463772643, 4.162297165573054, 5.924762012468541, 2.4379658537155637, 5.360675394585244, 5.988985708729943, 5.25257512646805, 6.344815267892048},
    {4.945571132319713, 3.170495612692598, 5.407972768938574, 6.385414555995146, 5.227761071822219, 0.7869801813563068, 5.227359167106518, 4.944089964111602, 4.335683787193265, 5.66019821701507, 5.49232761398708, 1.4404587431544982, 4.740743151978191, 5.883139088515783, 4.8139564914256825, 5.637489300353474},
    {5.946707383807945, 3.135681990717475, 3.5769608709258147, 6.66623175960824, 5.413934902227986, 0.5468772487043184, 4.920189036251429, 6.295051062376563, 3.828278186386716, 6.260150406990941, 5.711702589266969, 1.9312211633043788, 4.318616290241621, 4.93089108454103, 4.204480013749626, 5.249674173251748},
    {5.545010305160768, 3.3224683569001505, 3.7463280577420184, 5.730662717166778, 5.044864364299117, 0.08890570308532612, 6.006754777285731, 4.684500198233588, 3.6433891479014324, 4.7767577686405716, 5.333997497055163, 1.2978238090093113, 5.527706558175157, 5.431176674501863, 5.778226441296053, 4.83723332487675},
    {6.408834641343621, 2.007102145730946, 4.686329298250047, 5.7008570914723, 5.589350190509195, -0.965721614908104, 5.450277282052637, 6.551459484377357, 4.491240309946673, 6.343516131000154, 6.542290573293109, 1.9065372549960877, 5.867484218788283, 6.6961274655953344, 4.663496289169109, 6.214351311508129},
    {5.1552974282376285, 2.9407480733385496, 5.084067938658169, 6.153109054550136, 4.98998889773019, -0.6986220077203058, 4.638687917651091, 6.053571199786169, 3.235579623100779, 4.988035530365141, 4.687981779762269, 1.4276293030969238, 5.413669310452473, 5.326254919365524, 4.953702287715467, 6.520619947223346},
    {4.89495739353644, 1.9921222373071463, 4.205232289029257, 5.4325868608658405, 4.569589189289161, 0.18761855016223902, 5.8784398688870505, 6.023612907445712, 3.0100105665976686, 5.705785869759466, 6.05690742875512, 2.490768705009157, 4.0968599001258905, 4.7427376204681675, 5.425684619862009, 4.875252491037138},
    {4.917154225955801, 1.6818236295583402, 5.070348472413336, 4.840144238459393, 5.222092888252776, 0.7179708877767564, 5.729034016218128, 4.839831573712586, 4.126304917298431, 5.359879522586309, 5.12428576485451, 1.979004657886604, 4.552571157546818, 5.443943927589678, 5.565319946982221, 5.575268715226585},
    {4.609302188133174, 2.8042651931053744, 5.218107621688436, 5.6921966035689415, 4.918404501446399, -0.035659476395299886, 5.400353758653626, 6.15700306923106, 3.258409682250568, 5.706364218506717, 6.089023198253929, 1.1235199797862074, 4.809854435984784, 5.058448252824528, 4.727429099552185, 6.135711343190594},
    {5.852350559594172, 2.481827501572901, 5.0819226855121835, 6.588887543290897, 5.064648900639979, -1.1792555767559543, 4.926568887265961, 5.455306196609327, 3.55149382997034, 4.8928325543424505, 5.91971043579918, 1.2376159827719468, 5.674336437566728, 5.54816981811978, 5.188605076732339, 5.373467330500042},
    {5.492366660545095, 1.556592437240974, 5.022657023707567, 5.216293264240162, 5.488092089600038, 0.4173679816009557, 4.9216783109856355, 4.894568392345949, 4.007416400587383, 5.943362226365943, 5.363385785700737, 2.410902818648646, 4.308129162466329, 6.11177437248107, 5.59452514336721, 5.439924317017369},
    {5.598132923096122, 2.7593296265663017, 4.7880962085914565, 6.412878077177145, 5.396236473382274, 0.031015922998702247, 5.052655706011206, 5.306519556986972, 4.0481055605185805, 6.277744560126205, 5.5965643058924, 2.2913701244957134, 5.048554295077813, 5.607622519089602, 5.35533047192524, 5.479041627281155},
    {4.925767207415624, 3.2490459278921695, 5.643751416814315, 7.09527242466151, 4.613006072815219, -0.5518369572584346, 6.213746664385468, 6.028221943766224, 4.343602981986353, 6.3603956030325035, 5.250175588363682, 1.2023310347477143, 4.742932306321612, 6.665280562096727, 4.146423691750814, 6.709121592909534},
    {5.268663836060984, 2.5172044969360425, 3.841588425049387, 5.455947050665356, 4.2331343510365596, -0.21570579973536874, 4.535637837997563, 4.960701973117393, 3.287544447455399, 4.868923565858709, 5.4194734843370265, 2.1802971929924664, 4.911331864459648, 4.793254391935871, 4.44405580561916, 5.718912139017648},
    {5.854280998374389, 2.6542287331771295, 4.951439376673851, 6.449183117541411, 3.744830973038049, 0.5751561628687448, 5.883157494930381, 5.282708127400556, 4.500271457875737, 4.760112213557486, 5.695741415824927, 1.4319393826899538, 4.815641464421557, 4.42868143755673, 4.368321178484548, 5.899521153354952},
    {5.076715352775565, 2.1322908458720464, 4.7365500802957685, 5.703551748186024, 5.733180550047653, -0.42433860249458344, 4.397453608351609, 6.21829712145213, 3.989013288279021, 5.585960956536503, 5.729999481404547, 2.075733553300593, 5.905890913647255, 4.96219059226043, 5.1005982882423435, 5.154372288670276},
    {5.313766419490563, 2.7759065549583655, 4.025030389354766, 5.851912683357532, 4.150211427754298, -0.8082548928665769, 4.948306710105913, 5.639144624743297, 3.532641557725593, 5.1004346425135765, 6.122311538603454, 1.1649201486224439, 5.595129660628207, 5.950999549164452, 5.290012670268215, 4.90068886175805}
};

static const float b2[16] = {5.89773308682255, 3.2895065516624826, 5.219391582638802, 6.197058405753825, 5.276782953005228, -0.2747807549897664, 5.898239525596949, 5.940702695256012, 4.436278745200308, 5.870904969449874, 6.057576492605762, 2.782323220058558, 5.980615833155645, 5.789428214926476, 5.681851531045075, 6.136125679261745};

static const float w3[16][12] = {
    {-4.593970431856805, -3.849544464651419, -4.700799015146936, -2.9403944547379055, -3.1749496957309766, -3.77248585638004, -4.296463237838072, -4.674806581806638, -4.708086034882523, -2.9979415620593266, -3.4038060562416144, -3.823661663290919},
    {-3.01200960586593, -2.056726325574273, -2.081257328313708, -1.651713989734502, -2.331626378870192, -2.3052759831237024, -2.269097005034582, -1.292684421643362, -1.131853273888905, -2.47077547109567, -0.9806860860498987, -2.0160937421582905},
    {-3.0070631911133803, -3.821275296264247, -3.4281544464430596, -3.886135621836296, -2.848848099579976, -3.055915734416525, -2.4373815425732706, -2.7394789183634782, -3.98704635651202, -2.479343622718692, -3.3204732630636813, -2.600105530550598},
    {-4.441224960630087, -3.08157499788031, -3.481874895634129, -4.495011816953059, -4.76398184118965, -4.21130260825444, -4.047902755590561, -4.6241649486498675, -4.29102519434964, -4.318261694261086, -4.718877550856386, -4.810392816480737},
    {-3.727726834469024, -4.490257851383801, -3.5932096183553384, -3.243298215887382, -3.0134941039669094, -4.2295137200835855, -2.8214936647354167, -3.5955251766379663, -2.8245244168376185, -3.821955893878911, -3.0953996251210047, -2.9905247194956646},
    {0.8071451760327226, -0.3924033280716102, -0.911866361271245, -0.4085771964018282, 0.30227437609977637, 0.44060248308458894, -0.9128405510454514, 0.38886869536731566, 0.09630898174435462, -0.19139574756967992, -0.6867124368691132, 0.3240947846736439},
    {-3.083079402550763, -4.061363350711734, -2.8111394889561914, -3.0969858389197173, -3.3769725690752788, -4.633747730402708, -4.2026589856910626, -4.020782518518903, -3.078036891612407, -4.055653136130994, -3.683324715980686, -3.313611342793809},
    {-4.034307569694658, -4.328912500506595, -4.69668583493308, -4.501250815742619, -4.538956833204867, -2.9572231679565686, -3.823348969392944, -4.457404978358441, -3.3672961085968947, -3.190990778898022, -3.5965952516929764, -4.610526365338758},
    {-2.9664380304157, -3.168242721775344, -2.512614352283911, -2.816943238607271, -2.840810968017902, -2.8349611818141978, -1.623608942249191, -2.147019659413111, -2.889073053476525, -1.925059781890267, -3.3680169582054633, -2.9174329627834084},
    {-4.343801838828036, -3.3768174978786525, -4.379495532102033, -4.845573739656505, -3.4528619954078583, -4.044981220054233, -4.181308217239517, -3.0061431668220533, -4.419866677781584, -4.178345743881303, -3.952849244169841, -3.6349709015931677},
    {-4.039888204417324, -2.9580368956107894, -3.610383426931155, -2.9509889141755266, -4.480172622043475, -3.5210144366598195, -4.000212006608927, -4.078517751949243, -4.1430767033086955, -4.457715099460482, -4.327356573671123, -4.830080234961106},
    {-1.2296345811579374, -2.8165781815981576, -1.4950305426946722, -2.123730076476118, -1.1062040344159951, -1.8042700926015538, -1.6775296750956117, -2.30594349597981, -2.21058305532559, -0.991773428364475, -1.0118501012936867, -1.3505744758515295},
    {-4.1681412925953465, -3.091914445942733, -3.8856378515953627, -3.7229977237068494, -3.383369548672919, -2.7771226231759125, -4.199132364051091, -4.068994269239412, -2.6629588050438904, -4.092750309978588, -2.8588370031972, -3.258429049963082},
    {-3.1219007614624754, -3.96578021846177, -3.797924868336885, -3.4899303704881453, -3.7160179119400256, -4.2297828922097676, -3.4227675467547485, -3.5756842608331705, -3.9237661497837593, -3.6018604208443747, -4.137276033503569, -3.053093378373121},
    {-2.2571859302477435, -3.268010060107105, -3.0112403049104706, -3.4673410959729485, -3.2150595032207523, -4.142146902023714, -3.820221454412224, -3.302500372717131, -3.7317427421381373, -3.4800283839703474, -3.0604268017941356, -4.12094060936537},
    {-3.775546681376012, -4.338493701858432, -3.9505963247005806, -4.438342370696144, -4.886740526894482, -3.4289966643867156, -4.48212504493847, -3.5023061673485234, -4.072140772892183, -4.95390125920697, -5.015431430221113, -3.8950439486587145}
};

static const float b3[12] = {-2.7622557646328953, -2.106322608913769, -1.9361437416045308, -2.372553930687382, -2.4362108224391235, -2.103927489719277, -2.586261070441505, -1.944252914319687, -2.349335519714817, -2.4176427322371765, -1.974980983147205, -1.9953770711220238};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
