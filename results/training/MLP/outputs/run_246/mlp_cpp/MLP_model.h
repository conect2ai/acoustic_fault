#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.05642355161126026, 3.3383569629726084, 0.6741074055190382, 0.1874376602085928, -0.2540136697678162, 1.4541647828283502, -0.03911633549343608, 4.6944073119094485, 0.7036522122055495, -0.5075909106017711, 1.4254738861990894, 0.37009261150401523, 2.2284416586888405, 1.122964040211607, 2.759434147866736, 3.168877233616362},
    {0.5664863201763174, -1.939890993953501, -0.6643279343842037, 0.3351300147568414, -2.5233852911585957, 0.6741650548860133, -2.3435788846852224, 2.0256725956861232, -2.7421449850625446, -1.6793958162616092, -0.6759256544210265, -0.35896298198007137, -1.7620573427915718, 0.24504917245928906, 1.3633857230845645, -0.39701611456077374},
    {-1.4654393179455025, -4.871541195858112, -4.943752957736233, -3.43093707240201, -4.99028942798738, -4.1667503184919426, -4.400889721125958, 1.7078300308481902, -4.965915745502582, -4.597163658712831, -4.7148394208152355, -4.381580826396907, -3.2564029068198037, -3.096582407563046, -0.5958486052681538, -3.2217848643164664},
    {0.07705992907632007, -3.8309310453565457, -2.842866735125875, -4.633821919795213, -4.041126895296982, -2.764211014206036, -5.799617286309148, 2.8256497985177043, -5.608398259636839, -4.4416462240176555, -5.426678816120098, 0.34549127026951565, -2.072839387891289, -2.315085359808718, 1.0668410655633291, -0.849794176557058},
    {-0.27344633914037775, -6.119661204864851, -3.05578849878762, -5.607785261892356, -3.5890444175223153, -3.401555917970062, -6.132963519658199, 2.0446649946228885, -5.244809248507272, -5.4129768953084, -5.502570199745796, -1.9238652272054744, -3.6919376796237398, -2.8710251027778466, -0.031112301818569204, -2.4490439793683714},
    {-2.2804059258738567, -6.340481809772878, -4.894072477602702, -4.498545667750406, -4.345644000125208, -3.938299723344109, -6.631268326365972, 3.302124025015963, -4.889041239251591, -4.732740939977033, -4.913821812842961, -3.947853407339905, -3.30728817998417, -3.848143482080762, -0.34309630155903487, -2.988266494296003},
    {-1.0045487388562577, -4.7143150846247135, -3.124829652578643, -5.3898352967311265, -3.652446544423041, -5.134319780704033, -5.3585574562513685, 3.168123823561331, -5.824820132370885, -2.915331593556916, -4.330110933349998, -3.046828700956792, -3.1355990558267024, -3.821971336725542, -0.2775636818621343, -3.3006462883946748},
    {-0.08832252136761382, -5.035536139518397, -4.452121562949869, -5.130284150766234, -3.2823882310399473, -3.3375777463546785, -6.104794416918671, 3.5089550752898147, -5.238808960915746, -4.305212649656279, -4.753913248317968, -2.2638047232250487, -2.02864579101038, -4.2908094939796335, 1.297968094871773, -3.775861741160642},
    {-0.532067434012934, -5.0385757571195375, -1.7183926352094792, -2.488408446052636, -4.486200495243136, -3.3517514808502953, -6.0540984016092665, 4.202120735909244, -3.6541563225700147, -3.4556888400415184, -5.303377107323331, -0.07790349200827038, -0.15846482394535732, -3.8393459338129823, 1.7026121512882821, -2.240522982802391},
    {0.3109778633925991, -4.664008208800497, -3.0112745997835284, -3.6621257469312622, -3.298710329022147, -2.880852585663383, -4.715898476244051, 2.8575972780204597, -5.817093714427065, -4.0677742689559615, -5.163365757356912, -0.532338743778564, -1.7712483449141783, -2.8571949849144707, 2.5328367162522536, -1.869748425635809},
    {0.11659189949318549, -5.520548998253666, -3.041644067735514, -3.149338653663599, -4.5938873555338, -2.1860166617346657, -4.237710648277995, 3.226924949966198, -5.117227244706112, -4.909063459848054, -5.123818896254806, -0.9510487593259732, -2.1343547681301573, -3.7653914952927408, 1.7917075352968184, -1.9466155215449028},
    {-0.8240848849707567, -3.934770854372227, -3.4820301167044643, -3.476412662578349, -2.942517949729996, -4.0659030444344015, -4.03526980905837, 1.8635690518929393, -5.763007644451785, -5.847278874977352, -6.1600794373297205, -0.16957863176283353, -2.5250747781777734, -4.032651546045034, 1.9946090991481866, -3.8397758436410134},
    {-0.19472585673097112, -4.246549659572249, -2.6286217713353017, -3.5339662823572633, -3.9851357256129907, -4.660149093417384, -5.912965949387862, 1.0683417834885198, -4.453310926091472, -5.355634832197812, -4.8103886721277975, -0.3857877891249628, -3.450660218769839, -4.130169236057378, 1.9779809245857973, -3.340456775572933},
    {-1.5593537813970395, -5.598535026118455, -4.232262264495269, -5.141720207808911, -5.016807005778231, -4.2602749020628075, -5.948980659272577, 2.561489741077787, -4.603672226613715, -4.40822687077565, -5.375255447596903, -1.886376262038704, -3.8572068059731808, -3.7881187217593957, 1.3187268990487377, -5.474312683699422},
    {-0.8295058869913061, -5.47426229620275, -2.64042440753179, -3.7653785192012292, -3.8702791401200556, -5.064399380552216, -4.119812578788958, 2.0843317621278925, -5.036318169137007, -5.326617432562761, -6.2945072682805385, -2.402477744639075, -1.6570892186503885, -3.809612218795097, 1.1711356637237678, -3.4722369251960217},
    {0.19281450429184402, -4.148478566644153, -3.5725279997989348, -4.3385265231746395, -4.27070619778025, -3.373075109656282, -5.171600831422717, 2.1360786704956696, -4.691329413784553, -4.487030608920644, -4.762468038808589, -0.6950333210211205, -1.9513156929924305, -2.571573223387228, 1.5289123299518186, -3.6644409329633283},
    {1.4145093854343778, -4.195569534727195, -4.57568694730048, -2.885649180608766, -3.6362665816707826, -4.575891514623791, -6.2048986785926745, 3.751583880036067, -5.88006056464105, -4.229352040224646, -5.886656081282437, -0.6082881593642759, -3.055139274295557, -4.228072548522627, 1.7462976140381434, -3.4330581312743638},
    {-1.0111436113907757, -5.1269069194417085, -4.235983758750828, -4.481038538063366, -4.198458260841634, -3.352043308458972, -5.980870054687841, 3.631305557351028, -4.2672718474809885, -5.500759476338735, -5.750810513142606, -2.064470072092837, -1.7366433871193725, -3.7616322948172476, 1.843098186856949, -3.255970743704815},
    {-2.5734189559006797, -5.247925579695327, -3.126883422842374, -4.633335200083155, -3.5299760079111944, -3.6961583448263426, -4.776536453733175, 2.9913520467832684, -5.6466671145485785, -5.464157161523678, -6.074406382971062, -2.884830719260311, -2.7050600984530613, -3.866706291450487, 0.9031352087528218, -4.736451194332695},
    {-1.2007878481710277, -4.562702474354853, -3.3961906372518147, -4.256876675642874, -4.6207848726142124, -4.742988896750172, -4.470532138793759, 1.9916178405222944, -5.634039029527623, -5.280457928284082, -5.054231895842335, -2.0373103979168774, -2.77667446097581, -3.270935276610824, 1.5361765885910859, -4.144065700464728},
    {0.4723427741753306, -4.832886997842727, -3.8106118281373025, -4.985986188766637, -2.9123966886035815, -2.74780703933824, -6.08507651935249, 1.405748439347561, -4.5027415172706995, -4.246500426084541, -4.523315485873243, -0.025251681774093825, -2.602820005996244, -2.655078747025602, 2.758094221608815, -4.20735119058228},
    {0.2747808310985873, -3.3360721213534137, -1.8795868431768752, -4.194752367969082, -2.536788934205645, -1.6038789646407847, -5.266537418079692, 2.7364070733686714, -4.58555388057829, -4.2905128865594735, -4.558901231334173, 0.771148375547134, -2.162938093648985, -2.9481814332752307, 1.335265295242427, -2.0324558538886444},
    {-0.1719741927304961, -2.5123387007822706, -2.055003333012602, -3.246087038622718, -3.2916901387346607, -2.5270637779485985, -4.423218090385903, 3.1309608206283257, -2.666353554130046, -5.321138333066053, -3.1136967753413187, -0.631769010690789, -2.2667283060728387, -1.1565682020856545, 2.778910702588023, -2.4718827790077045},
    {-1.267144689076459, -3.116779254096399, -2.2508987606573663, -3.506101160469949, -4.110533822443291, -2.5197902568758255, -5.117600590648837, 2.242908701899841, -4.4011698820694996, -4.524570860891348, -3.813416075876037, 0.09292520921077388, -1.2275519282158058, -3.2852940873326615, 1.0369798282973826, -3.3004071160350597},
    {-1.6650526836409332, -5.271308711898271, -3.623524577576874, -2.7409529645199133, -2.5733141512833506, -2.7445684324024695, -4.270623007877, 1.9299627904655554, -4.91079527465032, -3.5315585397589704, -3.953147434481397, 0.8825787928756998, -2.133095342086854, -3.7712727704228097, 1.1711907309350698, -3.193327124565887},
    {-2.37196079491901, -5.046726830496652, -3.9580732656875557, -3.818044783316114, -2.95892914812382, -3.4834687374533, -5.1827333908869875, 1.9020805509685894, -4.594948327699382, -4.657364315968441, -4.079747074921957, -0.49644001398643356, -3.375003806864257, -3.1734302471236946, 1.1321127834045555, -3.6565545331787033},
    {-1.2189950313877478, -3.940380584097975, -3.302227113232837, -2.6850202671273595, -3.2386031734590865, -3.4982647816272854, -5.1039769584425825, 2.144361066638213, -4.059111744600873, -5.268607585022746, -4.7173037496024435, 0.0979255966014126, -1.9494920261414672, -2.7335054821157243, 0.4112176335578379, -3.701701094177155},
    {-1.78659698348866, -5.007642969066305, -3.543152298065789, -4.277583724953688, -4.060448829315721, -4.022025087248158, -4.6195489852833855, 1.7812100024469466, -4.168398274383802, -5.4029388473554025, -5.732953457776675, -0.6270358246416755, -2.9910827353083604, -3.376157298641573, 1.2432139510699427, -2.6723913522758704},
    {-1.2931740677643753, -3.7903065312699025, -4.002291205948391, -3.846563674761495, -4.748877292928821, -3.9164908366217563, -4.415350371397991, 2.2037123524387736, -4.0615713353642136, -4.1115218675491185, -5.00307580083633, -1.235140700492628, -3.4932986552894927, -3.199429584955738, 0.6712226961582778, -4.684377452322551},
    {-0.07750895195401229, -3.656618649110402, -3.018778695568216, -3.2882515160262726, -3.9427868659995102, -1.6758897885978956, -5.119646225315698, 2.603434596343763, -4.071951112161973, -4.567887746873825, -4.696943390680696, 0.75926906413062, -3.6406635078464675, -2.890771535524111, 2.5104298671511907, -3.310816365908907},
    {-2.902778790723195, -3.875116508400894, 0.008447629191153811, -1.278583480855401, -2.1111241395773375, 0.03630180168737954, 0.010768166892655931, -1.566201613346976, -3.9265452852438876, -1.4528884210186863, -2.1041206198754865, -2.1008913373686076, -1.071236980890019, -1.3784699175602242, -1.4409300984734954, -1.5306018996049464},
    {-1.8851292650594953, -1.3171605255204548, -1.3890093391954519, -1.5733900860652665, -4.496489519993478, -0.8524314682877381, -2.2220880291762874, 1.8540815400369666, -1.959866156246776, -1.4499519904340155, -2.2786812514439965, -1.7850501034544763, -0.8081042904561317, -1.8864543235014706, 1.151207772957657, -0.6430697998637294},
    {-2.3432966648496683, -1.2544374879597942, -1.0111492709098435, -2.7105577244534196, -1.8109597443027607, -2.4934216613918565, -0.9981353282186403, 0.585062795487807, -0.6290132083826911, -2.397940128250921, -1.6356167165186264, -2.4340481875460314, -2.100737315625589, -2.314637260326002, -2.0702290420583735, -2.821791515001166},
    {-2.5369445746650476, -0.5479447589727678, -0.2292514134487493, -0.9469419825767191, -0.5043668060521009, -1.1056938038732382, -1.123851697116841, 1.7694817304359156, -0.6574105086126412, -1.264071117137263, -1.7861196274451707, -1.7134265267663475, -1.085110298764833, -2.576441229589326, -2.0189616170416835, -0.6034732901089317},
    {-3.0654164667015475, -3.082134669295004, -0.9914918076524555, -1.632044403310011, -1.833149185036982, -2.17218948187417, -3.5731935328709286, 1.3391170063509539, -2.0746287654986606, -2.0685642458667117, -2.9924945174711035, -2.22698994548859, -3.029198450859801, -2.9900189113341606, -1.902602102205069, -1.1613090620111237},
    {-2.958154273369803, -2.791721787968431, -1.7041700615138164, -0.7331071570436629, -0.732775026777823, -1.641613121966755, -0.9543922940593625, 2.4032421427317665, -0.8668967318269066, -0.7377615735290705, -2.663358665709086, -1.3275503340127084, -1.5610777555078834, -2.3770460105863873, -0.6699293946104403, -1.4163333477783993},
    {-2.823757953927469, -3.531853729774313, -1.373211452653119, -2.8987906587742844, -1.7884891155664486, -2.979325853348985, -2.210827805452397, 1.8116688253703082, -3.509905806906037, -2.7197741320377187, -3.2391743798599, -1.9493128285732237, -1.594987110950492, -2.2466671801274947, -0.26459083426285634, -1.9423163146535694},
    {-3.535780149770535, -2.252576515586327, -2.5425942419845673, -1.385007557365701, -2.741080197574754, -2.297277844286684, -2.4953548037394797, 0.9382626906934849, -0.7165813000683658, -2.3346397577071154, -3.3171233184014826, -2.2154418357050827, -2.3167300366271486, -3.0129951196583837, -0.15896504467726116, -1.6341404362151832},
    {-1.7777864743649112, -1.7442457319970546, -1.5634502965049666, -0.531481576872696, -2.5725801587068537, -1.111801523871358, -3.3201166180100965, 2.4685659619201834, -2.34140927912401, -1.8748241456778043, -2.834752935883663, -2.457072003993305, -1.0035288002002283, -2.476990488499776, 0.03397618277745249, -0.20825643071837802},
    {-2.9704134798025623, -2.5097887836452872, -1.516942505859676, -2.17817727623144, -1.8599193156588092, -1.2954219472348616, -3.279767606818524, 1.723915701048578, -2.911211441944114, -2.4396490963424036, -3.5229914854104525, -4.007862538025061, -1.9189191073491694, -2.537815134095245, -1.3412622740530225, -1.9717171831891096},
    {-3.4120727931689387, -3.6249608465806973, -2.2748004430395246, -2.7345579604144485, -2.273624601961466, -2.236704794967809, -3.751078101824948, -0.07063905611930256, -3.922051677501117, -3.030274645406399, -3.922523237747736, -2.7611184767634542, -2.4439565706124937, -2.2451917239103842, -2.417139871093612, -2.0403566232170043},
    {-3.1748291939300834, -2.1420894954376624, -1.069449292243461, -1.422730009150695, -2.2752020499505177, -2.0194765590522454, -4.049494997173485, 1.3369170127626822, -2.8643693572806668, -2.050314504539636, -2.641048739939779, -2.941286477125874, -1.374059545210463, -3.625318990429754, -2.1566219096931993, -2.4184264257883994},
    {-4.100562682552169, -3.8169447262533773, -3.1880251633124677, -3.291085466194282, -1.739580628851448, -4.042971445698746, -1.6450296223240857, 0.8677752069485112, -3.2256983396697514, -3.9865577430406813, -2.4668079144173882, -1.888426837890338, -3.2376410551145196, -1.5042932046401036, -2.0619342871023343, -2.241445068928301},
    {-4.829906451654635, -3.9792808427655855, -3.139078344922649, -1.953842199004884, -2.3796989681838747, -2.901372529607551, -2.8829951260730646, 0.7705963202177434, -3.383345739528334, -3.680688204191362, -3.863502043607358, -2.6737621071646958, -2.634944831601606, -1.776220786426168, -1.5160576933795282, -1.393164228945202},
    {-2.5630753850726653, -2.643924178211467, -1.9458456163090019, -1.338397525059761, -2.7103476352365194, -3.1518287399908256, -3.404738253057915, 1.5785369183676823, -2.910974282802062, -3.357650369716823, -2.8180038904744933, -3.545870055337585, -0.6327919858041217, -2.3319416348167796, -1.5684281808788259, -0.7534453617026999},
    {-2.7332788597477005, -1.7233314447273271, -0.9860218447324843, -1.9314006634996521, -2.91774761758977, -0.9193513660337553, -3.6348155226084735, 2.292940410681779, -2.552539309594199, -1.6827891812767253, -1.8858696985963785, -2.961612005133466, -0.9697570509297812, -3.4236203530104135, -2.8436086968586163, -1.1891156949475723},
    {-3.4005763139300265, -0.49216648052825485, -1.1567788723618193, -1.6523888727923264, -1.2069381476569025, -2.9302796518128686, -1.5057594481844732, 2.4129640730343844, -0.37867789951462966, -2.0036099825372577, -0.5698807565905297, -1.7082137392675112, -0.26540346950921767, -1.8136996057633457, -1.6222367478644029, -2.1658910957754207},
    {-2.6391779421520454, -2.1359200460118757, -0.7823406825031253, -0.0892792589455418, -2.7089628548641134, -1.0931836236589343, -3.140852577025397, 1.1117806022727497, -1.2308783670635886, -1.4780119182957028, -2.446871975538487, -3.274150950137671, -0.45170817319586964, -2.3170468040961105, -1.8429618894649311, -2.1353173692964225},
    {-4.196944806631772, -2.1396923758249495, -1.164896812472445, -0.2266801200817562, -2.597298963266408, -2.0071084181874665, -2.173122640718712, 0.7653711498866101, -1.876195889251615, -1.9323504499790232, -2.0150782366055076, -3.410194827810186, -1.4848612480604886, -1.9540861297513474, -4.118121312214975, -1.6137423168764835},
    {-3.5003542684834965, -2.562899552986057, -1.838881835633151, -1.1064891485923585, -3.0963933413771967, -2.528709032880177, -2.74271151757256, 1.130736017669537, -2.027746935044989, -1.9825656643500043, -3.2341898036766734, -3.462465325130372, -0.7430974602832111, -3.671546560006839, -2.6041910838325566, -1.3728734704428958},
    {-3.0765932299039145, -3.7391490846794126, -1.1340900991240912, -2.9599176931119393, -2.9553536035723322, -2.978068618548429, -3.0333112004563123, 1.5856711911558228, -3.1466550393882877, -3.2050216367181714, -3.229925538919953, -3.0813782252738404, -2.1073756732742623, -3.0159543035072955, -3.4390463970259497, -2.0536690146335546},
    {-4.293787710328898, -2.891171494592387, -2.280186591211506, -1.8341244212032162, -3.529443791375037, -2.5265425974267535, -5.072816216598919, 2.508370029469272, -3.145308261748251, -2.2628227301446793, -3.463646177406265, -3.5083506523965875, -1.670604816739611, -3.410746199692096, -3.279616576803917, -0.8392014103032021},
    {-3.7276668049993114, -0.7898877410700833, -0.37593921610351705, -0.6543973058615867, -1.3691828626233382, -2.465950540715428, -1.7466202130432724, 2.2464750285420036, -0.6971539422708971, -0.9494971931693836, -0.42091499805905197, -5.052584538569355, -0.6544465127186719, -1.4061197986799143, -3.597810936966965, 0.441268632099541},
    {-3.942078415552645, -2.104372480484946, -1.2518596728087807, -1.5078644672534025, -1.4811921241493513, -3.6163307944379235, -1.0488247075330774, 1.9241030858359043, -1.108933682414862, -2.035751840501256, -2.007199271834554, -4.16392765596075, -1.030544609079956, -1.4942961412340594, -3.758151835638266, -2.5758139976644254},
    {-4.014414772807909, -3.585064261662867, -1.9361115605534482, -3.0476419832554016, -2.5808975402866983, -3.4964769347117826, -3.5579020568239397, 0.4508285418264847, -2.447725154162166, -2.0084241716286204, -3.932883044562585, -3.7952028793795884, -2.625979150850746, -1.911218205148335, -4.510802558742983, -2.9709433598570123},
    {-4.450123765424501, -3.2872991792279525, -2.1203983098454136, -2.0592732633245294, -2.0961882031823933, -3.4528267074850403, -2.468263158274375, 1.2003445729266347, -2.4056971321214484, -3.5691552053031925, -2.2709284167783355, -2.8563648114324667, -2.3087817559002697, -3.3745798140856986, -5.692493865207202, -2.7930340446721162},
    {-3.2065113955313005, -3.407390093217706, -2.0131111030869135, -2.0000065572107193, -3.091498423043182, -2.0192438702772306, -2.0775461467930345, 0.7523161172303017, -3.651171276190697, -2.154016108021378, -3.3138174898539177, -3.4801458506914864, -1.5687624966475762, -1.9319215502245735, -3.5608799930885446, -2.2110070796556016},
    {-4.591914617630909, -2.9005354345808096, -3.1688981985893214, -1.788562157290733, -2.644813845579761, -1.9498912993864417, -3.2621308083168095, 0.227988931721004, -2.126049244710403, -2.589557943229737, -3.940687753351329, -2.4453982935341516, -2.3000782433231075, -2.4433487243046588, -4.17676099674648, -2.058413307532179},
    {-4.803149209827642, -3.6713629837762576, -2.395028416177564, -2.4458977116413245, -2.5264304715461035, -3.2385444953495264, -1.30862272181872, 1.6211050225766144, -3.0483170628745575, -1.3470721333346416, -3.470579699242117, -4.3587885994719135, -3.047328357898489, -2.8207113644943256, -5.539394270281455, -2.5132895362710777},
    {-4.142272728435247, -0.7391476727579069, -0.7897224023898739, -0.9569626516258698, -1.7926975873691495, -1.3090950345980237, -1.215017139874951, 1.4545858207883122, -2.12792762799223, -0.4485913788609602, -1.9049771035723864, -1.5863466447722059, -0.6559512228791278, -3.7055047036234194, -3.326472894852882, -1.6806546301618646},
    {1.0851799259569381, 0.46593809150615717, 2.0921948228587715, 2.615785173569494, -3.7829443655730213, 2.6360367285145005, -2.5414230193801233, 2.3948528850181465, 0.9435639197872676, 0.47303050528018703, -1.1820320146037333, -2.3896449406805345, 2.157172688749173, -4.7448150266731455, -1.3303815605229872, 1.361033840926167},
    {2.643202033902684, 1.3436733905681102, 2.8776319085649353, 1.3370127338577231, -1.5129765760551865, 2.615345379591758, -0.523595797488287, 3.5650011409070945, 0.1142602795902391, 0.11930248341449622, 0.5205390505546846, -1.4626041675142214, 3.0019905074509263, -3.3722425526377635, 0.24152389848769396, 1.3181412166564777},
    {3.360725645237528, 2.076564352827213, 2.830268329407368, 3.0372325383913084, -3.2607302546977306, 2.549059684664399, -0.37218124659282736, 3.5584694346651555, 1.139226106265672, 1.1316656848419975, 1.2601812145662663, -0.08991822144224382, 2.8768968600200098, -1.8739781788870304, -0.1272506040453973, 2.2168225154373555},
    {1.3476187713663856, 1.973610343230792, 3.2308298446496657, 2.593933742067506, -2.0954162825093436, 2.978271485657485, -0.026702221686139845, 2.7010913142825346, 0.8572857879771258, 1.0558972960782205, 1.6683180476658177, 0.44225454127136243, 3.797841777028803, -2.1875538038321465, -1.0045979892652435, 0.6953174323877328},
    {0.9167058676297674, 0.9410139551400372, 2.0136244415535924, 2.455746063634458, -1.8429608741602161, 2.0640147532557505, 0.09298452910373683, 0.8088445575637772, 0.5181474897916265, 0.21072084197355212, 0.5958444875792556, -0.5444556386867587, 2.6135273013470988, -2.381867118748916, 0.31789229311830114, 1.2916708609290704},
    {2.152964987784941, 1.0814041545600197, 1.652135086107085, 1.4947163739466165, -1.8617370722879065, 1.983551340236909, -0.7302304704196708, 2.0227303511487587, 0.4150834000455559, 0.7833576476470229, -0.12625936054524153, 0.19537897815371194, 2.6473114482251603, -3.129775099288515, -0.6204796965462788, 1.393030864047437},
    {2.9460435404516465, 1.8187392370312998, 3.584010504432712, 2.406094956638368, -2.4642358487122276, 3.2770661241722365, -1.9089161768687597, 1.1637541699375922, 0.5668476021096552, 0.7354172978803298, -0.9972034672611598, -1.8039303211973325, 2.5055599015572105, -3.1042850303065017, -0.30254560406227604, 1.2752074580781814},
    {3.4478254614238613, 2.544542547406532, 3.6246529042167475, 2.0176978832801975, -2.621244024611903, 3.1792272133475317, -1.3405764365192085, 0.30738958120368826, 1.2274349376608085, 1.6433544192570864, 0.5876792690218217, -1.460776382599733, 3.1070853962528036, -2.024393587759828, 0.6203222583499783, 2.2292863273029253},
    {2.8048262512792363, 2.3689160206036974, 4.306245591310919, 2.1015378178072073, -2.151394720714971, 3.9389429477716216, -0.3505318549547177, 2.0296073424469148, 1.6936975838310913, 1.4903045176072147, 1.1235795312324588, -0.9011014863415433, 3.533314694975773, -3.036241210343268, -1.3496994819596837, 2.44134421916289},
    {2.422840454567874, 1.5500928297834338, 3.614204362502843, 3.545057208683903, -2.0506870146198932, 2.924156547415468, -0.8772332430621137, 2.74214517025241, 1.1196164627196452, 2.0716938862077323, 0.6674708155983923, -1.0035148354169023, 4.259342913831688, -3.3732879609561195, -0.32187920616038235, 2.2234145711244273},
    {3.4749970964334507, 1.460918327012422, 4.426269764541877, 1.805584051766189, -1.6288682414007871, 3.6563788381953195, -0.38256270143391163, 2.551970009955513, 1.5807348768434277, 0.5317781139217655, 0.1890903385426183, -1.227207833995805, 3.742594356311138, -3.694563989013368, 0.49064729095682474, 2.623638895481692},
    {3.354316439894004, 1.97348641066385, 3.2929172974863534, 2.717145400277706, -2.0321080221326686, 3.0044865208324563, -0.8739349456850448, 2.594079691240972, 0.6781472821358306, 1.2247106335744238, 0.3899430754107512, -1.3764756493708163, 4.485821854236034, -3.9705672443785263, 0.8733149251759214, 2.346650744375213},
    {4.481259040035883, 2.9692749304324684, 3.935629005443437, 2.0562033750506616, -3.0847426738174137, 4.121238514470203, -1.8496766494417898, 2.670078186485705, 0.5189858533509728, 1.150944157876801, 0.5943107831546899, -1.1227613145067483, 3.443078105980841, -4.515400943168599, 0.17129723070338915, 2.668980597940452},
    {2.6108734949461594, 1.9743432023573853, 4.4613620732962, 2.55318916076524, -2.217133732026364, 2.8279456756328623, -0.6932163715785297, 2.8020741649979244, 2.5457725504135658, 2.5509908138934394, 1.491864284711875, -0.654622687018204, 3.1623447190648237, -3.4014188048523373, 0.5413033697479516, 1.383264868542674},
    {1.8667310354050906, 1.8982402475106575, 3.7970145322486615, 3.8264650440652246, -3.7227202478639057, 2.4990791981334826, -2.240393465510171, 2.017719306548386, 1.5729416737238662, 2.5726403874875783, -0.4551173613041785, -0.5479864531924484, 4.3517781248600835, -2.9651127614419432, -1.4368111962718744, 2.1838783370995336},
    {1.5631128059017936, 1.689113074895241, 3.6354684985244896, 3.3058707254361153, -4.765261859233111, 2.3080817932135593, -2.8643538767924737, 3.129540657857606, 2.0645914651402175, 1.281906461464464, 0.6712064699954478, -2.1287763317962187, 4.192083687713895, -5.212023409643441, -1.455371334845664, 1.82374202879227},
    {2.977785631463646, 1.0715416057523253, 2.9848646307885898, 3.3523123576144704, -4.427203495026325, 2.5359315323810177, -2.9670124159618214, 3.092773936011389, 0.9541098326132917, 1.519453368100782, -1.6872920276120504, -1.8336665099128493, 3.2309977624904276, -5.599460629791947, -0.6924955610382326, 2.141244784633336},
    {4.347288312128462, 1.4914316835852557, 4.397006079348508, 2.4834703487299685, -2.721919488123412, 4.171896115524703, -2.116725476558959, 3.075578729420814, 1.015308254517758, 1.3081017127383752, -0.6244344205859551, -0.6495778543251313, 3.9573719089560395, -3.4162577654219577, -0.3755320838735844, 2.7479507810201462},
    {2.9381095780312663, 1.2972904064693942, 3.402251717920273, 2.1451836776229185, -4.247831093682866, 3.2667237764793935, -1.3954807872233927, 3.3345685808316587, 0.675306836546317, 0.3766093433142637, -0.17328984362181146, -1.047951806275627, 3.931096591499246, -3.6051613481653852, -1.607275888159489, 0.8741503633469123},
    {3.7597955282652773, 1.2229475351559969, 2.627710541702519, 2.5580483096516176, -3.5254069599064004, 2.755379314578285, -1.3591531288084708, 3.4611031043544243, 1.5600877464658192, 0.6455344585518489, -0.5979279179246737, -0.0971684997798248, 3.8981892603737975, -2.944564922351964, 0.059864517692107724, 1.8169343645504221},
    {3.04112487709411, 2.055966403006602, 2.3941963665971073, 3.2098645941367177, -3.0132424621520437, 3.0223354971336818, -1.4584529652079958, 2.119002710570672, 0.24177881661797224, 1.186825725433533, -1.0112397871703407, -0.8801468368555196, 3.516086586116302, -4.830085336121312, 0.7558828133254669, 2.220084534943142},
    {3.972331700769956, 0.2776257623085737, 4.1864733123751625, 2.8737535517518626, -4.110764597948369, 3.6563649168562726, -2.4804453148138035, 2.7516565762216953, 0.5661968260891151, 0.6689748741013168, -1.3820724553810046, -2.07025616796579, 4.6205747711618566, -5.170229730296396, -1.3475108917313687, 2.6089882189282307},
    {4.029973533507939, 1.6159385925996836, 3.331941852799421, 2.624832444211796, -2.8350293562582816, 4.228025893073782, -1.8704245199293317, 1.980902592998226, 1.4501662391475412, 0.6016638431133209, -1.020875653273249, -0.8382392598295723, 4.60859329670141, -4.132770286158732, -1.3871241987963323, 2.563531594501559},
    {4.118949904987245, 1.0832056175338598, 5.089971548858854, 3.090204176707267, -3.581138171486794, 4.628529371337604, -0.7245411417865575, 3.1115673763322818, 0.4667345406321393, 1.746213779515928, -1.14125385132146, -0.9923684252404733, 3.434607134215701, -3.996301865617919, -2.1327237345786627, 1.5637591375337156},
    {2.824353859852368, 1.3014059458836402, 4.940666421263683, 4.447728673826612, -4.385312635916567, 3.7571315491405266, -1.661241581055371, 3.6292182051729136, 1.9349592066915429, 2.407790682858158, -0.2576985811766721, -0.819337584298256, 4.763665322463679, -4.031995597372873, 0.17301887619485468, 2.029958629516991},
    {3.66543826355442, 0.8485347592013209, 2.951661464626901, 3.3213256272145997, -4.191108194705738, 2.923720234407111, -2.627411417372766, 3.5373492324325326, 0.8811851709414847, 0.6063398218269328, -1.5645507774120235, -0.8341834150896609, 4.733347797013954, -4.0413881582355815, -0.7797974263404301, 2.9934821905464455},
    {3.374921879345038, 1.9715257693874964, 3.4733657254036596, 3.5284067628297584, -4.737701196888789, 3.4616818280629618, -0.9971081459741477, 2.053123369267585, 0.8209503183823987, 1.10855610917104, 0.09665609452341614, -0.9809748514650799, 3.3720711645182053, -4.668110525686025, -0.2599769946680116, 1.8105422317424362},
    {5.030253809007015, 1.8712870468354081, 4.667687068764775, 2.329538744917559, -4.163014546200971, 4.315808303773998, -2.2994779846152795, 2.7036245993041663, 1.7717597924961273, 1.7784266269736975, -0.5290217338499668, -2.0294311926194015, 4.034866331412978, -5.0416241730190565, 0.22468989711379916, 3.3891520229540686},
    {3.845297102470256, 1.4618355356184531, 4.000023798731554, 2.875108162103682, -3.7393104256273757, 4.208486317030528, -1.930071033161991, 3.786803891140331, -0.014872626962037342, 0.20039098912778716, -1.3333672514949797, -2.4864422516203586, 4.215503448010619, -5.2250679824673885, -1.3226912579870505, 2.0341468800786386},
    {3.214926032978123, 1.5005112198027044, 3.7453384143558477, 3.8963127706632315, -3.3643507866850326, 3.8636487754275555, -2.326937512828175, 2.476492042367142, 1.290371895799633, 1.8266127496491609, -0.6341693970903562, -0.6507543181376967, 5.022103994679597, -5.3443998031296935, -1.4611280221699274, 2.8856142152285322},
    {0.34659741370202357, 0.06367600353404716, 1.6224115824224974, 1.5566070861186017, 2.0567493165337787, 1.0006051038237482, 1.8519605324351336, 0.4645231740906257, 0.13895770551758405, -0.19855721269476054, 0.49597154094550105, 1.3378135163566447, 0.5260103017342684, 0.07524889827692244, -1.1934809835118576, 1.2499548162052225},
    {-1.1575022168901017, -1.0918692700334942, -1.1380052006885815, -1.7661709446003755, -2.0136119734992897, -3.2510819593048828, -1.3992543539192406, 1.3577265992014322, -1.208982520362697, -1.4859684976037935, -1.8387753100547333, -2.584636738967322, -1.4067330566663765, -1.0667588279012548, -1.7674259028197914, -1.5342320368085232},
    {-1.4123711501780252, -0.6115459130497275, -1.5341685992184932, 0.19383819923624132, 0.08856933691055369, 0.04978451594029787, 0.7615978966635321, 1.236231165392168, -0.7230661443758952, 0.11511132623108992, 0.15044195349820524, 0.6303085471680727, 0.2573928609455573, -0.17923982585038356, -1.1117613374952735, -0.9519772233263295},
    {-1.544065009141907, 0.33226859196450564, -0.18738180819535838, -0.5898396776473329, 0.11584785356453091, -0.8267980940250771, -0.028872555444893484, 1.2381216816064429, 0.220111503783154, -0.013849437803334001, -0.693548299963095, -0.9201389396036308, -0.6076572217683691, -2.023334785457857, -0.3628323965270005, -1.2517203340959162},
    {-1.2971317035770764, -1.1269529621431524, -0.6400429604021632, 0.11419327025101327, -0.3291563807089209, -2.087671939637736, -2.0558679960146993, 3.35879140405939, -0.17484024243585874, 0.08129727424021396, -1.8951009923779534, -2.1648069579707307, -1.3818425403216874, -0.9695892270591874, 0.47854476723988065, -0.059688671192934466},
    {-1.8224151450379054, -2.341261807892448, -1.025113277878271, 0.03639128162758513, 0.7121779080264321, -1.3930423512014494, -0.5209805628195071, 3.160727070680248, 0.3459979457112232, -1.1119826132677355, -0.9013184214962063, -2.038649958335563, -1.2296174597383214, -0.8874127161531753, -0.060216366723540485, -0.5854970508341208},
    {-1.75956442687328, -1.6344995789602537, -1.2022357779725992, -0.47932750490087744, 0.02883528540591251, -1.0442038156621527, -1.1134814349472981, 2.728979721348582, -1.9648694921482652, -1.915121079398298, -1.9099240704521792, -1.091168729455407, -1.0265112315769087, -0.9549410540297781, 0.3000397954774927, -0.5390889895539112},
    {-1.141883286290411, -0.9399594887458708, -1.1673499876765465, 0.3035600600044417, -1.1771183959945417, -1.7258728902364784, -0.9856549908488815, 1.1026004749752856, -0.12688181445848984, 0.054653808629797414, -0.8677397930264039, -1.6901142470718018, -1.035814384950374, -1.1758548934814936, -0.8980966141733903, 0.4298423000580965},
    {-3.0903902751551384, -2.746067957371262, -1.783598128661833, -0.009403127157896889, -1.8098648411064973, -1.890767583999754, -2.8574308691909245, 2.6634339188738174, -1.1172320423566693, -1.8872128815029663, -2.8124153361348663, -2.462129030575811, -1.038208149838532, -1.1008557942845822, -0.03529655093522734, -0.7038292555112174},
    {-2.1282703579561435, -1.712591540626175, -0.5727620466714775, -1.8987634111737268, -1.7215996049039273, -0.7619367313567695, -2.2278007800466204, 1.1710765726434214, -2.9633227339189214, -2.6744106940244845, -2.4447879027208956, -2.5585769231599054, -2.2428954577117928, -1.8436569419120499, -1.4038826410247995, -1.8627318237184336},
    {-3.1033200595494552, -2.2832832123393505, -1.4204996634132279, -2.261173939379438, -2.2505289064193925, -1.4189554274727005, -1.9734011014836483, 1.3667303070955614, -2.498368870900772, -2.084156370784203, -3.0064023739593964, -3.1008284793942433, -2.615368287599265, -2.590839076030386, -2.7824054061965673, -1.6551945737792877},
    {-3.1742006812954595, -1.5146853393879018, -1.0788540131260276, -1.0557748339027735, -2.7362877903059615, -1.2995413023945526, -2.8569577806200717, 1.486667621369716, -1.5500907026950892, -1.84096735356561, -2.9069640187125105, -1.5622867418385546, -1.5523914697150656, -1.7159262238479476, -2.165230024548236, -2.632347174216747},
    {-1.7959259466462576, -2.2949226879753386, -1.4243590147742045, -2.056875430301997, 0.2621232138941516, -2.2566457850935286, -0.6092936432979668, -0.1020643599687515, -2.460671199218244, -1.892845052559979, -0.8467660616513935, -1.4057153115365435, -1.9410764647056895, -1.263982375751309, -1.0186088241130586, -0.9718489611857727},
    {-2.356688986365131, -2.3266679277310343, -1.1196007343761287, -1.0103504957750848, -0.5999404341186609, -1.2473255613613754, -1.31895388185243, 1.0935768637673304, -0.8416635083686408, -1.6957266978003611, -2.509557156887049, -2.046446029623912, -1.1747977903594258, -1.593758329085962, -2.204420602445152, -1.3202426471356545},
    {-2.62627092032351, -1.5751107526591974, -1.3851097376603185, -0.7665640228921419, -1.751630357508882, -0.8230538603957648, -1.9804820722601646, 1.8093755596234466, -1.8780421596256087, -1.825526801358207, -1.3790035018886992, -2.803656442889483, -0.16289312756332103, -2.185681010550961, -1.8517995888895113, -0.2926796487787274},
    {-1.161234373038826, -0.34717763092836973, 0.5610494112507053, -0.2702515266644284, -0.8870802718877737, 0.24026958288351205, -0.5177084072691887, 2.4086636946756887, -0.10188796853827507, 0.42856296645900327, -0.7851268784729247, -1.6725137003101693, -0.6705530935049608, -1.7909558459694646, -1.0482477757441657, -1.465664145945381},
    {-1.6099161224648653, -1.0843881174453298, -0.3375505464359189, 0.6122636822654764, -0.3585213121160463, -0.6592460772112515, 0.4077126277505446, 1.3533263233762776, 0.022800742093557397, -0.292296541447936, 0.6531169611669525, -0.5303588280022599, 0.23647668939097588, -1.3957311469566582, -0.7300563596585445, 0.4426519314739846},
    {-1.294776808689972, -0.031690934733211315, -1.308053212796359, -0.7635539118555768, -0.5197073673561943, -1.9709043489195686, -1.5333507619312552, 0.7529283861431756, 0.49550109502411016, -0.3675891066917608, 0.5918814002095365, -1.0717326289542477, -1.0690676103608283, -1.8248939439945326, -2.436302274445559, 0.22342445792141835},
    {-1.9615009493052715, -0.2535990600151051, 0.34539941674176616, -0.07805502088304384, -0.5468807145885611, -1.466294653374272, -0.9601028557081525, 2.0106231619006643, -0.6219076874874565, -0.4891966659795162, -0.9107590404939743, -2.008792037168469, 0.38435892758297124, -0.08342857221957221, -3.3973210320336777, -0.8789176887824102},
    {-2.7732149193101363, -1.3307726170600727, 0.5454241845795795, 0.6338147462566323, -1.6128250401165392, -1.7655963739729241, -1.6933050186681833, 1.0687387059726214, 0.33074416443084104, 0.3957688666557014, -0.7527780111463456, -1.7129077833339834, 0.35955639886788887, -2.188710226773812, -2.2011402895023218, 0.28641032977712405},
    {-1.3428437643454527, -0.029155983408995906, 0.011412630354268977, 0.7897184816482029, 0.9012842826140056, -1.5392164469473277, 0.2097295449592743, 1.5993950403916957, 0.8697958047007003, 1.1860881403300174, 0.3706572350218466, -0.5501675330405728, -0.3184598484060831, -1.4091742365559343, -2.7672750205111973, -0.3674053643857553},
    {-3.434194227405151, -0.11546827850846118, 0.3936643396145142, 1.1956494820724404, -0.07188005616814558, -1.141497762815814, 0.6918547595023384, 1.9188508710770273, 1.5429071968876749, 0.8329746024395837, 1.2081219139248287, -2.6140659791034007, 0.44271332644653266, -1.6966317895368088, -4.520597803214457, 0.9167916316088512},
    {-1.318511723164552, 1.2264662627096141, 1.2087859341028155, 1.9254300799832307, 0.8177298066423072, -0.6837444606648372, 1.483423633702257, 2.1032810762494, 1.0449143215891334, 0.48828593626489986, 2.185078798906315, -1.6041269669811782, 1.600552143916019, -0.5750759484831607, -3.6958175012549255, 1.5103357052187383},
    {-3.1226944541970827, 0.25999330803781384, -1.1664726150124223, 0.44061912688656746, 0.885023836658837, -1.6959184578764277, 0.2519838526065835, 1.4456374296128671, 0.9355484052946565, 1.3015314015400532, 1.1647672074146986, -3.216564105759546, 0.734649911750454, -0.040002794652421604, -3.1362857413748753, 0.1719340898634521},
    {-3.0609237476562714, -1.9168795100697613, -1.4170175986185929, -0.3121816943679966, -1.7288673938747274, -1.8650467742910481, -1.0828448696780133, 2.2489232226174383, -0.44993914464219426, -0.45587836974805024, -1.6432906297452885, -1.876723021454358, -1.6912432256202914, -1.0248051857263514, -4.254999010757434, -1.5784237402951944},
    {-3.529264676970172, -1.9429874946210868, -1.5919193616211333, -0.7078320888984231, 0.5272157490342856, -3.0524416639145997, -0.5642145422379914, 1.1803357306621975, 0.03343066648454881, -0.336174420826287, -1.0813792035619778, -2.6878786509716495, -0.5199607412280759, -1.0985373525313928, -4.383281927641555, 0.22086736881232294},
    {-2.6111682551554543, -1.5290974909136072, -0.5230804042678618, -0.7202392218727509, -0.27303392353562206, -2.3798526853331716, 0.6462462388626397, 0.9214563181482204, -0.31559059243025844, -0.38240481114738845, -0.008115640169249984, -2.3002611481957738, -0.3498376933944348, -0.8013968824043743, -5.17575561529898, -1.5680106637582951},
    {-3.882746547925977, -1.470849870789447, -0.469044571863437, 0.7184824371769587, -0.7282435933346587, -0.9777823873671893, -0.06354824532400492, 0.8395363541717203, 0.0005762036691724821, -0.9931132659683933, -0.31777526073273754, -3.752050584020513, -1.0578293673855166, -2.0876888468717336, -5.55192780128527, -1.7901335798399682},
    {-3.6531530786047024, -0.19818122825230788, -0.5565764689962485, 0.4465351381896082, -0.18746138249415986, -1.5814963806750408, -0.3439295692441276, 1.3819364288373592, -0.7448802197632892, 0.07556689658069528, 1.2296841080065715, -4.547460608026922, -0.2302985123476144, -2.444644659723223, -5.359187477970157, -1.300793751516319},
    {-3.065998272008381, -0.02116343021737114, 0.8649147052794068, 1.8664529190400734, 2.247638804288364, -1.219774597773025, 2.442662378505015, 2.705957081506505, 0.7820082691267997, 1.4028278718227958, 2.351082870288213, -0.8539002141499878, 1.2598520310528567, -0.16769882952137818, -4.562502208725675, -0.3410809740729483}
};

static const float b1[16] = {6.501391254251782, 6.125699779599836, 5.9048530297416155, 6.176518666440827, 6.467594824884802, 6.313863043896865, 6.769923393990734, 6.949541566260659, 6.153182138463085, 5.4736691610216255, 6.576292928418092, 5.892880615633699, 6.569289152245108, 6.640966917247374, 7.109213796185972, 4.8769359716346115};

static const float w2[16][12] = {
    {-3.9652487986857206, -3.3874433501735526, -2.7286873501622693, -2.9556997028446275, -3.7302880976479584, -3.042568472156231, -3.7757352700723725, -3.0000903639187553, -3.628344234631613, -3.9556834793314306, -3.435875491524892, -3.303977540118604},
    {-2.6870994702111983, -1.9583074168178476, -2.6354846448824323, -3.7067970338633622, -2.971453429354218, -2.594460554490605, -2.6267108022947356, -3.5122088512897425, -4.049800730313347, -3.5481294707462925, -3.9241986662402444, -3.7876291213107276},
    {-2.7414024454052033, -2.80057206336737, -2.269188428707185, -3.440467049417952, -2.883435556884789, -2.8445035561359933, -3.490572429145972, -2.2483023638012503, -3.571328868576528, -2.504811476312992, -2.21216752986058, -2.3845721591522353},
    {-4.0417364042685975, -2.9848535214580587, -2.422218018011428, -3.219988936383156, -2.8292374558540323, -2.0641493847739243, -2.8120139070340806, -2.2840169639143633, -3.356912031469569, -3.1610810415222437, -2.400622186621907, -3.7399568874882494},
    {-3.3239804776932687, -3.355360057265741, -3.6324395000507774, -3.300073128619618, -3.192845577393886, -2.2616118140876007, -3.4821347228769186, -3.0035762545113003, -2.949918724092467, -2.7637090795754133, -3.3941286007936835, -4.181921398246783},
    {-2.739143000176679, -3.8528413122989833, -3.7771452904137277, -2.7580648726956087, -2.739335866485628, -3.7554540672805476, -2.5855044451885414, -3.9673984793494528, -2.9637626571050615, -1.8915403631564323, -3.219740456588384, -3.5304994112214634},
    {-3.068483745771288, -2.6483174877328923, -3.3717782558230027, -3.519711942998371, -3.534775074121528, -3.989663344638208, -4.122399277808397, -3.3240793440176493, -4.1289668713930885, -4.39686523537477, -2.236550139823645, -3.770560344845259},
    {-3.5414662849654692, -3.437933553363073, -3.49438218919269, -3.7595473705858757, -3.4815384239384337, -3.456334980591825, -3.549156143985042, -3.480077949162464, -3.460103341360108, -3.471052477192152, -3.7372718935105382, -3.4516233806499894},
    {-2.3979110247090505, -3.268114195095416, -1.9470711437447334, -3.0130693958935573, -3.7323473026950027, -3.195664020464456, -3.524355437439157, -4.095705126449013, -3.4122435684453514, -2.885311154674906, -3.9153289999928496, -3.5775278707961156},
    {-2.75946075096801, -3.237800048878306, -4.131951269156482, -1.7648063351661214, -2.295376734368377, -3.3346448236864736, -2.852730363303496, -2.417697722560718, -2.1678419145020524, -3.6098443942927547, -2.422971365953302, -2.1826044979284944},
    {-4.151696169187609, -3.9652928890412644, -3.775681159524648, -3.061569019749137, -3.6315658920820226, -3.3555095371765127, -3.059188949175107, -2.8610926818709523, -2.7116532005217473, -2.7179329192291886, -3.2093138181100915, -2.8209926649475987},
    {-2.7290590218448454, -3.397359884478458, -2.906491698311137, -3.7176507494582305, -2.5220602607024127, -2.610599676291736, -2.8574389379164282, -2.5007783610340724, -3.5891508367008313, -2.2292561600004115, -3.7062086925801836, -3.4489695133555736},
    {-2.793726792102127, -2.7114115858604886, -3.7120142422272027, -2.892460597728403, -3.5800618154815917, -3.5931847942824024, -2.1282022350288625, -3.7049768759873865, -1.9215143824233964, -3.840700279001225, -2.6926724320845987, -3.2054883811552477},
    {-3.8554930750660326, -3.712217131263943, -3.191430737363669, -3.5024606611658484, -3.7655840037944692, -4.216505527212039, -3.4373352676884172, -4.449087976623049, -3.385264568398734, -3.9992227672103926, -3.9511600489082404, -2.698803864286373},
    {-3.280012180536466, -3.7419330054868345, -3.701687107205771, -3.280841935948997, -3.4444771725981287, -3.8920284749931993, -3.064398824939885, -3.3335810433954247, -3.8665876370679646, -3.327568139610556, -3.271466681426236, -3.2276607506741297},
    {-2.320094916114489, -2.5485074166230457, -2.989874024314165, -2.9752898755397057, -1.9049774622003635, -2.1503144505572984, -3.6842079368002527, -2.6078915640104823, -2.170121187129825, -1.988408878065513, -3.705128831594713, -1.223492298624702}
};

static const float b2[12] = {-3.958156048284203, -4.853092770073504, -3.9128722761766226, -4.4706729258447835, -4.179541889133721, -4.565086775890691, -3.991582782284678, -4.2392061746094205, -2.711297856675342, -4.623984442487435, -3.762702506753099, -3.883614324670029};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
