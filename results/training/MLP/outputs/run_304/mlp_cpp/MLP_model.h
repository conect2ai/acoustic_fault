#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.2235841082969432, -0.11251882665000974, -0.8852482182667509, -0.3862125054414451, -0.7276750848959496, -2.7213308970718666, -1.193297422577009, -1.5224305183300528, -1.5316453319830294, -0.2819438301623256, -1.015844647156306, -0.054997570007151525, 0.6415461501421647, 0.9242197113516963, -2.2235482444532537, -1.4795002610941885},
    {-0.19345384958696832, -0.3943469683535605, -2.2566438528293205, -0.651539657311258, -1.2976978864582083, -3.0059993949067447, -1.1236462255659498, -1.348843641902687, -2.097917281491298, -0.4090601434633587, -3.1351184248904143, 1.1017642904647065, -2.0062356513300763, 1.3493295099417233, -2.1484716869686715, -2.4283102754783523},
    {4.10025155127629, 0.13493088374518641, -0.8111395729486907, -0.9219436974008172, 0.040410701079297236, -4.682108511793639, -1.391639148542145, -2.240784174002845, -4.271816214243042, -3.1987566849105784, -2.1365608740218085, 3.6710508718481223, -5.298206639469683, 1.7603198347963454, -2.545890906631013, -3.2748953828775123},
    {5.059871263108806, 0.3818287448823578, -1.7696579983735747, -2.387641796472454, -1.425328158993132, -3.950262548827281, -0.3445728699828658, 1.5589656546540667, -6.214692373692286, -1.6369853224152833, -1.6960051240614336, 2.9737919180691237, -3.8087547628441203, 4.2946193531023535, 1.5156817805361733, -2.257010135150501},
    {4.353174238050929, -0.11173417638867728, -0.8616090622626469, -1.194011797280045, 0.23331691597637036, -4.226637906405828, 0.02767202053292658, -0.30908203370298415, -5.934532790453971, -5.0123921222724555, -2.024230301194733, 3.6073289082506297, -5.157121824014987, 1.1258516079511256, 0.9703809338703503, -4.006482662399472},
    {2.1884760283633993, -3.7433473503672703, -2.4326475810659307, -4.529798967512341, -1.3408173269790735, -5.522684224439931, 0.30641333890999756, -1.00673746473364, -6.469392942752551, -3.581382257382789, -0.5926912617504524, 4.114252674115114, -7.110719339467379, 0.16047044339018904, -2.2930748163791006, -6.313494980371305},
    {-2.217271949184609, -2.435255327600708, -3.2713023507992816, -2.145033099213557, -2.147350320179021, -2.8236909262477052, -1.0206832493362994, -1.0014370068214407, -6.645999215399519, -5.122824813152839, -2.442553438299293, 2.4166313019319006, -5.351176563925072, -0.09514104706023672, -1.7851179486771798, -4.401006015514578},
    {-1.3573818442304535, 1.0197139459266706, -2.437028605101604, -1.8496367560055718, -2.838845611426633, -3.715649360643928, -1.1882860693654576, -2.055724238672708, -4.699073044343454, -6.798493526180763, -1.4538884536872847, 0.5603749707472749, -5.420839269628455, 0.9446200972069346, -0.4476919365555563, -5.144266970735542},
    {3.463062189349151, -0.3106548803773537, 0.33446350230672717, -0.7294490829534045, 0.7119462258542357, -3.0170917271113034, 1.959750975398634, 0.4847234641306039, -4.184774902578195, -5.680704018739047, -0.4964986569054512, 2.7974812130848012, -4.421808160087699, 3.4663207924860875, 1.4838104717463745, -3.995032380979457},
    {1.2344889722351022, -1.343547271545182, -1.3760466222813177, -1.5062428146060507, -1.0087389001255753, -4.716975101083094, 0.1717626532049646, 1.1809358602054398, -5.305058790069882, -3.5449191883240783, 0.8217364719404421, 2.7637345096920383, -2.998747652467275, 2.8298834146192933, -1.1167150951085165, -4.450680472884517},
    {0.10331670079460456, 0.8765308922582582, -3.7704368385226745, -1.7234592227915808, -0.6121893098911134, -2.652565442277843, 1.566020246819254, 0.7887951400644269, -6.058280537719848, -3.266236510009261, -2.4396863612198705, 2.8189063756361965, -5.415123662756009, 0.16042094599657106, -1.8068718430029647, -5.336467073137241},
    {1.8333663286955246, -1.5998943736247826, 0.450204324043822, 0.1537765325799333, -0.4433443585514377, -1.4906796538639093, 1.1391884493074067, 1.0264555365423946, -5.05765424826867, -4.196437979052304, -0.23337818668684948, 3.0192451211590523, -3.6436860502774304, 4.610912303673477, 1.69046743355343, -2.9057208990276058},
    {2.730618984875486, -3.144922631236876, 0.580841175694646, 0.41074035669437464, 1.5685312682052281, -3.15283369197317, 2.3151820435208403, 0.5424804084362288, -6.725501268762975, -3.155263234515594, -1.1717371177401634, 1.805724004416383, -4.717103906089213, 4.467387135172448, 0.807368548585424, -3.6463426324565638},
    {2.0688070058064776, 0.748338947419906, 0.9429134729858462, -1.1797489858723087, 3.3496986910444733, -2.6182968585785225, 2.067959929157862, 1.5241388636249142, -4.143099052471691, -4.184677707622937, -0.5094721976863844, 2.1499962587268304, -1.0346287171474544, 5.6519039915626195, -0.0806233426498101, -0.7612308499248731},
    {1.713418616945538, 1.3324640377151893, 0.7350828152081336, -1.5121617314811844, -1.017920463438772, -2.368859046961664, 2.2156201392686556, 1.2218966641325395, -3.7265289682696707, -2.225524791199986, -1.0523521895048888, 1.9589158774710358, -2.6307565535932365, 3.9030068675067273, 0.05075653068636297, -2.177295911844147},
    {2.6310608149176598, 0.03777660824477225, -0.5255343999762115, -1.759956702391653, 2.925372168029217, -4.541182209614073, 1.4457996492050127, 0.7446787412607554, -4.997647452982906, -3.947085456053335, -1.2787853960593156, 4.182959086264217, -3.22413532330213, 4.221884394474818, -0.05915054050999062, -4.18495406798971},
    {5.801244429403487, 0.03637952894653437, 1.488417881964791, 0.6247534024209579, 2.2170015443477324, -2.5485375052473174, 2.611313956590992, 1.429212161527083, -3.857782640441788, -4.976652524663537, -0.7966164984122069, 3.7915966955537597, -3.5657325440240375, 4.197551607338494, 2.9391750250133475, -2.7835628788408626},
    {4.60419993537057, -0.3813418011408483, 1.9197956417620483, -1.0693833370573727, 2.551305473158631, -1.2219624782152634, 3.377059148874784, 2.55380823675367, -2.1525210336477474, -2.912320317034015, 0.18060452006343394, 3.4545058986116253, -2.2537046000552023, 4.45213593750184, 0.8384853042265782, -3.37937564574419},
    {4.8034508873546, -0.9852515909323295, 0.593050006342397, -2.1213931366728818, 1.6080484219969207, -1.2715624632313653, 0.32383580203277756, -0.916718047835907, -3.5240885674734703, -4.677635852127162, -0.553403587180569, 3.099366849074622, -2.3968315253772983, 5.197738654204206, 0.4893163253059459, -2.6150875186509652},
    {4.527059951425556, -0.8085755237062392, -0.7551381325134083, -3.167855650889022, 1.7408140947635626, -2.1496584773703864, 3.271658443893119, 0.39086510795950774, -5.577804872028826, -5.124572170896064, -0.12409180244937676, 3.903440193597734, -6.341116515576752, 2.9404769900585284, 1.0968680630673233, -4.751575031830735},
    {4.779011803262011, 0.6573372867258302, 1.4518807970243288, -0.937750543761338, 2.929198069822882, -1.4686820334346389, 1.4898221511209508, 4.128777594536814, -5.214024990491279, -2.301899214594073, 1.3041113914408697, 2.378883301960517, -3.7875001739927994, 4.510113573603535, 1.28193947927561, -0.7261435291655435},
    {3.5871939967545297, 2.061831960665241, 0.18542688133447782, -0.5103219727557752, 1.8579858835078416, -1.963104005532999, 2.158599436074227, 1.3675150979098132, -3.5674524183687017, -3.8459139002227682, -1.2994214491989002, 3.4946591129838924, -3.915873913535023, 5.708732191062277, 1.301297009495245, -2.6115936725562574},
    {5.2830118693840316, 1.7113171494846822, 1.2194780477423481, -1.3586997449129374, 3.4864081347303992, -1.8398663080391218, -0.05894136327632786, 1.1599708652425837, -1.610486971144111, -0.8749281943765944, 0.14220607511155314, 3.6017763593048007, -1.215356927024056, 4.741761824982437, 1.798423886239475, -1.6801421878000653},
    {3.226584660850607, 0.7883753876977755, 1.9025729939221587, -0.2959499828610374, 2.899848158109264, -1.9495718784151512, 2.7989808971598835, 2.021025024932308, -1.7134011040806107, -0.9039662140441301, 0.13777212030741406, 4.3283909164785515, -2.6889525229387634, 6.691427437531684, 0.8802532584517262, -0.2045269346211501},
    {2.461548609405348, -1.1096545888060607, 0.3961729055152978, -0.9863237304866133, 1.5437375426059332, -0.40465751859893134, -0.014273393536252859, 2.5466689893706906, -5.42534652164896, -1.9780301453868687, -1.6356459784432842, 4.269348987597599, -3.3439627826329015, 5.292242296480298, 2.4692671582745516, -1.5365429572384608},
    {4.940181422729316, 0.9459057084885591, 0.3481246626078604, -2.1904161847777264, 2.7286528608450293, -0.5985870520233251, 1.4681823745576295, 1.6958047073568707, -3.878983041491063, -1.4821550910804504, 0.06189513264249553, 3.9589635132935035, -3.130645647426536, 5.591366363214634, 1.2098857327143295, -3.181327095382517},
    {4.648189311780772, 0.3682438682369553, 0.2833957658947501, 1.4247970915508092, 2.2929615452714343, -2.753525970914701, 1.8301752226117685, 1.8572001133185343, -4.325622729981744, -3.384975301612052, 1.8026898524059243, 5.6055705358479555, -4.237963983170601, 5.340517726559756, 1.1757815429071905, -1.7317347393709877},
    {2.585219092644743, -0.43049810967324276, -1.2663887673900276, -1.7431628796161796, 1.4670697369314503, -2.390671666809317, 3.328708712237512, 1.3626742487225247, -5.19316854228231, -2.595375125289592, 0.2617996584084395, 4.3645260307075295, -3.897487769466396, 5.5481654928483595, 2.241287170141839, -2.4510605388135307},
    {3.809791996817068, 0.5627757378824382, 1.533942191817946, -1.0488672535880526, 0.9245335516776455, -1.465523259429052, 3.9706227631853603, 2.5025074738142985, -4.078656065471771, -2.3905282010277262, -0.14986871401868326, 1.698614396845093, -3.2940138171385542, 5.738008671392673, 1.143654076967185, -1.8469177963814039},
    {3.719903609561264, -0.29191832500865633, 2.573928284521042, -2.5907345172708376, 3.7332612349879177, -0.9273250209190067, 2.645965901120899, 1.9136585150448917, -4.109913707633778, -1.278348833966382, -1.1255606853395967, 1.9708881210434643, -3.237792978964567, 4.428553175645449, 0.1373373983765464, -1.7127603498870065},
    {-3.7630443268082403, -4.337027641549425, -1.9036177582039928, -3.548417186343416, -3.566521135012147, -1.626414716964417, -5.4590137359733735, -3.343726944619033, -2.62455977011513, -2.3520866728683707, -2.3224281863502596, -1.4615222918641793, -3.0532548222914677, -4.5970872703262495, -4.367417370852412, -4.576474140316594},
    {-1.631919059368824, -3.454626004497393, -3.1211294099204294, -4.784808039462825, -3.7060209361211958, -2.648930465989714, -1.5504973767452541, -3.1214975445800532, -2.2375535620135896, -0.5400262758383507, -4.279839242191619, -0.1666268565440116, -4.8631006432923805, 0.16404358955758697, -2.5250538880644906, -3.94172414777228},
    {-1.0514445814371995, -1.0506193317202297, -4.644893411208509, -4.824304641492784, 0.43480883934208675, -2.9501440836477757, -1.954326269679007, 0.13930500267068913, -3.6189360058074787, -2.1627492956536782, -0.47901433913921376, 0.3776748109945591, -4.116796452168183, -1.6689040548394796, -2.299670760085475, -2.9138812932292697},
    {0.03233949211723218, -2.3082880347688524, -0.2633067512390184, -2.7738063779960034, -0.38275819754595314, -0.6031886534445946, -1.2799984818045729, -0.5398276570380954, -0.009512093228554416, 0.768741655146213, -1.6862127298050569, -1.941899179183692, -0.02149133576532391, -0.25359464012370375, 0.4113810234729638, 0.7535205797224311},
    {-1.3200765097915002, -3.1794365738687813, -5.515558042758525, -3.411408152519412, -3.3825386543036053, -3.5013973503680913, -1.7067451083868308, 0.18950322227319952, -2.6698560682388863, -2.574193668658778, -2.827050679919438, 0.5326124572659344, -2.160601811608035, -2.6815632732264314, -0.9072420976352193, -1.7004905828930483},
    {-2.0849611800984325, -3.1051028052234293, -5.535878308699949, -2.059594772373216, -2.646006368554835, -4.110922879883514, -3.034998580965948, -4.356894287906239, -2.04507814704933, -3.7439377417004427, -1.5251680288540872, -2.049543252977612, -4.816329078997065, -1.9903661813484967, -4.236461238647133, -3.3345527600958516},
    {-2.2768986983061588, -3.9189016924460147, -2.9680152965349644, -2.0774746071173467, -3.6671871091865227, -3.5789037960836905, -1.2170508700719762, -2.2817705493403926, -4.0496898159873185, -5.247810215097039, -3.1016183735423883, -3.0100932761413133, -2.864168696087942, -3.346346537976686, -2.827133509343864, -1.9716260683944051},
    {-0.2876409102869676, -2.4335307182216415, -3.6048555848691013, -1.2149373004483113, -4.691493756693432, -4.65165026400621, -3.6737993696371127, -2.334266744422526, -0.5914105471895156, -2.671051656420084, -1.70697171208295, -2.4582218618384557, -2.4480902557698516, -1.7503220497895424, -0.4383071782388988, -1.585805019070149},
    {-0.03592208985839475, -3.0205546823538065, -5.159831288816978, -1.6726844092064133, -1.0463700545671302, -0.0353098643149525, -0.8270981163300594, -1.318601590800014, -0.5709987156827715, -1.2416162960610253, -0.7440230181692843, -1.3294453902701526, -3.064698491193868, -0.4962323086388293, -1.50386680583432, -2.7413094193157},
    {-1.3164178426701327, -4.407105453395125, -4.984200875410427, -3.1507406146807786, -5.293138257253872, -2.3663360911171853, -3.2697034595211534, -2.5965523010405542, -2.138410376818566, -2.905213384296527, -3.2156945276248114, -1.758876875475849, -3.1748249897625116, -1.8352679767252864, -3.4843747509104226, -2.8916056928339895},
    {-1.0946783628596792, -3.915725172187875, -3.9151138282113167, -1.7525545718606181, -2.316641635226311, -3.140618681729865, -0.9222658050489708, -2.1377404283718446, -2.780008700287603, -1.7730539697865038, -0.8542939571081474, -1.3108042098740966, -2.818990485110197, -2.0351072523261657, -3.807791575735792, -1.804423733339795},
    {-0.6302811651387512, -2.0003851315333256, -2.5535169752856057, -3.4130948033605364, -2.3787672964607, -1.5247799227940284, -2.5687339031523053, -1.2020731580453654, -3.173014802150759, -0.765169073444091, -1.027971731717623, -0.9967132497049962, -3.5846815477156038, -0.9966808273948021, -5.225529407640059, -2.4634215747115533},
    {-0.4458525076516969, -4.577576464510575, -2.424847192929573, -3.9137171829966118, -4.092240249380394, -3.2776173679123377, -0.6957746138622729, -3.860226053513186, -2.3886451160367304, -3.7718721989746364, -4.755793835393816, -0.004020937320385073, -3.2729745419003327, -2.6079732248422536, -5.554776544297605, -1.6871044203489014},
    {-1.75285342064701, -4.202069850883059, -4.855731988920448, -3.3797437456235317, -3.6750740389603394, -3.520895858146075, -3.3145365542897247, -3.0093073861468786, -1.3836346315945238, -5.2109016479058425, -2.3614960164062606, -2.6594418236336885, -4.334704840500692, -4.963757630530779, -4.499942708223124, -2.9887220708937776},
    {-1.0235111898083407, -3.7168807109943547, -3.5374664629263775, -3.6267901302501655, -4.228402935632724, -3.591486804548971, -4.382784510834746, -3.534059436800733, -5.022975793205225, -2.768494849612304, -4.757335596861222, -1.45305362450923, -4.04173501952277, -1.5627955476057978, -5.121564792491791, -3.6688642103451077},
    {-0.5558605181886286, -3.949625381556487, -5.0745444991822435, -1.786897561774545, -2.772048199724282, -4.413351686319984, -5.126996072797949, -2.224698076109429, -4.2239328877218565, -2.757691407948551, -1.5810594705397822, -4.001800610127065, -6.051995150873594, -2.74642739819819, -4.741722464685159, -4.231050985099974},
    {0.10743089663884837, -3.5791306808979297, -5.327380720567749, -2.7997588367248674, -3.17178672942919, -1.5922446511737351, -0.9381495414622983, -4.0256470951961205, -0.31575920116657674, -1.8275662038273854, -2.595958139327821, -0.7684812885742158, -4.150909968725918, 0.20409346168049242, -3.0867437321916213, -3.8585239319161135},
    {1.1114525981069117, -1.8808307502333073, -0.8030826106180673, -2.781981306634731, -2.876207940412732, -2.2294154837891864, -2.1552460757069456, -3.168987811764833, -1.8906246600374654, -2.4417781970810335, -0.7818860258329098, -1.364941266146464, -3.505540544665525, -1.5944649499267234, -4.127567999896798, -2.6398467221237083},
    {0.150427693457642, -1.060996346817146, -2.9176071529329577, -3.9790132013617634, -3.6029981687692536, -4.231983906050659, -3.9619126746517908, -1.562975518964709, -1.0037888193944247, -3.9780901895696017, -1.271999426309695, -0.6850192267780718, -1.9218515772619216, -1.9343561007810055, -5.444526665255009, -4.165997630898991},
    {-1.1721540709207054, -3.486156810564264, -6.660942684195954, -5.375897982795787, -3.226638938502233, -4.84293383156493, -3.738464149026686, -3.3300118071019766, -3.1733090938738724, -4.037211487894174, -4.05434364935343, -2.220193654315066, -5.9022904301557215, -4.606594775603539, -5.008834413922733, -3.872954096912554},
    {-0.004677426701915985, -3.7127608829283893, -3.9866348004996826, -1.8608385537647707, -2.7442200658646234, -3.483546804702537, -2.95809506376268, -1.4709265053794334, -5.105851283035406, -3.800268004231958, -2.8822334695418026, -0.8044388358281189, -3.099787719481851, -0.07687536211269638, -3.268018800234963, -1.5208070434988485},
    {1.3542517631279016, -4.210832709789584, -6.5427384022158614, -5.104590958723862, -5.299085749186538, -4.224859871961716, -3.175378552283022, -3.5992213762237326, -1.568070400959414, -4.634519135553547, -4.02746132259885, 0.6158701352214668, -5.674305261654506, -2.7486936959871535, -5.432625072853171, -5.267403001357875},
    {-1.3657574690146561, -3.326307152654648, -8.041909090185666, -3.8099609242667176, -5.847209300628362, -5.179244822899117, -5.086458519971812, -3.775115288808901, -2.683086179964311, -4.061638772795076, -4.30494295772892, -1.782925092961738, -2.9558413285642664, -3.657746815007005, -5.361649765005337, -4.809480086600302},
    {-0.27030641321527, -5.569984909279784, -6.825740096261009, -3.8503844398853317, -3.406757847030227, -2.956144143474715, -3.091046190981655, -4.4162464325571795, -2.5316054362960254, -5.8456151707811035, -4.921797787997276, -2.0702245129883536, -5.6337446428799005, -5.688339119324854, -5.2615771537456455, -3.566529059359743},
    {-3.3171771996983335, -3.0217294763077165, -4.265698928121675, -5.1317030903667025, -4.413194109270188, -3.733508502131419, -1.270130372341837, -5.061231152821076, -2.5406734714091583, -3.9148940744410217, -6.312660105904279, -3.447188887943771, -5.667717536871577, -4.714718394940531, -6.688780099516801, -5.669862879408993},
    {-0.8324933573667765, -3.9512147884478908, -5.214888232782325, -3.159288025237842, -4.436632250983835, -3.096867600134243, -4.689120778217544, -3.583492071955828, -3.704870256327921, -4.400418636304477, -6.2548528056565695, -1.481115953989446, -4.8312016056447495, -2.0383731304943913, -4.979389064592713, -6.5144389705533925},
    {-3.469992289864413, -4.458688637136746, -4.328697872243706, -5.85616377654033, -5.557717646795383, -4.916640205952174, -4.994688914628317, -4.139976761603786, -4.15247179925434, -5.48984453447025, -1.9079513469903995, -3.557041442127773, -5.47882967033143, -5.2492795522004405, -6.820705292875904, -4.557281352408246},
    {-0.41765122499239604, -3.284160409048642, -5.416473678175871, -5.293092162123974, -6.978955149205138, -5.189265502636672, -5.023170204963275, -2.6739406756047814, -3.0980095453683507, -5.864100403869673, -5.318809372886507, -1.3090590352675862, -6.058466296715905, -2.3658907089949834, -4.2632362100287216, -4.001748888318324},
    {0.005676974111713583, -4.169712223283309, -4.917558855875772, -6.03260499472996, -5.146545491924422, -5.154607973900043, -5.19613601991378, -3.957912145995736, -3.3798639709573046, -4.516026057556983, -4.3222594185101135, -3.3380612073770273, -5.48155602892205, -4.202223067132762, -7.216824915263745, -6.7893626521718256},
    {-1.5011485579490023, -3.0927380717293227, -6.749556960657748, -4.659983939519162, -5.875849737785594, -1.7857998011367953, -6.389337755172361, -3.2410854772897126, -2.800027892253634, -5.7424093221527, -3.044132262959701, -2.6980240510205715, -3.675403022300376, -1.2136861243554378, -6.511444517560366, -4.213217663221363},
    {1.8348684066294376, 1.7361685607475401, -1.3363957071126642, -0.23235640512921094, 0.930008687305168, -0.36540199971322623, 2.189460015139788, 2.1214589281915046, 0.498771194344932, -0.7428340420357351, 2.4424181437508006, 1.537288296188145, -0.9151209332493335, 2.05801839635385, 3.0672418810198665, -1.378526626759419},
    {1.1738620769606634, 1.3801380527125302, 0.011992448625641649, -0.5121634111690174, 2.3436480554223724, -0.9573668995665108, 2.400224398672005, 0.29809752958801505, -0.4427034550886148, 0.06839963596976929, 3.109737761623002, 0.7637784462531687, 0.2796740852061295, 2.4865776221950457, 2.53772441620921, -2.018821823879074},
    {0.8439984170628153, 0.4307076215288185, 1.6071413282410307, -1.4500946868716478, 1.5513819778064442, -1.0064716120246309, 1.2292414323971694, 1.2732994338684265, 0.6461681880592712, 0.11392031772279389, 1.7007984948838295, 1.1383003109415772, -0.6890379782332032, 1.1324881374617697, 0.8733743763243349, 1.005591762530594},
    {-0.05918313151391544, 1.0452777095944037, 1.0753243190607766, 0.9369775651434606, 0.02848633531311166, -2.622758974539902, 0.7517668880231168, 0.06770699656768421, 0.11038294569546427, -0.8160993308363395, 1.3710521450446136, 2.3261469023597887, 0.2169535516209438, -0.5548768228542532, 2.5165980183088412, 0.34076788929285173},
    {2.0857387068058584, 1.3351880740031605, 1.869395174330335, 0.8312027995739024, -1.1233022283015899, -0.5732862476237202, -0.1131515649918203, 1.423723822400837, 0.4831154717475673, -0.30685225200092325, 0.9696657427637305, 1.729153444306354, -1.0415367214403077, 1.0010857283403887, 2.725330544091029, 0.4567495780691141},
    {-0.0310783521893626, 1.4795542471007808, 0.9193489093720616, -0.014209516147056418, -1.1059634123281308, -0.2594629784299599, 1.0464672346508834, 1.4313257867754559, -0.36244306265557585, -1.7929576779994687, 1.3195760131116823, 2.2217092901888145, 1.1581566784722226, 1.653904781756113, 1.9663648904218378, 0.2291591903650567},
    {2.2399809873007395, 1.1169334708125738, -1.8025747636585374, 1.5949791023064679, -0.9761574607804723, -4.027345448389018, 0.8345558351319445, 1.9702569410660131, 1.5520244906921765, -0.06169162578764829, 4.545484952714118, 3.1944371360431627, 0.12557566869009276, 1.8884173677255554, 3.6367132912176965, 0.5194032675233814},
    {1.627920153702244, 0.43693526867499916, 1.756449568007683, 0.39115387244221905, -2.4717954581610173, 0.3001879714953059, 1.067561323103253, 1.3829444200735717, 0.6884763242864159, 1.5932071610058807, 1.4594445930111284, 2.767749688331161, 1.0157230134299822, 1.6644976734214763, 5.23957780277742, 1.0359872783717798},
    {1.4722489262107847, 1.5505983903093954, -0.6538743571598942, 1.347854883944512, -1.4049823123700924, 0.555531215361332, 0.5385238869620425, 1.329845225392816, -0.1102321276108415, 0.49174362606743344, 2.7267274085868567, 2.5452895913008113, -0.6929655993588391, 1.346770035319125, 0.04655981571505321, 0.14111345483025256},
    {1.0385722651001223, 0.23643259706859365, -0.7435648103057139, -0.9101396501740416, 0.8806041695142546, -1.3077588535578928, 0.8299175960437081, 2.4814091983897897, -2.2421589866295784, -1.0269295116364008, -0.1129447125635731, 0.7187444063924064, -0.7082950105414779, -0.2295725163104805, 1.9672505872773698, 0.6682343121926915},
    {1.0467948468865993, 2.821254845372317, -1.044575894474767, 0.45030885925797726, -1.286939858887836, -1.059744220595328, 0.4968573173680695, 1.722408978019008, 0.17774920752600745, -0.1729791445107514, 0.8337759800702695, 2.638431453811345, -1.331888443095366, 0.5236188827000047, 2.0677108067163696, -0.6499435763501307},
    {0.6069067850624735, 1.758637184268409, -1.9819504756236817, -0.2271498826950972, 1.1630241036913025, -1.4876942098560324, -0.9017592866257598, 1.140197828685474, -1.3563807519141275, -2.187231993151272, 3.98417056961004, 0.8854339205463856, -1.617151325427393, -0.3214200799800114, 0.6544208094096231, -2.036732392689131},
    {-0.25665270399945544, 1.9634477284754002, 1.2452389145913783, 1.3440510612185523, -0.8321745275767259, -2.469808420363572, 0.2959447393852034, -0.020050538222003925, -0.04832855600684039, -1.93961836997283, 1.9702564826670954, 3.49192910316703, -2.5950689046499815, 4.2347922039334325, 0.7003844172992963, -0.5446220329688789},
    {1.2858008469021232, 0.9523621590634107, 0.0715912381466977, 0.786420966716415, 2.1073641985250218, -2.0025764370276633, 0.7623206255204217, 2.4904223038662225, -0.03351785282331103, 0.47643786769344243, 1.3069116101832337, 4.669196851510839, 2.6468461967378563, 1.928679074210355, 3.418848274994963, 2.1819658868660397},
    {2.5338281559573645, 3.626969744735648, 1.032808718268621, 1.5104377280626482, -0.676928813611234, -2.824655923014425, 0.9320299085284693, 2.6550047311447127, 2.2936398438199563, -0.8175314721242679, 3.367762037404531, 4.027334318268395, 1.636817357653665, 2.2654472482393206, 2.7519885121382366, 0.584585457117897},
    {1.263306114218275, 5.0843302993917, -0.05048381258850981, 1.3845127529137164, -1.6201361291511056, -2.32480137597822, 0.76563169956217, 0.8106179800538703, -0.02610945670316694, -3.2331841108531942, 3.3236424208281377, 3.2696508237650552, -0.36671130223283105, 0.7675359576855088, 2.126400098229326, 0.30718740093366587},
    {0.5505899863744207, 2.5612020341955093, -1.1744608722390988, 1.141116698939214, -1.6133937171394468, -0.19680817031558503, 1.8356181167069414, 1.8592555823302515, 0.3440760395871019, -0.5613084443458989, 3.9697247891063214, 4.388668825533109, 0.7202444217451011, 2.8066540942791054, 2.6613164109915144, 0.6888634411091351},
    {1.7165047760742016, 2.8780446350119004, 0.6553757918834445, 2.989349464619715, 1.9089262963266695, -1.6924397292777138, 0.8655515857680836, 2.1367063737469025, -0.507328697793817, -1.4344598177043153, 1.3998619063050046, 3.5617160968950903, -0.6899262201718553, 0.6595758151020026, 3.1096278457461883, -0.37698899660625146},
    {4.214770456109917, 3.9095984136775015, -1.2689501775835454, 2.7013612691028768, 0.006797729649013614, -1.3816504901596636, -0.057180444394522516, 2.438378912047717, 0.302409095221463, -0.16888371527452023, 4.086349108498762, 2.3163798601194414, 0.4778677483474361, 3.2699161687814438, 2.5510806417008918, 0.77904789951325},
    {1.1911962649588725, 1.5833786917943795, -0.7764834947340263, 1.4002603476665718, -0.06818039488936439, -1.1776660118257265, 1.5963533972840152, 0.06593362556411189, -0.5809589253804347, -2.3692882850200605, 4.181183383639122, 4.225891636053684, -0.2146518808522908, 1.6189702530491268, 0.5215270374116932, -0.4706561584198407},
    {-0.08627753379923976, 2.045938493420832, -1.0530745190823683, -0.7126720743245879, -1.343719119821243, -0.8699228695040926, 0.11159087135535442, 0.8461771671079487, 0.3584386845275121, -1.390703791225625, 1.4718880243153307, 3.302297833213993, -0.7349872224399863, 4.166877810155754, 1.1141206886972903, -0.9902604866276119},
    {-0.07339163520275724, -0.2288798634110052, -2.880437400866182, 0.12235922208172331, -2.1671640475780665, -3.006608451312541, -0.5932245434677099, 0.7279105964053243, -0.41963658888210137, -5.340666721991475, 0.36985886225708675, 0.6807496445851725, -3.2291384289696574, 0.9066654196209125, 1.1987675529893518, -2.35558094110854},
    {0.03958320098752997, 2.8922812658607424, -2.1211626897486124, -0.41839625344122855, -2.8088837788160967, -2.5046536467228973, -1.7254189962327129, -0.09680922767037509, -1.136645462649935, -5.148411533836415, 2.7143266286602317, 2.328629709296189, -5.383008603680033, 1.663248906074432, 2.704739238034033, -2.79003813949602},
    {1.5794843025278047, 1.4070351008830622, -1.133244228002389, 1.4784489742580327, -1.9399298464003878, -3.9191734544065584, -0.8358505411544944, 2.546198528097598, -0.2870978037775078, -2.1118264716054855, 3.6834917344019393, 2.936227321507725, -0.3175361578327726, 2.9348679667812556, 3.3759714617352654, 0.11026275246675497},
    {1.6230508176456269, 2.7461109429722836, -1.9060570670094696, 1.2785379971420283, -0.25218475569912796, -2.7303049937924024, -0.2630103268809968, 1.6809627197221197, -0.4307923729342325, -1.7769037958016618, 4.158049438823055, 2.4275863968784863, 0.349476520350287, 1.5976053241873345, 3.407484005931378, -0.9349522876487485},
    {0.8037909652107577, 3.480175727849215, -2.0832194403401294, 0.2929093564218726, -0.5786499630767605, -3.0744162980187086, -0.5906594144082693, 1.1106675818549532, -1.4429389279659417, -0.3095288761728177, 1.7353752457940186, 2.352240907210734, -1.5591455911647665, 1.2987544371241218, 0.6444314853323969, -1.0218457065698427},
    {0.5164660589455868, 3.5164124295191055, 0.11133620492929465, 0.7985331591578251, -0.2280960381233238, -4.493379097355849, 1.3109690166300476, 3.2152780019590375, -0.7897947042162831, -0.9713281914245179, 1.8013609519991047, 2.208252676660143, -0.9182355257472999, 0.9819668697055808, 2.2805892408693125, -0.6134702940528761},
    {0.3159169119691824, 0.9216104648427735, -1.262959162060417, 1.3082147947072973, -1.387223104163963, -1.0248773531957929, 0.11564069126335129, 1.8413722819704585, 0.5389889726350204, -0.3588625643491505, 2.627390709611584, 1.4477374437618413, 0.04426326593808418, 2.3931683760716234, 2.673911981609389, -1.022318562799072},
    {0.4749372676686991, 2.0787144819808305, -1.0797827085046188, 0.32796888790871903, -2.4664320435900544, -1.8213019167071922, 1.2878062600901095, 0.8218171068932213, -1.3961052537835166, -3.5146067436464414, 6.060176442425981, 1.8686065695841616, -0.818795021256362, 2.800482822578305, 2.3103588550098686, -0.5222816021671072},
    {-0.12183473870648268, 2.675713424281792, -1.3945097742271495, -0.28354067889070095, -3.110539355954659, -3.667312535742742, 0.5700519460262548, 1.4987263515010054, 0.15510484465959803, -3.095809872326543, 4.494693719950823, 2.7041488063199424, -0.2594964263494615, 1.9404621347115298, 4.448201165656856, 0.054005421470071445},
    {-2.122627486934936, -1.6569660953567542, -1.7951693918072846, -1.3258503410263693, -2.8347545816320485, -1.4802513080511486, -2.391166423297307, -1.591867885236856, -0.5658395904710455, -3.6360164196877323, 0.19423493118120108, -1.5625230712768794, -4.76765932612787, -2.7494323327913834, -3.0218756316731517, -1.5816510820546905},
    {0.03799675351595388, -1.1446571559823215, -2.0133254981779505, -0.7353014935785472, -1.6685717671608224, -1.0381588319506057, -1.2481810437718486, 0.6975000679349653, 0.5130242174947375, -0.7408581617813669, 0.4242865432823265, 1.7425716488482708, 0.7179800644122593, -0.1507419824335473, -0.07148570498994754, -2.29780026882167},
    {-2.0009393589345645, -1.6281468256953622, -1.4913139301621017, -1.6879909169321898, -0.794890419185146, -3.2252538886387896, -2.1600809673625676, -2.293403462000834, -3.612037427850942, -3.433423576384884, -0.9837755615875405, -2.173779396715478, -2.8284842768210487, -0.19160471222613193, -2.842839122663631, -3.4486960800596194},
    {-2.252154093038622, -2.475785180948252, -2.0727940877681283, -2.207079891486941, -2.3249269435983524, -1.6497697970813903, -2.038661812722973, -1.2490348302600656, -1.1135539329409294, 1.002506123719653, 0.18557408602507933, -1.7607369871662715, -0.17118539425688237, -2.3429061299121448, -3.4297106744063055, -0.561880251072301},
    {-2.17174170092245, -1.412489816278992, -2.143236396787235, -2.237894821247818, -4.022262062363794, -3.29807495200498, -2.37887096345824, -1.6852526676974673, -4.234864367063986, -1.4175327078053832, 0.6842486488166082, -0.9241345575005013, -2.9727000208987593, -1.1778993394879227, -1.8640772858528853, -2.6757649391597593},
    {-0.3165510418352877, 1.0268049703955608, -2.069336477738325, -1.6071267628527386, -0.1939582422638972, -2.181085274367934, -1.7840505957441803, -0.7800917389680377, -1.7020396246881377, -2.427239715387601, -1.7547662809855058, -1.3828743248372268, -2.6838865470971838, -1.6305260305576585, -5.352151579885227, -3.096989492332471},
    {-2.6226560695958576, -1.7994747997284444, -4.290142541153212, -3.291319251727836, -3.3853512629064855, -5.3995389603981, -3.6567778981450174, -1.6516524421773235, -2.0507957387483224, -3.279533212690174, -0.5982009658152325, 0.4556328593989841, -3.923820053148268, -1.0215344917635247, -1.9305897658418527, -2.6027626198916223},
    {-1.0658180723497017, -1.511518012569998, -1.8522893134834284, -3.0113281710346254, -3.199829548674592, -0.6838897453481868, 0.0858150527936603, -0.7767245031741605, 0.41039550781534545, -1.291935463107116, -1.360058160804676, -2.1944798812515054, 0.10807513128861854, -3.5086081778692613, -1.0376550193316332, -3.210619028236866},
    {1.0798703701387142, -0.8994152320885933, -2.82817783527538, -1.9152613026364638, 0.23862121016502974, 0.706678307402173, -0.311303045282082, -0.6914322383180219, -0.1918015884550835, 0.0977852062757155, -1.8420468397857024, -2.72570680914062, -0.7080880725019822, 0.4213634725120307, -1.369191416798365, -0.670783301318444},
    {-0.8616718749312512, -2.767107608483673, -2.409011106853132, -4.877888477582042, -2.8936446561639038, -0.91209525845091, -1.6433683446845035, -2.2568974904577543, -0.8846470759628368, -2.9322959319568254, -1.5301812680561993, -1.147945612209766, -1.1856605757223595, -1.9019348407187164, -2.311593150179715, -2.4506607238801226},
    {-1.6589435223378666, -4.050369400617058, -3.6047943842058943, -1.8259072981406752, -0.8208724653252322, -0.9226593356077613, -2.505119837546249, -1.991153415045165, -1.7822744291277353, -1.6749635519172437, -2.7358730012892263, -2.9681017289671137, -2.1989864218708903, -1.370023543702332, -3.3873415613443223, -1.3593399428316348},
    {-0.6632641865092955, -2.976827887564594, -3.2190627223417003, -2.7028245885903055, -2.33418356805162, -1.4792126513130692, -2.7907381611689734, -2.7703597957917627, -2.710730103158135, -1.0642406076796782, -2.4926829912485653, -2.153891905154482, -0.8494297702926621, -1.81771177240091, -3.114891279711696, -2.564980544189058},
    {-2.4827820232274993, -2.6384537447665073, -2.266680042132499, -3.3701455180233046, -3.4988099051012567, -1.84021958757382, -3.603599238881933, -2.880209550414837, -0.39712708450543216, -2.4849914374197573, -4.2887244672643465, 0.22494404343430555, -2.4370493659246626, -3.108569452940774, -3.515039187089641, -2.795802635519633},
    {-1.2616154650133031, -2.9144333632698496, -2.8623597294065477, -6.105064641515989, -4.795365938959562, -3.6151608622132576, -2.033172293025703, -3.1669207209240344, -0.9763420670443794, -2.2525773220769407, -2.5767148699785483, -1.1872332974077624, -3.0283397453327576, -4.783998397097545, -3.2721041345104913, -3.352523439793916},
    {-0.7632842364722419, -1.8817118227159684, -3.194604956529028, -2.7068323837623787, -4.253666929835568, -3.466671554220716, -2.4985767332735187, -2.729252269634029, -2.0342097311200935, -3.3161485713078602, 0.10220487863456608, -0.12878008238311794, -5.151375777235023, -2.05383572813019, -4.051914826508684, -2.638236726203166},
    {-0.8286622442712632, -1.0254692741091043, -5.768319985243936, -2.1590598696841634, -2.0504285038025616, -2.4511186109172147, -3.4119052162195316, -3.7683129356704317, -1.8591160386082912, -4.913147643160168, -1.1973938902252867, -1.4466277690584777, -4.805391079567728, -0.23953529363026604, -3.4097025352151116, -4.338231654318826},
    {-0.669156940550097, -2.3097915366900024, -5.259718709911678, -2.728454466053142, -2.8466531739709002, -4.5150393137854055, -3.201160814127787, -3.2795174834506677, -2.2008620123283413, -4.3521651673373185, -3.35519265900843, 0.2288711658744072, -4.255312746151157, 0.7880375508406651, -4.801009545365487, -3.0918237973105795},
    {1.5523003646045863, -2.9380307807353336, -4.017020386233631, -2.168051012226254, -4.201318475285937, -3.187453053896574, -2.7070735870709, -2.330786902956234, -0.9074894867633423, -5.203450841714354, -2.8240780040962883, -0.7803412271403413, -2.1865180844670165, -0.9442179820606055, -2.398623814443695, -2.4996290731078754},
    {-1.333407874759114, -1.9779874284490373, -4.935931300546763, -3.06792885481998, -3.9083412132880717, -2.074494518414176, -3.050574521541502, -2.9559284904601473, -2.987517614620806, -4.93245565424275, -2.271586777365334, -1.8509491773805422, -4.67294833280339, -0.4825806442122898, -3.8612954633112677, -3.9609512586929694},
    {-2.5575624772449568, -3.5702913221180856, -4.89297068423569, -1.7095192319044172, -3.0250366008432574, -3.4418499192073986, -4.710420736269928, -4.586888693487073, -1.6813928055473015, -3.6460246894453068, -1.609858139637341, -1.8256551666634708, -4.164779213739719, -1.5793954198037885, -4.853196251084806, -2.372055041649875},
    {0.3352683162480719, -2.955822643069655, -5.525103560469351, -0.941872711581277, -3.354692423248359, -2.496783500749363, -4.512484167334666, -1.098434682843001, -2.7667216869225815, -4.839551688708508, -2.1853737061124003, -1.4185214553468046, -3.043100269871132, -0.6753345159568028, -3.5741719709370554, -3.722269169553142},
    {0.6447163407206282, -3.5315094544960863, -7.8058453045011476, -2.189794427155108, -4.780474523165692, -3.748468594667109, -5.389127485627296, -4.696812198577543, -2.848120712398277, -4.601580480193609, -3.6764190901957763, -2.284317640352325, -6.647413858309125, -0.5636766058919457, -4.630857280853266, -4.7383701036980455},
    {-1.1911979550553526, -2.9024888751555262, -5.604013582222026, -2.5333977253417364, -5.5271689902522, -2.8584098214447486, -5.19892473796688, -3.531965166773067, -1.1660872043091035, -5.8151057421546914, -1.7687573078978915, -3.9843254001879083, -4.639956982347014, -1.52133427410065, -4.577543474668497, -4.487583426812509},
    {-0.0832924838091559, -2.6881963833514395, -5.413949417911943, -2.4405293202582716, -5.730063406573369, -0.43005046113888057, -5.211016667323047, -4.566499081475653, -3.1206913050639655, -2.841025705344438, -3.249915169570914, -1.06657266082898, -3.646315144981491, -3.5654557763409596, -5.098013144989888, -4.4289398124085135},
    {-2.248839120974773, -5.591231100977664, -6.08801116455742, -4.835591188355318, -4.126092709470442, -3.1144042233647964, -4.1232973041302206, -4.098209262281648, -2.424601265150344, -4.047937632428019, -3.3247220658929932, -3.078341748281156, -6.31126066235138, -4.0595297277563445, -5.057956408585266, -5.540901347725157},
    {-2.5142852063631254, -4.870666243161063, -6.73002190380078, -5.599254652903164, -7.190309015087854, -3.096865212441913, -3.7615288028417164, -5.822524024060245, -0.1924227344271691, -3.4909254086044417, -5.2049153373500125, -1.9333015381098808, -4.575549269509225, -2.9581250149483735, -4.944027228990876, -4.675371453617565},
    {-1.4911051581710193, -5.420055388689996, -6.097972826450442, -3.7140411638232727, -5.9186769019119, -5.42898294730308, -5.063268897387803, -5.951055152817654, -1.697706623571161, -3.7549625563694735, -3.0406034050042074, -2.6409349339979, -4.069129989414669, -3.594855525607733, -6.494117835286885, -5.065019989162203},
    {-0.22753054489306776, -3.5154567064659425, -6.582692052774523, -1.6319136112468247, -6.243314652582076, -3.7056921530180613, -5.661070784767851, -4.848847109542118, -3.72176296708905, -6.619338509663805, -2.8534483789932086, -1.8687099529806972, -5.60148286088003, -3.8207509508307314, -5.364224434181263, -5.911648543713707},
    {-1.250287762751154, -4.965963488439807, -5.764348266043396, -3.080250722040701, -5.806184796699267, -2.412646734091272, -6.358112592200338, -4.799403165656219, -1.519519388600663, -5.380989796159685, -4.2405506787623874, -3.7387092631798144, -4.726371002760792, -4.468114926775465, -6.149437490676817, -5.050739163198212},
    {-0.22898368735615898, -4.098719810491384, -5.022749324035, -3.842712915202642, -7.553015959884739, -3.79366081115032, -7.829722385734669, -3.786577876475238, -1.031969340580637, -5.1169207223318525, -2.1921663889304215, -1.7343002154153764, -2.49924086829751, -5.900153721036314, -6.4760224754403435, -2.3968174748282145}
};

static const float b1[16] = {5.895012955036713, 7.547600447094487, 8.089431506429456, 6.185973913367519, 7.357794458382669, 7.1071334514903075, 6.211822876850652, 5.681990429348896, 6.632862507271892, 7.648311863792955, 7.3427417205652805, 5.8730897397511415, 7.462459822854564, 7.1349064676002, 7.817634152992072, 7.1125539522779535};

static const float w2[16][12] = {
    {-3.376876615003295, -3.183226532429788, -3.2205705619192555, -3.5986186695628795, -3.35789677115526, -2.610009279391515, -2.727143834824383, -2.62520685746363, -1.965012728102298, -3.2052244803247874, -3.8824560765856178, -4.288286668621229},
    {-6.18567253348788, -4.241704355001572, -4.175682287657127, -5.14110637540415, -3.6585350512261594, -3.7012116436086853, -3.3671793525849427, -5.460378572562709, -4.83481114549953, -3.945946740826454, -7.285042932970721, -3.443429015599162},
    {-5.095417842488966, -4.833908065819691, -4.49258002611246, -4.992182825721708, -5.217341964460284, -4.438140067715896, -3.9195875489839467, -4.272099586232428, -4.228328107359317, -3.6253134776123646, -3.8225746795556423, -5.28688192038675},
    {-2.210294001566006, -5.135025993897905, -4.117913606810509, -2.7811064684361178, -3.487994210524921, -3.9018903620993806, -4.779471618846569, -3.531019512787671, -4.436478008198388, -4.331105113551679, -3.5468112636059765, -3.573028074624085},
    {-3.9044700577636564, -4.747449925293606, -3.382954710579264, -4.818228732026121, -3.7839979172401677, -5.493336172080416, -4.640161896863668, -4.315093194404622, -3.6229217331089547, -5.921975627975991, -4.301405515582739, -4.402736408057258},
    {-5.832938380580693, -4.101818732107065, -3.9123262612251395, -3.843290641489719, -3.3267610986718976, -4.4388443075346995, -4.767816858156186, -3.968471332524224, -4.061134224582019, -3.8056867399318586, -3.0157864784371227, -4.41800585707412},
    {-3.260457408110789, -3.5742151907053543, -5.17794621776462, -2.7626615630255125, -5.654280642752288, -4.287717128086691, -3.8362963434982835, -2.1954715851308184, -4.841104024474935, -3.1314707224702887, -4.206784149250562, -3.369690685672045},
    {-2.76968782679162, -4.595841455965157, -4.566111577745639, -3.0515517410528648, -4.36538841898423, -2.8740998209275834, -4.169930814051745, -5.474394772840641, -4.935428313978398, -4.237453187380822, -1.0499231047325974, -5.249247505277177},
    {-3.1664755583168995, -3.139919244265343, -5.321263839835655, -3.898031412236794, -3.685070065541982, -3.995880900386372, -4.109413459717874, -5.9103995230693664, -3.883205477656704, -5.221301733266481, -2.861996042559505, -4.466543490700605},
    {-4.100613912054967, -5.286499843357172, -5.432497720876976, -4.531607914928393, -5.3536211792899175, -3.5216549147623235, -3.890794828397773, -5.344782988303567, -5.428705808266319, -3.739158289243665, -6.373189082446373, -2.903172762596122},
    {-4.157572881445373, -3.985903525418453, -4.18124746880929, -4.557041486601418, -5.537209125559139, -5.128971905745643, -4.044198367153254, -2.6630625220831554, -3.8454721336286535, -4.2362026745303805, -2.7124691990554752, -5.652593690262205},
    {-3.2107433419626283, -3.50219647534978, -2.9004761697324217, -2.6180988135170113, -3.038685090888249, -4.516475013329777, -4.306602717641099, -3.478823044298448, -2.880478865559627, -4.160980131067355, -2.7907406063811604, -1.8135030498329217},
    {-4.961242462949797, -3.3406938029281528, -2.6656772747291217, -4.990075025030326, -6.630118801488282, -5.14187706119567, -5.361878274241254, -5.729056834676728, -3.656254062220394, -5.695460495916363, -5.495237389841904, -5.155572211830213},
    {-4.052724312807174, -2.8008220618580304, -4.134368198854908, -4.545534403028967, -4.135257321571445, -2.9205376567375487, -3.209352814013427, -4.562532613208986, -4.6194207097332045, -3.135273004138623, -4.538434075539716, -4.185808766143622},
    {-5.552999094486934, -5.228224536764405, -3.984797182570461, -5.04797831742676, -3.3027804521988733, -4.814021366071596, -5.171843694214438, -4.633792253443633, -4.289163184169647, -4.688714654581495, -5.735995179414908, -3.7617141392944338},
    {-4.474842663100011, -5.4456385869487836, -5.202357847812603, -4.6526199755900866, -2.1907805820006847, -4.595740022716083, -4.128562656806859, -2.818223197643974, -5.05311658150419, -3.5296638881210685, -4.535991367296575, -4.981359372361568}
};

static const float b2[12] = {-5.974585491467479, -5.842058587579215, -5.744328271460733, -5.624967519865956, -5.815456960425953, -5.68443670465919, -5.447794587506735, -6.10765168034091, -4.17209915488843, -5.761382135039704, -5.005530336084536, -5.228544047248029};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
