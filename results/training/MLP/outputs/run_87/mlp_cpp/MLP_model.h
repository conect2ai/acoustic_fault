#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {2.3549689376547684, -4.743962148923277, -0.406456105338902, -2.523577421281118, -2.485666595123438, -2.6387169659660485, -4.428683420456883, -1.7463341542255904, -1.3234322284460642, -1.5884267152276546, -1.6185602710431732, -1.9305511368817267, -1.8001559440479613, -3.3000582527427866, -4.4660362187229055, -2.084277831806974, -1.8756865359025356, -1.8907072671376843, -3.790955961438073, -4.552330226011964, -2.47880855086211, -1.0541948609956255, -1.239838544560723, -3.4895579953050713, -2.249018329789371, 1.2756573479032314, -1.5382081446955616, -3.1893779483501357, -2.2701206476713716, -4.658540760889967, -2.158941716729457, -1.6843032355360001},
    {-4.362787623345632, -0.5082056605209547, -0.5042278721283027, 2.0873938133536853, 0.4069334428987762, 0.9935542541730187, 0.5411163599461487, -2.739825337278031, -0.8562994327823694, 0.6955808807318598, 0.3009278619043139, 0.6892014461221028, 0.23426394109517704, -2.7823161328923263, 0.5737149725793083, -1.2178520926079144, -0.7364270643396995, 0.18700026812119921, 0.7656055798221955, 0.6192566814340663, -1.2755854053641678, -1.2237390470585428, -1.1074131608763322, -0.8706923462699705, 2.5866338428302544, -1.2032429868210068, 1.2590088012466387, -0.5924437052730195, 0.8553537955546681, 0.6215877944300895, 2.452004976093344, 0.1566599081864325},
    {2.3154095249240836, 3.2752343908105743, 1.962320856060527, -0.7476817468721065, -0.45739471563443257, -1.515747883691984, 0.8923719575088535, 0.9326799242817234, 2.272266363870493, -0.10262445440517695, 2.373899360378975, 0.45083798806225356, -0.8235646118333583, 3.903369687527092, 1.9638785589601695, -1.3369005959344735, 0.1478637919772888, -1.0986090658366614, 1.4745416492063668, 1.8463774548429492, 0.9115805113034113, 2.7862437389362906, 1.0728425567231132, 3.0524361602276087, -0.859815674083665, -2.3112090378790806, 0.49285349200286627, 1.5191176284016226, -1.141195937237922, 1.8787251802899008, -1.358842341290306, -0.5539301423617253},
    {4.1797974755878675, 5.206511085550341, -1.2426463651136477, -3.184818534296474, -2.211559534797467, -4.09616327047006, -0.9328425466759974, 1.5989617016259459, -1.370279674009455, -2.236025407108104, -0.7386584896721884, -3.4246512195472194, -3.7023660443858266, 5.79742530404723, 0.39452949566908974, -2.2823573920145943, -2.555483769366744, -3.481311704930639, -0.999440476812457, 0.03351399648806229, 0.01336372873277815, -0.4684589145156981, -1.0557474369311795, 2.2172834140430893, -3.9943762982878535, -4.073524184150319, -3.029896597770017, -0.6978938488743989, -3.5393761413847646, 3.5177708021712046, -4.180379114634023, -2.9099978367183037},
    {1.173634913397002, 4.710294354574043, -0.7303378225666048, -1.9713456764166897, -0.28268569591150283, -2.4018086919434656, 2.115329728809147, 1.8131446213614866, 0.46497734379902134, -1.0867972261265455, 0.0095129010777504, -1.3338113813444992, -1.4465310937887463, 4.100108403562475, 3.2032190544788866, -0.7027495765743617, -0.7655780530638794, -1.2078689213356832, 1.1524451411020085, 2.44386024580735, 2.0136934713726133, 0.9142436956401833, 0.6128606856241926, 2.0161898421371927, -2.976328833553823, -3.0016098036833005, -2.5451123129242355, 1.5018493369696846, -1.8846400043355904, 2.7042496477922335, -3.2857652444138683, -1.0950884757702954},
    {1.9129726003646292, 6.151208070360456, 1.6688025672637492, 0.3629424214277723, 2.743346095044437, 0.1359864660192031, 5.753247214075955, 2.7374333704776914, 1.8220805080118971, 0.9036111246614135, 2.163819310249851, 1.0542615870890348, 0.621013840016477, 6.1145326269439675, 6.627783791826484, 2.7113658760403294, 1.9266785750503772, 1.2643401397396907, 5.019653346089201, 6.654014428932249, 4.309028065688289, 2.205684606036377, 2.2262416315899882, 6.694658266199195, -0.7060384652216132, 0.11869910491910557, 1.3459582233021439, 4.89256349627899, 0.6828764569990047, 4.716710775921883, 0.5305707349810739, 0.8921860183125617},
    {2.8698772967479034, 6.313347947690938, 1.5311656640044113, 0.47583909603737906, 2.398009067189359, 0.25087432361416645, 5.166382238004798, 2.882818805679543, 2.239923405351687, 0.7567193086758873, 2.320346136533337, 0.6953538188287661, 0.7076540972605664, 6.698280893790956, 6.487317790656192, 2.1672265527688377, 1.3488731817458213, 0.8085952609175845, 4.70300701922622, 6.217562787845882, 4.099875692222958, 2.5362220043974424, 2.027969309702986, 6.404416446562571, -1.4102120611092097, -0.18208232052694515, 0.8882649092280739, 5.015580066635387, 0.6625003709475402, 6.0300870977294885, 0.37302055365340303, 0.8377916725430161},
    {-1.8627575391018396, 1.1152717450354745, -1.6400271700472326, -2.53982224005204, -1.760879255083993, -2.3498357680889796, 0.5668129949303524, -1.792549709316943, 0.010954430626429226, -2.860305227931621, -1.6680908380744592, -1.6396733818790066, -1.9483701409925545, 0.21282700566212243, 1.0515973099822669, -2.4941833117812524, -2.2957219003588194, -1.0825867164272784, -0.2642377136143984, 0.5434919437771206, -1.6314326073105954, 0.01814975360446223, -1.9665339349374196, 0.1802430751852859, -1.6519428954096664, -2.849632753479937, -2.474339669074127, -0.16235611205613865, -1.9253436997219975, 2.395717129853223, -1.462679077054569, -1.7213553673233009},
    {-0.6214251333808978, 1.807531925978688, 3.0312513494897044, 0.8449508543721997, 1.2759262392889321, -1.3719342960753906, 1.231482779348554, 0.7170299889751761, 1.3583143352856457, 1.75543366915998, 2.0665306750337082, 0.164451814236487, 0.46899643842782623, 2.316115922661703, 2.5501275574925417, 1.0003501107738613, 1.0113901512486965, 1.433969205908305, 1.4630115528329808, 3.412646982927532, 1.234157867217649, 2.545158369158088, 0.9034257035925163, 2.765859785649914, -0.7261593904188338, -2.559856736273845, 0.37707350400106926, 1.8994593632372623, 0.6110804783879182, 2.5688772590575124, 1.0450795306509266, 0.9468492170929167},
    {-4.764584159237161, -0.44125808377490644, -2.2627747719655056, 0.5542195283595378, -0.2715035672333633, 0.211456966242724, -0.04465410303011865, -3.2470814990295978, -1.7688106169297395, -0.3416365419998987, -2.1206625808925526, 0.7593994778265454, -0.21868157963117613, -2.636459898813358, 0.1829800838458045, -1.3549527439017288, -1.0998266035360187, 0.32803675849356123, -0.43952766192666204, 0.37838100815684583, -2.6834538835093533, -3.244586050124653, -2.676829217426787, -1.7644480550664772, 2.8020640236338608, -0.47538803739289875, -1.350828516323388, -1.4901999860913435, 0.24619639408763758, 2.9785711423236823, 1.6399543482050674, -0.008396290643147532},
    {-1.7429293123223915, 1.1956051439699504, -1.895152528745972, -0.6095432413205052, -0.2564776121248017, -0.08964194685199017, 1.9634005570088684, -0.9541152538496608, -2.008850973564654, -0.572238776186873, -2.1681857499161996, -0.36246034081226, -1.0825483383708987, 0.7646605215196369, 2.292945692229849, 0.6712476662235012, -1.0045963053581553, -0.20734449094945556, 1.6691465404891843, 2.335626083023335, -1.0540051632290854, -3.0461352462079128, -0.6497019040133872, 0.7344518197857339, 0.32995761593882456, -0.4810424289225706, -1.3727880151981675, 0.5069166888985541, -0.336216005990313, 2.6606448557118743, -0.6123442609410659, -0.8263168058495077},
    {2.759790530107592, 0.8239171350489413, 1.204534701293825, 2.022575988855876, -0.8563287200572358, 0.3393120482581651, -2.247012686596809, 0.6701827109675081, -0.05577807810672352, 1.2616845241398087, 1.6602757603031537, 0.6323345710917213, 0.20371878884948927, 0.4959014443195955, -1.9743147274735258, 1.084462918916281, 0.470145371482812, -1.1162353329213075, -1.5116653037259637, -0.9089029020011563, -0.644291448692865, -0.07279940819377144, -0.10655783310286093, -0.9084592385659961, 2.0311664743886415, -0.22515457824078763, 1.9373840997518974, -1.909416573657241, 0.2812951033424556, 1.8611795443549997, 0.774176312860189, 0.3219198295119763},
    {-2.948947785676277, -2.009065016613409, 3.4585346570620636, 4.648580951600533, 3.3659130270462074, 5.306765181216808, 3.8114051558050672, 0.7086179573064867, 3.423737947159176, 3.931705135790816, 3.056881804016897, 4.223669688787028, 4.361153433055613, -1.4322427717288118, 2.651576542584995, 3.412462417467068, 3.960687164039546, 4.316923343215819, 3.3957207886471243, 3.238037329997437, 2.0966479283525556, 3.0401822230470175, 3.353107752098595, 1.7769135929946536, 3.6393938360768066, 4.857330973736692, 4.6647416064164355, 3.423649846706472, 4.538101843255067, -1.5404131704502795, 4.838836464657713, 4.2573729031167735},
    {2.3785812192136393, 2.976524073869997, -0.5761336590064682, -0.5969955757435226, 0.06937599162753352, -1.3732564244431706, 0.6618751507609428, 0.6890620377002796, -1.9612722164547545, 0.3412787574044681, 0.014849242719134563, -1.8099974658521174, -1.0340027794063824, 5.056521550407902, 1.5680810222921233, 1.913642517959585, -0.15359413848413367, -0.8816809821007761, 1.6862632039614665, 2.3061580939140263, 0.7620460396040805, -2.3303834291300305, -0.9134245648908474, 3.009646298696651, -3.5365036824591054, -1.1857909574915029, -0.13982009491833092, 0.2867620517055915, -0.3343950285424281, 1.7888339634058643, -0.8718772586694674, -1.2973189036058692},
    {3.5887949171082316, 1.0382136692420638, 2.395961598636916, 1.1111372210102002, 2.923670644003066, 1.0600082040650323, 2.0193737962699734, 4.048932961773323, 0.8714804024366269, 2.6774102964676745, 2.666223332625597, 0.18415129824064977, 1.9718110939515698, 5.693194775196262, 3.255949761421382, 5.846910117759552, 3.36844250794888, 1.7920461628806137, 3.039066200442513, 4.7070962482414265, 4.663066226190508, 2.911523366453771, 2.129805134385062, 5.190964901697414, -4.308363867681852, 2.245363492577403, 1.851327604302507, 3.3729292419833143, 1.5294211772399797, -1.3913650641402981, 0.5277539372767751, 1.472181831185896},
    {0.004028405299192792, -2.197887720923847, 4.151724946987964, 4.209376229687917, 4.119847540172249, 4.4268273912166505, 3.2375657725437796, 3.0094605594802, 2.799245582318013, 4.310001078203834, 3.7265538072686772, 2.857958912202651, 4.666095736217072, 1.8259815284084633, 3.407465714501672, 5.970689333506462, 4.828032779693005, 4.585304689702194, 3.6109877196585254, 3.769997508300989, 4.264974588008559, 3.522028673338084, 3.541636284324854, 3.520248382257038, 0.6571215633974824, 4.95362298990197, 4.086319233631271, 4.400477219992864, 4.0328883006099625, -2.873906257726957, 4.089241546733335, 3.9300488605487818},
    {3.3432146193930423, 5.77868782474162, -0.6862946460849755, -0.42729821157239783, 0.7117271058138388, -1.0194642204618947, 2.2258208957293646, 2.1810058670532566, -1.5645149487961039, 0.21643945889892613, 0.2989949637207979, -1.3732173466136273, -0.9545350434777152, 6.406517143190169, 3.7748258716422107, 3.1128161285205977, 0.036103108357670166, -1.2251727483501986, 2.5842363705889886, 4.47199625826113, 2.7072621298692927, -1.01276231636049, -0.7093719095997901, 4.694169536460967, -2.9872231874588295, -0.9905838561823813, -0.06355316213526024, 1.992199710028447, -0.6630569799493753, 4.71114081442187, -0.1245549382778636, -1.0263498833350269},
    {2.705720547700843, 3.820458202272106, 1.2779068316034072, 2.1099710106436307, 2.5318309826211474, 1.2783722713423966, 2.532745601851691, 3.4005153363870924, 0.7424850256823284, 2.5321716848446707, 1.5228360537709524, 1.6209368881320478, 1.3324174796596877, 4.594444049194424, 3.1172035729418526, 4.122034155567627, 2.786459385749751, 1.4339352069283269, 3.062200466885213, 4.271388534601554, 3.1290327893186625, 1.2386571930907155, 2.031313202077161, 4.322754254432338, -0.7843526458778299, 1.6630249777478772, 2.6574053206351524, 2.709111540777602, 2.369278999233684, 2.748454243687229, 1.9548410757863193, 1.2472503344814987},
    {3.736458582722469, 2.6854298729201456, 1.4246669671658239, 1.001296584705877, -0.5622205624622721, 0.4852290787064374, -0.38965557519173705, 2.479035691256881, 0.47202871221329146, 0.823743302953827, 1.24797438939841, -0.1973572161840074, 0.19061619647528424, 2.9841094267698223, -0.13272545002364988, 1.2579841100036868, 0.4572384286470062, -0.8480508762853489, 0.18223145009021754, 0.9734921005746591, 2.322000988170961, 1.6289798445071155, 1.6071816196868858, 2.080728307293915, -1.102452526532532, -0.027775211713647288, 1.595362727951707, 0.4039716780937662, 0.9321185030693383, 0.9749772008987126, 0.9996156938563944, 0.16183019620616454},
    {1.5414505425839349, 1.2501910557660407, -2.557926575934934, -2.579427334268564, -1.8693328132134939, -1.320150939687926, -0.9742159681341942, -2.22336699813807, -2.600192929357515, -2.0460713850201118, -1.3645829931070388, -2.896153459468141, -2.2875635706056796, 2.113114753502787, -0.48246598280298286, -2.3412221274698495, -2.6529768704327252, -2.4695564663576732, -1.1085920175466055, -0.983735703022153, -1.8313265800466132, -3.3845660808630207, -2.6211837377472493, -0.8923719349737502, -2.295475707248168, -1.6430627935784674, -2.228938618393123, -1.5467932460674507, -1.9208927875969437, 2.4658361038493837, -1.4329992608797324, -2.9549618224405347},
    {3.969994731285983, 2.127441899596485, -1.264487341163042, -2.1864077707876755, -1.2037735537482195, -1.0608903400099925, -1.823612177295988, 2.660135113152497, -1.1555698511897976, -0.1813494980129704, -0.6012923868644313, -1.9209357531555866, -1.6195801326992136, 3.268888154647674, -1.3624263161786205, -0.8860023458672642, -1.448476291790211, -2.0005873599047717, -1.0039839975948266, -1.6566256633778755, 0.20869446130341388, -0.5971970700041574, -0.031613643364285585, 0.5275874509236044, -3.0728529139079113, -1.2764040426717234, -1.0919451704454197, 0.04256389224064363, -0.7872555174067639, 0.8945550728782365, -2.129469716791954, -1.8524132502384802},
    {1.8926882371313636, 1.1928297984568266, -4.3362624952597, -4.037008046467423, -2.7713358704489504, -2.935824253700605, -1.9448520522490689, -1.6214577174669944, -3.8300841706409803, -3.3142824574218674, -3.844000631253734, -3.752816020322368, -3.1030393551385305, 3.276363016219239, -1.622929363693373, -1.8401013932744081, -3.450546371388179, -3.059624732705921, -2.0174207067974277, -1.2824855423043344, -1.9483536417357923, -4.153306769272561, -3.52156201016959, -1.464859071146447, -4.5181349075929464, -3.4063982377070747, -4.191116570163598, -2.4830224298616863, -2.9900942898403913, 1.6400891349346924, -3.596509130260918, -3.6007360365354564},
    {3.3553186895703946, 1.0682079465611407, -1.3064161763917386, -0.7121039520445909, -1.8743070341509618, -1.017047580070335, -2.3540675517196212, 1.2611319618150698, -1.6256628452488466, -1.081924681276984, -1.208574630660339, -1.9317728426662601, -1.0091463320834455, 2.6273918900401054, -2.004261952180713, -1.4035058962318152, -1.6254841934102906, -2.1384438492899647, -1.9988305340595562, -2.4755932804413594, -0.2398205750040318, -0.5355168551637957, -1.0079673885171243, -0.6298533056752044, -2.0826672246616282, -1.4919433820512098, -0.796957201199064, -1.4048308956001783, -1.2074865285901968, 1.096834133381436, -1.7841021230543657, -1.7985443052818633},
    {-0.31878649213602983, 0.6176826425872214, -5.171839888279208, -3.8383149117440514, -4.352841406242986, -3.2097019804161846, -3.240314665160153, -2.38605312098241, -4.085098528569537, -4.583570720149353, -4.5663484671552474, -4.325309061655513, -4.290411083150542, -1.2602293222211378, -4.054141663329634, -4.9172106556361985, -4.69496367932733, -4.260645691720334, -4.05376676079162, -4.742827025972531, -4.280252560682808, -4.470328637298029, -4.13433973450099, -4.6399248458060605, -1.9711209380552248, -4.418941888199483, -4.402122968143709, -4.481493273366109, -3.937519519619842, 2.6070569421074086, -3.910593506845988, -3.7728491114503897},
    {5.509871929128035, 4.711495265074771, -3.626340958282499, -3.3806043941880017, -3.1853913196612464, -3.936330591807431, -2.3379399636546103, -0.40140576181831394, -3.14859308917644, -3.176366272293573, -2.7227518228863015, -3.5358338114933447, -3.751015165071135, 4.750972529762884, -1.7485477969902428, -2.6946456396917724, -3.551139583279484, -3.9191673301817422, -2.3181766658698324, -2.076714006536569, -2.6764640982781134, -3.412100582530714, -2.8639703050915726, -1.0803898527016593, -2.403038712030264, -3.3908003985980053, -3.117147264310207, -3.0567654023614295, -3.8491837899197954, 5.691543515676566, -3.8256108445463775, -3.7906923988221664},
    {3.665994001978451, 2.1906331226484257, -4.160200404691289, -3.5537782430201315, -4.346275587683113, -4.362919716136788, -3.9951520976355783, -1.7353619812989094, -3.687079810236258, -4.062386009792987, -3.397554126838422, -3.4820434255922983, -4.447385838250082, -0.481745963354698, -4.391422876163411, -5.419330039550477, -4.499176270699931, -4.802655596340321, -4.59633043500692, -5.084336995363171, -4.535931263675634, -3.5439364983161554, -3.2104629642757727, -3.6857939453067194, -0.31942777828971336, -3.9539572767562396, -3.797241099388142, -4.612219470646414, -4.705325985939084, 3.866398827961679, -4.044568887358246, -4.240623755823586},
    {2.2667377876217403, -0.01179530225241305, -4.412163370106609, -3.007685450349271, -3.5779085942560944, -3.1439927934917766, -4.605748261029921, -1.2747085561968854, -4.786944948942583, -3.442790166699096, -4.031758004589765, -3.6839218655098627, -3.8534791232995884, -0.9200658987170267, -4.547289018030465, -2.668466701905603, -3.6572720747898315, -3.923344785948074, -4.703635451470007, -4.7130255689586065, -4.084273078724315, -4.964365839536742, -3.3463331463389157, -4.576736522737348, -1.4423192586934426, -3.035966790180305, -4.05635151206103, -5.075958857080432, -4.019483102748475, 2.0435599014866965, -3.722094625376031, -3.1628466754134377},
    {2.8025263515734946, 2.1825602858367334, -1.9504878388920641, -1.4730337135484324, -2.149352971104745, -0.8467425094126572, -0.8483036107324062, -0.5168805124515348, -1.260977486342573, -2.4564855747118592, -1.307283783394513, -2.402874042133121, -1.582199694068422, 0.44458873568121493, -1.1588403759226087, -2.601763039024791, -2.2144101789221255, -2.1192788991101645, -1.5211700942933015, -2.2390076847884988, -0.42722369886290185, -1.609316483692751, -0.6178085965314576, -0.6542257656458887, -0.2915041218220611, -2.329112440746735, -1.495882581130589, -2.1216702447713143, -1.8734734494882157, 2.247031969531918, -2.6645698292253677, -2.1735930366288234},
    {3.6453493726510957, 4.656281113286835, -4.646253193331586, -3.958274987706815, -4.25059605920915, -4.670762319942117, -3.3028557276575343, -0.4791166099411144, -4.741564822375806, -4.100496650228369, -3.874374868211657, -4.437516349555053, -4.9934200561943545, 3.53031299340749, -2.3200705221550137, -2.951105059859043, -4.174158929572802, -5.067964733689876, -3.395709445131205, -2.4548575855120913, -3.305894711606015, -4.740300609435549, -3.9981693532825853, -1.5218587062961053, -3.5028641100155964, -4.657009458217476, -4.266907401899051, -4.148567503388815, -4.921546102187961, 5.603379317552999, -4.655241256443944, -4.897431585142259},
    {3.344030005733175, 3.389758241257532, -2.214653291770236, -1.1821395048748498, -1.9254259283827104, -2.4181818898171574, -1.2182519646137082, 1.153139655214046, -2.812674953565464, -1.8006117601968223, -1.3907750365270946, -2.5648332537743053, -1.8295346834792896, 2.7347543365448597, -0.3878774288830448, 0.3836549596064136, -2.149723003745404, -2.818254598419315, -1.2661123485801857, 0.35102219161694714, -0.08322597783698427, -2.1599339782123885, -1.8935595282440296, 0.7508832242612008, -2.52609208350236, -3.08682226581481, -2.299141424753039, -1.844164642825876, -2.2687042364201617, 3.2597415374934156, -2.8625825023765694, -2.435006562171072},
    {1.8985728703976021, -3.327236805333074, -5.470342830801905, -6.1216485595154415, -6.002578608498641, -6.817415648142764, -5.394360785431075, -5.770386907140171, -5.958348745248787, -5.928285125412277, -5.941806713139684, -5.658321293895862, -6.586788651990672, -2.630389356569452, -4.803958914537517, -3.6269891977616724, -5.143333079020345, -5.444644367917219, -5.894263787125844, -5.237077096104709, -4.766857989944789, -5.5501487702643715, -5.763008621383226, -3.6347044104330215, -3.929433572446382, -0.137681269365997, -5.577047902743821, -5.346903620776325, -6.662352625936143, -0.8009126625332162, -5.882055575755305, -6.046313351961117},
    {4.049964832668741, -1.6547160574138648, -3.7802799428793614, -4.637423926977642, -5.009590050629733, -5.494959400859228, -4.650161779087814, -3.881317968651251, -4.688979219536751, -4.531786502973452, -4.282943996379523, -4.250747269255007, -5.351107324257167, -0.9607872120140853, -3.5619579611315757, -3.332687149345725, -4.931736686626585, -4.936210876421514, -4.413810506060863, -3.6671886668743134, -4.755742110281587, -4.318694997317569, -4.680051382427808, -2.3041310486557416, -2.2851339039352303, -1.1417572201181994, -4.276500637893912, -4.344994305893568, -5.761729709293775, 2.4428301189087547, -4.484286141953875, -4.934777291390048},
    {3.242463167085963, -3.423125606543336, -0.393934810598784, -3.550337499475543, -3.101408199333867, -2.629316838555523, -3.587053306991993, -2.627943452473383, -2.2621290013463793, -2.973653256530014, -2.973104075040531, -1.2925877522003755, -2.644321055960754, -0.9703436198610973, -2.3887012799850758, -2.1443891652937497, -2.5485771601683167, -1.2596109905761175, -3.3874799589377145, -1.5966394233005055, -2.396267209606299, -2.2135741399417763, -2.8027166753119217, -0.08304002108850068, 0.6007340152428368, 2.1530082784613245, -0.4597144015207585, -2.9300928796552643, -3.455741724371416, 0.44691029200031096, -2.4252222240145698, -2.2043748083065697},
    {2.5114645117338164, -3.217664676841638, 0.005928172035759224, -3.09343829437046, -2.809718626621563, -2.722485179067679, -3.5845159318713224, -2.2710024052243027, -1.1266449675140846, -2.066697987747723, -1.6540656462672165, 0.4899721716032252, -1.48715918233162, -2.31199689156556, -2.9344900213951948, -0.7265532591850049, -1.4127565387968297, 0.00024330756788306106, -3.275899174332847, -2.437225897591543, -2.618978054951056, -0.7381232889481916, -1.145374381543379, -0.6495106695279224, 1.1196334698159294, 2.7610372023334593, 0.9225041624106044, -2.8784887552446676, -2.5306436871416795, -1.3860178740403513, -2.051469831411669, -2.358297634494232},
    {3.3081100444310954, 1.5257675521317704, -1.130374828552296, -1.901706810491503, -2.8502127267242137, -2.155763183695419, -1.7971629984706687, -1.9015376267476627, -2.015888413560113, -2.408809827719378, -2.277401127454704, -1.1959895144336372, -2.4685225590456357, -0.736817787335799, -0.6418828330442767, -0.7829195744853203, -2.14505048832659, -1.163841512226437, -2.2960218348805013, -1.4661498389293417, -1.7387182949880184, -0.7756744029316615, -0.6374087752489422, 0.9204766005024616, 1.8825066368000165, 1.1644019853369196, -1.101394021107361, -1.5535489278190766, -2.8198034694833525, 1.4206473970832694, -2.996248578021382, -2.4224255747330075},
    {2.977952224278426, 1.3373108731623904, -1.0526565238430556, -2.1919933076415243, -2.4487517089858986, -1.5792925131486213, -2.785500202181415, -2.448076678673265, -1.935798230022456, -2.7076581328595557, -2.087300967858282, -0.5259207155350454, -2.7004742254679064, -1.0479199850527954, -1.68748593975785, -1.0490107064097167, -1.7934863236196117, -1.6520860353280051, -2.5881407847344, -1.0977175623029398, -2.8765004617082734, -0.8230128352628862, -1.3863003310719855, -0.811545313426238, 3.479670376647179, 0.21653428434294006, -0.2276208443409803, -2.5169464552207743, -2.59016938604923, 2.008653936418411, -1.870618315036764, -2.7037779553121037},
    {2.3250416091801114, -1.1981583398798277, 1.242775227016603, -0.46485418092851427, -0.9008117782282463, 0.08581538108415415, -1.4431759596587534, 0.12272912729562896, -0.3862376761726843, -1.5588364863451583, -0.3449906623037565, -0.23903088127889455, -0.9274656724187064, -0.6298614323159499, -0.3960478015389018, 0.9083140404743785, -0.38062387679988147, -0.03350973216305768, -2.030370400826048, -0.6964684522241142, -0.016084940564678282, 0.162419376217054, -0.5446999283881713, 0.39678695516364865, 1.7196780909900027, 2.104717127280297, -0.12455489852510251, -2.343436374400123, -1.5816725621237004, -0.2972935641780936, -1.1037184248349252, 0.06939888940598865},
    {2.325071698004873, -0.18938380426709472, -0.6301246331875648, -0.3445303954817452, -2.2269450752663063, -1.439813240479093, -1.1924788675739528, 1.0567765939175904, -0.8188891687963559, -1.4855599411970428, -1.473232488968005, -0.41132605202726125, -0.8298095287439924, 0.6845731587606274, -0.6066579295657113, -0.36827216986124267, 0.3850319497578436, -1.2348603188887246, -1.5037006973903302, -1.3117080779543746, -0.8675406816828973, -1.0581581592067688, -1.0290653931957314, 0.24696812685835773, -1.1166357468549504, 1.3114018976644606, -0.13087312166338094, -1.0001651257827546, -1.57002021342136, -0.08773989037348279, -1.1992580674874513, -1.7359395204668353},
    {3.192846263259676, 1.6836695448313619, 0.0028490333614263623, -1.4743498872772334, -2.7215582498088184, -1.705926062243466, -1.4826159873226639, -1.1533404056689016, -2.1274992648495896, -1.6126869230760685, -0.7069572167365156, -1.9574247391304966, -2.6025169939372303, 1.5247005792747605, -0.4738362641695084, -0.45034793447453114, -1.724813822587696, -2.7818804954330165, -1.9216662855054794, -0.15303221961603125, -1.2972440629274948, -0.9460224472368349, -0.3897448295732586, 1.66365832426175, -1.0574252090689675, -1.0694078849211115, -0.9697830462149404, -1.9935077135333834, -2.205483694499202, 1.9195811702337797, -3.0107659254764805, -3.221163844739847},
    {1.0422258214629891, -0.060029000871166464, 0.3065520542273811, -1.414523914636904, -1.7829420520040955, -0.3383101684515528, -0.9523674629413904, -2.001744609227925, -1.574760215937767, -0.8396638825028658, -0.7558976007175421, -1.3981287256926744, -1.3052782902557418, 0.4380149056788935, -0.6259816190026227, -0.39739259233869406, -1.0910111674364338, -1.186199651885832, 0.29852221909310367, 0.35241325584526906, -0.4810109197456537, -1.0005178027580433, -2.0834391189000057, 0.7352133542105708, 0.08313847390203775, -1.5722438775147956, -1.1208413405312936, -1.0231352622408005, -2.1371668146557825, 1.5973246975435549, -1.7351160477609033, -1.3574188256091906},
    {0.8346462075435331, -0.874308365173135, 1.017471415832305, 0.549430003099995, 0.08619109915053313, -0.4579920345222605, -1.4315472985681659, -0.796241845683882, -0.5766682442814048, 0.417860897981979, 0.49961463995281963, 0.2891943995256385, 0.12647900435369547, -1.8976857493705617, -0.8056601191469418, -0.07671567281023785, 0.3986243946850611, -1.014055714922053, -0.7054455891409662, -0.7691129020115236, -1.8187058348538503, -0.2792007046400133, 0.46637483588048934, -0.5564088967414726, 2.262534102051361, 1.2237265698104023, 1.5229831129468963, -0.1898943440964267, 0.0432473891520809, 0.5422566394631455, 1.0365824686210814, 0.5464442414693419},
    {0.7425681945646119, -0.9058856786744434, -0.5628825372951113, -0.7369705426871204, -1.166099850022143, 0.3718810061648807, -1.2001069247790457, -2.043376000645793, -0.028920315562605065, -0.6938978511292158, -1.3933460898767764, -0.17113428588605686, -0.20468555941912323, -1.421405540069453, -1.0108488331375487, -0.5670581598498244, -0.06745644226978756, -0.7762010930067956, -1.0369358390953631, -0.7079110255657628, -1.2990285541884996, -0.2571634132849141, -2.3103286060989117, -0.8591702632873702, 2.5860024777281043, 0.6950218529366958, 0.5511034166242613, -0.9456202138630865, -0.4553036324771705, -0.09183873978453938, -0.6213440035242285, -0.34072491843974306},
    {0.8426738849082238, 1.540087006981269, -0.4535781132101408, -1.7105608788447964, -1.5344206059161065, -1.861452942983157, -1.134681466539658, -0.45864646511946705, -0.9883867033070192, -0.6158272398802059, -1.8353532200120446, -1.83240902866339, -1.4976718832134341, 1.4548496776154318, 0.26188992371999675, -0.7708553037955089, -1.6708280211869133, -1.5324282525224469, -1.1968427077918045, -0.3508343379315123, -0.6630835697544876, -0.32296301554565365, -1.7370671134125086, -0.08360170311421283, -0.4716380408058176, -2.3232542323402865, -0.39804183432784024, -1.036230532703148, -1.9207312468854763, 2.0444949326420407, -1.7113158991467503, -2.546585489635794},
    {0.10865326149835235, -0.846029383936833, 0.07260445789467017, 0.6280918136117293, -2.060759358547946, 0.96816284447515, -1.0462630513976305, 0.1854691776737435, -1.070962284364435, -0.3340734350358289, -0.7120380290196077, -0.9721814592872497, 0.3947013108704332, -0.16722753010660588, -1.2619093650375341, 0.3628039461509207, -0.9591022056398172, -0.558148895761627, -1.6110573257425822, -0.3653448474783268, -0.7999479632611984, 0.6443934405046348, -0.3412269470365761, -0.09379210344973692, -0.5184553599332655, -0.1753849032177686, -1.0610197117846831, -1.0150552203822216, -0.8465813189249634, -0.23744281347874932, -2.0111911501405695, 0.2146664510839357},
    {0.567509709270944, 0.6349979765596551, 0.9000636315846591, -1.8535332919448744, -1.2293870302011944, 0.2432447512598357, -0.46720156116833167, -0.3784818077817282, -0.007218983602540203, 0.03588681062485305, -0.17104371526364043, 0.20385198549925043, -0.25806990095089694, -0.21077620651967302, -1.2597440114703597, -1.7387665848290963, -1.2457012357353705, -1.1641041176449838, 0.4167258168645302, 0.04493582667604117, -0.9165215016217244, -0.6328384679115813, -0.9056304662916097, 0.6653290413024869, 0.40401013927541385, -0.23621186188961565, 0.3956550519613191, 0.0026205518197992867, -0.018313044178206724, 1.0436972436536611, 0.7372082460250295, -0.5946862743781348},
    {1.5213190285569704, 1.3086295585573329, -1.8427352568279436, -2.647779834961788, -1.9595433260578883, -1.3682949651672476, -2.161611589689572, -1.478250732873263, -1.4598274775784421, -2.1501509599263726, -1.26314055427928, -2.5723364125114774, -1.6824730658820133, 1.437400505148321, -1.2027442442710463, -2.3837840148070653, -2.1917413159437933, -2.033658731312446, -1.4223416773625008, -0.750058410117512, -2.008096951819239, -1.5163127162954995, -3.2106823287910946, -0.2906595668378097, 1.1828828842886177, -2.221458397887416, -1.3824774397787152, -1.6395878537423103, -1.6368626469606864, 3.4485187478944526, -0.887174136346183, -2.0001253196969238},
    {1.4032299012381766, -0.18398483467597843, -0.8569307730275143, -0.7583590605536177, -2.4340809685390727, -0.8624946696594918, -1.1039925319902557, 0.4555781993698348, -0.8668549444880064, -1.0114565881000614, -0.8032875033758963, -0.4859127622338837, -0.6789908409878458, 0.4706335820160808, -0.15525420340632104, -1.4232630915293205, -1.6737214054715752, -0.17117091148463448, -0.7837356408210239, -1.5292238252866732, -1.620080950301707, 0.23382446387829592, -1.393095298074972, -1.024494036925371, -1.0626389288383145, -0.01886828969728625, -0.42971771020083166, -1.7690302532694244, -1.3128700650353857, 0.05656631373469535, -0.08762422156791451, -0.4539494074609165},
    {1.1757687981336002, -0.20360811435505696, 0.6074916301621438, -1.3676771464429447, -0.8702650965053291, 0.5745828630162076, -0.15037759934805095, -0.826615072450736, -0.10002117206345654, 0.2921293950397645, 0.6504888180167245, -0.17293285040501255, -0.5398619308265076, 0.25353302035402514, -1.285064465113175, -1.0619211256592629, 0.34797952434167473, -0.006171425308427716, 0.3114406091300682, 0.03536671255198341, -1.0657728845446728, 0.2019210439596851, -1.0977244116299638, 0.15148991988376972, 1.4910976060833443, 0.17869081757158015, 0.8021078947768622, -0.7192484268560846, 0.17059976074528932, 0.08100706337026686, 0.23303713628138711, -0.9306795025106176},
    {0.1712855703294988, -1.4877790667131625, 0.802535779324065, -1.990468116293752, 0.13060533878983863, -0.15651480411275642, -1.1616239194931908, -2.4306173445412025, 0.10830251804102674, 0.07751977905424427, -0.18664885940803597, 0.02124416450564551, 0.87576254156227, -0.3611444316602537, -0.20234881688858672, -1.4622056512207444, -0.6054308519141125, 0.23162245158025163, 0.7379065073044059, -0.12443090102503067, -1.564343723960625, 0.8115044850705493, -0.2687561802698358, 1.0048386633699737, 1.4392974648974934, 1.32079660422927, 1.5513653930886457, -0.46930720580817314, 0.15606304652326888, 0.2734343965112728, 0.03587335602865748, 0.30365588546738925},
    {0.050579597781231014, -0.5419958308364365, 1.0130953696447937, 0.20479469397057787, -0.8494740127587554, 0.9254001250954775, -0.7189322902288218, -0.8036020588342453, 0.5852223840142108, -0.0492521835982358, -0.5159359912186257, 1.320644004334959, -0.31162611364478776, -0.9486772079401917, -1.3966922994224111, -0.9866765813323708, 0.4328940108241973, -1.1263945035256366, 0.2973183741059815, -1.1456498562727975, -0.9857535772979137, -0.3973593813369141, 0.6404395942392397, -1.3259253034412337, 1.008487860417591, -0.6167361623686247, 1.4182899716096833, -1.3170326063802966, -0.2549984202497029, 0.29390139553057215, 0.7834279451940925, 0.2553054947415814},
    {1.0694330955744797, 0.818177985128099, 1.0456608077875473, -0.8273139201463998, -0.5939440835698537, -0.3475964245443341, -0.3575617656868054, -1.652093320651162, 0.9463744106248874, 1.0264209039726757, 1.6268172965605214, 0.9114402986253424, -0.43992527646836876, 0.7884024937089024, 0.45547661951346297, -0.4613077104773088, 0.5434089710693646, -0.005876459954107931, 0.22566174500349592, 0.7410831174228977, 0.09259614835951516, -0.024888078550994782, 1.1369313266954664, 0.5169222170079217, 1.5448169949477215, -0.3613831021659652, 2.3525818799244216, -0.751886974040255, -0.4378106836772465, 1.1811784432597627, -0.057288970467657706, -0.5561731257565861},
    {1.0846302045080416, 0.7270839351115025, 0.02550547035611003, -0.16899065475195038, 0.19313887272465097, 0.6691372958098217, -0.7289085225767465, -1.4552053756359324, 0.2915341060614155, -0.02175969989738726, -0.9632071664617496, 0.6510390229271245, -0.6918918695029852, 0.3746739989321966, 1.7571605212894694, -0.25227324033004583, 0.413096224695515, -0.3048212913824821, 0.8496968525937627, 0.4175089330748033, 0.285666979902445, 0.6289714002310656, -0.591844782913342, 0.5512992925535513, 2.1203101440465533, -1.663979427495226, 2.340944572069491, -0.3926068412595321, -0.32643681854648837, 1.8862658598964883, 1.0494515348109916, 0.7440415896801421},
    {1.1981505793812621, -0.15399229289955238, 0.4932057347925242, 0.47528354689990066, 0.01596719626912455, -0.503549738066868, -0.8859236068466849, 0.04676634436583773, -0.5333411902163248, 0.6323078361384542, 0.4582246131244236, -0.20808473827538385, 0.22854843142772133, 0.40952896561814556, 1.0406956933685578, 0.7810141078741482, 0.5991123675378708, 0.2717124847487336, 0.9140878541848765, -0.037228786225571846, -0.4489620486593448, 0.06608782759326365, -1.062041575277633, 0.9572347204178113, 1.7866549171548134, 1.147955843535726, 1.1650635093669923, 0.6141621039250522, -1.1458825656795257, -0.873035923645157, -0.18787564380310567, 0.15212937841416732},
    {0.39400499665060923, -0.3791210704414457, -0.3704395221708927, 0.1467875682608439, -0.3648238485125794, 0.46264590167792624, -1.4495225089784527, -0.8856061762471021, -1.1289663160601577, 0.8236163290338704, -0.4994413448569882, -0.5637377572694096, -0.5492347014630913, 0.500840655183185, 0.731058957955001, 0.18786919949081365, -0.03554529990764515, -0.42919661554469074, 0.37120946806242916, -0.1618574866087843, -0.5557216102956873, -1.3855166621927144, -0.6202110437071466, 1.460293712694086, 0.5282895285381702, 0.4835736790361726, 1.0554335675227218, -1.2310052245967535, 0.37176068460355, 0.410958843411089, 1.5806120508906858, -0.5651784105884768},
    {1.804053522428203, 0.7242222138773728, 0.1951815385878573, 0.2419020628171067, -0.05193900374688341, -1.397114707900993, 0.5930818378177626, 0.3990517676132353, -0.23515603147576222, 0.5325252319524798, -0.04641976477089651, 0.8922312435308148, -0.8295653665598152, 1.5163844973216183, 0.367124349992903, 0.24808454559492896, 1.2380233326015475, -0.5767198135271637, 1.0631323367063734, 0.4814793145342629, 1.1125402748473905, -0.465070489662519, 0.14739825269589807, 1.1184347537932038, -0.10368399915226231, 0.621230813494141, 0.6588562865864096, 0.2344176766129102, -0.622651730022864, 0.45384948398489, -0.11692531378847197, -0.5365852004424645},
    {0.4590545864584024, 1.055290576666364, -1.3343310538364224, -0.6701437282138137, -0.9647122177743899, -0.9597292268978012, -1.2693923797446949, 1.1474148273073908, -1.7856292556530442, -1.9613509198123356, -0.9705904634920454, -0.9636345406150024, -1.2910325322689948, -0.3456331286276517, 1.2435100284427865, -1.1234578506497916, -0.7900256636752803, -1.1815772759761851, 0.6441392642171967, -0.43421796363776427, -0.390970158710029, -1.200159758868239, -2.181457296888232, 1.3400624819294866, 0.6796672556044093, -1.4322524167408845, -0.2628006975887023, -0.5248486320643462, -0.5145644328669935, 1.5353167983060207, -0.005135771367364903, -1.0589022944405366},
    {1.1773646728830982, 0.0766023664262077, 0.7255944800349783, 0.15128643019092605, -1.104216035720099, -0.2631585328876852, -2.2732800015866856, -0.2799610041099685, -0.9167627260428658, -0.9649883734183999, -0.18216835062446743, -0.33725505507804693, -0.3530366527967031, 0.9899655356692351, -1.4374661690510928, -0.12224978384561361, -0.7045949185334578, -0.20185986377988735, -2.2962024509447665, -0.3137634000630033, -0.06476769521601736, -1.9439152788387075, -1.019526665062766, 0.14983302756637215, 0.19693874795067437, 0.6333869799822088, 0.07510914642067018, -1.5881988740726565, -0.5633345722029831, 1.1558228456450452, 0.266626092214096, -1.1046628463453245},
    {1.8258819944409488, 1.2727111032780825, -0.1380124025615783, 0.4937629988766018, 0.87320438505292, 0.39863684065095034, 0.9925904534498121, 1.438364121301436, -1.825230217030037, 1.308441053689416, 1.8069751155397384, -0.4324506466863344, 0.20727811993226397, 1.5216414114943828, 1.2249783315227063, 2.0817986664207364, -0.4138448084354507, 0.4382634705870144, 0.6552513956014463, 0.8454164468336953, 0.28536001695223556, -0.09719120673559652, 2.0736066283951047, 1.1013165922772277, 1.6507217288989384, -0.11863319768977786, 0.39172176211407306, 0.05026691069960497, -0.09729428035251626, 1.3446867841772256, -0.4447283968146252, 0.5274006393633585},
    {1.9620397647316041, 2.1156736651700636, -1.129302723048052, -0.3376966670029028, -1.2989362642060598, -1.7680921549447266, -0.19137920293974983, 1.9091636066624973, -1.0347329023688412, -0.8351064930204147, 1.5895130494045298, -0.8734966305710562, -1.8707067648134899, 2.1832255184988187, 0.054767872387978866, 0.19301978036459358, -0.647846237999681, -1.8600937167628961, -0.5075754507782537, 0.720802383584131, -0.47689557381796227, -1.2261562443775513, -0.8215076861324377, 1.7145374554420378, -0.6217952810328509, -1.0406708012403805, -0.4057635296915948, -0.9547516956342661, -0.5157089100197688, 3.3357362789286986, -0.9432386111808713, -2.053254177163324},
    {1.889157026729513, 1.8937873167562167, 0.6714510227738124, 0.5874971324224609, -0.17824735409001757, 0.16217619018011747, -0.8545653294047421, 1.1605624346002767, -1.32544000054516, -0.6650376088830056, -0.5957726658440919, -1.6010939508593687, -1.0848165912734373, 1.5412637727049077, 0.19861859819622246, 0.13882828381462367, -1.1963752682108686, -1.5341607059569837, -1.33755010257503, 1.4411820956616386, -0.08272769874810894, 0.6758957584552306, -1.7345656423092122, 0.9959344548873994, -0.34326974103637725, -2.3375582036880993, 0.14932860821448918, 0.026055232674374165, -1.2988782792568732, 2.032019095372024, -1.5790918010665211, -1.570882689953323},
    {0.05063499365712902, 1.0026269257778346, 0.9042115968925858, 1.8360160015537963, 0.8351963893970029, 0.23317826044344214, 1.3346408206395475, 0.7764874567805855, -0.11423976722136983, 0.1474849882937805, -0.004587512163756202, 0.9959612603279524, 0.5251593043793129, 0.03498683079515631, 0.27870749173570863, 0.20260009633359943, -0.05139332294871922, -0.20361542946957342, -0.0921430999328559, 1.2196847989920612, 0.6162317833889169, 0.008334659073283993, 0.21343740077664694, 0.10552825851556616, 0.5487017999499935, -1.5512388574343399, 0.36019072658214185, 1.0734175650410103, 0.5507419740767879, -0.28325552598701426, -0.11484023289624147, 0.19250446645638106},
    {0.4868589910052463, -0.25598785212952774, -0.4246156930191804, 1.3628394107217425, -0.3862662905879394, 0.21573020194073192, -0.41530508037723984, 0.6972375684685194, 1.075322477399264, 1.60755055958221, -0.2730974380140233, 1.8009944988631967, 0.1905713758852345, -0.6485644660872307, -0.5801442468829283, -0.15740604635823877, 1.2506246387754247, -0.2949473851563211, 0.7092906992986134, -0.4001999893599151, 0.7242663174518926, 0.6693289085794937, 2.426163131835179, 0.054882438148109496, -0.7014831168509921, 0.4843995571936235, 0.8830969565227896, -0.6481891241146008, 0.4860684337180881, -1.6159328396655817, -0.9508257953275365, 0.40053763384230007},
    {0.49266349445901725, 0.7382932073989769, -0.8858742068905222, -0.2730504837661235, -1.0535735267447988, -0.824817394983381, -1.0515247251858826, -0.06283490161102909, -1.0465608514255365, 0.2826967580873835, -0.34513602040996666, -0.2341758939261655, -0.43855937230529213, 0.02935370305349285, 0.05439826891735851, -0.18232276582786705, 0.1056102823921474, 0.5705926206924987, 0.34198452376999977, -0.0033419292842570563, -0.5743582658380056, -0.28663273829137015, 0.6522565411496459, 0.35461082845841024, -0.9225393063080825, 0.08405157451684608, 0.2367016393499933, -0.6387203305020875, -0.10368391598407248, 0.17827332036079116, 0.9789754597678164, 0.4039513449735895},
    {0.636368408603932, -0.018897730227576997, -0.6732932267826288, -0.3404185229627863, 0.3219134236744855, -0.4416987207493145, 0.21133737890956997, -0.4545792044259439, 0.14045719663276252, 0.14575635064194803, 0.3542744479907085, -0.4750686591001171, -0.20290105368276573, 1.0058113748970987, -1.0990854669230556, -0.011068031988188249, -1.1079678516004627, -0.6939148721082491, -0.06386600946297079, -0.5467333283740085, 0.5822151462179067, 0.08924748358782501, -0.20040079533746247, -0.4419461378069831, -0.8495476845010612, 0.04481778534097899, -0.565607721400275, 0.5826951436104101, 0.01086197425068266, 1.1275567528231294, 0.6097092555846892, 0.3014891874524665},
    {-1.131869255539443, -0.4367485542315382, -0.19796953868704406, -1.492275838974798, -0.47846874972848374, 0.31191533270626837, 1.3575094767315476, -1.561144977832343, -0.338741591541964, 0.2828841190166873, -0.10067614799348024, -1.0292326981422564, -0.44125604234838867, 0.8441174033427221, 0.01908268189211805, -0.8270916279631576, -1.0946489049488177, -1.2489306135595504, -0.1075403308923114, -0.023134690310664632, -0.16288989207093335, -1.0838384077132694, -1.3839872216665954, -1.572835309765269, -0.5736692146450699, -1.0932337208105765, -1.05090922155426, -0.1450705945594943, -0.7537148530706382, 0.7828814220909995, -0.16826520670971237, -1.2503497037989788},
    {-0.7389856969878474, -0.2152406324308376, -0.35467163111310485, -1.6925586085679334, -0.19188608432477777, 0.4371946501402092, 0.8568482873009937, -0.583340355969765, 0.07675051950931631, -0.1871170594187186, 0.6134347276067458, -1.208542571675239, -0.5671915223292885, 0.4103092552329203, 1.7563792633603643, 0.1787762203073461, -0.41985354156775045, -0.8386942313777722, 0.6977880978542151, 0.4434958218799498, 0.1457914465690379, -1.4995633791554654, -0.529909751407627, 0.1324202087374935, 0.023563448833940914, 0.04323273143154157, -0.00010559696905174028, 0.24947750381720707, -0.2681889056117832, 0.8143293797804794, -0.06345953386254202, -0.6318605191442798},
    {0.07092606374708986, -1.0818003206013174, -0.1268767799488549, -0.29790831289149816, -0.8633160648921532, -0.15308002701417522, -1.1664576532427544, -0.5266852459504927, 0.12378667578254093, -0.31612106296477654, -0.15432374368530338, -0.6391383919046163, 0.11336840810307403, 0.27773823505802164, -0.1598510631226462, 0.12697109380035446, 0.38040433733369766, 0.5852899438917027, -0.6017348770960427, -0.5824346133936764, 0.06692587197835727, -0.6070827826606695, -1.016090889012367, 0.15821043923373032, 0.8101237918923099, 1.426252202586596, -0.2141453406772733, -0.5174325686892455, -1.0769769895919743, -0.033848430787254365, -0.2223597932430583, 0.41259626383611453},
    {-0.5988537106408439, -1.3393055095743227, 0.34062768346202466, 0.23742839253317172, -1.5304084146868127, -0.5288702483473326, -0.8741478244302576, -0.2106860576596686, -0.4723177344780889, -1.959495383628891, -0.600826457482338, -1.8022897219628546, -0.1525027728586376, -0.432131242040553, -1.466230636787549, -0.5497090117010098, 0.16003638542084683, 0.9216723549989609, -0.7398073459998024, -0.788767390114084, -0.2983790002663264, -0.41284814655524676, -1.5270312270671076, -1.3045068399015822, 0.4384985065239795, 0.505391140036789, -1.0629936838060716, -0.47393614372771986, -0.9543809602293479, -0.9950223561631685, -0.8898495196233255, -0.22389152522251682},
    {-0.33079505756913025, 0.48311393030914995, -0.41954779336885595, -0.37691779715002616, -0.7252773285062915, 0.20475106380754787, -0.5035112545487963, 0.6560765057973791, -0.4496559422757365, -1.2421837999651413, 0.25907600471477743, -1.4073253099283989, 0.1718222996419593, 0.5289200610984479, -0.0004266535631475218, -0.005317310654900026, -0.26307753758183844, 1.0906571337977315, -0.3664727287719509, -0.3910840309020039, -0.694442514238876, 0.40303641927095574, 0.09052469466731371, 0.04422662974071662, -0.31464673019809264, -0.4078887237729914, -0.30574194856852543, -0.2632983402411751, -0.12666656381360641, -0.008942626393852703, 0.21773739428764707, -0.6130887323257697},
    {0.052168551410101745, -0.39972523815979405, -0.7198018973985499, -0.5016100990130488, -0.310201304074918, -0.43663176727690034, -0.16677633823592927, 0.7729608376082315, 0.2435249381212975, -0.1147531328788106, 0.48278449864491385, 0.44747600554595635, 0.5344071991929079, -0.3638159338997743, 0.8732423995858813, 0.4739616314153376, -0.3311413806238288, 0.33035057616315455, 0.2448285721711588, -0.22263301863517992, -0.16247747721283756, 0.12879079888134676, 1.0250446857924929, 0.5778894602781319, -0.5669173481938893, 0.7792924908907389, 1.0960870695776697, -0.5260832898517676, 0.8009644950721772, -0.537630809414175, 0.19493225357344063, -0.7503201809103915},
    {0.21764719855375214, -1.0131419834963942, -0.3266545704509054, -0.9734379353037054, -0.11177042384112797, -0.6664403033535643, -0.9874056593971682, -1.11112644503745, 0.6765172512065237, -0.3588951938529457, 0.2726856056837174, 1.0191463249545636, -0.29810303676281164, -0.554594536841067, -0.5309553844038484, -0.19766992366544767, 0.4514504183406615, -0.2619825200614252, -0.18931703312847895, 0.2508012823216893, 0.4560271670813652, -0.47390596585019046, 0.010801513281393876, 0.20102428510127548, 0.7025010768054831, 0.036462024241145835, 0.3807345817936065, -1.1254607067234939, -0.22341499498224612, 0.16968442131998, -0.03636718278381383, -0.23359537744423134},
    {0.3436424157807524, 0.31806281919363605, 0.2963482223978123, -0.046087752556038517, 0.8549656018681311, -0.6081298280500402, -0.7450542469386433, -0.3119111218504381, 0.601487416042287, 0.6205443565332048, 0.4434100161709894, 0.575077297444286, -0.5041939071573939, 0.5587810901317067, 0.00012442857841302358, 0.33968678684153625, 0.47017695306842616, 0.6877721209861304, -0.7514198950030276, -0.33532568006068875, 0.20034649824399178, 0.050845320452619726, -0.13199655343115113, 0.024850037446236307, 0.7863070578121313, 0.2386344676970687, 0.2400845164813766, 0.26612845840074606, 0.19459130379305556, 0.8957324461516845, -0.08215957607091741, -0.30919094147546994},
    {-0.7191289801832585, 0.04644969873322756, 0.6630231312985776, 0.396400594755545, 0.832419992697132, 0.6407056497231547, 0.7455985011120229, 1.5551643847591616, 0.8423212516764783, 1.107631204498848, -0.10648224584806062, 0.669919420601416, -0.39273252517547375, -0.2842709847183939, 0.9697688993517461, 1.1248218719319556, -0.033852997840062814, 0.028846379245281144, 0.37222794922383146, -0.46904831989936124, 0.8348737100352704, 1.093204253096628, 0.02293077311432335, -0.09852165533302444, 0.9594562552389345, 0.40367395984852805, -0.17599129500411473, 0.9433687895576596, 0.21501569454808217, -0.15950136543444998, -0.56504718726866, 0.36285491712758355},
    {-0.92456329116595, -0.3648943433372014, 0.4986077676553208, 0.7096787113758697, 0.17248159184805553, 0.4373148901426673, 0.7357912443384669, 0.4076082059365596, 0.3840617896662431, -0.06941586440467278, -0.6586686798119435, 0.783735335562137, -0.08324939352412256, -1.1062409481522957, 0.41332204053585003, 0.720188554036147, -0.1794793390630894, 0.5649799981386953, 0.9705422610269862, 0.01914461220159785, 0.38890176138058, 0.5458520267908816, -0.822307768213241, 0.10745986465680823, 0.545349516849906, 0.40513021884872236, -0.11237361733413145, -0.23400857908064712, -0.19734746790491658, -0.36670172829275893, -0.2833095976049223, -0.0083217671023582},
    {-0.3968411865485197, 0.2308337805589, 1.1352315369192245, 0.6477304164472003, 0.40222880941906947, 0.04568733552390284, 0.22225003092007087, -0.1566359258439558, 0.2984391763111765, 0.6769206717546583, 1.2848012562864306, -0.18107020987322878, 0.6806542341992416, -0.6307582311486264, 0.2674947935465224, -0.26853566560982406, 0.18549678900031086, 0.6199212365990316, 0.6281653063816938, 0.7115758477947561, 0.0798601260609994, 1.100127745918893, 0.16318949890497195, 0.11354989881748262, -0.732972025236532, -0.8315203213360917, 0.27201358370137396, 0.46648860020105004, 0.9498979086148293, -0.7232828360298461, 0.893158145935425, 0.5742137655464867},
    {0.5831581751210588, -1.1426229713476588, 0.29792740558049263, -0.9221864630542963, -0.04029351847527119, 1.0260887100729053, -0.0885646364780102, -1.014498675725673, -0.47017662201385957, 0.8514292460539689, 0.8963410828996509, 0.3701693351161172, 0.9636110134999777, 0.06159937273001404, -0.21993883407630369, 0.38668997322114085, 1.0254755678827234, 0.8920941275519885, 0.41415217343659855, -0.46039014916290916, -0.2630912937032312, 0.34386327777434994, 0.567807157505988, 0.0780496193923337, 0.5023438187630596, 0.40540175800949324, 0.8432471577082371, 0.8651664460135717, 0.8455981914112858, -0.3567287034588181, 1.1825159529114633, 0.13345685583827202},
    {-0.6133330088434645, 0.7037540207847272, 0.1495799383092224, -0.7133083823782238, 0.7679907702456261, 0.40253563704396744, 0.772617340837212, -0.5597426266818999, -0.2832966129065194, 0.645544918693956, 0.7359063509588475, 0.38549474386607663, 0.40605819155978623, -0.14362196416401787, -0.043114174431251755, -0.8033534906147761, 0.037806248217552185, -0.6006432448811939, 0.058117489529010066, -0.20700253384090528, -0.3216741259989736, -0.7894669671966883, 1.1172496736731914, -0.05019683888207029, 0.36479797819818754, -0.49642348034074296, -0.4941670160084893, 0.29363721049269226, 0.3094103795530662, 0.2903590874819981, 0.5996895667989659, 0.40726500707679675},
    {-0.04455574464253149, 0.2271383883198727, 0.6054552124456308, -0.15098730314010317, 0.6095768798587258, -0.4752752648281882, -0.5065804527741737, 1.0867216765004066, -0.27937605964106493, 0.42480493584094026, 0.013279654522821566, 0.47471141267004074, -0.04831780879161977, 0.2319279992512857, -0.2006462975623412, -0.7025643998365487, -0.36263077981087266, -0.23518305767240905, -0.0867167646544164, -0.2526814634025279, -0.06913353920968275, -0.9273787931723692, 0.8531465067212181, 0.21550199494055453, -1.19376334572142, 0.3423807826553008, -0.1380202109025858, -0.4488603119874893, -0.10611669838875983, 0.31305742261744623, -0.7564443790241528, -0.07271368803648257},
    {-0.14294869401660582, 0.5335116626869176, 1.4830791594692108, 0.09522480761249139, 0.7885886655294919, 0.16115937458680363, 0.13238678891134445, 2.131561146711183, 1.0518293459239265, 0.6060746704779356, 1.0302055414260731, 1.423395908675696, -0.14833335268543707, 0.04274582064157462, 0.8787247306702571, 0.5001475413174743, 0.4438364944369238, 1.1772023431916838, 0.497808295973711, 0.12022897521488539, 1.0496042687251075, 0.8803168161234707, 1.5207925503827817, 1.0119240912285143, 0.14882279887579947, 1.3464524869974077, 0.16581771195016476, 1.0264768609147517, 0.5903304162289423, -0.17166643581909902, 0.6768519441430912, 0.3266149542784882},
    {1.0132537046607317, 0.1870016990847652, -0.6459239094511909, 0.45744492704695744, -0.26546390022597355, 0.5308894213387064, -0.5209325423112933, 1.097479037247548, 0.23989663698046404, -0.22726598664825648, -0.45513296891533805, 0.06389074216062306, 0.35122426965792025, -0.1448954480808732, -0.06990781418142311, 0.3391095540088431, -1.2257774687224348, -0.22942275955069974, -0.5529804815196747, -0.19851487066766393, -0.37350181193921567, 0.18308430332414957, -0.8002954202284381, 0.0466159395713907, 1.4378621345100746, -0.3036078292522456, 0.5357158749720892, -0.1728611543069664, -0.0363068615498578, 0.6319761548899888, 0.2862790734871922, -0.0025342160953506407},
    {-0.1931240345463381, 0.14488844096921868, -0.31119296567302845, 0.7803865812335266, 0.06586836582823037, -0.038837205321606096, 0.049453807708671506, -0.07043665568637525, 0.12626116179638408, 0.31922608874093616, -0.45554412127856647, -0.5492286535550576, 0.5360643404988893, -0.3451146950013913, -0.8479781536118974, 0.2742801675057141, -0.4052692202734887, -0.2598575338254978, -0.7939846271264065, -0.23074316018230612, -0.7475058505973147, 1.1702203379782907, -0.824375966706237, -0.70406765451117, 0.5577396420919871, -1.0928418958562143, 0.06371096956550128, -0.21667554719331678, 0.3109162115878682, 0.603315670287266, -0.05009009460887386, -0.028836705734383253},
    {-0.5867671792187316, 0.28468778826104346, -0.6065565616973653, -0.07675501093009088, 0.2596686840052606, -0.8629860755638111, 0.7373738291486639, -0.10510443895793387, 0.1629669898396806, 0.39643660762775446, 0.20590762253609812, 0.5645566801034577, 0.1368588006026059, -0.04633562973101339, -0.3492306982036016, -0.8437960314781927, 0.12786494032330006, 0.14650410535021346, -0.20351621830695404, 0.24488036957270756, -1.1940354075268398, 0.6196032663981754, -0.33078780651241296, -1.1125228395091513, -0.4275281743836324, -1.4606161762830054, -0.33146911731202006, 0.14532738048115124, -0.010858695073484392, 0.2893556035197712, 0.394764992735466, 0.7416162783426827},
    {0.560095048754893, 0.2473170047856771, -0.9992537483891952, -0.340442931022674, -0.2965332827857225, 0.3607430821335102, -0.39804660127822805, -1.1002529721030705, -0.18921749570235014, -0.9114617190896177, -0.8182251478155176, -1.086730329416763, 0.27593728401889983, 1.178413064939667, 0.15301453989717345, 0.6345600877762596, -0.14481836340003812, 0.07696076604125394, 0.4927681509445085, 0.6978430486653368, 0.19071419615648746, 0.08566392067766582, -0.5817613436617872, 0.6695979122424376, 0.5694398261182054, -0.8154008274397061, -0.17912927979194876, -0.7265623907364742, -0.19076715909206163, 0.9071797643447408, -0.18594148101270896, 0.12743573886080928},
    {-0.6723144406575314, 0.18187383483241298, 0.5346922559287568, 0.36353926708275763, 0.5475999329198339, 0.8879531208423833, -0.13474369451313895, 0.2594855224418691, 0.2651922109969222, -0.5152080579531063, -0.23468574310937967, -0.6807889297479021, -0.24077288498683494, 0.15295596734160208, -0.7152871376193921, 0.14134394348649604, -0.23683128632649272, 0.02862182467851358, 0.2689468471459307, 0.28729858304816774, 0.8941918547599815, -0.0192829165282863, -0.4044538604539717, -0.3692075504911056, 0.34010919793522726, -0.9440857836291777, -0.6278725250410369, -0.3737169632285966, -0.3930707421024211, -0.3305198479054418, -0.46817668508086, 0.5340890193436001},
    {0.2885012824689552, 0.04248836017113489, -0.34866028083995093, -0.8772527130243777, -0.7777242257383467, -1.021237887407955, -0.8428325959862617, -0.25342467085688425, -0.05845575971702406, -0.5540239981232228, -0.5430518023089324, 0.2518759447295251, -0.9278899362875539, -0.28990303819745994, 0.055774433506665055, -0.742479698934543, -1.0456992636689038, -0.8810609538255467, -0.7148469957320308, -0.4514600489452999, -0.4175498979709552, -1.3376911003499266, 0.011873227344560646, 0.07834572459478459, -0.5025667067443941, 0.6678425525017894, -0.48414322420104494, -0.540661184536617, -1.2874287587616176, -0.6236597212323174, -0.48208174391404485, -1.0196006763713574},
    {0.8154281114396275, 0.8362529546499994, 0.3370108633781442, -0.28378819713436815, -0.7919995117048727, -0.025569461802935324, -0.2821206901410169, 0.1196970067058114, -0.33362704449076036, -0.8108564441833244, 0.37166948029789204, 0.20942469432982355, -0.14935030680060135, -0.005338538000831376, 0.11716071915428355, 0.10739149300353584, 0.4283316886455447, -0.33182261385628425, 0.34093538123657896, 0.36238521007712965, -0.7970855523335688, 0.27084659588152876, -0.2126662137857267, 1.3181801657350811, 0.6241975330202381, 1.0851782832197392, 0.9365168184201142, -0.18928914058222862, 0.08865136424286411, 0.17023912016030093, 0.40332024573276315, -1.4231556365256521},
    {1.3761879851893966, 0.5266485927540424, -0.08942140445447756, -0.531874560126287, -0.45904845090253504, -0.9121178877900019, -0.21906058135748085, -0.26300145451013657, -0.34749222482406145, -0.5728791741178092, 0.17038693439796415, -0.2291003624109947, -0.5302131042396744, -0.3962908414021042, -0.6950492828203766, -0.3553731967511951, -0.3103581847597971, -0.7900906345347651, -1.1956718251739085, -0.3200668766475704, -1.6009548539568, 0.008917690782632414, -0.05643133088089109, 0.8624528710569107, 0.11096527742970555, 0.9935984618160272, -0.4444375366563035, -0.3519355332284381, -0.6366436955689142, -0.6864398950776527, 0.30380809324916075, -0.7249164130315238},
    {0.7382164388280282, 0.9185250971236819, 0.8411869859144603, 0.4753764906978679, 0.15254325538003424, -0.2041924374460031, -0.23089318237884374, -0.9998415407026661, -0.41851142912750205, 0.7706290614497251, 0.4324677717759592, 0.09756627032667631, 0.9911453395196623, 0.08654998726749358, 0.994295909294062, 0.4289695128661976, -0.020957547414577993, 1.2396520944839928, -0.25326522782489924, 0.08604028900549433, 0.08202719649884861, 0.5700717489764852, 0.2866141456018262, 0.5563688833332096, 0.01855370550671423, 0.342393532364652, -0.24251934590270632, 0.26226868055082303, 0.6281258104745951, -0.35616459572415843, -0.3081501346692681, 0.61929813412478},
    {-1.3154886135058148, -0.7631352100804017, 0.7217375995171863, 0.7662355604163078, 0.2001401225373173, 0.057199495792210155, -0.1926044623800202, -0.49394917616055556, 0.01781842870094648, -0.09355080984293232, -1.0288672318074397, -0.2034095360398407, 0.17375261643756182, -0.514222142674416, 0.5997837567169468, -0.9341642777130581, 0.15378541082437724, -0.39044708407426787, 0.5239919106869678, -0.44032190525110193, 0.5848406376316396, -0.47199141873105455, -0.8792322986958885, -0.21944944437529562, 0.2512684682768389, -0.04735656480040614, -0.24630640123704087, -0.26583414330307437, 0.23008244379295392, 0.4660067310521808, 0.028568846002575435, 0.06375078995959169},
    {-0.5626942170348054, -1.2345353638965497, 0.5518731882402397, 0.6541844243419721, -0.03868324348812767, 0.05232121915031675, -0.5908208940756411, 1.0516218161314426, 0.26875628306442073, -0.6203990258224876, -0.6426134480525876, -0.3863397302030324, -0.44981275892279743, -0.39014924210160584, -0.4842623332402139, -0.060055157727347055, -0.23140418671644766, -0.24671534351874747, -0.16966470468537267, -0.5658565922542756, 0.13769935133359285, -0.03467741869821821, -0.6336390538316025, -0.28662692284456365, 0.42300956215176316, 0.41331684869937946, 0.025440225644429843, -0.20972366367757453, 0.04361763923664671, -0.2653123090996054, -0.491272662017633, 0.8151555933269907},
    {2.4178766829120417, -1.0872977083627817, -5.618691467173181, -5.476749922612026, -5.197154187241808, -6.485422458354643, -4.704041767767844, -4.871945826965468, -5.919628238314178, -5.622633716518974, -5.405986901744584, -5.458591071555597, -6.472929232561263, -1.6559443362921047, -3.5567383947836224, -2.580543398437472, -5.3885075634879165, -5.2065527828567095, -5.296865006018382, -3.774295012776387, -4.065584472742361, -5.751906075037089, -5.241774202724011, -2.7283772381830063, -3.0418362381766624, -0.5475602943169762, -5.220919666233779, -5.269757873228222, -6.152046065613722, 1.9334768100434332, -5.298052806004063, -5.822925498857676},
    {2.9145603563773306, -0.6977690341653576, -5.215056657451201, -4.5506608101795685, -5.189522219845537, -5.850401828449108, -4.75477251467038, -4.078978218855414, -5.958866400583059, -5.353694090512502, -4.817588027215865, -5.25096190307193, -6.041496470575955, -0.8745753011576378, -2.874673844391778, -2.527749528584374, -5.5042912099931, -5.705610178568389, -4.528597563713815, -3.1335061864851075, -4.352767141023806, -5.716051898237023, -5.345875820630788, -2.348486733385911, -2.4059370855563045, -3.0153800049093813, -5.443705215501027, -4.925467020821162, -5.918308720182042, 2.9484999438027524, -4.81707994260611, -5.546905618750181},
    {2.83383625622169, -2.9351002844082688, -0.7203755398629718, -3.1416578321436552, -3.03335733239919, -2.179970291866973, -3.476799092907463, -2.382027484263084, -2.6015606011648296, -3.09709060839726, -3.483717668296639, -1.2856775142431867, -2.1444794154876896, -0.4456800633157842, -2.8812922764126543, -2.401390518090993, -2.9134505003223414, -1.4056990147946045, -3.0946096454874, -1.6009066492948958, -2.8099979570605575, -2.773890704427812, -2.9870281820544595, -0.3215551650121516, 0.6854124882847755, 1.54998505474384, -0.8417053494220524, -2.752130747924463, -2.7354008406611685, 1.1227095107951535, -1.946939874467776, -1.5943054013493576},
    {1.620298490784183, -2.61191069351097, -0.4241501676053274, -2.768148706407667, -2.3828620095205717, -1.9093427996444248, -2.3238884437407124, -1.3103214843154543, -0.8851836470022157, -1.7861796792096134, -1.1431626104381536, -0.37751141668380217, -1.135147573731614, -1.1031736621493862, -2.210412411933767, -0.2650714053893181, -1.0478087399286082, 1.1434575263513167, -2.8489954578593184, -1.7213765656803497, -1.9172357963925797, -0.8134205556238207, -1.5128697555538877, -0.6354643535494281, 1.4857007702171727, 2.504074750488045, -0.10852234867354903, -1.4301583327670122, -1.9625548465895117, -0.5593433097093936, -1.608867508805697, -1.9101227348307346},
    {2.879371840281243, 0.5783038332595352, -1.2811272566343144, -0.9859150779337958, -2.374761092191012, -1.3442938637118984, -2.0367680875657324, -2.4222261942257446, -2.346121002653615, -2.0222748163415556, -2.2600164912863745, -1.1943366785311582, -1.5026500512431622, -1.1525126374629162, -0.8066549316169904, 0.10304299483849258, -1.6151468225934085, -0.44708643400952597, -2.130201147277603, -0.8365077075622427, -1.830500278386422, -0.7327562285646376, -1.1502088521738163, 1.0324026039041105, 2.2494456578809863, 1.7464647071733095, -0.2960707340356473, -1.6375395276625622, -2.4577837051946694, -0.3182875869890813, -2.4722967788402106, -2.208370039658806},
    {2.579943508901743, 0.32264316869598414, -1.4484109027200538, -2.297917922686813, -2.086780736730651, -1.706345429957515, -1.8560546818096173, -2.8089037060948585, -2.3562684590759275, -2.5428134515030782, -2.22173514952953, -0.9993749047864564, -2.7164522536394005, -0.9739597736109895, -1.8492799037372558, -0.44056653454691774, -1.5189419158188144, -1.7625449550112775, -2.029357791588434, -0.4748215533134095, -2.6092317387689308, -1.9961276552543048, -1.7893273982183582, -0.8927886982981235, 2.5604426680599275, 0.6366214787161103, -0.6631768600157284, -2.21884624462882, -2.274097920639056, 0.8793620549676279, -1.9851808751031108, -2.8690853111579897},
    {2.660419444155043, -0.7827237776681419, 0.49660522835599374, 0.14250176090985497, -1.054887330899298, 0.15944107157964488, -1.1581006930255344, 0.8222216213514123, -0.6091982329136311, -1.3625357149238615, -0.4222206876021693, -0.568785768053506, -0.3101294356489869, 0.43663944347295336, 0.3833079766931839, 1.401495522026724, -0.42415372926734574, -0.007040343861520188, -1.537558339067656, 0.40191193618253246, 0.8051597407746639, 0.2915281160538121, -0.7118212984245096, 0.578581483522097, 0.26095032556036696, 0.873819513477721, -0.6372848685479071, -2.235214577445495, -1.3510421276751765, -0.8286195489353437, -1.424791049545713, 0.3813385967333236},
    {2.153234481014464, 0.4398795470686509, -1.2142323600829201, -0.9500104515783343, -2.324161213371281, -1.8038353517929304, -0.6942443741364711, 0.5145845471686795, -1.4513620340791802, -1.4568789520860013, -1.5167767657227929, -0.8801559547452924, -1.7859612156907445, 1.1582929365243915, -0.8352494800060443, 0.13996429431571353, -0.3608369786320516, -1.1171421500555752, -1.4954071779635933, -0.7511782131597828, -1.0518456661648585, -1.3483593313297735, -1.5083031179174653, 0.76238008762164, -1.9632872534760406, 0.8835924649045453, -0.6682083077607948, -0.8255781728146548, -1.8946549109961177, 0.3896875065341329, -0.7529521696850499, -2.334706212294061},
    {3.277595692212195, 1.7143315558444032, -0.24509884291293127, -1.4097939389063072, -2.47794695204031, -2.291767025562543, -1.5404812177425555, -1.1929901006649892, -2.6699781015929385, -1.7604695585343346, -0.8451952384169642, -2.684387159107681, -2.8898780817125154, 2.2334291052963025, 0.030465383483816184, 0.7323906979999687, -2.2732529573097855, -3.1418414911457875, -1.8670301380144214, 0.5372006512508131, -0.7765495891337284, -1.4314502578244044, -1.0438908846794235, 1.8823827373985886, -1.5377696170070922, -1.6636718734880922, -1.1799355715792061, -2.1250842776845436, -2.5994944724497193, 1.8444387458602531, -2.813443745992568, -3.7703857952035014},
    {0.5520170707685905, -0.6731495892638589, 0.3297776286665105, -1.172569155442363, -1.2616381167106279, 0.6104940054503974, -0.5701835784564588, -2.2205333940513534, -1.0942868446575922, -1.1423152424340381, -0.45588365372904455, -1.3032616405285264, -0.3918231077830496, 0.5282376579736564, -0.306590431005436, -0.137304235725955, -0.6360323406000644, -0.8562387802972883, 0.1795594714177334, 1.0543016366115125, -0.5846256198986761, -0.9618919902372803, -2.1634821701175286, 0.47097653448597987, 0.5454692161738011, -0.8053460440738195, -0.8962365751852971, -0.3257470793581302, -1.5792156188161868, 2.15189691113289, -1.1362912435671528, -1.0568453724084048},
    {0.3650649949430901, 0.30396526567953613, 0.3752236499880196, -0.7274249177802272, -0.15982712791975956, -1.1215078358325479, -1.2631078368471627, -0.9669708195536374, -1.2710178644251107, -0.8656170734022136, -0.2349691300600888, -0.4186947356257535, -0.6884854550185731, -1.3121936263321894, -0.6815344777572946, -0.8478201799012347, 0.12297633047310524, -1.282803202851573, -1.2768023007163611, -0.8015048441254624, -2.4761823372698553, -0.6757682445826175, 0.042302042593900774, -0.5976655485300072, 1.3897195474955577, 0.364817668638206, -0.4790245941516875, -0.7110314170786421, -0.4992788458492354, 1.136599071548957, 0.7827642764184689, 0.06561669968296979},
    {1.3079579225353906, -0.5156054456135966, -0.2797416168503096, -0.5558230182269143, -0.8263935009698739, 1.1138541811552143, -0.6998252020990694, -0.8075302384307576, 0.42951182149457595, -0.8244008925774873, -0.6413111783050551, 0.0041390411402364175, 0.2366468112873593, -1.0053361409132564, -0.11001940908132453, -0.21045723337125977, 0.5801770166798147, -0.28210892003405713, -0.5540009635134407, -0.5396606668212983, -0.5241594307953817, -0.032123389317123364, -1.838294823958557, -0.398947310579074, 2.5960736818450214, 0.2865314549522464, 0.11143935312771691, -0.3566013401325841, -0.18701911906074198, 0.07895346305920947, -0.5931645117010508, 0.07278662359923156},
    {1.2720176140797397, 1.0382814299167367, -0.35001353270931657, -1.0890323751496396, -1.8609302464684008, -1.2626522042341772, -1.6248715479833822, -0.8848802028569166, -1.2822971031394002, -1.0593516277407413, -1.4659574983868933, -2.035035596707431, -1.037729248326658, 1.078113329820839, 0.23407313974403338, -0.007359921206287973, -1.1106592069379853, -1.3220764223240322, -1.2436015245113883, -0.259763073552463, 0.03241584456954023, -0.8211198454512928, -1.3945006333553183, -0.12920398304366376, 0.19659644303977292, -2.2566168746343567, 0.11985749562190091, -1.577502387582398, -1.655161994755488, 1.8179713476901944, -1.600091544945597, -1.6102854370895285},
    {-0.6043095676821676, -1.2486529077269712, -0.6559301885988712, -0.11927572066971652, -1.8577669988845933, 0.08806744068079582, -1.1105231775145337, -0.9275000896271766, -1.2875881947125523, -0.48972129504651973, -0.37483600565158637, -1.7130029261788906, -0.2754679130399125, -0.12505718266910387, -1.471226796828031, 0.07087737444574162, -0.9457488080660489, -0.27606814558247605, -1.2968156507824473, -1.178707612323466, -1.3777374589686047, -0.49881881229970343, -0.4415172714822031, -0.5240862227550028, -0.7815997797791265, -0.7820755637870667, -1.6355912284946976, -1.1372206724476717, -0.8585079521411814, -0.7100612767171584, -1.9547578823868461, -0.6221793998670612},
    {0.04096003994601074, 0.04745952332548302, 0.2471167056388422, -1.4729427437034703, -0.7004756307357513, 0.18587087577473332, -0.05224320818093541, -1.5883025766486059, -0.827448223565589, -0.035921809097206193, -0.31857224299217557, -0.008745328007026387, -0.47033420331869646, -0.5638857501984074, -1.0863962770846198, -0.9988329068208717, -0.826357589348729, -1.004821960974668, 0.026779101594156234, 0.39970872563088083, -1.0078174640802964, -1.4713537712479405, -1.2551726678557638, 0.6818803327066376, 0.24803592896522098, -0.08948040476471779, 0.16605170558993787, -0.07216998913924458, 0.30780666579126165, 0.2578209339932676, 1.1685865104583926, -0.4282211759159944},
    {1.2089499879662247, 0.518930832191812, -1.3366317014125053, -2.160017404653503, -1.7439129646009814, -1.0465019309724914, -1.3285988724184445, -1.7729486476801728, -2.4179658411760743, -2.3312844805599884, -1.2948800269255942, -2.4301499588836024, -1.7095118654505137, 1.6348851074320925, -0.5130081772254299, -0.6815304275032015, -1.5709793396633647, -1.4901367171768152, -0.6404498632715574, 0.6995595790530436, -0.9458970655195439, -1.6074108556909887, -3.154327867324701, 0.21491205364007593, 0.6069162440415806, -1.5504878308204408, -1.0448587403909646, -0.961927596532782, -0.9094646679620283, 3.129263497980118, -0.5768768789251679, -2.079056602780354},
    {0.8164792956478202, -1.0355022822592501, -2.2571777409931633, -1.3063699021141295, -2.864424857837971, -1.638476847791629, -1.4009665517462413, -0.6291955923498782, -1.7498593147092527, -1.6657607135013854, -1.631655001057521, -1.365624440404906, -1.0771826413590062, -0.2831889631422557, -0.9102276903668368, -1.0536429322743197, -2.3227742939621505, -0.6915505730082642, -1.3939514763558998, -1.5451813718608256, -2.5002716161540315, -1.505732532045559, -2.681600239589248, -0.9001302898165917, -0.6198812600959832, -0.14639456398600667, -0.9988697302622013, -2.364493180412486, -2.0438023772290954, 0.1967771275943588, -0.9283706486778932, -1.6087306513213202},
    {0.8656134052476074, -0.3537134615520128, -0.08126713242663622, -0.8182539724735474, -0.8545076677211297, 0.3380016214854663, -1.4291860345423395, -1.944034459840745, -0.8941220835478731, -0.020211455580499818, -0.5262689896237145, -0.9905119140886318, -0.5793934300470448, -0.6577232841211926, -2.032571978520193, -1.0506603317438128, -0.6832142096092365, -0.8499201856234955, -0.18874968135147338, -0.9240195671044776, -1.4635394363225045, -0.4195402363797914, -1.4820512483689436, 0.19134691961848505, 0.9561974678324702, 0.06205361348478068, 0.23509988078263383, -1.1174007782344597, -0.3966286486306886, -0.18886088930724518, 0.26463169519343327, -0.9566337435579372},
    {0.00039680704800920815, -1.3466810432940748, -0.19737197320298122, -1.9607736871984, -0.3381618505958199, -1.185237539292099, -1.5751283762540138, -2.8535649007358916, -1.5476599109999254, -0.831289771904106, -0.9061419279642566, -0.9250503521150882, -0.11932943873471179, -0.39351276288925324, -0.15819743392606586, -0.8465882983426987, -1.0225775635296623, -0.6297884956295853, -0.23651199510914814, -0.614003295415958, -2.234509161363305, -0.40026126888325847, -0.9236437405701742, 0.5652335529894328, 0.6329489120338818, 0.9882599598259199, 0.2949298614718832, -1.2067389998518296, -0.5800340102911034, 0.48444088921416883, -0.6511665947163554, -1.1769227615880034},
    {0.007836397294733576, -0.27509721185749564, -0.536439158240174, -0.779210530488414, -1.595579787552974, -0.8034109609213873, -1.589196307723927, -1.650195826995359, -0.5327619037883282, -0.6988863830485113, -1.8865429332186403, 0.7406680918201116, -1.4520901801582358, -1.4972759572435128, -1.652678814920315, -1.670075526234443, -0.7163820587269615, -1.6025367926685647, -0.9984151278197164, -1.9401928363469838, -2.1406896041602708, -1.6638904849287959, 0.10994962478564181, -1.6640998060624406, 0.9989533524651061, -1.630277232653128, -0.0793979055224889, -2.0670107120551346, -1.2375974169515822, 1.130797213860087, 0.5501993753993226, -1.057801941391949},
    {1.0114669482912655, 0.06841508501224647, -0.21095172165022907, -1.3137377545155084, -0.6312852443831459, -0.9458121985402275, -1.617329473028785, -1.9980106532076858, -0.31115896839670887, 0.06300859138240798, 0.37888698585218733, 0.45727019375219635, -0.2616631622005743, -0.6794170320278954, -1.014657619780732, -1.8035392199031668, -0.6445276603880301, -0.9346488944246992, -0.8055962025418758, -0.7993425066466967, -1.045797280911024, -0.5174932574451101, 0.45238737280978164, -0.5495426216547715, 2.309260104999841, -0.6569414886687724, 1.655681472322198, -1.3526125795829826, -0.44342487106339984, 0.5070193137180508, -0.2910129925977992, -1.105997544037671},
    {1.5022604844185994, 0.7804893350465316, -0.2332672957141499, -0.37242221249865853, 0.14751287205236543, 1.044277776260687, -0.6248983975631653, -1.7756165669574218, 0.2931594095657602, -0.7920698549286488, -0.6993967190173751, -0.11008135749240967, -0.276972273316249, 0.12919061930784087, 1.4591472643125738, -0.6336256769781785, 1.1945781879416366, -0.6127589728162054, 0.08360018057562006, 0.3621658080687867, -0.562670511903627, 0.012651024983020086, -1.2165258280899438, -0.2598318831444062, 2.574878053713689, -1.541709061908085, 1.5990398532596377, -0.4609834895917731, -0.440031418009151, 2.075054516636426, 0.9236248110884624, 0.8010885153055751},
    {0.48830483769719357, -0.5839947474041735, -0.06130824524409964, 0.5281801696989861, -0.14019889657990955, -0.5742831279908616, -1.0983959355237363, 0.12276020298833341, -0.3208834199923155, 0.745731006917037, -0.015367955902317149, -0.6156586722810651, 0.18781947242653182, 0.004461751004851313, 0.5077305514259718, -0.2905252898866845, -0.06125631316882447, 0.4063582166463056, 0.3262697143351167, -0.3675567344580996, -1.1238967370073911, -0.5876566246354201, -1.6814883639634544, 0.21229463495023862, 1.47852631492918, 0.6001436465428561, 0.8613356232626663, 0.24108785695118934, -0.7689572767538956, -1.142852443373339, -0.31762765067183496, 0.28765780565846427},
    {0.4397651702787411, -0.8978457815091074, 0.026150866934284027, -0.508060648148872, -0.07455903085400818, 0.10458131517251139, -1.88000849087936, -1.073135905703011, -0.6410571786896077, 0.9782774860190737, -0.3280133245967238, -0.2129632390400011, -0.4790279599912672, -0.11311367637381078, 0.891035286791667, -0.46094496680061814, 0.4027105743498462, -0.2021178264763789, 0.2725877081627025, -0.7858689454583692, -0.813064319787275, -1.200286783017526, -0.31147448598652433, 1.3747110792663058, -0.33692799579666355, 0.11658890389725561, 1.093313522014851, -0.9666453065424343, 0.5213407752451967, 0.05697051871903104, 1.3865757777987977, -0.4879019735242828},
    {0.6475863769999622, -0.004480947040381338, -0.64070038929297, -0.6261891662510136, -1.308538727517473, -1.9487131125172374, -0.48139221362319395, -0.38495400566087035, -0.7494717029205332, 0.1244800236771572, -1.3304659750178367, 0.2310758387535162, -1.7144949743603937, -0.2386290188755728, -0.522565519747348, -0.768869462953262, 0.23751690646865606, -0.9642826843138177, -0.5707599874050182, -0.9565752206554397, -0.10343950670458356, -2.0469209724942563, -0.38542862752330403, 0.21289222840339062, -0.354277317257451, 0.40593246140688066, -0.07792513627218021, -0.8336276523763709, -0.7579063978854071, 0.42798598432255325, -0.4420277726798148, -0.772554369674828},
    {0.5895514085955645, 0.8616094293753046, -1.5524452510248978, -0.4114223191716921, -1.161784091423264, -0.8958726716831068, -1.3414249446877926, 0.9232425231374697, -1.1579063524669801, -1.906091577599667, -0.9213176442308603, -0.4640332981725095, -1.3292832526735938, -0.4221372539902904, 0.9078475864857818, -1.1024695325412186, -0.3010597048369664, -1.1488096153690286, 0.4816367162695246, -0.2991034826470061, -0.3828449017714198, -1.805064541790705, -2.468662978279452, 0.9268527018070135, 0.6382002446271199, -0.3981268360391317, -0.7693043272089082, -0.7932687818438023, -0.24496147718930952, 0.8841908916113771, -0.20519167619226794, -0.6519418146953548},
    {0.7711035795065765, -0.7969674712914016, 0.3725413805648477, 0.16880320498199594, -0.9716744382250428, -0.2580920283926445, -2.036596817357999, -0.962636507143468, -1.2659365576911659, -1.2997678287041596, -0.9130539638921242, -0.1560276431739176, -1.0526745154290738, 0.02521449066989531, -2.0505600436619362, -0.22645546051785811, -0.4190311863552914, -0.32260717525688826, -2.832844026925411, -1.058217020995641, -1.3909168645890617, -2.481114008127718, -1.0320965975566991, -0.46450973409489793, 0.5183947322350378, 1.0570387739527762, -0.34436560714712794, -2.228923020335334, -0.6886387167334852, 0.4902367819163982, 0.3820243763645152, -1.104162101226996},
    {1.0982548184276404, 0.4182508678470984, -1.0280441475977409, -0.6867839490417879, -0.05890621797327209, -0.5015312198199845, 0.511073540622375, 0.09859161524003018, -1.518260258530333, 0.5918336334608305, 1.0374874000385834, -0.9020422914555445, -0.5843219089143588, -0.4381530951181589, -0.1533492351698102, 0.21503296917902906, -0.819045817570963, -0.2420485897286133, -0.32191234475387864, -0.8317190149423946, -0.5618224684510373, -0.062360113234245715, 0.8513116237821928, 0.4784520601408305, 2.0658643950088953, 0.2414961250828285, 0.03342142011192457, -0.30264096614626984, -1.0646546053073864, 0.9309076865289798, -0.6490178459712105, -0.15762309337230757},
    {0.5893068001731113, 0.9232212159367068, -0.8810037370461844, -0.13035089931847577, -0.3340778225279562, -0.9139888328149735, 0.7860497046615997, 1.336213903560092, -0.9176063617289502, -0.07716180320038521, 0.9249097995202606, -0.12905753603240144, -1.0992678195193366, 1.3690181153359777, 0.11587625016478162, 0.20207237949419882, 0.019383719493212107, -1.4379618131341136, -0.7169580811007443, 0.5625653411411671, -0.1943958101331423, -0.7231741303987577, -0.45654854443466175, 0.735710724710738, -0.2916950978088166, -0.03260666033700083, -0.40526087933709537, -0.551129756880592, 0.29762643260458355, 1.7326167012903895, -0.18676541812233075, -1.5079470050136268},
    {1.0865055053388675, 1.3653943567597466, -0.18150685443004197, 0.8770202982795289, -0.5571060540543483, 0.6456966438822752, -0.0294051265772724, 0.7299095522236551, -1.2349656655072432, -1.0797810458439554, -0.6540929057370816, -1.8663118914420458, -0.28994094843200463, 0.6043759804792722, 0.6002255073258623, 0.6043054911918079, -1.6263740010940348, -1.5811566524706695, -1.3519020064108191, 1.287072541433403, -0.17258094980492986, 0.9683530582621653, -2.2736795247594883, 0.6043252866282011, 0.12149467954661924, -1.8908892196998277, -0.023332474780033505, -0.1291104661720588, -0.7296373228949042, 1.2340831517385034, -0.9415236880935167, -1.5691401510170522}
};

static const float b1[32] = {8.820348031305034, 8.716910840288437, 7.906246870782604, 8.058486348780644, 7.958335591155316, 7.851107704265888, 8.195055549902127, 8.4086010644196, 7.91422971093096, 8.002472210247797, 8.054286782710214, 7.997471796507244, 7.765051861240886, 8.376434660752903, 8.088814025911786, 7.917521079133503, 7.887242181139923, 7.843199030429735, 7.887056004446085, 8.158698194364204, 8.080782842077777, 8.166359044166711, 8.04461930089247, 8.247806470654469, 8.281056727191487, 8.053811906009845, 8.165739511074003, 8.08916138202822, 7.793667734957025, 8.82969556094079, 8.05915070293585, 7.838730334143912};

static const float w2[32][16] = {
    {8.160166677193953, 7.879803931495523, 7.800850049886904, 7.8306722364695425, 8.452671254841942, 6.747487647517996, 7.816099342310956, 7.980087667150675, 7.933228628953214, 7.715947146345427, 7.144251491196412, 7.887768609999691, 8.18925621928405, 7.703195192413108, 7.764406728568477, 7.746145723570979},
    {7.971031498077807, 8.252276039005286, 7.986262220111592, 7.891353869507179, 7.984429141485336, 6.812397991975509, 8.314328843361498, 8.294587034680472, 8.169754402980706, 7.7470016747142445, 7.314873790740353, 8.276134934002709, 8.116200809033755, 8.38055861429658, 7.589372672568216, 8.028012411826241},
    {6.707279168078448, 6.539897606553915, 7.069390826026186, 6.928617552458092, 7.0608849254000425, 6.205965327328527, 6.502856607140355, 7.053591650726979, 6.957414258203079, 6.953296530527026, 6.414474659607704, 6.9529102816575, 6.836511091892956, 6.902365684004285, 6.697720087428404, 6.572780426980049},
    {6.744637165999395, 6.851325762428272, 6.7432702725129765, 6.6498109612637615, 6.769956466745964, 5.955835991812032, 6.560638293331514, 6.253131844742365, 6.067326777202497, 6.9061244267479935, 6.307469986229895, 6.634359793182526, 6.964637155779305, 6.783271052408936, 6.0172819667424156, 6.887792951250741},
    {6.593918092073423, 6.833252638575514, 6.848855491823703, 6.374429331102422, 6.8162480978591224, 5.615568142041199, 6.583764841683551, 7.0195498914093415, 6.354981958250167, 7.1175653914002, 6.018039417732035, 6.394070336574929, 6.917113152555683, 7.174239890739217, 6.81497870954073, 6.6240405207799435},
    {6.285496267877873, 7.025365915270203, 6.2882475740623125, 6.645521382982055, 7.154805026000916, 5.576563785622772, 6.566778653015932, 7.054604441648526, 6.408099808562104, 6.944594300645074, 6.103168266163815, 6.664021344251602, 6.585832734890995, 6.884884317333946, 6.834864899571, 7.161082798588083},
    {6.48116241286532, 6.8443883185493375, 6.6831196036738305, 6.790077571027936, 7.098041731666755, 6.125929144554721, 6.961221387658738, 7.180418641329399, 6.610181760040624, 6.997724462860809, 6.4536855515634395, 6.8577377410234055, 6.954337997302867, 6.601559551783251, 6.976832829954646, 6.933257086122528},
    {7.039079180596629, 7.363350632162363, 7.161141963980837, 7.559088896249202, 7.396016808860409, 6.025401562553704, 7.486046259142828, 7.524559196664491, 7.69875867631132, 7.421771559447394, 6.723738535060788, 6.900904429709616, 7.794350300318001, 7.3618056370211065, 6.577991793633028, 7.194782333785737},
    {6.929249674004608, 6.521537035562511, 7.351567913881687, 7.317832030806682, 6.699695979753972, 5.8754651185451845, 6.484095142393635, 6.983634192438336, 6.975159993067215, 7.067477762869897, 6.487038990296873, 7.2873361658941285, 6.899917537866442, 6.905799124466405, 6.449684323172262, 7.104350162381064},
    {6.616743049156581, 6.779030859897189, 6.756141589760126, 7.249076346817923, 7.245170086776107, 6.238837247523727, 6.8220230464144, 7.121140119445813, 7.13910877473647, 6.6124504764049385, 6.2709926676434256, 6.732062013229843, 7.245807927430881, 6.428404428124257, 6.038907815743955, 6.6706198056080455},
    {7.2807741369904635, 7.304215204721358, 6.997760233206305, 6.855735804625663, 6.94840390941763, 6.596353947724903, 6.484872245798192, 6.707058363048351, 6.877850912777743, 7.378759944215755, 6.313021147904548, 7.557404117111959, 6.900139437869275, 6.886411403037688, 6.976772109302574, 7.331802933609842},
    {6.77393297272687, 6.987693847452331, 6.826545477099103, 7.085861772107876, 6.841593215766467, 5.771184393814932, 7.255547239394458, 6.498952525749398, 6.4496050400979215, 6.690313838749914, 6.369853727385954, 7.017718971328818, 6.87349614461022, 7.163216279628816, 6.242676193212617, 6.7514220790164465},
    {6.5223301520864405, 6.3248095966761975, 7.03459228797634, 7.0034169262160475, 6.558892360363891, 5.2947735268833025, 6.705210294285954, 7.216450081861999, 6.707847050084128, 6.670565620919794, 6.058766325762406, 6.204076092030104, 7.030966519821197, 6.778400858824584, 6.02905677623912, 6.655934604727024},
    {7.844114769488159, 7.910955590297329, 8.059681270659828, 8.045346740819598, 7.995832079332892, 7.211485947283607, 8.355515164008509, 7.787450024372018, 8.210043783273656, 7.516695455200155, 7.012408533032742, 8.100279574911754, 7.750747099604166, 7.965479710944253, 7.395203863074395, 7.708938209703918},
    {7.447362449763686, 7.391504936411608, 7.334590093171904, 7.348599441558803, 7.349883012234446, 6.195040325444479, 7.356661401691984, 6.959298798840328, 7.221830635182869, 7.014413835060591, 6.995250615620644, 7.415907257585747, 7.317490605438478, 7.310435064955278, 6.955811115211242, 7.1232064024430475},
    {6.613214303261628, 6.980785511799991, 7.190823060579098, 6.951830772687389, 7.3700642656661985, 5.445739180552298, 6.890694526426539, 7.071736044124262, 7.093530955995478, 6.836266292717023, 6.094323965335675, 6.55726966151183, 7.134100122905837, 7.557972503500642, 7.064954793512726, 7.325543731344616},
    {6.456289678043932, 6.698056464261007, 6.934474967346933, 6.6473297650241365, 7.238028708980261, 6.105691334279454, 6.984698736614283, 7.482800987177963, 6.607257024766142, 6.791179919481852, 6.536798047122435, 6.721920347597071, 6.695308227620906, 6.637553058778759, 5.937904893541902, 6.810247415027165},
    {6.336037927295922, 6.680565234892363, 6.782353698840198, 6.28199892412474, 6.668474223118495, 5.559470128884905, 6.699869905199343, 6.859592946318857, 6.27256589910022, 6.976367259806722, 5.778697813920855, 6.825853267070596, 7.292902402749432, 6.351782896838765, 6.321756324498008, 7.007243976416515},
    {6.677302224662193, 7.042941401662697, 7.0263723001877025, 7.4911168099436845, 7.489065237265675, 5.954251554571939, 7.047514316409107, 7.016637998088379, 7.039649184598255, 7.1482694834584946, 6.284852345371935, 6.687427683514417, 6.996967734138605, 7.186793176084972, 6.448631525916823, 7.570044168425431},
    {7.083235883610937, 6.720368074470985, 7.496880429074687, 7.234593515477767, 7.511340752895218, 6.222354347099404, 7.400112621826371, 7.102152977362268, 6.563728030191868, 7.465442906165421, 6.827185055611569, 6.958460847644814, 7.275941311082264, 7.260601371377169, 6.764797640093269, 7.1966073486134405},
    {6.8086350860307325, 6.870189814365027, 6.7979413215450695, 7.058505010282581, 7.155658725820194, 5.730887511773733, 7.181702940572728, 7.099282538043228, 7.121039702764614, 7.003596974034236, 6.382877223512139, 7.366632343943237, 6.687372924912255, 7.0155286316502385, 6.370546830281732, 6.851038808632552},
    {6.870110524910517, 6.931256962033911, 6.6737136260342425, 6.8537866734175115, 7.057142104582928, 6.157824728727506, 6.806048874300167, 6.444736692264613, 6.936774401474152, 6.973426532288041, 6.513564300401077, 7.071395461720361, 6.984700483162833, 6.985662600644415, 6.514714853641562, 6.730350209450444},
    {7.203320777254024, 7.073640253987481, 7.032165455702148, 7.178023741172775, 7.213517107150042, 5.684691348164316, 7.015265128077524, 6.58027235041321, 6.598159915956175, 6.6658256964123455, 6.492229281152791, 6.805797935308475, 7.1756427600911525, 6.750330015186702, 6.718515626230513, 6.572891305785146},
    {7.5472500016369555, 7.628566257783828, 7.2246719618208655, 7.283691562648458, 7.836552613822749, 5.708920405510735, 7.435669200539851, 7.869642457512736, 7.37050184518268, 6.892202512987967, 7.181804470835821, 7.862918417783628, 7.448963743906916, 7.474962378198884, 7.103452046480873, 7.102560211416003},
    {6.826658264241778, 7.392411310716231, 7.541302354432053, 7.0882849101439165, 7.3374793882189016, 6.318228259150832, 7.117652261227615, 7.648384264234084, 7.159401198691255, 7.011092730205612, 7.17170155269338, 7.2946371626017905, 7.290202609467046, 6.973424993309101, 6.966120163981053, 7.57386428669993},
    {6.7635249571060525, 6.915136224555969, 6.778967066832076, 6.8179329045701085, 7.102150692391991, 5.775638495957547, 6.949983289094171, 6.664202547296841, 6.617653156584084, 6.8243204150446815, 6.781408770651875, 6.45456116624485, 6.7920400732188515, 6.839381250071128, 6.620762702750756, 7.132907819827232},
    {6.651008309263665, 7.178621875450445, 7.222613447641513, 7.304449591531065, 7.010412408890019, 6.166100302522996, 6.92205227228247, 7.147398010042451, 6.429280930784097, 6.938986031173684, 6.208340389411398, 7.280000933866708, 6.939500220657102, 7.0318101652376015, 6.949963043531318, 7.238900108314048},
    {6.817456804613162, 6.565503711133112, 6.401334584900935, 7.1649443313619585, 6.736243832824907, 5.5376524256219986, 6.550347043347415, 6.7672278564906865, 6.33689677288288, 6.93816462388692, 5.939769316044757, 6.745960517197457, 6.806374220562729, 7.494881390180828, 6.609509879770176, 7.150070910765567},
    {6.632333176827537, 6.076794252229195, 6.357548055396323, 6.656493181023455, 6.716380767598665, 5.403735575567016, 6.3854177150952, 7.010315559585354, 6.467736822603036, 6.603271990161297, 6.071737747839637, 6.690216566377794, 6.9137918567185945, 6.698894429655331, 6.609225158681407, 6.944425989427666},
    {8.417743141211353, 8.442201467504626, 7.904942162654279, 8.44611365635525, 8.277609491576802, 6.641742824506656, 7.918177887839479, 8.050878439394907, 8.158977947612295, 7.969282147087566, 7.507300519347661, 7.932880692932209, 8.31614027431803, 8.278026168817696, 7.4879129991173325, 8.340793150609606},
    {6.618633380146879, 6.4089419004389265, 6.506697137354939, 6.601453555628568, 6.798058734685319, 5.885587879323405, 6.610776514296562, 6.750389747313106, 6.384504024237363, 7.09646381444087, 5.854568573804494, 6.800781444861923, 6.729653987612228, 6.660367114036763, 5.691705995841355, 6.0495589228847075},
    {6.545258022619738, 6.6434447835500325, 6.77583738877834, 7.04379766726746, 6.6457557194818415, 6.006279883868908, 6.514783777146154, 6.994066249294346, 6.40176251266635, 7.041113777991002, 6.027784412410075, 6.519361945449589, 6.578535773688255, 6.830727846092896, 6.343926097581283, 6.5411099653203575}
};

static const float b2[16] = {7.159971011805939, 7.149494896635315, 7.114797459262603, 7.321885849003361, 7.241770863574429, 7.0635113103234, 7.148509737349663, 7.21294645888702, 7.153579179432702, 7.0667487928024775, 7.137165339762565, 7.216944539316476, 7.175943978544123, 7.222717155351462, 7.315308821745395, 7.261047180630044};

static const float w3[16][12] = {
    {-4.647355197776681, -4.568720051853273, -5.277388489942407, -4.875929095033165, -5.135153869859306, -5.027476602716597, -4.416493299913361, -4.328988306994004, -4.056999155860985, -4.22774660384342, -4.7458906301466515, -4.84022460357059},
    {-4.764565772945678, -5.464780533646114, -4.419345385579861, -4.897661562818753, -4.683942432176416, -5.441113844204904, -5.209671577086003, -5.0865668820227805, -4.181050373747877, -4.639637754852231, -3.871187909781949, -4.707137467100266},
    {-4.746479592756593, -4.233178479498269, -5.043713048584039, -4.802775578353435, -4.584882101818303, -5.343488524974081, -4.694594482397182, -4.380156193717393, -5.128739406336916, -4.90052860090474, -5.304233698882743, -4.189445886157858},
    {-5.043728609594719, -5.1345813561757225, -4.817319288434445, -4.408222905071175, -4.035154593682681, -4.992117158472315, -4.763271954410325, -4.536750760571585, -4.699580412666422, -5.117773686435969, -4.974733797859172, -4.551219837093945},
    {-4.707011381610821, -4.330718136235093, -4.916878180139821, -4.874920334224381, -4.674935644993501, -4.561185702565428, -4.927371049261829, -5.332876064351579, -4.191431186613695, -4.713164503849188, -5.315572630869876, -4.894856214014563},
    {-4.060037844945564, -4.003599936005612, -4.152483675650421, -3.856293175322021, -4.478091927386971, -4.061810553997155, -3.560436901261632, -3.565575079231998, -4.394726354519989, -3.6195812167286205, -3.870769702467728, -3.4561235449077117},
    {-4.9694978166457755, -4.440914324721983, -4.410901254451126, -5.26785455999087, -4.76312076661406, -4.320426051309447, -5.273427944974147, -4.871840380073338, -5.25272984342046, -4.410045545937632, -4.572698248218982, -5.869469129271083},
    {-4.70090659146243, -5.046687852571274, -4.035129395765601, -4.694228981462993, -5.063272132321965, -4.575536915162216, -4.737901869561122, -4.781601187305086, -4.696933230085881, -5.27345640429882, -4.303957317240977, -5.1328454739382785},
    {-5.557986476157335, -4.8619613871125305, -4.226898598447529, -5.296444535616003, -5.672338903717283, -4.833676743243069, -4.331235421939858, -4.654265527633026, -4.582930982336584, -4.3675356478237335, -5.564663490134876, -4.620234922255085},
    {-4.719825114260379, -4.805632840530067, -5.087535757495674, -4.766467645132745, -4.558242800142661, -4.680098344876971, -5.060017047804758, -4.461100488639361, -4.404347973694323, -4.665067937818879, -5.082598574406992, -4.7620763730504345},
    {-4.557178595115331, -4.274764316610875, -5.0707993805388965, -4.210633507977578, -4.460216083969145, -4.359853778303489, -4.4256664398712795, -4.146714916430443, -5.085613955335593, -4.228973665802037, -3.6791372463100265, -3.9307694453040996},
    {-4.396784126494874, -5.48414390973792, -4.8437295127465365, -4.803796742669097, -3.9940682553040516, -4.252417029842645, -4.913371535128223, -4.673329975852665, -4.945814187124411, -4.617986895370218, -4.799201953155818, -4.747245306255123},
    {-4.910858403418107, -4.943429062822274, -4.820749703156938, -4.030021200142587, -4.898055140861337, -4.313195311342449, -4.898682956425668, -5.136466704610349, -4.53125698315038, -5.429359098958049, -5.234946923178115, -4.93831273473482},
    {-4.411290169437335, -4.430064628968519, -4.631920452840591, -5.242568361391433, -4.696664981370212, -4.303714503743344, -4.572394098466866, -5.102768415591434, -5.280085738754477, -5.326125348939466, -4.633307099968457, -5.064919253605421},
    {-3.8962089933471433, -4.489635789149264, -3.9555069856621823, -4.799711308804588, -4.977100755905435, -4.910262113404937, -4.500370230179715, -4.684256553591534, -5.067528915314527, -4.708022548177417, -4.4414123568639905, -4.599435101743627},
    {-5.201857427824907, -4.68840913703704, -5.59026672843832, -4.447256019103295, -4.682979231377872, -5.29916407053724, -4.844682186269523, -5.41492541031403, -4.8607494825594655, -4.915288012958509, -4.780756395081231, -4.779102882662725}
};

static const float b3[12] = {-3.7135544355601975, -2.0487350058197866, -2.502016075432329, -3.363719615533214, -3.096756457665044, -3.044344453741335, -3.1248048223904497, -3.608760275735647, -2.3899242865214907, -3.2225952122952823, -1.0321307079369257, -3.273151599423875};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
