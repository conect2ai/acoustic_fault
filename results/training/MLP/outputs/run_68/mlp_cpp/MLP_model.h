#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.8274355696289313, -4.652770109300234, -2.5870920861338815, 1.1468563951562665, -0.5907141371348029, -1.0678590952701372, 0.00884496395588396, -3.690867132841565, -0.667337937524747, -0.7761420158447789, 1.4694984976642478, -0.11888467731285038, -2.4113343432937544, -0.005252450324445502, 1.5187855181253422, 1.338370518242501},
    {-0.10260207573281442, 3.002670157962533, 2.5055667053607618, 1.3082091203736574, -2.136213374094479, -1.1283783147805118, 0.25435472321049335, 4.356923273260394, -3.6808851088697736, 0.8033899070917246, -3.198042834465419, -1.9751005742690837, -1.239127211506659, -1.1408549281749436, -0.6556813238989466, -3.6289727260616575},
    {0.4550649933143755, 2.082259867656161, -0.5724197870377878, 0.2263337301661897, 1.0595433261310658, 2.2583403059500324, -0.9176678219787202, -2.4630269504590006, -0.9271766380525933, 1.352611976295272, 0.32313756168889907, 0.3578338805228009, 0.7783334165667073, -0.644109114046161, 0.43295555373326067, -2.0987476676902146},
    {2.0540372328495735, -1.2161036109811247, 0.5322339029889166, -1.9596534582986853, 1.6210800171104893, 0.5623928192301222, -0.6483206822835612, -2.924001203241087, 2.779049955977286, 2.9266284271358454, 0.8977247182169693, 1.1745355311627879, 4.282052253025373, -0.3329281486211882, -1.7094197017381207, 0.4233209125935925},
    {3.5773643506334314, 1.6226491654022377, 1.994360854427184, 0.4711038708561022, 3.5674418676780446, 2.101029448160135, 0.929207913042325, 0.12216017896884475, 2.3316607407814005, 1.5551392588490038, 1.4205604790724833, 0.3382177619778584, 4.571043690575755, 2.909030426848213, -0.6259794980675093, 1.775511745935048},
    {1.9914694454872746, 3.5424445073138386, 2.8398390328546803, 1.2687736816191244, 2.5663574696734326, 4.081950074481057, 2.0272925515400475, 3.016790598254736, 1.9637314569153406, 3.3577531090127497, 4.682453115390377, 1.4278059952870552, 5.972066529075547, 2.509939111672563, 0.32263113253054104, 3.7584392648819183},
    {0.16889693844050582, 2.697267640465293, 2.8347913386218253, 0.6204312981790359, 0.09922681046500151, 4.2070249449252834, 1.8916542662194122, 0.13097445895384446, 1.8576218605843478, 2.710060976182624, 3.955678366017552, 0.858844191015805, 4.018139028106451, 0.043108920252521256, -0.5772241464452236, 1.6029188884748031},
    {1.2092249891882332, 0.9218173663858016, 0.27806486069395975, -0.1024522832408558, -1.683298151243279, 1.470524785792209, 1.164809813604244, 0.5488853321570492, 0.4161065018559071, 2.472873519387655, -3.5563689890070513, 0.006996023982090644, 0.8570445871054111, -0.08260085371565055, 0.20286036668581747, -0.3519807786948441},
    {0.7678834051754202, 1.3497495428031716, -1.6893694417190004, 1.2320557523682327, -1.4854282789554494, 1.4093173555991252, -0.11368404263529205, 2.3921170460871264, -2.098081157276249, 1.0787781832063263, -3.7837331249205644, -1.1308691483544648, 0.29423622198950555, 0.2576892322782377, -1.1425374882858907, -1.5398038171646296},
    {-3.135056030481938, 0.006156904111300022, 0.45657663583307334, -0.25908547786374836, -2.9547942425391134, 0.2621498859991155, -0.9782403388304292, 3.032392487687858, -2.3004253941463717, -1.2109137701196149, -2.123096860514504, -1.541612084061116, -1.8260149174680815, -1.3056967154859378, -1.9533941020102932, -1.2565044326563526},
    {-3.2837760484504663, 0.5542031568292891, 0.9899985517153619, -1.1470850065084446, -3.2069714992917975, 1.2957614178690542, 0.002504894141875005, 1.8292276601752104, -0.20082544593004625, -0.37904836465078245, -2.8939246099882574, -2.350635990937772, -1.956142316262439, -2.5971460593342153, -1.5339977693899967, -2.5795232554324254},
    {-2.8401988407351118, -0.17271823510814038, 0.1656110314531679, 1.477745522234908, -2.179985558556786, -0.9053615284029568, -2.403367926811364, 0.3353067452574994, -2.012221471145671, 0.2529992021043235, -1.227291273544393, -2.6005148116057955, -2.0630256719721936, -2.9164998803132147, -0.5142884985115341, -0.19166185481390755},
    {-1.6309564560227467, 1.3417619851336466, 0.013846085024216349, 0.22595649958860686, -3.1121455998500682, -1.1368599043574994, 0.2215262813251196, 3.2549951250100806, -3.7118199415114326, -2.006290472404904, -1.3345591301594928, -0.133731116572336, -2.7357578388571224, -1.518560126424781, 1.8143130994270107, -2.225154296391572},
    {-1.59513372193191, -1.6348373496026645, 0.25129650111231067, -0.9902607297339635, 1.1905772649517232, 0.3990678781414883, -1.3331249184080032, -0.13492820788248355, 0.971721466064928, 2.4710865436690033, 0.3500082999559479, 3.514827283151293, 2.6445118048643588, 1.186387971657533, -0.9223032469253194, 2.916860063635176},
    {-1.5137159438478989, 0.46462714826700513, -0.8441978694783167, -1.4572767671920561, 1.3350551773120045, -0.1484545342260378, -1.0080124001693782, -0.6174974603325399, 0.9613015037066844, 0.9820680397632373, 2.035925022622617, 1.503318406662337, 2.2816316644992725, 0.7441557805402592, 1.8303815668984245, 3.419462896217541},
    {-0.8857414377496992, 1.300936622718593, 0.19080892480313932, 0.8944990440301719, -0.6410381204263634, -1.9678077452422824, -0.5880069096138687, 3.489236177124543, -1.9583818157609876, -0.9206776173985067, -1.72312455489295, 1.2804377054975529, -0.6285027590318525, 0.27593989721178147, 0.930250028304343, -1.2215493582107866},
    {-0.9081733249145133, 1.9571328635296255, -0.21785304933523086, -1.267561540836288, 1.372258091424592, 2.0405401427065284, -0.17603692761510867, 0.6077492048751648, 2.2319684128792785, 3.7346222652446754, 1.5043835538778603, 3.192028345905631, 3.454940874024943, 2.421847067595245, -0.867391875922048, 3.7624861464840538},
    {-0.7860071671186969, 0.5187930488491757, -1.42919192912088, -1.0534604311338909, -0.421279526586188, -0.29619648223730466, -0.8144708734041599, 0.19651259948069136, -0.7636524390098144, 0.3991290312534032, 1.1867899688915262, 1.7794453409766733, 1.437123674833963, 0.41050637101009785, 0.10049030788683133, 1.1311283999917507},
    {0.12886628802761527, -0.7212594121839561, -0.259372818422601, -1.0392810011937579, 0.31640893925316343, 0.5689833338680248, -0.8784683825606867, 0.08749981698862394, -0.10372447051278824, 0.4602546029088644, 1.0113036475392472, 0.8469478152952254, 1.7275057777251175, -0.21843764709158586, 0.8577899540556209, 0.3291074578528867},
    {-1.3673288181576935, 0.7597341526901888, -0.6910345480145244, -0.29701280075256464, -0.11570517899728817, -0.4989520379398863, 0.36825664265374164, -1.1942448040798355, 1.494577111327846, -0.6543395677667868, 1.595203598348993, -0.32239199031432114, 0.7238740605038809, -1.8501794908173101, 0.7582883197446383, 1.3305147992680086},
    {1.1186291760676874, -0.7186915342451575, -0.11791755201903395, -2.8678929143937015, 2.499791781597002, -1.085747323118825, -0.8972395418967467, -1.5435292969179477, 2.2201799352420073, -0.14363418041479853, 2.9516417736303064, 1.4550210823401148, 3.21182849714108, -1.4377113442418876, 0.8186597463496913, 2.31314823989005},
    {-1.393013404173045, -1.213774819665972, 0.3797959917272228, -2.6934377560564324, 0.46526473894235654, 0.2838854619931952, -1.621696923402511, -0.6790391622187116, 1.6999491721987514, -0.7661240175574271, 1.5594589045088658, 1.347932248118705, 1.9782385016188897, 0.08180097105316277, -2.896174931468365, 3.873648874369821},
    {-0.44374884706444867, -1.6382373266593975, -1.067560022662382, -1.3131200943609898, 0.37118499105568514, -1.9908381511727917, -0.6517809885968578, -2.243780219275069, 0.05640163764516527, -1.8306885550368484, 1.0086553186718237, 2.8112758919757583, -0.12808185026621102, 0.39840214144443414, -0.22731453042932814, 2.4406468411496545},
    {1.7350885637329998, -2.0909055845021887, 1.3707717684474965, -1.53659208105156, 0.9959271372658675, -1.1255351171178476, 0.09656832798599581, -0.25188538850559866, 2.4519230751342005, 1.0800457770608063, 2.3705380818254658, 2.512803173139282, -0.146270996161955, 1.3166849078513807, -1.104341818878367, 1.6725590648026318},
    {1.398593513948106, -3.838489178298989, -1.3816890231971815, -1.4271387186827205, 3.078246861628163, 0.7541348940305825, 1.087447720954943, -2.5440893310509693, 3.4947433556932723, 0.44118903779944585, 2.774503630650038, 3.1473576381463086, 1.7630494955517835, 1.2429255807842616, -1.727739245383838, 3.748510194659463},
    {1.1221119328227165, -3.015684297595707, -1.1701934456891216, -1.6665702386466537, 0.8353322368197483, -1.1076861857071758, -0.55434987051421, -2.5445140060527414, 2.017283494345739, -1.0038354692804325, 0.31266264121092263, 1.504624287231013, -0.4668041637023429, -1.0676106695237966, -2.67898941564589, 2.002555070928706},
    {-0.571972584663765, -5.049703297728297, -0.9828703071645369, -3.5117347586084113, -0.5173207061970374, -2.468558596836629, -1.6101506315467062, -3.3772791933436332, 2.458041020294186, -0.5766634450409628, 2.0177233216692456, 1.8341791480686083, -0.7777656915678501, -0.4233783057028346, -2.3086979476039287, 3.115491761109033},
    {1.8187744489576791, -0.368903013236591, -0.7751206076921521, -1.6613000350836558, 2.82302280609744, 1.2583635228370873, 3.0966993033250634, -0.1279596964669381, 1.1809723525223463, -0.029973333277065882, 1.8304462075960952, 2.33645211595683, -0.47719730618234424, 0.3774574704903407, -0.11272318494102046, 2.0748266419315566},
    {-0.0910688217162029, -2.91942918805082, -1.5753130544881275, -2.277195093986781, 0.7147110660822706, 1.1706570603710067, -1.3201103146407656, -3.2816980981101103, 1.956485635584372, 1.3733262373641624, 2.457799490074312, 2.436546311489615, -0.3078991236055297, -0.1524976090527581, -3.4627333714239756, 3.7658602285402116},
    {-0.7483953216846313, -0.8741302024056706, 0.8329639271270609, -0.18737800128821572, 3.0177684974495387, 0.3310006241268147, 1.549317761097154, -2.1910795126854885, 2.3865397428427393, 2.0486216155051693, 0.7574036386618713, 1.810705455697522, 2.036446762306833, 2.3471323272828277, -0.34674884401293693, 2.1440595099962123},
    {-3.7955463770134608, -4.6396867343998, -5.009238295656336, 1.1236861444625434, 1.1724939774809646, -0.7542358044210234, 0.6870437584723367, -5.496438566545219, -0.263175951059363, -2.3122354109076784, 0.34815269699875473, 2.3125499742404765, -3.5416113507747875, 2.2999941746138015, 0.8919880003696949, 2.2275054204861497},
    {-4.970457655175135, -4.235815454098692, -4.133918403209154, 1.9227928086045767, -1.5257942397290045, -1.4256930386593458, 0.5092191264220335, -3.7332334551628064, -0.6400103788805226, -3.3381449731912762, -0.8949358962377517, 0.6136325083021673, -2.3832596131169796, 1.4635518569337946, -0.25319674147113425, 1.2306425604319076},
    {-3.3260779509951037, -1.6502992291227332, -3.851847162098657, 1.103513650919273, 1.889697785521427, 2.077179125765854, 2.2587589956513385, -4.4787168273305635, 0.4478237828652723, -2.0118580157811867, 0.7310287572651887, 1.5373038999428028, -2.729612231749408, 0.8716138733576804, 2.654649502438046, 2.377965479978198},
    {-2.148716994124073, -3.115269219158034, -2.2232381014589375, 2.37817703666522, 0.550785140556524, 1.2751292267687528, 2.47548377354727, -2.679898696176035, -0.7330596455550554, -1.6516625466750883, -0.5135282348391036, 2.1051430357826533, -2.755298489383866, 2.38436225040958, 1.7806171837454128, 1.9856541006765964},
    {-0.8868145200982674, -1.9694484835015902, -2.5595400602619174, 2.1755232967896716, 0.6733584069389476, -0.17288687141261033, 2.8999867736123717, -2.6769837942809915, 0.9638343636699065, -1.5243535876486918, 0.9424417786082088, 1.9703640756999226, -0.8343222348071009, 2.046293623202779, 2.8692934215042873, 1.5338559801525085},
    {0.08858492988902339, -1.548083224379936, -0.3352192266522552, 0.7055685956460511, 0.22372189379764418, 0.18526315517015038, 0.8957508728554494, -1.3459369765140685, -0.3626425453613776, 0.4767118837111075, -0.2856939659956915, 1.4279075146404094, -0.5937515478136073, 0.6667669618907724, 1.3343266008122694, 0.5549636271723847},
    {-3.126636356477942, -1.2454837940040007, -2.686703836591432, 1.4809608351836874, -1.1411927532136859, 2.0829063619965686, 2.5341784303598467, -2.5552414228960916, 0.8422495785046283, 0.6681550596633453, -0.6679472243631966, -0.8823078705546519, -2.6750320090286306, 0.41485784188661334, 2.548276361611358, -0.37160081913317267},
    {1.677925913648063, -0.10516817822176813, 2.0174906478194212, -1.1355708955510335, 1.8552185105765242, 1.061808218074627, 0.06074221702301147, -1.3024738743724869, 0.8955270986150855, 1.5534236127947372, 1.5775897610637122, 2.6921651965458047, 1.1794466398211123, 1.8869596184637807, 0.19196146301058303, 2.615385777401311},
    {1.7786814180364379, 0.2347040548131768, -1.2386385423167259, -1.2584522468496153, 1.4512918446686993, 2.126822034382699, 1.0053051286849473, -1.5980845583690977, 1.116529555616758, 0.691662863020095, 0.37400429175701516, -0.3055351481383058, 0.030530540924873357, 1.6286215332216154, 0.2641188647265163, 2.303938742875519},
    {0.9364477532306972, 0.7679242364122881, -0.19854221263064017, -0.49400625508237406, -1.3200205516969228, -0.20519543702304982, 1.1869667889522013, 0.4187544499332351, 0.5303920989803963, 0.48331436869273237, -0.08282202426135984, -2.068716434405881, -0.41957420641894777, -1.2934305882349968, 1.5111316639185004, -0.31784253577996935},
    {1.0937236202028338, 0.3782561209400219, 0.1695476474547186, -0.010846473700524538, 0.22699855721172016, 1.4162690565006593, -0.04115610461108567, -1.114674654869716, 0.39214466419963645, 0.8967947839034272, 1.180150209970445, -1.3588864680285107, 0.26255728215426666, 0.6524968603009902, 1.3158104983194685, 0.03293272458931414},
    {1.1952252532044625, -0.8647330246063514, -1.3067158512239014, -1.434617883432333, 1.4502869180474303, 0.7593477830018295, 0.8295663245115931, -0.6623011893546145, 0.3847153057968709, 0.32202920796721274, 1.2991088447064127, 1.05484411947351, -1.383368798917475, 0.3387206435017607, 0.47425235242171354, 1.3455728097094146},
    {0.24322746118024308, -0.46148755797831303, 1.5450645528831368, 1.691253336245859, 2.2006848220194257, 0.34384528773137935, 0.3954004008946043, 0.8994425432738171, 0.9663375881289625, 1.3430718735442666, 1.6123725708201255, 1.8148732779984154, 2.3586660146990512, 0.9067429903382954, 0.5171688621559728, 0.9968585350711017},
    {-1.056008781988138, 0.11341275058102458, -0.9272917928331745, -1.741263680101125, -1.6997294767994742, -0.34258934998837265, -1.819509538858933, -1.3846942079207203, -0.4695628987359047, 0.3791361395828986, -0.8263997121870452, -1.962253148095716, -0.5267367794642812, -2.379472866400388, -1.5811558099609988, 0.12534171551811543},
    {-0.22891001643119657, 0.670200362355153, 1.6942874961655017, 0.6888608266987176, -1.8178141904632297, 0.25221727418060463, 0.7394657945617515, 0.2493658096682771, -1.4410505080810116, 0.3119344938181136, -1.3343561619098012, -0.047762101311097045, 0.9185742276754056, 0.4333984718249859, 0.049200048902166754, 0.8036640543674325},
    {0.5935655816199485, -0.6214137785893062, 0.005785665254948795, -1.1165302522019012, 0.8417964799978351, 0.2184040396493773, 0.7437878331644043, 0.12363820845832604, 1.7193804201534686, 1.484667304996648, -0.9563573052978062, 0.14765059610529246, -0.6175536455037021, -0.2961172837899965, 0.542320930840195, 1.9879401822056324},
    {-0.7344435013127674, -1.426472393924484, 1.9971520057753895, 0.8285305775972681, 2.6887169057984734, -1.5258252648723858, -0.9581332280880734, -0.3164266647349016, 0.6224946940991838, -0.5875757844402019, -1.0387837325808094, 1.1034114693007222, 1.8666818632969433, -0.05956906093679919, 0.6104466586886153, 1.414933573422484},
    {1.1328644398157564, 1.2850337134561483, -0.1764322960497029, 1.9695896930363286, 1.3766337535226292, 2.120438707033996, 0.27988228824660893, 0.6368585164097794, 0.9333634330264867, -1.0607011996786784, -0.9478905680440953, -0.3450838256333714, -0.6212744717976314, 0.45973408427889795, 1.2904776454446778, -0.3419599409223105},
    {1.0396778208426587, 0.41597736840425087, 0.13226072146721254, 1.0847478566490834, 0.4183786826635694, 1.9949414662192766, 0.6644519289298121, 0.4939505412938348, 2.0351085579245574, 2.7533842622180837, -0.979605768012341, 0.3308582219144875, -0.5114840832129763, -0.718999167402315, 0.6164512533255738, 0.33654738283987784},
    {-1.5489355769072306, -0.32218395968975366, 0.6586070911986157, -1.254393392082409, 0.8042263778760541, -1.1636251135622453, 0.4461276477903841, -1.0411638661578413, -0.4825933115496812, -0.6591533121704892, -1.3186031507188833, -2.454480122275854, -0.23606794761989522, -2.14648753858466, 0.0017448761504363383, -0.6604924272104626},
    {-1.2289986830638275, -0.39287728152060164, -0.589854262702296, -1.081366106516937, 1.4944136160777546, -0.9694977966894662, -0.1707528608477515, 0.3563138929464255, -0.24403915930563064, 0.2807030756441427, -2.349471375503113, -1.9345963748439725, -0.6112085701389371, -2.69112014535805, -0.5847462927825574, -0.2669654117742385},
    {0.81512491974768, 1.0375055415679209, 0.049239831936371325, 0.7819549098847519, -1.6639373001658657, 0.7485006256506691, 0.9734323533012011, 1.5343701795303004, -1.3441319557077065, 0.8077888893331112, -1.9901253759696302, -1.3199975343286061, -0.8075733444161727, -2.2673947672995665, -1.8463747856612491, -0.6726138416652058},
    {-2.137376691864967, 0.015297769726501816, 1.6226960785240838, 2.4026762602693856, -2.4264973174799405, 0.49332334176669285, -0.4582244081033009, 1.048038860486288, -0.11118447306247624, 1.0814207575949317, -1.7642487183062647, -0.2870395612420448, -0.11658329505716922, -0.2528837289349615, 0.9394689920234888, -0.945705570927168},
    {0.8498179438874249, -0.5671069628580547, -0.20321710953361338, -0.5454127008719957, 1.7146868616987803, -0.3465518613031462, 0.9073959729911931, 0.24263173705400903, 2.2078215054963226, 1.41439089577703, -0.6191263975687853, -0.39785133660819033, 0.9053605523364907, -0.6400432590972891, -1.1218849461075147, 0.20170086210035984},
    {-0.9871943172396263, -0.7455558339540789, -0.8309313947111387, 1.8828883889899999, 1.2569593825016983, 0.5828278760194955, -0.8802051323091651, -0.5249157122313496, -0.2448377772618231, -0.3571447162166273, -0.7759249122487094, 1.9508040514308982, 0.10653503061790823, -0.14856518166154833, -1.3651712319627356, 0.3465680901080566},
    {-1.325571844771367, 1.1678538199108073, 0.7766503980184524, 1.1926557017935882, -0.6978691708423642, -0.34759819734272634, 1.4256522914548364, -0.7874618761135993, 0.27328551270732376, -1.2249074760672034, -0.3250835982655254, -0.40096258791111433, 1.0874234547026354, 0.6760563962085824, 0.5774512948145866, 1.1993628289825335},
    {0.676863273755538, 0.7503496803993883, 1.164480794081888, 0.6910360008136154, -0.6629038731856003, -0.6152264506956642, -0.18250848826763186, -0.344423178797391, 0.8942649331353225, 1.164028064768588, -1.2900255713812823, 0.6384815928973062, 0.5689667156771301, -0.6599430658976053, -0.021345620016909383, -0.6447513083019236},
    {-0.3912675333662923, 0.24448781293379837, 0.9663448421520148, -0.24081252911484227, -1.4943106884665804, -0.1630607048824262, 2.0066864293900837, -0.15504424560869096, 0.0422076397439352, 0.5704121275396287, 0.5965326107830238, 0.5993819426103595, 0.08064644549845643, -1.4657781045836342, 0.6543620471104724, 0.7992998206624071},
    {1.1819371334976139, 0.2850420758170827, -0.68280771508383, 1.2513560559515522, 0.6393145720679592, 1.3709814221767556, -0.5509829792129939, -0.9430161849924936, 2.010524715932964, 2.012784551185227, 0.10224721687537275, 1.423632011076236, -0.47750484397310594, 1.7097503213634033, -1.5688945674387753, 2.2245200290647684},
    {-0.5170682241712443, -1.8714413050124887, -1.7166282600362603, 0.5285592295276276, 2.368679550829504, 0.18325264831584157, 0.6625491235050793, -1.1141419206741863, 0.8878395265374245, 1.3375752214469665, 0.23689265567001178, 2.3834272264220457, 0.3770881101033024, 1.6358121862274655, 0.2797804230863905, 1.7378826346650316},
    {-0.7407141188182355, 1.2646758784256242, 1.8770498396478312, -0.036034562986161124, -0.9405436428178742, 0.10651179744254789, -1.4262405570705945, 0.5650687630704239, 0.17048050967311737, 0.1211924577108218, -0.06599766295190546, -0.4844530849721296, 0.3482086655646002, 0.15562724780627846, -0.21631126983763357, -0.9354142872534402},
    {0.8676906009273426, 0.5350630873116072, 1.8351017579705973, 2.267380618886554, 0.3897725038473006, -0.09073205063027372, 0.010985898996438715, 1.2523873361667606, 0.6473903949669184, -1.068037230588125, 0.5120479444153225, 0.9857698294267001, 0.8754960695565064, 1.1586037093427999, 0.8402625171478026, -0.17353565693235432},
    {-2.356344929889329, -1.5747212996366156, -1.0994336365000676, 2.2470267748496426, -1.0521599900257463, 0.6870388964027957, -0.534747206834964, -0.43876217364346876, 0.20147934282090948, 0.49318225253419096, -0.18873806066023838, 1.7630718923768471, -1.1702831903322024, 0.9459655505182519, -1.0310232748478119, -0.45340237871293115},
    {1.1475173810044959, -1.3354735477740454, 0.10602355746404533, 1.2881294491757649, 0.49113511349181, -1.0868084184360207, 1.7986447907852043, -0.7451725721038176, 1.567177065457457, 0.9864403753238692, 1.153855814711799, 1.2815938387722965, 1.014398530958821, 0.3807116463334009, 1.4786585184228065, 0.46873035106553096},
    {0.5630122093930999, -0.8320229998098034, -0.22138521384006501, -1.9327157877630452, 1.878351940187479, -0.3263263039379653, -0.17743475371362483, -0.4225607000559454, 0.7189043322205889, -0.6371315191890248, 1.8338957327039644, -0.4907655417727144, 1.2274650354473455, 0.11054631350143396, 1.0107867204180176, 0.5953919975003623},
    {1.2021651011218875, -0.21357788417644455, -1.6228872663328886, -2.3820680266192613, 0.8390410330155246, 0.13953653108548153, -1.0876369774293901, 0.49622076052139574, 0.0338480950492238, -0.7761444942136594, 0.7421484742986967, -0.7829474976218714, 0.3757287579958561, -1.4688508566102285, -2.9337900975036417, 0.5436754597030578},
    {0.09717570956116676, 1.2413159301358239, 0.09139778385787359, 0.8237142627863662, 1.2883754014474926, -0.807869061664989, 0.5450990482840319, 1.3916454940927623, 1.6924689205040717, -0.11498776833201038, -0.19917466838766512, 0.7337149818978266, -0.01888278289268739, -1.4928651820374919, -1.6415967348265406, -0.32858096178149376},
    {0.5228067684974402, -0.34116650972668333, -0.6147482609803584, -0.3163562682900352, 0.23898602843680775, -1.0318177916162097, -1.8173253531265074, 0.6160061704635189, 0.44190052063141344, -0.3716289805058263, -0.25138244124641423, -2.0133077001920543, -1.908380180376984, -1.2587616402453317, -0.9806832060373057, -1.5264718083386701},
    {-1.0970990456898584, 1.2861404823270142, 0.6856040204711924, 1.36808116587749, -1.469322860389364, 0.503441765556295, -1.1134415740344672, 0.5489098639097248, 0.010390547339460444, 0.8840513171742418, 0.15385575819582012, -0.9870199676441418, 0.25175124220345124, -0.7585966680861508, 1.2326851757294432, -0.3940325219438791},
    {1.0787181717076741, 1.332778814347241, 0.8673114834593565, 0.22590519264561432, 0.3758009745301962, -0.7230181422432603, -0.10741239561664752, 1.3320000766007998, 0.4123568773980996, 0.2655499448897224, 0.849638694599793, 0.07246048309714806, -0.395640009944322, -0.1378918788284375, -0.21207444624006458, 0.27470636164947887},
    {-0.31464827057885325, 1.4860259263665452, 0.5320864131622726, -2.010413525080569, -1.0308605306567966, -0.22920701355735232, 0.3678927994355917, 1.114279418389518, -1.090867327027026, 0.31790133206624344, -1.5937490394432063, -1.6983060680417792, 0.0382136168380563, -1.859242130889686, 0.2828875748376696, 0.540319331731763},
    {0.5385069957080434, 0.7615184510299973, 1.2255911958729162, 0.6333759540488036, 0.16512185686548916, -0.7113408810917033, 1.3623396406856323, 0.48053333803707937, 0.5304373829473865, 0.34677750264619733, 1.0474308588151986, 0.5877740929957049, 0.6119192718123763, -0.7713177938218146, 1.1893113849672743, 1.1339352678373813},
    {0.7002849270661721, 0.9562423739325696, -0.626870181108625, -0.34911554772769915, -1.7671031991530204, 0.46344378870766584, 0.9013025107008065, -1.4767465240941475, -1.4501298384772463, -0.09728326897563531, 0.9686985322995073, -1.2535708452277972, -0.3125855130624082, -0.4660469652671049, 1.3109079731816011, -1.055960900953347},
    {-1.8415237929763943, -0.19951794112413979, -0.30318394512216007, -1.3941519044714377, -1.431037891182193, -1.6889404616854007, 0.4310544328902308, -0.8499837231575335, -1.5703950552695793, -1.6579526508524776, -0.9944308586231154, -2.0813419169897256, 0.23336882194249214, -1.7155038668469236, 1.023461116654471, -0.3335250440752219},
    {0.08501483700749878, -0.5007680400398349, 0.19591772760695128, 1.6290515538410077, 1.8552913220834144, 0.8654338743576104, -1.6763835737426043, 0.7660009727320276, 1.4797907424163217, 1.2710633056634286, 0.17970760966845437, 1.4576045029010896, 0.8270412481202305, 1.1049731360585466, -1.077628995104119, 0.16047996479340035},
    {1.0396728584968031, 1.0303361148966126, 1.5401426264541296, 1.1852306870934985, 0.5784980939915059, 0.4156255392599123, -0.6195706215556251, 1.0533832639215475, 2.066599728195188, 0.40625099412230753, 0.22649302489311107, -0.09925939083056987, -0.2889042792851377, 1.4968941931657145, 0.5306399726673467, 2.5436762419744423},
    {-1.5222401776591246, 0.8038729013398582, -1.027870607667098, 0.5771404344265522, 0.7559078802604902, 1.199710580570083, -0.9474752900018414, -0.3244024118374719, 0.7500459683388362, -1.636510626379645, -0.031286262210612883, -1.5229384275033613, -1.2112571446760168, -1.1317006211670961, -0.8773174840356873, 0.3072852026344875},
    {-1.4963226688150357, 0.1255694206829176, 1.0171868788145548, -0.8049120036992274, 0.2922428593374185, -0.5650446990066377, -0.0320519573583362, 0.061077524546167904, -0.9658731449367758, -1.6836747306079591, -0.4005572676275606, -0.6501658843333601, 1.5224618219734967, 0.20752235666724644, 1.370497380558576, -0.5417286622425314},
    {-1.2266054054266218, -1.5064312388995353, -0.9504140843893859, -2.564125406198123, 0.12986936478477487, 0.8480745593776867, 2.2906280403431007, -1.0947729343338561, -0.30763824448550364, 1.0340381754215728, 1.0055991072560142, 1.0671813477507024, 1.2573695123983992, -0.8572378300772934, 0.9756635581187658, -1.1738875746600619},
    {0.6521076835399087, -1.1132181800363457, -0.9237384845707953, -0.2893797710074775, 0.4979387189748684, -0.29130694967126364, 0.8586449827016612, 0.348475470943469, -0.4714144363875965, -0.19735116801772476, 0.13380788435702512, 0.9916179034504576, -0.5564719436656265, -0.4634103580759795, -0.016878606118890704, 1.1381254130250058},
    {0.9628392821434612, 0.04120612911389345, -0.7086671763859396, 0.5368765511406941, -0.7385824131883785, -1.2812019613333232, -1.0771693725275557, -0.3353591409682271, 0.5874399265798227, -0.4755814050717502, -0.21154686259449795, 0.91239429514055, -0.11220351191826035, 0.9015069835114903, -0.3474356056119843, 0.5722502718761917},
    {0.29220384155553325, 1.6239388144461524, 0.17898649566470673, 2.0184300632481493, 0.36457649814560233, 1.0590132238623644, -0.9705023303017952, 0.4289671717623063, 1.033486858696056, -1.2043663552715205, 0.8865531717404627, 1.3070267352843576, -0.15370145617344916, 1.9648927948968469, -1.0862635367039082, 0.4083425475610855},
    {-0.974710273003659, -0.6227936507708695, -0.17525272254436258, 1.6454399998833, 0.2539659612716335, -1.0604336436553141, 2.069246867949966, 0.800228703955679, -0.6906312480258181, -0.926719759996146, 0.12857828207381203, 0.4262616038348138, 1.005636634283716, 0.6876675564490811, 1.6840045552516083, 0.0944771982542279},
    {-0.7068056064521998, -0.9478479745997355, -1.053955135278544, -0.7074960594007107, 0.638232088875837, -0.12682414909961537, -0.5040259557848119, -0.6491389781647324, 0.868346406856784, -1.1591776782305692, -0.45218988566379337, -2.165603627645972, -0.48717666144398186, -2.300534109646066, -1.2303038212452304, -2.080702132809163},
    {-0.5624644067665775, -1.4624868446553008, -0.1286213006787463, -0.15956209448470973, -1.3025863877441077, -1.3073757626761717, 0.09285774032405579, -0.2983504716172348, -0.26041011930137253, 1.5079859323343574, 0.4247800105021983, -0.7310341957354848, 0.1997808019770552, -0.3832505018692965, 1.1193426360594365, -0.8872329464500391},
    {-1.3296012404352548, -0.6027609161807752, -0.9840958846357194, 1.7324270289588226, 0.7149274884291832, 2.042245466126928, -0.002941814411074244, -0.4008146334526276, 0.7336690110661975, -0.5634343699536908, -0.5429923996763072, 0.4886227829525665, 0.25253382512996175, 0.11326795923036317, -0.081809004458494, 0.048693020208235425},
    {-0.9963311377226327, -1.9334358528419455, -1.8896602731703767, -2.0152141611804093, 0.4019268375455847, 0.48930418636212253, -0.6509737521672609, -1.1720590877219004, -0.5458971172220352, -1.3872159649784026, 0.13648618224200837, -1.4490659060616564, -1.1961840645046622, 0.00902705855917048, -1.6635358578649675, -0.025344021119205237},
    {0.5294966256598729, -0.07488492944429782, -1.2427311148323352, -1.1276744919718202, 1.1941135936007428, -0.7275971054890317, 0.3418474448742864, 0.5616257822519175, -0.2856600932238173, -0.4426727874838854, 1.4185119295451267, 1.5616782085745764, 0.4534584099161905, -1.73193778704622, -0.5303968672994944, 0.09290232486711023},
    {0.7123790759981075, 0.039503492907682375, 0.856170538454231, 0.9314863909541949, 0.15775907340213643, -0.19379091469131854, 0.5226735481670592, 0.41811412759152516, 0.6520933619890624, -0.11146761742466599, 1.0549943513995077, 0.08073088240653008, 0.526806338107247, -0.378342974090794, -0.879126162475437, -0.37871399873471295},
    {0.39292521164526645, -1.1918186453518342, -0.32513153831938413, -1.390326758208806, -0.7184059400650655, -0.03617669921914635, 1.0226841463031353, 0.2905846568062316, -1.446090256646397, 0.4534765722363094, -0.2237012262720646, 0.41477135456297126, 0.11151039894099124, 0.2923004977485232, -0.08382221195875297, -0.9581008296242637},
    {-3.490163081721168, -3.98927606390693, -3.0676928707384175, 1.932796281228095, -0.6273240181408969, -1.7486771468333362, 2.1278200059138586, -3.1412099368507307, 0.2149952719105685, -1.450467829169696, 1.042995183771954, 1.6800318731684845, -3.2484124897624365, 1.6070160777366713, 0.41647334020176074, 1.4095590568341645},
    {-4.65621514019558, -2.7896152293733927, -4.39300203393828, 0.8076158664944261, -1.1030389997307941, -2.004382272186843, 1.2574546568037945, -3.741026508145661, 0.5618154082895016, -2.2712697740802694, -3.0571756604526485, 0.5606615514941903, -4.080171298867935, 0.22222479883919372, -1.0714476376128852, 1.4370902242596266},
    {-2.0428617556033215, -2.6918581645770927, -2.425570085895335, 2.863600451030958, 1.9391679445764967, 0.510558486563657, 3.388412346345848, -3.4271892204794163, 1.4877365752095622, -2.2933605561381936, -0.9602311205133792, 0.5758885503419358, -2.3225174606786174, 1.373956862428376, 2.193300409806875, 2.817073716630444},
    {-0.7317147378019367, -2.848536281195285, -1.723742279663374, 0.4714017058725883, -0.4477350758305191, 0.7406335336607234, 2.051756820732602, -1.5879101293340732, -0.4687311952448322, -1.6040295314658433, -0.4225548459446466, 2.3242352944285813, -2.146349644121846, 0.9392402645214776, 0.314473742506544, 2.494360551339467},
    {-1.1945812612378102, -1.1820893504508974, -2.2362181223550883, 2.1353443580703546, 1.309784527923744, 0.48127286236947053, 3.2117174775232376, -2.789066865314417, -0.24279226957907937, -2.2230523046628186, 1.2092604792774901, 2.374380839949163, -0.816278212738053, 0.7376377119033861, 2.0085347060438226, 1.9374192025365524},
    {-1.0126220142922233, -1.113413447735018, -1.4865693711081178, -0.3907896699044375, -0.18283369145665518, 1.1983397369114226, 0.0190697792298257, -0.982563493039521, -0.4810848553498761, 0.5996198925092351, 0.24264910632885434, 0.48937670017195944, -0.5199210406592327, 1.4144300708584165, -0.668513997921482, 0.7584350886318301},
    {-2.284878959433067, 0.05468423462694713, -1.1737607616809858, 1.2905230457258288, -1.8910153371008238, 1.319134949509497, 0.402651179135791, -2.510809352124726, -0.31814284087800726, -0.12453812727569985, -0.08011078765049387, -0.20893353234563541, -2.569482110886853, 0.8371041636396709, 1.653305385307855, -0.1946306172470084},
    {0.8079985002647201, -1.7468539520491817, 1.4522288918250468, 0.9575111046719522, 0.8695265745227169, 0.18172901318514847, -0.42693123381908016, -1.3475491635539945, 1.0983873284040415, 0.4818046502052756, 0.24816172364632175, 0.45767220392054525, 0.9247459743915779, 1.616920799018088, 1.307535122435248, 0.6154841664425327},
    {-0.35592235703815395, 0.8056332855603734, -0.28140247586216804, -0.8141096355448384, 1.4935722483848777, -0.1573040546752745, 0.5106378228576796, -0.9753307541189281, 1.5646173812671524, 0.3518032079205065, -1.2652756785524142, 0.11414279399496546, -1.1529637866366835, 0.8791121978907748, 0.2989205285984637, 2.3164188223108937},
    {-1.2881573987066528, 2.236025226180768, 0.6860956321098503, -0.6452824702502737, -2.08727514484051, 2.433599176546094, 1.2963253150437755, 0.0374885164746284, -0.8987635040986206, -0.8388733560370558, -0.09386157329086868, -1.9217689424918023, -0.5383249830835303, -1.003061815235179, 1.7916276657246588, -0.49915265935111536},
    {-0.48003000791135464, -0.5834184750857293, 0.035692531491218045, -0.7042929454877394, 0.27242419073922014, 1.8644855531617097, 0.9905736260187872, -0.6062632576194379, 2.2300024900448396, 0.3222487543936452, 0.29218894040231574, -1.3726391271129121, -0.05568202465652879, -2.1306543197287064, -0.21779463804480806, -1.0114073458743627},
    {1.764089267714413, -1.0266897263256438, -1.7206924325686725, -0.3529768742739054, 1.414939003756712, -0.7799062606918541, 1.8197912383475106, -1.4856099714237065, 0.7651163750174054, -0.4986303100098345, 0.2048362245569559, 0.3266311969206246, -0.6429168921360162, 1.24365017560834, 1.8016933817466412, 1.7169758083206255},
    {0.17706406628274401, 0.06681752059812902, 0.1310350462264053, 0.1385084968759793, 0.7843517322580092, 0.031239299116912315, -0.050370607433058254, -0.3396680040986995, 1.3246742422840776, 1.885747320410587, -0.7583110018098067, -0.28965408370133533, -0.8573015515842185, -0.2118539941035921, -2.031332572399474, 0.9556566393718804},
    {0.940264377535459, -0.45050324922670265, 0.9914873687150195, -1.606647823230814, 0.6294858583902705, -0.4994833665802371, -1.5464469230404385, 1.1768061927641784, -0.9578721001024532, 0.41009404480233463, -0.5635952151283168, 0.8008428086215134, -0.7699419845756073, -0.7574352609525676, -1.5988245873976012, 0.17498340532450632},
    {-0.7901383201491692, 0.995676659615589, -0.49465771603592734, -2.067946316679586, -2.7260441885863242, -0.7448017447652107, -1.018309266010747, -0.5759872605065126, -2.2071059869817344, 0.3057254918281005, -0.49776717583079716, -1.030299703379955, -0.19063159302522042, 0.587993346215197, -0.6014811324403114, -1.5207579738954922},
    {-0.0075452772701827845, 0.2584094685667684, 0.7145637036472223, -1.0468397661362205, 0.21211522799288096, 0.20466879635519955, -0.22709898610688056, 0.14608715099615718, 1.2973472964801331, 1.4384943476093806, 0.5536418685622564, -2.2314257835410913, -0.5905182954427974, -0.882218157314537, 0.021793120395006256, -0.03870453383341669},
    {-0.09893618045233837, -0.8762610206204392, 1.2162570567515076, -1.4668984335913664, 0.5231720421908124, -1.1765074096861685, -0.30487434198298713, -0.13194681455023174, 1.1894334902526646, 0.23517339047397223, -0.17577731734991003, -1.1962151509488932, 1.2775714936594482, -1.9134394183813304, 0.09663604787967742, -1.4007183804920773},
    {-1.9404562381386006, -0.37107474365903176, -0.508910209863727, 0.07520683446081901, -0.1377655095162787, 0.28244071962582923, 0.8165828141918542, -1.3559723944456796, 0.763034782041733, -0.4841665445245581, -0.005294551446878905, -1.5097571801584742, -0.9953814941203059, -0.9807874047014085, 1.3486597807643117, 0.004218917069050164},
    {0.1263136866231998, 0.9899413885172265, 1.0045965617151744, -0.8703631644002681, 1.0886276815619416, 0.2510384006310123, 1.2317411617826084, -0.10902944563375577, 0.4816535860621723, 2.1166243359047914, -0.8766283310931762, 0.035660629816104766, 0.7181559240365333, -0.18150665030327273, -0.02066299015603349, 1.8383484054957435},
    {-0.5395848721139508, -0.44318369003706104, 0.42466144819045154, 0.30280958209568015, 0.36409108951970137, -1.632008139565441, 0.24884097591290918, -1.043450999964256, 1.7680245729618462, 0.512332630214974, -0.8139852060915301, -0.7273785289518931, -1.0189216310086155, -1.766428284881095, 0.8035052705245742, -0.639209923603387},
    {1.8963601305997042, 0.5496656618256254, -0.44430043105254496, 0.4052897696199372, 1.376500442548527, -0.7455997886570844, 0.4578485686162139, 1.005505532944819, 1.9371845636329483, 0.960130002048474, 0.5617493957944332, 0.06643959415220686, -0.2461000580449065, 0.33630245215928395, -0.4228650109618225, 1.4802187365228765},
    {0.1991826624750887, 1.1605692083865318, 0.6710591767281208, 1.537706611698892, -1.722213192378811, -0.31321519399566045, 1.2549231575714876, 1.7322152819019678, 0.9825847506174696, 1.0290135692930324, -2.6848867057101415, -0.862735476867663, -0.34445900801777474, -1.7063260806983682, -1.6886020356618743, 0.3584685189055117},
    {-0.6220067774163647, 0.5470343494275869, 2.4338653855890264, 1.150475313830814, -1.1721095182751224, 0.42941949284823017, 0.8700019994218459, 0.14516265687204352, 1.0199750082456325, 0.029544017691923875, -1.885305102158935, -0.7104942656580305, 1.0440191209888878, -0.22293938365908203, 0.2962115299930617, -0.15206967598150814},
    {1.3901785084286418, -0.3257014011068255, 0.31796882012762506, -1.6830319694946996, 2.2307770156044815, 0.006429299091667259, -0.5085617340773203, 1.3139671773400081, 2.5292323548475886, 0.8592515822682629, -1.2569987504036317, -0.4098656530902547, 0.4643753039678143, -1.5973021124011488, -1.9145603365429005, 1.5072785723945812},
    {-0.5839787741981348, -0.39836528425014184, -1.6129925222037649, 1.112625234644964, 0.13603515360151092, -0.12766018414493746, 0.23764727067362332, -0.4501089703073373, 1.2125221992151107, -0.5210733318209251, -1.0997394145783808, 0.18457154342251864, -0.463389862430213, 0.4321736169330036, -0.5194151980494323, 0.5103094839510383},
    {-0.6334749800854259, 0.7766771294227539, 0.7735546476537871, 1.4948153748740693, -1.0547116497856306, 0.23990514721900658, -1.447174245076899, -0.8126862157394217, -0.9251996767401065, -2.051548183085157, -1.8119465280142466, 0.4224920146473577, -1.3578630578040813, 1.3482810548579436, -0.5182294334325699, 0.8686800156154089},
    {-0.9336092738244883, 0.32483088356294915, -0.32171805514892043, 0.7839143963175436, -1.4732921100761447, -1.5019682900934652, -1.044500150614205, 1.2335300204928665, -0.053172410752219394, 1.0708712932361402, 0.40085862161147345, -0.10256068375454663, -1.2515249327562215, 0.04195237947724403, -0.7247071355394685, 0.39722332619851913},
    {0.71433560608603, -0.604031095482221, 0.34946969173495485, 1.6675944131409097, 0.6512449253284, -0.8962205386746238, 1.1883774231950293, 0.7802084583324204, 0.27005803746039675, 0.21614852876007778, 0.22643833935186297, 1.7540057058944705, -0.022397199111085536, -0.382835054254158, 0.47090312682123986, -0.5443733925907233},
    {0.3479318229964378, -0.8901944548874531, -1.3564174881790232, 0.15325402308624522, 0.5006843323742554, -1.0357548296606194, -1.847382224561535, -2.1514677697634257, 1.144418245730604, -0.892630418140677, 0.47223001750059873, 1.6266170307598178, -1.5015818370297564, 1.4973611550783519, -2.0961011545684336, 2.1158965794706424},
    {-0.4718374747197745, -2.0205763974246045, -1.8449367493932818, 1.8790003929375356, 0.8613049680019988, -0.7558341057813165, 0.4604920669934474, -1.8030214019540993, 1.5080842475293998, 1.120802338990751, 1.0694345588620566, 0.9273520568860123, -0.948366973203451, 0.7599773030897151, 0.8502192666709086, 1.3475359530670084}
};

static const float b1[16] = {6.292963286954906, 6.109708393468089, 5.8889922884478185, 6.29128456257124, 6.215518375084612, 5.645572327663715, 5.890324738266954, 6.186385152634891, 6.292052172286617, 5.534639789728142, 5.833249663694663, 5.810081133605378, 6.002140374852881, 6.376836645277473, 6.304594686114312, 6.597387147162906};

static const float w2[16][12] = {
    {-4.011827841943418, -4.324923696717627, -3.337965372877331, -2.8960536674871196, -3.172087275877161, -3.985990488861159, -2.4586204164962924, -2.5785901781962237, -3.187511655499334, -3.4763624084923386, -2.9677873984567618, -2.5633026870946556},
    {-3.2618427670586225, -3.580214287709501, -3.4240480078830613, -3.7194609008217894, -2.5722505117379333, -2.2359630886379196, -3.493193089324348, -3.672111221126701, -2.608984489095565, -2.7007763659880335, -3.5448016739558037, -3.3639326542573866},
    {-2.984001428520947, -2.92018091950903, -3.2055539732527256, -2.1891818380232357, -2.7959063750601816, -4.10815360756118, -3.83533165459396, -3.056286857664785, -3.2288251339277476, -2.7931605557826416, -2.219792646262038, -2.5405507054185494},
    {-3.9518700229489805, -3.476779238960819, -3.354173582175415, -3.0819766663849264, -3.2123260118084853, -2.8677465595276685, -2.822788323543576, -2.8388053025963553, -3.585664215558734, -2.8570237742248024, -3.206539453544682, -2.093992265685315},
    {-3.5559102992840215, -3.976888933647459, -3.790804894195701, -2.8620682094951726, -2.7408565249209635, -3.1422709916644203, -3.63348580135908, -3.1857345578343317, -3.983298617246143, -3.1050061607230823, -4.243405630829895, -2.6812297959335303},
    {-2.3456143310188593, -2.889048927911152, -3.1720995769267404, -2.66826063266519, -3.124691479507578, -3.65612870738281, -2.263674014759939, -3.292190020437262, -3.4599286643124647, -2.500717464233186, -2.702362786989699, -2.477820857514087},
    {-3.104709153900752, -2.7014777645907246, -2.9499559987695534, -2.3908313950221114, -2.7055170440686114, -2.170078275033026, -3.483087738235898, -3.8651955871551857, -3.3962445507093375, -3.0104744562532217, -1.8737598340627852, -3.0894095510114727},
    {-2.1120729082405987, -2.392944072382987, -3.316057831820196, -2.3285203902724083, -3.1783299701022245, -3.0868149190288965, -3.228286004490552, -2.3360422998063988, -3.246688133935427, -3.73883043825542, -2.839836279354869, -3.896495536260354},
    {-2.367633755317329, -2.8233941581462942, -2.6706302008805953, -3.8275631044361753, -3.1548537568501054, -3.0483357322972338, -2.730336201702701, -3.1253339960978224, -1.983810883438686, -3.5790018573714617, -1.9783310829935175, -3.971598771525754},
    {-3.2761099521820594, -2.65340102910926, -2.8812991449856336, -3.41547331114114, -2.814042132403713, -2.1281272503489714, -3.162219968053733, -3.42873156500961, -3.2068338540254806, -2.588593784575481, -3.876548224813187, -2.456956937905547},
    {-3.4961868526182975, -2.825129969258099, -3.029966032605886, -2.7898734447179057, -3.3271747766148847, -3.249979227896043, -4.077259665627323, -3.573337816314649, -3.5084235133072954, -2.5508935070124985, -2.689129665407609, -3.314037682278443},
    {-2.4838071469531204, -3.6263383690030215, -3.2521640592105756, -3.7506515544748047, -2.7016116089613513, -3.3200392719354532, -3.0704437664818913, -3.657047634789398, -2.2225787797450964, -2.7818946128353743, -3.271087941723093, -3.0379289948990946},
    {-3.100124025758212, -2.8982806132883394, -2.532020747482769, -4.361245958052789, -3.396859781367226, -2.6870982434725876, -2.0182997418653086, -3.9366935732477173, -3.458141709159591, -3.138654073304587, -3.8516791448825045, -3.6086164831913896},
    {-2.905437811691522, -2.510045805803017, -2.988748085766719, -2.790911140922938, -2.6971548257235956, -2.227797204166336, -3.492689062777848, -3.181389191706301, -3.754195179226583, -3.824561300765697, -2.7039155405454998, -4.258089062632762},
    {-2.7584070244109298, -3.2611923147270723, -3.1915488167233392, -3.289161863858335, -2.7731001721956177, -3.5641673848087945, -2.3849159587148794, -1.949428061373221, -2.2309888442438477, -2.83527728403866, -3.856861266044183, -2.9688635727948274},
    {-3.7550944666830652, -2.6552261068389442, -2.8120991622959552, -3.4895767842944556, -4.250447590287632, -3.9189459195099894, -3.3984328528913363, -2.6281202033696904, -3.1262277597497063, -3.4306327987906142, -3.6374347839326737, -3.25917428819404}
};

static const float b2[12] = {-3.26396780507788, -3.3669654786827574, -3.704165167026461, -3.3896306703781622, -3.8745748728032514, -3.193730743168734, -3.5814301507459207, -3.2039106011326974, -3.098660403519122, -3.167755550752154, -2.7096297672272702, -2.7603448370224037};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
