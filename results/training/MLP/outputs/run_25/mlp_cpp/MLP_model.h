#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-4.533173850013203, -4.895975063181689, 0.500543684824487, 0.4671297213085563, -4.283063738508924, -3.261128730309095, 0.9846599161042248, -4.921901540968463, -5.134331886129229, -4.7701618752265595, 1.3902703887180612, -3.313455802547951, -5.263532633766931, -5.721442864631062, -5.071742524513237, -0.37418391001845724, -4.867536654192652, -5.59110098049161, -5.163366795644118, -4.878146884743914, 0.15748190858662203, 0.011846815220447154, 0.5805896781895529, 0.16458302922802293, -4.993454217428224, -3.249120971293766, -4.435496407156435, -5.367676193837508, -3.881804182450483, -0.41382234109320365, -4.6554921764267405, -3.0060554698169932},
    {-0.442059859424738, 0.04456179218756902, -4.320834184441271, -3.286130701595311, -1.32778052341938, -2.9252467633695187, -4.459736483999415, 2.6832517621428496, 0.7662155318211722, -2.236538490224039, -4.040000310752347, -3.4797487113047363, 0.9033918460921075, 2.1161607473816826, 2.069305898232692, -2.077925542041461, -1.205692967703965, 1.4335565440038263, 0.07452591303733798, 2.298762460098022, -2.8638943822733998, -3.9292617449388056, -3.657114993399991, -3.641127204467642, -1.3197562163779448, -3.708898676900965, 1.1944190794274272, -1.418936704821826, -2.3236936145327975, 0.1606590419152237, 1.8967818244154646, -2.968315063072228},
    {3.275662109875085, 2.5794711591522494, -1.8115183115782634, -2.1737718155113726, 3.2407189935455483, 1.3716074913041945, -0.5120088976146602, 4.417152349704921, 4.218981334701586, 2.229812724664488, 0.674058000265323, 1.7536593348100677, 3.0831412580889737, 1.2170054757076605, 1.1268702553391725, 0.9068002741020554, 2.1010781066469795, 2.8224860137567855, 3.5837762578667967, 3.6982783867104487, 2.5887324520206203, -2.2425502167481435, -2.0650358814366467, -2.0879122138310486, 2.9045958369183467, 1.3393498610303851, 0.7995723414508855, 1.447769636317214, 2.96032289912941, -0.5385809550497423, 1.6892494453601719, 1.9603352693154201},
    {2.1532150578391693, 1.5761958204734972, 0.705424865101385, 0.27417022777263916, 3.112896094295306, 3.1514271673446417, 1.4811807406261683, 0.027837342819832005, 1.3511211087123411, 4.002380856284979, 1.9458250614891874, 3.919651494951321, 1.7329371332371644, -1.0226043455062341, -0.15277980547497, -1.4484838529941124, 2.3177273378752274, 0.9997824969555782, 1.7186094024576963, -1.3141938353599916, 3.1046509078412092, 0.7959766626220262, 0.5515074671906413, 0.868097727495695, 3.3843892458003157, 3.549768232071743, -1.9513775692436603, 1.5034386779794437, 4.3058525697418295, -4.617285997616631, -1.8953941801061163, 4.1430161281615066},
    {4.557173036813048, 3.95056701799246, 1.846918268645425, 0.4916408837736194, 4.670014795482575, 4.005668924903645, 0.8436624711589082, 3.5802558975141148, 4.572005480457637, 3.9899728614335035, 0.3403088859429735, 3.1778311846678986, 5.203231236285874, 5.040594838933064, 3.407562323650643, 1.3112254439271864, 4.575659501243055, 5.129517763581138, 4.524384844974348, 3.1644424134379414, 3.5980892226716175, 0.5117693279529492, -0.7556818797113525, 0.1432526524610786, 4.55455189059387, 3.4798529905746296, 2.639218777631694, 4.957772530256023, 4.414493895612007, -1.74469371498593, 2.2378035740830207, 3.490503399682914},
    {5.895640537927071, 6.755190836041406, 5.0825152191704674, 3.333175419814137, 6.869485725575458, 6.42548395461321, 4.085421700056562, 5.64289762885626, 6.559525358791744, 6.7583743823252185, 3.937081143283424, 6.081273630622306, 6.711791875317608, 5.865700770109048, 6.1776185510841195, 4.646524573558406, 6.575043333281011, 6.384019490937876, 6.480765313661328, 5.446834953781102, 5.112251394023754, 4.787799904953109, 3.2444988164028934, 4.008546775371151, 6.8392538449448725, 5.420264605353349, 4.049942277993186, 6.486348305698318, 6.35957168933209, 3.16579806957975, 5.10552662419588, 5.496939859623006},
    {5.10570615131897, 6.2450517782612796, 5.424072210302171, 3.6650614582042356, 6.374503928390957, 6.1750383373898625, 4.343171289351224, 4.849993067498049, 5.840048000604517, 6.631484071223667, 4.105465213566451, 6.164957702000427, 6.09397444139064, 4.831933331579772, 5.812837026994386, 4.442717951326857, 6.060888612046903, 5.819678389975536, 5.623368065617993, 4.8081639186896545, 4.939452736612538, 5.231017927502377, 3.435700724816282, 4.718959775928957, 6.48531238791239, 5.702761047311346, 3.1115213318266117, 6.046619582822849, 6.297070498390977, 2.124585813294636, 4.777006765090742, 6.0135189434195615},
    {2.9743209932296937, 0.5069158422868757, -0.5542670093699391, -0.7976881845297124, 1.6577774647414771, -0.13832597978455338, -2.881602857732731, 2.051499925281771, 2.22767274094948, -0.4135122210855261, -2.620440590463302, -1.1681693551502783, 1.5012986616232007, 2.548114789746804, 2.3628518020515674, -1.0674218647336986, 0.7195909610104153, 1.7061787872532066, 0.5213635417917263, 1.2829306882239384, 1.305794984112708, -1.4749213285749696, -1.7844514843965777, -1.8921835940839837, 1.6956468429849876, -1.353509950642146, -0.6284186456866353, 0.5764865364291575, 0.3514560076316344, -2.327673912454208, 0.5128393912099161, 0.18825750731773494},
    {2.697520452682649, -0.026618491449793866, -2.022666746215008, -1.4859252690178146, 1.840746441297584, 0.0230725797794519, -2.4069669652544885, 1.8750072728910725, 1.1809033802504765, 0.10980068250733584, -2.3208216455724338, -0.729092831618561, 0.47953886080505426, -0.46069050141238865, 2.4623174440315103, -2.8341850677266405, 0.3161639128875085, 0.8427854124823971, 0.930465875042827, 0.7776278550480854, 1.3726449689168445, -1.6378388545357803, -2.1227715256102675, -1.9116490726717497, 0.8955724385866111, -1.4824645720971057, -1.1143420075482355, -1.3975903886150673, 0.9378364144328305, -2.9137759675255706, 0.18617244344350128, 0.3477754950765383},
    {2.471405926917389, -1.0352120611673052, 0.5063151718298559, 2.752451795142266, -2.678453749922741, -2.26484535157502, -2.629251914319463, 1.1197422071938552, 0.14812737013239713, -2.078549524846211, -1.0172963269901591, -1.5641319474920181, -0.513173978056633, 2.283281918647667, 0.9864571346947091, 0.14700464854598097, -1.256953317606208, 1.68331298139747, 1.320565559828422, 1.3816282872776802, 1.0750404812356293, 1.7554509392388933, 1.445321339091949, -0.538409468791368, -2.4744746640427233, -1.5179266603286745, 0.4353071469319466, -0.4889699364937068, -2.9949842536392945, 2.5605001638057003, -0.03340915597304126, -2.415379810725488},
    {2.9191166384701406, 1.4987457307758953, 3.1193882131628508, 2.8520229559545296, 0.48169191751176205, 1.3328471899445384, 1.2883357474370893, 2.254871617390702, 1.3162855596408674, 1.4557598371727065, 1.8495478241011658, 1.22118750521291, 0.8341422597962097, 1.5275191071732468, 1.1416183827176978, 1.8803391071913407, 1.2496964902174126, 2.119578680906184, 2.8506675411847, 2.3914722358749843, 2.2351015620934684, 3.180686726494711, 2.675888469323337, 1.9408519668250959, 0.8793443430170752, 1.8755499098354282, 0.06722360884759182, 2.550010078228147, -0.138274395059933, 1.8615730194653715, 1.00937439781321, 0.6782356406598316},
    {1.3183396015942246, -1.348617644685749, -2.201419476330946, -0.9898624437707654, -1.8479081127005939, -1.5692645033633719, -0.6447721046573502, -0.2038792638336281, -0.9788280608472045, -0.4984768434619263, 1.4550881330879502, -0.48096384006286436, -1.2317545598937274, -3.1553840859735356, 0.33826114003995833, -2.907509223174186, -1.5657896510315839, -1.8261655303766622, 1.0736988391849933, -0.8059296505896276, 1.0984921085477886, -1.8870569141002682, 0.3078027245728854, -0.6133254132570677, -1.3542193778178102, -1.2755389678419045, -1.34324994276412, -2.5978899871417314, -0.04686279607712145, -0.328429542795948, -0.530694705566362, 0.17738395429936632},
    {-1.0944301689386657, 2.1214999619598367, -1.9288327930954792, -1.857205067981064, 2.108780660386958, 0.5163999768272297, -0.3252654833849944, 3.469072675810117, 2.329896782471769, 0.09779891289414519, -0.7466449643414179, -0.72542840268743, 2.0742857287328103, 0.5729895771970652, 1.9269245401150414, 3.009542383235003, 1.0633282187773518, 0.8273005017954681, 1.940255059076226, 3.947681466087351, -1.9205555171388582, -0.7279585159290023, -0.5586517549498973, 0.2663817805688099, 1.278995972156559, -1.469227863984143, 2.7464012517389884, 0.9236119125898398, 0.6910667621973824, 4.8111729216976205, 4.443248915854478, -0.4827809882111601},
    {-0.40843922803640936, 2.5624764692642237, 2.0745501977588843, 1.019587112920905, 3.2808670771225503, 4.785719285574964, 3.293285232764028, 0.560018131647535, -0.8741011399926603, 4.33723462513492, 2.6256501893852, 3.2681533698951135, 0.45572850984769286, -2.6728206506209364, 2.266756375170274, -1.839607506475444, 3.223137225484081, -0.8217041479808888, 1.7000384189631552, -1.0854606931439839, -0.0630114332825518, 2.740249838817453, 2.9589006277592995, 3.5961415246897594, 4.073251646565027, 2.1119594645358006, -1.2213914828662027, 1.3831585059794451, 4.412046270821345, -1.3803134613993313, 1.1724867971989186, 4.379488051109684},
    {-2.059338636505535, 3.865386655881521, 2.3251671437909094, 0.8415102209056265, 5.451638704209254, 6.146277068252935, 5.014436911905946, -1.5666648772135734, 0.4849504881655137, 5.473459922936628, 3.5329594038791434, 4.919365763990282, 0.7282318344602887, -3.47005536294548, 2.0127335447987442, -1.8802746972435125, 4.5506830069543565, -1.3984839585359907, 1.128866470828997, -2.510796858797217, 0.13959571447581817, 2.9913383353894996, 3.5073920219223593, 4.890336949333597, 5.822684931881198, 3.687787780299907, -1.1582471933696643, 1.1855298201466742, 5.985120027680576, -1.8552329198575468, 2.058788599376064, 5.475234413936882},
    {-3.717586647463613, 2.8149473170156774, -1.7676435476411538, -2.520124540645183, 4.294258424609031, 3.9758064874915258, 1.504608352193777, 0.3075526404466053, -0.14454243811687723, 2.244182221633941, 0.43082434783946, 1.01948032193573, -0.16573838952513362, -3.4826207265536024, 2.590875355750819, -1.6435246914387618, 3.429886308899524, -1.717305836153593, -0.1307977919078343, -1.0833254820266318, -3.626483986301126, -0.5190103740107918, 0.4370154384336916, 1.8353714579603182, 4.024594968983923, 0.1617231081213765, 0.884246404705962, -0.09808672117448586, 3.805361413866403, 1.2979578555667437, 3.6614868034804804, 2.5861708744995746},
    {0.7545643019397639, 4.764716898243954, 3.9391608927471418, 3.4985998179723903, 4.744287992315889, 5.799409489223165, 4.786173207114078, -0.045017892306287666, 1.9211568129371988, 6.0132105507456926, 3.7863097766811427, 5.726627671055665, 2.895918624440912, -0.7483371111725282, 4.19333677027587, -1.194123007387858, 4.693470929167139, 1.6734935676286222, 2.6700561594585, -0.8380899586926878, 2.093016897454154, 4.749019033927422, 4.638341768274146, 5.390882769240407, 5.746597944327289, 5.107781225529212, 0.03924693167926519, 2.583993431474083, 5.501624157131991, -0.9546954719311471, 2.148758036093206, 5.665124676790786},
    {1.0744595596817117, 4.345792893150468, 3.9523625016150827, 2.918323984103816, 3.9661096138362266, 4.986324348268286, 4.547650035575483, 1.5178631339793578, 2.448653017532854, 5.191299521018082, 3.581834638813441, 5.057043118764096, 2.539065163699516, -0.8037648281669837, 3.580570755936516, 1.0035597600108639, 3.7941574062270917, 1.690285307193297, 3.1130749087756797, 1.3330886674925293, 1.7685169763675872, 3.7223830732684973, 4.187629058766693, 4.758691946247293, 4.169153469714437, 4.004063160542368, 1.9932177028504658, 3.1429517347807217, 4.457979706168796, 1.6540788201657464, 2.9420921272916893, 4.5092432766445585},
    {-2.4187112156779316, 2.244446627052242, -0.7017581515952712, -0.7411425110773758, 2.811546810943676, 2.480583474290922, 2.060057975776561, -1.380412038611237, 0.4482258771201847, 3.3760621332498513, 1.2188821017191456, 1.5762370033217104, 0.203709734557468, -2.5051748345422062, 0.7253560210791313, -1.4641230423236258, 1.3431848272741238, -1.377693158237505, -0.9923542002659876, -2.0381226854851353, -0.7689665765381636, -1.0015326052594646, 0.9324681568191815, 2.3489330548511442, 2.9206872400590296, 1.162482345581635, -0.3480121534885823, -0.9665796439033649, 3.0323062168544626, -1.9057706416628053, 0.7612478761234209, 3.2867330673479587},
    {-1.4518554557859682, 0.38130775842624975, 2.8200295717579977, 2.2781431859966617, -1.282697618459249, 1.6368061711429696, 2.7287072779663304, -1.0065622037760678, -0.8129755461998975, 1.9392459779161977, 3.4586388156251577, 2.693826375260864, -0.3062222136955395, -0.6479174415873378, -0.4294303789805405, 0.48744271720198157, -1.1769624217398709, -0.03727607419057966, 0.05509526029074857, -0.17486920368448614, -0.7022143189151004, 2.1345635543177237, 2.654040975064551, 3.0277767935278983, 0.2579183314925244, 3.002828015500156, -1.114823078011257, 1.2966708684872088, 0.7641585072560235, 0.3711248175217061, -0.32593023357590445, 1.7904545448860103},
    {-3.352702943206814, 0.011934962729561993, 1.067916053946988, -0.40227274572802935, 0.4870585128014864, 2.6252856926177914, 3.973102760418081, -3.5864349441546355, -1.4312567758041035, 3.17851182269871, 2.9068039178617235, 3.043393033235631, -1.4220583872621844, -2.762706598778865, -1.5276241929660004, -2.2800335140892733, 0.28153023224641827, -1.9863584834356984, -2.763915056535402, -2.5833766950558474, -1.5541562014578656, 2.068047026561544, 3.321433531547427, 3.4191687312754664, 1.84237420891103, 3.425539483722468, -1.469805104459304, 0.30874552566148117, 2.4789102586600844, -2.691001090434183, -1.5527828311905154, 3.6555173217897723},
    {-2.3365998008867686, -0.5566694609823896, 2.949713664698247, 2.1235195569118197, -0.00843247127034725, 3.4456992643725437, 3.9571323135348835, -3.586712722438778, -2.6603932721855217, 2.4036406521162874, 3.0932507815095356, 3.1799270289925685, -1.590243973789984, -1.6649507687225311, -0.3642504428542779, -2.5921532583738363, 0.8035974684391085, -1.907301133560264, -1.1538231991826446, -3.9452332912435604, -0.9790795084418231, 3.180914718028142, 3.72115039815915, 3.9733590202675204, 1.6464919641473703, 2.9361273553987077, -2.8471763284839566, 1.2346032259502495, 2.4369015185637766, -2.2088148157817287, -1.9199952232041393, 3.7681552800036076},
    {-3.8289630707172515, -0.2075149271176582, -0.07150426584041089, 0.2039314382129571, -0.2863547298414424, 1.7758010544656802, 3.404013554404027, -3.0988920413223857, -2.229123758257487, 2.0272124708792836, 2.252898617686475, 2.053284472132468, -1.581906123780308, -2.2804819143430133, -1.5259609028977272, -1.62884162728825, -0.20873982276200195, -2.3287707752293114, -3.1898485177931466, -2.2395969748284297, -3.242000569945283, 0.8016969737136753, 2.0916364255384026, 3.1973258845443513, 1.4469038134486012, 2.383187747551597, -1.2475438745194813, 0.20913747193552068, 2.521243580555178, -2.5238635394600037, -0.22162453889013473, 3.505557745247563},
    {-1.4058958190053201, -2.6574272789984734, 0.2244432751502644, 2.7478639132350327, -4.1110288020651, -2.080866288141233, 0.5680155978726834, -3.7649760034734507, -3.172794157517122, -1.4144728601728824, 0.05268227252892361, -0.5909733034120481, -1.7116550978509757, 1.0726692505453506, -1.350255699760681, -0.2565177122028424, -2.6027230727111426, -0.9939125970992773, -2.9475032750588794, -2.6564940222970237, -2.257382658976718, 0.980207817820207, 1.6324888452874373, 1.046118510894474, -2.4241395609566556, 0.9734717688396125, -0.8983554103172778, 0.3911732982927977, -1.9303281289544116, -1.61659195883451, -2.609049561316897, -0.2537151905689253},
    {1.5394004138427915, -0.47563496300318325, 5.045027513542586, 5.404799310240281, -2.3527330723979802, 1.244930868238457, 4.535797761639157, -1.8266986092490765, -1.5925416774783046, 2.083508433834871, 4.312600886210071, 3.630909283340587, -0.20857951404861919, 0.9070665993507, -1.447304047077391, 0.8568996233695614, -1.0310872809661953, 0.9201449646193536, 0.3266635851713672, -1.3117008782318154, 3.785896282481394, 5.036699568720455, 4.288849583319576, 4.087867466691856, -0.35721672449300235, 4.494110460002161, -1.9816650540988006, 1.8735874412825406, 0.3143084040166945, -2.03134847205381, -2.4873041371568823, 2.899725095553734},
    {-0.18312528142074966, -4.363566665782869, 1.6661044459992258, 3.090745615435028, -5.095086880965166, -4.090800694208191, 0.32560027845712003, -4.324626142876398, -3.2965376497743746, -2.985658997948613, 0.9144401222729298, -0.4546784069846759, -3.158656236317998, -0.6230535239597411, -4.089631516589722, -0.005148492159509917, -4.213974107287189, -2.1222858618426694, -3.110277324164074, -2.5652088725179345, 0.6917063550431111, 1.7210799869050075, 1.1464178360692312, 0.4753082333217909, -4.827937458472217, 0.6879884045577838, -2.663631972694272, -1.646979666042901, -3.636844254376438, -2.525566569965452, -4.687369384338676, -1.0876183434184326},
    {-1.6378909720161339, -3.970929872474528, 2.6124799790799718, 3.969740214887849, -5.229860591601392, -2.70015555905246, 2.443513812664816, -5.597579944924514, -5.002378737679887, -2.019442039846171, 2.1555581213792694, 0.8407314129799562, -3.738560435880075, -2.0544547263052766, -3.2507988448725813, -2.120255289769212, -3.622233200912526, -2.710478953215267, -3.7073114887214142, -4.295231823083298, -0.029499153654423148, 3.7012719320696026, 3.3208938427596277, 2.4192987602234726, -4.120576535700763, 2.1700461805272866, -2.7496796865369824, -1.5835388603583924, -3.2808177881420635, -2.9040703574389215, -4.746666751166024, -0.5879815178000174},
    {0.8832200795211551, -0.07017940875201385, 2.1869582190328867, 3.066018634574571, -1.5017292656889336, -1.2315873094092897, 2.7784027895797325, 0.05701145658139292, 1.1170225955567976, 0.3329052113896678, 1.8531617539627094, 1.3951574260332236, 1.2789430406855142, 2.937041148163823, -1.0655834556007793, 3.3496447972798644, -0.7230825008541356, 1.290304358547721, -0.2806887307997718, 1.3459985901885825, 1.489644519986558, 2.0632533693708486, 1.3898507263923852, 1.855329205285212, -1.4319993050463955, 2.781661351788067, 0.6636524127021294, 2.087388658319399, -1.0785319207820803, 1.0688880129088192, -0.651478078295039, 1.301028717501457},
    {1.4348626745243729, -0.9933507336794364, 3.736928125221497, 4.523414809476447, -2.26680309312791, 0.717001519142143, 3.5365250586200134, -3.8838999593119334, -2.253885993897106, 2.14370968860648, 4.29942338320204, 3.516265490340228, -0.6273131722839549, -0.20186423961295855, -0.29912258142695597, -0.7818623982281813, -0.7451199355709804, -0.3490716990970108, -0.26185798031534635, -3.07800704989318, 2.2973603789838353, 4.1396792447614885, 4.125406557848778, 3.798019997884403, -0.4585090386425085, 4.138393274261495, -3.038497789067819, 1.0226534857195237, 0.6112288870827653, -3.1985184212604714, -3.7099416460433448, 2.946748571773175},
    {0.5518159572241655, 0.5359465848085547, 2.8526323922755394, 2.662974013160414, 0.8742154990945975, 2.0004689660695365, 3.3694616472374084, -1.9870189958525624, -0.6103053364108038, 2.712250321955537, 2.0969444282581606, 2.8168619384527864, 0.8513395571043582, 0.6591686211325386, 1.1249908932919093, -1.1003900713528132, 1.3298034049984124, 1.1007294530554572, 0.5440870243416122, -1.3414469430899483, 1.7482999598424893, 2.5625443134473755, 2.6203235006041004, 3.443409985650489, 1.478039584522712, 3.5027456936367223, -0.9482867503464816, 1.336476231391157, 1.886938438122501, -3.1476852285393355, -0.40287347320793765, 2.4106344153567347},
    {-1.14333898431465, -5.126509475267685, 2.4072728069883773, 2.613371641576711, -5.2453544066709075, -2.0720813158852063, 1.925277194761306, -6.3700177232368915, -5.939789518348596, -3.948903979285823, 1.8153982369861117, -3.0612186497412686, -5.856179505619312, -3.8487073695935377, -5.968885743936417, 0.6521006717376673, -5.910485777458484, -4.081525349046912, -5.254061572854954, -6.283856111538522, 1.8396856466524663, 2.2888969295254924, 2.0668129980998144, 2.065703899934432, -5.365815555313147, -0.3977759826602954, -6.2306781852488, -5.283712554042437, -4.760250762245513, 0.5212532441528928, -5.972907667666768, -2.2037233651571735},
    {0.028064827267699658, -5.061217885504272, 2.3766223566763762, 2.4958899044239167, -4.55668592901397, -2.870730192701713, 1.4803081624935788, -4.58167353883228, -5.191333209397488, -4.262529875217276, 2.900476634839724, -2.643528679800273, -5.346854515978583, -5.135032172724919, -4.733026127691531, -1.246624171895724, -5.379590874809128, -4.842242675874823, -3.4661699007181075, -5.4150020722713235, 2.7456417927179273, 1.7112266816733357, 2.3886666925481075, 1.3393326936006, -4.472123751623082, -0.4905920328263116, -5.909268493675397, -5.737776667217743, -4.068309706657575, -0.3866184688112338, -5.847460862229944, -1.7119095792390617},
    {0.8861636832477171, -2.1096701911190956, 1.960957754727068, 2.4500786554140825, -2.792122106689723, -1.2055452120510626, 1.0063332927328008, -1.312471311303985, -1.884939678732728, -2.5950355802252294, 2.6251877150245835, -1.4003122270751511, -4.137977002421856, -3.1521754668575945, -3.8199984861962157, 2.5562713101909837, -3.3620139985630155, -4.112940922999071, -3.018424700288771, -0.8348363551092957, 2.365242692873009, 1.9426333851399407, 2.49456694575337, 1.3622516020020796, -3.2700764972994083, -1.4695136917457348, -3.0750270360086915, -4.0016308597848695, -3.3281230945129647, 2.6958533506150513, -3.8937571478946693, -1.0868044555744731},
    {0.9804448264828318, -2.357908704288724, 1.779782537435436, 1.424472811674841, -2.724123157501412, -1.213073337431937, 0.920320143268827, -2.223410708343021, -3.2632983890206373, -3.33198860995876, 2.2767613415901278, -1.8473608284299115, -4.1952013037096885, -2.5310789457751124, -3.4089426636361937, 2.4255452954675274, -3.436752499860383, -3.808689975936747, -1.2830264164608405, -1.5182641717235696, 2.9644818650238047, 0.8930605705252795, 2.251758154374513, 0.2845116697506603, -3.1341968820003916, -1.52428852313519, -2.7778826949326936, -3.5336762541264464, -2.756011273737706, 1.9676891875276914, -3.8244457690802904, -1.1375624048600987},
    {2.448410207577084, -0.9496087027517292, 2.3966710175707364, 2.7654167514109527, -1.3158431079410513, -0.5340677446352156, 1.8145640710647106, -1.046038854763694, -1.376457861866161, -0.5903238300144991, 2.18037412801746, -0.11885296098277857, -1.9294700917592404, 0.9639405829202683, -2.0315689274428017, 2.562244423551858, -3.2272993418806326, -0.0023578770618915244, -0.8559810927370577, -0.5540613762126889, 2.768363081832761, 2.5484207900487643, 1.2341668317038599, 1.9629728744239925, -2.542897016843123, 1.0737389751992623, -1.77007479978578, -0.9059447654095074, -2.0524835105745396, 2.489973258312549, -1.87502786072159, -0.42035847623151423},
    {2.980336092755428, -1.565127092233616, 2.743860262866991, 3.0422153004605628, -1.5203782462612205, -1.69283597092742, 1.0641255634691806, -0.6603495023191314, -2.1589754497198896, -2.322044778095417, 2.41408848385563, -0.27282421917816607, -1.6877557648813015, 1.0316505614799893, -2.051751317932825, 2.9401581339569574, -2.9777557211798267, -0.480902093151415, -0.4243904661388534, -0.016518477334501576, 2.766349232802728, 2.663751431857475, 2.473761555721554, 1.0371903301316163, -2.763433111132357, 1.3282117349362383, -0.643406067653959, -1.8496674707402943, -2.377839826736945, 1.7101435642483895, -2.6086366626982427, 0.025135648313191566},
    {3.023628132041467, -1.149970716751891, 0.9112411082299119, 2.520171247697628, -1.3855745793680205, 0.33841763538841335, 1.7784707055361426, -0.8020792708133535, -0.10889848477597948, -0.6917117626048205, 2.032385266767561, -1.0489561311094515, -2.160995152296769, -0.02436604498312656, -1.0902598652024005, 3.491284157960181, -1.5691486153705734, -2.1037492321553, -0.8561523910993026, 0.5101948621134761, 3.1063647168565076, 1.4250632100238776, 1.544537504282194, 1.4320986872520978, -1.2408281754336044, -0.08980963282972444, -0.7930765965757332, -2.290212615797591, -1.1908972771130637, 2.386796237876801, -1.6862621973291354, -0.1347494122284765},
    {0.7752200145124265, -1.2192170968971046, 0.8526253896946396, -0.011394616726108643, -0.13788530537159474, 0.8436657745413226, 1.764053202423605, -1.781670254932233, -0.7880877595515915, -0.6893404267419422, 1.194269290505757, 0.07431515524199617, -2.0443252936395018, -1.1622865328079248, -1.9141500026921545, 1.0591861710985808, -1.0574250552965259, -2.5806513054908513, -1.87523424347997, -1.6836208576971374, 2.230110610626554, 1.984181350195012, -0.2875322761470627, 1.5565898539223442, -0.08117204208573069, -0.41584889891003096, -0.8420937454538986, -1.1850292164556147, -0.02176285393064069, -1.8107924930249022, -0.6419117393773828, 0.9323022622137878},
    {0.27711276448259525, -2.837987284151679, 2.1111878298628457, 1.5458662953788063, -0.5984579200067623, 0.10848715652650172, 1.8888678516531427, -2.190443741870872, -1.908979288300171, -1.1763015311929208, 1.4601528268002395, -0.42651475829144075, -2.575684943267985, -1.6948451113276057, -2.954443344345414, 1.0835667907130206, -1.7451410415957331, -1.7628328294805884, -1.8613784646349796, -2.313283183148007, 2.508678416045475, 1.7664883888753842, 0.7023781078664403, 1.9115375447472434, -0.6185003051039796, 0.2258312341336875, -3.988143018559995, -1.8117364588878777, -0.7160853233743711, -0.7026647263277718, -2.1514938684924165, -0.11256890814772068},
    {1.1354480635314375, -1.4212601216901348, -0.7536953625913038, 1.4810608705420492, -0.25272372005950733, -1.6059819290834199, 0.33536794668044106, -0.7128332315283754, -0.06336530927946493, -0.4410534310307272, 1.5842101259251524, 0.20469416730861115, -2.481104647794746, -2.3049900303358455, -1.1219916887056802, 1.609791963144804, -0.7912228560615376, -1.263200865920727, 0.0060229859012312535, -1.7085780300312308, 1.8270720902650353, -0.3545211245308659, 0.8850164128901676, -0.5710643254038419, -0.5051106793565002, -1.2507151250375315, -2.1291750402623086, -1.4469104966297657, -1.3782903555231698, 0.062168171735869256, -0.8816460489598134, 0.2313540405840879},
    {-0.03307419195591786, -1.4378322115878275, 0.7004415550622879, -0.032523878583579226, -1.4163111963522357, -1.4870374334212249, -0.015287075320855915, 1.0919436541784837, -0.19773248258734577, -0.5937090311954186, 0.7985321029616452, -0.11223669624613274, -1.622628457834707, -1.201605211707101, -0.623873753701683, -0.9580456934413649, -2.3917938488748027, -0.22893546836189743, 0.34969429360704246, 0.6481155285361813, 1.6915798019066601, 0.19582105172174147, 1.3515575289900186, -1.1756068185382473, -1.924942957531143, 0.1623829723106352, -0.3532133731772332, -1.0338954187784457, -2.055194774423372, 2.184960106733936, -1.1003137465821327, -1.2626106515230446},
    {0.927353850757009, -0.028029919828713813, -0.39019273506901825, 1.0085205342900596, -1.3203404047939087, -1.2425167747269583, -0.30726959694919964, -0.4458179563129707, -0.8901875867669309, -0.42310470958889157, -0.09294425165197737, -0.3383590393836811, -1.5507688908455128, 0.8420307913525609, -0.737422277757329, 1.9373117448690187, -1.5965889255519723, 0.5935709522216271, -0.3593949592650305, 0.786910712772095, 1.298820900718168, -0.35874786202934333, 1.658968703180179, -0.8962788397236474, -1.3072161062500274, 0.5333168054870719, 1.0356723379214308, -0.5232661163773579, -1.1835200182721768, 2.289097057863078, -0.6163797375213589, -0.15318018799514455},
    {1.1308274320419827, -0.8259584182156038, 0.2922448606933549, -0.16731369621996756, -1.0521329902459151, -0.39037257893114613, 0.10664263224650143, -1.5771874484825315, -1.1418134113451213, -0.48632779518265595, 1.2706741094702416, 1.0404913531047162, -1.910553152424411, -1.0122330746852588, 0.32560401355077695, -2.5703219653773126, -0.11124958626460547, -1.612632069927938, -0.6908498565158637, -1.4057882087867697, 1.123626754624734, 0.08460657251966602, 2.127475704479627, -0.29901659312460394, -0.4067676872571517, -1.644403530619448, -1.7403411545407146, 0.14218139853088638, 0.6153138572198549, -2.1836652612690868, -1.8171563473100814, 1.2624768454748758},
    {0.7223220233079009, -0.8305930758267958, -0.5595872894114812, 1.002951669516149, -0.17562432322575064, 0.13085043062659363, 0.8927199426754695, -2.081944333452968, -1.4607851267150265, -0.05702329224346246, 0.8423790258617597, -0.1047205618841373, -1.1478962547543607, -0.9650970901906055, -0.12842166402399055, -1.1460740567917365, -1.661198379023944, -1.689947277619562, -1.7931051899041757, -0.8347805825030532, 1.129736462591221, -1.1035262919718807, -1.2953061592015047, 0.0906364181934922, -0.4416325275377188, 1.167897119056752, -1.4930388811591044, -0.9299780466569715, -0.08139198853871021, 0.30072479953135206, -0.6534565075938692, 0.3142647276271229},
    {1.5629047210533566, -0.3974631495038643, 1.8929560852725997, 0.020776500796244254, -0.3593486203056673, 0.1121194622991385, -0.36818401150558805, 0.8420095116719111, 0.1298818404696037, -0.9113617078492239, -0.21943774416320963, 0.22438177386512625, -0.45482083338449086, 0.7598176402145786, 0.5073182804803555, -0.5699439214769553, -1.112404390951551, -0.4540791995467895, -0.7432028247048059, 0.8726202724525602, 0.8894287948007014, -0.24453626606950138, 0.8232934097457482, 0.004396080210652536, 0.5498734688511595, 0.687250170547957, 0.4422848847015442, 0.3171032261438944, -0.1977512957870091, -0.3211847237711959, 0.08333175680295193, 0.14469319585005228},
    {1.089558214575542, -1.890688223168577, 1.2761683332842093, 0.49132198144375416, -1.2201172586627493, 0.014615651608195052, -0.79722133027153, -1.0687635065585728, -2.8159653714756927, -0.6428833738901863, 1.0270924523722726, 1.516939711391766, -1.0211870693033076, 0.739816716761087, 0.8303921516331076, -1.1027523921927946, -2.093544296404027, -1.1038554526838222, 0.12046724359799796, -2.1098479329960265, 0.7179911139572277, 0.14120827576468065, 0.15880912651422427, -0.19140901859914458, -1.7926505704098448, 0.45527892763282085, -1.3978344760925252, -1.2727116822868625, -1.0374580479821838, -0.9235509239410864, -2.7713338542375476, -0.2933429982225789},
    {1.835014195719369, 0.16859840570562845, -0.35387199478670905, 0.6608422934147065, -0.7231931682024272, 0.08126611429067916, -1.567898642303738, 0.3373210716457026, -1.8850262187526923, -0.9760617398719756, -1.3918057153602836, -0.8538992299774812, 0.6833258240721907, -1.4303566371843555, 0.7639342140444998, -3.5249375114970602, -0.3731337656376441, -1.239463045935492, -1.046588312330073, 0.30412096111328263, -0.45728730028428477, -2.442458079983776, -0.6725842958815479, -1.4680559043946073, 0.22871569404088876, 0.49376377809307653, 0.7723161162761023, -0.11754407021857204, -0.3343790815382142, -0.946123555413738, -2.3519183155773336, 0.15590475550523572},
    {0.9107499551742009, 0.962865716457856, -1.8814941916216532, -0.051440568254643, 0.7097238567303698, -1.7132737571628578, -0.15448794353142248, 2.145808332998479, 0.37339003841605717, -1.1667066192646371, -0.14149973733873034, -0.9304099858607104, 0.838718127809394, -0.08411458565120712, -1.3552015857262036, 0.2488083031059944, 0.09722392386314228, -0.2189433855989167, -0.3384090493198822, 0.6736385524975925, -0.8424069435907179, -2.6593842155551433, -0.9368064388539709, -2.094136240072956, 0.40461777692446255, 0.03295217794565892, 0.5603854571267032, 0.47004572173018, -0.44259578029494917, 1.2044339800903763, -0.31893416393061913, -0.990500263644959},
    {2.2823190724724203, 0.1360483816539643, -1.3819418744125684, -0.8519992246185034, 0.7119167658602473, 0.34429426028001964, -0.8780581837062795, 2.2296460320410283, 0.9697747235835974, -0.8766094483050482, 0.3604577097898804, -0.6415532604899294, -0.2408840190724135, -0.7053998051149678, 0.31359247891762415, 1.0846143648330298, -0.7892218674976905, -1.5574115902418286, 2.0694284628015533, 2.200409982247477, 0.1848067992456504, -0.7995873294772796, -2.1764264443076944, -1.157697398508959, 0.17312209509860432, -0.8472524182121542, 1.2643252203450528, -0.8216164901783668, 0.2492090491222344, 0.3259906483951553, 0.8594767926652517, -1.3850008708158827},
    {0.35336445534375865, -0.9456156664352524, -0.11385957391310284, -2.0755169983536073, 0.22584151042717912, -0.9465514952651591, -0.6405028639182976, 2.330859128665956, 1.3275244584755366, -1.044275966300591, -0.25939995305014363, -1.1009596439376301, 0.5722603260561346, -0.5718014925597295, -1.303132041277179, -0.5913907780545268, -0.5230962313303051, -0.6009336769833376, 0.6731239525611945, 2.423379962503704, 0.6040551230057591, -1.9982204357896765, -0.7591477886143749, -2.015707251731365, 0.5551478302379043, -1.599180993255941, 0.7073915136226782, -0.4414574226620567, -0.5150437316217515, 1.8661462424789519, 0.9128048906697561, -1.4201297000365467},
    {0.6110885197621396, 0.8614823589156102, -1.2859952514431945, -2.1743293586014167, 0.20506027295968698, -0.9406171776148802, -0.8288273054382921, 1.0194458109690814, 0.7023066712222039, -0.2938089836736259, 0.8389729767348223, -1.145042266344369, -0.0383880778552691, -0.45263877822445453, -1.7476811450586172, -0.37264543062412964, -0.10435436098543814, -0.13746044291187498, 1.1894570791383028, 1.2936648866879046, 0.13824439618157242, -2.355752133320821, -0.8012666312293872, -2.514517536393567, 0.002621909722644817, -0.9125853745301906, 0.7253468323504104, -1.5223579793771171, -0.5986326834131133, 1.8025337785197793, 0.4829267388853246, 0.8949237416339032},
    {2.4869728812559133, 0.8814696626726863, 0.43183545648370414, -0.5704237403842853, 1.0566616251261696, -0.5639586374983386, 0.3621548321733838, 2.286203265162179, 1.5940888384051095, -0.07033816731071976, 1.3501930571276972, -0.14532858916938884, 1.286172965943035, 1.5581035463830346, -0.23022521797594103, 0.6769095433867448, 0.6201646215965148, 0.7981238193817874, 2.741191293724918, 1.2008070494082317, 1.767285918585562, -0.09962776126003257, 0.17970195527019928, -0.8229196794427539, 0.442890368822412, 0.8964698228859209, 0.3202341781151792, -0.07189197499499526, -0.2927604493885056, 1.8916191870697348, 1.5067856361372953, 0.8298037885837213},
    {2.3670953448603256, 0.9370539587743903, -0.03895330617874718, 0.03549397425032537, -0.34372954673776657, 1.0928279389224547, 0.11596299597430014, 0.9437465748662642, 0.5649913092007011, 0.3370102406319681, 0.8181418537992268, 0.4377926071249939, -0.6540009202845554, -0.670218848496525, 0.4123549294730763, 1.9988061669905246, 0.02813384089524472, -0.6494347083529167, 0.4242218781835667, 0.73080678082276, 0.9228605691559066, 0.12104976904761422, 1.5454393828499626, -0.07259282885856963, 0.5930753410510328, 0.11774819914301697, 1.4457482615733113, 0.5424501279510733, 0.023459165184225625, -0.7582894930798602, -0.48186287359503455, 0.9734002536028398},
    {0.7478720620768473, 0.25725964309797383, 0.34838290866501603, -0.19462904006919987, 0.15884487545367976, 0.9713695230414676, -0.31039418200101343, 0.7617012505413938, -1.4764833552371874, 0.12868202251878785, -1.0509357943238116, -0.48804393305733323, -0.4225921818270364, -0.4578885762224799, 0.8453322387134106, -1.3167376377389879, -0.8012377893382251, -1.411626739061541, 0.9921027187006883, -0.08681371994523217, 0.33814000678093925, -0.2202028458996642, -0.5776123784711183, 0.11788484378232421, -0.9392996610838634, 0.3432631462835761, -0.4698427575805213, -0.6341043701976261, -0.5154530027624643, 0.2327130059397536, -1.0902234247733857, 0.6174191180177335},
    {-0.5526260818932569, 0.494047032252247, 0.665533910872767, -0.39864417119240214, 0.5964947606770656, 0.45897446000886427, 0.4418101870082224, 0.4925174911962633, -1.293085840531423, 0.2722070218099024, -0.24904590791111886, 0.8498753487099168, -1.035085363541464, -0.8133190466435474, -0.0019470919007329591, -3.0241612909693587, 1.155380691735842, -0.37915932145959635, -0.7081694944169863, -1.9157892464178667, -1.1982023651090856, -0.8048448696818371, -0.726267509976372, -0.12206022273662946, 1.0960180111001723, 0.5825393591379215, -1.2074321187758914, -1.6313639194120049, -0.15776406515740704, 0.02524094050616334, -0.7553590573853185, 0.6065383031100581},
    {2.7197673166011946, -0.011299318294934814, 1.1368870257263728, 1.0429764793171046, -0.24432785689497083, -0.2791989943709766, -1.2523998056383752, -1.3337832035282076, 0.6179971066311416, -0.09997009910579328, -0.9834952775040019, -0.2805563486009107, 1.129977077971262, 1.4092007687099661, -0.6971436764326596, 0.9731100413288676, -0.11105488510563806, 0.09992760987922246, 1.8144278422965152, 1.165668273874983, 0.2943058803304113, 0.18065761829552082, -0.09547873122435173, 0.15594432582970652, -0.08208237054552835, -0.48605879099858046, 1.9725457730283877, -0.052653532858060466, -0.17213315876166319, -1.7381376017666206, -1.2491297134057742, 0.7985383403685681},
    {1.256739601273982, -0.6332986781256221, 1.0429966177609793, 1.1465571119847238, -0.8578616579395995, -0.135649250231336, -0.6595649930428285, -1.5683846585491772, -1.545811404816639, -0.013190097719156225, 0.407949679269353, 1.753546399236782, -1.7277126135394099, -1.3030426856288733, -0.06949085660438689, -1.105304632350525, 0.055658704176828805, -1.1655327475729498, 0.5734490480972472, -0.6066786401526734, 1.257339347670693, 0.5450880908947425, 1.0549641107389245, -0.24190379882488938, 0.03885675748028598, 0.5319855899221443, -2.2299736814417637, 0.23178019172207823, 0.08289872586716517, 0.6413130062230139, -0.9705727005776218, 0.5018296440912718},
    {1.4777313120408626, 1.3790467662873542, 0.6846005739713743, 1.2154418681484116, 0.5159491429005292, 1.2096193033726548, 2.059882229428491, -0.5922055775279573, -0.02261597726500357, 0.819862009532094, 1.5263514917752916, 2.370226040438059, 1.4909903775746463, 0.5515379339348602, -1.0109820147854034, 0.9076142250926418, 0.6738596179353896, -0.47167261300268226, 0.5515099701552085, 1.1762069170150358, -0.6769493741574819, 1.0013954612143863, 1.26857256729826, 0.42326889290447633, 0.327390223483115, 1.9349450978651508, -0.6427521074576671, 1.234470315789472, 0.6682038158471112, 1.521363463799897, -0.8771671648975081, 0.5536004221256724},
    {1.7092533046535558, 1.3691908890083433, 1.1838889183214347, 3.0581094136414917, -0.009675356155850716, 0.4715808783804023, 1.1351085883812255, -0.4574768269055825, -0.42375911951983064, 0.7884560688321425, 1.9831844249350683, 1.9787485298322796, 0.8329781464060085, -0.36549318970394384, -0.17353919010731933, -2.166881858590958, -0.117169304891553, 1.2050460819845485, 2.389761083137185, -1.2982056664903219, 1.7076404053548426, 0.0863161299661773, 2.0619270875243396, 1.8587166459786457, 0.6708248692196584, 2.6063404988656114, -0.7113139527749078, 0.8646007026169702, 0.6473067195423158, -0.19632651644091326, -0.9861682132479137, 2.487051469185319},
    {0.820972350498469, 0.49755156615778356, 0.12685383024822322, 0.11552893723666759, 1.2675758296085298, 0.6444778577081823, 0.6542112564120747, -0.6476374747908125, -0.644613665562471, 1.1619058025075506, 0.9427210752984003, 0.6641834708344811, 0.1433446796273869, 0.896210854288265, 0.9385408015322709, -1.1782868222035185, 0.5586187856840434, 0.4328362600779973, 0.8217947639314609, -0.09245561295871568, 0.6022296293597534, 1.2824673272462799, 0.5929847278995324, 0.38391793178825606, 0.8483116092291543, 1.2248432414561086, -2.0553772856158803, -1.2003369651030973, 1.4576798081091586, -1.1299422818912248, 0.36277103126974675, 0.9186536573448373},
    {-0.14005244114010387, 0.9935537031733243, -0.1885645979853713, -1.0656315524102011, 0.9436412953717463, 0.3337480185402907, -0.18973632068497484, 0.05881768797370507, 1.0532645930363063, 0.7935648889574188, 0.11763864463070499, 1.0500219645486164, 0.5480031031520868, -0.8310828511459196, 0.629410457859321, 0.07852118974219371, 0.7677412314073083, 0.02058653620153552, -0.18669479685785423, 1.00964182668993, -0.32442217872877277, -0.7326420569076232, -0.36741508642431975, -0.7622642607842018, 0.7516923351077285, -0.27936110576210726, 0.5450096331830065, 0.7586929926635029, 0.12007068835720867, -0.0053211896552497005, 0.6220440242633839, 1.0534514248420381},
    {-0.9644323407097997, 0.09487437044139331, -0.10204615515511559, 0.042266452889577866, -0.12414166801884359, -0.7511664205243529, 0.16476505416213835, -0.44154733311280153, 0.340320178159079, -0.22810210486262203, -0.1970855119457137, -0.8740622963907847, -0.15370781158942873, 0.321710399391538, -1.201298810860569, 0.2810798992329329, -0.39314448645143446, -1.1974900819031709, 0.276006626991856, -0.6497212340175348, -0.8970044576315004, 0.006469908223387096, -1.103613711301425, -0.4181675621545122, 0.030935630525570922, 0.4059693482695356, 2.3548056166828575, -1.3886345124554926, -0.44689395560442374, -0.5879777339635949, 1.0651679303802335, 0.37277408608674256},
    {0.8519963095355795, 1.0297424164759954, 1.2097233215896266, 2.115786548086176, -0.5183909542474302, -0.34345945028127844, 0.2495349394874445, -1.09998911332237, -0.8843428576651542, -0.45616870732067927, 0.6257590045390966, 0.2800506331736936, -0.5015687512116082, 0.0771978464674595, -0.5932502248017888, -0.10035063855097719, -0.1653552614916502, 0.16386406362689357, 1.317821658496654, -0.8070357106967491, -1.0935296205359781, 0.6615749791844389, 1.5038651762370265, 0.5924433325407494, 0.41471818899984786, 0.7964988763275983, 1.3153376388530502, -0.10561326003647618, 0.07540308848994681, 0.8204720538514566, -0.5296972846008791, 1.092516318324173},
    {1.1388347040371012, 0.15341529630858455, 0.8828348769409818, 1.6281696797210083, 0.4024000435059192, 0.7217546367992062, 0.9806137457029405, -0.6577813747374, 0.29469144056973096, -0.2586693728657433, 0.5415008921239767, 0.20472928253613756, 0.7293908042185308, 1.0520299843002898, -0.00015839858735233446, -0.2134080467464357, 0.8413246709306407, 0.8670935530917486, -0.3196693775946626, -0.8639028545099027, -0.446341416614347, 0.6783339697477055, 1.12521992537919, 0.797736937643779, 0.47870935599084063, 0.6264387074759163, -0.5965370661606886, 1.5837966457492088, 0.4080822268095397, -0.5041166315011761, -0.016060489893663692, -0.3432106553736189},
    {0.4758951251911549, -1.12667727217382, 0.6857772962852557, -0.7485848382862255, -0.10469084644092079, 0.3211068877911383, 0.15251551465953878, 0.980957968787146, -0.2961581368189096, -0.7149472995305806, -0.8005533187927834, -0.9612487064579669, 1.0046675751719438, 0.6254011757756941, 0.525270228287694, -0.38473294240265304, 0.9375936606423755, 0.5577606472632155, 0.17461981299154933, -0.20498892185194856, 0.8309414405374913, 0.4503251964608157, -0.45460197635664246, -0.4954939283946727, 0.13669235289268164, -0.1409762684452016, -1.46243724489661, 0.838667980150686, -0.43054526336070137, -0.2863792506788178, 0.09334163592737467, -1.5679470205438886},
    {0.043686178941755534, -0.7324749510310598, 1.0112534739675203, -1.248670877704498, 0.32480624658000057, 0.6972387807049701, 0.7139097633276482, 0.6477996840907616, -0.4714216342972928, 0.7117974621469194, -1.0730261577730646, 0.664891143153457, 1.365343228644581, 1.076943548652605, 1.2266230653966275, 0.3991507480573441, 0.2393618235377404, 0.9126707499848009, 0.6548168531930855, 1.2041992516076627, 1.6670078668585138, 1.2216771681122254, -0.14402157555980288, 1.1348735061083908, -0.20129943988739285, 0.4433071587524072, -0.7372532965121046, 0.5918456611359911, -0.38217695334984203, -0.023791486902300686, 0.46986653591600697, -0.7659268217944686},
    {-0.05561680890160871, -0.6111475648031136, 0.6732988704096168, -0.21593867615899534, -0.39567106415062236, -0.0079712556294055, -0.005930123192372269, 0.974182993686909, -0.5732793087284695, 0.18645062137981677, -1.115615257997461, 0.6702582138844199, 0.49888738964705237, 0.5779758556500137, 1.5090313561643727, -0.445443648682557, -0.4558586170806212, 0.45135576144549744, 0.043320617756252164, 0.6802678921789501, 0.5775614132868923, 1.1152252363624433, 0.0405105612682291, 1.0865624638257976, -1.1176771367326241, -1.1004189898159047, -0.15803385089917915, 0.059798017383070695, -0.6856775305388613, -0.7637800286022091, 0.2033256133718307, 0.17703562177253057},
    {-0.14414561997031092, -0.9532491129556832, -0.7137572581181402, 0.40837459332487325, -0.9042327995958829, -1.0724295753380804, -1.09403400563725, -0.24596673887558865, -1.4551138190379158, -0.9777586346515218, -1.4136120133343952, -1.3800997455903228, -0.8896217710846195, -0.8555159600113976, -0.1316231765957988, 0.08293491332085066, -0.2511262625879224, -0.8542497092659395, -1.820008389039514, -1.446245299376424, -1.0274288203619255, -1.198852310780755, -0.1552854391982761, -0.5484726015354427, -1.057891808567569, -1.7623398922394828, -1.465815573594628, -0.06389170911401174, -0.7415685462246843, -2.1190208747757655, -0.9757387143085203, -0.07410709775358679},
    {0.309339457617062, -0.4600712821904444, 0.18451208045892922, 0.8142609643547802, 0.14633584585798703, 0.1293311570777933, -0.14069708054115354, -0.0780646934279555, -0.3186436154649629, 0.5161804383874183, 0.8429754990581128, 0.4285889495107099, 0.1074560427263501, -0.4129211670148367, -0.5486344296518325, 1.321797680408763, 0.6068947050859691, 0.14151638800780583, 0.06292192878487192, 0.39598244050876685, -0.23198322015338765, 0.37888682682977864, 0.5634179402704785, -0.32478595042794367, -0.00595134783404439, 0.28596320677966314, -0.9240512943877836, 1.4196936597453096, 0.6260260677274095, 0.3470064231115284, -0.8987887486604769, 0.18026677607180885},
    {0.9738020800765789, 0.17874599806735889, -0.7141301446634162, 1.0386212355686526, -0.276869404264758, -0.40381438428230326, 0.8748722321491831, -0.4982931406836873, -0.14483428459506187, -0.39116702703832684, 1.236237796198588, 0.8474472432117858, -1.0048823498288304, 0.4977722070327943, -0.8894726614963663, 0.8988463114088693, -0.1824503048304899, -0.5979684338379573, 0.5934995003715623, 0.8345507897978333, 0.27011706814764336, 0.5371903567883498, 0.34178015578969556, -0.7822649652826755, 0.2964299885180172, 0.7712097644085674, -0.056887932824193674, 0.39137103587395916, -0.2402306074636944, 1.1568853342406547, 0.29407129679683347, 0.10372945678732641},
    {0.6166550390835945, -0.6443631218207474, 0.43638065559479217, -1.1040441996134736, -0.7888822773328007, -0.6286784454592709, -0.08771588310378706, 1.1536740955358593, -0.3666856839018184, -0.5040280180526074, -0.7325295931284841, -0.47185899453126307, -0.9902700365867184, 0.8678683520616943, -1.3900216795408937, 0.29797999487608795, 0.006182629000765907, -1.3036865561039632, -0.14765699523592749, -0.0613922810060366, 1.7272946012676174, 0.6165651219998053, 0.2648261700325314, -1.3114001630455965, -1.0089299323472332, -0.9291163749236303, -1.1119903425062354, -0.9522293391914293, -0.34911950850853757, 0.7378253724282164, 0.6194377060145849, -0.09892384731862729},
    {-0.04337830748095688, -0.4179454597244156, 1.0319146722834902, -0.8046706800932396, -0.20524541241437497, -0.48272824740220516, 0.24241031824567014, 0.7780960446218415, 0.29076162291988, -0.5484171666813743, -1.8805738966073364, -0.869132429702447, -0.05575314532711415, 1.0845179350525367, -1.3459469275713751, 0.014938690865809961, -0.19691377443375316, 1.18454939199196, -0.6387885551638602, 0.2033524793729505, 0.9233277027233124, -0.009998671575318821, 0.3835396601882964, 0.6832560402993935, -0.6698610788512659, -0.5554496329837344, -0.7299785429781618, -0.6659874525661776, 0.09361274899136639, 0.6100673433952984, -0.23934469140639758, 0.113392346030475},
    {-0.16953838925547107, -0.07247204716222526, -0.6528225596194054, -0.3721235887024851, 0.6795204713868084, 0.18683958243650703, 0.2617227367975008, -0.3844799803514903, 0.3707570055178433, -0.07719796271549094, -0.652535991289907, -0.2690331175795393, -0.5504200866629679, 1.1982125484327664, -0.26431796479771635, 0.9196711655118442, -0.6154822587617504, 1.151384712123596, -0.38995377612418414, 0.4161078166140999, -0.9253992690141846, -0.4656818561493393, -0.7725656819577308, 1.3645953307386278, 0.28297406665475344, 1.1633485084431476, 0.06970868727601866, -0.3133540971089209, 0.36636747570639583, 0.05371771251254364, 0.4926956466592057, 0.13210749786011983},
    {0.7068449009067788, -0.10516399709296292, -0.5460988156763511, 0.3526070515236084, 0.11809284864627151, 0.10117927158479034, 0.3379046505635619, -1.2336580329446984, 0.43335415957980483, 0.36615429764738866, 1.4845251826203691, 0.8035775449004083, 0.020147617623245895, 0.9109756043509173, 1.819765631914083, 1.3610487172206578, -0.6058739271341549, -0.3941948480992602, 0.4099259856509624, 0.923208242159071, -0.11862015757256737, 0.5182513507587581, -0.7453628924903457, 1.3404399882124283, -0.03673551952144154, 0.8641836524650988, 0.47012110019480263, 0.27754448718476565, 0.4118287072826454, 0.8544495827448058, 0.4164550960353453, 0.06189367073714362},
    {-0.8311660774767059, 0.4866778209523268, -0.7641132282033734, -1.0134483418316227, 0.6333557679254144, -0.5857659692755953, -0.7090375188898823, 0.5350720027253978, -0.008182519045574068, 0.7793827949820759, 0.9139907921748646, -0.656381050967743, 0.9044420709727754, -0.9307278838453823, 0.78499140507276, -1.5536839250343224, -0.07114772753714792, -1.1617362170791248, -0.1948882430716871, 0.09193121167815495, -0.5623109686910035, -1.3764953533158837, 0.13501075582882618, -1.391607167648963, 0.23260543234736136, -0.6573301219151675, 0.09495293265240898, -0.23799623986828977, 0.4799033268078336, 0.451168188006514, -0.18010595854066022, 0.5924494137012238},
    {0.36751290667790804, 0.06465931645858983, 0.7654394639778039, -0.72800927262534, 0.882656089297769, -0.015684739565938362, -0.563666616040197, 1.3994302867991892, 0.7711707408066255, 0.18066895818916687, -0.20057580583239226, -0.5809456096945056, 1.3068153097293185, -0.661387624133439, 0.21458489023352673, -0.6413616022818094, 0.719775437622917, -0.5488173845372346, 0.3828639208081642, 1.0909620634279718, 0.2695081758699458, -1.4769478305457442, 1.0769531696907653, -1.2966781278951236, 0.2295981820179672, 0.25648016686441183, 0.5673627794704063, 1.2139385601293298, 0.31601725340172365, 0.5373497631762234, 0.283623221617727, -0.6663268179411513},
    {-1.1820141580027126, 0.6337704445472261, 0.4273376968599859, -0.43825724692464724, 0.34634322660731043, 0.7152383746605684, -0.7968158228018225, 0.07681911015283077, 0.8685167157846282, 0.4961139979913606, -0.427016199440973, 0.3253463517561047, 1.428231373732141, 0.3600936495629441, 0.9069146710608359, 0.5002261043439383, -0.010688438003440187, 1.4550758110664586, -0.44320890749778435, 0.5398498668142655, -1.1460012202756193, 0.25009630155395185, 0.7546384756927883, -0.2401085468810612, -0.34018111660221045, 0.19407582576440388, 0.29578668725837914, 0.9174259354025991, 0.2362907165216812, 0.1270574735120596, 0.8950041193298591, 0.08498274028551511},
    {-0.3826014214833415, 0.5728943929692217, 0.7682550802885988, 0.5218527716670925, -0.5843425816243237, 0.21300219961875566, 0.3230743879753088, -0.7210170844220269, -0.0186874840052282, 0.23001424783718288, 1.0892519953636064, 0.2731373692878165, -0.45899491933186376, -1.3006369274460758, -0.14143374272429063, -0.6893730272369135, 0.07793428223713414, -0.42887823945051695, -0.7587924855624738, -1.1728650274339798, 1.0021967653625623, 1.0148145636398822, -0.48764838870653776, 0.57886976022228, -0.6069012627385829, 0.3642059620842859, 0.2737378783002663, -0.7976791235480497, 0.18816962898689202, 0.2595050021199047, -0.5607687661653331, -0.3772347771933591},
    {0.3101589134412211, 0.29794001291549105, -0.06515780627638872, 0.2152112719515151, -0.7879655484121483, 0.3664383362360293, 0.9251600475701122, -0.09069600069682576, -0.1818998161349875, 0.5206738223648125, 0.4937315915919058, 1.104774452642743, -0.4280756035855876, -0.8282650060859029, 0.2526938150613222, -0.6181027486757494, -0.6238358494835872, -0.07282054542921126, -0.35994764785355315, 0.2940266899023885, 1.3455261994337973, -0.39144881856943736, 0.23862361951052818, 0.05683613080737867, 0.08465419430469041, 0.8206295288740646, 0.3459831063483149, -0.5002059908191375, -0.11578944569533113, 0.12185505887197734, -0.37698970567030077, 0.01665123591652032},
    {0.35313494223548536, -1.0412679686333253, -0.04767055735051969, -0.706527649786811, -0.5588026979289388, -0.9383143000706575, -0.8254240043849592, -0.9819439604381928, -1.4227194495968787, -1.1919629702069372, 0.7725870321807121, 0.12303444628148477, -0.8621014829868368, -0.6956474163736964, -0.5465982893636211, -1.453774327607351, -1.2895106477246536, -0.8644088792235912, 0.0767049379768372, -1.0632168638937514, -0.9412309175162086, 0.3601366220345463, 0.5436011782689744, -0.189036254965207, -1.098581672800381, -1.1752461193743833, -0.6476027847417405, -0.7949440076435282, -0.6232276700731673, -0.2296782668873254, -0.039794862777242895, -0.24117896142687723},
    {-1.0923670020771787, 0.07719253139410136, -0.933135954872276, -0.3159666052191308, 0.0006390744671900667, -1.1958647608102726, -0.553033338832946, -1.1754759731987539, -1.1793891184880543, -0.4857944806816786, -0.7395209352123162, -0.003294470770574893, -0.6878843906230575, 0.8365305964751444, -0.4007726938626284, -0.8838794503614149, -0.7949890616290525, 0.5776169189010684, 0.05308142054011617, -0.5944930140962654, -1.732002861293964, 0.35904881272524675, -0.27862835873304825, -0.23274754364528294, -0.2870684361035813, -1.1964871505203056, -0.5221934734765794, -0.18948480243604338, -0.9181960136429765, 0.11299209922484332, -0.3494319344735427, -0.6844317551959317},
    {-1.3323849268515149, -0.5215310053880523, -0.70886747416009, -1.1729676297295386, 0.24352856464657052, -0.3956423701193333, 0.1931659222741613, 0.4715087664580563, -0.13936551479969378, 0.03841223612629969, 0.3941936480652591, -0.031792687495773506, 0.08209500479121869, 0.02186231124311876, -0.7669949216193456, -1.3892918153106515, 0.006396536201266993, 1.3312802585661438, 0.2536293159316394, 0.5656274403566703, -0.47917177844892017, -0.7453554226782537, -0.5627567623952574, -0.5576853154004714, 0.018391883870141894, -1.0589300716299719, 0.18261521207445586, 0.5923304872189816, -0.7303439679421461, 1.160318636007054, 0.13898699804096795, -0.39079093819628197},
    {0.03597184181961174, 0.34201758146696826, -0.5130078631767951, 0.5647792034482729, 0.09368424247332743, -0.29594942208588465, 1.0329233483871456, 0.2054683896744333, -0.08608799146187998, 0.18519330911085213, 0.2271049796717031, 0.25896510704149694, 0.8953973690480203, 0.45096433088255744, -0.3091744523995383, 0.7317612233077019, 1.1710384002252552, 0.316208148546663, 0.6318080484683326, 0.28572127809927905, 0.4516643287506941, 0.10435151003201104, 0.4798305450891694, 1.2621841722758458, 0.6895135574373414, -0.3678119548110604, -0.9870261768543038, 0.3987133552086459, -0.047651881961927635, 0.988001724997315, -0.5033378110864017, 0.09629393738398459},
    {-0.11028087490305633, -0.4357895762252901, 0.9554452520794748, 0.07433267453677546, -0.016826249670843233, -0.6878059677564332, -0.8239336133576215, -0.5806130304682191, 0.5179211794948991, -0.60460922547348, -0.09963584740185755, 0.28993503168104345, 0.6015860407772644, 0.020743378472336694, 0.1269296909981426, 0.6032052934815775, 0.701301486299327, 0.48947997325237774, 0.530466451226445, -0.316557982310865, 0.11020356381398337, 0.6749953185857008, -0.2737401714549664, 1.0541773763357576, 0.6494314442920799, 0.34987570081489244, -0.04277939161362762, -0.6024343087293158, -0.4687650527081745, -0.006437990853495947, -0.06633280131957384, -0.23612064418466958},
    {0.8391627883668438, -0.20999240227058416, 1.7671975364388197, -0.08062010763327704, -0.6856522062038957, 0.6057350470883592, -0.3484889716836272, -0.6334709702261394, 0.5138570360559984, -0.06910539637687409, -0.7457678048430981, -0.015474770145531669, -1.101909001848343, 0.03633912087254081, -0.38537385042853584, -1.3692025712457705, 0.07821236783476394, 0.3807986903120583, -0.4347645188243084, -0.22768815693054525, 0.4446923645733856, -0.45162080854786, -0.0017458926833196636, -0.6119799981773094, -0.35338784082368396, 0.5908562980069397, -1.4494968009045703, -0.43841290065265126, -0.2185533207645274, -0.17381270525016077, -0.6891679993644172, -0.5725660172937862},
    {0.4549609500431322, -0.6193757060281817, 0.9602727429157311, 0.6170449218271611, -0.7534699974228374, -0.8173430629931526, 0.01875605507849814, 0.7098509594540194, -0.268969840178064, -0.6548983496598831, -0.4130753069335054, -0.5694365605429071, -1.2739782443008623, 0.26118568229329314, -0.8428409852113838, 1.425140482028025, 0.08221614352972757, -0.7976195661097387, 0.3775869643922992, -0.3796118791686325, 1.450638887703569, -0.30720143816707307, 1.7788138458560858, 0.11985550259238736, 0.028653695367734693, 0.3361823285475571, 0.34953576574229234, 0.37038891234077503, -0.9242160437904784, 1.0779864542232651, -1.2417003856548332, 0.43632943940503705},
    {-0.24909311109999896, -0.4713457474307948, 0.07621063994027558, 0.4409016107841083, -0.5944962371773191, -0.07938220468919235, -0.2924625139188411, -0.042637845707065525, -1.2918963638661558, -1.2192054849138378, 0.11019621933720439, -0.2706388198505061, -0.5566560656103352, -0.01606440081594154, -1.444446596929428, 0.8658622241790918, -1.959450855908442, -0.1550924911170502, -0.19975789139968364, -0.21696534612599458, -0.6425998089851132, 0.23498337997339114, -0.023710426995553993, -0.021962857723502788, -0.959148578070121, -0.055786605645829185, 0.11726836076494106, -0.5018241145257566, -1.3392142756119025, 0.5165275871308688, -1.2031971084431217, -1.1895826084495533},
    {-0.008621097150643891, 0.10408549925148955, -0.46227177786441326, 0.17620718906642868, 0.17775366706634782, 0.5518233407658095, 0.6769150231448767, -0.8065954695712382, -0.8460849520850092, 0.7835337835765549, 0.05341734231149073, 1.224038920119081, -0.2596595107797046, -0.1504978722217948, 1.0488850185182261, 0.14369694216786486, -0.3141884221013759, 0.6778451383515006, -0.14742508625574882, 0.2558483386961952, 0.028265992249553715, 0.11463042556183707, -0.1992086614456386, 0.8145947146464838, 0.10908961337337146, 1.096750889416583, 0.3718279384998529, -0.11484262208877925, 0.36852236407701, 0.5117284614417509, 1.0643359745142835, 0.3495125068468457},
    {-1.0029314323035095, -1.067947288505893, -0.2905387434089242, 0.3101135505325825, -0.7457657310596681, -1.1094638689840166, -0.4203063110603948, -0.012196356517644556, -1.1607812944798057, -0.712390325983414, -0.39854785943914434, -0.013073782106542479, -0.6302310266601782, -0.907724392227881, -0.6292348012895679, -0.7802355445850319, -0.453707542247708, -1.1130195544873047, -0.4588154258694527, 0.677521701271087, 0.20145273446305575, -0.6546811267362311, -0.8427718048948615, -0.49175794895904346, -0.8738531456930847, 0.037772960340940076, -0.8760880669695976, -1.040786624633782, -0.28303694333632917, -0.006708036343464477, -0.26437336402206163, 0.1469132083198408},
    {0.8100666053114265, -0.1521942531228455, -0.2604832469761572, -0.27451714557771767, -0.0305333004913379, 0.7758362489331568, 0.7926310336641348, 0.2159826704615145, 0.8821132063794686, 0.024121806557521146, -0.6192762322487032, 0.8773625421112173, -0.22416185927162507, 0.3026209737142689, 0.6430966904712342, 0.2738271784909537, -0.04556003119152895, -0.6309064876502385, -0.8498066904760303, 0.5658364828212805, 0.12427267637056545, 1.2798538594750826, 0.4872442723891357, 0.5322590954130696, 0.34996579837934516, -0.2512199032784591, -0.05081524838198961, -0.1140179714008466, -0.1819500597357867, -0.9446742669068413, -0.46003084934720945, -0.19581052246636765},
    {0.6485084556051617, -3.3015117123294413, 2.8729942111203393, 3.411429819429973, -4.166922549694492, -1.5825896641766424, 1.7296596489677611, -4.429964915358981, -4.369588353842535, -2.5563966421537225, 2.008780534486298, -1.3962471686620197, -4.484008822371434, -1.2113692249319095, -3.5737891236299157, 0.7951127492529786, -4.454445472616544, -1.675766599193446, -2.1056052884910743, -4.6507111631115565, 2.7434116875183068, 2.667979376867954, 2.820028155738499, 2.162329041912094, -3.8229840232427503, 0.8552939016533627, -4.998626802446731, -3.056426516241029, -3.592239029396357, 0.9709572163181902, -5.2431518109171, -1.3096014799661655},
    {0.28900539717479856, -4.151006503258466, 2.7177065241361382, 3.6285652711465843, -4.27161330997016, -2.4432052729807703, 1.7941460051480806, -4.6551700831044, -4.877930280233506, -3.3515233274147773, 2.463828921979539, -1.39584824718321, -4.668350215349261, -3.8563279168762152, -3.36032080185118, -2.387403777436748, -4.456098707611471, -3.695812214539637, -1.9307292860163503, -5.012269537982694, 2.8983221883773935, 2.675166516795071, 3.000377262899553, 2.020199991020194, -3.833606194881459, 0.6479678369935641, -5.780748632245253, -4.681669075578318, -3.112727028163226, -0.4505656398108532, -5.900356317214126, -0.9445402305199124},
    {0.6365769376156902, -2.1498029141242982, 2.119916114724174, 2.552623513563327, -2.7800168355505623, -0.8041462669038314, 0.737541899728237, -1.2365795165563958, -1.6049442041194684, -1.4765579156161512, 1.9117381890454497, -0.7780284059497584, -3.5539237000594732, -2.192225326810216, -2.767457029787511, 1.817487030217609, -3.0079102173430354, -3.001739395536842, -2.98903504476515, -0.6549099152695788, 1.7983060125247678, 2.3095338223515385, 1.8938049579429235, 0.9823709166724797, -2.873713758254966, -1.115327687914709, -2.742756573818208, -3.2991654635796737, -3.1426588417630046, 2.2894609391960445, -3.756121179630472, -1.388446780619828},
    {1.7154780915914276, -2.0868191541379333, 1.4598934094681608, 1.2251777089061415, -2.5118221718651372, -0.7158777419044072, 0.7101543669418104, -1.4881270278705074, -2.970659363936343, -2.696346387861308, 1.6423187431738075, -1.244058462392038, -3.517584572568444, -0.5862837044898896, -2.578550583585314, 2.023331554394907, -3.1180653860363496, -2.5646227622598063, -0.8903982652185457, -1.5444899336839908, 2.7797795420195404, 1.3029386351253325, 2.2658242374789896, 0.49269948784470013, -2.5686177419408995, -0.7267052525858063, -2.1243401678502436, -2.1205435672964197, -2.2959737638078157, 2.5125633470908184, -3.0361196046808265, -1.114075458221611},
    {1.8085479705353464, -1.3733430767954005, 1.2383200678818875, 1.5948584748684909, -1.429480697274648, -0.2816400449467652, 1.3769111538695056, -1.3488083389447696, -1.6477707174690401, -0.7619225004830481, 1.8725965791804124, -0.35215240584982327, -2.8063361638778015, -0.08515976661018805, -1.37388600104814, 1.268619305507387, -2.729248686208436, -1.4189673231137345, -1.311770547000604, -1.6351938791760812, 1.7122415095534391, 1.4133416549098692, 0.811662118940841, 1.0708915870031628, -2.077180057905446, -0.19919606633420095, -1.5006004911642714, -1.4221306106444933, -1.8718262924524587, 2.345311826131444, -1.8668288406408913, -0.9104685527623521},
    {2.413504204095443, -1.9677138410523123, 2.679821393858778, 2.759571894402067, -1.107277521997694, -0.9348625963937057, 1.0135293392787146, -1.0464029573793432, -2.4981542326505504, -2.0575232583953382, 1.7230962678933286, -0.21389066130334644, -1.7306521500556582, 0.3893316193050772, -1.2178445876688748, 2.178598107914237, -2.550741030413412, -1.581957295671472, -0.3709924809418696, -1.2023557780483014, 2.1790901095777957, 2.5263085412963244, 2.3253981914521136, 1.0764592382708305, -2.233897515057424, 0.8264966314979338, -1.6704977486456682, -1.8511811765252797, -2.166977384407775, 1.5030559882691654, -2.677597551189158, -0.04021009647760262},
    {2.4909934656445634, -0.4109319297110946, 0.7767575252495398, 2.4034114990017663, -0.25344986237446737, 1.4425961736834327, 2.367416424682246, -1.251462323845334, 0.2677848248101791, 0.2816492272853314, 2.0784659011710587, -0.532240097763477, -1.6517399884077282, -1.4165334815374608, 0.292715033256912, 2.1883514405597797, -0.6536045071918557, -2.4803105923286184, -0.7623568230627696, -0.38983881486443883, 2.051518574619751, 1.1528693252628932, 1.6289533457926744, 2.017043702487998, -0.08457733667155849, -0.4198815392361001, -1.318147596165744, -2.151712861043661, 0.25609782412673465, 0.9328538321788803, -1.6151167731354985, 0.5869872492021739},
    {0.2279851638672683, -1.0634825810967723, 1.4987998318138849, -0.024499139901852384, -0.3149683572419454, 1.0866580946311766, 1.369855637918975, -1.1664865737935446, -0.8813069570615839, -0.9403020462176538, 0.4330576928825472, -0.46414522880586484, -2.1662413721480167, -1.0607843759626687, -1.154514360599075, -0.19471483278842763, -1.4550724443211427, -2.4938039051202905, -1.85442994149559, -1.961486288396798, 1.8591417907227632, 1.5258229381507347, 0.08291249579664912, 1.4595213322531422, -0.17345188847092904, -0.9516078814401129, -1.7155357025011644, -1.1697195352364094, -0.3687443971767516, -1.6664169305518763, -1.275819616797452, 0.3426406310885404},
    {0.5921050272813719, -2.3637279048819586, 1.8523232853254203, 1.5232822047780166, 0.26345707105718374, 0.8078117663623491, 1.6352093286647238, -1.6687356456056668, -1.2346531089363653, -0.7238459828885998, 2.017223875523657, 0.0942228253638843, -1.8102394122453012, -1.312605105017254, -2.2075038068793535, 0.41965989614141, -1.235454616181536, -1.7620342222854615, -0.8548167087743566, -1.814600818731482, 1.9534653182895791, 2.2029061543000075, 1.5960213314925604, 2.3822719461371125, 0.024162080188918536, 0.5253205368485561, -4.363841790223151, -1.2493962586370677, 0.2653123779115615, -0.20332240961145717, -2.2643887616970626, 0.36925669709773984},
    {1.3875734925846397, -0.962288826540808, -1.0653660174303954, 1.4576202765059112, -0.005595980371284007, -1.2386344838719492, 0.45864664564797625, 0.23131421909938465, 0.3850654004822945, -0.06039233873413187, 1.2363517375957047, -0.17853787939912, -2.2942757806470295, -2.0794638428341186, -0.7617417641731636, 1.5121869887031654, -0.9549852993695747, -1.5099384484173184, 1.1082219997447376, -1.222467953482219, 2.5638753208768725, -0.0407113360434309, 1.1810984017395605, -0.5531864601150793, -0.28927030380920893, -1.5317467882818074, -1.1599666845310486, -1.0441440982137422, -0.9348281708015105, 0.9259974212390439, -1.2191197324252443, 0.3100598820292776},
    {0.010240529834332879, -1.7045082095781618, 1.1493861290567788, 0.6230906212168814, -1.6762305877962993, -1.8142281663407342, -0.4994872191361257, 0.9069515078429892, -0.07049169457407044, -0.13478964965749252, 0.8658857152112572, 0.5301406434754606, -1.5892305127761688, 0.38310800215038615, -0.4097714358788557, -0.42390269210413883, -2.215613719754451, 0.49720681892043406, 0.9409909806703193, 0.4901519173148277, 1.893840983440082, 0.39971251963018484, 1.7562713980902696, -0.864086154559355, -1.878755420261383, 0.6849735808188409, -0.5596638684555469, -1.148840842307259, -1.9820363473678166, 2.2795823992300197, -2.034476607530259, -1.2711383102978104},
    {1.1990376954828459, -0.07508975484851174, 0.9476749864705732, 1.741955970962124, -1.1007641709308595, -0.8537151187077486, 0.01781202899760987, -0.6995995644406342, -0.5669317744445277, -0.031136920872539785, 0.2066980106173761, -0.058184030471973465, -1.1964411827763002, 1.1368247687468085, -0.5749342117170926, 2.357407896671166, -1.089958970851212, 1.0620046982041307, -0.46587763151638983, 0.671248917265525, 1.5049183117750664, 0.43090036139788734, 2.317105337358328, 0.4599776012432992, -0.9336938925662178, 1.3731311440884755, 1.2199230734536488, -0.5542497213047831, -1.4105045669707597, 2.111590613972237, -0.6408780750160811, 0.047939787219134423},
    {2.008594607293189, -0.5214144728137474, 1.295325193462642, 1.2081697050662579, -0.9950669838987977, -0.3883108725282076, 0.7945021683115743, -0.9279676177270443, -1.2459729841149254, -0.3415355559476148, 1.974704027232584, 1.4320865700093623, -1.3719639960250112, -0.2730596588880205, 0.625353110911509, -2.404841444922379, -0.7389765502067275, -1.2212557154928148, 0.6602901976694001, -1.1134811047080984, 1.5112289307967932, 0.9224875070221717, 2.40270608641469, -0.01549896306569114, -0.03230165262139424, -1.0122181531590446, -1.1463069336714795, 0.5271024647182941, 0.9556666036058664, -0.6779971409530064, -1.8618097526159063, 1.5552632269440327},
    {0.2903549694237118, -1.4803342777201656, -0.4470219901827152, 0.8430216719829524, -0.8560115862437147, -0.20134462951993046, 0.6796677953128636, -1.9187618323512015, -1.7497208716367951, -0.46921650328274206, 0.7845838286242636, -0.791200338703094, -1.1187623845241639, -1.5269801584652447, -0.7120158759890823, -0.6566101291203859, -1.8687259356029329, -1.6711765519848043, -1.679514330477657, -0.9314849087207316, 0.9188423238896516, -1.3671324731620405, -1.459943220669477, 0.32139547410241814, -0.8109975811959454, 0.15996003473705273, -1.9909797083585072, -1.3898008615731432, -0.4531464340035364, 0.42538386360601615, -0.7993084658243192, -0.5825653998012045},
    {-0.02771706760727953, -1.488164523464548, 1.1903732696363283, -0.45712371842624333, -0.20415970876548886, -0.37937139513506035, -0.9287485566984357, -0.042717478379543435, -0.2810106866408243, -0.853207173314973, -0.8278280281562097, -0.14654304269247034, -0.6561613681802946, 0.37502784028986286, 0.1824628392105699, -0.7169303549544843, -1.3233825113225812, -1.016627847455249, -1.2439525241261888, 0.4192356774958931, 0.37412771309791204, -0.05721900681688941, 0.8385942245396638, 0.5580985971786597, 0.24030658680401795, 0.09680512103861959, -0.46023468775206455, -0.16574536321786834, -0.8708184871044516, -0.41920673426147675, -0.07557150704968249, -0.6960010334514566},
    {0.54259154736902, -1.235850348438386, 1.8367782959969994, 1.2912988644547296, -0.3203204084786007, 1.0152122571371363, 0.3609884817379074, -0.375505376331924, -2.596540838927868, -0.04287927222072572, 1.7311456745115197, 1.9635593222330188, -0.5011930973934565, 0.3744870681091959, 1.3947595095098633, -1.4205707184681542, -1.1667215769616164, -1.2542550617938037, 0.6427959398344649, -2.339730030902432, 0.9130209249010444, 1.006588731531902, 1.0699887036760098, 1.072117939483443, -0.43436019073411475, 0.9871107748944474, -1.9932521350909973, -1.369137668676253, 0.09467560502936694, -0.07112402466378923, -2.247247638845314, 0.6926595975647575},
    {2.015324124801582, -1.0254981246216237, 1.6632530918988189, 1.8167217779940033, -1.9114672208797383, -0.25762197960559297, -1.283871750910675, 0.03247516358536871, -2.5707692585039323, -1.573304338921455, -1.216063757253528, -1.2611245415657435, 0.006808978042201489, -0.8556652699644698, 0.08231553016290984, -3.2286519982021047, -1.3117547474076636, -1.1279135433103373, -1.527436536271421, -0.4602661275371932, 0.685206169527739, -1.1464188713987844, 0.5939121984755282, -0.7866356348056939, -0.8143231029759754, 0.7493361228525504, 0.1964536120464385, -0.33205608078997434, -1.6076823556244837, -0.797412691214798, -3.0159539535815973, -0.47240377050176413},
    {-0.2960503733598113, 0.2571775906000774, -1.6248439334051057, 0.9778465964677607, -0.24963114049904922, -1.901150538596793, 0.2820848321330229, 0.8365409954892091, -0.4846988388658574, -1.4324283019270705, 0.0052632814131599644, -1.0337189667936513, 0.12590674171584687, -0.4564766890054393, -1.3207279372577112, -0.6344561864119109, -0.0696315325367549, -0.4267001236243756, -1.0195340899585652, -0.46082438864617187, -1.1701039420599986, -1.3259098624118362, -0.22888493267980625, -1.5968053689776238, -0.3235007131925886, 0.38218644021630704, -0.7232483206215857, 0.16381245385961363, -1.0165305167268126, 1.5278198020540776, -1.2108383514305547, -1.6496026723358446},
    {2.2987933603980197, -0.30767312764234245, -0.7312133784965245, 0.2852246386616035, -0.014420825015517351, -0.19648952527052924, 0.1198189752500174, 1.2853414595681905, 0.18845209987990208, -0.889254323455099, 1.0921786971777818, -0.7340225857487481, -1.4198797449545393, -0.6024108070224027, 0.3078441876879609, 0.48193216683587226, -0.9260571401362508, -1.9466426561537615, 1.7873041297319676, 1.4926698525328586, 1.1635645197858453, 0.11377442203180153, -1.316470536444765, -0.0008689874474294316, -0.6199594800983781, -0.4405049348555838, 0.2895182220964346, -0.5087333999041082, -0.38279891703331337, 0.1026512638560838, -0.4736957218893735, -1.2610502290491166},
    {1.1219060141623582, -2.290413369918823, 0.3614852104332583, -0.632011088654143, -1.0341638382507887, -2.3062281563402403, -0.9052250514948883, 0.840874164861974, 0.4358518017730849, -1.45878232983604, 0.2612911976056729, -1.882061596270838, -0.9317462353628949, -0.5301480534854162, -2.1204162765454857, -1.2090234335883256, -0.9338776889019028, -0.6696703234762731, 0.13963296499626154, 1.492695485283915, 1.22517786486679, -1.3484866781240301, 0.18721484049743148, -2.2844758880040725, -0.7134425319989774, -1.11624109103078, -0.9731518242886126, -1.1808573074540745, -1.9852183633210434, 2.0527110452681145, -0.551302605395295, -2.4357241920015715},
    {0.8305734237922842, 0.12597923279259074, -1.3592880604170992, -1.4594950414077261, -1.1028555250631107, -1.734050429839566, -0.31976907782416875, -0.2479943308031843, 0.1275478044941785, -1.6719797862687495, 1.3539509816354691, -1.1329275409195625, -0.5966047774218114, -0.0517275776533795, -2.3731850124625633, -0.5309197017691916, -1.029850392933353, -0.6072099719222208, 1.2520376162570386, 1.176363526160554, -0.39121330025382695, -1.4784884935833584, -0.8129133619051861, -2.046642537428432, -1.779260181878377, -0.8294255727000239, 0.7236772041988601, -1.756185596541619, -1.9997570155940263, 2.2525997392234967, -0.7441008264540332, 0.3118721721144264},
    {2.018113029659337, 0.8796467770204013, 1.0155754363904945, 0.9837718598478474, 0.4444120653049444, -0.5238712757364716, 0.7374744998757813, 1.5858118493654858, 0.6909478727284913, -0.6343438941226848, 1.2644263387085812, 0.47328323892927054, 0.9165175330933409, 1.363490533302663, -0.41484037956419223, 0.41488361065303425, 0.06728972552439633, 0.26120578452495735, 1.8568704017530215, 0.32053750738250153, 1.4770840859639611, 0.5422039479311893, 0.8614519223749993, -0.2598530160110977, -0.4202933747460195, 1.2263839230473284, 0.31722854388167043, -0.0047211994494092335, -0.41085084136262034, 1.9529686081398876, 0.5227087640744246, -0.011401456588023884},
    {1.7973305166697606, 0.45207091875679756, 0.8248730450753649, -0.39926447062323067, -1.2049488936200157, 0.9248942747767377, -0.5427858093915865, -0.1502006593319913, -0.4498620489554067, -0.09218187613631826, -0.5665244618808727, -0.5473920775864489, -1.091098650440106, -0.6168261929316031, -0.19234030790100998, 1.8057414011681772, -0.030239261953154732, -0.9169791727218685, -1.002099350141079, 0.20131056700154712, 1.0565943887268934, 0.08277612752658806, 1.8599279954076604, 0.08101523182920842, -0.2650931312813539, 0.29674755176968604, 1.3464507257236609, 0.3382269128705447, -0.03527476770536986, -1.1920146613867255, -0.4260236426322121, 0.5067569543454894},
    {0.41148672266360914, -0.26363425643434085, 1.2052589966752176, -0.43684815966853335, 0.2754344810009874, 0.9548796670955596, 0.5844249465596904, 0.43771031871011407, -1.0259127767200036, -0.3826630342287065, -0.20843460484963558, -0.35367639220901587, 0.29466807441466236, 0.4045132443163445, 0.6781595315225768, -0.18173687905623984, -0.5167566710936891, -1.1565189026582066, 1.4713086785481377, 0.5030692766062866, 1.2107968053462257, -0.3714637919194824, -0.3554718719470085, 0.022564357020150215, -1.119444468119225, 0.3636095712484612, -0.2770630343622425, -0.255109869830498, -0.13679503745521093, 1.05503453619644, -0.9154112690963675, 0.978825782781844},
    {-0.844544646706002, -0.7259475353741897, 1.1013537264334734, -0.33553231362701497, -0.583201285793486, -0.5056602135758237, -0.20323598152008826, -0.21110354781090376, -1.2016613350193779, -0.6258498672681974, -0.07936012633761802, -0.20904152825900013, -1.5586905012653247, -0.5812356991923693, -0.6155080484454154, -2.7039178167007782, -0.1310925046706634, -0.6355638163843002, -0.5077579948888873, -1.8256526936317368, -1.5521952058672703, -1.1039800738016912, -0.6715794302103448, -0.5102107463616908, -0.3460142530519764, 0.6168000170715514, -1.5109920541659863, -1.6646768122267843, -1.361955481367141, 0.6001856689435098, -1.694532046917205, -0.4170941267722877},
    {2.6131850164047052, 0.10285349945724061, 1.798571873827331, 2.0147905460357727, -1.3366832089369216, -0.34149673499193134, -1.1949729433513054, -1.2132356736327627, 0.1637248379475061, -0.3213025170628179, -0.8492960733083231, -0.28323114469043836, 0.8760036535230532, 0.9928337244689522, -0.701157686786043, 1.1979034376931954, -0.22008638185875407, 0.3042119271733724, 1.5530018004255877, 0.8662475139241836, -0.13081649488872446, 0.8786327254165437, -0.019671631805062106, 0.7227242794902673, -1.0253941132605275, -0.26312492167722396, 1.8149346442388048, -0.0053732099804787185, -1.030802520128373, -1.8071839338335236, -1.763537021718506, 0.5928672529069511},
    {0.9514573900895155, -0.9018118369386745, 0.45901843690433414, 2.0358842020347976, -1.7211489867132101, -0.6147482492611833, -0.5245151982839751, -2.058145119151007, -1.7982704167669834, -0.7288349608900649, 0.6731588176239894, 1.3646262436748384, -2.121424093696615, -1.466714303077965, -0.6428379649877444, -0.8414220216931817, -0.5267195021379666, -1.2665564740997053, 0.5398458056944344, -1.383026334514612, 0.7064740357661772, 0.996324665117432, 1.8753034811692382, 0.18854019994651672, -0.6149480050536902, 0.3638026541083819, -1.9214496736087454, 0.03688211504907964, -1.0174982322951371, 1.0070653501779818, -1.9247906280422997, -0.39631423617082767},
    {1.1451961560068957, 0.5302088455111617, -0.7240650070795936, 0.44106961963965, -1.2249180853770714, -0.23643140002510762, 0.33723833313107665, -1.0525721033087734, -0.27456786566141045, -0.1328032992605443, 0.04113785612715241, 0.8619542850674933, 0.771625305835606, 0.4735643802667905, -1.9343522079467153, 1.3027657204982122, -0.5409512615620564, -0.8651520076546259, 0.4077478247054234, 1.1077183879049324, -0.7096919367489822, 0.11095172007369024, 0.16861300319093048, -0.25722927575415744, -0.8174521967894549, 0.4289541856298872, -0.8196805650397108, 0.07195791278546192, -0.9550043593923618, 1.458704395781172, -1.2955095128010652, -0.6026164733061805},
    {0.9319696438276774, 1.11246324489427, 0.8127325420594989, 2.505335894358766, -0.17145920547251559, 0.04419425224447186, 0.9534657398946363, 0.48555735144990564, -0.7761298288294873, 0.6884033366554112, 1.846918388478702, 1.2730444730671089, 0.3555433523283963, -0.5047886371987333, -0.17823717876426112, -2.3414552283293686, -0.5650049887889766, 0.9460681517999414, 1.656135577877827, -1.1978332026902758, 1.0667348963022698, -0.8076781468129629, 1.6531082604719092, 1.5271267301795075, 0.9598492593350461, 2.2115774940458146, -0.007324931560459938, 0.6961385229916246, 0.3363767811717037, 1.2496766716707757, -0.9462945942292708, 2.120679820628899},
    {0.22892525196149122, 0.26916363284499706, -0.29625516192369417, 0.43800954899742683, 0.3773751639390645, 0.20249070380375503, -0.33337582037123037, -0.6502557918094614, -1.2637764924836603, -0.18002891762222126, -0.43543748530464943, -0.000915338988112213, 0.2658136708921046, 0.7666345629935982, 0.39864977950554265, -0.7108197752253973, -0.42045751246961227, 0.25864556934498695, 0.21294625980335574, -0.6905010152371267, -0.20677532441648885, 1.059361682145169, 0.01592044294459148, 0.4666062830704824, -0.24262028199948862, 0.3120537945602649, -2.271556989081536, -1.8550353153857044, 0.3947258168192284, -2.011086479774754, 0.4400079568227279, 0.16862458069304773}
};

static const float b1[32] = {8.387934534088252, 7.801834491402494, 8.169006386328109, 8.149215032455235, 7.679756349246914, 7.845582634818458, 7.947142278842179, 8.302258998885607, 8.081419297737817, 7.962310699514309, 8.157667145309736, 8.04853128054489, 8.123355493808356, 8.348844532293635, 7.982014482777301, 8.147804297829563, 7.895785983099132, 8.19336027280706, 8.236722823145985, 8.112977811605525, 8.325466727915035, 8.166965813146213, 8.190247137121888, 8.01529439825504, 7.902530094134877, 7.999143480475886, 8.081488272728604, 8.23520890228553, 7.861778307072062, 8.406469332180654, 7.91342244770435, 7.899245061113433};

static const float w2[32][16] = {
    {7.636975502046547, 7.279117563221189, 7.878362855902597, 7.691082529378047, 7.337136182078301, 7.517832447879348, 7.401048041974621, 7.688359646349879, 6.505576749148354, 6.7069032417563115, 7.21520313728096, 7.1602070601170205, 7.329866863975428, 7.416567360045253, 7.8323989410575106, 6.705896384108419},
    {7.022445410902355, 6.694800700356483, 7.312492839375773, 7.077607094048042, 7.034565319129261, 6.939786808143024, 7.505708716272661, 7.16596792320945, 6.394490164733416, 5.851481828173288, 7.240768160855459, 6.632794381364371, 7.277585062922337, 7.36511659149295, 7.30477236380468, 6.817745292361679},
    {7.443202880153585, 6.640883289137547, 6.943556324866822, 7.302859940108819, 7.091054271339821, 7.108571269007544, 7.269619396261022, 6.895831238746848, 6.273872743052808, 6.41766726018375, 7.204510552476982, 6.676346899822938, 7.159165427047182, 7.088020527626653, 7.283449451133931, 7.120238305086424},
    {6.993546879550026, 7.196691383360916, 7.14637775357365, 7.6434911757572985, 7.201065354761235, 7.5250322104969625, 7.000144018360567, 7.391107429637081, 6.512375200255342, 6.62009076791548, 7.328300652600837, 7.196639353975105, 7.607362769584436, 7.265186300432381, 7.2255331227709565, 7.07028856854478},
    {7.163077448242295, 7.008267217208425, 7.230697006676543, 6.943603111595461, 6.96963304940743, 6.943631747737991, 7.02217624887125, 7.29262119635505, 6.638691186655646, 6.37354821165807, 6.776962345831132, 6.6156323243168185, 7.225730367734131, 7.009443439436359, 7.395694759351639, 6.611154205602597},
    {7.142697262782525, 6.618341261669309, 6.757007965650799, 7.259249671532623, 7.256942344284852, 7.417995273763116, 7.210399791581284, 7.209881134623634, 6.657876938391736, 6.202056153388228, 7.068716258846274, 6.769765596121556, 7.440278582459473, 7.115819255956382, 6.959074652406677, 6.485432085658598},
    {7.353090854177774, 7.186044245274243, 7.443469119160618, 7.543166203480079, 7.652256951959621, 6.955159519338354, 7.548694757704584, 7.399598796365738, 6.688521060767771, 6.02206576240615, 7.237943383619261, 7.076044986536951, 6.942705593789045, 7.4853534992204125, 7.1810102606757615, 7.07410678696857},
    {7.453709510221037, 6.901948771665019, 7.546628209373219, 7.011079905826677, 7.446385149198275, 7.329773213101947, 7.250283362769632, 7.304046283181648, 6.197643337014429, 6.528756250331524, 7.3975345451429115, 7.11237190633369, 7.101296984596064, 7.205401471330371, 7.484384100905955, 6.6210215560326935},
    {7.078713917423914, 7.03215811315566, 6.978491799283374, 7.046256487434702, 7.33789469092832, 7.323462990533798, 7.12633064767587, 7.175647278472177, 6.722358995518528, 6.329814763890009, 7.1895156327871925, 7.266669641254056, 7.308839592393751, 7.315530801227762, 7.450420959157037, 6.644333728553166},
    {7.185663939132669, 6.81034448839766, 6.931439660905534, 7.372393423768433, 7.369428309479882, 6.87210981781308, 7.194106860380432, 6.875908106028388, 6.090421130157456, 6.002361234151555, 6.771940656688992, 6.55320424563451, 7.432882824106527, 7.180392396128589, 7.374172465537787, 6.3745149515797745},
    {7.4352824943116165, 7.028523388498923, 7.38641920525048, 7.592699883947303, 7.4490939374058085, 7.119244054854198, 7.155115537901132, 7.17483553542854, 6.137267373398633, 6.481430281137441, 7.571656924049782, 6.865093654813829, 7.344522060344114, 7.504663626253146, 7.455813134798611, 6.72720526861169},
    {7.577285088268043, 6.726370448781788, 6.914328588912069, 7.197664779819487, 7.3967866636735025, 7.1253732159194225, 7.314325450326774, 7.4274060641928665, 6.0964249036724745, 6.391475271398093, 6.8144943001855145, 7.043117664746064, 7.083780564231962, 7.167144651577932, 7.185087490118669, 6.798623656926738},
    {6.917953729050415, 6.761183541864888, 6.9089176030715596, 7.324921195754119, 7.376580206168199, 6.93248007394326, 7.380173142607731, 7.410670133191037, 6.299094734542094, 6.20374491443911, 7.361280161507596, 7.121310903681745, 7.229477500191962, 6.761325490515844, 7.36225764577533, 6.414049973261711},
    {7.212730306812129, 7.319140788919186, 7.369225543970261, 7.755277516108452, 7.919573092345346, 7.239715733433334, 7.358180026312931, 7.445822801773692, 6.557247701125635, 6.45343659080692, 7.719246656649455, 7.200354353462193, 7.679200661880135, 7.71682634190862, 7.363543271852326, 6.515535401620441},
    {6.9685826104573465, 6.982300421129942, 7.2973771361159665, 7.371040978398755, 7.069100027569478, 7.473940977409412, 7.475729847200842, 7.274245770532823, 6.554550554462943, 5.992647333694592, 7.346310939210412, 6.577576908832533, 7.284860044241883, 7.271922326347309, 7.042643129308877, 6.717730598039875},
    {7.301917690808896, 6.689673927233073, 7.159086528328081, 7.332003194957646, 7.58226865951412, 7.578041411842523, 7.431707980541093, 6.899849099545104, 6.304871743060592, 6.250804730790421, 7.462148778756609, 7.075371153376535, 7.346596247300455, 7.1791296413615315, 7.455170794907638, 7.005791076893759},
    {7.191705971173836, 6.9440143391144975, 6.793242504746967, 7.250903761692712, 7.434047720236612, 7.39037640978931, 7.157329860890655, 7.313221815385951, 6.384469177628868, 6.284650365616639, 7.072668809263491, 7.140075847598411, 7.05468930667903, 7.284538296989811, 6.934216500058706, 6.421228604195069},
    {7.786276056464366, 7.065936608111117, 7.6683199767509596, 7.386230941799452, 7.180705258036097, 7.56752216663337, 7.598774555391498, 7.478748113934112, 6.469875581669234, 6.4613629311082015, 7.182404059132664, 7.505409712336267, 7.333548551997744, 7.521486191742896, 7.7385829562765, 7.009453781613332},
    {7.655856403763764, 6.8064162618236965, 7.461213715087553, 7.223039234835375, 7.1015393360133565, 7.617600892401062, 7.457782710427554, 6.943667002489447, 6.287746552511414, 6.158125945127684, 7.469369900395211, 7.207346005730833, 7.590482959886275, 7.398629942790697, 7.588284560769011, 6.680677419924412},
    {7.765385215428068, 7.283004214368412, 7.2649312760925655, 7.4745923614142304, 7.326620938045944, 7.295437261743435, 7.715357082701252, 7.510624854490144, 6.273884536481684, 6.478400004388064, 7.589438050789519, 7.095225090267079, 7.335789187686381, 7.596262424633488, 7.568595075834342, 6.9832683000510976},
    {7.36633811717549, 6.643193917535372, 7.574861280402301, 7.066630685680037, 7.380920608413012, 7.386687008953061, 7.543426973436797, 6.843680703986311, 6.822289146445735, 6.305074918786747, 7.434610989138377, 6.887252976409676, 7.51980477299721, 7.499294676514568, 7.593130230193427, 6.556789728608092},
    {7.408914985930045, 6.826943674993825, 7.048541282180051, 6.98823273059048, 7.600206044478561, 7.438788428298086, 7.411398301481585, 6.835179506733048, 6.312750236563958, 6.16719656936289, 7.0036338462813585, 6.527599153003359, 7.020102084996337, 7.502922193668808, 6.919636963559261, 6.750593707089163},
    {7.535058042656995, 7.1116126689582355, 6.97943903469906, 7.540216168685681, 7.082135728967299, 7.228767744275244, 7.504382766567181, 6.866978757302499, 6.580900850356169, 6.132858679215184, 7.466013107065306, 6.49515228132637, 7.134731264073414, 7.166589986004358, 6.990249908722818, 6.52712961030818},
    {7.2070250391521, 6.92246947252234, 7.086639351497882, 7.502666888622099, 7.060684886272574, 7.338884856628939, 7.141108219647793, 7.022311524260108, 6.323257415770923, 6.1878772277260605, 6.92654398231268, 7.124377356542509, 7.038992531511808, 7.508226183635428, 6.987019924355574, 6.74302491828215},
    {7.120838187192897, 6.369662969749795, 6.948717295006769, 7.327062926070833, 7.221511066623674, 7.0458067526836325, 7.407433549368225, 7.274036348972723, 6.060005787094753, 6.243468575449414, 6.753534991089165, 6.777071097671195, 7.352879419898497, 7.223002372916341, 7.25532809213881, 6.598159681102377},
    {7.434536052158103, 7.2388758155816655, 7.477987172478806, 7.558704971753281, 7.230972219490753, 7.292673247394687, 7.5403840015682775, 6.9658282999759695, 6.345333699001611, 6.572208756034245, 7.164199573131089, 6.756908685774052, 7.48695040296273, 7.465849886328391, 7.042174242077896, 6.8440574081798164},
    {7.142855259572273, 7.3460982004581705, 7.166316690657701, 7.278263186789016, 7.784924168017061, 7.131671313962064, 7.3646660354425535, 7.665943804473391, 7.029796224120694, 6.079531400865886, 7.34411701939959, 7.0164151428783335, 7.398837453691648, 7.067449236859122, 7.049353162818861, 6.675380636296316},
    {7.544134280219075, 6.77398580128589, 7.031325677413016, 7.537414565301162, 7.383223489573207, 7.320427536262173, 7.056686820083251, 7.061705022970824, 6.260428966969786, 6.137102762061866, 7.3832441300406595, 6.67170786266465, 7.198112582903274, 6.874983990112747, 7.0172681429147, 6.751700761729631},
    {7.508399265334674, 6.743001949904118, 7.190324154606051, 6.980732202775295, 7.582132311688267, 6.970596537612214, 7.26599999386007, 7.186368726949381, 6.208284650159132, 5.986784879921041, 7.396330575025845, 7.082973109957334, 7.370280710745551, 7.175868969525586, 7.423951116000826, 6.7094957938671635},
    {7.4172998521842155, 7.036420360665089, 7.321943190547933, 7.195781229802132, 7.634405788205892, 7.547030109860469, 7.588309093599713, 7.671039758931462, 6.832614602025917, 6.563554961377162, 7.445197696958096, 6.992862256120693, 7.393958838962824, 7.057387443413879, 7.021571615671943, 6.900290129741106},
    {7.131684978249799, 7.060795491132859, 7.2504353869546145, 7.203854049841201, 7.107316147006299, 7.557323239188658, 7.491400509203307, 7.365739123494693, 6.294455461900759, 6.323846307196482, 7.35353218442955, 6.865280990888817, 7.222989467939534, 6.781964153078438, 6.860759394866349, 6.41360942365416},
    {7.567213255418477, 6.83805110118998, 7.464920313959245, 7.024522744146223, 7.181939240192531, 7.061277236887631, 7.49254698349127, 7.223485700819344, 6.642401210667257, 6.336998968119028, 7.12650272795322, 6.768641192138822, 7.51848146573993, 7.245613457345064, 7.519550268717649, 6.839983004943034}
};

static const float b2[16] = {6.957146943106148, 6.946051938507862, 6.977934056232264, 6.849257730511459, 6.968848338336866, 6.917717928465194, 6.9044786718878655, 7.027426974541009, 7.052052868148348, 6.835218879209103, 6.9527949212302955, 7.132101589210592, 6.921091827199846, 6.810692453599406, 6.780074076278582, 6.732429995273074};

static const float w3[16][12] = {
    {-4.705932080022362, -4.341169097966854, -4.429351142691319, -4.835477417091131, -5.02548567516823, -4.599123694931113, -4.606771130800594, -4.72079715215661, -4.517036118867544, -5.044225092866311, -4.565333513926818, -4.751150762982247},
    {-4.224705763779022, -4.344732094317893, -4.817922688677492, -3.9661992942088884, -4.098771127524807, -4.514854965064843, -4.292535147897537, -4.2267789546739944, -4.293840790334256, -4.397730786612646, -4.398786023722367, -4.575053357355374},
    {-4.845641942885819, -5.15352729675528, -4.614743467370019, -4.582045754441579, -4.1595326643218735, -4.476886585998912, -4.810394264460863, -4.967275165127923, -4.34886645235394, -4.759984794928814, -4.641395571250891, -4.363570354739013},
    {-4.515478548190381, -4.801356400822712, -4.120734022060169, -4.428382630440289, -4.507503356768159, -4.596074606371082, -4.9565428303481935, -5.032023272083524, -4.480848252407884, -4.7505476195221545, -4.326769250794865, -4.384223116240539},
    {-4.614867558337899, -4.662529061756423, -4.162528225375654, -4.719798227779202, -4.9922014983027205, -5.102410978212418, -4.4019912131089045, -4.492466301213174, -4.869836755616373, -4.941956020531711, -4.583786539679391, -4.8590444085578115},
    {-4.506215884479081, -4.776957571279779, -5.00086421913209, -4.306132135055761, -4.803033586761776, -4.3870184756437585, -4.989209952931805, -4.439635173411256, -5.043779578717867, -4.627536894724288, -4.139799746216661, -4.956105485879865},
    {-4.325895778795615, -4.931634038772624, -4.976413930848971, -4.9109658764468715, -4.349771487659191, -4.291109793655853, -4.489267758681184, -4.7683968883459205, -4.503827328452766, -4.6201372127960765, -4.845172165229648, -4.60177103908528},
    {-4.543513668055231, -4.6045021285987575, -4.443319194393228, -4.7862412067353635, -4.457589887431376, -4.497623174306954, -4.997175609935431, -4.377130465671225, -5.10002268273977, -4.868567554160291, -4.87267707288517, -4.882314352307541},
    {-4.25386296655905, -4.026294564499642, -4.225935297306421, -4.245621037269711, -4.558043005761403, -4.359447798114951, -3.805129152529917, -3.613730792784732, -3.942188230571473, -4.170992642579548, -4.779307059634321, -3.8794219808432464},
    {-3.729870633214407, -3.655347641622226, -4.032969281570667, -4.098036063691714, -4.174657607421442, -3.8109199850990088, -3.441563703616194, -3.521036667325168, -3.76579844728082, -3.719966852038706, -3.6002029708071066, -3.737734036884879},
    {-4.779429172937509, -4.791627932956862, -4.729590964687862, -4.16383459413852, -4.668001832828742, -4.841393322191903, -5.202356177591332, -4.430862002591352, -4.451598637908026, -4.463602915907798, -4.786863929768081, -4.447362222567336},
    {-4.375789922014638, -4.485781153699874, -4.587866579133693, -3.921429313764055, -4.3978591768369375, -4.648797651607538, -4.333347270059547, -4.689849762263167, -4.618279794266715, -3.9211043561578043, -4.665334790524347, -4.08428255751236},
    {-4.428092868243595, -4.331834378988176, -4.80052407327256, -4.858479787306799, -4.9455972861860635, -4.935836421950367, -4.531135596512096, -4.39044539989354, -4.772017449307841, -4.302541045674234, -4.388954719584345, -5.127795813975625},
    {-4.679137191307559, -4.443777951941201, -4.248650359553604, -4.494452602787593, -4.491243610015053, -4.430666658976863, -4.646317601166657, -4.94913658597854, -4.142210894429546, -4.176779271846329, -4.643165220553065, -4.482211868541952},
    {-4.90474291999874, -4.728163390149174, -4.802464046011315, -5.0130732727891445, -4.343379501899481, -4.47412759698526, -4.346309950851491, -5.0903952284787195, -5.086663666062805, -5.003506374115034, -4.579617712633374, -4.238672577273824},
    {-4.501647510902285, -3.7688078649275334, -3.9727388564000936, -4.682977346993306, -4.063657176632706, -3.96575573854055, -3.8796956594863548, -4.133150728363814, -3.934734468399946, -4.116931054872924, -4.133774048011394, -4.516594144125457}
};

static const float b3[12] = {-3.3632440613677552, -3.0759077804360024, -3.3411545070712942, -3.1178478756723473, -3.699358056367515, -3.019561432687443, -2.788802601215826, -0.023295185322254757, -2.4805801194828843, -3.4415936507471434, -2.739023734745266, -2.1811068502388253};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
