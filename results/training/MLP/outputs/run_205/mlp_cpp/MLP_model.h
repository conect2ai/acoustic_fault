#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.6214597128349604, -1.0591843184228118, 2.3279090390872623, 4.005749392031584, -0.7373944327974143, 0.8855186329608383, 2.877069211009824, 0.39866308975272, 2.2408034553355414, 2.7769754206641046, 3.995322879601339, 0.7744527827295768, 0.34930026143970655, -1.145887911111675, 1.1854639616406393, 3.7063165302815233, 1.5043830458656544, 2.19991542416813, 3.4090090813078233, -1.7269153063002176, 2.7429942388341004, -0.8263848577151155, 2.2425960510687095, 3.631799196084097, 2.8303052591788136, -0.5642401618141356, -0.5148281151450288, 3.7035425757448093, 1.1203455400720723, 3.82990667955009, -0.24896438320915598, 3.83525957078099},
    {-0.8017698096970403, -2.81488239629452, 0.32190348224815224, 2.8052330065852047, -1.0156974963041132, 0.7006955050814055, 2.487196616014218, 0.07928416773082671, 2.644527637135476, 3.424892873542774, 2.4799295399134267, -3.316128729771221, 0.37264797662204435, -2.5085679212873373, 1.0215465414015423, 2.379916606075409, 1.9057894450128434, 2.9330231796323454, 1.876714543166415, -4.363964953853979, 3.237374943158125, -1.540991567328987, 2.3835880666240192, 2.714113902431517, 2.5209516671106593, -4.250108354145599, -2.8246191328652777, 3.098253142436846, 1.3513049220573734, 2.0688434751190026, -0.5110495004824265, 3.0948511828041942},
    {-1.9697555694591622, -3.756481217165679, 1.8133647439717409, 4.457963394116321, -2.3531456167147216, -0.06991437891017901, 2.9107310622203033, -0.2661313261484274, 2.277606245346279, 3.581784777626597, 3.7802552346944256, -2.664839064412407, 0.331718973732979, -3.224091507828112, 0.5671033216649453, 3.9772155974572865, 1.9297645779843322, 3.1805326777391927, 3.1610782412862175, -3.9981815506450302, 3.5890198094346397, -3.1315218362459607, 2.4767459190495758, 4.054922084329819, 2.9040104095535155, -4.192010481556273, -3.4619740146383067, 4.296316709363423, 1.0610508291120062, 3.7630798319889758, -1.6058053480878614, 4.300159979764422},
    {-2.528804687768382, -4.330796162390176, 1.477328650430172, 4.244421565559343, -2.5731272195395714, -0.9325627919051289, 2.0929618218177533, -1.0637472232453167, 1.4950827019422983, 2.5898960735335166, 3.850992266985208, -3.584093238212334, -0.2543988530115571, -4.10322412135375, -0.0448093039963161, 3.802867139443794, 1.0049965980628248, 2.5853482936149152, 3.1263084764128153, -4.889269588022087, 2.8405679238167783, -3.971706916622001, 1.6892220565951854, 3.627273108755665, 2.1660868750064246, -4.505852697174415, -4.578936062231253, 3.8900589190693493, 0.2932044633143842, 3.6531360162048645, -2.2627438135137994, 3.735655956834027},
    {-3.6039361595902686, -4.885468618963943, 1.195257303154532, 3.474129457593239, -3.40245907666594, -1.525669680966309, 1.4570432799085122, -1.6170674407231973, 0.6508452283903592, 1.7192905916790295, 3.3312849425882254, -3.511755591641485, -1.0109924283019918, -4.8093821495228655, -1.1323397358301106, 3.204629958175203, 0.14919132127726314, 1.7820724940271708, 2.680355251915607, -4.5433828302202635, 1.9609314346106703, -4.782045033321489, 1.139836172496292, 3.1573852802922415, 1.6437504785155264, -4.786038498179232, -4.803346663180938, 3.0209705036398113, -0.5351196401862356, 3.0493826184783837, -3.214037399024212, 3.3817077640020052},
    {-3.6067081859416525, -4.788702602304239, 0.46413267301017663, 3.0576014908220124, -3.7859564311937732, -2.208390006252846, 0.8481411347928685, -1.758420867299187, 0.20688340263136074, 1.188449604918533, 3.040537538986109, -3.621589322266871, -1.2643909285720265, -4.477459782558209, -1.9730624527973388, 2.6983497442307103, -0.3732100622817086, 0.6464518583154695, 2.2021011505134926, -4.450364511024394, 1.2631062811083067, -4.777211426545852, 0.931196818616328, 2.5703942845095438, 1.1477402520825526, -4.657762752076584, -4.744075215880572, 2.3780206631345693, -0.9611957461536874, 2.4934877828726583, -3.4637692791804926, 2.5156415530816543},
    {-3.7353105453282565, -4.645373161539283, -0.011198675788644166, 2.061591981732874, -3.7518798729230616, -2.1097853676000287, 0.3354029341102872, -2.287675255196179, -0.47505507262078955, 0.3543886272892006, 2.4268854093901786, -3.6822996016611604, -1.499124865197793, -4.44372230039447, -1.991189354218984, 2.204872743745261, -0.6998937544500906, 0.1206680770198765, 1.7408818889574083, -4.456846762528626, 0.6588128503993568, -4.304592669276554, 0.6491613589464565, 1.9256654268514177, 0.8605196659154404, -4.842264455511909, -4.648377334791876, 1.3542424827699358, -1.4500507983345772, 2.270897037828424, -3.3422043639203496, 1.8139957733226397},
    {-3.590118234086016, -4.542170564601174, -0.5068754460882885, 1.8774635923626626, -3.926429291963942, -2.057075068996971, 0.2641878116260958, -2.8132182617522927, -0.2048885087104448, 0.3314196011850876, 2.37621265590511, -4.341715761367686, -1.8353133593914743, -4.635996872699147, -1.9380560979803252, 1.6756413806049235, -0.8586432637649184, -0.09061778662251133, 1.1642328320858035, -4.940204528236227, 0.6781336662319251, -4.674659362301153, 0.8180558230886438, 2.031524141489448, 0.8433270297998587, -4.673151420662431, -4.766331243723582, 1.160155403416683, -1.8856424345977965, 1.8734110876493038, -3.5727591988714678, 1.5109010054151493},
    {-3.3322019156286116, -4.630452893470327, -0.6767403471619856, 2.5131002225774526, -3.3149753466123415, -1.4354225834332053, 1.1547712254159306, -2.6155910680221246, 0.7467190185316531, 1.183267046166519, 2.2328610332356726, -4.494648982895067, -1.6469695923833394, -4.486167433559218, -1.5481017215264399, 2.099635254606396, 0.03727735435636987, 1.0182145917660976, 1.3726792148951912, -4.854945571260948, 1.480154698501179, -4.361040888890181, 1.217185430638072, 1.9495411590147895, 1.2343871846342804, -4.782040215713551, -4.940220612647415, 2.153996990450738, -1.1991701129848424, 1.8323096133667258, -3.2614973707531707, 1.9679533147292292},
    {-2.9262267544710907, -4.6284944994720005, -0.6864350039007122, 2.8495441010519684, -3.0028606506584965, -0.926323567636058, 1.5800908147996615, -1.9991798280036872, 1.187863625569865, 2.4414201895108065, 2.371814004038705, -4.4728869197620895, -1.1204677514236083, -4.3262455810246845, -0.7993188207186847, 2.5256993625454442, 0.613330881348673, 1.9041262240994354, 1.571694347418437, -5.308863391788186, 2.5011441813623443, -4.223488275379551, 1.2742758808200456, 2.3903613621133375, 1.8482631210830835, -4.8678224392129055, -4.757447596724562, 2.661221732678915, -0.6724844953544129, 2.078838064162478, -2.809577954875488, 2.734261862046094},
    {-2.3098760586202505, -4.14201468011336, -1.4398840774045285, 1.5396459468515238, -2.6365256800265326, -0.941929350261132, 1.2455174205045272, -1.985410640141437, 1.5194007543180221, 2.3329584903281617, 1.4721476866592424, -4.542656989852619, -1.1710887120261586, -4.117618026115408, -0.5890441539072762, 1.2976654166877826, 0.6856105961583511, 1.9639556846665558, 0.5029807039560339, -5.2171870310793, 2.310484876442164, -3.843661172325808, 1.364303703831457, 1.4753277976188437, 1.3813278475850674, -4.981997869060586, -4.492446168471045, 1.9834452366945887, -0.2535113835514644, 1.1479976984176647, -2.228504508047578, 1.9560962078182693},
    {-2.7465577748074246, -4.247691912037891, -1.9390693819920313, 1.2566738966107844, -2.52639715237986, -1.183443547581722, 0.9860432771766966, -1.9751826873857659, 0.9416019506431299, 1.8904898129030339, 0.9469712762552405, -4.3702544281564375, -1.640719826658637, -4.196610659354117, -0.990858804001716, 0.7190612857540938, 0.08802886458404814, 1.1785905703440445, 0.10549929883736348, -5.039884813448576, 1.6490909375494212, -3.8648623787163445, 0.9650534401577427, 1.3321613670827077, 1.4032565450326984, -4.636877883137878, -4.364297460865463, 1.567957924132777, -1.0561758532228798, 0.7392592609189077, -2.759989801948143, 1.5834985644421673},
    {-2.521758043843184, -4.193737366089152, -1.8329860918273608, 1.4326559667955816, -2.6512136060857157, -1.0513968566340322, 1.300971361989995, -2.045253675271507, 0.7991822110580227, 1.9705571928706036, 1.082143637194787, -4.545664141247957, -1.5009181299897882, -4.2276532200504775, -1.046225789226536, 0.9785375568195067, 0.0014637230590103484, 1.5576466901280905, 0.6301930651355179, -4.781539026994931, 1.8801918577499446, -3.668299252812141, 1.2056629588189152, 1.3435891300076974, 1.2359075850677619, -4.839016864152781, -4.553271387601503, 1.7663290226063513, -0.6917513045593425, 0.8595143850906689, -2.746674332805802, 1.5080770522266351},
    {-2.755953928200892, -4.453333510318146, -1.7545633884156855, 1.3078439057440556, -2.838718425384525, -1.2533647263361232, 0.9327871674748112, -2.2388305657989434, 0.4321428478234631, 1.4693795265335583, 1.1489063095752838, -4.335109440598255, -1.6187314222845373, -4.302879126151603, -0.9074355770720965, 1.0231299847901534, -0.06303938637860615, 1.3852318328380944, 0.5267312018319096, -4.84749373391458, 1.527266874818903, -3.682186702798571, 0.7623267264622909, 1.3538458755652023, 1.1642804385165924, -4.792788143936013, -4.687611344618204, 1.7573273627146677, -1.0958748387333968, 1.1378415121403422, -2.748506810198989, 1.4888413041533246},
    {-2.8565862761787884, -4.6010345181319545, -1.0421357379671816, 1.7212105729024998, -2.857322398694103, -1.2493408265981367, 1.1314040215908594, -1.996379501434483, 0.861608878746434, 1.931942493170591, 1.7762781823405787, -4.330144977741418, -1.4947349900068523, -3.8719970255868104, -0.5985737322139971, 1.662947968086345, 0.18567043660517202, 1.400830724323779, 0.8838187138843918, -4.968639699794673, 1.982730060849172, -3.8779536373903594, 1.1882144004943258, 2.0155181214571476, 1.5631598049783408, -4.679849865823923, -4.356163789990918, 2.211618850608705, -0.7683883436883823, 1.6087616685176773, -2.7064325561012454, 2.1088030635403947},
    {-2.7841356785638407, -4.534806895862208, -0.5443173738149191, 2.5009888949328105, -2.953728669255024, -1.0890135900530369, 1.3779856912968635, -1.8333449888332536, 1.1618175428177806, 2.057766575560027, 2.2707301399632898, -4.640680447002271, -1.448372336271149, -4.322551810098809, -0.8708018467742364, 2.1490903161851422, 0.336667008182926, 1.5991212281838387, 1.5693815134581162, -5.124635143609561, 1.9770667365301022, -3.863912717212659, 1.4729557057228313, 2.4404656816402417, 1.5985221827062768, -4.834607936928432, -4.709040893553891, 2.7348431501323507, -0.4763207895969937, 2.201802504640633, -2.5587846947026534, 2.576180705477448},
    {-2.5536905231034286, -4.539997267620914, 0.12661241627454906, 3.8079165753689614, -2.65843542310039, -0.7130779850024794, 1.9472929919423856, -1.264543549017185, 1.4194726690343527, 2.598723904114701, 3.0913403173523184, -4.122863332123745, -0.6638017255033647, -3.8531569853844236, -0.07996404691362421, 3.176846361637228, 0.8989443627282251, 2.360348961271813, 2.319294940070557, -4.828448878703737, 2.854769668015412, -3.662209718856866, 1.9762280504265721, 3.043080928847915, 2.0927150501423415, -4.700777663353701, -4.431888722168049, 3.6147165600059403, 0.10816315572095288, 3.0037447366175667, -2.3425247490653938, 3.497379936177109},
    {-1.734504044098347, -4.062789688414015, 0.6802337956963789, 4.1085637619790205, -2.0452965492234014, -0.2337745835380256, 2.709437654931979, -0.6669520251841775, 1.9134316149466672, 3.3285211914694286, 3.597843828841526, -3.4975617490892636, -0.4063611214478542, -3.2858568991385546, 0.2932669609780414, 3.9377388316908446, 1.3205114233652402, 3.0051280141512065, 3.0961795012506235, -4.184194423670943, 3.2676664523985424, -2.8744179349748995, 2.5538097766298455, 3.660597627792684, 2.669921394331145, -3.8242426705612185, -3.8152612071335867, 4.017222520012213, 0.22375544894875796, 3.84456117847518, -1.83008962014161, 4.115545692846835},
    {-2.2754727127072876, -4.0054083486071885, 0.46111966517093006, 3.979030552257879, -2.510228750617461, -0.6520619187870589, 2.334825861619594, -1.1475849210504532, 1.7308917093734115, 2.8772492500145774, 3.5993555706699083, -3.3535644805886387, -0.4968613060360624, -3.4650843555023703, -0.25613154077296824, 3.621211131195411, 0.8897726615241058, 2.1478386769260953, 2.8907845034890567, -3.845209232016975, 2.923020784995489, -3.48315379179911, 2.0852808597857235, 3.4032568788508537, 2.6981881134183325, -4.02011341053534, -3.786815670720843, 3.7782571580030218, 0.011236798354790052, 3.7700824871209817, -2.568469333017879, 3.8753004734245735},
    {-2.670887962093613, -4.674674846283075, -0.008751846032643677, 3.7233763267119158, -2.7550930350286538, -0.8971304792875572, 2.0756695070523588, -1.5195217568295325, 1.4780733849886665, 2.616498965743007, 3.390636212456564, -3.748168813327574, -0.6285123679839103, -4.078811413018063, -0.3600985256643871, 3.3606613429735086, 0.9026592821439317, 2.4357193748274866, 2.4249585148150925, -4.510069715868342, 2.7962588554324257, -3.879678132752622, 1.7949615833172061, 3.3987178188229943, 2.5307541753884983, -4.409121774704103, -4.4329222215812605, 3.789318455179922, -0.1681830662300485, 3.302055419629629, -2.33618762309849, 3.653065718901517},
    {-1.807627362135286, -4.1383350691801475, 0.0751964859139922, 3.5037748427629887, -2.113854927912731, -0.6730002612934477, 2.3803618954012444, -0.8853237005223848, 1.7560909108645721, 2.9315510152730666, 3.387256470138327, -4.0203757854693665, -0.23488890466303042, -4.09742253801517, -0.15931778242156627, 3.2058711334590044, 1.3295112414574886, 2.550706960258163, 2.4895477291837715, -4.996629383685928, 3.26450848784781, -3.238788440017422, 1.8397579981378043, 3.2516163269430085, 2.309849057476807, -4.565084058061493, -4.254717470317213, 3.9135054352096654, 0.6585214521847262, 3.1170933437168196, -1.9431004862088774, 3.699794166414111},
    {-1.1788737198680583, -3.8162266063802788, 1.4624666474397636, 4.611912315826734, -1.5546436579611953, 0.052266992024008724, 3.0948972221294535, -0.33450202263822587, 2.5529430467080476, 3.622245804549682, 4.093242515455155, -3.2431136378059073, 0.13674514776030489, -3.2411847064688972, 0.6826148507284423, 4.230261521284341, 1.6002276307494625, 3.1070908292232633, 3.4875128056513374, -4.537687816623085, 3.7382831927471494, -2.6808478301748893, 2.8397770552612442, 4.0977224546051865, 3.0706280783137103, -3.9703569329042834, -3.619835234132948, 4.675335942191213, 0.9922100210999678, 4.151096598532073, -1.1307911328419642, 4.4419657282801515},
    {-1.168404988700753, -3.1441861307061787, 1.6542425622271502, 4.666330742305897, -1.0896843571929227, 0.5189190441975096, 3.5356351843842138, -0.09318465630021314, 2.885218501102522, 3.608253890191809, 4.2447762805136335, -2.685606159799112, 0.29016679515344834, -2.592920801689162, 1.0977927012793152, 4.509273565066714, 2.0936397457762563, 3.617609363121, 3.8215871570420443, -3.964809149410355, 3.8338174189195415, -1.974285903203024, 2.9249863377372733, 4.306781571437795, 3.3568743867196655, -3.6195921741143073, -2.6856638298131155, 4.694884276121203, 1.1710832672103824, 4.177979263131071, -1.1887258935531801, 4.518029338829703},
    {-1.3836332225912036, -3.6305563736949376, 0.8112940517647629, 3.988579865580724, -1.653454381171898, 0.04787901331413726, 2.7683601804016864, -0.6556464765494187, 2.436536803128428, 3.4337222612754896, 3.632781994576067, -3.6758004838206046, 0.050042072145334515, -3.2387302563819746, 0.7398548821273419, 3.5772244836119276, 1.9073255284742945, 3.3679820994493648, 2.870917763546102, -4.448024489493465, 3.803280617353881, -2.690192523065298, 2.366897786833115, 3.605518987090667, 2.909909582424443, -4.06378440335697, -3.832566282847781, 4.461206361965813, 0.7294531418254244, 3.6310721175127343, -1.5464304358595242, 4.298594600578901},
    {-1.5995127117606647, -3.832787155983176, 0.10428173995810527, 3.481663137838024, -1.7346219034104826, -0.2288354112786025, 2.5528931814143223, -0.6903358325158754, 2.272524379430755, 3.6176306547332437, 2.9295678510196095, -4.108485756544716, -0.043179091603080866, -3.713709430122356, 0.5011463021443191, 3.2453655442515355, 1.767138466979541, 3.3938193123610203, 2.27753826025245, -4.803820262665958, 3.7846189184045245, -2.755936216543998, 2.0477771327642795, 3.2360367794875513, 2.540726510129006, -4.563867131470213, -3.893973500196995, 3.869953685033986, 0.9915661729145855, 2.872825766554324, -1.6295486289469325, 3.7008038757220505},
    {-1.5507254663927836, -3.9602835035843054, 0.36266808182551624, 3.732489125869037, -1.6942377452330173, -0.23792346577069087, 2.703246138752261, -0.7398040886166285, 2.3468392161734597, 3.169484341038185, 3.216752230582974, -3.550088909750394, -0.13526443451854467, -3.270338793157723, 0.39711162669883077, 3.257459494863804, 1.4822395522775924, 2.836341962420059, 2.3536026923866773, -4.256865751605778, 3.5547816969049313, -2.659571097062156, 2.1755282576019632, 3.3467140347747835, 2.7941580264804653, -4.274647197560968, -3.602701499641817, 3.980162754521977, 0.7741349838899215, 3.281142361856096, -1.600689836315617, 3.846319037329103},
    {-1.9381878300731503, -3.7587687200762137, 0.9780884224085948, 4.393416539398826, -2.006815831146892, -0.10599005043981823, 3.0320829274932044, -0.5042326798783165, 2.537243064790345, 3.805425267801069, 3.597143742550639, -3.7503298703105, 0.033556000243107086, -3.525407343313706, 0.5831286030948123, 3.868668111613973, 1.5285196497137807, 3.2982275188575048, 3.097025740711695, -4.206422761760081, 3.9012121621542373, -3.0305677410850813, 2.708461781594254, 3.8043320966640133, 3.0755687558662608, -4.49818476705116, -3.674863365227685, 4.2449978309789795, 0.791194202896062, 3.6537095537800655, -1.7190689804881363, 3.989593076732199},
    {-1.9224434731027122, -4.128815778996836, 0.856599962087241, 4.094482461950066, -2.1296715959727557, -0.16321456346171162, 2.874856362558596, -0.8285962924374282, 2.3986611378364113, 3.355542215289286, 3.552042030133902, -3.5615375243072167, -0.16329014547592788, -3.5676594931579797, 0.6712495744022243, 3.7802146245683494, 1.845863626357282, 3.3149140675438504, 2.8943598020524255, -4.722336234264858, 3.6716628341108137, -3.178643353363627, 2.4301741323797104, 3.8156865200171786, 2.7540673378531912, -4.467734839297995, -4.136956586963037, 4.367478729380272, 0.7837510291123148, 3.817724229898891, -1.9932576492153224, 4.138642256480394},
    {-1.6373443769160891, -4.08240169791077, 0.2664522161556853, 3.8124910830870533, -1.9808446077799187, 0.11829706314350824, 2.965390137763881, -0.5344384399201867, 2.2937516402955573, 3.883641128990282, 3.181127483132481, -4.000484538746953, 0.14246994593989049, -3.289112428213188, 0.5476629382647403, 3.4276246141671525, 1.9936402863025182, 3.2510993228537446, 2.4333503233345586, -4.452254736423536, 3.6946830756939786, -2.635839328372378, 2.1257084516799116, 3.602155660298876, 2.4949365962704646, -4.452860506414745, -3.901143477411813, 4.223502373282201, 0.972691342486789, 3.402245582248489, -1.414013008712495, 3.929348885027763},
    {-1.1636864117852312, -3.951466010610014, 0.3471144156113842, 3.9480105695953105, -1.5940231937023164, 0.11328917739339892, 2.756280419596661, -0.2712095791915333, 2.1825923301899666, 3.4190717733157987, 3.294427483773522, -4.077420658070865, 0.23688213286624304, -3.249837479060584, 0.9010297962732511, 3.188085482433988, 1.8300248171429785, 3.1594810814486296, 2.2769935925509706, -4.571378020412984, 3.744792386253283, -2.3551579343080533, 2.205403253316716, 3.5344399335507686, 2.662651549081554, -4.674165471562464, -3.472469015777097, 4.088502720467802, 0.964584134352535, 3.403133264875222, -1.3123388032756682, 3.7399566785043477},
    {-1.4867292067169184, -0.9110400686302651, -2.0104335013948087, -2.22972321462722, -1.3592667650521342, -0.8818098472005208, -1.8853514604042967, -1.244056023290414, -1.4155912809923763, -1.6912688426408986, -1.6063139276436975, -1.6145779010680468, -1.2707033010990876, -0.30629239002847086, -0.992037788740771, -1.685067453947454, -0.7046459753407518, -1.6292765585085953, -1.6265764962153368, -0.0886102852103647, -1.7331365680450472, -0.9808342010179539, -0.21317669997410577, -1.7496462548315244, -0.29255415423542686, -2.085322785832226, -0.49677588416010315, -1.4829824194826315, -1.4929456273908037, -1.6255767385801703, -1.216794359245625, -2.1945016517294027},
    {-1.3852454786407409, -1.8522385337408638, 0.22577001726496135, 1.3914409851541925, -1.723387378871809, -0.961666219934549, 0.7109027423123286, -1.2490636083086806, 0.07842002257758691, 0.4745267736706064, 1.560509920465944, -0.4871223123139043, -0.5998646247392471, -1.6425660583459492, -0.67397921551156, 1.4453639940134724, -0.30660742700853916, 0.47266184548054313, 0.8965703164352292, -3.163837854601518, 0.7348613318013345, -1.8200515028563606, 0.42795558615329393, 1.2366257822390674, 0.9130257028668681, -1.9660101599271136, -1.5939930585228061, 1.37367057538129, -0.6801471314960185, 1.7494137425466163, -1.7154472620492116, 1.4680596776362511},
    {-2.8072486235181433, -2.0614739772730446, -1.208614699897529, -1.4725355787291976, -2.918027101405436, -2.74519538338716, -2.109859098310336, -2.7619634472894017, -2.7249488510478153, -2.53492695292274, -0.3554124916475925, -0.3904416866262287, -2.7474638459251794, -1.770682177857187, -2.818353318491597, -0.664718638240193, -2.7177797674631883, -2.9170679992660484, -0.40067460193476195, 0.5342615525193769, -2.885725456141291, -2.259106872531271, -1.719082911583251, -0.92727736687858, -1.5736633278590284, -0.1606306164445861, -1.7264407886463207, -2.0584082598940565, -2.6713680849030923, -0.26375359542542803, -3.011808462882909, -1.4790913327705006},
    {-2.313339267052751, -0.935767545105496, -0.9495033577857358, -1.5985449279012927, -1.9648661856090346, -2.1454387376347706, -1.3344096439804851, -2.5031914204147894, -2.4294947792836465, -1.9904508743252134, -0.5975176536973185, -1.6235143287363019, -2.6184718936323805, -1.1167199667578558, -2.433939282085261, -1.0577603350538418, -2.605491084545929, -2.2006892307331705, -0.7125468239323779, -0.9580059626189499, -2.219004199953674, -1.393949798611392, -1.1429270312297766, -1.1198247571830682, -0.9876246639652291, -0.26702651225083796, -1.3986957118107712, -1.5731833727395415, -2.27051566360508, -0.7455952681141519, -2.101085783938276, -1.7015968937080619},
    {-3.0214906108015125, -2.5304440835887876, -0.2356041024146934, 0.13264743331781922, -2.928196690647028, -2.666491702640889, -0.2917408961347998, -2.4515337883930584, -1.5109629176123818, -0.6302692987042694, 0.5624574784469007, -2.3251975053874503, -2.7499899789956315, -2.9459831280111186, -2.077639145946708, 0.10361154551485947, -1.5326206186636806, -0.6585839732155849, 0.5043662307832933, -2.8152046152175245, -0.2967491903358629, -3.3434574317823014, -0.5376595595099971, 0.19192251975147068, 0.06168324031583005, -2.5811843123415534, -2.7329407102955283, 0.2733108128366408, -2.096714359016713, -0.018157086380183096, -3.0542600017847197, 0.040049762290843324},
    {-2.9888786444009594, -2.8962530894935528, -0.9400564756717291, -0.8157123645115106, -3.413661775929476, -2.6473141089858014, -1.49082557596242, -2.900114701346647, -2.402762025381269, -1.7824531114106037, 0.19620169075326105, -2.017872119796966, -2.9710008225051667, -2.8064494923841212, -2.706866731604912, -0.38421740598266446, -2.3709984240588557, -1.6627249267383257, -0.5258664902160607, -2.4346850777438473, -1.5790080423607926, -3.2915225002489517, -1.0376200793322727, -0.35118919311929936, -0.7864618625798527, -2.1559768831505686, -2.850060944038667, -1.1013205347487887, -2.308767059388144, -0.2707010068869398, -3.1323165105815898, -0.7547024308470545},
    {-3.1198955266040254, -2.554030227495503, -1.114637541505458, -1.1168748291587727, -3.145229217166927, -2.770993333817201, -1.205978338893139, -3.1022956461929327, -2.2450386215642486, -1.4425961942601422, 0.5042481865931663, -2.3192296964091765, -2.86438013687054, -2.8722383561048574, -2.745435947745445, -0.0323488749179228, -2.2674104383468414, -1.479159526798615, -0.23571611987792104, -2.789210100019956, -1.6218140090255857, -3.0339614255600433, -0.7893928558245306, -0.1098232057811508, -0.26809615881718546, -2.54742788483742, -2.8547099646323186, -0.6146373128037088, -2.67461692150171, -0.28615793892458236, -3.074878660086159, -0.6553214301560872},
    {-2.8206815098315454, -2.057379032301704, -0.696523834131804, -1.3001639360856259, -2.841075484925068, -2.5178431687575724, -1.0187847760113489, -2.7307116763613406, -1.7037910409818384, -1.4062509038003748, 0.4642255534135608, -1.7403052179844611, -3.106213088219118, -2.491692258684509, -2.304050869161727, -0.1220839361248642, -2.0798244009573996, -1.6777086597888065, -0.21971949409013652, -2.613823015628928, -1.3285669444644008, -2.862484270773766, -1.3295745344452286, -0.2829800837837992, -0.6902853201993929, -2.229765336105309, -2.820969399245008, -0.7929061738854458, -2.3736552851802464, -0.6178907329754454, -2.9398606402913856, -0.9680346723923936},
    {-3.3308780856159554, -2.4725909163810758, -0.4963435196505574, -0.8691177105199854, -3.2854847971402705, -2.7332664580020394, -0.6915532355893079, -2.977835910130017, -1.7678145841214972, -1.0486373813055776, 0.7140668103074423, -1.9080360757611545, -3.259905312077229, -2.9219709953235897, -2.749683922770726, 0.11645760022956855, -2.3114849401794384, -1.4226545463319435, -0.022941998452858846, -2.3340693585400696, -1.1368574165931, -3.3611456954545074, -0.6216055270492992, 0.20150487416622279, -0.01851527581524863, -2.1223077039799687, -3.044048440545953, -0.8309110937236597, -2.5649168823115724, 0.1506033813529036, -2.958935338525988, -0.42349600183380426},
    {-3.598893828080831, -3.2486001470460155, -0.395183942474835, -0.2928950989529706, -3.1835819320476997, -3.0890146666370457, -1.2917353752328502, -3.202280454360447, -1.931266993796232, -1.5365473167613048, 1.448078483017882, -2.4280307106040615, -3.0278277339707382, -3.031436916141315, -3.1094002397608853, 0.6343778867094299, -2.370431312714761, -1.9647101852449274, 0.292133629907775, -2.693372590378305, -1.3352412287548077, -3.573303392282898, -0.5174314680470253, 0.7438137152861372, -0.039846601904432774, -2.8474452659864715, -3.3603282560562833, -0.6258880932501062, -3.031913114179702, 0.6002504904443694, -3.4808940258769936, -0.4628588646276987},
    {-2.9227784243138792, -2.3561956687306673, -1.1417730502677732, -1.3123991504311563, -2.4472314138424793, -2.3744918678999825, -1.3645433905731885, -2.8111646268053243, -2.0405748627197386, -1.9665326707500552, -0.10138419610369528, -1.7009118377092962, -2.5257023270547956, -2.5231260976678405, -2.339788720058296, -0.8746876533074193, -2.3915003180070706, -1.7064896827860454, -0.49629390145126173, -2.724773877763068, -1.8820218252628118, -2.693896404942352, -1.1326892514485167, -0.7911488050785991, -0.8606649977755181, -2.7296296433532716, -2.636142735087244, -1.5606124614447665, -2.4986706286308005, -0.9586459767260271, -2.5544013314170786, -1.350845942131065},
    {-3.23397666618186, -2.9892225498976637, -1.3018028939605746, -0.9851933920274882, -3.1573359948203152, -2.7203221872545518, -1.8276794719786411, -3.013427138313588, -2.393535323073811, -1.7583587311671744, 0.17298013192056721, -2.0178226440907765, -3.0900592217579903, -2.722312902217601, -2.988808184573423, -0.6236308386113889, -2.432620809981016, -2.3284727184779075, -0.48658590528410567, -2.798122783341263, -2.0562455017099235, -3.1721785155917828, -0.8236678939063793, -0.4957639549633969, -0.49441500691928325, -2.4553998742420986, -3.1071348737923556, -1.2183747058501344, -3.0856833007856648, -0.7636408789578479, -3.2561083015033896, -1.468517951273025},
    {-3.2854177385811423, -3.2742344737820757, -1.121193920700095, -1.3256801280517023, -3.4047954389940465, -3.4488125978301305, -2.511189345370372, -3.1008799408883285, -2.9072211208393477, -2.5600925154455263, 0.38151767579168605, -2.3362250230137382, -3.081031979439522, -3.3429946499335705, -3.556744559627093, -0.4132501394706271, -3.086174149087923, -2.75159359782439, -0.37372680123654184, -3.242516791566803, -2.279276092270054, -3.651010075827122, -1.4730777131771349, -0.144831057401102, -1.1506973535789773, -3.141151668739317, -3.499779180321365, -1.1441836691143255, -3.113735933979548, -0.2833273916989446, -3.454174777068411, -1.2070440643488345},
    {-3.7841547267118805, -3.4513105079571993, -1.2125522770115595, -1.13104527871522, -3.948781209597645, -3.631526235747891, -2.3635168117291276, -3.6834281578332497, -3.253573261498885, -2.429368398072008, 0.13951188704824113, -2.5494304899158045, -3.5187367589455114, -3.1617110739869876, -3.8373644002008414, -0.4449714916756491, -3.432400384691066, -2.913137499552358, -0.30141876930224726, -3.066557380286062, -2.3716076217250093, -3.7452165641804553, -2.0793028010221026, -0.49153713706597874, -1.1211908293878408, -3.2211215452879554, -3.3153632150252026, -1.6666200598169096, -3.324279645246407, -0.5283453846214756, -3.5810623576420193, -1.1036065783633457},
    {-3.626563628095156, -3.3959110736023663, -0.9069032242925154, -0.3530980727076713, -3.6738087416992378, -3.3354183275505873, -1.9771731436711362, -3.357932411421487, -2.7399763139795676, -2.5420313605939864, 1.0987574452902873, -2.1422161035942997, -3.3433496154781728, -3.2633103118835907, -3.3919352037691435, -0.21941427028262833, -3.131588790107096, -2.7435305621848998, -0.1734427119406602, -2.5057119463354653, -2.5297538745469352, -3.7931817236935825, -1.4167787345884757, -0.09398111285549927, -1.2285899977294894, -2.719447373276312, -3.2570807693437973, -1.3301566029260241, -3.204101624632682, -0.016047402874518123, -3.641768717615463, -1.031489854150644},
    {-3.6252867589663937, -3.171390332508381, -1.2201109762740006, -0.6018965437160824, -3.574840324591943, -3.092186125795727, -1.9286756236497744, -3.2437922795514305, -2.9485861314740163, -2.655509984304215, 0.7907130346419492, -1.9122985507638812, -3.3017285799970657, -2.998681804249373, -3.549820285090216, -0.7742806378600618, -3.1805671985762354, -2.9475901573617422, -0.5087193005187046, -2.0344680641352584, -2.4337756529797216, -3.5122820967847486, -1.2545857390623298, -0.873612768324992, -0.4723044401991929, -2.4208543196061383, -2.938791613318664, -1.5421157044049112, -3.580230642941359, -0.27342141113553353, -3.5027706501720166, -1.611013373787474},
    {-3.334974703415942, -2.7332868202233604, -1.0645448332261576, -0.8893007070564791, -3.0832324881439686, -3.0563539307376355, -1.430405923416502, -3.1568875369197045, -2.868834400362419, -2.2744558194533533, 0.9446373039516339, -1.7836013724202728, -3.269392261349817, -2.889222114620273, -3.3459731194380837, -0.14106002432870235, -3.074664446913884, -2.3805049978614, 0.24978971786514137, -1.6085410332134575, -2.578234472487342, -3.2051584313251995, -1.1207479277037815, -0.36504309922043787, -0.28268598449239324, -1.853740366086415, -2.8947795993457985, -1.6447539596454612, -3.3035133854668, -0.032901880453902535, -3.2792713851788675, -0.9407231711675387},
    {-2.973364831061484, -2.9924257819382616, -0.412938526825238, 0.4037274220095186, -3.039519776546983, -2.1644791531298395, -0.7715367808764482, -2.9564807438140677, -1.824548083507335, -1.1885942648882657, 1.209143826704166, -1.4690287313190782, -2.980281074825013, -2.2487012472527863, -2.266328976744389, 0.7430677538847359, -1.835311610381376, -1.6232719454273734, 0.6496897998605703, -1.4572317091924099, -1.504423036559523, -2.750278060556121, -0.32400713811398735, 0.3086311188074453, 0.23408785134658255, -1.7976562234873712, -2.2432000020835505, -0.18924784667441724, -2.6857925913567358, 0.9900773177635696, -3.1806156587792103, -0.41315003474875317},
    {-3.400725259878869, -2.877030844475072, -0.9191959596131736, -1.05583981740745, -3.386386477642985, -3.24187396653833, -1.9972224899498976, -3.269037091073515, -3.1330092368204454, -2.6909361821574294, 0.22246540709268087, -1.3938457146977912, -3.289690237663479, -2.4147827692873025, -3.3071284155529064, -0.3684474233665012, -3.1081211489138068, -2.879050396485839, -0.5062900230547577, -0.9043242950541599, -2.9780807205456234, -3.4087118274717296, -1.5447761470933938, -0.8654362084197695, -1.0879878571107795, -1.5279670704018586, -2.487754592662546, -1.8776804202700452, -3.6864553692178283, -0.2932463686133674, -3.599458595804226, -1.3024937866626545},
    {-3.8961582544815507, -3.415064824879265, -1.0332744956478137, -1.7915331400897765, -3.829126948645174, -3.7341419776782048, -2.5177014147213153, -3.683115262600037, -3.6646045036623316, -2.9408114153463263, 0.4082279549361108, -1.7816160990663212, -3.377748431676886, -3.157231962315514, -3.8872616574697894, -0.4951521021287169, -3.510239800275705, -3.0012284975528187, -0.5811544680661548, -2.071539156328693, -3.0617774886358715, -3.83066352182408, -1.2826265721744612, -0.8387709889720384, -0.7218664709073112, -2.481287577757146, -3.3237185031546166, -1.7680336581955673, -3.3322330993407268, -0.7025114890939063, -3.757262666347312, -1.4475593636097093},
    {-3.952230148393424, -3.769359104311282, -0.9743154272080924, -0.8719018197777795, -3.800906397286456, -3.428183530331795, -2.1089084726584297, -3.495317022923434, -2.8214402925662068, -2.2002836286415235, 0.648384428233085, -2.5326185712364877, -3.3217851817277273, -3.7888025594052683, -3.5539221831502177, 0.0026187093116275748, -3.1996413295808024, -2.4740501060742246, 0.23133233398799602, -3.2247430842247065, -2.2131050361773656, -4.116065669149902, -0.9815257242866046, -0.15904333484611158, -0.27673758367751206, -3.386380493171674, -3.7099444411117357, -1.1492914545508455, -3.363048671051265, -0.08483793398411475, -3.836677435268081, -0.8688352270646396},
    {-3.5535762932425063, -3.2153000248350034, 0.9918784964562278, 2.532280911758397, -3.74764750771812, -3.0473310406527223, -0.05143128723141574, -2.9424366776391113, -1.8967328575776614, -0.9224051376963492, 2.8218907957155275, -1.4108020565143642, -2.5509593928285192, -3.2111429450509137, -2.707503894647952, 2.4247610961328325, -2.417256492276133, -1.5639398344124893, 2.183540924729626, -1.5831636978370642, -0.8630899029057212, -3.516639696665339, 0.7500448818357299, 2.292981788882539, 0.9497656758657103, -2.2708261026332095, -3.0095479319362677, 1.13065090429258, -2.620905196287835, 2.4809232313223535, -3.6986146938739446, 1.6805580265288824},
    {-3.62556972883494, -2.595011146452278, 1.520705102440439, 1.645063430569131, -3.646578401364698, -2.814797793298333, -0.8873902521998351, -2.596495899153347, -2.7582741069409926, -2.498380888224586, 2.817108030260502, 0.31377452135324524, -2.7171159561868525, -2.2031160721056238, -2.9885497984163534, 1.9380865947371861, -2.642377169926075, -2.8437499256880656, 2.362216617918458, 1.374551805173362, -2.4697019008352092, -2.99852742901748, 0.3964753338872641, 1.97874491883885, 0.720791283839228, 0.03754575917253174, -1.3642877398924247, 0.10167406624027797, -3.128746110555229, 2.5790885850217355, -3.4380791106220383, 0.4116476474140623},
    {-4.132747327733673, -3.5378045459384087, -0.5430455360026689, -0.48183347825179207, -3.8133162895426187, -3.4219239292437087, -2.503839457021234, -3.4223311636569047, -3.5835722843766105, -3.3867367443183523, 1.3122937829322692, -1.1761797697351224, -3.622189689785958, -2.879566933065434, -3.7225140925793467, 0.1418523444087591, -3.5192307207763394, -3.6257279937181024, 0.9416647094490418, 0.14451523844533345, -3.5670936929931605, -3.680982093108495, -0.9338188673700234, 0.14907405078303437, -1.1490716339451683, -1.6704916615477021, -2.5224271763033843, -1.6852689959640172, -3.9820455936760624, 0.9784145068355146, -4.075656905097941, -1.3948462336456209},
    {-4.060272990225455, -3.555953076921722, -1.093389791510882, -1.1517326423949181, -4.033962413072099, -3.7234607303547156, -2.4425231115065507, -3.8607139558000556, -3.7093025967174067, -3.117105951260087, 0.06822631277517249, -2.361971043929816, -3.878070471571569, -3.5868962806873586, -3.792396520219257, -0.6264337222492313, -3.553709412094673, -3.3105243994641502, 0.00010901085626771705, -2.2812120406555616, -3.1440895630836434, -4.205781527859301, -1.8548293100692037, -0.884532847853572, -1.810206337143802, -2.9942758575409174, -3.218790254961868, -1.996360672946671, -3.7121579443774424, 0.037281598205295044, -4.0344499106256935, -1.5436072683472544},
    {-3.984398539694247, -2.7025854007031027, -0.3217074500977821, -0.3744740636978384, -3.770426542807545, -3.539588518562636, -2.264820295145169, -3.695271256710974, -3.494166775565106, -3.4852098528094517, 1.0656248805997555, -1.0347499716459843, -3.7493279514346716, -2.3442746406045347, -3.62392980365581, -0.036010736194616595, -3.5972880531685236, -3.5081088455087794, 0.6380335998702762, 0.24815011026249573, -3.269927325634618, -3.273392749857814, -0.7655924235259317, -0.23196006879380546, -0.6160804285967749, -0.9263110010816673, -1.986267485931943, -1.7677108781981246, -4.0877408812009675, 0.4815533595024488, -3.6921052585107237, -1.4965695998239705},
    {-4.118075881946853, -3.4610871530996565, -0.4817523879168947, 0.015487056372263603, -3.859107515212286, -3.291424017577983, -1.6980323911619402, -3.601437155474083, -2.892358377170405, -2.72778998200227, 1.5116472893451152, -1.6090046187880103, -3.597960699284757, -3.0667090724194246, -3.168059429660955, 0.6520713411040455, -3.0304702667164505, -2.762131453648191, 0.8928227123263551, -0.6862239487751608, -2.758040958614541, -3.5168168291868507, -0.40933412121789, 0.4417874141030899, -0.3176092337419375, -2.336293550279045, -2.290281981496575, -0.9991084965731413, -3.9171411879992255, 1.2216524669801256, -3.972462733963183, -0.9160096033170212},
    {-4.12835392655158, -3.6890230184126307, -0.7318576407077604, -0.13517089255820716, -3.8469931455875033, -3.733054600582743, -2.340436296580443, -3.816236143882844, -3.4929209445135205, -2.716700930021922, 1.0019838855020926, -2.51016295597963, -4.172328009317386, -3.090613963203097, -3.9924887968846363, 0.13709457625948585, -3.6170651154663362, -3.0539699192047873, 0.20886169938086557, -1.4246452137428927, -3.0989733146378975, -3.8361803662923517, -1.1774485708367666, -0.36137034219505243, -1.0183858113175248, -2.976297655071341, -2.543572917971292, -1.2174499537360064, -4.101380919147087, 0.7702688008730539, -4.346638131255243, -1.1867095795951907},
    {-4.055270947360246, -3.548001194249892, -0.43649181999100845, -0.5564938330637701, -4.187763829571678, -3.733985394298173, -2.2437188626635765, -3.592954296117203, -3.590611291247449, -3.341811341448238, 1.0289382889612262, -1.8232427177319206, -4.057024695924234, -2.870588745654765, -3.662138024484406, 0.17102267893186385, -3.358652234462955, -3.493967540409551, 0.5877164729920343, -0.5349865780972706, -3.116975188405801, -3.6923633226164574, -1.2373208207101687, 0.14194319790765764, -1.0092871814180018, -2.045803255240492, -2.496679845868441, -1.3626564785059792, -4.0297068976047346, 0.7509841227699865, -3.973955431020519, -1.2501255981714556},
    {-3.893732299172613, -3.485361039482512, -0.3619769093745467, -0.03696504017592465, -3.6376761785311627, -3.393640734203699, -1.9181042409290725, -3.8483748035651253, -3.3931101524431826, -3.024653641628805, 1.8060324413884834, -1.763035509936212, -3.81871354386626, -2.8637200881830664, -3.535537824323527, 0.952526593555517, -3.4104283190352174, -3.377178459558142, 1.0021537242632834, -0.22367231557726963, -3.349711253628916, -3.4881277112459297, -0.8177982468115921, 0.2910012466551618, -0.45097177578320347, -1.8135389115075256, -1.8885798909867029, -1.4315752220557147, -3.9767738884658526, 1.1376830554732027, -3.7835948782655127, -1.0374834191004267},
    {-0.33306245467023227, -0.5121307616050148, -3.218635981922613, 0.2739887843855582, -0.5996816361867088, 1.2864519564836572, 1.459369352150928, -1.6131090570547284, 1.027864620185805, 0.49510809965580377, -1.8443104586697663, -2.2636270525800857, -1.7266989754804474, 1.7588993108080506, 1.1633136180827868, -2.1646480262080856, 0.8271707717943342, 0.34094149471560864, -3.1040432815096057, -0.692858283463394, 0.04973845310743116, 1.1549100713683569, 1.6714207151931566, -2.1258008968703566, 1.64837590999734, -1.1295581115712068, 1.6507172493684419, -1.3347030525812416, -0.9706255242782982, -2.012151223865671, -0.8115316261753749, -1.6062669138755683},
    {-0.49249122827840525, -0.43813227243389347, -2.8548736567134894, 1.4906645930728193, -0.7290813667698279, 2.105838866392385, 1.6911841156966891, -2.0005703928667513, 1.7965768585645971, 0.7140612872390779, -0.9649894483300795, -1.6025654475948707, -1.3808678217816577, 1.9638827650722486, 1.5357843902307182, -1.201779500575367, 1.5730948321554876, 1.1316236214179936, -2.1065959459831984, 0.08178853728449642, 0.4779001004839073, 1.1297108153314812, 2.751715836507051, -1.7987878640115145, 2.1943628767753816, -0.3851596924294847, 1.7087398660956907, -0.2690925157587555, -0.6758249984464014, -1.4571322159697948, -0.742800202021439, -0.7477229902607772},
    {-0.7867233054108673, -1.0389996746568129, -2.971422624014574, 1.0750711982228278, -0.8223086884764816, 2.079309560605108, 2.03878138986762, -2.4914936131617824, 1.7900794579553427, 0.5271202205148199, -1.131454869721478, -2.5220095337363753, -2.3259791808240164, 2.0657804558683313, 2.086763107454601, -1.8425199961811551, 1.7685688127746575, 0.6994820832474467, -2.1429869902568957, 0.3491924494256973, -0.1149101058484569, 1.4558860338771744, 3.2431791635362206, -2.2400711050215727, 2.8533770678939487, -0.8856730096007023, 2.1868071716892468, -0.6403594124775874, -1.7616322363086119, -1.9872927306420303, -1.6661976496377635, -1.6357969386654838},
    {-0.23592848380117512, -1.0672312103139556, -3.132558636808673, 1.3853355823983764, -0.08037808666985526, 2.131094364851233, 2.3844402057054586, -1.7855162490765117, 2.0677643052299537, 1.1526757702197141, -1.6899880207265778, -2.5157475105221434, -1.7653301174536509, 2.0059231317768207, 2.1333422928609975, -1.924501756783034, 1.9314647196621404, 0.9534501395094399, -2.461777908644457, -0.039346737628849666, 0.31708554268776384, 1.4932443623566243, 3.5259230454320725, -2.2784498328307206, 2.93693558382025, -1.484330539865272, 2.2107431008122607, 0.1505632728389324, -1.0821340601346525, -1.9421384740749008, -0.9043649811358265, -1.3821011282917095},
    {-0.32446581358728743, -0.5476621529982666, -2.481484177313663, 1.2288667445046313, 0.09403019385709253, 2.284537931569367, 2.1948932548241427, -1.6574396375570744, 2.263402689846486, 1.692593776927277, -1.2830162898840198, -2.5255263998782107, -1.0713565077199128, 1.965425309366174, 2.6683250589812526, -1.1442823753408973, 2.3361342118817623, 1.7115341541739157, -1.615150246834331, -0.16463247839620207, 0.5458993592182508, 1.672239022982754, 3.2679531215493025, -0.9753094983306181, 3.2430910483685937, -1.4399182850538845, 1.7879471436118768, 0.7251811448130759, -1.011272828895565, -1.1634502017310027, -0.503848811347183, -0.2717179981105113},
    {-0.5897010218309516, -0.6127610933684755, -2.634759370952664, 1.3690010310836733, 0.12466919872542398, 2.165693643177822, 2.2161220876568772, -1.6433205743026404, 2.160755949985047, 1.3803630105074018, -1.2950412390463801, -2.484027651498751, -1.5090582842913653, 1.9159952474541457, 2.375513708681468, -0.8532996043678344, 2.2469501353231403, 1.5873041947364313, -1.7057615580134593, -0.19892166125189142, 0.3853360951377384, 1.3212935639718089, 3.2568124940095293, -1.2936912478916325, 2.820411877262384, -1.0281412657885087, 1.7741886718053488, 0.2927271536953763, -1.1708599308693195, -1.0775453754978006, -1.1989965608429498, -0.43079432577497156},
    {-1.0079663448292724, -1.2470775776109406, -3.4148129652596024, 0.7596716668870174, -0.6317441639053428, 2.0960350301578186, 1.9855400434589168, -2.2282245986818814, 2.100160989786249, 0.3927417446109981, -1.8263256607941405, -2.701047384176629, -2.1952145673791685, 1.8265023734919041, 2.0685238829109, -1.7689705674513336, 1.6514210602514219, 0.6745644066938402, -2.5595179931319216, -0.38960903085152065, -0.06514897047270457, 1.1799599966193461, 3.005466163298394, -2.2242403845985876, 2.8777179668248287, -1.717740997265858, 1.485012906452832, -0.3156598872174484, -1.399605122531354, -2.1588083719907676, -1.514411912956399, -1.6331333098157619},
    {-0.5271699230762138, -0.5525184173953925, -3.4763896412761914, 1.1459777886052358, -0.2621125509639178, 2.5674052250099906, 2.2682048274656017, -2.185621894306299, 2.617732323667286, 0.8732178398511324, -2.456010699780062, -2.8507432686084835, -1.7918300568858456, 2.4109102950729, 2.7150890988049103, -2.078579869845646, 2.4591814857617953, 1.413986674059793, -3.0502999932892885, -0.3195580091398821, 0.5576967418693227, 1.5126691397340044, 3.533019206199351, -2.1070124614941457, 3.0023431185777323, -1.8054379992946477, 2.0514920723770476, -0.5814622860557318, -0.9820953049091429, -2.0744968305922598, -0.9345569692735813, -1.560113857139957},
    {-0.34159821586385125, -0.8319981895479169, -3.5076858060065685, 1.4852848963143475, -0.13159761174306608, 2.4797196845644396, 2.58663697726317, -2.3607002216287767, 2.391800476620526, 1.2799058679834414, -2.4108301989106176, -3.145085650216463, -1.9034389852900555, 2.1450514610306786, 2.4395841285547175, -1.8681531320674227, 2.3164119269751353, 1.2097336087951809, -3.2400656323751904, -0.03432123732845564, 0.3339266189217566, 1.5749320863520668, 3.614607558187447, -1.9790241780640805, 3.474091289801237, -1.8877204549282702, 2.146153093500044, -0.1514958792231708, -0.8498431850307296, -2.131598243754281, -0.5363941070594686, -1.4407837014048859},
    {-0.7596956554552008, -0.6183159866960006, -3.6815546812047755, 1.6926798902377411, -0.17863059164933293, 2.767740013235173, 2.859374947547778, -2.3590033273140123, 2.3528991209028485, 1.0784346416257218, -2.175482736913065, -3.163649675591004, -2.0880759370415922, 2.441830348598502, 2.660963919200705, -1.9945559147683984, 2.1693952615020704, 1.227372393606946, -2.9247744997509617, -0.09282470006472082, 0.611425345591986, 1.2473228663399798, 3.5629678829619817, -2.090796147201766, 3.3648269732098317, -1.4569689215883872, 2.204408266563463, -0.30626811955773947, -1.50839015821011, -2.0073031745963146, -1.197867821584959, -1.4909973382640818},
    {-0.49039971215752337, -0.7591964285466646, -3.3424922682542406, 1.356626398631108, -0.18789763116110492, 2.523211709088697, 2.6304013887464315, -2.410297085371085, 2.0539693069694365, 0.5666570752105576, -1.4082689759832343, -2.6512696657016863, -1.8933143584410415, 1.9897801267585853, 2.3884419122924045, -1.9881018764379041, 2.1340885465189934, 0.7832145985941141, -2.972411715201652, -0.207503483305357, 0.5087371139140884, 1.1617694716763294, 3.5268592019049145, -2.453161065945054, 3.328820535725274, -1.3873706766903684, 1.83422608595467, -0.4775351393552904, -1.4748825215634567, -2.3037734343412986, -1.0232004154708123, -1.048919810609812},
    {-0.5118509749986511, -0.9672920605112452, -3.4933432518242142, 1.3870224632585408, -0.3309189322645644, 2.72741826461316, 2.6189008754461316, -2.591443181020279, 2.31274617006301, 0.9265615580952279, -2.13464996908492, -3.083327136688676, -1.9894476340056562, 2.363177507251021, 2.4774465716939438, -2.217184220566143, 2.0851046403541162, 1.2104559399726529, -3.366310957089645, -0.12253773100817554, 0.4728310503075951, 1.6726676919735728, 3.3553080405722095, -2.600621362902626, 3.306018955266377, -1.6533049371666906, 2.2472353581098066, -0.6475150235980281, -1.3765129138035435, -2.3852717984128793, -1.1861272690945561, -1.6481476155224442},
    {-0.965243365094955, -0.924859670962579, -3.6616259144963106, 0.565722330073766, -0.7238986187278939, 2.224734372363274, 2.3805052082368965, -2.5250879411938296, 2.126118405552773, 0.9307842895420658, -2.3242994076826564, -3.5156733189348706, -2.0606388489628418, 2.2207298636422665, 2.3980461628385945, -2.395906191404537, 1.8311860758485201, 0.8667010924028771, -3.4070391285659976, -0.8181733521633652, 0.09798934860118329, 1.816385063355957, 3.209877636432342, -2.468474190443144, 3.1783622548454296, -2.075328206288957, 2.405175663701411, -1.0801100105130517, -1.7308375309851327, -2.4834590204430564, -1.6737377297063407, -1.7214040595912474},
    {-0.7389147568309673, -0.7905841144347107, -3.6071969938055766, 0.9685471554686279, -0.4222466208067082, 2.400861263077527, 2.2291664806171894, -2.48568458002174, 2.0584046903484454, 0.8197099108984011, -2.148934338769117, -3.260833390503258, -2.1701437006011464, 2.385400853706535, 2.4703723704440135, -2.72744935246394, 1.7569221841627578, 0.9918037011558182, -3.393900560305086, -0.7253449786020414, 0.22550383155885273, 1.8293944391446402, 3.3420177502463377, -2.7270965825659634, 2.9686375742292848, -1.4043317627152634, 2.1531258778824656, -0.6382233411737461, -1.3239646944122705, -2.371662637662937, -1.5763109760270662, -1.6764922797583022},
    {-0.6985504349625772, -0.7850767232040456, -3.6119428149819273, 0.2344255926432352, -0.5053857951173025, 2.0226593002518762, 2.277675157060616, -2.3071964875823325, 1.5379034356053878, 0.43229375794816133, -2.0781972030547786, -3.1890132911796285, -2.2951433150611216, 2.51342398456183, 2.3898087554967558, -2.6086574135013585, 1.6739835112848127, 0.38560066612542687, -3.2232258767767803, -0.1808084302548483, -0.054471099346515034, 1.5592496245558942, 3.217520109926501, -2.4875287441709735, 2.789603292322049, -1.4877537805188676, 2.624812965462705, -1.320980941478044, -1.6372488761847044, -2.685369668500103, -1.508335876940495, -2.201422961568878},
    {-1.172197184755395, -1.6209931393277488, -3.3732468340464226, 0.6244863211266444, -0.8411663615324142, 2.323083379187165, 3.078732804697248, -2.3353989365760826, 2.092771793638814, 0.8711605376895585, -2.0773304076948906, -3.229390164521785, -2.391863463766668, 2.0671924022814747, 2.4944926437199566, -2.7779499326130725, 1.834974214908005, 1.0425773574936366, -3.0670107684141215, -0.7458330308184196, 0.1659391684577305, 1.3732580228461515, 3.2520308559509483, -2.8747402065614263, 3.0778990398312276, -1.7589341089703814, 2.3876326955237186, -1.1026983825513903, -1.9066371380013694, -2.8455612894364966, -1.496499311634077, -2.1428505470175505},
    {-0.6270328098986817, -1.150249771336208, -3.2292559506921097, 1.7296613963394627, -0.5517568466457942, 3.112462797447956, 3.0941494779270613, -1.867101127441097, 3.0141347130494993, 1.5855043205798334, -1.261667584596054, -2.994676926537811, -2.10937004653175, 2.6412834977062025, 2.7389923801230016, -2.509024529012095, 2.444173893924275, 1.8199212603976427, -3.1133812883072207, -0.2870131366993256, 1.4248742568540962, 1.3819027717856371, 3.942749007462083, -2.2246434680513825, 3.458348481627122, -1.6038719329735567, 2.370650695180434, -0.4376076955579641, -0.929685023730118, -1.9429180117848512, -1.123142764087996, -1.6621481461782246},
    {-1.0615637306763117, -1.1839558328268531, -3.761514428973154, 1.1471044909296515, -0.45789157347613424, 2.6472773403107444, 3.1247420130549046, -2.2975685503963366, 2.6659324021920043, 1.5410988400857755, -1.9982344557093157, -2.944013307720943, -2.246867875171485, 2.5823441972287706, 2.4268882135052747, -2.780084839966212, 2.348107261717143, 1.4843217980494654, -3.084358911082831, -0.05781731274948532, 0.5243670484305426, 1.4755904685154368, 3.7915799381575566, -2.486709517584084, 3.6791786787005254, -1.57583016164194, 2.5661015718910187, -0.7543074970792113, -1.454363704528988, -2.477872246713471, -1.26703488035132, -2.1830003610219793},
    {-1.1341227987052245, -0.9105448457665931, -3.533000623974383, 0.7518154056119174, -1.043996404095145, 2.896061918178861, 3.1062188958580523, -2.3195951076484214, 2.297545032247562, 1.279814535206692, -1.8788307112492748, -3.1101417629777095, -2.2725922950148467, 2.753601225751911, 2.4989708561759874, -3.025194747445783, 2.469749488101685, 1.2097523833199304, -3.2009141947770767, 0.08429849466532204, 0.5346230724417816, 1.7941221870070723, 3.744888279010996, -2.9676046849578768, 3.599874459144383, -1.4027016796761576, 2.7223499537717615, -0.7283296412452179, -1.4700980038733913, -2.48446590781955, -1.4763647199807315, -2.294880143006165},
    {-0.6625808215997581, -0.8029157198675565, -3.5761217677292882, 1.2821079911018898, -0.6411650420179359, 3.251119027470084, 3.294613639951117, -2.248302669781423, 2.9700298489108357, 1.1508305962335283, -2.2027439639245703, -2.813109969290764, -1.811823505392925, 2.7223965391473706, 2.819664796825025, -2.882240055518224, 2.53846980082286, 1.5258387204745778, -3.5007184498441677, 0.15597426171272324, 1.0542412820420772, 2.0361490005505583, 4.115344958182654, -2.845847244855426, 3.482148694731187, -1.2276758877009657, 2.8826763403884708, -0.9785343461849182, -1.3162453950345503, -2.3676448142773117, -1.248278687203794, -2.2430996841830435},
    {-0.6832726121919706, -0.9920852930236873, -3.734451615843942, 1.3888707807760172, -0.3857724214206006, 3.372913401142783, 3.0671489708286748, -2.289335232027194, 2.719461154733775, 1.7085668895241353, -2.662497557870796, -2.9123270002638044, -1.9656972218213276, 2.760023266980145, 3.0822275940892654, -3.1329857691771394, 2.593299028047398, 1.3164250922117229, -3.4100034614712955, -0.13945186784292815, 1.3300224968774144, 2.3439471976502313, 3.6306399544666093, -2.812367946936591, 3.462868616536757, -1.411123458952092, 2.9493483725436485, -1.299870658065058, -1.2819170966158988, -2.794255797189445, -1.5158944186596828, -2.3245667453520635},
    {-0.7352229038394293, -0.7404398448183086, -3.7187842844256194, 1.8030628427813613, -0.7528675701167236, 3.5769843983928964, 3.387648850176047, -2.2987819487741756, 3.023986375175878, 1.723016092002007, -2.127880671312174, -2.7820891792184086, -2.3246208510696937, 2.84104203433339, 3.18541084796508, -3.132980166584905, 3.061962652445846, 1.6830777604575011, -3.29086300039059, 0.022361901416966746, 1.2393411663699871, 2.127796588312255, 3.9085098618296503, -2.8364582206504054, 3.6937842524635354, -1.4240437160099872, 2.678599489689687, -1.313896619472845, -1.652710934999082, -2.5175894814528688, -1.673391092108224, -1.9170940039038424},
    {-1.0889862688873988, -0.9289252393475831, -3.9970057453123458, 1.1949077609811185, -1.0998449141220579, 3.4082206638131423, 3.1661771729873203, -3.190897705657523, 2.7058437100923887, 1.1648407495169713, -2.237714337163384, -2.950527285554974, -2.6379582599668714, 2.942629494137059, 3.1157778875825466, -3.4223154624724237, 2.674728022849528, 0.6978691543784568, -3.5976795915000492, -0.204352768124983, 0.66865892305972, 2.421634839393752, 3.7528968688393043, -3.2885845811510896, 3.5835956990211284, -1.357250397258413, 2.7739540637151507, -1.7104335967148554, -2.3811619490593805, -3.125896531198575, -2.0490070836829046, -2.3238466898369663},
    {-0.7283392820107145, -1.2322680791875251, -3.8738066551254167, 1.0629243800206547, -1.321414381337664, 3.4781227943690127, 2.876711075473276, -3.1513155421982555, 2.7508874944468364, 1.3954254856583574, -2.8432921256641532, -3.2566800159188998, -3.1236703883741845, 3.021543295840206, 3.0214976538365983, -3.1922639884977144, 2.7816071175316956, 0.9816946430381064, -3.801941884493663, -0.4026775676112155, 0.906914578808067, 2.2691163548011493, 3.8465960491998934, -3.3275476409455984, 3.6993681257043853, -1.8804183269469767, 3.0381648763800033, -1.5595591694346718, -1.950798533429082, -3.1786857127004664, -2.078950440329837, -2.266122491638088},
    {-0.43248772798773366, -1.1961095121491845, -3.7027554231470283, 1.4208616540030716, -1.1214946056681294, 3.334561402459546, 3.212649122788295, -2.500087785640648, 2.8208919735864497, 1.2884727201639308, -2.282077080243364, -3.0701659102530607, -2.7278685928647834, 2.792833566591752, 2.8608074547744113, -2.814226700470295, 2.8891264844002666, 1.1679316938480888, -3.60023061475308, -0.07732320296345686, 0.7981174624833336, 2.3630717298862303, 4.109693761262787, -2.6044354326702095, 3.721361578939398, -1.9598490711823406, 2.903388531263807, -1.0077311902053272, -1.5491760785227322, -2.510485199604147, -1.2996484280034293, -2.077364871061913},
    {-0.9682163747273601, -1.487011670193402, -4.008821716139311, 0.9247001741321376, -1.358175268453361, 3.3194002858035376, 3.2406507567815033, -3.1586268337795214, 2.885876282819109, 1.2614507904783665, -2.515522359720335, -3.20059310656945, -3.012890924682827, 2.862490122240751, 3.0669947810274527, -3.0526171991732, 2.482214300476763, 0.6492292582713006, -3.696100747786418, -0.3183067030686554, 0.2512679388839352, 2.1754069434687673, 4.091191733145762, -3.13627744048755, 3.8592623188706816, -1.6438759368383684, 2.9168031558662766, -1.6079490007450263, -2.2028002440491465, -3.121470033955536, -1.9108691996044815, -2.5540290467149616},
    {-0.8731332503113256, -1.125968295438082, -4.197742702590045, 0.7881124991929002, -1.076757472919544, 3.4581684214916626, 3.041675340242129, -3.2065192380492076, 2.9427271655183693, 1.0915326788810797, -2.820073502856229, -2.9850731576891474, -2.924166802199372, 3.0234268331655487, 2.9195111978022252, -3.3710514916633807, 2.7575281500582585, 0.8235582624871097, -3.5340111305244384, -0.3697601706344471, 0.352230836228572, 2.5594618090150676, 4.179474878109118, -3.3766171864414534, 3.6479650619789687, -1.777455729484668, 3.3561416323145807, -1.8171782441825801, -2.334670877645977, -3.1566361478339178, -1.6726832159658063, -2.30264971860845},
    {-1.284749367483925, -1.5478329772404849, -4.030480121384257, 1.3341882382283383, -1.1800787221278564, 3.190290540116084, 2.982082848706984, -3.229870772855353, 2.7226917340932784, 0.8637349895738256, -2.337792644798223, -3.111956646097396, -3.1360057332044597, 2.6947905470661113, 2.966183452598468, -2.953876358693204, 2.53026470264208, 0.5733623969316146, -3.4612766745989902, -0.14651496878858197, 0.6830982441221113, 1.779072318271017, 3.8462965979942125, -3.082613926605168, 3.977478712188491, -1.9568271472267849, 2.863037009161998, -1.6762381601399268, -2.659914010334114, -2.7776451893339082, -2.1586232701747727, -2.7119603183964056},
    {-1.5278210174576092, -1.5862092822162341, -3.894875683427581, 1.2300613859063123, -1.4068829214596765, 3.2545218453519884, 3.310831772964761, -3.3540238273522425, 2.949427062523604, 1.1327760040303705, -2.549752338749896, -3.349471872765316, -3.0941472223943487, 2.8448236509075433, 2.9416076096576775, -3.2283502210720694, 2.8391576624819526, 0.6090254294842423, -3.6012792573758583, -0.17907732998124795, 0.6046495031982189, 1.854192565283891, 3.926699557145632, -3.3651729377579773, 3.8059558050983715, -1.804508110017112, 3.0950668513648076, -1.636654522439904, -2.605912394718206, -2.660621143609928, -2.4743791316588446, -2.6697767890059394},
    {-1.3761105779982583, -1.7229874080220773, -4.021632825016963, 1.1868390774986228, -1.4341193176730354, 3.3961608629706057, 3.250984000455257, -3.0926586016001187, 2.786868458349994, 0.9339498049310714, -2.60002207123211, -3.4023792816888476, -2.898912682128588, 3.0359342487000998, 2.959957778184606, -3.315673389625646, 2.7606164496137118, 0.8665952185875584, -3.5668610451821428, -0.4190368678851863, 0.18253424492315487, 1.9027157257415714, 3.9854560973736026, -3.244291963385395, 3.6308377118528954, -2.11086111382564, 3.0543893476988138, -1.6653589195935417, -2.4457583079913956, -2.8659082221408005, -2.059811639444819, -2.395856021296215},
    {-1.4204878445009483, -0.005742259533279476, -1.3941053069317682, -2.6381460990558594, -0.6693599661345241, -0.771346024261475, -2.121228311109376, -0.9490979220567651, -1.7066484560143549, -2.204189826501243, -1.2295101148013359, -0.15688408376546772, -0.8912643405531587, -0.07798280591933159, -1.528756920789061, -1.865611232192488, -1.3594083095766998, -2.2005182331380992, -1.4044354157754355, 1.9069715840957935, -2.400700638663104, -0.7082406001187923, -0.19765406712372288, -1.5972804906663174, -0.6901803157198533, -0.1826099684792522, 0.3803448873391483, -2.3542717130284703, -1.570465756976977, -1.5090273503390725, -0.8872933985422343, -2.6708588384953704},
    {-0.9890571306266631, 0.33939656100629634, 0.3073674520066614, -0.2296688938005882, -1.274194638895402, -0.5946192218329487, 0.20851909644913105, -0.593720302680485, -1.0370513409580262, -0.22953402844979073, 0.10777404398743086, 1.222234870080563, -0.9115181811627265, 0.14732624266660097, -0.5543288819314636, 0.25683137071968576, -0.7214268083972507, -0.4274804692252156, 0.575991309817321, 1.6812646162491727, -0.5980680062293405, -0.5054136266849797, 0.08029804606755811, 0.46922610406423765, -0.11624215077090388, 1.56394905779409, 0.2821949048975671, -0.46749056943147, -0.9086183735152276, 0.6792264679518107, -0.8916203887729695, 0.1828850643561947},
    {-2.4835998850362357, -1.7727645915664259, -1.0149141483249773, -1.68910547080051, -2.169466280695715, -2.579770007076876, -2.236547545290256, -2.0585709529593847, -2.553786161781096, -2.6006628406705565, -0.1137407973974977, -0.33309891303967104, -2.3611689955542694, -1.6663638787500759, -2.735740158099573, -0.32765896451574794, -2.6593522567086154, -2.6840750194177296, -0.20874424786614243, 0.3360779795121269, -3.080242917446449, -2.128270614763337, -1.1355636211254965, -0.7306952966556328, -1.2121570240737976, -0.3724446225857037, -1.7941059753021904, -2.0278115139223423, -2.243318572852701, -0.13170778585082105, -2.681064632785089, -1.3031619794866223},
    {-2.0946837477610507, -0.8317850963875925, -0.7138034525014276, -1.467865431244248, -1.5155670238925165, -1.9031052342436827, -1.376982708990158, -1.879905980749859, -2.401689478914749, -2.413107940448714, -0.05725449557099371, -0.8645867943278994, -2.3064189753937927, -1.1306146886725474, -2.114242979618404, -0.9571325516320447, -2.652600338031394, -2.3250695387001388, -0.07707794311856579, 0.06825455957897698, -2.3459658923623596, -1.3634044205414118, -0.6116713692866006, -1.345129462591807, -0.6689968050788097, 0.2133422564113666, -1.0065907503115392, -1.9720290890021956, -2.014096574231043, -0.7304888222725126, -1.8483331901020186, -1.6400377779014783},
    {-2.484227401104149, -2.256382413852604, 0.5820912997003291, 0.9855922969433155, -2.887234464952894, -2.1761656364565996, -0.3584012818259518, -2.3931359485300385, -1.537156133873282, -1.377417829934687, 1.2354886567414172, -1.180713406296204, -2.4376223970192856, -2.2741100287918905, -1.7429940287051855, 0.8027579712563974, -1.7923510141032344, -1.1505278248831166, 0.8533583050534788, -1.2133314887020799, -0.7583298394449249, -2.7843152057121916, -0.0022611500683014344, 0.4720284522943979, 0.48593315230444994, -1.1223471174825574, -1.86760921099297, 0.1639765576576673, -2.1005899999685993, 1.0020710742351442, -2.587878239075527, 0.1411202951019435},
    {-1.9997126164284802, -1.8751126443567478, -0.21218155142682832, -0.5818532205736892, -2.4309840442135946, -2.29227186368475, -1.1358595753086609, -2.1500747786121788, -1.83913244574077, -1.4458598615637823, 0.5271038498411866, -0.9701742134057159, -1.9183338096659113, -2.1767134748122414, -2.3032560490853236, -0.08379378306872895, -2.1214785415348136, -1.1599930017630655, -0.12505855325921816, -1.4986550412577822, -1.0741292151850823, -2.1139636103265196, -0.914190450529137, -0.03651216634220383, -0.5043707384191596, -1.3795403494383651, -1.640253205592246, -0.5720050101528269, -1.6355016395383852, 0.19578325352789216, -2.1274324950375583, -0.6606970084890562},
    {-2.456594269700294, -1.9616710142219949, -0.7719783368894018, -1.1820460115948919, -2.7230012959475696, -1.9101014413683495, -1.4395343684307331, -2.6959715701887492, -1.888302569603857, -1.5951531370354401, 0.47890995156454874, -1.8543408743207481, -2.620012332142812, -1.9999531962322477, -2.127770339442341, -0.42665723382910137, -1.7239869937503596, -1.3047357905968617, -0.14513076195859154, -1.8735011146667564, -1.6589712187905714, -2.0731458175339745, -0.4403670986476654, -0.4405509849891156, -0.284192271731867, -2.2445873202053015, -1.983844586661708, -0.741712622987355, -2.180271499644217, -0.14598236239852125, -2.3813174537096944, -0.5896096556794519},
    {-2.311976779665026, -1.175475717320551, -0.28076718572987547, -0.9939543743911627, -2.218043528698303, -1.9178008454149449, -1.0800831914294386, -1.940096577976899, -1.6058498933359957, -1.304896509529202, 0.40635070845792115, -1.0962109280780363, -2.3171982516581004, -1.3834309676334327, -1.4315638540756657, -0.1967371517328764, -1.6375907107885548, -1.295314226699968, -0.06048157337534587, -1.0561636131912717, -1.5581487819371682, -1.8036937160890325, -0.8028380868986065, -0.021689487022876795, -0.5313442921799764, -1.1581482901191718, -1.6755227067696483, -0.9370892052047116, -2.0068576401821416, 0.054864343369183464, -1.961896745142054, -0.738874602810005},
    {-2.294006846684446, -1.9069216426493312, -0.2716653115713841, -0.6069951632218208, -2.528176212666295, -2.23311465617357, -0.5209875036690303, -2.468861629644305, -1.160997495377138, -1.0645742001176004, 0.740254597364249, -1.239676760497717, -2.5754386269028884, -1.7850069943184739, -1.9163378186361493, 0.11675901009180353, -1.6987559506112782, -1.3692597771670538, 0.46137274928907235, -1.3504344623503366, -1.0965301867568427, -2.495904123495103, -0.6097288944345759, 0.26381505634746977, -0.5287993165291237, -0.9638637291249001, -1.9925662487394589, -1.167486317944133, -2.424667863452291, 0.22940237826676438, -2.6340527425573317, -0.6898419209647069},
    {-2.6233274225612977, -2.134192734591331, -0.048273740796328596, 0.3661377188769309, -2.698908108153629, -2.0722479776097917, -1.1378028187594813, -2.400184270835981, -1.5223233710245296, -1.081022088640559, 1.541324304950091, -1.0511023531336787, -2.188060003903625, -2.0751704314709136, -2.235382776086661, 0.6705754970835918, -1.6739148360338425, -1.8886870359251544, 0.8334423420013964, -0.872480734525711, -1.6283997986528072, -2.4663101757564965, -0.40144710888277596, 0.8546255114966546, -0.2704151857346194, -1.4433453428899066, -2.489279376775671, -0.8046002956420597, -2.334529211233993, 1.001919012119157, -2.6502738511358923, -0.1792714700851824},
    {-1.9851117249706447, -1.285011968327699, -0.8349823731264095, -0.7960605880996542, -1.7394108624558802, -1.3785545851164884, -1.0719942296091887, -2.171012757058486, -1.3785492261206769, -1.8955400887993998, 0.24317131223337635, -0.5365148830586707, -1.685502496905173, -1.1163949990071504, -1.5079542249779498, -0.40242127654313775, -1.7105447678701449, -1.4350060149958084, -0.14276309069444934, -0.885826728862316, -2.0107894602578384, -1.6072024945944396, -0.9306571238932595, -0.23913002224474245, -0.7608351697467677, -1.3824981067263267, -1.6260587897701388, -1.3790954429732973, -1.9381773887267648, -0.843292197615192, -2.2158437758657836, -1.0902553794237317},
    {-2.575831805355356, -1.985774961303101, -0.7637337110574096, -0.8740976267023906, -2.2185833435184894, -2.2034918730335114, -1.5601075146973582, -2.273317624526501, -2.070639863906068, -2.009095165385408, 0.7776392849303735, -0.950896646517417, -2.1932332740333713, -1.6349101782768487, -2.5161749414853682, -0.24702953945447906, -2.3945759418940304, -2.140084704122927, -0.09685106980007187, -0.8521144495922423, -2.0645665145152496, -2.023813348285188, -0.6855008971902595, -0.5059700255625467, -0.38873423158423476, -1.3341716800305012, -1.7463538805992669, -1.0981634279502699, -2.4717480000970666, -0.30159219394966513, -2.321453505130395, -0.7707639156425272},
    {-2.6096448277878745, -1.7880209764466861, -0.920275346769425, -1.5933400060850422, -2.749102644391121, -2.302033369490225, -2.213951326311902, -2.4750641990961655, -2.383199336159217, -2.2998697510378148, 0.3248106871524011, -1.3898999201379483, -2.376122728748248, -2.186009801891041, -2.3802524444560773, -0.42032255081327563, -2.5606400345342104, -2.2546403822972727, -0.2980199310139333, -1.3349146934380796, -1.8868584780530193, -2.281007018999855, -1.1960813180267031, 0.013200245263102173, -0.9203913728169636, -1.7267062075395225, -2.2324062453971636, -1.520208219908987, -2.3719625741677435, -0.05754504652406092, -2.536582189134342, -0.8134272313222295},
    {-2.779202953507003, -2.347117579345548, -0.31458216226702834, -0.8999100951162583, -2.974988943873434, -2.953184831479659, -1.9548331271804311, -2.3952446090753834, -2.646305754385198, -2.133386689549973, 0.9839332872064853, -0.8980398322602657, -2.6700770900820947, -2.25707367780162, -2.850773473368036, 0.08642981287766537, -2.4886329099852826, -2.5239168423713902, 0.3727774990985806, -1.0710617313134878, -2.123287743105716, -2.510138347897454, -1.344068728003048, 0.0848189875989038, -1.0438681914800072, -1.338155657431126, -1.9313440547886973, -1.2698498719152524, -2.482392384262183, 0.049970629322492986, -2.792381499572749, -0.92247449534399},
    {-3.3336412289435144, -2.581220444607698, -0.1438025818651694, -0.011761819284191753, -3.1148762251536333, -2.5301340408977855, -2.0788311575456726, -2.502817753282748, -2.701039569883846, -2.133054071600459, 1.6551510492493722, -0.6591027936106982, -2.6825773392540717, -2.5559875640743175, -2.7545224265137276, 0.48025719768200537, -2.709156432726495, -2.7375162191287052, 0.8844000277941587, 0.19750614068438652, -2.1056704126584833, -2.9876243085793717, -1.3353636193197367, 0.23919913094238646, -0.7840453043953899, -1.036286095751965, -2.083762765601724, -0.7631487243117765, -2.885939317346922, 0.6960273093980531, -3.050977795144674, -0.2733518059788193},
    {-2.96152608527881, -2.2773386118158396, -0.3798401534520403, -0.13696892649076053, -2.9175607172404194, -1.9857497397948478, -1.7948920624792764, -2.2910360802319323, -2.40984409565846, -2.3107409324370933, 1.2153449705586536, -0.7175129124398073, -2.259726087373809, -1.804714333751472, -2.3205574344512465, -0.3421857607595004, -2.5328962736156386, -2.7836207033856106, 0.11860257341405434, 0.08516337809974402, -2.5160280302869964, -2.0902960077326935, -0.32355481115276047, -0.5450286926212085, -0.022752300411360664, -0.447963661043348, -1.2896084449673644, -1.4191806401158835, -2.502134789035095, -0.21600106695208934, -2.727583164630954, -1.108731772720795},
    {-2.6070440966009123, -1.4248333862943359, -0.02095590053264516, -0.6027264830688368, -2.7374559599880395, -2.498262939230042, -1.6719727588507582, -2.416346240039467, -2.2538416061607833, -2.430732348830891, 1.4061916909753025, -0.030660381974078242, -2.2717173042639636, -1.5632005002951408, -2.5076708280966624, 0.2677007237603244, -2.6342993984807013, -2.3913749517082494, 0.5725831435987152, 0.33462330206662394, -2.7837745274867203, -2.044975833504285, -0.9097965705897942, 0.01582670619726101, -0.278933411639309, 0.15170493987491002, -1.5853583319629416, -1.6487735130868582, -2.6755560106030587, 0.3090728659864373, -2.7344956829006257, -1.3163819430267623},
    {-3.2366166742666658, -2.079376455010165, 0.5477186039868913, -0.03831274252774432, -2.9184848185487775, -2.30872586168724, -1.1601387516979336, -2.5828844375666864, -2.6143612899861948, -2.271039426086179, 1.619306795419654, 0.37859146790919024, -2.8846341582039674, -1.6417488243249836, -2.5999049456490066, 0.5570838010394397, -2.603710328747743, -2.725099299948524, 1.2073747419426826, 1.0851464100385473, -2.8537783898340296, -2.079780117127051, -0.5523627261431977, 0.5279910277027069, -0.055389060020170126, 0.09945564296091411, -1.2811795661765606, -1.1890987165342484, -3.1840371589550145, 0.9689836031070199, -2.8508592808191775, -0.6696092033079962},
    {-2.999337431374033, -1.815665975125944, 0.32773574461086696, -0.11007682765185531, -2.9027663891710223, -2.2082204341724623, -1.2350554409542718, -2.5074704499464966, -2.3274655552564054, -2.3874821612982546, 1.1125795626196051, 0.33495834486976506, -2.6162737947594623, -1.2361798082428326, -2.1583815427471564, 0.31158658419369767, -2.6433562030902706, -2.805212068991449, 0.7317450642567269, 1.3413807399762903, -2.7176634390991286, -1.8632644667373501, -0.6855690664862928, -0.13975441723495208, -0.32676264240957564, 0.2895964769416624, -1.065810457773778, -1.2989535357875135, -3.252754529055004, 0.6817210434421066, -2.8292834546972077, -0.8286625522617317},
    {-3.101702828055161, -1.991066872654439, -0.41690439516756245, -0.9352046480124393, -3.3104576794223655, -2.8905401042485224, -1.9707215886902147, -2.877896311183997, -2.950540694064495, -3.000703339480312, 0.5316557118724817, -0.4931494289547926, -2.847049691504071, -1.9840888436333457, -3.0447863473161485, -0.04937199102248195, -2.8262645233712007, -3.0293977548166495, 0.30404335467617705, 0.05399224229705683, -2.7267979514211893, -2.6107167335070054, -1.2342468047361639, -0.31888876556293605, -0.6985243560313733, -0.4396138596120868, -1.7946322435209128, -1.9284489414038022, -3.222949723788594, 0.013551187512909554, -2.996800825090229, -1.4314770930924803},
    {-3.7691485186577007, -2.7230460492367525, -0.161351616144584, -0.4709094470063662, -3.3240491288934795, -2.626164093446285, -1.8742340135887385, -3.261543412398707, -2.689668900967757, -2.916493546421881, 1.2237730655381902, -0.48829301392756935, -2.9892265506944815, -2.320076171158435, -2.924236858663524, 0.4697148652010741, -3.234321491377089, -2.99819239608375, 1.15831186032037, 0.459493653882528, -2.747627975855111, -2.7739685835357397, -0.38268543445405223, 0.18003097373510313, -0.36195639183334893, -0.5962250426806376, -2.004500248212192, -2.145389452802904, -3.389038670766007, 0.47510815441786464, -3.5182266627679044, -1.2877262963025824},
    {-3.615110039709543, -2.1197366561309496, 1.3133282891842084, 0.7583790556826304, -3.3002547100249155, -3.080360411599552, -1.779144714427252, -2.496915134994302, -3.148021482333999, -3.7098446263980467, 2.3214958204146288, 1.2052954062409642, -2.9318615690103624, -2.031720667527966, -3.363626019361268, 1.4559296034602973, -3.57807057251903, -3.762796747369111, 2.2568808954617223, 2.327272685950384, -3.5361626018602283, -2.7949582932176114, -0.3812170934557372, 1.123637341394757, -0.29260887615963344, 1.1269615934503296, -1.2561926295043593, -1.679754543638793, -3.3743397457457536, 2.0330679093279573, -3.3634576137920256, -0.7215900648039669},
    {-3.272631794096209, -0.95571180544101, 1.1792595402533173, 0.5249268811130346, -3.125439960654511, -2.5286237388976347, -1.9109683297832056, -2.3816072736971576, -3.2819715667526426, -4.098161755543297, 2.4456422582234065, 1.8415600332563031, -2.420275289214514, -0.9666442202503365, -3.0085502453775708, 1.0031023437362707, -3.3938550902930085, -3.9423405226240513, 2.1596081624629933, 3.7490182086008113, -3.7817648680741986, -1.888846551870928, 0.05838507939374649, 0.5636743066895001, -0.20473941524287811, 2.2192637456294104, 0.21844911671097703, -1.7490391500938707, -3.3268327124838124, 1.9222094752684173, -2.6941057103943855, -0.988047611315286},
    {-3.8015817266197867, -1.8916247220536493, 0.4680881270307478, -0.4046147217648673, -3.243837239538889, -3.172478391235241, -2.5270547585003884, -2.8419914320592365, -3.2941200820080754, -3.9078605391615584, 1.2548008869125888, 0.9032952652809865, -2.8272823382795647, -1.7132503640381502, -3.239462976945395, 0.33790795956918257, -3.4555445506073452, -3.9984498491851217, 1.2647980783720072, 2.6410007955887207, -3.7122973655862346, -2.5066364553026417, -0.9016407887988028, 0.14277841067729355, -0.9762040244902042, 1.0643800636777152, -0.7332071045893042, -2.2598081837762263, -3.523719773325026, 0.8893361370580704, -3.401318036849677, -1.4039803318775754},
    {-3.774904183757088, -2.881149178687918, -0.39681029892409986, -1.2209009410211096, -3.486881654453541, -2.9515181314084327, -2.532284656668494, -3.3159962428011736, -3.688256399768918, -3.614079203842814, 0.7388271792134723, -0.4527359173455695, -3.3366589146744503, -2.3116439587958735, -3.585230102053693, -0.20975790908386988, -3.2712735739750585, -3.7035185441091465, 0.5358246349883604, 0.8525558761657426, -3.6717641155366723, -2.8850044757006676, -1.087733414896573, -0.8396197690583403, -1.2133428791363094, -0.5908344552612372, -1.6584167459482049, -2.2091529706887076, -3.6001739681766813, 0.2603062806183591, -3.7133853861803097, -1.8314523060549353},
    {-3.5452520561193763, -1.9097459277204745, -0.1972198675671761, -0.48247038372295387, -3.2190875688108394, -2.802117255232234, -1.9769263624052815, -3.2379876660063465, -3.5554156398537047, -3.946983233972154, 1.3035002311997241, 0.3870314004472529, -3.2433661388116097, -1.4448648328615785, -3.439704676626551, 0.07087626837709499, -3.681380666789826, -4.085019451265336, 0.7946346106703873, 2.448112579994973, -4.061645774225586, -2.114300880941571, -0.4340387532519848, -0.1507643980526625, -0.43793839660985207, 0.9529416642286941, -0.45664681113298256, -2.7588458160140634, -3.7435467534313296, 0.7815478332452812, -3.5380251311038733, -1.8014285794737654},
    {-3.534616753795609, -2.198057733769647, 0.300048256532411, -0.8716747295037478, -3.361549003309226, -3.162479428742842, -2.2258542199237366, -2.9610169687078858, -3.5597770146640344, -3.5947387547170644, 1.357956413225084, 0.26046721983698895, -3.284431099911275, -1.6677840835602644, -3.324813303269312, 0.5055675661332287, -3.4042750474662906, -3.8040393084287967, 1.27971353709729, 2.4270283340932703, -4.115915122856807, -2.790337946568833, -0.40922816997304134, -0.19086717743508974, -0.46434100771071574, 0.316506662257695, -1.2437252455267256, -2.5248255756681988, -4.069260269303252, 1.0956827055541425, -3.628457296910056, -1.7426354399217252},
    {-3.7532943438658597, -2.692085910061231, 0.02813794400702544, -0.6165776555676281, -3.460909256140763, -2.9935185947824237, -2.6440099890266806, -3.075284731388824, -3.3785464670289302, -3.586149323053193, 1.3218316283595346, -0.08554549918627871, -3.297239073490021, -1.9569400659637497, -3.569702270161917, 0.3379933210676919, -3.6158658694663965, -3.934314104078494, 0.9482731249244276, 1.9129848866664536, -3.7095756094823504, -2.6097449768633134, -0.9475361114058537, -0.34018150488348503, -1.1044059806702622, 0.11945010312789912, -1.3387277990138222, -2.5441977891497154, -4.037158129544966, 0.8924451682403428, -3.758804897127856, -1.7692285749299377},
    {-3.536871757882215, -1.9779668381719222, 0.22673331556497522, -0.494213506637618, -3.5044486801920423, -3.134430551630542, -2.2346010353083834, -3.1801204062688533, -3.5630668129741894, -3.9730586303995237, 1.3381008766441582, 0.3728980642474302, -3.529271566471015, -1.8214850963052531, -3.3395083230426836, 0.4257116317655666, -3.447316026011934, -3.9260610201385027, 1.050194881778882, 2.7310834963988397, -4.191610552704775, -2.6522553334657064, -0.7323344751055848, -0.12627551320685296, -0.9354278091694117, 0.7244527250121396, -0.8472800189776308, -2.345606642921041, -3.958762567121717, 1.1129148325401355, -3.4301996914231268, -1.6391084352316614},
    {-3.694931102337712, -2.0242185231816263, 0.6001591752661467, -0.6881379229985177, -3.2709883063350196, -2.868633478559395, -2.581275328619526, -2.8061640277971263, -3.57435038499062, -4.161177246926723, 1.7245320001491922, 0.551445843845504, -3.073754519794206, -1.461432469776867, -3.4255691621477173, 0.5487099051083225, -3.513958396824297, -4.111549389088353, 1.3855203278664807, 2.9144125442225195, -3.9897751805877144, -2.461679001366232, -0.7499795635020834, -0.1821638172751032, -0.943056392178367, 1.142682864956311, -0.46443263787269007, -2.6635971971495103, -3.889812284027437, 1.0366036670276197, -3.2247430117241933, -1.6416539187276187}
};

static const float b1[32] = {5.55236884830498, 5.27188252017019, 5.417913391573789, 5.575109688762632, 5.406574791046957, 5.540125686650678, 5.5497095344107485, 5.489204523976186, 5.533187796324654, 5.258743880008622, 5.642948522182999, 5.711001370322184, 5.446354128684354, 5.36081252688846, 5.635664334365067, 5.408757272008385, 5.4419003965716755, 5.208120575822049, 5.4453537295070396, 5.856617712487517, 5.2283784934414035, 5.58914228026278, 5.661804348916844, 5.465460252665373, 5.567120927920434, 5.641524998984805, 5.663747305904816, 5.252218411073615, 5.421005009226417, 5.424304111663738, 5.44335321674128, 5.418126009168932};

static const float w2[32][16] = {
    {4.742210309773877, 4.96415227405604, 4.241593703939006, 4.720461906717883, 4.864928983373876, 4.790311918927612, 5.03278782880295, -0.12618944714329242, 4.963623398121321, 4.957565310448163, 4.812110716115878, 5.08469474305636, 5.087977082504076, 4.737269294250307, 4.440723836701289, 0.3364811778143609},
    {4.614617435749397, 4.788592814055473, 4.250605489909753, 5.044519622754435, 4.922674724731257, 4.717712155262084, 4.617735173394068, 0.0669723010266283, 4.904370508448663, 4.744111934908705, 4.860273936940246, 4.816743840732866, 5.027195405761553, 5.030374273717791, 4.991967502191461, 0.5847758162962272},
    {4.714580415733112, 4.586802030418652, 4.492845268071714, 5.0285622177520475, 4.981382761269032, 4.9446281487850605, 4.954153487259925, 0.18148494013409086, 5.291830504248247, 5.2301500166637025, 4.849340111067998, 4.84739437984656, 5.18718486549794, 5.071115105765356, 5.233017011550313, 1.0114812742319041},
    {5.041235701717842, 4.960192997281117, 4.824420826077808, 4.976294018292885, 4.674772121125225, 4.5469001195605845, 4.550913697280683, -0.3536109702284983, 4.904544236812152, 4.876939240910741, 4.80201639313306, 4.810385788335184, 4.374166288885043, 4.532233508913337, 4.424639529135214, 0.7195940256661946},
    {4.637509174613467, 5.021785849672504, 4.566476425220659, 4.960809962454774, 4.8561073951178475, 4.9552073065463675, 5.149896551024565, -0.09090956274839082, 5.0475311888768415, 5.120881795014795, 5.1735275042441256, 4.944669231452297, 5.092516560956192, 4.91883729457871, 5.097589885804714, 0.6686194080787634},
    {4.975442489992182, 5.2742018194322595, 4.74211472656786, 5.100548451801824, 5.061815861869422, 5.2869591092173165, 5.166740919470722, -0.3678506316773377, 4.973900405887675, 5.007461608225645, 4.774595559796839, 5.231488067932545, 5.094079936102091, 4.9779917460148155, 4.860475208841648, 0.9681375015538697},
    {4.591706888792372, 4.969370369717804, 4.871627120153991, 4.493059381826906, 4.843678886893589, 5.164355091216966, 4.98786023606217, 0.14666053754320332, 4.7156857050644465, 5.121822250586732, 4.940027077386068, 4.729160913741069, 4.5816723823383425, 4.439260603925463, 4.44425220214292, 0.6444627819999237},
    {5.114063852095282, 5.169316671956805, 4.664624153888751, 5.010883618582427, 4.540967670416973, 5.099106392158209, 4.879790134899477, -0.1402135033079911, 5.162441463607028, 4.626683858142277, 4.751322518526586, 4.994049306079087, 4.746333442469924, 4.81402006604957, 4.722859560449125, 0.36483312156877756},
    {4.570494067553491, 4.568640167806213, 4.350224908751287, 4.640468919967377, 4.391009251598701, 4.825605263618687, 4.577103221149285, 0.21603374118143578, 4.71284952702882, 4.759397402460037, 5.012445063703415, 4.734197123725747, 4.3695585765812215, 4.4151671786629345, 4.780097482866667, 0.5734801693170676},
    {4.52221916595992, 4.453829222677513, 4.223403013431371, 4.800625979812869, 4.270478850381364, 4.792018457939275, 4.604579461393006, -0.24004835652894768, 4.7589898561725335, 4.4839013222150745, 4.957987722765986, 4.92312680274934, 4.6704824726695255, 4.360707216916941, 4.477565852058755, 0.8427162808409612},
    {4.67734299869082, 4.28800907025738, 4.092536003045454, 4.19759344600498, 4.660868661043472, 4.255018922770679, 4.589309136543757, -0.2730933660717686, 4.720460133058611, 4.740107552881556, 4.698192017632026, 4.499712417413826, 4.620654899474284, 4.342302174372322, 4.431559299822449, 0.3428298790899354},
    {5.025768541398327, 4.699991891571124, 4.471579532478787, 4.806375166189377, 4.977085012053452, 5.219753524826544, 4.939199702344258, -0.3126033984197779, 4.967634784419774, 5.435223511613453, 5.164635502242126, 5.204860903504789, 5.009655251795068, 4.938218873450552, 5.248687981927664, 0.749941946169897},
    {4.707061784813534, 4.562367522218006, 4.579064258302924, 4.781778608094333, 4.996944445968031, 4.949075837019252, 5.047115785088952, 0.009352772562694475, 5.156672787704381, 5.117257325767558, 4.712925321898589, 5.05010495061402, 4.840385844906051, 4.9669116067581225, 4.908122467465889, 0.8146023759750287},
    {4.8251856727117, 5.4570739311466765, 4.580808591121894, 4.937313117290004, 5.024367982405549, 4.937577615513715, 5.076514312307745, -0.349881291191904, 5.156064468877423, 4.968826989488539, 5.051154697940868, 5.081590618229048, 4.965770377691428, 5.194117571352466, 5.22488150272975, 0.8883346744821893},
    {4.967706444469196, 4.8581616903015465, 4.541831219487069, 4.923698589569985, 4.815854633533474, 4.984696061941429, 4.898562073555103, -0.3380810742232855, 5.113775617833926, 4.731310564196875, 5.000062939022008, 4.85796006866476, 5.209396360904822, 4.739835204695237, 4.7570288792331805, 0.5695044041067765},
    {4.604763375105395, 4.660125671527754, 4.675416400316067, 4.401988848749883, 4.316351820799986, 4.76573243607104, 4.653144786498326, 0.07138606089653406, 4.971848227829379, 4.3986656993641775, 5.051045228547022, 4.547773571479709, 4.481449136940074, 4.711114030949392, 4.454517968410628, 0.8839090564834268},
    {4.931007374367933, 5.145782596991877, 4.478696810944363, 4.8997932512264875, 4.471402027074766, 4.8604573550826204, 5.097961315470677, -0.11941729369721858, 4.921979254056595, 4.9529311539414875, 4.901364605846577, 4.856067803517023, 5.091296436162503, 4.64998341173397, 4.476242885776578, 0.7290303921083938},
    {4.465290167093129, 4.6136949309897775, 4.684450705381128, 4.786204239140415, 4.698960572850693, 4.7471268746578055, 5.021924602948598, -0.17287102213745573, 4.68177533772586, 4.9636119158040355, 4.6586889181630315, 4.425691199022904, 4.4794250940410265, 4.701482359000687, 4.823179403762998, 0.45966141068635497},
    {4.65445538118585, 4.317777826141979, 4.313761572620814, 4.439858244095469, 4.7276234350987, 4.998075061400648, 4.515410382235622, 0.0619672516596575, 4.767373657668731, 4.720671377694497, 4.611890096184176, 4.461332900856371, 4.816282694923259, 4.8795756095196445, 4.72528335873783, 0.544289438238943},
    {5.178501218098673, 4.963038715418256, 4.97129050036165, 5.250697031859474, 5.423364802915545, 5.66588367094048, 5.450443110494063, -0.31985492549414285, 5.1320495461959235, 4.9791995918325425, 5.568186049433287, 5.369820469092323, 5.030004480887555, 5.497136855168158, 5.465225480926513, 0.8801373347632735},
    {4.6689324660190294, 4.766908398237279, 4.364278104862354, 4.693495666563399, 4.77647522452539, 4.422611519993482, 4.859212495236753, 0.19581623419196684, 4.566010212932949, 4.63739016823427, 4.842592259007329, 4.5795332182976285, 4.567218350484881, 4.246529673186633, 4.394703173517247, 0.6462795229255054},
    {4.942785151771914, 5.224026826169725, 4.421537107042528, 4.837588566545307, 5.025877530522702, 5.00045084222096, 5.128328298018578, 0.23269209973100866, 5.1827513153193765, 5.327305069875374, 4.756438687991515, 4.94653831460884, 4.907902178602397, 4.921525959917009, 4.9877106235924735, 0.4524570705459426},
    {4.876795471181619, 5.053475911053486, 4.64226860567475, 5.124758679176677, 5.047146526539173, 5.17516707731795, 5.080597876194709, -0.1798478046359105, 4.640913340777354, 4.971236533787424, 5.251373264840478, 4.9242117381584265, 4.945942402275617, 5.09014671333896, 4.700483969732213, 0.5825240717676524},
    {4.901907574113723, 4.816162411022491, 4.593044979298217, 4.305231591394223, 4.433785252586644, 4.907789348503419, 4.866908675009852, -0.07122976965582993, 4.281627207437742, 4.633194042693431, 4.978548277571528, 4.555850808953856, 4.618320167174417, 4.466844307810422, 4.843095908361787, 0.5293332900919768},
    {4.853048613873401, 4.775594987699242, 4.910588434677718, 5.237775369394004, 4.84682744147694, 5.011430791126181, 4.8625680488806475, -0.12992442847662433, 5.283145947573517, 4.70208148263169, 5.231057260436498, 4.9158602377206755, 4.6824725331242565, 5.048914356773206, 5.136136241083332, 1.1031814585059998},
    {5.036958069988533, 4.787743938665789, 4.661342463688999, 4.807649045862545, 4.705880069898562, 5.422250821555456, 4.985707541445516, -0.10498582436722562, 5.06755824829195, 5.095987116045013, 4.897649886593134, 5.030202468444544, 4.989615025992384, 4.850879208238101, 4.798554361384235, 0.9747721395420921},
    {5.427143277795949, 5.219621267403323, 4.474342158401704, 5.093045881679604, 5.08622032697651, 5.11907220626716, 4.807078262481139, -0.20933357980682593, 5.400570727667768, 5.468561385802266, 5.096912904874876, 4.832355469125757, 5.27440685680525, 5.132041509691709, 5.3164931241781535, 1.036710349592902},
    {4.472672861087385, 4.5209253536089795, 4.513615279618306, 4.37473943508328, 4.664310112441406, 4.621076355198809, 5.034680146453746, 0.1738311871330889, 4.760321612303658, 4.64865830796327, 5.143703120133961, 4.727026622937518, 4.720536899787173, 4.633567001292809, 4.90930354954644, 0.5854177410646987},
    {4.692124851189179, 4.569328744859233, 4.774732236891469, 4.622016145149202, 4.409004298493564, 4.881958942906117, 5.054506402144297, -0.3203081469460335, 5.190461808993129, 4.92457432339296, 4.6109524080953515, 4.985250885981184, 4.633051673484295, 5.028578612916309, 4.918357667798103, 0.7491831568877539},
    {4.648297047517863, 4.8979742395523305, 4.199961537673423, 4.502443433751228, 4.937991012276701, 4.525670361539915, 4.770051003425838, 0.08071996741702342, 4.806842299512086, 4.385938658492537, 5.036206627468725, 4.503232755305794, 4.617023801593326, 4.484157639795283, 4.7279255491434435, 0.36552500169235785},
    {4.999637030218757, 5.03190230312399, 4.626007940292137, 5.077291717891199, 4.566173379966487, 5.16274184437682, 4.749992822398693, -0.38862618836124085, 5.021237730730032, 5.219966234922844, 4.667420781235451, 5.014051003288105, 5.168761901173084, 4.657918863781233, 4.79059730885399, 0.8348501444298203},
    {4.788706467031824, 4.509733050155137, 4.028434637497806, 4.462151484570156, 4.296019521156462, 4.829894425395436, 4.915693609505501, -0.23595873650641042, 4.789352337930828, 4.413339290241085, 4.753735218016829, 4.423383352053364, 4.7060332813783825, 4.6654457011180765, 4.2416948294502195, 0.28600962124830354}
};

static const float b2[16] = {4.412414896842363, 4.622056319343787, 5.034872448467665, 4.578935721998677, 4.8436387466792965, 4.6781359424836015, 4.5847329297483475, -0.058518598094204184, 4.636994538110668, 4.648733305850585, 4.548106048606949, 4.500747543239676, 4.7811026531575145, 4.80187270452541, 4.75477521469168, 1.0721217967154408};

static const float w3[16][12] = {
    {-3.742165157473181, -3.8606254523400443, -3.738293626761628, -3.7564892275006323, -3.469020562256306, -3.1535174893464184, -3.749921678086151, -3.8473615415011144, -3.4612841063008384, -3.5191540470077065, -3.9978631337456942, -3.7100241721520937},
    {-3.578929475195393, -3.166158274230402, -3.3678641619486225, -3.1833389259007734, -3.994120076917681, -3.3212795120809973, -3.345485175896297, -3.678087788550496, -3.3347887758670254, -3.5342231543701823, -3.568268169208159, -3.16703416681835},
    {-3.1001017116441933, -2.945507181806412, -3.244248470429687, -3.684781090312422, -3.2658075954521943, -3.6710351112477047, -3.559875164667514, -2.604213115293316, -2.8306139552689933, -3.5049348474603117, -3.295248457674104, -3.270186510470654},
    {-3.7086869745531863, -3.9188715212653373, -3.388000753310213, -3.9877576217902537, -3.247388865986094, -3.3065491162171354, -3.8873790321362907, -3.424439299427392, -3.250646717248482, -3.075373771141337, -3.7936503165714397, -3.3842478630008976},
    {-3.7985691804005373, -3.45504440948097, -3.565970014687817, -3.5307940540174942, -3.525950767806244, -3.706612538665566, -3.545568619600116, -3.637961556687823, -2.9022993738541225, -3.195740224921216, -3.1309060752269704, -3.177581808107667},
    {-3.397743379891793, -3.1681180635899095, -3.2207317613946413, -3.7944862703413733, -3.7343259540832894, -3.2495310387831804, -3.722572939840634, -3.8094745247652213, -3.883554761510034, -3.5444078823915395, -3.6533384242295397, -3.5723312812392676},
    {-3.438187446042014, -3.5973946375887844, -3.3503713779758084, -3.240121968643472, -3.8769467778054407, -3.837467672880103, -3.0065655736013106, -3.4545002925010038, -3.595352550830701, -3.8600515411472185, -3.221070692809164, -3.2166904928570554},
    {0.11827405509696931, 0.2720261916705508, -0.39908851137176504, 0.3869777475887052, 0.10902981589717585, 0.2849752484976961, -0.013912773202931918, 0.19887510839314887, -0.4370998898662381, -0.27606237269498274, 0.02639599287493645, -0.3869374367526845},
    {-3.6387542788247638, -3.7234474801207282, -3.3886437344311187, -3.365364192082459, -3.160274824926612, -3.741519623683482, -3.005942046590032, -3.224142143256411, -3.543982023696499, -3.768909444203933, -3.8030757786954448, -3.8982614787194647},
    {-3.1923352691220734, -3.8905522499930143, -3.4988865389733284, -3.8103375947854694, -3.439004741555839, -3.4753547939480565, -3.782355684772658, -3.776237140614806, -3.491625767706665, -3.7408581895896127, -3.8312074500201083, -3.5426070902690694},
    {-3.717541647982456, -3.2693106331567066, -3.72930019175476, -3.4097519380035974, -3.5920890064595477, -3.8561269630755945, -3.3156127129306174, -3.529741812933808, -3.6715728246658803, -3.7292411422053795, -3.6001629012679954, -3.430969162373164},
    {-3.6193541689199416, -3.3620278759623425, -3.764229291334042, -3.766997416240559, -3.8230131570718027, -3.8692795400547864, -3.3349823190909516, -3.6056065861056963, -3.995148299999571, -3.307302436397638, -3.2562992781659905, -3.8382398712345713},
    {-3.385569428372739, -3.5407656833043784, -3.851952361343087, -3.258066295811463, -3.2468427421189907, -3.9011299057339652, -3.9081834150348578, -3.56030410450053, -4.070332053253221, -3.9375259382057983, -3.9126329702939775, -3.6605455379488565},
    {-3.3063675050375227, -4.058948253957722, -3.4908840952305105, -3.5247142714663586, -3.8033950301306874, -3.3035140184838503, -3.7486201936818206, -3.8311118950639296, -4.002959546323392, -3.676074983944506, -3.2277454942550974, -3.9519103537872016},
    {-3.8925240772301124, -3.294963333441198, -3.9031110377767146, -3.282142555476591, -3.312339288594832, -3.109459274984052, -3.7640058954089914, -3.5440682097220493, -3.3816540457470636, -3.0077811511913386, -3.177837495127697, -3.6282331204707012},
    {-0.31480219855281527, -1.1142716044295349, -0.47455780753900867, -0.43767269870511594, -0.6675941333789672, -0.7480775100405684, -0.40719042933079536, -0.816015326558514, -0.6177845617759397, -1.1119996988731682, -0.7896903051287836, -0.7493877793357151}
};

static const float b3[12] = {-1.3512972265702503, -2.02149538877022, -1.6878806280964302, -1.7633613960826662, -1.407256749077066, -1.715113325880042, -1.889028849911642, -2.3311777436386807, -1.618506661943178, -2.3684022545189247, -1.8259455072121797, -2.0199558528561257};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
