#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.7880314068053123, -1.467092473001288, -2.689566145740483, -1.1429888690035872, -1.861862542928443, -2.6669326324948908, -0.39360395778951185, -2.9463076718065677, -4.138816727291079, -3.7626047818767048, 1.6276576729240781, -0.606047398275863, 0.6039496615359028, -2.8514330788557603, -0.7035671092473554, 0.15452143827706252, 0.1315809882368161, 2.9427711021372653, 0.9089782436207423, 0.7209037793568341, 1.314694652060519, -2.160552681038331, -1.012099658690357, 0.7101308108525336, -3.2134540749174603, -0.038792330507652927, -1.9668618526915749, -2.4788789234104334, 0.936426515605298, -4.234841214990622, -3.6381170260608338, -0.4759810053742181},
    {-0.1803415459286799, 0.7148720848589454, 0.6628338669126074, 2.0536003974462704, 3.5283223576152642, -0.3771646800198926, 0.7683154990073872, 0.34876971136075363, 2.13900812259474, 2.330464832656827, -3.4159882046854944, -1.0342882044140886, 0.47329081907479215, 0.8638207381050717, 0.4950596137004221, -0.6411489482879578, 2.488852191445092, -2.013450669042291, -1.614718504277724, 2.2873504874670703, -3.2934928862462067, 3.70219941694446, -2.7959467872786647, 1.4388584411215524, 0.548968233374184, 0.32154212200042254, -0.7291111359546469, -0.19501194348493095, -1.120907622153699, 1.6858706314791068, 0.43129361079881084, 0.32076552389726126},
    {2.532717064695065, 1.4386065345502987, -1.3767699907017243, 2.7315853334754725, -0.12300279214987282, 1.4464285377122494, -0.10776535528397416, 0.892881692543082, 1.0734080248105857, -0.25159710429057247, 1.4640348491680353, 0.17982164366498848, -1.5657500172319023, 0.6556139680778098, -0.8989496574972056, -2.5225241485346177, 0.3629504071003555, 0.5991436183613941, 0.45540839218780305, -1.8099097950261427, -0.7956722379272668, -2.764463563704476, 0.8072836693095722, -1.1394024456094125, 0.31006995768750745, -0.7038873429251858, 1.7306167543556736, 2.3013966238042056, 0.9532617896388386, 1.1551311282528283, -2.6645927487462977, -2.3701683843215613},
    {1.1730166200824295, -2.773653795822726, -0.38069711263637596, 2.1083537185804837, 1.8029370072123603, -0.1308675033662025, -0.49462086954143525, 1.4525745045772835, 1.1356931826980254, 1.68412249194963, 2.0156423493726874, 0.1605384217862093, -3.029897789080319, 2.1969307453702456, 1.1224391543197907, 1.9494265740696661, -2.3332361100266423, -0.789060343364132, 2.6515808451241973, -3.2183574741402468, -1.738121443299141, -2.1884859052705723, 1.3289553525821682, 1.2353541102390448, 0.9561790943735331, 1.329421200775738, 0.2391396807641647, -0.4542930859304975, 1.1702614714811135, 0.6964710938784995, 0.8767531556784595, -1.4919302285066156},
    {3.240169196230955, -1.1702530387303716, -1.1269419737802617, 3.243386346498264, -0.9253295632045344, 0.8817181691812963, 0.6671262977142538, 1.2693652314048547, 0.442522910449409, -0.6077882100847334, 1.7739368540178901, 1.953555062585661, 0.5457105212426024, 0.7402457883928333, -0.40025364029724053, -1.560880334095986, -1.000525366786282, 0.8528521209835891, 0.9083350253765043, -0.6384549358700835, 0.6243843723276558, 0.4260844683260469, 0.5605484857088489, -2.3150943025596638, 1.1563431636316197, -0.6168132161519214, 2.3993640483436343, 0.05813334038896496, -0.7645462346747655, 0.2607588972304068, 0.32372633094275516, -3.4099033463546684},
    {2.085956406768826, 1.4573082694295016, 0.5060138584051145, 3.362748571892943, 2.1317021294974845, -0.7567304787708923, -0.9344904513458624, 3.713464963356912, -0.8162466427849605, 0.6272922073553541, 0.41728204787684897, 1.8574477230967796, -0.4933373062638944, 2.4259324918404883, 2.18201699850699, -0.6025620858510143, 2.582937676139966, -1.4311523026675652, -0.5343521827632153, -0.6060572881284484, 2.2964712431424723, 2.6213852889491758, 1.9523797869745998, -0.296824573459001, 2.619627117146381, 1.320136548614353, 3.2338579009548707, 0.34168263376564045, -0.11109690720184938, 2.9138711945084577, 1.4350930020572545, 0.33084421952517723},
    {4.457008120448164, 0.8323021731151085, 3.10621045412718, 1.9525825757621322, 0.28553092261626833, -0.023171348387965134, 1.818042595585907, 2.4533125284750743, 3.0562809805104374, -0.037877422768146096, 0.7490087515509948, 0.5170799735263044, -0.1201710435098365, 2.701396686335142, 0.8810347980786304, -2.217871026317402, 2.7174358818532496, -0.2790595020965607, -0.964257629378793, 0.028067571928373444, 0.06569217967296691, 4.30402477611944, 2.3365704101246987, -1.7774444700113483, 0.8462648242789187, -0.47626177313507234, 2.9848508293633196, 2.4944216453106103, 1.4200505204357312, 0.5991866783674289, 2.72214420104832, 0.3536552675420386},
    {1.5548711962646893, -1.723487284337982, 0.5925744779605187, -0.7586119692872679, 0.0584113985432629, 0.2286348097696732, 1.6717648299240109, 2.280742589669392, -1.8021070013562044, 0.9644392195712097, 0.24654266895408636, 2.3311894860965037, -0.04681294480033959, -0.45280617771960213, -0.9590709398190808, -2.191137887864216, -1.169608844129176, 0.10377794795295163, -1.104131499557444, -0.3381094577864491, 0.14070470331967358, 1.2458615886247397, 0.27276130814726635, -3.1054600652862367, -0.03686970796033572, 0.8758667992479043, 1.6348972990075756, -0.672955653143149, 1.0037612797780222, 0.5617803571405146, 1.9583887571775223, -0.6330735498658738},
    {0.2678574412576207, -1.8662025830240079, -0.20822196418815497, -1.9322234355595782, 0.6394474324777264, -2.03719513693976, -0.017049217832343005, -2.34550459210822, -0.3684502415482792, -2.824166474806914, -1.6248929206387122, 1.2832516439446338, 0.23751672793809206, -2.8610712099358815, -1.391222802004059, -2.445610649579652, -0.5259746014706244, 0.49867655853734755, -0.6136217292525522, -0.9935145050974732, -0.504227760753081, 1.3259888598657497, -0.6048627590261019, -0.21851747548549935, -0.563707616855919, -0.6108573839852294, 1.6807235230187754, -1.8314376174035991, -2.246526617871325, -0.05636086011935287, 1.6643352209432807, -0.10110219949747232},
    {-0.5627131125266635, 1.0185331025079754, 1.0164489609742342, 0.6557106460604447, 1.0206601003225089, 3.4685584527821116, 0.507663261721969, -1.9715938352955036, 2.177021263717598, -2.796759640078933, -2.2080597819262446, -1.9427984088347519, 1.4921861393718177, -1.4489509339630569, 2.756561627300315, 2.4622117725697565, 0.5007724122748894, -1.1367620474612523, -1.0577069426619625, 1.8374684371886802, -2.245186300077053, 2.2210974798515353, -0.06235316649913347, 0.8448849827800374, -0.18313728285301717, 1.3334703792373515, -0.09526679689077983, 1.0287873753522796, 0.14081087983618507, -0.20602306086734778, 2.4635216123539094, 0.879436670466218},
    {-1.3554215217736778, -1.1064600009605992, 1.7340437973428577, 3.0152808718766817, 1.5970753373503583, -0.5654082862269585, 1.218448381698817, -1.7853763730536687, 0.8916515424233413, -0.47931722401044363, 0.3731273929032498, 0.1254080577462708, -2.734091585069582, 0.8506447151847428, 2.2127667636049506, 0.7753113752148783, 0.3775638681823863, -0.5653935074515031, 2.0713954615155847, -3.793454086392525, 0.34617604375916106, 0.6489206961201479, 2.095622116940646, 1.916112281519308, 1.328304840940646, 4.883635183002285, 1.0265950472050631, 1.354513328101082, 1.310852956220492, 1.5953505159701122, -0.7458597333510285, -0.5092434033484391},
    {0.058689598670746, -1.8776235962268462, 0.8696525570378563, -0.6592621955672237, 0.39373143222920703, -0.6499841068189168, -0.4357210346759169, -1.3015306959113941, 3.9890874851038993, 3.6095624263904, 1.3000561345095791, -0.4245797456273528, -1.9420783101023333, 2.8058399076890805, -0.7687142292525139, -0.28874027669075464, 0.3214365468500863, 1.5257689387945772, 0.7602395921358496, -0.46459907270902545, -2.7654297971311452, -0.14078408329821948, -0.452866817885658, 1.6670478080731266, 1.6789219344254016, -1.4709824166636762, 0.8685886207540479, 2.681806299890753, 0.37826501990856354, -0.7607129738067056, 2.589116291176254, -1.380363245947112},
    {-0.13828479484856956, 2.3320085357045173, 0.6499388177032918, 1.3884222503793915, 1.414722846372386, 1.201770948074468, 0.0020847963512711123, 2.0538426143420314, 0.3682052284865418, 1.4557019289360182, -1.0954706694307448, 0.23526031153695606, 1.1069066340041185, -1.406525101703748, 2.6309168904624616, 0.3610141823502473, 0.7737602490783191, -0.28857053688514567, 2.1839045658018197, 1.3337932289956713, 0.052426736057052344, 1.194786285037549, -0.07265043918988258, 0.3818897556409439, 1.4186732718873547, 1.0890070896425015, 0.5426627017578654, -0.0039064628482422216, -2.7243211432845995, -0.1757873512186809, -0.4325841215519271, 1.153881528482893},
    {-1.1710044806836992, -0.009103916613656357, 4.340050816291526, 0.4534491169658992, 2.1765473502509267, -1.5486838744654507, -1.8252593950811533, 1.5149800018181827, 0.662471734785236, 1.529037009156873, 1.173661852745164, -1.6622714546933253, -1.7619920660248307, 2.24860402222903, 0.6563268293406029, 0.7416767601566759, -1.033809484879393, -2.803950998683431, 1.048575088718297, -0.11680571749664856, 1.0619940707391253, 1.2019027919610228, 1.1161914459310913, 3.2326945871772663, 0.941821841276354, 1.0350273100329528, -1.1276388959063, 1.0608540625205127, -0.08639903202358153, 1.1431360638165815, 4.298628488881039, -0.6695277696337972},
    {0.9158488563176691, -0.42219508888686896, 1.6797568504656752, -0.5104611342435039, 0.22860266536949547, 0.2584369845804125, -0.43154469822189245, 0.5506557962303247, -0.11626038963873331, 3.4823813373147368, 1.047618226705803, 3.2906343081270335, 0.7565363031117862, 0.9643400561792007, -0.6651699925180777, -0.9058930178972107, 2.0737777375674584, -1.398880686844013, 4.095605719931883, -0.3559620177875462, 1.015877884407291, 1.4562234704432269, 0.9454015226514916, -0.07085811864300474, 2.77273593421533, 0.8478784122384686, 1.0894675278572918, 1.5833745216169832, -0.26652258066325346, 1.7450273642414826, 2.21759497522479, 3.506251084089848},
    {-1.099769684578602, 1.4701611933741545, 0.3554505527721958, 3.0574790314995743, 1.6655199054059926, 0.02463399535667698, -2.1464968714663915, -2.147956546058646, -1.0897351468994612, -0.44193010326317306, -0.7866851896226285, 0.4952713608617264, 1.6430072578694532, -2.031387354450577, -1.5989287646015455, -0.9662718955412531, 1.4032969425926411, -2.9159222444443595, 1.40098332551237, 2.7263134600474834, 0.7344970295737676, 2.7040261963263217, -0.5974198037726766, 0.23391312627331784, -0.7716635221551872, 1.2641784129004208, 0.8099631916478396, 2.558200914170552, 0.20075041749872977, 1.2915027130840069, 1.1284282313249465, 3.4693053241495075},
    {-0.6302027943289344, -1.3860593397583425, 1.507320921546396, 2.662884193493862, 2.330135773022778, -1.3863858595031986, -1.7135194497923543, 2.8562476395314524, 1.7102956472522994, 5.404957563613955, 3.756520623193575, 3.4092444501740444, -0.4055350011290428, 2.1826024451203936, 0.9613228151272489, -0.7078281680968581, 1.043123854199757, -0.9601599646300444, 2.7703329958285123, -2.2514253778766573, -0.30967357414047625, 1.330349532716947, 1.1845787706395456, 1.8371368598829572, 1.7480194213838467, 1.2359536958059916, 0.8465584754419966, 3.420687966504059, 1.8998180780955987, 2.458751777921017, 0.7749481995408436, 3.9211131801184913},
    {0.39235551516949324, -0.747011626553562, 3.6638780143328984, 3.3023729161346833, 1.6262141076233914, -1.330764137429633, -2.019373507564831, -0.382300176474637, 1.8352819768020976, 1.7476291563879927, 0.8937987189758115, 2.045438379626004, -1.0138664373100814, 1.7283397788875405, 1.9102458075976159, 0.7004094188848246, 1.3987791809223806, -2.7603649604651714, 2.7132321048380974, 3.23117813847271, 0.6790418733033712, 3.2363022793774654, -0.027051984301588807, 2.1202754449191903, 2.6984254164756085, -0.14092386973623344, 0.37537616020168424, 1.210232929942857, 0.019360962981512027, 0.3563645399490065, 3.669911736404995, 0.006926657362250717},
    {0.48020211486019226, -0.8965657549721859, 1.3839476119344203, 1.2897651321684265, -1.1792391714774653, 0.1863164352928891, -0.4732612469264726, -1.6670258135135811, 1.0231768861260664, -1.3490549633378992, 4.379044753774937, -1.790790601656089, 2.563032675929577, 2.4386327222151993, -2.1009014726633524, -2.135909051408222, -0.4930326850909993, -1.0022760716720294, 0.9033862190135326, -0.7664708592479068, 0.6191180347401309, -0.32421552186697605, 0.47139000347892995, -0.1599601883400996, -1.112910539833483, -1.0668497557393932, 0.7253179397143629, 0.15888226378212797, 0.6165152657023746, 1.5456585770146674, 2.0221906640555245, -0.2273388701140859},
    {-1.2142623140994895, -1.168262669579098, 3.4838829735944685, -0.8846866817129234, 0.04376972608018306, -1.6242981018492508, -1.0588595578067268, 2.058631660130867, 0.5193566511735903, 0.7565530578666508, 2.8312616842098755, 0.17843111391408012, -3.0846393434280444, 1.3519841205820353, -0.42809160647692684, 2.282108800272743, -0.38132487067394966, -1.6599389941767344, 1.4264097764999994, -1.763472198494847, -0.699134743166016, -2.7187211548037906, 2.6465786654193217, -0.086265992491755, -1.4854475010884154, -0.4647783540831967, 0.21276014026867293, -1.98108562284587, 1.2859022240752012, 1.308798213438936, 3.455032891561703, 0.3019290235693651},
    {-0.6705064817059592, -1.5769064016971392, 2.125036623466276, -0.5333217329171192, -0.15588808380738395, -1.3830085747108805, -2.1371810605692847, 0.9941266407958139, 2.5209915199168655, 0.6385975589782297, 3.9707648151939283, 1.308628710919999, -2.0095371849628707, 3.8186551772640995, -0.7573906861268379, 2.553915164991451, -1.4682480418923562, -0.8321390785705317, 3.7360992553683614, -1.7236282962945182, 0.14804973230763643, -1.4081011922348008, 1.0250804679347738, 1.6484372399408318, -3.1283601203296856, -0.008447085156797415, -3.277126214641451, 1.1394575534806903, 0.391602578640239, 1.2540475860730615, 0.46158168071027705, 1.6559278989214288},
    {-1.7160381161674596, -1.195146521857149, 1.100058038455918, -0.9781156949720412, -0.4649039079151273, -0.11847126716054865, -3.082205924239268, -0.4818429605438491, 1.8970683303126838, 2.3352366962812616, 1.1305766444125016, -1.9691615076527214, 0.30360188890261225, -0.7509529030407985, 0.009582940516817927, 1.6447732761279807, -0.9595632939499542, -3.073994517087697, 2.494607442689345, -2.470392194820213, -1.7195647538713965, -1.9453652392620402, 0.5828689000534995, 0.7700746883501266, -1.6579206003714912, -0.9309723975361314, -1.1903020874267778, 0.9560557305191537, 0.9228412479030301, 0.34892181640792513, 1.0951539276665996, 0.08502823274781258},
    {0.35685522632462, 0.674783870135079, 2.3971421932235333, 0.8504459169478739, -1.5060860869553048, -0.8849015658855419, -1.3551035240475469, 1.3726989649059487, 2.994992006986244, 1.7660830052848626, 3.7417681237062075, -0.11056109924748302, -0.26476299827430094, -0.040871962190307524, 1.8198652197482321, 1.430728649462686, -0.8530796779393245, -0.5080939728538169, 1.1697957070888287, -1.746942947418211, -2.2427284059091512, -2.554713916733333, 1.1010760720387944, 1.493182452853408, 0.907681294721105, -0.23870540725202913, -2.8048694746297484, 1.8141165459290565, 1.6995763374337747, 1.9640486624479065, 0.30982913788684535, 0.6029804057160459},
    {-0.5982542546264326, 2.671598632427605, -0.686259302416566, 0.0459826927790362, 0.20331691730732093, -1.8969813657470243, -0.1308100854741977, 1.2107581691242864, 2.229535159919521, 1.959162694114617, 3.6525794178503257, -1.7566794068154934, 0.7036156705541056, 0.13345442730411247, 2.0377836067444974, 2.530710025259373, -0.9104849432657516, -0.3441428197366374, -0.28181846836702074, -1.8270173733712651, -0.109795154320308, -2.235552209417561, 0.512133425979784, -1.035087878551854, -2.640228353950467, -1.5557169448097252, -1.007934182316958, -0.013642229440958196, -0.5675888906119382, 1.2608206793876304, -1.1408648322967183, -0.18036905874467607},
    {-0.6511385941991888, -1.4443124891441745, 1.1902115105357391, -0.619004466591613, 0.8882090156262934, -1.7680769091841286, -0.8885173369326262, 0.26421067552427513, 3.2361941583774736, -0.8777018745634056, 3.1036597696374777, -0.822775235728118, -1.0075436095590595, 1.3417807082445639, -0.8570492213366815, 2.750501539459065, -1.5604369045219633, -1.516069325294579, -0.17375207126276307, -2.527699388511388, -1.0918390779993927, -1.2579904009610774, 1.7712930792693118, 2.019749693088594, -1.569377552570337, 0.5336381410411025, 0.3594364321830394, 0.18242798723541484, 2.274590755299367, -0.6406346920938509, 0.2740373175961386, -0.6926562838226177},
    {-2.305153200806613, -0.7396188680737461, 2.3795022628521814, -3.98941936598387, -1.8832575351359437, -0.6320619496228558, 0.8484114509751243, -1.6534538517799775, 0.8501322311032229, -1.8687865731877673, 5.080284683907735, -0.16839085925134656, -1.2442218217376126, 1.0984457330959194, 0.6285042965287063, 0.859625381760314, -0.8611620713056686, -0.2574926583231236, -0.7749180119877861, -2.7312874777465215, -1.9317412649279808, -2.561284770305589, -1.855960518969582, 1.0528111301993865, -0.10264261562370568, 0.7616643741675624, -2.4279569835994788, -1.1211075857374653, 0.3959244950542177, 0.5391415099496697, -0.6469567272517656, -3.6487826275294553},
    {-1.3306392838768477, -0.9167670510700491, 2.0936010239252947, -0.681839784189271, -2.3829769815289366, 0.7270544643344387, 0.334866193254608, -1.3809797870949327, -1.425659970563204, -1.1350490707818204, 1.5687756894390985, -0.6301633914147389, 1.1178615206438591, 1.1902219917552688, -0.5397190870187762, 3.2692795091217883, -1.5075498839069243, 1.1599692095198022, -1.693893229811066, -3.860982943111536, -1.013498999950698, -0.6820728542591583, 0.2941623416311523, 0.5872516219340133, -3.008949891918471, -0.7377535615723446, -2.7208639443486144, 1.7226127109780172, 1.713376865527876, -0.1718952416495234, -1.5094239776712728, 1.2523890409976142},
    {-0.1766301875005726, -0.2983127002688397, 0.3576548667192582, -2.224627817089688, -1.066866108292434, 2.4812307497356323, 2.958968897777164, -0.0049005508801835875, 1.3835405505874458, -0.5798877851035462, 0.9067262129394941, -1.411504028711844, -0.016160024956073816, 0.6790068954470897, -2.010008915559034, 0.7816564612672261, -1.8857557978098671, 2.0087787047971593, -0.19806558764132387, 0.04515122485952929, -2.008769974476264, -0.49330906546748404, 1.4255809384197173, -1.375629533837416, 0.703216193270467, 1.3842832953610524, 0.21643363012511382, 0.8625634852485745, -0.11394060317917393, 0.9813755257062835, 0.07631859502570709, -2.600733173852785},
    {3.2434283170603666, -1.5071254283791, 2.3445886847206565, -1.7797420004204572, -2.8564368891334007, -0.9818517670917933, 0.33100941752321456, 2.9075649787917297, 1.3703881574032482, -1.0048202732306486, 3.9898790689975385, 0.003965324060427922, 0.45872767350093024, 3.3516042424654318, -0.9351534598164959, 2.206307398547375, 0.3623289231408062, -1.4424196716571087, 1.140627621880439, -2.3964678292683494, 1.4820430103538251, -2.98683092083933, 0.41474302675718777, 3.2925761955461947, 1.7364501656718745, 0.8544536080359467, 1.7284239019725256, 0.2429604833633633, 2.263791320873018, 1.6729828867762817, -0.2510412271335965, 1.1494420316755436},
    {2.4929583036416108, -0.47902492517780826, 1.0690961646934078, -0.4564131828392838, 0.7154873667823527, -0.6943413788348308, 1.6057331921456859, 4.094874348110973, 1.7001771365584555, 1.037294979132407, 0.03360262438603649, 1.3017205008953365, -0.46600195504942077, 3.9887392999999465, 1.3820633861822695, -1.2530164028829909, -1.3942417490702341, 0.7308254678773182, 1.0538976456113438, -1.7988971615782934, -0.15472625545575105, -0.5109864828588742, 1.0728309546373955, 0.05174276792594072, 0.6892203893224247, 0.34435159959851686, -2.0723059328969518, -2.733199437482482, 2.0721045252660897, -2.1487183106902967, 2.7367962405266097, -0.3458416966437571},
    {-3.0595228608308576, 0.9808532892056089, -1.2485282897378542, -1.3567963854080622, -5.793341907909223, -1.7287487007285018, 0.19980672855776124, -0.510674413049029, -3.001465976081852, -3.4551872867280364, 1.551173183997537, 0.9462386984846765, 0.5272883352685626, -0.752977366612342, 1.7880574263813567, 0.20181628769898702, 0.13151553794991946, -1.6471393140214807, -0.8709185990991288, 0.6686991173444156, -0.5279448380183488, -1.3731295833951078, -2.0664207247572324, 0.0798638168320336, -0.6179576941182388, -0.08319817932987016, 2.8469203328922315, -2.476453740294524, 0.17166005768479625, -2.3972572910812957, -1.603573951165651, -2.649371182131913},
    {-3.9292658501269635, -0.6114732954034044, -0.44314074903873846, -3.016477745059161, -1.2925601693281825, -2.1576680513309316, 2.306546141052118, -0.22508962977493233, -0.9773911771285929, -1.409222933127345, 0.7707628807939041, -1.2674184436582066, -1.0996605735931575, -0.07775508289933693, -0.45137917787827986, 0.6452971798304767, -0.5738237765214846, 0.6948339096039245, -0.5477338660531333, -0.4485685477395845, -0.25076561899383637, -3.1119631822011833, 0.29581843236768934, 0.9973851152578095, -1.847792232377673, 0.0734642158976773, 1.1573204065032907, 0.38161060110944195, 2.055329504955027, -2.8668758637740255, 0.27437326255405825, -0.6208638880634125},
    {-1.7895352623246188, 0.39834199953353644, -0.1790800800869164, -2.658786431689044, -2.822170442544953, -1.8762001362273386, 1.058778830607595, 2.8822941325039237, -1.6440641125562876, -0.40090739481365445, 0.10086904060974279, -1.3253537676147562, 0.39267928083519965, -1.901457378855944, -1.0703550044155163, -1.549432486879924, 1.3453422726213797, 0.34265576888531635, 2.856657102949989, -1.26886672289281, -0.5168332941314323, 0.6422127966623341, -0.133557474275584, -1.0544657307787546, 0.04506352834798941, 0.6739834733806228, -2.241328441257894, -1.2974740229345707, 1.1720228143592146, -0.832110010142872, -1.7709581097136464, -0.8038177975669718},
    {-1.5753336863126135, -2.626140157041232, -1.153719177416162, -0.06835366211852766, -1.1909370446414889, -0.716331011004823, 0.39050619250470314, 1.0145935475036312, -1.089864503664091, -0.6871693950486415, -0.735129598838781, -2.042943424163026, 0.19581817418583167, -0.8068855977676357, -3.927277283409263, -2.649047513667573, -2.1775880094919824, -1.0107998907835982, 2.135782790100005, 0.5349383615517025, 2.0751524665686882, -1.859624663778036, 0.20039184443907862, 0.48725818328114784, 0.5686577521250059, -0.8236847581097, -0.522209504916027, -0.03985235917906297, -1.4177148794999963, -1.7106898422004737, 1.0321468528080855, -1.4323693049465291},
    {0.09110450758101475, -2.024103780536846, -0.9702055613218022, 0.13280500850507532, -3.489340573442323, -2.2771758972546405, 0.479069565777281, 0.13949232961315777, -1.3945911656217431, -2.1744942496688444, 0.7830447614237949, -0.9862358810775523, -0.8230401763179316, -1.9592947530513214, -1.3871511854654592, 1.3890398451292396, -1.5543755548854366, 0.06466016020565829, -1.3838572078343812, 0.6277554751080552, 1.0880843212507323, -1.465663192033661, 2.2551383331642385, 2.6732159083001923, 0.7864459357735479, 0.5261352902444123, -0.01505878194389697, -1.0310264298337821, 0.5487519313521941, -1.1483725778273908, -2.160333517978646, -3.6399996810351247},
    {-0.545225987902766, -0.8366933617256578, 0.05816726120928607, -3.8618538882518387, -1.921900943861898, -3.261104013678827, 2.291663564643472, 0.9854920629530767, -0.5687063949700317, -1.2183672032824115, -0.7283811823000428, -0.9308832777117043, -1.0433842467233885, 0.6765125405557735, -2.101536512735816, 3.270246555529343, 0.6871142401350888, 1.3553229901220554, 0.9973361982519839, 0.24420415481112806, 2.3545946106360165, -0.6424453256419169, -1.6166588904292227, 3.0546830736332575, 1.2357246360394083, 2.036591350350628, 1.5792531424508462, -0.43746270253960223, 1.2588930788086707, -2.0090339261343924, -2.488903172768646, 0.06455616450161694},
    {-2.2946611110650528, 2.2827218213766796, -2.1280357927353064, 0.8050005418537128, -1.9524851966751169, -2.919945872240013, 0.3648436940377293, -0.28449615317855786, -1.1732732491249132, 0.1525681478381767, -0.983116341194872, -0.49672215641119877, -1.413529935494468, -0.6065363681910518, -0.07460361241320351, -1.0495557971861342, 1.2407694242722656, -1.0732484856970044, 0.2516401137348578, 1.6148499151808011, -2.7517710384005545, 0.5001312614296447, 0.5825967501494798, 0.008563509992371866, 0.17164149981101812, -2.8518704417913026, -0.2084166793214717, -1.8191759792543722, -0.44961742457336207, -0.733714050977135, 0.2400682639311476, -0.2206275361036087},
    {-1.4591205358898311, -1.1937415074351168, 0.062053774661275984, -1.4503071714175637, 0.2347887042638978, -4.075266682868228, -1.821858664969055, -1.5003360570969868, -0.08073276675965131, -0.7534498719588518, 1.335893809363195, -1.6607819832617288, 1.4321443223245627, -0.7573277579004938, 0.5223227274119463, 1.3698459548450967, -1.309367571683055, 2.6382823398389066, 1.7062103159960509, -2.5556369861151995, 1.5636935299655152, 1.065001721107866, -1.6529323866159518, 0.058939791575410454, 0.0992151929587317, -0.29337935287176303, -2.008490120992913, -0.6838401787235603, 0.42482781401358033, 1.3748156260584403, -2.2786592831504047, 0.7194508916031391},
    {-1.5358480395874756, -1.9144481888890146, -2.0287071636992047, -1.5735685889115982, 1.2644295951142555, -1.7005946915550214, 1.6566132421579947, -0.5281762716730267, 0.07874908299771316, -1.20817026079156, 0.1888325222868792, -1.23267764997866, -2.1873837220477808, -0.753243724204523, -1.241727027736636, 1.3224001385393664, 0.6392985567159762, -0.5025229709906872, 0.6649670104504836, -0.7848824269877003, 1.7195300574103543, -2.154065405886328, -1.5754836688252583, 0.11747454262165248, -1.3686686792815421, 0.30512201100158326, 1.5565837750988216, 1.4704060599017246, -0.03678652860498993, -2.732517297042271, -0.4949433573456883, -1.3008471111943045},
    {0.14890574151054464, -0.9196055363178062, -0.6854334982177787, 0.3267479627300163, 1.4216920805611715, -0.6522285876950671, 0.790870520698847, -0.9214168827966768, 0.21809396605499262, -0.11565079942954463, 0.5770332125432581, -1.0422495836322145, -2.1945275838527007, -2.557720783985541, 1.9114367920349076, -0.46318405670027074, -0.9824184522869517, 0.14276710350954572, -1.170536926407424, -0.6789175699007525, 0.6859549894137837, 1.1823360658800903, 0.8226084060791449, -0.26320296773571766, -1.0308536923972849, 0.23930540078689785, 0.4318027540288693, 1.75139105855363, 0.8360202095629122, -0.8417146133216811, 1.2823627141441232, 1.3441672087609495},
    {-0.05298982020280614, -1.0661798523108286, -1.1319268233527708, -1.1055444244848414, 0.984090192150513, 0.6626544077591082, 0.9918652036443055, -1.5463884498529359, 0.7295251805221555, 0.33234867454272293, 0.35180481791386625, 1.823297450077392, 0.2913162707005256, -0.014916680569267432, -0.9757568695856018, 0.6102951978504876, 3.1000503823037153, -0.48860113851696957, -0.47225662889682274, -1.0412671471678552, 1.0758408315873007, -0.584635851304928, 0.6538242257329145, 0.07207175731369114, -0.6054011970237745, -2.3872729006609608, 0.2893505437335309, -2.517149398699167, 1.6026524844459495, -0.03677624176224766, -1.211845227395572, -1.3976297642541295},
    {-0.3507022217841581, -0.0768029113569937, 0.7753806931549373, 0.45329543234851727, 0.4092350051028294, -1.1863597056220638, 1.3933439309858018, 0.2283758155462815, -1.7345467642940147, -0.96886984151707, -2.0583881256044823, 1.6149737909758926, -0.827749800180511, 1.8138744385392198, 0.8000156133988957, 0.020261953758005227, 0.425989004060414, 0.9225869298143708, 0.036417472639324835, -0.7130876501530691, -1.0345937859896963, 0.05259054751843787, -0.6500254277214761, -0.3544277169009407, -0.0012588601843240338, 1.7628005497977648, -0.251339508826837, -1.056625413179699, 0.024626667132525055, -1.054395242715616, -0.21797199314590684, 1.2276680238698798},
    {1.7109113814058698, -2.347824185406932, 0.9216147057807256, 1.640483594992057, 1.6067488175717166, -1.975753983070481, -0.0002040631892843664, -0.8018777956110645, -1.1473832402797786, 0.16695454766104909, -1.9596594908609097, -0.6388184161727574, 0.10013559822366025, 1.0620843883859048, -1.7363650073780756, 0.16610213254489276, -0.986757685406304, -0.8895625192225614, 0.3672819068147879, -1.3281047606672058, -1.047062455719389, -1.8535585819269367, 2.487988514734772, 0.14561121580537162, -0.41152035293905886, 0.4945071386237695, 0.05777392346302958, -1.4368901036109165, -0.583476989294546, 2.3629143496803793, 1.3834744439907447, -0.6376523415409148},
    {-2.072763744839461, 0.5088175388691027, 0.15985091244824776, 0.2768350740540801, -0.32837391635064467, -0.7945224024407697, 1.3072644975847572, -1.1787104782446398, 1.7369150206376225, -1.1885763311181867, 1.208402266572962, -0.24440553146009236, 2.019919053386081, -1.8063636118311728, -0.1382106098525119, -1.058326296030532, -1.2896112763393128, 2.1075377897632035, -1.3120280006471512, 0.486477710777124, -2.382776943254824, -1.0472978536018862, -3.82537696845117, 2.9745698130485643, -0.11817279445181565, -1.1790019240223193, -0.7529527421238044, 1.2830465830524318, -0.2739056404704874, -3.0646281379746023, -1.9930360017818771, -1.678756325628299},
    {0.483108089428833, 0.25255935383374306, 1.1940493727650505, -1.322921852184897, 0.6311090459247095, -0.0769252536544922, -2.063103116744606, 1.299301704224848, 0.15275269410257508, 2.3558553884662583, -0.5068045823302589, -1.1330623086683087, 1.0440498608737274, 2.478679600454227, 0.08138099371853409, -0.28807248048833795, 1.2951414442645042, -0.7885270027362391, -0.6132954695940235, 0.5658212050833731, 1.1959126025426403, 0.12891918719063578, 1.9224815645000883, 0.4359910077803798, -0.2420664939043806, 1.3286253965180568, 2.6865389964608464, -1.0241129897885601, 0.21274884465762786, -0.6363848966969042, 0.8718840037242984, -0.8948944540868718},
    {-0.03135036741226089, 0.7484264505188407, -0.9360361571736374, 1.0162336054105219, -0.9539897205830232, -2.150086580928847, -0.45669008601482886, 2.537549977429416, 3.2615085276078526, 1.0187256377630103, -1.088145782111143, -0.32319988101375663, -0.01274620257288376, 0.7139579469046092, -0.2768677055819875, -0.8825167188249069, 0.6056318824741892, 2.0259197542265057, 1.266501945800964, 0.17041868816341554, -1.652028318943857, -0.6095573405900964, 0.43563742375774095, -1.5063747063847004, -2.445171383254758, 2.9419499366313717, 1.43590175771089, 5.7425054377290106e-05, -0.14529543529878403, 0.6420320701706345, -2.082266179011607, -1.1515767498593337},
    {-1.9793564123814158, -0.7979831027770983, 2.8798986087275567, 0.32965589457404254, 0.49562772155893897, -0.246671002925025, 0.7581245545421992, 0.4725738726934486, -0.8892419623977843, 0.9311523878817224, 0.7803850744295977, -3.028470248391006, -0.19916948541202192, 1.2532324923007159, -1.7174141962477816, -2.271543209711483, 2.4115716284743973, -2.00723915223493, -0.9378020988491719, -2.624649622102049, -1.6845397442493346, 0.5953960638208577, -1.3618077098441483, 0.7190997751823145, -1.6734206660776556, 0.6469375387665632, 1.4827830387356848, 0.9058388609183928, 0.8656960020801924, -0.2741348028846118, 1.6569818293480738, 1.7032766419204803},
    {1.1247253975437164, -3.5162423138940606, 0.08256081758464208, -1.9260277305879234, -0.05149938004551498, 0.5418319826418492, -1.3480296405987409, 0.21579691817616092, -0.022812250702179446, -1.536253584780171, -0.5501283959187288, -0.012429756959467752, 0.8517284594325809, -0.6636494400429213, -2.40873655635429, -0.4076758690870995, -2.2198659307149673, -1.375644218847674, -1.5692563387806666, 1.1593985173067742, 1.0515602682225953, -0.9778296569336504, -0.28038947086923166, 0.24881786558672186, -2.1375562274659554, -0.18316143358550868, -0.6555253662057926, -0.7766053420340703, -0.4099078256393114, 3.515455956865887, -0.9715268585651976, -1.5035050230842644},
    {0.7946662217424065, -2.4605486553970652, 1.5711720426270481, 0.16442096666076353, 0.10238929424347429, -1.1979592998421131, 3.206697392361505, -1.4113201063906808, -1.3142634756995415, -0.7069352608325482, 0.0816745364514585, -1.436534938457324, 0.6038665209870289, 1.6377213830920125, -0.23559905097113093, 0.19802759633898015, -2.3005105933267727, -0.747106811303061, -1.375570662391033, 0.43100914103493, -0.2668997003705752, 0.10513523976636911, 0.6033259673904361, 1.8737415335760519, 1.2611766117298466, 2.233975816509745, 0.25826482768744113, -1.8025960654285687, 0.5610871181799976, -0.02954836079166304, -2.5297252719598315, 1.0504032710555928},
    {-0.7734537783679493, -2.786410147397547, -1.1677644323792429, -0.3005766472136345, 0.09697513855426514, 2.9814938959016395, -0.3432435170965501, -1.0486467456081616, -1.905872432546304, 0.05765658498603526, 0.4239718733062023, -0.4818770498363721, 0.8318785250882694, 0.5883391213079242, 0.7906228716027285, 0.12441243335904141, 0.9834700390741206, 0.3855828322498044, 0.41902297393412374, -1.1724581555104474, -1.316334803881538, -1.112706113812538, -1.0954123961904851, -2.072241388284075, 0.6191733430759582, 1.253005692935502, -3.00112665435749, -1.3482402861765732, -0.1594046181010276, 2.176486365684683, -2.881471151958965, -0.9389506348251507},
    {-1.638101716096258, -1.015781003863832, 0.16392746625280652, -1.2483473226596353, 0.7145462783229357, 0.5079815892186118, -1.2138984446491998, 1.324883139257811, 0.7655938888901367, -0.32032916714997717, -1.1943462645763572, -0.9751251136486524, 1.5181726488918252, -1.3428184210149874, -0.3240604662282961, -0.5746330025260515, -0.7246120361482212, -0.31175656544630437, -0.37507749720069583, 1.7148808451635835, 0.9424214855101047, -0.7662339127763074, -0.8789059317914872, 0.6477223359110822, -0.7523168129237429, 0.08620346315508098, -0.2023155855980201, 0.5237761968467443, 1.1205709563971493, 1.0796720752417093, -0.4512314540359113, -0.2879771295235676},
    {-0.18699220373765676, 0.9763065818954867, -0.2741953441155239, 1.3136220493838355, 1.029359052640781, -0.7471652453414577, -1.9538695620431035, 1.2545778658127174, 0.323330626468155, 1.4132843461590499, -0.7434370323963734, -0.9636575463025465, -1.51602750422122, 2.48575427096425, 1.615335030301057, 1.7296996340362685, 0.26558839571974885, 2.575195660830315, 1.8383943739757302, 1.5269501061764765, -1.3421215513062852, 2.0443956379463923, -0.47773552002022424, 0.342737752383876, 0.7667055795307953, 2.026100905600296, 0.43492775661428, 0.1472903138213636, -0.02384050375060532, 1.83434127725114, 0.23405066182609371, 1.3981851663787228},
    {2.341436617901083, -0.04672339779796531, 2.010878961136066, 0.19199680339158265, 1.7065322486678662, 0.7617149541538581, 0.5850511672504842, 2.799248568235558, 0.8658288243455479, 1.744831686691703, -0.710649802616204, 1.5527719747070106, -2.1228009227885702, 2.3075641432275087, -0.4574762926406018, -0.2256820834489521, -0.2017432806723919, 2.4069044802324098, 0.09309809791038735, -0.3369580276582014, -1.8488676026028306, 3.61918797719998, 2.2799286004359276, 0.598092196188816, 1.1335338498136995, -0.5060385889416081, -1.3074552013712066, 1.44578506254384, -1.4612772123292652, -1.2515013036439064, 2.015612735578377, -1.0587814652879621},
    {-0.21302923516197125, -0.8145773088144818, -3.037249689036228, -0.6455061358392985, 0.555074586034615, 0.9580656051911062, -1.480573947595272, 0.1012194895197836, 0.6709042842923545, 0.5142523169355497, 1.9697571427660292, 1.501264782070932, -0.732670646842644, 0.1217288862970068, -2.908117926453134, -0.38097866692961513, -0.9820366938896221, -0.7289323211346324, 0.15956082100927016, 0.7862844955856917, -1.391608646382309, 0.5284417738857511, 1.59789714709431, -2.911219351874061, 0.16462020624285717, 3.0489097060169628, -0.7263129685799988, 0.967539316199464, -0.4903061329749226, -0.5625236861899104, -2.200050025185634, 0.7436912467933193},
    {0.5665228549888619, 1.223891453213471, 1.1851389903965543, 0.10956959591590466, -0.9045036629292988, -0.6738371511411853, -0.16769094910681254, -2.29608543943329, 1.5038010265222053, 0.5222161419892296, -0.4480140243956292, -0.027384112037107035, -0.9729586679862303, 1.2041739696324398, -2.4853256773184174, 1.7405926592384389, 1.1875763237074417, -0.57525948233342, 1.1107078079792418, -2.2753981681618245, 0.16740066868174536, -1.6867739538190711, 1.6881849429693074, -2.155847600984756, 1.153729926013077, 2.542403772912574, 0.11883134322420255, -0.37497375020249113, -1.0687610373270087, 0.7932260294647108, 1.3431522493651529, 0.6365064775455559},
    {-1.8174129663873262, 0.5912527936109336, 1.8275242069007156, -2.575485341711672, 0.3103492537810646, 0.3554560946386862, -2.961049511756144, -1.3669683067688894, -2.0263307886367508, 0.14718389648656843, 2.0201598268307803, -1.769372583509206, 0.589293057971382, -0.9985838608668345, -2.383569349114995, 0.018506755056426613, 1.3118747374990725, -0.7658176083803977, -1.264626841063657, -0.9374495544736808, 1.7023340746389488, -0.31797089586175986, -1.5171160364968446, -0.2399700137000743, -0.27266942982507997, 0.4635037182437174, 0.1171157559672053, 1.4571928466146997, 1.0467379083980795, 0.17416410842821897, -2.3157869632121133, 1.0865337640132409},
    {-0.9794998682385896, -1.6564734742588436, -0.13457027421881007, 0.1547555801174231, -2.347359832055016, -0.258764083334345, -0.3546861873035156, -0.1918690677792484, 0.2348750919283911, 0.7435975495877796, -0.15293314500372784, 0.22339130005118216, 0.09183009077359568, 2.0334596092902832, -2.139864288745208, 0.24823076063183483, -0.05412505677876282, -1.0559832283162984, -3.344391168176354, -0.31178695703627674, 0.22602805736421516, -2.7335824525538497, 0.06667514600396758, 2.088943706685985, -0.9659525123252337, 1.2283765785806982, -1.785406456579877, -1.5315955234178253, 3.9977140466752004, 0.30018656730829674, 1.593213994807247, 2.1088656714132403},
    {3.319453943670987, -1.2902476746265883, 0.95927625698766, -0.5886394206637922, -1.1443881168691261, 0.2917187453685173, 0.9052253577001077, 1.6792481330719335, -2.4692061678701207, -0.22520243514847832, -1.5251325364630475, -0.05454919322049, -4.606548371673392, -1.0441986677899322, 0.02540209960363586, 2.6192633542899246, 0.3835617443732218, 2.1102689696812864, 1.8311998751541212, -1.0115249846670977, -0.5917189415782638, 0.9461870728998918, 3.207416333922834, 0.6714172203216315, 0.2228519837810997, 1.2671565458377971, 0.7838256555473527, 0.06202158079436862, 1.7098059012214128, -0.6589633359890628, -1.1163338338089268, -0.005014923520703669},
    {-1.092800221357532, -0.16331130603988261, -1.2453695835605583, -0.5380846446513953, -0.8368054304196034, 0.062170200681604094, -2.739114417107165, -0.22300081043058656, 2.997098337882511, -2.13437761445528, 2.8485982873787106, 0.4401784295402217, -3.503149740724177, 2.2258407401092493, 0.4617804633631779, -1.3502595722087476, -2.4322442991028272, -1.206768701856925, 1.8310261286977623, -1.7561016462662107, -1.8586156340522249, 0.06447665287808531, 0.29684015447131973, -0.6328030184654608, -1.6338072487659403, 0.7197416446061625, -0.20752481878207593, -0.9147212757783425, 2.190286950551444, 0.27802811148129214, 0.4656592021672573, -2.3090062533338913},
    {2.0593925011311796, -0.9881521441557426, 2.057980815430479, -1.4162267513661688, 0.9917968713077114, -0.18922885406828843, -1.0833474906743916, 2.479719563629346, 0.7756697370421716, 1.7324460508327624, -0.47244103183673936, 1.2125234782274, -3.3303432480217254, 1.2327856296236392, 2.4908577351688073, 1.0840519378463491, 1.889316833399144, 0.34374504273433854, -0.20099511988619595, 0.738695005148186, 0.12363742542316995, 1.0525020124591258, -1.9165095893323587, 0.7282094827595755, 1.7971600522056097, 0.6269134103593539, 0.6171270976139491, 1.3352675432579346, 0.1562285067973435, -1.2383656588613676, -0.48742659572360697, 0.4322928881945705},
    {-0.7060349525646195, 0.6615752339851355, -2.2114050241139283, -2.3832423462943377, -2.2660096285546345, 0.14848478409797775, -4.078291576170871, -1.743485119506287, 1.716877657872704, -0.012090700534837292, -1.6364449451668255, -0.7913794606981427, -0.7849654569618704, -0.3615161381187653, 0.07032123836020747, -0.6563485598935488, 3.225233771505237, 1.1792584306245626, -1.8655465730757854, -1.6412361391152546, -0.12875967153724124, -0.5781135644365486, 1.6654012053981917, -0.4628423138793855, 0.8277691225807041, 0.7855714700779821, -1.6562763447622166, 0.0602336513320658, 1.1399110502850758, 0.17055972363329527, 2.0678139338179315, 0.5621507958039234},
    {1.235779368262962, -2.004782857118838, 0.9001415370374597, 0.008973002825840057, -0.5738130136612974, 2.158151579882798, 1.6760578626085239, 0.453745595639905, 2.306666071135002, 0.8399869011883968, -0.8818983518094647, 0.9952368109740832, 0.35911783909469075, 1.6027373323181955, -2.096231435174935, -1.067428288297269, -0.13305656631126692, -0.3158808063381439, -0.4866827700438505, -2.0265010538937487, 2.817314981931036, -0.14289072942724707, -0.8099039168780958, -0.8296657430098764, 0.11391773035558916, -0.6396251728260532, 0.6428897438946781, 0.6907020722057289, -0.6439435894338884, -1.2058671896845234, -0.7648290359589305, 2.2081707109141395},
    {1.1996068073917794, 0.24417252536176498, -0.2622898672163608, 0.03701120068186375, -2.0341344058235, -0.2082322936881997, 0.7881247701621735, -0.06871540326445065, 3.2072939606355826, 1.5995989516325615, 0.44822230552030257, 0.31451098430452884, -0.8027230270316279, 2.2412659866980005, -1.303990648778076, -0.9741558501291747, 2.1013372760838798, -0.9606898439815402, 1.0920190698127152, -0.2133093634749089, 0.11956208937511077, -2.9459711898072705, -2.3564305252776965, 0.5833098954865908, -0.8965425903443341, 1.2406656311161144, 0.6337589278422632, -2.329753951680698, -2.3539780009779827, -0.20278484748892947, 0.9190313618017133, -1.6278011559234378},
    {1.4798615271760764, 1.2696751614004893, -1.9212944023194138, -0.22059723994941316, 0.2024601610801755, -0.1724832899550151, 1.5084150868436488, -0.04541284113506548, -0.21136454921201514, -0.15681015249945812, -0.06285237422604159, 2.00506433784255, -0.6093198919513072, -0.7073430381927507, -0.1438377167512359, 3.140171590175422, 0.1012023022322611, -0.9461464442174281, -0.40817146575600743, -0.48913207300438527, -2.0580000826650733, -0.9006222554840553, -0.024611970509609466, 0.1741502223965733, 0.17441140154226387, -1.11475239935062, 1.738305333233945, -0.6701077920595984, -0.3893294884454841, 2.8190152084523854, -1.6839648380999956, -0.08853359850437241},
    {0.8807548545319321, 0.2556974022069398, -1.239517154734877, -1.5755275491990124, 1.5191539536932313, -0.603525219357532, -0.7227746309354467, -0.38515833395692484, -1.7202073288296937, -0.4319999079949252, 1.5624555342405857, -1.5877500565402312, 0.8755828621018418, 0.34500296984961826, 2.360779202749974, 0.9365606632162522, -0.28133999884968763, 2.4396759260662, -0.6507498113131891, 0.5885787280153228, -0.3612907336577431, -0.7135061765278023, 0.3861673966246612, 0.24911428744415748, 0.38747212967711514, 0.5729476193713404, 0.4560044270228989, -0.28943004632208985, -1.3151095804440467, 1.802549165050131, -1.8133745842062363, -0.6506126490526165},
    {0.49446259737824555, 1.618933996913796, -0.9403673412835861, -0.11550273626999683, 0.14245773759640323, -3.1674612132743074, 1.3642364096661472, 0.6419340596780856, -0.3627463873535026, 0.9842753527574609, 0.8700761252441415, -0.34730416305764084, -2.00261264320494, 1.182355316754704, 2.527305790447467, 2.5334933559115624, 0.7213973172873085, -0.7242915778299299, 1.7056838975965791, 0.9961904143349333, 0.0026986392814747555, 1.9380719887745517, 1.33831975965379, -0.22232489359883248, 0.9757509678438769, 0.5882200834315193, -2.4195121848240313, -1.3561486776594722, -1.8596790818090208, 1.4000934532996745, 0.2296665243281964, -0.7197750615140623},
    {3.4636394675081226, -0.3023136264353593, 0.3501375466058226, 2.730365165234454, 1.0096727904498473, -0.013795541041755306, 2.6446049200802704, -1.8268463145917508, -0.8960230759452309, -1.734849669413131, 1.1892299960279147, 2.564012662169385, 1.0108721927304372, 1.0598237699085598, -0.5022513530820408, -0.7341072977098068, 1.8659385693693524, -1.7281683115022657, -0.15492510534960585, 0.060233281068182355, -2.730523063469807, 1.9528802690932991, 2.9951304529621465, -1.9244810668720838, -1.4261119052391908, -1.351472805302799, -5.108697083114593, -1.5380886490569377, 1.7614536299260586, -0.30205068330691814, -0.9872818315267582, -0.817489424609751},
    {0.6473980228485308, -2.0157389469116525, -0.17825496464262122, -0.31659531834823224, -0.6600306565833426, -2.2742460392702912, 1.368458095281415, 0.4207560727268041, -2.0647577295025052, -0.9698099012835805, -1.1111337906563568, 0.25803217729743677, 2.126968864300347, -0.742498296640914, -0.9467095247911348, 2.4290982867070765, -0.9135825812724375, -1.3379729339306938, -3.359379962922807, 0.6042165282653357, 1.8711827278471829, 3.2434355398960464, 0.5297375516285716, -0.5018719218330709, -2.8872565251238114, 0.1656038708599374, -1.7149771350388165, -2.183646967360848, 1.3244527319694759, 1.7101095129944435, 1.290201055797455, -3.2652008183448498},
    {-1.360285702076236, -1.1114296478025372, 0.9989542021608439, 1.7438046716274078, -0.5691303797104602, 2.295014772698039, 0.4740898368423484, 0.4548359761920481, -3.3139619091655224, -0.10991166664222121, -0.8576258278752285, -0.7178728575669963, 1.0737558447092703, -1.2688580347657552, -0.9267711125760482, 1.4140546799777363, 0.04057400237685958, -1.7929050212512978, 0.33404334009863623, 1.5108068572389541, -1.6354652735151403, -0.7482981448980608, 1.1913810363285473, 0.6990744001477192, 0.7605600856747381, -1.4100768874956047, -0.3186704279822506, -0.37572695066735273, -1.0472198875340397, 0.8733261720130144, 0.990985880833229, -2.019113992640193},
    {1.3006136651480737, -1.7214309462655926, -0.5764770726536267, 0.36229925431240767, 0.6605602341788678, 0.9039274874636969, -0.04403029695597545, 0.03314891366692619, -0.6725850435711574, -1.6290940667033476, -1.475021738855513, -1.5635530009911618, 0.36198016914629666, -1.1133005590911984, 3.9500698571513544, 0.08603769138045643, 0.4686925292441062, 0.7274709912825833, 0.58644817378433, 1.7523342999013745, 1.639862744833543, 0.8055795691327491, 1.6761812947372219, 0.272174255713858, 2.315335110054059, -0.7941202263935875, 1.4924010290335497, 2.3407638275056897, -1.06081089915187, -0.0377275769853364, 0.8194007966164752, 1.3003390089221785},
    {-1.7488317685449726, 1.8053284113306232, -0.2545457265550305, 0.8263895675527874, 0.13057052985792708, -0.8912957385840438, -0.3043195825241941, 0.9104732165346837, 0.6464776538319966, -0.2065985856249402, -1.0956186884006744, -1.4508250470388555, 0.25873398918303675, -1.0710580981222262, 2.3269566770605516, -0.7030404757441266, -1.3900923228033684, 3.771920908781684, -1.3881150130668345, -1.3699776045159557, 1.631268805191428, 2.053902594758897, -1.4963115876191038, 2.029059622977304, -0.7315522126223891, -1.598373050353228, 1.9081146189538578, 2.2340004764873056, 1.1802283488680518, -1.0192601667150631, -1.1043749761780632, 1.0565705096235658},
    {1.6474788114423382, -0.4749948939619703, 1.5816002301549954, -0.012139205762286307, 3.0184308217215814, -0.8497687504522214, 0.27129732503757376, 2.158891194523842, -0.9824320447993513, 1.9944399354155442, -0.164186211370354, 1.2198003030101208, 1.2088130883709076, 0.1432770014828111, -3.7646043926532244, -0.06675991103019027, 0.43371237983536093, 0.9681731044614249, 0.06098916014598951, 0.10737370725690062, -0.49246157730352463, 0.2860219902241376, -1.2823896896723543, 0.040282388069761005, -0.934506406350918, -0.8688697581255828, 1.5920171569631867, 0.4372817571555838, 0.4093021476132521, -0.6042693769034817, -0.6692370480992851, 1.0271390362040775},
    {0.03115016051203258, -0.7227193987339773, -0.8357225124237475, 1.7557661295186173, 1.690343961851835, 1.2042561681944284, -0.1455858758133644, 0.5228866989502113, -0.9773435583563561, 1.6380758274479663, 0.010379988314009254, 2.6631878369902795, -0.33892193372115975, 1.376494175317765, -0.946070596448187, 0.5972825953562869, -3.2132354100634717, -1.1447463997864122, -0.10562445701257411, -0.6072927619067333, -1.1140785559973327, -1.7264928247661293, 1.7929432030790164, -0.8378973479890932, -2.574195505044358, 1.5540667729220403, -0.1664277449068068, -1.5194198588122643, -1.1233055597563186, 0.16024029897299052, -0.6950741297053492, 0.6597745918540484},
    {-0.5444734984813965, -3.1487280953334125, -1.7753520319297509, 0.8244479691121943, -0.5534239070602142, -0.48977288389840046, 2.4976307625767804, -0.6334013728340016, 0.8476198394907682, 0.2835772880091082, 0.39911527651511364, -2.222570489392292, -1.7094471569715826, 2.260599228915669, -2.7934482284464996, -1.7928938871227924, -2.6339030806124017, 0.6433673761869407, 2.5904454614973944, -1.110394102695972, 0.4048231328846286, 1.0039329287075096, -0.49497780319122536, 0.9234143779620158, 1.0131296275879509, -1.001983836259315, 0.4270021490565564, 0.26050592649732685, 0.5665877679772492, 0.03460820187332272, 0.471414904777407, 1.118110426913169},
    {-0.7919784775309658, 0.8370587338754863, -1.1878837644962394, -0.728017116120268, -1.9738647634913726, 1.623256444607985, -1.0377404366505683, -3.8379834378433135, 1.8586147460912492, -0.1857628269870412, 0.34275058921062534, -1.0164229571957535, -0.10887371555828303, -0.9214647568221384, -0.6998736636729104, -0.48207779202197437, 0.4522857655464524, -0.8767020067879415, -1.4974498184719067, 2.2919945272276707, -0.5104806581989596, -0.9354863894970614, -2.3864523651723446, 0.26153010872265275, 2.1988714860864658, -1.01050701502795, 0.06166068371667117, 1.8627719064484716, 2.362276278253762, -0.6768568891253057, 0.10215359171116441, 0.7887781144699034},
    {-0.4987999230385359, -0.3636635050159916, -0.48677120273547636, 1.755237406900509, -0.26964655383364233, 1.7383160281034924, -0.9183410539055649, 1.4809358322385262, 1.4570911183574413, -1.0161697429206227, 0.09684613908648318, 1.7125712998660458, -1.1415184778376104, 2.264961449341929, 1.25835834047316, 0.6066299507552927, -2.2700017672049895, -2.573095506555152, 1.1097277346590153, -0.7283368782451369, 1.2075568825172491, -0.45996181487378873, -0.7583385023543623, 1.7863951939751666, -2.633967587457308, 0.37746499814178897, -0.5180577638898722, 0.7249513097638963, 0.5409524303217176, 0.16146812315201264, -0.23917432001396768, 0.5992842912429917},
    {1.0799257172573615, 1.4500489485222072, 0.04768840401118415, 0.8774449294622608, 0.7273315084121021, 0.5986844638598604, 2.1244509508176637, 0.8462952418555211, -0.12432724561641713, -0.6160675107102929, -0.568710935678862, -1.3745973052263507, 0.7710629316638167, 0.4281208166495451, -0.06126091620140061, -0.1250516524432736, -1.7039140365566574, -0.6222224180681122, 2.2585949491609365, -1.5744037270285665, -2.54848027571381, 1.1267064623653835, 0.11100187014996503, -0.7438815204745732, 3.1404111945696958, -0.6989746006787249, -0.2609299674502544, 0.13718937797677772, 0.7642690009824825, 0.5828831774875834, -0.6334102650691841, 2.4423237238423496},
    {0.07295022592092801, -0.8745742369585403, -0.8360759177571923, -0.8650292798629213, 0.7804073820019418, 0.5354440187642394, 0.4141909285328631, -2.3616664341119917, 0.8872965258007997, 2.0841720275681483, -1.0863303185171393, 1.4813433426382951, 0.9854788898053376, -0.06462118779439785, 1.237799761638466, -3.2363847100914263, -1.1601192081996348, -1.2924179796456918, -0.9491761754048855, 1.430195255071286, -2.450973760458007, -1.0081728259349438, 1.7663325870747506, -2.0230330083532726, 0.8590233048501725, -2.58443637853892, 0.18954539538224283, 1.265519740118058, 1.2269562196214847, -1.869882608689723, 0.560163651522741, 0.10159037201962812},
    {-2.2364423133935696, -0.0892197738255626, 0.694301172106254, 2.3579829331740965, 0.5953622514169, -1.4551301200346287, -1.8776100054804947, 1.0415970371973735, 2.2701204561119286, 0.5397503893323479, -0.318269993192607, -0.1394461877187554, 1.6688478877935662, -0.5615569073859243, -4.878222994110385, -1.758716555576763, -1.686368152880283, -0.3552654791643683, -0.6515371847643442, -0.6081252077650876, 1.6607157630526974, 0.7366586838802799, 0.8088647765905672, 1.0127520697974257, -0.9306185915339454, 1.5831343190447968, 0.5064446551428622, -1.7924369562369846, 1.6084417107104514, 2.0461201461394385, -1.6816405766283902, 0.21075757279124405},
    {0.30543676079748805, 1.9604538179423523, -2.425991442770169, -0.7801700572606246, -0.3069437549274302, 0.789676932293735, 0.2665600304594071, -2.1579130900851915, -0.4620655138086167, -1.2044141902036996, 0.8989735439548964, 0.25111576609138303, -2.065263778894973, 0.44797879077475183, 2.4099350893459075, -1.0730085286035578, 0.655703266168813, -0.5254293873395645, 2.362619852613666, -0.106694130718802, 0.29160577857369574, -0.9517440680781851, 1.063142160446419, -0.05686802920284929, 1.1817284565855553, -1.2411594138227564, 0.055416384149062574, -0.8130986220708193, -0.4960873008348577, 0.8455591977123453, -2.1663470237160047, 1.579742467933384},
    {0.6400936362374648, -2.821197999726816, -0.4938979169219082, -0.01604013857102521, -1.0340768251907286, -1.8144113122963286, -0.2516644975108593, -1.8935124491590438, 0.49785037237461705, -2.307029857543064, 2.0305505217348037, 0.2661169418787476, 0.18926892756086192, -1.097905841956697, -0.38651737707226275, 0.1823505594418532, 0.221451326566584, 0.4149719289673008, -0.58819951283734, -1.260422975235918, -0.9382622128288494, 0.010909695276572519, -0.7509515299596198, 2.99966248262949, -2.410993245511313, 0.8212410451325466, -1.2417616897124755, -0.061709661114220576, -2.5602900954924954, -0.27071475050110794, 0.5496138507684202, 0.8963161872251395},
    {-2.1887318252522094, -0.8152985957542643, 1.0563568370650136, 0.2705556799432424, 1.093708547670918, -2.4512430074388014, -1.7316886476803355, -0.9058480488445954, -0.8561960281251213, -1.7794726566411698, 0.018382115100527802, 1.2170972348372715, 0.004844895791122676, -1.3957756236611023, 0.2435382457908541, -0.5415001373504142, 0.8398601287721796, -0.07950741664193511, -0.5406345453333818, -0.7840438998194867, 0.5648341496974595, 0.1606713193125413, -1.25113267315951, 0.2163213288494807, 0.5925167766731552, 2.8286025092867693, 1.636878215725394, 0.7477135124726374, 1.6280450312097747, -1.2883562121516976, 0.5601641778652535, -0.26773106444492634},
    {0.6422149194328622, -0.14950894590719194, 0.23507408290808765, 1.4455063591705675, -1.5422854346425294, -0.6819444856365757, 0.9029355024112456, 2.6095072958030365, 0.7113248392506349, 1.526255221062679, 0.17209075016172312, 1.1053814895392535, 1.293804106374403, 1.192218768794366, -0.5137256410494476, 1.7242486710768266, 0.8047112981339781, -0.6919869950898446, -2.8385277370772024, 2.6715813076103996, -1.6177574490636515, 2.509121605849788, 1.2051480129440353, -1.316349804872878, 1.6591643202024717, 4.012018310949144, 1.2868861839957917, 0.30758433738041585, 0.788008699570434, 1.800820614011174, -0.8646864691025208, -0.34341206677122044},
    {-2.0809710029038544, 1.1263048276433258, -0.974537551702727, -2.930843776837804, -1.080500844707807, -0.36642074578013517, 1.6844759954083226, 0.4928611332412745, 0.6615217290096271, 1.5890137222846623, -0.6576378478826922, -1.009097363064212, 0.30477804813967446, 1.0831336819465978, -3.431707229105618, -1.116744709467568, 1.0470311362014093, 0.7633859930740661, -0.18847427159758595, 0.05471396805695816, 0.13471635777551158, 1.825689467344324, -0.4233497621069685, 0.9654260661127028, -2.9692799902200666, -1.1219000455843977, -1.848779614171263, -0.7747755168624354, 1.04691295630376, 2.4001191623574214, -0.45569940481585547, -0.20680749928035533},
    {1.281636381522294, 2.2064210820832395, -2.4994187478148877, 1.2700999195386729, -0.7843476107677569, -1.1345159467029462, 0.3269679720570643, 2.650181166362465, -0.1711913807867637, 0.26469955221456115, 0.25768981892703746, -0.3739255956389003, -2.344234812424395, 2.384235001076319, 3.7052068924430523, -0.4775343278944895, -0.8715634740182456, 1.7329178021459957, 1.6562955625882945, 2.1884685562262476, -0.8241024043632714, 0.6534804820501615, 2.2055520065466436, 0.4359273656636502, 0.45325304803113053, -0.8884641159048823, 1.4321531736401898, 2.7180329325942227, 1.0273894315389773, -0.37021792802479747, 0.5981509979988571, -0.37846628513148384},
    {-0.8664602534302689, 1.263178816059521, 1.1304711475729012, -1.1686430316763787, 0.28206827394213063, 0.7476991421663254, -0.7278761764332697, -0.8377624646341502, 0.4005979434369775, 0.18755440367545936, 1.587630984222132, 2.002695789065111, -0.47536162905514046, 1.9040814608748076, 0.6634657381499608, 0.258766783686756, 2.1045348119667175, -0.44154901227422344, -0.249311883483911, -1.560557678477044, 2.288580385607969, 0.2716837285329596, 1.4763462265834795, -1.5619980949147663, -2.4439471256440557, -0.07345112492372653, -2.3174360850191214, -0.6213297060209586, 2.002331586318732, -1.1522979761486336, -0.6755313797325672, -2.4962506264813356},
    {-0.1863780890558816, 0.11554141671552137, -2.2683165583415916, -2.8464823997149313, -1.295151946704445, -0.5407221762854375, 2.7065534246902385, -2.575988651226891, 0.37723286904882614, -2.0251897728659216, 0.3276030184538161, -0.6270338113004498, -1.2230882953557807, 1.163353929639574, 1.2507677076674057, -0.9308297299381557, -2.6193981943024864, -0.1728275309335414, -0.5645138793112456, 0.44372212469771566, -0.09876768009053051, -1.0951969011577534, 1.5416178362237705, 0.9373670028271619, -0.07781686636627137, -0.22065683092574914, -1.1194562492454303, -0.2281673687740159, 0.2173904820343696, -0.6958796812600382, 0.27329493007549505, -1.7303742498998875},
    {-0.17245921108224346, -2.672067020283748, -0.0916004714005633, -0.537728677694542, -0.47604077353120616, -0.4830039253363656, -0.8614826109594376, -0.6980912662559141, -0.2906152278382521, 1.1470164803982386, 0.16150794946008257, -0.19801550821836156, 0.2575374568760749, -0.1540619741276629, 1.968361694583907, -0.5910586275201625, -0.5919304119811751, -0.4645979586420523, -1.5861945482257678, 4.070553123029518, -1.5309067641789924, -1.5930427659528956, 1.926243471975353, 1.4105643965903063, 0.022917376132983835, 0.2405242947866427, -1.1317732449732607, -2.8041659100712315, 0.14117949417928352, 1.5148256747788043, 2.7928085113297882, 3.755096450470068},
    {-1.1886560365994696, 1.4132169028756392, -1.4847001183269481, 0.42237568902556, 1.0485895997661974, -0.6420388434248946, -2.0719137638860015, 3.875038064415181, -1.4099209321747166, -0.25619690190884437, -1.1698296045120542, 1.7252346761999973, 0.6400001512709929, 0.29678786169025884, -1.5015082480005435, 0.14008576085597155, 0.4363354121338369, 1.3097363825284827, -1.8127268683369515, 0.022112772386047287, -0.8026378880241782, -1.4127768230237605, 0.07527400298220124, -0.22384047181924943, -2.509074707779874, -0.6379808415618176, -2.6018104611484683, 0.27934272299624213, -1.125834216537698, -1.7541699977624294, -1.2294582973418247, 0.3979368085640423},
    {-0.6253161542439917, -0.7678635541391793, -0.5587128022000031, 0.5500052399364701, -1.9508063493740084, 0.06903425031639529, -0.7105025364962884, -0.25722338626311053, 0.5767683352047241, 0.027296268822502433, -1.4663651443797032, 0.7727086167703683, 0.23079900227390474, -0.09819812834361458, 2.058600144433383, 0.20912738896224378, -0.8964416854352985, -0.30684100176258217, 3.3156717899017485, 0.2869174172958881, -0.35429559410563655, -0.2898296482246209, -0.2432318667940348, 0.9695555661653247, 1.5208398358688706, 1.7126829894393436, 0.46980643608982087, 1.0306772211653579, 0.21818849345990138, -0.6244974636434646, -0.5826662077256911, 0.3045893713404328},
    {-2.9180095317315686, 0.33536997619796144, 0.043230363369432936, 0.05614036770655303, -2.8566523586700954, -1.7751691867422836, 0.8467669261960143, 0.602247366666044, -1.478839379489787, -2.567363313799334, 1.808515578678748, 1.2973857136624896, 1.6271428249655027, 1.3704804410120939, 2.8664337494434626, 1.9014068725046178, -1.570641678681324, 0.5234595299937341, -1.1817224488784548, 0.7301367317786822, 0.8412097983380857, -0.9800625073039699, 0.24482556128750868, 2.2069361773415603, -1.1934522702409176, 0.4811899089923237, 2.0241099897491743, -2.3708867365217148, 1.3154690125390855, -0.9265400457499223, 1.2945369105327966, -0.2709754724379457},
    {-3.7068571228866047, 1.3003066256835838, 0.5419897391794847, -2.513285889247518, -1.1456692333508458, -0.8741592468687426, 2.7260073870287242, 0.16932787775257982, 1.3912367331542057, -0.34739036779524374, 0.43786317791051094, 2.248151010023557, -1.5853526777859015, 0.613943648747903, 1.2984468398612616, 2.300324601389922, -0.9275391200724545, 1.8126432720149264, -1.3896895954385782, -0.49153110709523296, -1.5900986896101332, -0.5006396994771715, -1.5655006061234429, 2.2152084391625673, 0.3922776164832576, 1.324613226606356, -2.241442975371068, -1.3337800046448187, 0.5896145269955297, -1.1185744184295139, 1.96723241453445, 1.1361636422119055},
    {-0.8464647231723035, -1.90638367670096, 0.5527467279451895, -1.1481293821036058, -1.2366850750911194, -3.473119144316602, 0.5065655757595312, 2.1526221716824607, -1.2503862640558574, -3.791156370075314, 1.5598548868692654, -0.8715832782295795, 0.06032504344432848, 0.7967045722221806, -1.1487940221991197, -1.806080435081632, 0.27733735243256985, 0.5437481913318002, 1.3319827494125027, 1.2564691241975696, -0.7726378823604164, -0.4050564759577047, -1.8607729059708944, -0.008305453885588683, -0.6675360218748335, 0.9606872100102104, -2.626544412000318, -0.24311210740501604, 1.4494867001668166, 0.4955091032709444, -1.1065799085376382, -0.5353693740787243},
    {-1.5236895756828053, -1.426442466982787, -0.28450660422943536, -0.23841418034643064, -1.2308003250368744, -0.7230335719941756, 0.31177374528691076, 0.6291114671111502, 0.5633684425916133, -2.1563313697724245, 0.1308982865812286, -1.8685728064858742, 0.4284189308508378, -0.767469086876244, 0.484495761816382, 1.9623187102599013, -0.8491285400830477, -1.0603842637683782, -1.0767012633023747, 1.2368836595190849, 2.573554807278561, -2.12571713605539, 0.964133737227133, 2.2286241766672013, -2.647491370155852, 1.8305144819582317, -0.19739752185117065, -1.077816860104619, 0.6664526404596998, -3.9373932311143225, -1.5220805904068015, -1.3824964384455072},
    {-0.6715782061414014, 1.1702320614366186, -1.0496450840679379, -1.1698377011870382, -2.273106828416713, -3.867675913582721, 0.07180009044617379, 0.16675109709847544, -3.871205289060908, -0.27165908321061966, 1.2611282646002069, 0.08951023862844652, 0.8659955880943838, 0.17789166152380684, -0.8689134369535658, 0.2315304175682821, -1.8935554091118498, -1.6972999261251618, -1.0221336558959588, -0.11679740086326097, 0.7623943433182931, -2.0010530231883563, 1.2335457545170767, 3.2843146802047074, 2.057549433714477, 1.3457777996857727, -1.3557908374988206, -1.232084548965377, 1.1968761784719915, -0.8669578969028721, -1.0639956634992325, -1.6452574988219557},
    {-1.8707495852891245, 1.2833395749059673, 0.6457564325524829, -2.5259009323486326, -2.510108824301636, -1.727803899801167, 1.4666263639005137, 0.4538471114968271, -0.11487034503875328, 1.1856860729393424, 0.9840138739813807, -1.1012146585636806, 0.18807485036680607, 1.187313077205842, 0.373564871703168, 1.3150949109061796, 1.164156595161223, -0.1470491590249838, 1.140873056323618, -0.3234867059932416, 3.002283239030193, -0.5429194035568261, -1.1229014556080898, -0.23297039341066775, 0.17530587409521228, 2.9960421637244203, 3.8287083367110837, -1.442686703772049, 1.6361270563674415, -4.234361887564022, -1.403623816952168, -0.20604940928579316},
    {-2.011574384156704, 1.0380892075550918, -1.8485899760583118, 0.5179181413838597, -1.3144385667705392, -2.006853152043774, -3.7760836376298967, -1.2955883747554195, -1.3479231752842744, 1.9431406130136841, 1.2937230127284438, -0.2206465640189965, -0.5154750903649544, -3.1756636646079723, -2.6930732126888803, -1.3420854760960301, 0.8075883143455096, -1.663553662600349, -0.8587555194802253, 0.6992244875595611, -3.7825104204093134, -1.3275331500459473, 1.1080208826844822, -0.8729729601208004, 0.999448402191686, 0.9954993963877526, 1.6648027255762226, 0.06515367539332308, -1.4089459603565708, 0.5715841966522162, -1.798579278843478, 0.8128544563564537},
    {-3.599729478089978, -0.2118326482790397, -0.6176250243313468, -0.8090877015287984, 0.7767025092160096, -0.7729626788981822, 0.8266789990660958, -0.5182485771134928, -1.7433293723414898, 1.0595759214583658, -0.803156181687781, -0.8569817642981242, -0.08558093018746714, -1.5696683518252321, -0.39930243415190875, 1.9969383756239663, 1.2546325364268074, 2.592557076875232, -0.22214610735220472, -1.4551363646258992, -0.9761519018005115, 1.05372557667584, -0.660952494700285, -2.9593218308638294, 0.8922075128349629, -1.4679013377865642, -0.6222312162669795, -3.1530693013871427, 0.5798097781008661, -3.0310598207297437, -1.1905235665581602, 1.6223374349155992},
    {-0.3315974375032902, -2.1206807754372248, -0.4184453975758605, -1.2887368471542502, 0.008898920224995553, -1.2758650874966002, 2.383653269744179, -2.0498252882459136, -0.17716995301950902, -2.4199112126368387, -0.5346965965519831, -2.1539968237395772, -2.0843330540842375, 1.306038422967485, -0.756940225110042, 1.2989043838840026, 0.7140945270599061, 1.7086810256873184, 1.1882837536450794, -1.9283975730501417, 2.90964069651002, 0.3592055714111948, -2.999693368967132, 0.3223083427673933, -0.1417466471612834, -1.2887103952689118, 0.987008065215958, 0.7325937167891067, 1.163134731319064, -1.2321462891553587, -1.602205629360812, -1.005464493994414},
    {-1.416122951016795, -0.7120962445734983, 1.071595033412056, 0.39932057386529063, 0.37513349616140845, -1.924828396572848, 2.751368106311792, -2.2346461227931314, 1.1281890571086832, 1.058340135124644, -0.4551127831004064, -0.2831726181901444, -1.0967310588088721, -3.7261388791195325, 1.096857784869205, 0.11381153897269028, -0.2522095487503832, -1.4140421847351357, -0.5642288900582968, 1.869149308770939, 0.8912818557121037, -0.7535335570566827, 0.3247527682610919, -0.7628389500062311, -0.4675988867865156, -0.2085417669284357, 0.28721750142406016, -0.6199502177016206, -2.85267842874066, -3.4353678762880797, -0.16079899472315795, 1.3489383077583075},
    {0.6424655076582269, 0.8244646921890695, -3.078678506640357, 0.516947746607553, -1.0735120890669052, 0.15928057768128803, 2.138649555251838, -0.47511909996908225, -1.3525768491159096, -1.3458754007963867, -3.211249105416536, -0.41978862347195595, 0.6393443136147834, 0.2659397537477162, 1.0525990767963451, 2.3116582288915564, 2.060301096690744, 1.0324739534608778, 0.029433829301873993, 0.7962378359366178, 3.3205973703165688, -1.2446725130532703, -0.23483848401058105, 1.9485783794969516, -1.2534803067592573, -1.4954831667983894, -0.7932493129011973, -0.40819724436986865, -0.18840343012168762, 0.7789512016663206, -1.0935607453276452, -1.69442086374611},
    {-0.44550529310857867, -0.14073296125365192, 0.6862482766939657, 0.45455667086861307, -2.385726133450081, -0.42409513540584, -0.43912814679219303, -1.01421735617139, 1.4899686550716784, -0.9778731221750021, -1.7270253845867334, 1.1044248151649176, -0.014077825116209397, -0.7824199665152332, 1.0292265778794618, 0.4133168808403322, 0.3158803662789211, 0.31536767560545, -1.1755259353389387, -0.5430939759094199, 1.8760667449745907, 0.3172317060522345, 3.453211534698401, 2.1610860498750344, 0.8417173481075187, 3.944698295413772, -2.2621645535812256, 0.5774388545764189, -1.3458310622210903, -0.08231324702496627, -0.4563740401742748, -1.5489069010114582},
    {0.8800340980321438, -1.3199850592876072, -1.0364355808180783, -0.02511903490047349, 1.9886782261199192, -1.965955293630964, -0.2582396947363544, -0.6407703135510328, -0.22117290569108752, 0.411044263743491, 0.773314975286785, 1.0559482820599715, -0.3240621499610097, -1.4623544523368035, -0.856322897556286, 1.0361621772848184, -1.814364977617886, 2.047199584545462, -3.0065274868109833, -0.4471113543288711, 0.6363814716730303, -0.6899460134786166, 1.8875566447861996, 0.09880187177606169, -1.4199571145045167, -0.5630064829682078, -2.015467322607637, -0.37520176287078844, -1.837646025098213, 1.8333653399933434, 2.1231795040889447, -0.964465800101252},
    {-0.9680128364566755, 0.4353962620470397, -0.2567638363446267, -1.693844045564934, -2.3865837034777426, -1.347893640377716, -0.8338945927700468, -0.6242062860711479, 0.11975966748863653, -1.5093511020904655, -2.0233566717047893, 1.2847987379851038, 0.5952154515075126, -0.21632765937839313, 0.4496262953656351, -1.1010838659643192, -1.7328874205574307, 0.12791969411765539, -0.6163079448678359, 1.6958819386870985, -2.2991345980910314, -2.0842655742611624, 0.061034355959371435, 1.9578566588402935, 0.9917678132981682, -0.1406572593923736, -1.2561477724608168, -1.1817927114242335, -1.2084575299231342, -0.6118864052468541, 2.3180686569806497, -2.271645204812757},
    {0.5158660735422486, -2.886787104239539, -0.059563638507451146, -1.247431946488587, -0.515561171732056, -2.2166202251899216, 0.3536559592710779, -2.0470170595036383, 2.0532908236375014, 1.7199026087269547, -0.40633857131155776, -0.5957058145247585, 0.5518853720589079, 1.7373472483700203, -1.2275967719083924, 0.27121435322259085, 0.01951089535916905, -0.2751304053478116, -0.08262323121422119, -0.47035694250221644, 0.8722164853002322, -0.17473137457690283, -0.986737097474042, -1.057293747635681, 1.052722867289271, 1.2584527507929562, 1.3168890565466662, -1.8785985809092793, 0.4735186717732464, -0.3874943394656308, -1.5533423821303756, 2.614674400311632},
    {-0.6416615060587239, -0.990165937977384, 1.5768659028354166, 1.6495432787505209, 0.2701349768186695, -2.618537725658229, 0.4449862377564981, 1.7764280891854298, 2.3846091790159445, 1.7550225794239573, -0.4326106583891605, 0.4683787212872635, -0.1805065428308878, 2.6607723691138268, -0.011208424553033539, 0.5367085670999511, 0.5181182406625394, 2.4078038244112587, 0.6254317834426388, -0.5188701921526813, -1.2231848793696973, 1.3773327905821267, 1.5405400449925475, 0.1789282959427821, -2.281491908872695, 0.6476393696939903, 1.254224397757898, 0.23266912939933593, 1.4393301630089608, -1.9536400115933565, 1.2157670886003638, -2.9530103682208617},
    {-3.3061075114959193, -0.13857765099346922, 1.3345249599218643, -0.08230490443081077, -1.2049981738808255, 0.9399853880326221, 0.5869662828392039, 1.865326202677555, -1.6252491618766132, -1.5131435950766725, -0.031731092068307556, -1.1330910959338152, -1.1265139048212531, 1.074788607345867, -0.2980759100219942, -0.08637583045408564, 0.19037060473515058, 0.3784814817803461, -1.1043957249448473, -3.0356169783660727, -1.5688539273212678, 2.112035128243469, -2.074877237484219, -2.4270818310954074, -1.3850080385009136, -0.8441424386757433, -2.1005755977636333, 2.670997939065793, 2.1265068447628566, -1.4631268826172523, 0.3002938799732864, 1.0427558186181927},
    {-0.32038135891096964, -2.3848631226326678, 0.9437842107820283, -2.0276864244994295, -1.9336883121450361, 1.570331692906618, -0.7757565209485057, 0.6541749453564205, -1.5116170200074832, 0.9482618421927187, 2.5784076229672137, -0.4304491497593009, 0.27738705615057374, -0.7245153658557557, -2.621748356485758, -0.46816711017816054, -1.3335597746704442, 1.1471244374777076, -1.536023209375277, 0.003010461070650617, -1.6136253312600304, 1.0717717195507435, -0.5220000058278464, -0.04674038224946535, -1.5448305888715224, -1.4404608111272315, -0.45396539851165985, -2.7187293615259627, 0.4438505387827486, 0.011284194701975385, 1.1083879023193879, -2.0574368044187836},
    {-1.0219815094231444, -0.6623842771586316, -1.3250591534401328, -1.4063066351195808, 0.6944036456958869, -2.4888209433254045, -0.10094189593187294, -2.696368220575207, -0.5292126213184638, 1.4007523740730712, -3.1953451443454868, -0.7825791854850417, -1.103423088065654, 0.4097826672377464, 0.6041850543104141, 1.6648834751811423, -1.8349955402327607, 0.09166329673217755, -2.8124265799093924, 2.0520462566805246, -0.2713737789200481, -0.2741484898931212, -2.3687520569310494, 1.3273471794830516, 0.5080005344619608, -0.39752162099732624, -1.1964567172517064, -1.6865909231691807, -2.467336780435639, 0.30600087433295275, -2.1206225916088117, -1.30851092616637},
    {-2.398753659411246, 0.30672564698066124, 1.772490091343247, -2.142653244405566, 1.6102665812245782, 0.15134379531034695, -0.22783103996680884, -0.843309084019439, -0.21515246607794208, 0.2387241470068653, 1.4222705756008966, -0.5378400895650876, -0.15705886153678952, 2.63698934514186, -0.7168327293980683, 0.02942000244640418, -0.16554449484982284, 2.953262738802992, -1.98613017819473, -0.7352913967533833, 0.24882118585923602, -2.1476635858471775, -0.822199711880862, -2.009896830643309, -2.574715117353059, 1.2811154057621679, -1.3543774699551308, -1.8659624008063904, 1.6902283121019308, -1.7793197202549482, -0.7140011265621943, 1.508685833481293},
    {-0.48459690285383694, 1.379793346789975, -1.497280097450108, -1.1871030995058678, -1.8191904876846834, 0.38267656752940626, 0.9872441904154451, -2.6556334448700794, -0.4693752923993448, 0.01872476638881908, 0.9036154236648458, -2.7834178117664647, 0.35713763916112523, -0.716855541683934, 1.5219747868243327, -3.1180135303288408, -2.363444815531062, 0.6709378315019915, -0.1854604786822207, 0.1436707163660568, 0.2617437905203031, -0.21982116885234834, -3.948543923074643, -0.4096870719669674, 0.682211180034796, -0.3374729952298772, 0.3323885566506306, 1.0293460715392695, 2.4413340951893923, -1.1996900221519133, -2.0531841279348075, -2.0309144968328545},
    {0.6654714276730879, -0.3224143228829623, -1.3143004845789465, -0.2544648514375849, -0.6501607227426631, -1.0400519876522176, 0.40341904137373236, 1.855957534507987, -2.9743533151094717, 2.8467517726124316, -1.3476321635760167, 0.4432113691152523, -0.08526814738581359, -1.5147845729187857, 0.49435509092974267, 2.4675527082411093, 2.0524685553884265, 2.3912065783055185, -0.7916373319808134, 0.7934659814345779, -1.459273505899627, 1.8679404791078094, -1.5787900397400594, -0.5756816696593726, 1.2972287097392718, -0.6678279822039624, -0.2158636773812235, -0.10180952666683414, 2.102834342749618, 3.494703727564835, 0.8322518205480188, 0.002868244682638562},
    {0.6547947360691618, -1.7707773584058435, 0.571051731749333, 0.7366303168615759, 2.038228771803596, 2.394354912174421, 3.2745933010975548, 3.029020722253269, 2.030092550794245, 1.1589315445978166, -1.9968051435558722, 1.5518466871425196, 0.5844144510813186, 1.0103609627900445, -0.7565448400730916, -0.7079128383765002, 0.7620297954006845, 1.2693613239748527, -0.9624504293607298, 0.1844359484951173, -2.5521640739727944, 1.2489528631342919, -0.051552401888443594, -0.3259103975783402, -0.4906451976494167, -0.5849738309365278, -0.9061678227019788, 3.4828942730951766, -3.6270890520877908, -0.33609304929547923, -0.9045141668250253, 0.7650985156440445},
    {3.3536356774976093, -0.08939942966716279, -3.4595365883806393, -2.2573422348255376, 0.5454541133348959, 0.9819271318905912, -1.3856151908009526, -0.8998554126705646, 2.7010794257476087, 1.213110676056004, -0.2689882033513239, 3.406298176410203, -1.2766378473155384, 1.4518761628524455, -2.4198811377525855, 0.2197510244507965, -1.1938975140765515, 0.857818865366293, 1.66693200172235, 1.9454407509636986, -0.38548767429087877, 0.7525690543627848, -0.6632167870982252, -2.342615908967415, -1.1496480370339903, 0.0346379074556396, -2.320184017720013, 2.265528667184967, -1.504076875609715, 0.8068425113468444, -2.1918713275140442, -0.23862696298221797},
    {0.17188884488456277, -0.5669536248568088, 0.44729289898127783, -1.246853875869405, -1.0047108923708419, 1.230339248287664, 0.5056303937169815, -2.2135307658539585, -1.4450246054327915, 1.5414658246388775, -0.2394378480249378, 0.2622297989510415, -1.499851132541525, 0.6891453030418325, -0.9882256287946356, 1.1548442457299257, -0.19044284774346443, 0.7226411255241738, -1.1638026540643942, -2.419150355631624, -0.6428866660806628, 0.44275489957231595, 0.8198626647442102, -0.9662681407219352, 0.6236345885124026, 2.156475391777054, -0.04317296618898237, -0.3774341798581331, 0.2558695119138295, 1.7676989051400058, 0.4051264242615407, 0.8246674348741981},
    {-2.087239550302474, -3.143575436714472, 2.462190781032999, -1.4419756414202172, -0.5535233944740108, -1.2012997790144928, -1.1164776664338183, 0.43838005519744516, -2.1800921466550562, 0.31535943091717233, 1.9087976212487923, -3.2967210660802966, 2.8894822745123436, -1.7459317242751253, -4.606341331415999, 0.29974243677679946, -1.204206033515601, -0.9767651651457016, -1.4669528871599558, -1.7891750452982182, -0.019980545895446712, 0.11794599666062969, 0.43164934928924437, -1.3953387067462675, -4.478126817335303, 1.833722662822133, -0.17623292552404565, 0.2836900866348539, -1.3067565950228437, 0.577845625787325, 0.019083986247573806, 0.556072839319562},
    {-0.030912789694303586, -2.435791938620548, -0.2912601728936619, -0.7206702947535086, -2.112555146255851, -0.039156736499184094, 0.577115256819553, 0.5406674340136902, 2.155678803634269, 2.0842082100748733, 0.7651085759831743, 1.7396135428906185, -1.3324146889093171, -2.302588668939273, 0.1537323828668688, 0.7852372021776499, -0.678744183346816, 0.6964155357771954, -1.8211316268637638, -0.34275773981093, 0.6225881545124355, -0.8704400993580341, -0.7688394467325131, -0.9703950580235846, -0.460707650102469, -0.14360344599437033, 0.5999417298162932, -0.05208793150504939, 1.0740022457979717, 2.0516075436029477, 1.1510540549908281, 2.477852697950145},
    {0.78120781467185, -0.12150404182048115, -2.3987392854537686, 0.5709013926147445, 0.7992097150903444, -1.0471293755243014, 3.260270289970698, 0.8351183591039946, -0.6763318235515324, 2.6492589220324576, 0.6291371742020043, -2.312899599048202, -2.253037800400038, 1.21810436100667, 0.24701240174223593, -0.9599387333533059, 0.15177632135176572, 1.8537217618934703, 0.03847324489112799, 1.8927388873084523, -0.23727055850884526, 0.4004502773506657, 2.4923387424442858, -0.49068479757834566, 1.3603537540464428, 0.5347112955446616, -2.230239412023512, -1.3713055189196932, -1.153544213475282, 3.0817621985074846, -1.0227440378652959, 1.9887574362598364},
    {-3.0189233330634186, 0.00731728566424416, 0.7580604128637692, 0.10892932508444231, 0.46244920833107556, 0.28487507419054503, -1.0750199612483966, -0.6623289684422605, -0.0557886925757198, -0.79695845431225, -0.009478405627901228, -0.17823412219893686, -1.8495919423562674, -0.641271655539476, -2.1572323577906416, -0.7104016087969154, -2.916341786648588, 0.4600241871368459, -1.746692433983706, -0.1889013786256565, -1.4718349072763146, -1.3689020292884075, 0.513503285380071, -1.2084526378495202, -1.096179886280733, 0.342223064555844, -0.5658962025928125, 0.031181528779540627, 2.3809306980632665, -1.9311209112776706, 1.5293511981753996, -2.029634914946607},
    {1.3621577438826813, -1.7805515197810917, 0.37349888519597196, -0.9036067796134045, -0.32744212753559215, -1.1215439593355592, 0.32488457377501584, 1.3658812825050597, 3.642758639838915, -2.380698880745622, 1.0405892295731007, 0.1325682152354426, 0.16927571769712793, 0.14985801278746974, 0.9218910397027297, 1.5295823819672099, -0.16335523034838986, 0.5177471448338083, -2.3402504245555633, -0.33746862885622614, -1.0421772229748136, 0.05466799788351357, -2.056220363048472, -1.091214317709911, 1.5513177744666558, 0.5108817200896595, -1.385759242232335, 0.10893239246238948, -0.05506305617462505, -1.4448003946861017, -0.21144648957340156, -0.9078286981306324}
};

static const float b1[32] = {5.929251470268512, 5.477627060156745, 5.6236683476200895, 5.692078501088931, 6.137547907354267, 6.166357471465958, 5.879768446943573, 5.741085491808687, 5.772720041238418, 6.040659451166261, 6.137556744941037, 5.689280026172354, 4.9753101050672965, 6.2171524077475695, 6.22435533282164, 5.287053003524959, 5.43552971370396, 5.143685168907064, 5.882684633509622, 6.000190309191846, 6.3129048609284455, 5.742270460190056, 6.064747492185155, 6.404929871111579, 5.158295700811954, 6.080045585710136, 5.7865375005453075, 5.677972799488901, 3.913590057375118, 6.111144082125743, 5.5860473628593335, 5.704894078762544};

static const float w2[32][16] = {
    {4.562382346170686, -0.7635449103204004, 4.527486637852178, 3.312499484448875, 4.219706290504617, 3.942290591616389, 4.026000751725175, 0.3364872993018006, 2.198696202573712, 4.447249327152223, 3.8760056335417947, 7.473138731061334, 3.0364455000254, 3.219243093160853, 5.326916104346346, 4.640584537772377},
    {3.692741198777404, -1.8695894717715396, 4.233988813597168, 7.028368703713532, 3.673486962980091, 3.1085731995195744, 4.174369949071801, 0.6336303043336572, 0.8461883075325437, 4.226026461997305, 3.63567995303527, 4.383247022772153, 5.063805166025576, 6.3258215763646435, 3.547048788731824, 5.065442612949542},
    {2.2757216211482545, 0.0898763429500975, 4.853675579758835, 5.134549454968438, 4.155963819032364, 2.2864682565353784, 4.654343006814007, 1.9234409101990568, 0.6035144165608171, 3.9368659284529115, 3.819185523051293, 7.184465256570045, 2.45034675371579, 2.4435054392218136, 3.630593349253568, 4.0499926396539685},
    {6.129173845959461, -0.6042445897808311, 5.353485633385758, 3.5660279905999297, 4.751587299322197, 3.700171860467188, 5.369083926328338, 1.1800375696299565, 2.335377135924149, 4.387592703569355, 4.073710659485455, 4.500984961585969, 4.43008922739383, 4.34270496371956, 3.752922165919656, 3.744287898709256},
    {6.108535419935272, -1.0898418836174084, 3.372592545989486, 3.6743449045187058, 3.2045879038017646, 3.925479299419297, 6.182736490258374, 0.4109677507308259, 1.7898865318316404, 2.330399500219167, 4.817372317470041, 4.565186217419514, 2.723083744212886, 3.831309815043878, 3.69992731167369, 4.2403361742998005},
    {5.815411857270617, -1.6063595039246017, 4.914594087805985, 2.856351684315631, 4.314768813412116, 3.0198659370934946, 7.122807065066858, 1.327707964283796, 1.3338604644576373, 2.198082229364069, 5.013438765914638, 4.666001088985853, 4.091174320392956, 4.637141302199228, 4.541339921064205, 4.027091804456869},
    {5.248614555471039, -0.7874070524120307, 4.993490383232422, 3.149884104917101, 2.4752195781957447, 3.055726759169861, 3.2892236321880306, -1.0153881895901147, 0.24603553006068457, 3.436718916238374, 4.638810827203433, 4.821914353373976, 4.1894862383655855, 4.161520120828221, 3.393370485699724, 3.197398035846597},
    {4.493574189382898, 1.1340310762639076, 5.107554097741161, 4.453817057342932, 4.544074793622239, 3.9379387691693295, 5.056396722777021, 0.8612809996705215, 2.397506338298741, 3.090404088829074, 4.808536181548419, 3.82005738423498, 5.221906216155202, 3.4883501483404604, 3.6515146661795197, 2.507254785918372},
    {5.4407494745989, 2.6834316734286596, 4.200012435703305, 5.789781482783197, 4.12359266887448, 3.9924742374099496, 5.285296199765233, 0.48276121407736783, 2.560066838708988, 3.007769921161703, 4.6565500498292565, 3.9919458591400545, 3.1983338276255675, 3.6080158827096316, 4.186512720862871, 4.9275390800397405},
    {3.5736497739601663, 1.2318099170434929, 3.7283944065117613, 4.9075365373766, 3.462637388307469, 4.2576527821341905, 4.495715233616266, -0.20183025957645476, 0.3664533850914244, 4.3832769638946125, 4.925909919163221, 5.547782291234783, 4.2137910397378615, 4.150286450750167, 5.147214208951762, 4.129849543281214},
    {5.403232252555702, -2.7758244440645705, 4.7258623261269115, 3.0525942383890454, 3.421260472258397, 5.844745401428265, 7.2595841872728855, 0.4629157126448674, 2.385506506195366, 4.767724658636328, 5.75666917322573, 6.331248485696665, 3.1147485340149803, 4.805175083384118, 3.6204155197762726, 3.2450787571243507},
    {2.8292979003107908, -1.3969786060586413, 3.8132377859810593, 6.202898504298864, 4.782317377125633, 3.088773859761934, 5.348321679320111, -0.34926570600951407, 3.1740838447430573, 5.054382175996954, 2.790491782725466, 5.60675527134168, 3.7079659975359442, 4.053889273243124, 5.16574617258865, 4.058894062454011},
    {3.8471039474284376, -0.6583305407734321, 5.13113626983201, 3.8683178512097807, 4.6184592538628015, 5.447202954197628, 2.1349167269414373, 0.03055962318864565, 1.727674502359815, 5.466963650646611, 5.5496896887997265, 3.1740197542996778, 3.321005681849849, 4.169759657228964, 3.641802011019993, 5.598739089216832},
    {4.207985872359621, -0.503800178018316, 5.357774730760147, 3.6619301638446213, 4.120268123193199, 3.6545889964755203, 5.531269250197851, -0.03532222227472723, 2.3429201888683306, 6.613768230654003, 4.156549780644048, 5.612655259317822, 4.260682906730913, 5.282905725338423, 3.8570794147419223, 4.086804427912105},
    {2.7202234130721954, -0.9357100286115961, 3.233413396616702, 4.525060391511597, 4.373225299847278, 4.213867224247144, 5.13473868711801, 0.462105508903216, 1.7334928501309543, 3.513002715832119, 6.994070318982889, 4.541171000537449, 2.2201620571899396, 3.5371394596068995, 4.738620731529455, 2.195197939060804},
    {3.959525815871198, -1.0103755983074518, 5.075951378865994, 4.03662780686708, 4.955439273850953, 4.4131735103867715, 4.007005638000717, 0.9273327900527844, 2.7230248541061863, 3.246019539900712, 4.118081547645914, 4.27475735194584, 2.8383826061181456, 4.666929178603979, 1.3502657703741263, 5.100619450485626},
    {4.556824282354063, -0.40532835719974114, 5.248263739072444, 5.438020603882053, 6.108636655164002, 4.788518238173802, 5.714326716883615, 0.7160194727136556, 1.5094911314455035, 5.7900206869309905, 2.880667366129695, 4.42939132510511, 6.179487484066751, 2.1472999220085756, 4.194641426980668, 4.487767193959219},
    {4.323773993647066, 0.6947662692444037, 3.2592009314733437, 5.2969919845419895, 3.5499762541572175, 4.429219382799823, 4.759795058735063, 0.37700160630868074, 2.744766418849288, 3.110681554751615, 4.068348971564144, 4.456657539640254, 3.8405937183303727, 2.8314429128875536, 4.061840099280105, 3.073740843491389},
    {4.908492512135792, -1.3342416270752524, 5.120089362673414, 3.4216058105088445, 5.406369418894933, 1.6946675805250027, 3.1552189673842785, -1.5673485510327478, 1.680416885609938, 3.5782870076821776, 5.156827029798008, 4.371180473386961, 3.7920547614095437, 4.059674471358521, 4.129446942731454, 3.120302691365197},
    {4.8439929057668225, 0.2196096569494991, 4.101181303462308, 3.345901022458131, 6.175385087948493, 2.5531406606971845, 5.49332553398834, 0.6382175047127085, 1.4228778547225114, 5.016061904093754, 5.973916527785297, 4.684976888504974, 4.5161055635735, 3.9100421852531477, 4.288338636266316, 2.549511623004438},
    {3.8347706048518604, -1.018183471234037, 5.693972289042265, 3.8240907057633295, 4.1815147307440235, 4.354162276398673, 6.6678095569746825, 0.2178867928394565, 0.3255817803898316, 2.3500044723353306, 4.990227714674601, 4.63573644204026, 1.918664332481773, 2.4003624917309025, 4.522528636514487, 2.7007886602695828},
    {3.9225561405232043, -1.4923285596474554, 2.600597098402607, 4.11149488086551, 3.922563116761502, 3.724055740428898, 4.343999421214336, -0.6055928095176598, 1.6939783217883628, 4.635998385614184, 4.157362286768444, 4.80007185922262, 2.6086167999878933, 5.95654636216527, 5.550898782028506, 3.599411365955155},
    {5.29466211168753, 1.2829770014852793, 5.43505695658998, 3.436189654335919, 5.638616567716237, 3.9798664651461984, 5.129801475805041, 0.07126965590745543, 0.5604168753372907, 4.676918756622541, 3.95918127243278, 5.005840077683649, 2.4751847546406918, 4.102130302192792, 3.3557612448766485, 3.3351178795892173},
    {4.130540432242639, -1.8022988657341723, 4.851737575617834, 4.0248655681880425, 3.92078195621224, 3.376071614042525, 6.229014870912933, -0.8636101515238994, 2.183778735762707, 5.913016045863547, 5.64441633159772, 4.038343069453226, 5.1490228825374444, 3.27494508791996, 4.005109309094862, 3.7029129321013423},
    {4.811126842762381, -0.1786955875733024, 4.124786624748086, 3.74865020477496, 3.01861495658511, 4.813485281036229, 4.960663780327064, 1.7824860581110853, 1.9359312781533773, 4.648565305520554, 4.310019122481673, 3.6562585002134083, 3.684794185234364, 2.9674527089381226, 4.3061472723602945, 4.587540297358388},
    {6.212288026566172, 1.3457702904798599, 4.910735183628181, 5.300556137638616, 3.4527473388896617, 2.788620065335759, 5.750344099026355, -0.18533192187327754, 1.6126338027925091, 2.2646622976847555, 6.5606018485679325, 3.0549524365974188, 5.006654624592448, 5.041153350129713, 3.347922265840284, 3.7607728774418026},
    {3.2768002614355427, -0.31439467071779736, 2.9869342774315704, 4.503253242601734, 4.687200601126254, 3.1063881546286187, 5.28365928366816, 0.29480253734683576, 3.123901302390833, 2.3108605378530003, 4.48084393543281, 4.532571062946098, 1.7307196040054347, 4.748548937201363, 3.3737553140427794, 4.340339894210256},
    {3.0488973329617264, -0.6242486138914028, 5.254502729981454, 4.537150718021498, 3.6134969336273945, 5.250234678436398, 3.8146948821317, -0.4322443382145066, 2.7950289959752426, 5.03249659078925, 6.092525592906202, 5.283771021468904, 4.0159518683370905, 4.245259033536708, 3.402727053243626, 2.4734098751771105},
    {5.068364793193716, 0.8407206029436587, 1.9335488328967814, 2.228327523573915, 3.464265768863223, 3.0238731515474915, 3.3695558362177156, 0.4654898561222791, 2.471960062984183, 4.259562167828158, 4.209917767268888, 3.7869326079471994, 4.086738846270023, 3.1301108189143334, 4.01730561937099, 2.512888570803254},
    {4.165338353036368, -0.21309056038014587, 4.768855208260446, 5.86118818311603, 5.015414848686139, 1.8507693646883856, 4.695985813580138, -0.9275241916541453, 2.1947806913288677, 3.2364037082547217, 4.557786597137984, 3.563944385867734, 3.147953059532475, 4.507176412788535, 4.117647738922679, 2.2846654572806964},
    {4.218712970816973, -1.7223955585884996, 3.522016605282585, 4.336171870361995, 4.653860664382077, 4.6858016762212165, 2.604219956103278, -0.650856533177723, 0.309024060152749, 3.836889660832921, 5.857742139718544, 4.889262368507703, 5.002090794116786, 4.117206421571842, 5.04805464615589, 4.45901289413354},
    {5.192007456195902, -1.6870120773282462, 6.173526151059708, 4.804164253057691, 4.9478782846370155, 3.4457085755108783, 4.392457672007138, -0.8766812832625822, 3.5206800098041975, 4.920448878513197, 4.910421953884795, 2.9987800083733953, 3.9754217657342616, 3.831590186535911, 3.6653565298444146, 5.578121931367203}
};

static const float b2[16] = {5.194894725598305, -0.5704274094041704, 5.620021393287839, 5.330988804446059, 5.534187244387067, 4.385216599822551, 6.230967021056777, -0.2777372159896868, 2.291103232720217, 4.869837293710145, 6.183336927801022, 5.975622544043365, 4.934076650326934, 5.402683836459755, 5.031473364839478, 4.7756844888929635};

static const float w3[16][12] = {
    {-3.984523801157881, -3.7196042385659265, -3.3872846337022366, -3.4031400484009056, -3.316257262841639, -3.949974631613643, -4.378015192040656, -2.6165066955921383, -2.7163603692021225, -4.159644572628767, -4.003556762170403, -1.2418434566608307},
    {0.8194431896017582, -0.5917643928461103, 1.1397368861239257, -0.7941611941505667, 0.46819145743679963, -2.1948521593926738, -0.62926770547536, -0.6115154161117414, 0.9333793860947371, 0.15346830608683604, -1.7495553390361556, -0.8174753918407398},
    {-3.874889290308702, -4.145253244749061, -2.01279242943265, -4.379383966654248, -4.320514974617459, -4.095434108878054, -2.37324212554179, -2.4919740139169813, -3.15536229833215, -4.16841352166399, -2.370787366709614, -3.9516320725476586},
    {-3.3128962429703597, -2.7373324931927288, -3.069734017247194, -4.183967863296275, -2.67825426167329, -3.051272373771424, -2.6646205358803265, -3.6783088090356384, -2.225480910896842, -3.7478130785382797, -3.5081711022734066, -2.0763941081686124},
    {-2.08774523817913, -3.796419375337284, -4.420127617684823, -3.2525965986143315, -2.4768870333878796, -2.511593297200172, -3.1321485114155956, -2.9849582113552016, -2.796892053154192, -2.3976454801631695, -2.989456439771891, -3.975661062544762},
    {-3.6033243481558035, -3.542947881232789, -0.8043518496539951, -4.059716119744848, -3.2400518776373635, -2.1175826453993225, -3.9692576656431413, -1.7481983558973455, -3.9245620848717673, -3.381442873725593, -2.758996754260824, -3.3399484672547133},
    {-4.163513931167774, -4.390514451301653, -4.893616492778797, -3.442820015572216, -3.705418400301536, -3.349044926559096, -3.972048265626787, -3.9754454013541634, -4.736428624357065, -2.361446729658232, -3.8724094830773015, -2.916021277110638},
    {-0.48322120263662766, -1.5429573771715144, -0.08209720470016017, 0.30360233708567463, -0.7908883934871969, -1.0982557672640425, -0.9714022815033527, -1.3730971687656124, 0.9650400035560907, -2.056767572892177, -0.44678079178548485, 1.3484184568075597},
    {-1.4793806390405633, -1.2374374028383592, -0.8253207368075695, -2.5883712243307726, -3.0179305416798474, -3.785167134039187, -0.887839991704519, -3.0468500618311087, -0.6606260477654585, -2.351856476305087, -1.7377746855957072, -1.6172337725720614},
    {-2.8340154597157197, -3.6502448827971494, -2.097869665450119, -4.358970715463314, -2.6269062288326737, -2.962722659056783, -4.842332502861433, -3.385138125968337, -3.506495681600721, -1.9982777356843608, -3.300187337087977, -1.960330772692738},
    {-3.6556427901835287, -2.5689306529166114, -4.562365492714391, -3.2199105270850246, -4.2193469177310785, -4.584898450655653, -3.2720880277257978, -4.296819762683458, -2.6068349682827763, -4.34414148208635, -3.971390578881846, -4.1014980762848445},
    {-3.301783712496353, -2.449931345822575, -3.815610651283645, -3.910016440766292, -4.059459417676413, -3.8345710876712205, -1.6004938984177541, -5.950346459688763, -3.1334899692252813, -3.2808294851985753, -4.00707945509737, -4.323359232120648},
    {-2.2091765856121723, -2.243967550416831, -3.799694622331545, -2.3498452601588564, -3.520681054747733, -2.042284773535198, -2.3607982390727793, -2.6395287702702483, -3.036867345066818, -2.4100589242316586, -3.707410238651279, -2.4661853054356233},
    {-3.439974440837964, -3.756466592255215, -3.175522584192365, -1.0820365056731234, -3.4365855442181275, -2.797597648669949, -4.923390362127258, -3.6183576955749492, -3.046007313447901, -4.100432458840099, -3.3147495437493095, -5.228619873758109},
    {-3.4561979132267666, -3.5818697413062104, -3.112834094182951, -3.3759844879881, -3.1779558811722053, -2.226172153644302, -1.8673047370046596, -2.376605943146233, -4.031959999417708, -3.0009942415462274, -2.0105391898430596, -3.3487906728520977},
    {-2.816183855850722, -2.3941131263247124, -3.688516862279976, -1.2391758379170583, -1.2162155644571504, -4.013747466171934, -4.275124096295441, -1.9103044952870383, -4.877108770726585, -3.2020411760102307, -2.918832643456885, -4.2607992416125855}
};

static const float b3[12] = {-2.841305573258107, -2.9076353994948856, -2.6636332564032044, -2.4398382877163023, -2.200290540443828, -2.470872149888505, -2.03271026047866, -2.74004277600389, -2.6412449473231474, -2.6753209114215144, -2.7344564826851667, -2.4969903287685726};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
