#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.4519136948162911, -0.46298307120348775, -0.32775052713784114, -0.3679442006337831, -0.5979872496823854, -0.5676756462468601, 0.14192751669687773, 0.679074699580747, -0.6629304307612172, -0.6607159722086118, -0.4432759702331341, 0.23387969553682444, -0.35125970888707525, -0.6429978435697536, 0.4709038846222583, -0.17671250092217983, 0.6592896336730228, -0.8531828337116117, -0.7847468626921997, -0.6293561290780767, -0.034547393050398605, -0.3239279136064705, -0.2753415624322871, -0.29825179597016255, -0.20259704329551975, -0.4045740001132073, -0.6015448238968574, 1.1014969060066178, -0.41071719041538474, 0.5007024061215777, -0.42787463961362554, -0.5075869607412383, 0.7302475603770366, -0.3441853462734512, -0.5368906812335289, -0.16591412451709375, 0.7613268098654417, 0.6583535781987061, -0.31946329524118894, -0.3107192291877045, -0.6174210831752012, 0.6964290932864008, -0.48555856541518216, -0.35858329276175666, -0.3576019515045327, -0.42658073480069836, -0.23851603303730623, -0.38997010461167314, -0.42264762300226755, -0.5407089817891236, 0.8202745473639849, -0.5259262066492191, -0.2006981087645026, 0.6904074514098445, -0.16742125111046047, -0.07479229650634196, -0.13302602664192728, 0.7685277596110635, 0.7194491314506782, -0.621303089020264, 0.2418008948810567, -0.34338377749215704, -0.6627866203829234, -0.584979736044314},
    {0.46837436903650254, -0.5529166727110353, -0.18046555323215388, -0.480080007284249, -0.4958960182145893, -0.8416520737155465, 0.19667339950079438, 0.7515833148871408, -0.880641022293038, -0.42581023421197983, -0.6461499615441997, 0.525895418391613, -0.14619314414550047, -0.8475992899774802, 1.0370338657786453, -0.30279361706165264, 0.46027551926519433, -0.4416944962283716, -0.8145027782726705, -0.6315527922330899, -0.1955907796357678, -0.6137704801537003, -0.7475926694068145, -0.0382601770356075, 0.2727828898959088, -0.5228035318159583, -0.39562670867317573, 0.6672827172080552, -0.4907475330944331, 0.3323558041555656, -0.6756871247286812, -0.5605675141870505, 0.7070658433203859, -0.713347346907293, -0.5042017881894608, -0.2895560514787483, 0.45001997994307325, 0.5732457289741315, -0.43183639985526423, -0.33887536698666587, -0.5725553408106189, 0.696216383010421, -0.6139324471954963, -0.3404712854871666, -0.6673461017791371, -0.919301392267488, -0.8490904737049484, -0.660229847344461, -0.5547576981575423, -0.7192785398242404, 0.8341248105301311, -0.04872307257825928, 0.14644191734786013, 0.40196221398171483, -0.4297070655953405, -0.24621028845270618, -0.22124430761287614, 0.47437880741158844, 0.5995317283445786, -0.6218306554133238, 0.27889142966045494, 0.18787272743347022, -0.48856907464851534, -0.8148604995367625},
    {0.6084693444404445, -0.2090002143177585, -0.4602560437500308, -0.24934626860290177, -0.49766400926705306, -0.6040005411447754, 0.1975380834455404, 1.0130843168123254, -0.5318509835644707, -0.4886297091760441, -0.38496743007436424, 0.27046106973516215, -0.3923079656619601, -0.5452464766453812, 0.8468641059192703, -0.14732827188597034, 0.7217157320123228, -0.3701292234623849, -0.8711325799253894, -0.45102707484429994, 0.07330895406164971, -0.49708045928250766, -0.532173902399483, -0.048766069290334606, 0.07919671077366383, -0.3503614730122531, -0.1650437135572269, 0.9896122970287506, 0.005970170682680425, 0.40413659395186124, -0.6132559370351973, -0.8077629173981878, 0.6526125726189108, -0.3047108827317271, -0.5371800490276266, -0.15425540160356116, 0.860826907549061, 0.9015554312682841, -0.7477886085384753, -0.50433184191324, -0.7026102118104757, 0.6110782119534546, -0.35184010779390973, -0.4478754020297426, -0.48965038858735316, -0.7429625228231651, -0.5436381380959854, -0.4847427591463174, -0.4353418833956297, -0.5103216427302302, 0.9065978942977345, 0.044944342107779436, -0.26247190024835343, 1.1305539672254512, -0.20974470154101485, -0.2575542487511013, -0.26943958703145904, 0.6954633177541969, 0.9685252915058529, -0.6049681999312386, -0.07369979810122121, -0.02915221639076961, -0.30869732522515364, -0.5571369352569181},
    {0.2258447735199581, -0.7735570854858342, -0.28223414288112086, -0.5062198288067178, -0.6234893511222822, -1.115054510600433, -0.3686008714626071, 0.8930772888789313, -0.7111389275115515, -0.6511870094155687, -0.7047022564114449, -0.31759544899994724, -0.5959226579501866, -0.5970246110591925, 0.4641297863779207, -0.8384962753609291, 0.6464455004482046, -0.6661871619408168, -0.8783496353409032, -0.7247938933595568, -0.3955326997556591, -0.7090388504920333, -0.7194992712726268, -0.4827455673744047, -0.2805644714970169, -0.5185181890201642, -0.700635425989408, 0.9513025039439058, -0.5163249857301425, 0.15892333363821187, -0.8342068226061694, -0.4590717495482261, 0.9761180505649448, -0.6208879648887293, -0.9220148418533639, -0.9903276723561739, 0.8619102043049431, 0.46038452255795054, -0.6068678556137236, -0.7153643834814966, -0.914912491442181, 0.461710438399575, -0.8187707057741451, -0.9437665052217089, -0.7857976009614965, -0.9149539355033725, -0.769694083294366, -0.6721077931434213, -0.9078759075320953, -0.926169642211459, 0.8471795760187041, -0.3105512390419235, -0.4679008922025503, 0.20964427532120034, -0.5782543307205927, -0.7326960410100408, -0.45414699614312176, 0.49614050329178366, 0.5712335525060758, -0.8326252151729082, -0.1967417364628122, -0.25388802149010675, -0.9705940710934015, -0.8641134218818214},
    {-0.2226265900124755, -0.7749659620342998, -0.4444823959848264, -0.4538064192179531, -1.0391353625087607, -0.880178433246323, -0.38326803388479, 0.27189728663667256, -0.3707294408585149, -0.8786729069271483, -0.7704635727604834, -0.14533534767962183, -0.9060470530984515, -0.8621085092222045, 0.36828907309832554, -0.628335123857113, 0.41291660597162266, -0.8036324304912701, -0.9135367770374017, -0.7631346071864498, -0.44607885014118975, -0.48697645490646185, -0.4336139732663777, -0.20450556132113992, -0.01495620248296815, -0.4014677733535144, -0.88561301848746, 0.7186462385987643, -0.2710892097443402, 0.05705698290685924, -0.9232698092116838, -0.7664016341114834, 0.7910617077459853, -0.41072353875710593, -0.8518855237679359, -0.7294589124252863, 0.6220272324812769, 0.5472286945319272, -0.49359107400545377, -0.9336123248003216, -0.6522289417556882, 0.35775351936179245, -1.0111549736065828, -0.6427225650487433, -0.9038176854676216, -0.8363951708774433, -0.638477507802189, -0.7155697587489576, -0.7825084080524944, -0.9781593321177869, 0.506103301605772, -0.4053020353681758, -0.8317181734453293, 0.46272973215278895, -0.6498357467317564, -0.5245534095804539, -0.5846726696766664, 0.6127234791929766, 0.7965263158121529, -0.6399542183614789, -0.07419465731523038, -0.20525764725648224, -0.8456685040099352, -0.38608197997084553},
    {0.03442664031244393, -0.4978760897431602, -0.4418807428105886, -0.4820082990452062, -0.8692580561733219, -0.634036300502691, -0.5097249396684786, 0.4766235559424609, -0.7025105154299972, -1.0827839049062906, -0.7196024146073494, -0.15895413190817265, -0.7344774808455047, -0.6504354777155857, 0.4015159660884561, -0.6049531951157328, 0.6828901803447507, -0.8086241897140145, -0.7862808417698479, -0.634716001497028, -0.44610984367697887, -0.6754436086593599, -0.9305455121030465, -0.7549655041583921, -0.17746711798466352, -0.737791947395411, -0.6882342165644855, 0.6435805905257181, -0.2800327004082032, 0.2842503782213242, -0.8414765324220755, -0.7970641086911587, 0.40597706869131406, -0.6873515524545493, -0.8147777734522931, -0.7115697114420739, 0.8265725079390496, 0.6629153859045489, -0.5287528104484308, -0.4677710498712502, -0.77284642883523, 0.7656009630506876, -0.767975856844076, -0.8162868562836968, -0.7701124641511239, -0.8930437933077465, -0.6455668206471958, -0.9528435943662981, -0.9075506445977422, -0.6155563172587825, 0.6953354752612338, -0.3245814126670296, -0.6197256006118231, 0.6793339459982297, -0.2004692957130663, -0.589017714470714, -0.4029445787619504, 0.4854943214044773, 0.2799923099097211, -0.6744805844561081, -0.07125502613887866, 0.18104529960482374, -0.820771261586194, -0.6144454507272383},
    {0.5919971664728846, -0.534644862212268, -0.27727260320442626, -0.46234281392344156, -0.9647279711476795, -0.6186026459499668, -0.48211066418684023, 0.3745591604847742, -0.8346191816707734, -0.6313894130375524, -0.6760668889332495, -0.15366318356528033, -0.6554243508208009, -0.9144727919847243, 0.4658346997269751, -0.6120700837175456, 0.6821425593633708, -0.7706440028102923, -0.9401909152825103, -0.8783302268894294, -0.5882047408048512, -0.7916794085540578, -0.9055425886075543, -0.40051021399082054, -0.16083558839030698, -0.46016257884432943, -0.7207624931971702, 0.5265711740143272, -0.36207429115339124, 0.02405712913645902, -0.6350451627387341, -0.3822960864569732, 0.5903073610337104, -0.4478253882662512, -0.9767092635445787, -0.43775854399659003, 0.3905020487403391, 0.7473214561470207, -0.49906848142199356, -0.8323575361614725, -0.7682645472130097, 0.8472559486396234, -0.5972663639700705, -0.5570975724601883, -0.6834887748604022, -0.8190214606649628, -0.4375890359519977, -0.8053766525418682, -0.8031460508693534, -0.5885041736919802, 0.6725722745424306, 0.109267879209296, -0.6721561068680826, 0.38294693298746163, -0.34156349970306893, -0.6718051998546102, -0.3287052515872216, 0.6032541061640041, 0.3912934032910376, -0.6124982116656523, -0.013286770289989225, -0.06045989354619317, -0.6155801903416129, -0.45285536822739586},
    {0.10149119483132309, -0.6966950579556901, -0.39471527523655714, -0.7609854281688296, -0.8204045343635106, -0.7066411985755939, -0.7747473953327654, 0.11978870941247867, -0.6593931104423137, -0.719176901124028, -0.4611656673952309, -0.22155181231263135, -0.5285224319183222, -0.975776182927309, 0.6657639413398628, -0.44366526446027427, 0.46251924038334014, -0.7159154318896037, -0.653270561517109, -0.842386366623502, -0.5692435796042471, -0.9775034038773812, -0.7201164794913201, -0.5487782972409125, -0.27307151793615525, -0.5560692924261013, -0.5653020647490896, 0.6672742390495026, -0.5206426145916817, 0.2720879272338194, -0.8973848534505906, -0.8007306043322233, 0.40800479640988546, -0.33910492466587044, -0.9030079759900815, -0.8980651629194483, 0.7281005858761033, 0.6270046166351396, -0.5704562076546619, -0.8445722972137927, -0.8487500693604388, 0.5979755675038161, -0.5942432955459168, -0.6025636628965572, -0.7157662394230332, -0.4748369891491527, -0.28812079561027576, -0.9069040364716561, -0.6818017907950243, -0.6631698370565493, 0.4365236143020815, -0.24471186857687477, -0.48120168315738204, 0.3876156266468969, -0.6147836837229916, -0.3184382924329844, -0.30162041571888115, 0.2607193903436237, 0.6664528645879393, -0.6294647090232188, -0.21340387278961145, 0.008438400702053294, -0.8586546672291779, -0.48007374923002427},
    {-0.4073220332281273, -0.6440917716419976, -0.5637581254270446, -0.6937251216230425, -0.7624043624932999, -0.7183414164652264, -0.5968332084407939, 0.05320552235720984, -0.6406827326869462, -0.7565903263573628, -0.6466513490867228, -0.4083858311134435, -0.888664469560064, -0.8363607344885623, 0.22802921790234282, -0.8424347750245182, 0.36032396307889863, -0.44967293246023277, -0.7816413586158483, -0.5843215460236715, -0.6199314698866581, -0.7777259889303901, -0.5887326510331082, -0.7340589386817212, -0.21060571295439245, -0.5928853215459474, -0.5366860787339816, 0.6778184271229969, -0.5928789663145109, 0.03597842775582006, -0.6639710055237859, -0.8282886506928205, 0.6143449979364485, -0.6423916071655459, -0.6850048983529352, -0.7206290001161509, 0.5005271937433455, 0.24192425129711634, -0.39981445050394837, -0.6974619255970613, -0.630142846671738, 0.8099125742651381, -0.878923326633197, -0.5820884250400621, -0.7680329287591294, -0.7756939965404591, -0.5923516837067602, -0.5346855440512194, -0.9448288251656644, -0.8524462250072516, 0.49252187145394355, -0.10198010246631947, -0.5330576379581703, 0.09234864796912937, -0.46875646953521327, -0.4946324221142559, -0.7465155439745145, 0.3212697295718844, 0.30113189794871, -0.7948601196622573, -0.3105800233644033, -0.3632604996288038, -0.7130299374414305, -0.612077692171374},
    {-0.28903844613179613, -0.6105393756239794, -0.3017751256193891, -0.5535505995671732, -0.9027335656202287, -0.9906500755792191, -0.621333141591227, 0.5800726950164735, -0.8467791439947392, -0.7744103231181836, -0.5931608809712743, -0.249339728480146, -0.56037364858236, -0.6642169509722408, 0.8178158098101789, -0.4706751089464384, 0.5583345593220701, -0.843195777608674, -0.9532343732725499, -0.6134410967453648, -0.6377794452379691, -0.7362723967965726, -0.6965626096448356, -0.5096357103772575, -0.20879370168342914, -0.43397087870836465, -0.6519707899861794, 0.8240608770789298, -0.5947310871680102, 0.3696656891804887, -0.670403611295738, -0.9009735870134054, 0.8400978684296544, -0.5171143920156817, -0.768411586901342, -0.49269455973986487, 0.4291842445307916, 0.36389523063569, -0.5976722499840834, -1.0390201697960684, -0.943013962455583, 0.919218313645628, -0.8892619456804174, -1.0245598199311057, -0.8554024778102324, -0.8328486678081116, -0.733225695428187, -0.8681719695610999, -0.7748997455437081, -0.7754679558525399, 0.7278264825532947, -0.46674068649673917, -0.6054282821234442, 0.4356824277955592, -0.7574560764162536, -0.7628533819284696, -0.5813391082861595, 0.4870785636749619, 0.6372739669401075, -0.9239049344188478, 0.03179328442557122, -0.2216753676685136, -0.7150127367585546, -0.5394074717907321},
    {-0.05312631829970187, -0.3882459305867749, -0.22773148615799949, -0.6345570570210557, -0.7126976744798926, -0.7363434854343186, -0.707729053867587, 0.6297722598263015, -0.6946289916496197, -0.837822789564512, -0.8337314293361995, -0.017674453553130468, -0.48582176074364136, -0.7030693141738471, 0.8064334976630722, -0.4969090506405712, 0.19931429076124912, -0.8987226668032575, -0.8331875856158375, -0.7610711857055783, -0.6162761583737191, -0.8560679718032862, -0.9168608172014698, -0.6664839473629192, -0.06200459987435402, -0.4816322525688048, -0.6259099592149469, 0.5568432042198879, -0.695405413492066, 0.2186062202380882, -0.9782372589507352, -0.8785168851984883, 0.6993316722762114, -0.8452048957115863, -0.803075751149358, -0.6043019517758942, 0.38298394413301623, 0.4694069957656669, -0.583358957170608, -0.7834078820492838, -0.5369858777130151, 0.327977181552943, -0.9132119304491902, -0.8704841384721494, -0.7012953808197986, -0.7485793224149985, -0.984902220547022, -0.9374808271525449, -0.7930490876529984, -0.752724122921366, 0.5504653226467816, -0.35835758431843306, -0.7331903060470992, 0.17377348851977262, -0.357191977808452, -0.531644044599876, -0.17609507305018332, 0.36930982067751994, 0.4745729271074625, -0.6971233966854191, -0.3915314047706124, -0.3696027348498912, -0.5685162625590728, -0.7457584579465728},
    {-0.4609243562012292, -0.8496552753644633, -0.23548283780649573, -0.854751971900967, -0.9362699185007293, -0.7929831237374638, -0.45993562767877927, 0.1690237789137382, -0.517851078286501, -0.8505416707704753, -0.7077796949679062, -0.3864683982931252, -0.687252524161311, -0.581187640949085, 0.407907172693089, -0.5847296180338583, 0.3303291087643249, -0.8668693936845063, -0.6987540254922678, -0.7100515909112757, -0.8265774979342124, -0.5848363040879436, -0.945964356487031, -0.5064086534545276, -0.45395503548597366, -0.4313145651716229, -0.6196092338048974, 0.4183671147972743, -0.6063934952238402, -0.1323933161623999, -0.7429785476874256, -0.7599952779675933, 0.5737419520259047, -0.8787348173616578, -0.8287167743720463, -0.5362892129383305, 0.2109855436974701, 0.5380699964345249, -0.723055207198479, -0.5674194849425852, -0.8166444962110789, 0.34647475090936525, -0.6452786412543671, -0.7792097492926441, -0.6744323915395958, -0.7553376693417558, -0.6732307723613058, -0.48028124192226496, -0.8707304992096933, -0.6764879521049729, 0.4829881191365531, -0.3998563132895267, -0.8610772150274358, -0.0588650645012424, -0.6091448788889395, -0.27486810087687413, -0.6878038394752873, -0.057504721840132236, 0.46573893451663867, -0.8600141314612547, -0.3398981776885213, -0.21241617178871067, -0.8449932097815843, -0.5763940372104782},
    {-0.14190498750858319, -0.5709474955064112, -0.4276582846361348, -0.5496576956262131, -0.6909304950847875, -0.7029124589673015, -0.5549919856940154, 0.5305589098141708, -0.7561572374837945, -0.7887669339012756, -0.7235401138201498, -0.10164662419324463, -0.3313501192255438, -0.6951912314528842, 0.37104390415471994, -0.722541601806748, 0.3390409565908423, -0.37536132537562295, -0.839132644111923, -0.5941572332513422, -0.7270323419888824, -0.697548402223679, -0.7455013071798172, -0.8058463649942492, -0.2332697170624967, -0.519016195632297, -0.6381850161673902, 0.49118245503914154, -0.517233654161731, 0.07959827306790379, -0.8985918414921082, -0.6990646059555513, 0.5709799895067436, -0.5127904581597207, -0.6959724785758689, -0.7150755855493246, 0.43986200957895, 0.624965734214905, -0.7478407039751335, -0.47517825712488027, -0.7508342392312751, 0.5840218133094114, -0.7131726027298063, -0.6692391806890878, -0.8086710290396387, -0.7021994511666018, -0.6536093411546503, -0.4392563256026544, -0.821175013393459, -0.6034497946270626, 0.6644814655494495, -0.4485032901373247, -0.6834448894320081, -0.11119613849258442, -0.30192446740108875, -0.5458546128418551, -0.4619495526057486, 0.0791208340704752, 0.44430838835953296, -0.6969305495344545, -0.4594490979225146, -0.08773919910582322, -0.8294989414194492, -0.5031960349174109},
    {-0.2256905571134224, -0.45633679255749215, -0.2750888458651909, -0.3756000342648438, -0.7851637678618226, -0.581552118271506, -0.4150413390025281, 0.22820490267431606, -0.5449986940736318, -0.5974362476537458, -0.643839950025716, -0.40153297048060455, -0.7347197963103125, -0.6246679423779927, 0.5960393636160443, -0.7601551847219936, 0.49627256685433446, -0.8442933317762076, -0.9302169231124765, -0.613216236669791, -0.7097563590026463, -0.51739701317309, -0.6774511119545077, -0.6247751867540203, -0.3435237151315523, -0.42074013360364204, -0.6972822566404213, 0.3576256648158349, -0.5669859736427043, 0.017850712883263935, -0.7695050935899992, -0.6536885438321222, 0.6432318954294971, -0.7407568316579004, -0.75385069313491, -0.6838151879500247, 0.16377866537806324, 0.35770358419881293, -0.6621405312066225, -0.6714191150866227, -0.8372987460460818, 0.3643569245975252, -0.6754507926690804, -0.8046879855655135, -0.5844876196700891, -0.6637431765971058, -0.6947772667588045, -0.6549588295650787, -0.7162456814139463, -0.7561072611699676, 0.6611676274177993, -0.07603655010089236, -0.7133288747413554, 0.1851835365617889, -0.38010637873636244, -0.5270205761310612, -0.06343002660124739, -0.058593133946391145, 0.5321455662575049, -0.7609264774859402, -0.21725016439446984, -0.28175359235954134, -0.48670219300897666, -0.6966346489706864},
    {0.1632636941517288, -0.771303410457704, -0.22609952921604362, -0.6298678731143935, -0.639604609765308, -0.7267821049600283, -0.3424364644898386, 0.5902917095174024, -0.7311382787607718, -0.800558932366503, -0.7317391854359779, 0.0679495556323464, -0.5617033442998592, -0.8075490239701458, 0.5911837117514785, -0.7632395840973824, 0.5688494457103279, -0.7305019993887588, -0.6430746264077085, -1.0168804364313686, -0.32988837389037934, -0.6076932100556397, -0.6881450998893565, -0.49401582375125713, -0.22473413494462993, -0.3373503434768602, -0.662392263114995, 0.6438433935765644, -0.6328341860512602, 0.18260289306832062, -0.870803899340044, -0.8648613690803665, 0.7609919070895523, -0.42913289005160815, -0.857676244068978, -0.568975584579805, 0.6203116222433589, 0.6904154094663094, -0.7735051131855626, -0.5956249815397124, -0.44162127557432734, 0.4354703756453748, -0.6762907226004273, -0.6945441506822075, -0.7180552196881836, -0.7629654914636073, -0.8377849251204569, -0.4015365887888194, -0.7075599343728566, -0.6011705288022219, 0.653502796591171, -0.14887497433379265, -0.38944626663415305, 0.2768385326539491, -0.29182785997088256, -0.5392002290654826, -0.5021663655273634, 0.4565375376975908, 0.5609575749595127, -0.8488506735380996, -0.4035844714991544, 0.014778110928456833, -0.8600378347180112, -0.6672402278258662},
    {0.200603244754326, -0.570189005787373, -0.6171512509657463, -0.674555715866219, -0.6377685915063986, -0.8530637743704792, -0.5337663890091748, 0.6547365885051176, -0.4802376851000594, -0.5298821788098333, -0.7100683175018736, -0.11336159682829455, -0.5029094340497895, -0.7760398537371109, 0.5692060468165463, -0.6743329960400085, 0.7964581905639747, -0.7780121038361172, -0.9148357801874688, -0.8975072988284585, -0.5899920439761341, -0.6268383411542826, -0.6951264355666007, -0.5155359085006462, -0.2651069286696985, -0.5585272669340738, -0.28790691805513113, 0.784738463509627, -0.537279329495896, 0.3562970797093592, -0.7423663247412741, -0.6589741767686997, 0.66383457797771, -0.8912124133594652, -0.9928600762340541, -0.31380341291410363, 0.5913958868040456, 0.6383654160324213, -0.5063389034640109, -0.6598012558187617, -0.7787263449856031, 0.6987503936825421, -0.7497171327255403, -0.6557075638622506, -0.5066555150522234, -0.6831017731367033, -0.6648394613044497, -0.7717641340710127, -0.9289046006472119, -0.8661981627859796, 0.7208273755055301, -0.09279042283106509, -0.6481399278342115, 0.639772208232567, -0.31362107137727246, -0.5993037203845077, -0.4593283968764565, 0.6951745483107085, 0.8834086520287138, -1.1179379855524936, -0.3296011803669433, 0.06333326688960247, -0.6594302200244218, -0.849956508350149},
    {0.10882938505936451, -0.8054119245728497, -0.05244561844927535, -0.361616071813251, -0.8697889889704012, -0.7540923004713087, -0.3019759493874443, 0.6904826574647768, -0.7343448535267104, -0.8875950370010246, -0.7012028554121355, -0.008837172903682466, -0.7607350412935314, -0.6517246585664437, 0.5875862414380816, -0.6591544647522681, 0.7750123927841004, -0.7698974085438711, -0.8197378408643757, -0.5375095373798587, -0.4881378127226653, -0.37022423206733945, -0.9178709110313563, -0.36530371496977393, -0.08745495794075886, -0.4734166606083942, -0.7489922645006089, 0.9231512122559195, -0.3351982265147188, 0.2167606404569488, -0.9415181786556415, -0.626083045965274, 0.8245140949625109, -0.9475665782170747, -0.5359646757533211, -0.44872645157358426, 0.8182091986117594, 0.3727527610160959, -0.6038344323108918, -0.7420750936664942, -0.7751953699470495, 0.5512314689552216, -0.9653221439957734, -0.7290566552280103, -0.5392827348213294, -0.723961730698953, -0.44117033589862337, -0.5834522622756767, -0.9300235846685103, -0.5808113750669464, 0.7440584065281938, 0.0410874642968346, -0.7024567067560289, 0.47387165857911007, -0.3916286541958355, -0.5935826098909937, -0.4321231871456088, 0.5929021832624742, 0.8353173373510664, -0.8967720405274011, -0.3040336004278875, -0.2138653587467207, -0.7237973959626838, -0.6606412135167632},
    {0.4070806803116586, -0.37764657799511914, -0.22531411333024948, -0.5041827158462814, -0.5823344917289498, -0.8550651388126959, -0.2431392662684353, 0.7290603248244393, -0.4389706153174181, -0.6758064047606783, -0.37775906769671763, 0.21896554731563658, -0.36282539017879506, -0.4015206340741449, 0.6622821259735961, -0.5390479107957356, 0.8585902203801048, -0.5952952983132617, -0.7558475783798388, -0.22854729334270618, -0.32308387390571475, -0.4475906603956399, -0.6608924723208842, -0.34756144517550214, -0.11990318289124421, -0.37808529889013914, -0.5507956728701993, 0.8304448082888913, -0.45717883747322685, 0.4848398523913237, -0.5558547061908106, -0.4762172443249805, 0.7724373597036214, -0.8023822491875402, -0.4695114697556557, -0.3759856251899552, 0.656061857353716, 0.6225567145859779, -0.6462972665520694, -0.6180548717569567, -0.598709876477326, 0.6823660394207245, -0.5425768117815267, -0.6299340190606313, -0.6475626805149205, -0.7381220067065464, -0.6397660352115618, -0.45431661510620214, -0.6657329860991306, -0.5408258368132509, 0.8690696412550244, -0.36300858568888333, -0.5401277078927684, 0.7803320083047884, -0.28862878540836645, -0.6618721711120186, -0.42752606311192426, 0.8955590571696964, 1.104551586166833, -0.7366487594578452, -0.10668145545408297, 0.0026466953480550814, -0.7932323785375522, -0.4212239315833896},
    {0.09055260186871014, -0.44494442194978195, -0.5564318667373834, -0.17230037189601663, -0.7870253444975064, -0.6000523181165357, -0.4232432636629078, 0.8720161860690632, -0.3540358532511427, -0.543859592443579, -0.4610995337130896, -0.18126682365912275, -0.399309062030296, -0.5441971673560513, 0.7353385082571785, -0.5924982573534906, 0.8235004097264155, -0.7266649680251268, -0.848540805359068, -0.7095889464364683, -0.2449115145683892, -0.8274363918831185, -0.7104442428419858, -0.11431235432050246, -0.29075362616820344, -0.4165915882265411, -0.7126940686204307, 0.8468523906673443, -0.31628011354872326, 0.2513283275781966, -0.6198276347517694, -0.5782113618159829, 0.8537875752148757, -0.4603571653346015, -0.8490473907484297, -0.6154205147939025, 0.7423865310252867, 0.8137521199812875, -0.484075009407054, -0.5549578404752702, -0.47387487421819574, 0.7266053574674878, -0.5425367157476226, -0.7725561821912067, -0.7527791186064295, -0.6768541443018076, -0.6072400861694455, -0.6834409980499261, -0.9004651507770556, -0.5988546916643707, 0.9510704654672733, -0.18893420616536113, -0.42003052405758656, 0.6440590451698595, -0.11322732607359619, -0.36010043435994016, -0.36756763393459774, 0.516186377443784, 1.0482640701757682, -0.6329212459452871, -0.05302499693331011, -0.24058140504500694, -0.7199142541052185, -0.35203638866888953},
    {0.3866158574546919, -0.7327424435606319, -0.5110198553944773, -0.5395413907122246, -0.744842887227602, -0.697135063674076, -0.40155255537105816, 0.6414668408028514, -0.5570056131054619, -0.592749214479221, -0.5684935134454677, -0.03304570773197923, -0.6226120570894611, -0.7614862819470116, 0.9432397863868968, -0.5882483457110896, 0.8968463812455815, -0.47120487444286624, -0.7602774321250494, -0.7665888283530324, -0.3043491900744062, -0.47339131062276046, -0.9170784418842945, -0.12715451404074085, -0.07403786622581526, -0.43091664282797176, -0.5859678806488724, 0.8745183610979378, -0.4481985167595772, 0.26263490787411004, -0.7966481425548835, -0.5027043528176538, 0.7986161265366207, -0.7018448984381691, -0.6855478268548929, -0.9765544107147449, 0.5354777397710476, 0.5616637166982674, -0.6267265895736861, -0.5705781615280169, -0.5895366369885728, 0.810107693730688, -0.4831712164641935, -0.6056762823820501, -0.77361216383779, -0.6322163809757609, -0.6448756176623169, -0.5739247734887407, -0.5101974418797672, -0.7404944810645406, 0.8489306667485758, -0.14231293732680758, -0.7018772413011276, 0.46682663101671373, -0.2845206327850074, -0.4638718518793955, -0.26388845971450225, 0.27527447537667177, 0.9826033066627615, -0.5845830239714034, -0.5949761202676307, -0.003582053990478922, -0.8831307648484414, -0.7590489073395109},
    {0.009380552256617953, -0.6097888779076642, -0.0994241647029502, -0.6792076369545439, -0.7590810323826522, -0.6222706022367605, -0.45263057128735334, 0.6407385784366381, -0.5717391886354588, -0.5381290116992782, -0.7378313867252303, -0.03920686809440974, -0.7403199198725692, -0.7817081138823723, 0.7441638762515789, -0.8938348779597749, 0.7758939309255167, -0.7216489323804011, -0.8207971776666793, -0.9029912284045186, -0.5974024671865586, -0.8947201012030875, -0.8097702815952335, -0.2967820379973188, -0.1807832093822895, -0.5758863499193646, -0.5807720538220859, 0.8576873944388853, -0.7388096315604209, 0.3981520442109069, -0.9308295587840099, -0.7244092332294003, 0.8252875958384192, -0.8537858292533336, -0.9936708603867592, -0.500990481955093, 0.8902489954813791, 0.2543970386261721, -0.7455540695663323, -0.85542006865459, -0.6974327751924683, 0.4055167747048511, -0.590270633978459, -0.6343010622637348, -0.7596376625199341, -0.6495516085211633, -0.718815934870738, -0.8096039254624888, -0.7087985335053044, -0.9360067885034579, 0.7932848699599334, -0.35706217557530473, -0.8112244674866388, 0.3071338571893422, -0.2687886665954713, -0.4100237686820623, -0.44003336742734034, 0.5447469525994403, 1.0111652060927885, -0.8814987737314166, -0.2042486991981669, -0.20042966766625797, -0.7154271493993912, -0.8885093688817531},
    {0.4547419722557949, -0.4781301235634248, -0.2317656271378035, -0.6668317254266922, -0.781359156049984, -0.8200926887829241, -0.28979338221407486, 0.979591301834346, -0.4514314015960063, -0.5852354544515683, -0.431396760247952, 0.07346668638763326, -0.537005725464495, -0.4959037501235575, 0.9281480089392707, -0.5261454910685646, 0.5481367361600766, -0.5206786732459594, -0.6783488956126353, -0.537246171025843, -0.27790790007874083, -0.35030049818116643, -0.5441247048251132, -0.39576973830535284, 0.046868380756867715, -0.7567085248858942, -0.7351847266188035, 1.089481945583706, -0.43687421888587935, 0.49127769498885365, -0.941142634014519, -0.6827914969466354, 0.8435262726381861, -0.5948570513793787, -0.5382179594224107, -0.39994280969792295, 0.9773150676144909, 0.7188972692185113, -0.474280294063424, -0.6144755118728957, -0.7555672763736943, 0.5437623733133742, -0.5663448854889972, -0.5521901331882911, -0.6807906758761483, -0.5359561554751924, -0.544395609053179, -0.4446268660888001, -0.8539911570144225, -0.527890823107654, 0.9385296993771658, -0.3565323441926932, -0.3249216257540077, 0.6841519925781651, -0.4176238397177215, -0.5898271678470421, -0.3438256504358356, 0.7423264479419848, 0.952686344475649, -0.5154595548728643, -0.019533824533982856, -0.2660441930283838, -0.6227204394398632, -0.5984771210956945},
    {0.191061221025979, -0.25161134278242375, -0.25728377323909934, -0.48002278111322083, -0.5635239764697212, -0.8541493777871615, -0.03290872300209231, 0.9646575851284604, -0.695981812656652, -0.7527113810816835, -0.6916339066463705, 0.32718616677454887, -0.23496629770280084, -0.5361706897311507, 0.8481273426510564, -0.6644755244149547, 0.9682682779613844, -0.7475659880403842, -0.6463480446692836, -0.4764751037786632, -0.2625342144714172, -0.6773762549306697, -0.6708691686155278, -0.3140382069354706, 0.03867851173964672, -0.5998354247813248, -0.49889770232512265, 1.3029273573084772, -0.5385131346753117, 0.4489849951896341, -0.6048163832380131, -0.7507867935950662, 0.788445549442374, -0.7076477032426917, -0.8146485011325516, -0.5052329701760114, 0.7552996541077724, 0.926569078185302, -0.46164361461132336, -0.7444189874192836, -0.7287118156142236, 0.6563085951196613, -0.45659663378578746, -0.4785408653968075, -0.5516287351728181, -0.5602805261494294, -0.5960685222463087, -0.41287552257784843, -0.6088597547514808, -0.3366218631265129, 1.0290984634715115, -0.16091023745565897, -0.38343650182077144, 1.0033964630922498, -0.06402966042675856, -0.4307420132418173, -0.2542335364438224, 0.6092307012304766, 0.8478283037032435, -0.8128027017313172, -0.015397869959382615, -0.2595526480018049, -0.5606072318220857, -0.45689416944160516},
    {0.1376047781001843, -0.5502111136212676, -0.4273490763981047, -0.43830758108650497, -0.5675841927234362, -0.7250540346702498, -0.17825740487597122, 0.8619358366984465, -0.6629823579279455, -0.5532142940857214, -0.7469566117232275, 0.17543889275099592, -0.480280295783322, -0.5219637992690334, 0.849430985682052, -0.5090590511136465, 0.5665506949190696, -0.7715909604650181, -0.843436657004745, -0.7933829110074387, -0.4721258142799571, -0.6459379238449425, -0.7434844751260457, -0.13014626762353715, -0.059291549659397, -0.6551389956818996, -0.7085453811421986, 0.786060213465072, -0.19194670837089925, 0.5494237278135624, -0.412785199342619, -0.7373908176687993, 0.8672546118523848, -0.7248001345590394, -0.6647873238838476, -0.45568435280020403, 0.8128031851061447, 0.6015866257901457, -0.5046314379868698, -0.6771174244293796, -0.6505067594238924, 0.3964271559516565, -0.4856191410796457, -0.653751786785538, -0.7220869974656959, -0.6280646355414465, -0.7811367122206148, -0.6251083738214609, -0.9541879937466838, -0.5130513562489838, 1.0566770709439492, -0.2526420763699026, -0.4965511211173283, 0.6865730246688316, -0.45088572035479485, -0.2922616683753189, -0.41616647542065904, 0.8589375070641014, 1.042238755331656, -0.7199469147016294, -0.0019872456217246105, 0.06002738026838791, -0.5808640625412885, -0.7454969935389042},
    {0.09491099915315855, -0.6339339013972393, -0.3450394284946362, -0.4280480252127727, -0.7944829520096923, -0.7369759022086246, -0.40236246972710854, 0.6385763273497246, -0.4753703716729364, -0.6552801070005371, -0.5393922890590802, -0.10960577528885496, -0.6641130084129275, -0.6072136359413315, 0.8811269561308054, -0.7344866967102126, 0.588631176935549, -0.7960363025529547, -0.6698262791590939, -0.6112864660029063, -0.6471833349288033, -0.3528483292222389, -0.7286113269861058, -0.557687074099601, -0.08204637238450434, -0.5929705165660816, -0.7425610509839774, 0.819484963502035, -0.2604040420020964, 0.5071669270283474, -0.7095057927335807, -0.911104224391724, 0.6939084820730782, -0.7214964815707771, -0.6274782419462059, -0.6651372460687656, 0.7116813127786499, 0.5080888066090776, -0.7717803116356812, -0.6416832972242585, -0.7014280576392516, 0.5979310982952152, -0.6755808452631151, -0.5716074764043276, -0.49781933573541437, -0.4426858815128074, -0.8219158745254771, -0.5364082000114339, -0.6070667353096398, -0.8290098985047599, 0.7653756396857787, -0.0819285988602402, -0.7136081483481687, 0.26005605399693593, -0.4342535375522513, -0.5035289299885957, -0.37848459806044166, 0.7121436891543765, 0.9172756229915897, -0.8580540115033688, -0.33028465462637924, -0.3209360065977063, -0.8443198612933707, -0.887195665132396},
    {0.11318136676102745, -0.6936229191095858, -0.4958563584906565, -0.4510889793542182, -0.5193697713648759, -0.6744265166659773, -0.4906906723446119, 0.880045099121271, -0.8793749322077424, -0.765313871896464, -0.5595277914800374, -0.16378627123176775, -0.45031474795402143, -0.541447449107835, 0.8784513345817555, -0.686768288478073, 0.7586552247681039, -0.9695355029934801, -0.6717278240407194, -0.4139617525471203, -0.7556984341796745, -0.6115655844198361, -0.6122258385382289, -0.577673494244989, -0.29067061621882245, -0.4961753094396893, -0.23850913272694801, 0.9153203980219904, -0.3215763664991953, 0.28601004550187437, -0.5102367349431457, -0.769211880972731, 0.5417568074843302, -0.3797943553646052, -0.6439851441729311, -0.4620511648218861, 0.6201226390274762, 0.8163279558362062, -0.26470574872813063, -0.6938191065123295, -0.6958078800861044, 0.352556733201088, -0.7644765513571151, -0.6069479480237311, -0.753873172155723, -0.3964013849404899, -0.5367129809201604, -0.394653382745664, -0.7357098607257307, -0.6136372565981008, 0.9776883443121254, -0.13554303755413105, -0.6645485289445774, 0.3437178986359814, -0.446820986097772, -0.4885300018554663, -0.5022209700184699, 0.6026405099976547, 0.8433084753186975, -0.6218264417046134, -0.294139841801335, -0.33560426015916006, -0.6011282333329633, -0.7190057174463761},
    {0.5670163165032277, -0.5954839340047346, -0.26557655026442123, -0.7224768912374525, -0.7390583752509164, -0.5902284084452277, -0.3009266560305247, 0.8889497676080447, -0.5833065318942553, -0.6470069375166804, -0.3903349907218312, 0.1172311878781864, -0.3639409365756163, -0.6907360376844307, 0.7947473329108856, -0.6023875793822938, 0.8618772458880448, -0.6982967094869875, -0.6801329998699641, -0.6241407046322981, -0.3743901476436475, -0.6881110713000815, -0.46193826120114123, -0.3675279344477081, -0.016247323064575, -0.20137851004286916, -0.5896205015571122, 0.6971580549016112, -0.5536764768282991, 0.1072146270911799, -0.8149694823534909, -0.7973495440978212, 0.8314276765656363, -0.46310823403540474, -0.7815725630673888, -0.3206168254288554, 0.77585467091675, 0.8104276262914268, -0.6228294198093534, -0.7298328182119432, -0.5660558575376448, 0.6085800704359674, -0.6541472453275742, -0.44397771577503714, -0.6805796009621864, -0.48922718671698545, -0.5733683482614134, -0.6081374078489614, -0.7254503284006406, -0.8295393117647358, 0.9256020557080493, -0.647994378543716, -0.4632226142758719, 0.881407918021913, -0.395329122022206, -0.5950585003752445, -0.4067665327692024, 0.820117376311574, 1.1221606348199593, -0.8669306610776699, -0.11336672187884324, -0.1956797669212878, -0.5013015720562639, -0.650385500936998},
    {0.39729719045000556, -0.29359870746974354, -0.36015015465437483, -0.3023271632472101, -0.8105132337881383, -0.4083526492450685, -0.2211419293549806, 0.8280573104318443, -0.4876353026407046, -0.46634574092104514, -0.5609710948005346, 0.11672780383132875, -0.38781802923043096, -0.7047566066507478, 0.6618474430573367, -0.45277014510987035, 0.8611623299165435, -0.9050713121283469, -0.7415308088030798, -0.3930994941500068, -0.35142360146945967, -0.4060293311952962, -0.6135255817884102, -0.10597388438823238, -0.037479978404009295, -0.3358917956341685, -0.6870553388224455, 1.0985565923665939, -0.7061443845853332, 0.4984009893145335, -0.8215004957984395, -0.8094551603945023, 1.299794236454032, -0.7241916241200833, -0.9734520829165383, -0.6500434272624095, 0.7744739517064628, 0.7381968660827746, -0.6998113991420818, -0.7469652292756468, -0.7379981314741253, 0.6063560137536558, -0.6338637659051788, -0.7194633806904247, -0.5098457883559209, -0.6266151036202239, -0.5245740559819626, -0.8472709888144273, -0.7796293186087262, -0.4897345336057987, 0.9086799983069207, -0.13665461500136555, -0.44196887295188775, 0.5418931896828819, -0.48820295416686477, -0.40150338013650144, -0.46294285984022193, 0.9566955653967552, 1.0050189405090535, -0.5392656398261977, -0.044266027209295816, -0.289874071189075, -0.6278779651767172, -0.8401846531277424},
    {0.18935754705464986, -0.7790946233675112, -0.14150261000353465, -0.4069011624038078, -0.7436764605107978, -0.6738348596920083, -0.14320922559934107, 0.9208683661485686, -0.45178677714447996, -0.6052533084147914, -0.551300411044039, -0.08346121438147554, -0.5263350970606655, -0.7403978697043144, 0.747049629238484, -0.6950786138164633, 0.7656028741615774, -0.9305638921821847, -0.6316108859400064, -0.7706840219762768, -0.2880734314879632, -0.4436735703878408, -0.7230670976022922, -0.22279972076464327, 0.12635153174454597, -0.5916917533831949, -0.5612554492416656, 0.9344126268021614, -0.6556691318234625, 0.2987656883473353, -0.6147124175194696, -0.8782579486819553, 0.9191500006531974, -0.5114214849320846, -0.6367693062081835, -0.4362493755932869, 0.7124175955185361, 0.6420540704173892, -0.424507760089721, -0.38766624767175367, -0.9781905112645961, 0.4230381704380209, -0.6634767363448629, -0.45753960678680133, -0.5626639602592679, -0.720030321254617, -0.5036521675976575, -0.3913996560929026, -0.46084271771200636, -0.7031456195175906, 0.8988727008988385, -0.19447387179655104, -0.6424934356696199, 0.46853111313914897, -0.28701866245994345, -0.6581607716177298, -0.3732627805239664, 0.8021328570236984, 0.6596376658443283, -0.47949115684568233, 0.196593582471301, 0.12376559462852331, -0.723657797241802, -0.7954459042064308},
    {0.14937691361052619, -0.5030209918519213, -0.46821740061818523, -0.46185524058760463, -0.70905202466703, -0.7317048409540257, 0.04384936902602394, 0.9842417933790155, -0.5333183452729052, -0.6632855293904331, -0.5364177528633511, 0.12297862278056365, -0.4993365543887369, -0.7387842903693994, 0.8348793396737063, -0.6881816902423604, 0.7547520259231077, -0.7543417537387472, -0.7230785594397114, -0.8218805443883843, -0.30602418540043863, -0.5366542890610609, -0.8139053722516993, -0.14856252732692943, -0.17306296535984092, -0.43077529353184557, -0.44091915962070927, 0.7886549203265143, -0.6470804060066756, 0.046887627759819805, -0.6565647233705407, -0.6766598817156857, 0.6581252079334724, -0.46949121412318545, -0.7779403342119681, -0.23344706298792006, 0.6244732912089411, 0.28419062317574334, -0.7299570539622623, -0.5970253454731719, -0.7461196233715878, 0.39406697466564455, -0.6468882941672707, -0.7670615795940078, -0.6893191114882782, -0.45902462714220627, -0.7835156418261012, -0.7658934376207911, -0.6455359234296358, -0.6240909819938849, 0.8031136418846397, -0.3272211292684672, -0.4341893874423539, 0.48683615151366755, -0.35082317541592617, -0.5297000532817067, -0.3147368007025601, 0.4434419149334801, 0.8060303623285257, -0.6641530218833486, -0.24149357991307252, -0.0602843247911509, -0.8097667252806449, -0.6800162177223954},
    {0.3372054432004463, 0.1705533571512432, -0.22182059603461596, 0.43771607979597493, 0.7216742301312596, 0.5287641323086169, -0.23282491329228108, -0.030042157746943906, 0.4849614955220533, 0.27265572368620145, 0.5899780595580174, -0.1367110866941275, 0.39506573847457493, 0.22436873369542798, 0.22482842630326458, 0.3996273201850452, -0.08387598142426195, 0.3563946998949321, 0.4991012931253244, 0.4143185466662796, 0.20402428203375048, 0.1750693495717994, 0.28019928514508646, 0.23276904866150278, 0.2142515080938596, 0.19538826343458313, 0.35256137083367334, -0.005962702736016043, 0.877598372596108, -0.3123006105130488, 0.12661690235540787, 0.45884432013974186, -0.2748211790399876, -0.22210098871907785, 0.2831553000114647, 0.18234659190566477, -0.0024157404777931726, 0.12057220433078004, 0.2738476252956917, 0.37837344090710184, 0.651930114510065, 0.3356633419338907, 0.008973702540179656, -0.1573050228477862, 0.5262568416370047, 0.5822764718394365, 0.4299317248116193, 0.4045320195001213, 0.5103970192330445, 0.3066668024405895, -0.3162005778855827, -0.19835984754202285, -0.10344992200121637, 0.12886015451461846, 0.30728007762122195, -0.1452101136391596, 0.37299571318816105, -0.6847597124504485, -0.6491615522871981, 0.5261379432030568, -0.03306536862124126, -0.22416765858286908, 0.5178636147136532, 0.5779750988955391},
    {0.37392419096099716, -0.32750162423936596, -0.8052867925422745, -0.4375518429272659, -0.3247010893407733, -0.5372242776770361, 0.1007261277653064, 0.29646064997129046, -0.33202987102850545, -0.36567013558032746, -0.17789157160754104, 0.46887824838821224, -0.597267009668953, -0.6975591024519581, 0.3046383312130899, -0.17587373941828738, 0.5127626175812795, -0.5091082757685405, -0.3760081847328065, -0.439793416429462, -0.015879673571006992, -0.3301380239863498, -0.5748629408913242, -0.32623575607162636, -0.09301740801024673, -0.28201555722628796, -0.6949406006604697, 0.6505968064728683, -0.3118929706174335, 0.3059365538662803, -0.6670545221758098, -0.6716747150542249, 0.2750701556544347, -0.4228085221424482, -0.576424443964158, -0.29681564297203605, 0.5945479712404373, 0.05488554921625285, -0.16518760374127414, -0.6773886450957795, -0.1598110736337316, 0.17913231937618054, -0.5037940529803632, -0.3290734036578093, -0.3776621280512767, -0.497565011381292, -0.7967949664404296, -0.543395615080259, -0.2680008555093289, -0.39007935789669834, 0.36767811326666683, -0.23765316084680305, -0.17407958052102582, 0.2603509730807707, -0.5626503676991582, -0.83106422947439, -0.3050747561983738, 0.394529810181575, 0.5907222485764849, -0.39547537947517597, 0.38519984058704604, -0.4013480487831971, -0.7341262609806705, -0.4865940238763649},
    {-0.19285795671298045, -0.19651572858688465, -0.5159637380793944, 0.21076967965250393, -0.13336629473939784, -0.017918705440552248, -0.5265557637091709, -0.8574871473068377, 0.23825244189610242, -0.1696933155576192, 0.30576470866236843, -0.5445346183667911, -0.18665844229384612, 0.17120601486408224, -0.38130586829702556, -0.6116093364452335, 0.25464003908614097, -0.2917409658996803, 0.1044376639784553, -0.14272460845771026, -0.28375615642781915, -0.3850287108721222, -0.19325763728942272, -0.14309989516407884, -0.10633867797604712, 0.31217099038821083, -0.43030823676502505, -0.4256493254396107, -0.008740342061740469, -0.5547085088652527, -0.1389416959467884, -0.1309465084614593, -0.48794617875707924, -0.5857643594520366, 0.12118570905144191, -0.15148027959422988, -0.26715100703818473, 0.28543274729680834, -0.17895499611716764, -0.10478857351076526, -0.08121998426062771, -0.18149000365451368, -0.5930720460270602, -0.48376608747332434, -0.2649721586856049, 0.283379114961648, -0.05986363183555224, -0.5006762620989877, -0.0683566342192681, -0.09422937246322902, -0.4378250835625589, -0.1193741544636223, -0.43947789364199025, 0.15302177571133127, -0.3062754483365223, 0.012762493087145632, -0.22479170948799215, -0.11351138280160929, -0.3125092295311424, 0.10925324514895653, -0.1666685275874777, -0.4910213639244287, -0.44430771556668114, 0.16417237874105636},
    {-0.4206711661584969, -0.837649970729444, -0.7373548117397833, -0.13158924360732818, -0.3824151029377513, -0.48197778143573855, -0.6429648070481346, -0.5592706468931553, -0.5079283930424644, -0.4092784093950478, -0.3497171829037984, -0.5202671138796358, -0.5474746794413722, -0.5431141340790875, -0.3495466324059971, -0.46557423185879765, -0.0729863145130983, -0.6378211605097548, -0.4925739849576987, -0.36464832119053553, -0.7544442731287566, -0.43395328200661765, -0.3182208301787612, -0.2815055117854313, -0.5511833527203983, 0.10186848092405774, -0.5353212414486778, -0.5123613870056294, -0.4339482096086893, -0.5165869432233369, -0.35133443055027697, -0.40912325846572256, -0.5667250158367002, -0.6994151731957048, -0.3143666688766017, -0.3201624811677189, -0.24082727327265346, -0.0916994261301946, -0.37957252720344564, -0.2737991579566908, -0.07760559954997197, -0.5925212378315708, -0.503295748907223, -0.2270305607484348, -0.6209907961637974, -0.16709070086806638, -0.6168353079860017, -0.45949767796941043, -0.3481626018060507, -0.5088869488950419, -0.3726134351467597, -0.1266890675590501, -0.1602397276142607, -0.32459415085063104, -0.7159009616701378, -0.2587843732336951, -0.41142677569842107, -0.22303602383803514, -0.44898454376603913, -0.2137440537726411, -0.23185448691913246, -0.6370043314597402, -0.273493548732545, -0.1404991625260917},
    {-0.30331937312026563, -0.38519811976423207, -0.5046454809345176, -0.15183634905617524, -0.6106153518753433, -0.5943181401563128, -0.42643280146574575, -0.25236158189360103, -0.6035893978315344, -0.4361592569228546, -0.21892261243037872, -0.2746216983707501, -0.6649553976266803, -0.5004517196190011, 0.004933123679552051, -0.5310621616898274, -0.025378370532821694, -0.35299612002844777, -0.43240108946780453, -0.7463170458258094, -0.5649390215093641, -0.5495173105942488, -0.49614187015880334, -0.4107526486249376, -0.4600344157616401, -0.34084693920012976, -0.5381351617745672, -0.30138968134395105, 0.035914992147807044, -0.22227765911383413, -0.603264761783524, -0.5786777723938514, -0.196118254987896, -0.5425736721759491, -0.5799487888588264, -0.6628191493633482, 0.10093670751514817, 0.4055612152895058, -0.5613056544407665, -0.3407364363952166, -0.41232673712108375, -0.4223381669107586, -0.5530978977465354, -0.3335916570832077, -0.594732976791872, -0.6681282206958538, -0.8005590848346654, -0.6268279090108365, -0.659767486474646, -0.6400609298169373, 0.06465389340782357, -0.23039801379815392, -0.5322280557737952, 0.09877384098803034, -0.48511148843908086, -0.653684149275586, -0.27138567999719726, -0.04971362781442894, 0.17961859093960583, -0.40103216694554517, -0.12344335153766589, -0.5365115538007798, -0.6978774947961096, -0.21903829784213952},
    {-0.2396292868235119, -0.35428604283093973, -0.31881869459420403, -0.020768817059166642, -0.46438772393548877, -0.4879453300548431, -0.5631434493064178, -0.22801628634153526, -0.7693225537389541, -0.39507850976444664, 0.0898490580636564, -0.19266131915462, -0.5237603519917561, -0.3645602600818996, -0.08664422222986681, -0.4869291304913404, 0.24950575271654693, -0.4535479803667738, -0.4041821890686215, -0.6232312093455248, -0.41263055048648756, -0.17841742607111405, -0.49815721517110995, -0.5279579372281575, -0.6515775358722163, -0.1583277204268131, -0.5038439372638657, -0.12459064557525242, -0.3529469461573459, -0.17435422331443987, -0.0560768182150701, -0.43990364545426314, -0.08812145566833549, -0.7532352709735615, -0.5896150082675188, -0.46720200131979894, 0.11340439386006032, 0.17878904513451005, -0.4376382497599871, 0.10120250356217464, -0.6772324043256368, 0.1470272497079904, -0.6031389718832421, -0.48885726842255717, -0.722262691019485, -0.6474106861389792, -0.6953347744477875, -0.48534034147076194, -0.6325656515053628, -0.7285038471386056, -0.01399360564084194, -0.4367705151731375, -0.43747297552442416, 0.16989968429220234, -0.8702816104547307, -0.05668768795657381, -0.22172531717691493, -0.1008237218808569, 0.06104189179807667, -0.6766707849136514, -0.1740550318326218, -0.28218825686167903, -0.6171251784801272, 0.058986417285135706},
    {-0.03830625267823144, -0.18574280333689328, -0.2822839131668926, -0.17004320515517915, -0.7104890279492013, -0.43814687268721914, -0.613814932630262, -0.1706828531585425, -0.5517820465030097, -0.6489173486553029, -0.24569191772529306, -0.5160868091993409, -0.5846821063076404, -0.4090780624955744, 0.12526008202580788, -0.6593463977537319, 0.30402664036442, -0.3805014934340848, -0.540334447612317, -0.6240538838057539, -0.6350753326315101, -0.31763882571950297, -0.3315569843861695, -0.48679678330513465, -0.5897241851328999, 0.20624688895874324, -0.5519276161530153, -0.23912517656180907, -0.13125467804326008, 0.1849105794104786, -0.6391225440744385, -0.4979445430241484, -0.004802917858543201, -0.6469577284017325, -0.6381546077856236, -0.6084074962406202, 0.260731052727348, 0.2441842233481221, -0.4868495154502144, -0.24361494371756212, -0.6600623747743021, 0.4094172139154425, -0.6327204807659115, -0.5605722597811841, -0.6454354217826337, -0.5484420631451468, -0.7159831661793924, -0.48029691969163163, -0.5570906792984984, -0.5548212006259563, -0.030520274580364413, -0.5092864285195193, -0.5555834751222354, -0.06338776991229639, -0.6759177051579784, -0.6214910082303633, -0.024000806263104118, -0.5033156414839456, -0.08098963542888, -0.48819495740128205, -0.39238236288173617, -0.28867472606319405, -0.4343780891698942, -0.03273512302584998},
    {-0.6425779836005436, -0.4015988123583766, -0.538850879641512, -0.3638981041511326, -0.5285856281882351, -0.369590280558379, -0.43697291292097556, -0.47354266629555203, -0.33586315387776966, -0.45276284728164823, -0.2709675000609273, 0.1088524034157911, -0.39494355286029525, -0.3243696761146595, -0.22265643455285838, -0.7970508003324251, -0.21998296955648047, -0.23031728294424497, -0.35588431692750694, -0.15733785622102014, -0.39956077926674505, -0.5436081588207715, -0.4160328223158236, -0.36890801801220036, -0.47060698180584215, 0.11083787960093078, -0.7000558090488901, -0.16992831821976606, -0.2438447897737097, -0.22125571911582406, -0.4851419559015612, -0.46260629150589433, -0.08036864084292894, -0.6210995711012356, -0.3405978648845833, -0.6226300604352126, -0.23513951592569907, 0.20681987050082798, -0.46272642970557626, -0.2912647781713674, -0.5346645463644535, -0.012069763490552747, -0.6060134187107574, -0.4026154387094964, -0.895939968760984, -0.5610228068819454, -0.20150602816743998, -0.8116667068122173, -0.5215578386616996, -0.507745452565316, -0.33947295369715225, -0.5532940159252652, -0.5710511897729827, 0.2150716985604904, -0.6292730056219196, -0.4066590988681589, -0.2814426542085244, -0.18818606411068772, -0.23041801415432012, -0.3701155871346833, -0.4008907122607917, -0.3583557932896749, -0.6155336672033473, -0.06326869702790222},
    {-0.5274338535675126, -0.3092734169155199, -0.6368750200003156, -0.18985562352906613, -0.5705665824162687, -0.42940538461466615, -1.0083795781551828, -0.28754221993272033, -0.43846871637952917, -0.565221929773781, -0.4107711962184495, -0.40150145000348686, -0.39611511493814006, -0.6245343499244028, -0.15352647695837796, -0.7208690672846875, -0.10031339109474564, -0.339678165947892, -0.6956119265548215, -0.5730868109118676, -0.4398569611195336, -0.6597738653245588, -0.7916307243350692, -0.6308744528404154, -0.6638585325420762, -0.032061061301845134, -0.5063253127275968, 0.11670939976239054, -0.4005190063910443, -0.0758732499105423, -0.27781239616207726, -0.4491039920324177, 0.06355808031135812, -0.7268210482331, -0.14590496129659813, -0.6617553455447049, 0.29969638872537385, 0.19786848127722598, -0.24352050622381097, -0.37073430768888044, -0.6400675510750652, 0.3590396222666654, -0.14541770052456604, -0.541484477143732, -0.8054053467312461, -0.7542918327938367, -0.5607554461604346, -0.598469507405025, -0.763304982862767, -0.6591530293152219, -0.14729571445031686, -0.5680587514965185, -0.185790578052393, 0.21048303190669662, -0.4086159775861904, -0.45373989552711297, -0.5235051377264045, -0.048402238267393795, -0.1663338136708712, -0.3049113303063757, -0.19566736794095427, -0.6266877694314422, -0.896013869309138, -0.324487829437335},
    {-0.053197437033711194, -0.8615762049297602, -0.35855561566111505, -0.3749356251028091, -0.5063264883167458, -0.5334074653508657, -0.6230350648922621, 0.029281541213564664, -0.749458560763093, -0.6603732956735443, -0.13362418280484026, -0.5100613928012167, -0.4335902565527805, -0.3061732689695711, 0.15770081736367844, -0.6301538492166567, -0.06148418143109707, -0.382142967699927, -0.7022710772997875, -0.7652025206990384, -0.37074408974822404, -0.8395017378229273, -0.7109509886253049, -0.5559889678645612, -0.5891927382599493, -0.004789208540212838, -0.5408357211773253, 0.019069677491332378, 0.14602489036605387, -0.30576429675195815, -0.2981538618640549, -0.45636142135580365, -0.02176726610602778, -0.7135434687744605, -0.6028222096143769, -0.4918602589004169, 0.4071403053648117, 0.16958615777024263, -0.4595042623334066, -0.2668481149618892, -0.6827867385979474, 0.23303552028610885, -0.4224426644022841, -0.454140182232723, -0.3813895383875321, -0.7149423692007832, -0.5608219710487627, -0.5048033097546547, -0.5345363143641434, -0.6457514030561299, -0.0903981321317688, -0.35237403562068587, -0.5017947036316545, 0.14910476793465272, -0.6519099249431953, -0.7121159918855975, -0.26424699967458937, -0.5037695227102136, -0.15123098457867748, -0.6942548035620909, -0.544883617068231, -0.4169805987290249, -0.6460432737161612, -0.16355465541817155},
    {-0.0472683691626392, -0.5467935384543505, -0.5959669989538411, 0.013782874607410511, -0.24529264523180003, -0.5108192082693767, -0.7205191099913498, -0.38321779979099985, -0.5719029046654796, -0.9195324800116548, -0.058679786871065634, -0.5565668908757248, -0.3674924808510685, -0.34575203725860576, -0.4071344997484179, -0.3752179597765568, -0.13602033617091167, -0.33745602509301476, -0.3506364684930743, -0.6014311349460603, -0.6139748275843199, -0.06698199890352123, -0.38833668076087463, -0.49460654559885375, -0.4922730765455421, 0.06835605185959441, -0.15306284421795513, -0.3942450795030919, 0.22154477545196047, -0.34577984262671335, -0.334390249087415, -0.2224800199921877, -0.11200047444687851, -0.31544202449307857, -0.3297952476122721, -0.514312013139333, 0.1409701765300587, 0.10543197844837096, -0.6252910097027393, -0.3330234487137398, -0.41772887362903616, -0.21884149204914113, -0.47123545932546174, -0.403922295470911, -0.4844128011322049, -0.7164395390764952, -0.5563371918363802, -0.69619698252133, -0.5858355735770588, -0.6125380370454983, -0.32855391597985717, -0.578324618288944, -0.44388944694531546, 0.11071467970021004, -0.3501004441706925, -0.28066682077936367, -0.2672140848837769, -0.8300492762164189, -0.17700830740841414, -0.5103141259312214, -0.5278925998444536, -0.8860620233188642, -0.6070833993255917, -0.08543700795224649},
    {-0.003766545116693411, -0.7140387336039596, -0.40865233128200484, -0.32001756485165367, -0.4849149563961375, -0.5711436779632042, -0.6053572699269552, -0.3744443614707581, -0.483030212916232, -0.5551290856464324, -0.08753098385569244, -0.39957754109816845, -0.4572153007161943, -0.28960965121278975, -0.4229173903160382, -0.5122749695306393, -0.18124472835782404, -0.2645199548010149, -0.5566476743758237, -0.5256680990629619, -0.6389838883477339, -0.6267555500958342, -0.5828625339750438, -0.5298147798793694, -0.7605243697936038, 0.014968102840360313, -0.3301800225873294, -0.26731246874618053, -0.04989064095363072, -0.28082154069228626, -0.5351075862587541, -0.7298674168937774, -0.21178106895911686, -0.4884997175977436, -0.6983825935740382, -0.5525172586762372, 0.3487090134971489, -0.08240621317933808, -0.7702953446340131, -0.010041833719598587, -0.3453251090759467, -0.08350932840828754, -0.47824632537326806, -0.4844581105731203, -0.5484545597104244, -0.5706519278319617, -0.5322528150360514, -0.5861141585136461, -0.28946937138996537, -0.5949843141737502, -0.33519534096012676, -0.6226436103534488, -0.7270488897915144, 0.18558828915352227, -0.853843573955727, -0.5434724706967448, -0.2892864297399637, -0.738038049563059, -0.41616622511549656, -0.45364330847298634, -0.46686321918155, -0.7045692819636414, -0.6701301466239049, -0.1276979956218754},
    {-0.2688094703232012, -0.6467804109021421, -0.5582455784060956, -0.2273027677815495, -0.6816453246196796, -0.6833729920841327, -0.4737836675663198, -0.03007722821965599, -0.6603546578553151, -0.6351277799883717, -0.4050230752669495, -0.3826379580128675, -0.37502317171640115, -0.3011434649323053, -0.31177845116085884, -0.28064461518339756, 0.2227238509201537, -0.46719115802865124, -0.7021526821899619, -0.4990762862853986, -0.7938006877319512, -0.6763504798486859, -0.7128080854040095, -0.860247458946556, -0.6495421476928649, -0.11296881340940372, -0.3605855237653362, -0.17502611425770265, 0.2520164274085575, -0.4500694224585697, -0.39769233593152276, -0.6986397402213206, -0.38355074066175976, -0.722528121528929, -0.6567066827384875, -0.7109809828264159, 0.16816969515282776, -0.007917199473465978, -0.39580852289069063, -0.09977600289451279, -0.8504256595971639, 0.1674217373498242, -0.6789159659843272, -0.4867883436781231, -0.4577274549280035, -0.6504655203679424, -0.7846819526373724, -0.9781407226077009, -0.5133024564448438, -0.5751995176550044, -0.22772950533071346, -0.4272266259401137, -0.6769212115015891, 0.22115298101436165, -0.43058043860594114, -0.6096497844203504, -0.5159818908098041, -0.6539114831354476, -0.1870174924376273, -0.4545750236610156, -0.3705589667016474, -0.814683706270417, -0.37087588476214345, -0.12528200654418076},
    {-0.41174745730566864, -0.6045305127047325, -0.4310972585063686, -0.06341997909749655, -1.0008788608383064, -0.7104339028857961, -0.7051536081507386, -0.27475380450801257, -0.448013541171834, -0.5989987647827894, -0.47238617715721126, -0.6842178774241578, -0.5990281127208209, -0.4686262714911329, -0.5103736155398596, -0.5361756142023086, 0.08946353431567314, -0.5012124830146668, -0.6451636525404679, -0.7904834339128005, -0.6129637191744743, -0.7150636099619087, -0.7694246968265798, -0.5957412439357944, -0.9744325048654169, 0.06102565897888062, -0.7660073471633445, -0.200835443090468, 0.27868275333168346, -0.5692119437020026, -0.44029388610471576, -0.6621786535489935, -0.2754434616110112, -0.6217995508557964, -0.8415427074019544, -0.756325995879269, 0.3072619442164791, -0.45418866811006975, -0.7085207315324238, -0.09856851692761673, -0.5763472492437713, 0.24381885026716932, -0.5556409448103169, -0.5546765634020449, -0.5301724389542519, -0.6114838321317411, -0.509445118978822, -0.5240521012314607, -0.7177238187892672, -0.5775065950792949, -0.4936426447912249, -0.7258019875298022, -0.7331380736129686, 0.06404294258818874, -0.8271483305688142, -0.3451126059810703, -0.2954246619021682, -0.7961490013648069, -0.3450031640551735, -0.5849024316689846, -0.391160568614599, -0.7054466668935461, -0.6167079277131424, -0.08819912917822183},
    {0.04668390578396707, -0.6233245609017063, -0.8064276646975868, -0.1938168934718, -0.7326835359451926, -0.6960135336298755, -0.900668105492322, -0.24916437568667157, -0.5186062243360988, -0.5515912685232668, 0.13886492350569374, -0.4492521275520168, -0.31621573287496657, -0.565463995890345, -0.30619304234601014, -0.6388826456848837, -0.12253194705072222, -0.2789646563549523, -0.6469725438068825, -0.8175894526720212, -0.341844289778065, -0.8895355643357614, -0.3794691381636068, -0.5362799434372091, -0.7313060421083641, -0.1992808723540382, -0.6484091796540798, -0.2295143866632195, 0.07297198537683831, -0.7513491354374402, -0.021625646966776883, -0.6902047132995646, -0.21092790538916312, -0.5205754658341059, -0.6358486087841578, -0.6398079957222582, 0.2573727531017572, 0.03529915116676258, -0.4944717812043562, -0.09559883064433553, -0.6187478843688748, 0.0746747558592911, -0.60637616405367, -0.7346768854493729, -0.4438573428556342, -0.5708576784036007, -0.7495632665852467, -0.46063684314112885, -0.8565491709882798, -0.507991955711334, -0.3925663433285142, -0.6771126388406301, -0.8254378447166447, 0.21961771244086034, -0.4190839636829401, -0.47977184930266287, -0.2663883990313192, -0.49650127102265074, -0.3397214553783924, -0.4017499228077568, -0.526141604088279, -0.6386268733617871, -0.4206197844789996, 0.09476230077751402},
    {-0.14403839585461536, -0.5747169235966392, -0.46691851923396843, 0.06068042835863388, -0.40120640174363753, -0.312500934823498, -0.695059940269041, -0.4935829012059756, -0.3701570121866453, -0.6494979475804684, -0.037946125703815434, -0.8909767284394611, -0.04193663132960983, -0.5024606623463174, -0.33047024521023177, -0.6688533705642555, 0.07860318981902105, -0.43559722491474845, -0.6946325796115768, -0.44723716523936224, -0.8705534784577132, -0.4776922179034257, -0.43446125123148466, -0.526045964627971, -0.4206941033936085, 0.022595661153493395, -0.47654628030686413, -0.5537713538920941, -0.10032700199388864, -0.3172580316370882, -0.11668459777526916, -0.32933525568642646, -0.12442922571034583, -0.559612122585574, -0.3632996466683418, -0.6155433147882726, 0.35709546034830336, 0.16538770765518973, -0.3500738620135839, -0.4959430952955993, -0.5563190610877814, 0.07395947881546831, -0.6060842272196353, -0.7347038041867083, -0.30466928498377693, -0.33108028749117896, -0.24779859481792518, -0.7652687059006986, -0.6360444808362125, -0.4837436899283986, -0.6155617742819783, -0.5469299734943878, -0.4075686471906194, 0.13902403965267585, -0.6668167285420988, -0.5336508063197568, -0.41759239530615533, -0.18804811893122567, -0.4976067247183407, -0.14740435496821955, -0.308414655933337, -0.7076170941368758, -0.7711710631473866, -0.38832137537995676},
    {-0.060324137362271164, -0.6901378236236843, -0.3882602973307535, -0.13535133312025255, -0.33355150271869666, -0.47651696947698996, -0.631263333832465, -0.5152310903904039, -0.31757963130299144, -0.4927450465842112, -0.2937302461097604, -0.6294828597994058, -0.4204083907641679, -0.5791153555402013, -0.2967736163820577, -0.735510232578746, 0.2857674459719655, -0.09563649970243271, -0.6909616868540868, -0.6874907668655685, -0.6567284904273548, -0.553471620751973, -0.5012059507203335, -0.4526785043156578, -0.6178187856493073, -0.0004825056286778302, -0.4337697993530408, -0.38759851363892056, -0.29153306613289637, -0.5172893229357028, -0.3954355265598869, -0.6248576905357397, -0.07800016349321647, -0.7551108656564112, -0.32839880121092163, -0.45540284031416933, 0.22387266448922818, 0.16757041846785037, -0.5051092932202755, -0.3960234017262187, -0.4629883531200871, 0.11240262466747095, -0.6531604226278592, -0.6885901234810309, -0.328694418719004, -0.36306822034400865, -0.4819256354431991, -0.605749089080547, -0.44974821614328064, -0.39806148609190456, -0.40951974564458377, -0.5467649037965999, -0.32215631198718386, 0.293085474524416, -0.5307823562402253, -0.5272309279127795, -0.41444300734719464, 0.05132901104906689, -0.29418848811838866, -0.4662431873307398, -0.29520631934596403, -0.512982735399108, -0.561890969970913, -0.38978477239405745},
    {-0.10747632166723206, -0.6798459553263759, -0.5606361559942917, -0.1879372157835067, -0.5289976634620918, -0.5893719669456076, -0.7267092074897709, 0.1599519194184594, -0.3085577375895209, -0.7633753001704439, -0.09333971765597375, -0.1937965692067508, -0.3933417625333901, -0.15527642555272597, -0.009904439197815917, -0.3737853803181469, 0.34601149707221657, -0.42334773796580666, -0.6614980369189277, -0.5466801557902548, -0.42250145110823056, -0.3980217491228969, -0.319600132501405, -0.23366581654630136, -0.5413348034401306, -0.21489812810725148, -0.29977171905718475, 0.32452644158453153, -0.060479463710551316, -0.3859986286625177, -0.5179464224598705, -0.5382195090602307, 0.4535651357931875, -0.5913751377785305, -0.5162452682446591, -0.15232627529264303, 0.30913080994557607, 0.48936323541749827, -0.20141686740814638, -0.1961438411255412, -0.5306513570127781, 0.10261869785246813, -0.44656289336655963, -0.6182604512799859, -0.3318231091208185, -0.2935535806698641, -0.2278504739766329, -0.34242409497570364, -0.6535240162857939, -0.3790331966257159, 0.2620272468580166, -0.6691971885842074, -0.24228686065829355, 0.277353552921173, -0.45604247079163074, -0.5011841616895671, -0.5931352054538321, 0.0844189706729865, 0.355820237623227, -0.5682211727030738, -0.10093905288001782, -0.4753215349194275, -0.5643084858692156, -0.4824930193499994},
    {-0.003538743209532931, -0.2510399856918594, -0.4865029827559102, 0.14540692957265774, -0.2608367034556792, -0.19308234918545256, -0.5985071598054542, -0.6108195589774142, -0.3509098119559866, -0.5875944945231525, -0.07762018465412453, -0.916702594048109, -0.659792949385991, -0.22151415355694273, -0.25675892166526354, -0.4843346416407349, 0.044609691505920174, 0.2612385158145838, -0.5595486854637356, -0.4447657471442223, -0.6972110057034735, -0.5817028888796972, -0.2556604156656428, -0.43851584715144576, -0.47171763948187495, -0.03710369020665954, -0.784315350555419, -0.462499649955965, 0.4431003480941702, -0.45248684013526724, -0.3030064513661288, -0.3786397551818769, -0.0017948746448370326, -0.30846042639975735, -0.365101520464205, -0.2623507616547503, 0.35973185634643057, 0.23825919309342228, -0.6316979989608266, -0.060945896245592976, -0.34691174763669075, 0.013646256966416942, -0.5679956015317338, -0.2656357172962791, -0.35887801510675954, -0.42539057153322757, -0.40485280374977, -0.6491232291771836, -0.4705063663545117, -0.24700797019476672, -0.5000502484047654, -0.5860756972919661, -0.5999352901821958, 0.2843994952860015, -0.4624476375499294, -0.23137370844513447, -0.5663583662598431, -0.4724431507778754, -0.37792255682263726, -0.09976582497797307, -0.24709392958862791, -0.7594500015977184, -0.41141634938038923, -0.17661764801781016},
    {-0.2327902399885117, -0.686702790056282, -0.6589554258270357, 0.1672054017825076, -0.6351126535671185, -0.7187059144399612, -0.8156208187874057, -0.47652143548781917, -0.42156228826074255, -0.7315308618948617, -0.037479334972328, -0.7418458210592087, -0.4663391261628873, -0.4576959017417632, -0.09937164424424846, -0.4875626580984591, -0.01616706775343337, -0.21034910555734362, -0.31866365562169174, -0.5290906895393372, -0.699950698129501, -0.8733342009801192, -0.6457825752233193, -0.5948287384609028, -0.7998880717566136, 0.0050618368126484695, -0.5242846085956573, -0.34683320724250505, 0.28383311157917346, -0.7309893326178749, -0.23471005947528448, -0.2443870899406573, -0.31098596037755577, -0.7396839179746847, -0.4510829752722523, -0.6168399948563914, 0.19717536193994514, 0.5164790396144694, -0.6580220496542021, -0.2552548640916202, -0.3485621232169371, 0.24658857748895224, -0.42889882886644204, -0.5531956632901314, -0.36633901765836663, -0.8986772312171155, -0.4672049507522269, -0.782552393750102, -0.6528197226631896, -0.5973637235214513, -0.6303897432694584, -0.8284776524194888, -0.5570583904700621, 0.2248692710843451, -0.6084405831665476, -0.4330892135840004, -0.641435298250105, -0.3928358489017795, -0.42230498417253454, -0.4161354548038007, -0.3372742325213002, -0.625885675086132, -0.4870175675795659, 0.06324684440899157},
    {-0.2616161125394251, -0.6877596949341224, -0.4671820170044748, -0.25145023207585526, -0.6903086631196661, -0.6377423087039056, -0.9055258691965691, -0.5264344709523491, -0.44774376255931964, -0.6306345063354425, -0.5036009987182788, -0.6841682801679708, -0.7870930010389853, -0.8013165836475, -0.24243548528214642, -0.6777972253879231, -0.09116539952586006, -0.6005801634219516, -0.6984202495469668, -0.7657875358994224, -0.8241423724381975, -0.9793551307259138, -0.6045405061138465, -0.7971416742366477, -0.8248288170510437, -0.276502182036636, -0.5633448250968971, -0.4478139363726487, -0.43224297614643115, -0.5477595776939256, -0.5935975004166238, -0.6727766558586868, -0.2683273843471314, -0.6296214864466163, -0.6088999196142139, -0.9006517953553789, 0.08585273434254524, -0.06348536555086563, -0.6841005252618476, -0.3436155702980121, -0.6181549948171884, 0.13963964666339493, -0.7917656637167857, -0.7521701462386818, -0.6471027095607893, -0.7572868422721822, -0.7507850076074044, -0.7437051674364714, -0.5228037336200023, -0.6932284139973893, -0.4347384050613686, -0.6743358328010302, -0.5424178029031937, -0.32194621372011184, -0.5801126481595698, -0.5148956341232144, -0.5240254394473668, -0.4886258855606593, -0.36179602429829427, -0.6183408867198804, -0.6829686198030688, -0.5793466268234593, -0.7220643685241169, -0.29107753507048795},
    {0.05591130104648252, -0.4191083179074374, -0.7044255569845749, -0.2226849855913943, -0.4992186673226236, -0.7836186546526532, -0.5730142622857132, 0.20498581016117384, -0.5173607788682185, -0.5481665823750188, -0.14177809710633585, -0.6391739044155363, -0.45340534005731103, -0.567091940322788, -0.011026059403860797, -0.915072422473668, 0.48538471104678765, -0.5827292909466966, -0.8576652493984255, -1.062223321411768, -0.8209692487795189, -0.5600113461499161, -0.5873905693737181, -0.40882872470885673, -0.48157330810702786, -0.1859443007984944, -0.6344722026638472, 0.3657630855321953, 0.1571182126257268, -0.1250761445868958, -0.31888436827548094, -0.5242848151960733, 0.04834420208455899, -0.45027443310907556, -0.34369285599275706, -0.8961719385914575, 0.7457221683131011, 0.8023237603397076, -0.6852643823848801, -0.2848778261183993, -0.7233685132383236, 0.5725975960812886, -0.7459949669676189, -0.45497611647373865, -0.7121693410869466, -0.4798359705488903, -0.17959241212692154, -0.6483654235759237, -0.662146840271309, -0.6184910301497609, -0.06933920596306728, -0.5419240201632967, -0.541399012017031, 0.7092079654860131, -0.7449733130076449, -0.6321187225043076, -0.5562092804240775, -0.029439263260860035, -0.05830487211179461, -0.6672034955667522, -0.15965377442999565, -0.8656330303360042, -0.6093935506942081, -0.3411654663436558},
    {0.46785822884525113, -0.34162865209432325, -0.6244024796533509, -0.009506008002905441, -0.6991273173885916, -0.43836335929889064, -0.8372506380474589, -0.33463550428983546, -0.5315794601273757, -0.5215472714199011, 0.20892078275484371, -0.5861624602495865, -0.23382873419457897, -0.41332638763053037, 0.01027868264484429, -0.3291305364182292, 0.08848107786577772, -0.11429538827155673, -0.2679562164786859, -0.5334099180434326, -0.38203773790369283, -0.4388836193485328, -0.4665785532200039, -0.30969456395462863, -0.3826018844580484, -0.06253780829404701, -0.4838691948821976, 0.3211028747226774, 0.4822678353533693, -0.4439114719792647, 0.07633948489505915, -0.25518882316336855, -0.04487160547287924, -0.10394855485471803, -0.3483519506436245, -0.3521203393977068, 0.4485547476209038, 0.38736103033939506, -0.3846375413235592, -0.39178988147458843, -0.19761737384359615, 0.7238755216272384, -0.43930853826231736, -0.45046519694254106, -0.3686101841656095, -0.5515679870976588, -0.12140843070418546, -0.44692328488478167, -0.5659099906357095, -0.21325539000048313, -0.049731227289340214, -0.47618780848393255, -0.3597031742751543, 0.6848462060437074, -0.5457567236030101, -0.2619689293296836, -0.17633801494820994, -0.02340788280777501, -0.11903656245169668, -0.07941087643973993, -0.28700613618817106, -0.7086787115203536, -0.6592754380142687, -0.0557982072252103},
    {0.38618271406045696, -0.38947805566826804, -0.5937798707218183, 0.24123154657685994, -0.3882388287235077, -0.33721793712974796, -0.7930495111759892, -0.5765504981892029, -0.5968658862124167, -0.5020034451636759, 0.07918721971898306, -0.8022153093711724, -0.33370898733415555, -0.40006013699853826, -0.15400044138122496, -0.39960711512851815, 0.5049615896900715, -0.34776922372702807, -0.2922316565876302, -0.5232928867627785, -0.4946295652567944, -0.8216572075019264, -0.34312346097764695, -0.5145067599707857, -0.6526148183707215, 0.1271014919441265, -0.5571895033704953, 0.0015742787679593965, 0.06318632108458741, -0.6016158778453854, 0.08197731749459228, -0.2679578421725615, -0.30661031189645843, -0.6045928041780283, -0.5373685012894877, -0.5552955219864435, 0.5174421247572276, 0.2754073879541248, -0.47543625668527945, -0.27708028726498635, -0.32588495177526505, 0.6300541172997436, -0.6525674378216053, -0.6572029474556901, -0.4976810424404353, -0.559392507822367, -0.24899184657845855, -0.5233099232526012, -0.4494769520156928, -0.3797752486265905, -0.6380050803601272, -0.4276420137465782, -0.7201572595282487, 0.4932850174537193, -0.42888823228677125, -0.6283937433341766, -0.3457779757723267, -0.2170629647147098, -0.6690577216814069, -0.14366993712839593, -0.4909575766054951, -0.6499219904106123, -0.6839431128076492, -0.17892304726418504},
    {-0.16309495912137598, -0.44156926373161964, -0.5728836628516351, 0.14840817274385837, -0.7060077458583632, -0.5242479116155211, -0.5763467060045909, -0.4828923352318731, -0.5660433522986011, -0.7314446336604813, -0.1711763740666027, -0.6130375940876227, -0.41861823845539037, -0.2578646363458806, -0.009809337839858583, -0.691760014223873, -0.04846560686652543, -0.21536863172239953, -0.7774050045270747, -0.2973654763964656, -0.6735868371318999, -0.4976967810130001, -0.633009228766152, -0.6009639475958418, -0.36123420342278767, -0.3338089074600868, -0.6203460837076319, -0.35056301201487233, -0.08617868376905972, -0.4397499402912636, -0.4088306367020602, -0.4293153788294075, -0.39338751721571225, -0.8586031839904872, -0.31617044896095126, -0.7415416311117986, 0.48904071866543136, 0.3020644052894665, -0.5139102793347551, -0.6950510737267962, -0.3167768625812105, -0.1095034613427827, -0.7684444776775383, -0.6504240151768524, -0.574829067908381, -0.5344833035460245, -0.5559434390791114, -0.7960936054330034, -0.5069727252002733, -0.664354045139302, -0.19641308378552616, -0.9174125283641141, -0.7428640170483402, 0.16939483572060524, -0.6305120606100656, -0.36258062122464557, -0.4817613230133328, -0.22021394599276617, -0.5293374343894479, -0.5701781623529182, -0.4724408801265311, -0.6674647578695556, -0.5535862132686141, -0.19658766995688848},
    {0.036361757349874624, -0.49023073676281437, -0.6846659216822681, 0.18938596925459633, -0.41581277958297114, -0.11091435062180498, -0.8323336636919488, -0.7376391264687192, -0.6057017290464952, -0.6629224518610903, 0.17492849788372689, -0.6203867640303522, -0.32442728515703184, -0.07146403813924505, -0.12327476399730042, -0.444821755983438, 0.2995184631829294, -0.21664616420047159, -0.5237908025380899, -0.46387228421601484, -0.3470358478440317, -0.6166731241685233, -0.44328857598291, -0.4122948824816704, -0.5130051196120168, 0.38633042043505716, -0.1696321639811169, -0.20340761343607525, 0.6615273792549036, -0.8570996244304404, -0.1802418380937238, -0.4005230320284234, -0.48633171013943943, -0.33331809300690657, -0.23201887442594152, -0.6785136050145136, 0.3661676424708859, 0.3706798421667513, -0.42148009787542706, -0.7541472051010378, -0.30169816774006875, 0.3783001105298526, -0.7839679166999961, -0.3632176972760844, -0.5174929275606943, -0.40448705718533373, -0.17664107466211568, -0.7470672623125736, -0.48442353858242765, -0.11198418160041859, -0.3811505036023585, -0.6904584296718588, -0.5040070417742324, 0.35571278335131085, -0.37291135322276253, -0.4566537401108803, -0.37037671290776203, -0.21788250980479823, -0.48798482371763274, -0.12616992078514663, -0.563238425099201, -0.4743750588917374, -0.3989713973913461, 0.04932722972750884},
    {0.13902718298337677, -0.42948688059251217, -0.48326573503262726, 0.2519790848663909, -0.43278777473320484, -0.4122224237681558, -0.5662359137109891, -0.2812242139875416, -0.4485137695531067, -0.3832820116972693, 0.08021496340597621, -0.4740620151766626, -0.21911611600781628, -0.21500893996954276, 0.12566743597893332, -0.7193863979375044, 0.44194927408735324, -0.45035647384123134, -0.38794237814732657, -0.5026568701140008, -0.25654282956291186, -0.3400463919756072, -0.5318310493947989, -0.4121386817221519, -0.5868391265698316, 0.15798467855719595, -0.15328953299125436, 0.3343092210906708, 0.39333459756994543, -0.48417175179207517, -0.37162542510794183, -0.22676180016634043, -0.29138125859139424, -0.3765642629273204, -0.45972997619984696, -0.6544347821168065, 0.40773393691153964, 0.49000407613328195, -0.6247619931963222, -0.26628604785317966, -0.2216939768866283, 0.5628622125819008, -0.3423095926531398, -0.3206744827207905, 0.0083880169264531, -0.37999644775416314, -0.26332373437403545, -0.5289248006947289, -0.4581769257901602, -0.4732151281608014, -0.44957808491194134, -0.6873842740213681, -0.5646838511967416, 0.48901106865013444, -0.5631665843391331, -0.4696139181473472, -0.6445486890831535, -0.08268967531264398, -0.18436015279327422, -0.39663102977067866, -0.16525714013133383, -0.7911775512909383, -0.38501021926381335, -0.13811669706014154},
    {0.03768133102508588, -0.7221779810640897, -1.0216116789094263, 0.09654322797914193, -0.4228100709589174, -0.5062726302540956, -0.43349254131387804, -0.26519280191502886, -0.41558820661062873, -0.7781226415197152, -0.1065800903046431, -0.6966131119360149, -0.3515842507254033, -0.29422226032214416, 0.16845179644912328, -0.7112341009114636, 0.375204830587001, -0.681015793845222, -0.5819132110727888, -0.6799080944755822, -0.6840062509122575, -0.5550823903067797, -0.9056157727426104, -0.5753104916993902, -0.6643210911976135, -0.16112232247311642, -0.37887000458774966, -0.1250355868520011, 0.2548506024847553, -0.5482445157009433, -0.39747373990055346, -0.32642044635001766, -0.32747699059185226, -0.7708575611408467, -0.5246811943372208, -0.5410578228562607, 0.26630075255063246, 0.4014861853780688, -0.7203996557720681, -0.6315891378880744, -0.26213592513123946, 0.23885732077908522, -0.5156111688693598, -0.6348416969686368, -0.24874400701467214, -0.4754277543613282, -0.3296430335233931, -0.8892822145048914, -0.5551845187420269, -0.505542812586182, -0.5020502589761394, -0.8335482201895413, -0.55925438027953, 0.554256919146008, -0.9541233326577007, -0.5954626843306354, -0.33874705235634617, -0.3879450447588698, -0.7250387780461341, -0.33402706669876014, -0.32682015186125785, -0.7667610263648442, -0.7023198961913796, -0.13823939129775512},
    {0.23335819592903725, -0.6752061609477158, -0.6684985719058697, 0.13604735796447728, -0.4639301943750876, -0.0811372978117815, -0.6055376713232482, -0.5526104377805693, -0.5625096846998225, -0.845642874930157, -0.115225864657281, -0.8092615175435331, -0.30581454919228107, -0.1959557163091057, -0.1583250620202556, -0.36883215269987374, 0.25994599509553823, -0.7066379733743005, -0.44679216523019727, -0.7637966494397128, -0.7341311912403903, -0.5333473185284167, -0.5399071136533637, -0.45711194134516536, -0.5768814100687445, 0.14143856158954257, -0.42273398951145813, -0.024066086309244242, 0.14593162559095127, -0.5026188540226116, -0.18749517082302447, -0.3124746693667114, -0.4204542548420978, -0.6871907465151973, -0.16371531774998516, -0.5281970582216227, 0.27069888845411516, 0.4251492770047064, -0.47468075872697313, -0.26668316640984097, -0.21199915093830726, 0.5939886285756171, -0.6312082678161747, -0.6463725628853128, -0.30080621657585316, -0.2414193580606507, -0.425090223101397, -0.7526607913890497, -0.6763555662893852, -0.4922214669355761, -0.17357213469756924, -0.8393897935088759, -0.7080992540833709, 0.4344723075109163, -0.4675136837277816, -0.5992845240871358, -0.44460516409715245, -0.05055511608682746, -0.36491568848812017, -0.05112176679577759, -0.27657665719756785, -0.7518860403256585, -0.8420869507708857, -0.11317966734963486},
    {0.4242529449935331, -0.3486886411561468, -0.5897755284798292, 0.009693904015648201, -0.7242902670564866, -0.18991525225430395, -0.6570415195429475, -0.2871612354259061, -0.6003768689425328, -0.5723161293016875, -0.06373291440265635, -0.9861306332600468, -0.40213259421977166, -0.36694469329155827, 0.45233169307289767, -0.4818172721103832, 0.39771468621303163, -0.6930968491297359, -0.46537389329307133, -0.44381090881390006, -0.5416262707691373, -0.708954687179873, -0.42692809773744095, -0.5407840473239491, -0.5947395729450933, -0.039959554504295565, 0.026430587693151486, 0.07328755601067584, 0.32424765486204815, -0.6442030095919208, -0.21931718479663762, 0.01865410740610671, -0.16613983227356854, -0.6934380038710045, -0.01057013766374884, -0.8002723792443441, 0.5460668288419576, 0.6531922144906774, -0.5023076133834792, -0.33593199733757473, -0.39724207310943954, 0.6893949502513076, -0.5559254781445014, -0.6306563979163301, -0.09505011608311054, -0.2771036851050992, -0.09344671831472219, -0.41194419845002356, -0.4444690965647995, -0.4500022871644791, -0.16650681797046496, -0.8646185113945203, -0.4620156277447403, 0.6311877695600394, -0.620058013428406, -0.4863887932017716, -0.5007756466585155, -0.32367465446389077, -0.5504593184292575, -0.2468347649333373, -0.4760594184065126, -0.8450493648549663, -0.5608718471894387, -0.014663786969029933},
    {-0.38281993785663865, 0.40420288808581634, -0.09076982717548909, -0.1531362657105161, 0.09051809555424681, 0.28561518834063204, -0.35528343171694027, -0.2890088778428896, 0.018072368369673207, -0.17495249764991666, -0.12981656208705405, -0.018336693815361696, 0.06338151338614229, -0.045808119820571716, 0.5693303378268081, -0.2664583552098048, -0.4155183570155922, 0.2276521418030571, -0.1708637444442345, 0.09345750144224603, -0.47350418324020965, 0.3015197994634124, 0.11542846031381529, 0.2694219847564021, 0.2590770621697215, -0.316017647649148, 0.25061498950203487, -0.15760607870057808, 0.2637618729390058, 0.7431051290448414, -0.04258635443199827, -0.34976038161955786, -0.045918983132866964, 0.01130319142012132, -0.15692331716058716, -0.1997043051928149, -0.04421427204350031, 0.23608432723084072, 0.17760305353351674, -0.17804986807892945, -0.03218227579108487, 0.08939721041158179, -0.3779542073162429, -0.23132826324090844, 0.27936684187585614, -0.18670957246194583, 0.29249633543584397, 0.052668199218948844, -0.3970031670355409, -0.2862277248288648, -0.06887821722862429, 0.1850875038971324, 0.36653282187003855, -0.5614893806528096, -0.033365170358539364, -0.4138353680014661, -0.38984523404151594, 0.5321394263219985, 0.12724835514980995, 0.27091377715660864, 0.4629275172030033, -0.017467437801584808, 0.19915233235715135, -0.07236237103678202},
    {-0.6336935666202603, 0.5311854776745887, -0.3312042481159147, -0.6411233883375513, 0.3556438573944928, 0.22761804673519168, -0.014304513615167715, -0.3448760869591506, 0.2843984774970216, -0.3731441312891306, -0.2279042010233801, -0.08678434204205361, 0.17227602686175586, -0.11609652165567162, 0.5267297328605568, -0.3424171053531213, -0.33955744461163323, 0.12674156022489885, -0.462375917322689, -0.3891173202185134, -0.48579578630910886, 0.4388140487459591, 0.006510162910790416, 0.5409314046259663, 0.29550727074545213, -0.19187331111037728, 0.5608144606049201, 0.4161293517879486, 0.521680396385786, 0.4003894293402473, 0.10531181993152353, -0.47345628250596866, 0.09134935961124593, 0.06112752534444628, 0.07651376426930742, -0.6111611906640333, -0.3717047575447066, 0.41046963654065144, 0.05556193040780915, -0.3771551317340404, 0.12627563949571713, 0.08697240697009294, -0.4395522350759389, -0.05314879267970936, 0.5161321774034516, -0.09102811409124946, 0.25493917575227604, 0.03272520895236774, -0.29443591935435387, -0.07537639886970926, -0.07258291638745762, 0.16686887995313207, 0.2461661138585501, -0.44888520959275435, -0.11666947746791201, -0.7064491559476578, -0.24372466061249085, 0.6905167289321259, -0.05596480536670959, 0.09026470285297658, 0.4284381757999529, -0.10066575397258005, -0.1937272060719915, -0.22257786822187522},
    {-0.6013696806416452, 0.6984705673084275, 0.14261071880295756, -0.5193177140430053, 0.6238988804343948, 0.2163630897680874, -0.30631141709221993, -0.2307132094907489, 0.4631143001341161, -0.3523379709960624, -0.3580320236008452, -0.08978593208088625, 0.6256278746252286, -0.20162414576731807, 0.6156591294441482, -0.5223900070268224, -0.43895444942250106, 0.5513986355836558, -0.2105656369408766, 0.21490056747473324, -0.7879465944029228, 0.7807017155660465, 0.40600197205964467, 0.6295356539335197, 0.49185837017607414, -0.3336795784958842, 0.5282027532969106, 0.4624016098188524, 0.5785700609787091, 0.40892726120158857, 0.09093741236944095, -0.06368931482451397, 0.32541182483693243, 0.6592590521920575, 0.20429765097999136, -0.3408214853229883, -0.525614475967268, 0.45697459887426817, 0.3649978452199171, -0.5226862676514346, 0.045547573338840734, -0.3198465844783455, -0.25873886201180074, -0.13912622984520245, 0.7166405463899473, 0.36533535637768755, 0.5366817829652646, -0.18223420161924161, 0.018061869257676607, 0.3003490723883489, 0.05939708542639467, 0.3051910398264794, 0.3395320959828533, -0.49069735567739275, 0.16269823465643526, -0.7444166325951576, -0.6647486820283669, 0.6228224643777104, 0.0944043322272637, 0.139446373546145, 0.7413652087425628, -0.5681289520409407, -0.006404696871197139, -0.35330732729762576},
    {-0.38703466302685713, 0.6446372630731105, -0.05208365238347436, -0.4546184800807319, 0.6205149550337259, 0.30683975388900264, -0.14749565054820216, -0.058488798820960676, 0.23132874723501848, -0.4312941462817627, -0.3372215026406576, 0.26681514267247725, 0.38085918673900143, 0.11658524708975937, 0.8232848199638878, -0.38546915597905546, -0.2134230254556032, 0.28782273103283984, 0.22156956873348202, 0.46310313301631073, -0.9207068476255945, 0.47120447888547884, 0.16935689280073116, 0.8595565859252023, 0.6618249542719269, -0.27330261508380715, 0.4313578346757169, 0.019665209825185423, 0.6478644769300084, 0.3004342089038561, -0.05571089255393949, 0.012252806863574935, 0.21403237089332544, 0.29842470312905006, 0.2869789814208208, -0.3229747348395943, -0.39727430827575905, 0.4142392393907914, 0.35720598845659457, -0.38121459185142526, -0.11553152132196286, 0.053488630681172614, -0.4093337536633736, -0.23422087132418645, 0.5139316998784142, 0.156689624977918, 0.3171918731393951, -0.25255565925314627, -0.025283790961677793, 0.10427808434465342, -0.09248022008678879, 0.06797823309034555, 0.2769216378373836, -0.5837831813308083, 0.05924080321156484, -0.3840954790913445, -0.6385331673630454, 0.5419949758251985, 0.01658055608928254, -0.049042345807858455, 0.6081054752298646, -0.3177413429348099, -0.08766314827280149, -0.5621996952371784},
    {-0.37347255543741203, 0.5139312503229988, -0.21282177678403666, -0.48963687125628624, 0.5217263112406096, 0.30262473731611683, -0.33669124020794905, -0.0399050178431481, 0.18479810958757648, -0.6157027666922981, -0.7062289258325419, 0.2737265928515261, 0.5103712063049533, -0.09891253693491765, 0.3430482100931317, -0.4194360009264873, -0.1719656254928372, 0.2642520631199674, -0.0666939727441303, 0.3039916509336046, -0.1544695753610874, 0.31105938599892313, 0.025518681133502613, 0.5194803438294051, 0.5088692812673987, -0.2955598482439613, 0.49509424003706953, 0.3684786072929536, 0.6397636240790585, 0.5693046808737714, -0.30631795728892813, -0.12239977509193596, 0.4943430330822408, 0.1353404795475167, -0.004168996953527223, -0.556693766177827, -0.4395121550434426, 0.07355446236700808, 0.44948748431981905, -0.4035199796737487, -0.07490686005935854, -0.063195519613976, -0.3201668153932281, 0.17246788130565258, 0.14584418547885497, -0.18292040628509185, 0.20658099901011123, -0.560757586770581, -0.08735936959449381, -0.042825561549625815, 0.1867279176288527, 0.2857095249621588, 0.0032356219277359676, -0.4021556124317658, -0.06304043139088043, -0.6348244483312588, -0.7626851659881478, 0.12828915151814704, -0.12280761312308118, 0.0483358645115974, 0.512934717539464, -0.4232109739228269, 0.01868255845175831, -0.4715618763590872},
    {-0.651180470459764, 0.44874670560439567, -0.1946781653482036, -0.2913030167754843, 0.139391242526675, 0.477571085702868, -0.3181615018803727, -0.1784015345953013, 0.2437318608380315, -0.7590357867142036, -0.5741291293229507, 0.027424304499233117, 0.5919367154050729, -0.06372651475900164, 0.5271948587048763, -0.5018995199770875, -0.133337272020056, 0.12193354656901785, 0.33189506385460577, -0.05024148797950914, -0.5649923358760938, 0.4138159444164113, 0.12720149889936344, 0.30084866834926366, 0.7133303009500109, -0.20998751355114953, 0.8588320954260974, 0.502455244909504, 0.21110756428542302, 0.8176848594506498, -0.17590995226099768, 0.16819995708629942, 0.5372378385015131, 0.1814566755778884, 0.30662067209406496, -0.3169440740167221, -0.41440502953094793, 0.29816921181104983, 0.6392074307469313, -0.596649785229426, 0.18024124114828474, -0.20777552334520477, -0.46249161685457596, -0.13133002376620745, 0.276666744126121, 0.0700383898384611, 0.45041483315656716, -0.3888632382516619, 0.03839662875698993, 0.20413944235872628, 0.06539722481893667, 0.5677631614422387, 0.20350922804994726, -0.7965866682170285, 0.26173028322086056, -0.43678349351232604, -0.863935913622338, 0.6793681500526247, -0.15438234433746023, 0.1782026845585665, 0.7926063754643655, -0.23432386169755892, -0.030872031210182546, -0.4508547315921466},
    {-0.7289341144369796, 0.36045289370280253, 0.17329105039452633, -0.2903025711530052, 0.5013717841499306, 0.2353211836200193, -0.08071085344999412, -0.4478988312966686, 0.08195617510494752, -0.5903649708061003, -0.4777482979277654, 0.24605347160489396, 0.750447632892989, 0.25852657820457253, 0.3579851838457744, -0.5129198505002681, 0.027611026956194558, 0.4141060543976088, 0.1380726495151501, 0.45763368562246104, -0.41948411850837, 0.7049192079828501, 0.7403534221583626, 0.36185594757009953, 0.7180804884094095, -0.05444811603302433, 0.7483211365729991, 0.278487860846231, 0.4702940521351388, 0.39211665667790957, -0.03616943625126425, 0.0698924446441228, 0.3224688778643078, 0.3838236894205418, 0.09464215713487566, -0.4403874066597622, -0.5700637598695057, 0.03986336536778848, 0.16682858264601544, -0.6579774148740583, 0.22596943023530544, 0.13579053131599073, -0.45361881442685253, -0.10669968204245808, 0.7092749659970601, 0.3632805660024717, 0.44107337288510257, -0.45454183800366554, 0.11019041453906896, 0.1184361139713055, -0.12225184281127764, 0.713792420483299, 0.07218266909977956, -0.32573677935982126, 0.3461030983512406, -0.30424369946146146, -0.3007052378420978, 0.2203609688581063, -0.03579215837852088, 0.20766236361678875, 0.564720674507558, -0.28289124506021757, 0.11353426024480026, -0.458205887618611},
    {-0.720280945180245, 0.5410038942240551, 0.07026999986583038, -0.6173323335972828, 0.42881607976428743, 0.3816974966443285, -0.21263878766495609, -0.41723269208322983, 0.1284605569548784, -0.5503544259118913, -0.6524499180613982, 0.24311114632584724, 0.5330851532354248, 0.2220296319596678, 0.661756303111358, -0.14181853507070002, 0.16220045145660222, 0.2717056314570375, 0.040504144295093227, 0.3570746382965135, -0.06939436760362092, 0.6715944847907526, 0.39357427274961, 0.6042187944808681, 0.553720328783426, -0.4017724137761581, 0.6408166015727371, -0.018680445922084368, 0.4679101861064006, 0.3691646187757022, -0.1728832017382665, -0.004140993811384078, 0.4539661964202461, 0.49181791278655523, 0.33757067251169137, -0.15190751459630714, -0.27289603376207017, -0.06477336938260182, 0.5118789501126544, -0.4145915511101845, 0.10757276436945057, 0.2817959661478235, -0.3023357107119743, -0.17720507236917987, 0.6349839889063337, 0.6080104632032923, 0.3377867622568417, -0.49066773158020316, 0.059621740914565305, 0.3701376252219388, -0.029587539181331564, 0.6049042551141576, 0.49386151112881443, -0.5170906349339613, 0.4140708776874471, -0.3372394580781265, -0.31486279624044894, 0.694163984753589, -0.13805320597483275, 0.3060893391847734, 0.5725144561014661, -0.037335104411246704, 0.2782615490236449, -0.6200341017335067},
    {-0.5695160458587163, 0.2695501269760729, 0.1347354966319679, -0.7056869309406449, 0.3857900552808208, 0.5228775323747158, -0.21966448208366893, -0.4957710694642107, 0.31056657250124503, -0.5443490672074403, -0.5520270949028956, 0.3455743904607506, 0.7419626556492908, -0.02031758495981757, 0.5119519235171713, -0.3206962546110839, -0.159492212636557, 0.32184930663411815, -0.2095186752797206, 0.2729999257210416, -0.8255170874794334, 0.18808948502974568, 0.3084109287738168, 0.5188650583845326, 0.4869788573865516, -0.32115140811715115, 0.5717854926348329, 0.2934317612061612, 0.39782646714678727, 0.6810496099371613, 0.04653007608887356, -0.10372164034951378, 0.38064154792194543, 0.2262249965443026, 0.45447221624480466, -0.42919626359496615, -0.24903925516486677, 0.31443474717225606, 0.32585013821637665, -0.5010498105571193, 0.17685710407801758, -0.1503615410027117, -0.5411801458052751, -0.3851952757276943, 0.5243891870360855, 0.17875973833517997, 0.14368839152106017, -0.5977454938794925, -0.18474051877257877, 0.1925223754736388, 0.04810135431370841, 0.4607702673093985, 0.013196408644133977, -0.3114647413638639, 0.5016363268590933, -0.5245195078004398, -0.8199161091240819, 0.5250845949097103, 0.011018678894263648, 0.10102359554931017, 0.44501099757027934, -0.25021854297235324, 0.4514188576152618, -0.3904297229947795},
    {-0.4946653461884652, 0.28656348618377103, -0.1979463023272947, -0.6525124407063041, 0.5798216613030649, 0.3139325295934079, -0.2565598097351818, -0.21741700898612648, 0.535421888606723, -0.22785955160255542, -0.15446355430049488, 0.3204270020845938, 0.4370916006636445, -0.05057129029636572, 0.41863891252201524, -0.16552867385397016, -0.4465663121652809, 0.5532645216881794, -0.14647198001715347, 0.2549804018438741, -0.8693623746509892, 0.40468323570583953, 0.2823607442956121, 0.8995849114452255, 0.5145191498063773, -0.5595217105650663, 0.6446812030421741, 0.04836807189927576, 0.37052666893309705, 0.30278602146841666, -0.26537633218036677, -0.07492918053193073, 0.6660483887757979, 0.13070059933073727, 0.5219899183309945, -0.4308856013317339, -0.044402406659103416, 0.18038448296576332, 0.49942584236146426, -0.17689695546287626, 0.32153604834676847, 0.3515268210131874, -0.24147766799987666, -0.20951685441744752, 0.4669641408904986, 0.30687549738933123, 0.23455618980729873, -0.2899388999037033, -0.2572947577659756, 0.3403829574341314, 0.09511278206982551, 0.4571719210648335, 0.16793063595772742, -0.318815223136231, 0.3891996870207944, -0.4418846129509618, -0.4354147313950938, 0.6718859590396671, 0.15076210226066825, 0.1633692933317153, 0.6295879108832773, -0.16734403088486344, 0.5192611186835259, -0.2293152960510259},
    {-0.6760626982595633, 0.5498284735203183, -0.20703211676542202, -0.44624336959865313, 0.24479467363360208, 0.5081775550144892, -0.17633627534899154, -0.011073570067948683, 0.32909508490459094, -0.38253986646778765, -0.32079196933089676, 0.07119180542915735, 0.6456481908070256, 0.31791620836497475, 0.19793416878975095, -0.2491341943851482, -0.34376340697896457, 0.37965988375777515, 0.10876838118619404, 0.36171809956419654, -0.5428834389386848, 0.4541805514105146, 0.09273816740759323, 0.4312878293979295, 0.5063083149841113, -0.07906890281564755, 0.2500092374576828, -0.009564987090598508, 0.34887045435411673, 0.19189130061292847, -0.1760930331113645, -0.2863266548417938, 0.341660765227494, 0.45736413570273154, 0.42538918210664867, -0.5242092744306691, -0.2302398368184338, 0.5133840569481181, 0.2682055752349752, -0.34990073953941253, 0.45128779836810234, 0.059734136136114, -0.33287289629597455, 0.03490048819893585, 0.42074099116079655, 0.16735146377152044, 0.3723704471651954, -0.1741276501383289, -0.3386070875134311, 0.14726975058086197, 0.09815973879794192, 0.28832157463584357, 0.3473807198443985, -0.3316506023192866, 0.28856681873359014, -0.563248118597463, -0.4802184365791689, 0.5995568972093998, 0.22251614093898986, -0.014160369585641696, 0.8607796947747829, -0.06981855307238656, 0.2936656417998591, -0.6199090141481695},
    {-0.49136115212999293, 0.525073252057921, -0.08934392385072064, -0.40665959300592547, 0.3614080281016885, 0.2968218434100048, -0.029951674316802075, -0.11891582895748175, 0.23519942931535107, -0.4110291134617161, -0.5059057539759485, 0.4912482526291654, 0.5906169306991549, 0.1174556852458522, 0.6875126902588684, -0.39592359627260243, 0.07427600822816258, 0.6378342346470001, 0.05674954760116293, 0.208713196028125, -0.6018863664142295, 0.39808317896682704, 0.3180329205817627, 0.29961939345295313, 0.8302638316018188, -0.3120929449803056, 0.7019230015173568, 0.05736714628465458, 0.3308480448630063, 0.6185860957605401, -0.020512663736603206, -0.2048177049602976, 0.31850757934057505, 0.2912518043199197, 0.3387332287893316, -0.659594129090982, 0.09035948223368756, 0.3859336018272099, 0.31717738208088325, -0.5084961830621244, 0.4735219764086144, -0.07241728342734179, -0.34688692781038133, -0.07088930104644235, 0.46863639632685633, 0.08391482957987938, 0.40622291456365467, -0.2867496695925361, -0.42738837574420785, 0.4092053334482244, 0.21957447213663908, 0.26966028995797453, 0.4123802944375853, -0.38876126696231833, 0.5026535601774492, -0.7164365285787023, -0.9288975675579719, 0.7591280769400418, -0.035807280822756866, -0.039809373231065114, 0.7214620267215585, -0.2137170233156816, 0.15623153056942418, -0.527648534553225},
    {-0.797457020689952, 0.5181366698255633, -0.1432470274062652, -0.4294358685303572, 0.5283772805081298, 0.6376001674088946, 0.04007434941355541, -0.108744898156231, 0.5900813627900857, -0.3539801793036453, -0.28150351372456783, -0.20721914149671075, 0.5653313981050916, -0.024748184666320984, 0.6268131697256215, -0.31382546523985344, -0.43056187052024436, 0.3786985488107553, 0.13534855428996603, 0.5003106689245266, -0.6438347347764773, 0.6667960204097813, 0.3794783705151742, 0.6466254177483837, 0.7122479862259277, -0.242379785710818, 0.6370533132057844, 0.403364555115984, 0.5264844148849838, 0.5780819206599549, -0.19990122499676102, -0.4244235191090084, 0.36828087742466065, 0.26112991576752465, 0.3274874141402973, -0.3738846273346553, -0.3903873086126304, -0.06721628003744964, 0.3184675937042466, -0.6062542188007773, 0.5751076797484496, 0.01016350109560169, -0.574226905420737, 0.24685797771916412, 0.7083455560228753, 0.3157592043968699, 0.5666601801608956, -0.5834663873493298, -0.18376627087976052, 0.4901945162198267, -0.2028447077149061, 0.4459477122945434, 0.5148700410345742, -0.4513121651307387, 0.19181770427988706, -0.5790876255347023, -0.7653404869375153, 0.3358168308912317, -0.16089508189943677, 0.0286877822254106, 0.4981885199737073, -0.011426621381744056, 0.12973179696276463, -0.37301440626473253},
    {-0.7449710984963709, 0.4844831708009515, -0.13177137297072397, -0.18340661432137503, 0.307924985922024, 0.2554077903931658, -0.27929434864976166, -0.197435216138792, 0.43644504922589816, -0.5025465806991548, -0.22488513341798347, 0.12888513295785636, 0.333175147556166, -0.24530116584514908, 0.4606362429571962, -0.43009244140601094, -0.15525208182320097, 0.15203712831576266, -0.3074464122424361, 0.39674734908766907, -0.4149239671054501, 0.4514822397095012, 0.3758844331286538, 0.17144549629128664, 0.5537488131992906, -0.24390539944461537, 0.6562459162856062, 0.211227321257365, 0.19397322828217733, 0.4264376968857662, -0.2621680160628205, -0.4568189405846582, 0.007905143833384028, 0.1334192616935315, 0.26549751354791956, -0.48797079287783074, -0.3415755191193998, 0.20714587110801247, 0.5203487460180358, -0.6575376035683074, 0.3822184513857953, 0.031656094996953626, -0.2115905287279748, -0.16302812716331846, 0.5199867325088031, 0.3901115451412879, 0.44626796228094706, -0.39035875420292226, 0.1771733915235662, 0.44468179747292624, -0.001677306002044652, 0.34656926374664376, 0.256083906098628, -0.44929357876864295, 0.3925171230137602, -0.5760634199831974, -0.7172941585804427, 0.37184953464606696, -0.06403169943609117, 0.12356885339428848, 0.18325393501095127, -0.616273098813856, 0.12066848604490465, -0.5529033910465196},
    {-0.8509309734956845, 0.3494109313099543, -0.012188511302010614, -0.8650144883992814, 0.31988654998436183, 0.4446214873450343, -0.3786243038259999, -0.38104521156720017, 0.6025547343785759, -0.5230200753989485, -0.4463992096222282, -0.1224181523594883, 0.6946519522504891, -0.0007173085496466266, -0.0019597327913488125, -0.4145192769647497, -0.43779170272587903, 0.4899867980580086, -0.19634712138736998, 0.30421935358852165, -0.5351731282750632, 0.4532955470584037, 0.23034041983411174, 0.679482862318498, 0.6351631078411016, -0.25328345027610377, 0.6119735062071641, 0.14269573265786978, 0.5007134143907152, 0.46991279795354507, -0.3503048832473296, -0.022742049085465826, 0.059009410211389925, 0.3096611673787846, 0.08815988769586444, -0.38508640738174, -0.7002351009988033, 0.33521055723189963, 0.666081894869579, -0.3500397271067775, 0.5813622861831056, -0.10475374181188278, -0.41900796571106474, -0.27973239143191175, 0.342353041553441, 0.41659014455568955, 0.6952787638897068, -0.06485545606433729, -0.2633155864803834, 0.34315436587626647, -0.17850397505561644, 0.16756836638069655, 0.3877880936877539, -0.17341776917778007, 0.49448130617337643, -0.2355612611498043, -0.5595383141479204, 0.1302518334735165, -0.3223501042517446, 0.0955742947849924, 0.5311141990330823, -0.4709029098206666, 0.2399810297256001, -0.7063534960042608},
    {-0.507199408540398, 0.14785627616338867, 0.06369272078394578, -0.5640275435400849, 0.707136670229, 0.23651586190131516, -0.3886045201547758, -0.5430276904141524, 0.3888917709454363, -0.6560500940725895, -0.5293892584634675, 0.20364168619279677, 0.657117514252307, -0.585400883493397, 0.10021184166621172, -0.6603770205601657, -0.11181071751795639, 0.6940111747908256, -0.3350382876812575, 0.5238549193423736, -0.5672938474854351, 0.3436935225477519, -0.03440239408761571, 0.8485090309612424, 0.41919277899751917, -0.341443869533404, 0.5496114567760638, -0.05781494087100618, 0.7622842978995634, 0.24657748625264195, -0.4149395473579974, 0.1484859774756044, 0.2674991069384293, 0.25082536347499157, 0.5829380184196628, -0.42376411095964467, -0.38290316310054706, 0.3621040799469268, 0.4739694320620347, -0.6057877647085772, 0.10885454746470817, -0.3106108242025672, -0.21738621521406806, -0.32716476853216414, 0.6906615502125811, 0.24366470356585188, 0.21506627127879352, -0.2668180994797174, -0.08388813431227518, 0.46393506249195615, 0.11744065360778995, 0.2040108296716114, 0.6145888438454812, -0.47409032231636733, 0.3806887765299582, -0.5805329642765384, -0.8794901301557231, 0.6811248346179674, -0.21352033359411113, -0.1540002906010327, 0.6075623108807263, -0.6343841800369264, 0.10091504885835577, -0.5041677413808315},
    {-0.3130731602786906, 0.5331398159322407, 0.19245019196219174, -0.5840920275917177, 0.3045652240253014, 0.4113464480789012, -0.30570644777944206, -0.146178444345533, 0.37981956747841117, -0.19681304744503628, -0.6373225395419785, 0.015622237964843822, 0.3391459965200117, -0.4886054348867752, 0.43201368570214843, -0.4303107568468708, -0.22273404724952478, 0.43040400497115217, -0.2191447881883006, 0.20939332794379253, -0.5536638404868393, 0.3730504580602133, 0.3539306935715204, 0.555844271793522, 0.6557802132295396, -0.44352960821360693, 0.23408986843343188, -0.00945981591100491, 0.5236714959846155, 0.5596247999982541, -0.022433159889644748, 0.1870354563039998, 0.4949781321505172, 0.3330391925743398, 0.28988266056571615, -0.5084676448098222, -0.3394863100785242, 0.6632541054256501, 0.552248293441032, -0.595775645298832, 0.40755722616256757, -0.26171040538810686, -0.508629191516883, -0.19010732789390417, 0.3973940904613486, 0.16256900694634938, 0.4964498311266253, -0.4743775283763336, 0.10371353960544148, 0.23549124215223421, 0.18738833734780233, 0.42548771559818543, 0.05491927249800632, -0.33067253041470696, 0.17557898512360304, -0.4826468426360404, -0.5795660047231198, 0.5941178475240264, -0.0003219663197145018, 0.04918846193551997, 0.6127812563224095, -0.2810666956001629, -0.043375400417628496, -0.6442366977181879},
    {-0.9707204180605518, 0.19506008422199356, -0.23165202237513685, -0.6164604988430331, 0.37314697740722924, 0.4231330140512875, -0.38627028433011723, -0.17832974227909898, 0.35523267590435315, -0.5686642467097628, -0.3871388015222153, 0.006708022709027903, 0.6251588267306427, -0.15413188329048796, 0.41092865771538994, -0.5817621869750346, -0.24887625526196988, 0.1883943378991879, -0.277088847288271, 0.11220685321090715, -0.4675516282985107, 0.44784187555124844, 0.17483048832415524, 0.3333071582342706, 0.42015617180732084, -0.7169057741120864, 0.4322844808639896, 0.13233431656884365, 0.6358403892820886, 0.6560857737510547, -0.35475609199643854, -0.30337834359505184, 0.34433442224267746, 0.47096657094602684, 0.4534070094278265, -0.288332440632419, -0.38719980985195435, 0.47991837216608835, 0.5010004876332276, -0.6554371789271496, 0.40554491737696746, -0.04268401270784137, -0.5336641017454676, 0.06722057964127724, 0.21253073858100607, 0.36960513846353216, 0.09803947362388064, -0.4970660236338951, 0.044845111489703465, 0.21989102228988713, 0.26825987242364085, 0.26825139198722997, 0.3608199669013508, -0.48880144405171994, 0.44303961935016817, -0.4468841076738078, -0.5766498616807135, 0.8349603989562693, -0.0644410783328073, 0.0708293345392792, 0.5114110931383684, -0.3216294826158801, 0.33080599761115903, -0.6428796515884941},
    {-0.6525003935171282, 0.6014434108135022, -0.31225875016880666, -0.6673624063405446, 0.5731968841779194, 0.7363712914970747, -0.46829803464255504, -0.31363241355420685, 0.6125232647755028, -0.5174290857087579, -0.3100741193863642, 0.17826398258161213, 0.5864314961934157, 0.18316022567277276, 0.2647256864012769, -0.8336989231884221, -0.2568484990208584, 0.5250696866883522, -0.22850584679058178, 0.48505920475265435, -0.6695971931253568, 0.5193614166726674, 0.09222994160047976, 0.46548709805649097, 0.4520955904808865, -0.3008173157721545, 0.579155539544588, 0.5880144221502809, 0.13112842692281848, 0.45976481153536447, -0.35620790924793894, -0.2974811194939945, 0.6205414150311088, 0.2641394008911067, 0.38857522228152386, -0.6241385164801966, -0.34919244561413765, 0.22455618021094287, 0.6339174202382427, -0.6184306073833536, 0.34728730082264, -0.18882689704608305, -0.5383011862045477, -0.41791894089733533, 0.5237708871289564, 0.4206756361196036, 0.15343973452305495, -0.3177748570856468, 0.1852985258855252, 0.14732005757048341, -0.1504482904186009, 0.34280550874961374, 0.27461811797325836, -0.27150814901112025, 0.34015751718621534, -0.8139491773388902, -0.7086794515096853, 0.7589621930424054, 0.04969969223787482, 0.2615586549668483, 0.67185095902791, -0.5304701686830873, 0.03898126737634755, -0.7296602703395292},
    {-0.7104889434351096, 0.6408959187994338, 0.1539166239672942, -0.7353397100562028, 0.18427944157918072, 0.5181452788902088, -0.12015677882874007, -0.3469038570703409, 0.5947095171622752, -0.7355582677691739, -0.28626598917412, 0.13582619350049638, 0.5982310077834876, 0.22533975956073912, 0.2416856307384728, -0.46852216896854626, -0.3504038357314257, 0.4808795886150904, 0.2543343222375589, 0.6868218257689586, -0.6717633542893624, 0.6117615812515527, 0.41561644041871565, 0.5167775847773026, 0.7660137108675475, -0.4947017992595087, 0.6277661048406252, 0.5212529308978241, 0.2526210260627345, 0.6109660257677446, -0.07204933032876239, -0.4569845349381633, 0.6090446768903971, 0.41646559442490727, 0.47033966889772805, -0.30269869588010634, -0.1475641045264492, 0.4791512516307756, 0.47802155388872264, -0.5714215469306521, 0.3943908348749215, 0.2259544647175792, -0.4762215973058704, -0.22334100350497108, 0.8881911609247455, 0.21935406046616976, 0.47954785000522293, -0.2647549440707559, -0.17939609895151273, 0.6657977024149213, -0.12588768634775985, 0.20121491766008112, 0.35486301895774885, -0.46712008916005515, 0.3181108104709465, -0.4976102693325423, -0.47161850570984365, 0.7733141622429268, -0.14007769332296544, -0.11210040512508214, 0.9282041052521346, -0.498167478156664, 0.14322808777672508, -0.746063829590562},
    {-0.8916179921638132, 0.3289512921712858, -0.07998078597393339, -0.6562066543805866, 0.31792546393454846, 0.5774942050898901, -0.0800642247786657, -0.24527673576078213, 0.44119881570757596, -0.5360524288565022, -0.375312672284499, 0.547755987893048, 0.6384334855963459, -0.08020115712991721, 0.6116144584107895, -0.5235795345590074, -0.31984778011574183, 0.6287702936576461, -0.28719220525450484, 0.5229922328689496, -0.6146903106522734, 0.6152491018494953, 0.0377836231246301, 0.4236385207252096, 0.8405399182504207, -0.7169684144154719, 0.4956633433827412, 0.33487690985107643, -0.08213808884544839, 0.44248916028764934, -0.19964553634394247, -0.2151765750877185, 0.3627936585077404, 0.24338239736788128, 0.4102378694392083, -0.4309540125316606, -0.43799321394404933, 0.07933997497626265, 0.6404074095394515, -0.7025440987435951, 0.4376846723960873, -0.049420836337842534, -0.3994539775511885, -0.05950573699955864, 0.7542492565139255, 0.42102126219818486, 0.4656682196087399, -0.7197093920019576, -0.12660176418650412, 0.4723361462163922, 0.00758580910019189, 0.4490353577145489, 0.1824365872801039, -0.35667839409706614, 0.37370400602538795, -0.8248880861127488, -0.6528314953766048, 0.5016555931885248, 0.17236521723400486, -0.06747822866259197, 0.563774273234573, -0.6800000596181395, 0.1872962549501134, -0.7892317179210998},
    {-0.7339975113084979, 0.5545135506476403, -0.20105038884319013, -0.2229115390933384, 0.7182037694910524, 0.43201409418273023, -0.4439994757697278, -0.4596996557728279, 0.6671989940493515, -0.537200235186827, 0.005818779987387576, 0.11493162944861555, 0.5510075468281959, -0.13506964383094272, 0.4608729615806768, -0.43137504102872215, -0.27673894738878313, 0.6804211772090983, 0.00348118094832423, 0.6645056341443928, -0.6053441789144476, 0.9331325927689315, 0.43109647348797486, 0.515371011640182, 0.6597310036042804, -0.49421229632585023, 0.7515574523509231, 0.4148707983189153, 0.4371258200627477, 0.3699820264769786, -0.30338308969737315, -0.15407339800004569, 0.5188863801476545, 0.6235383797539387, 0.47378360020591365, -0.44248427194448964, -0.5631399999706967, 0.31054704086081514, 0.4086876727261222, -0.552165972005346, 0.8633379978095386, -0.06915858935955109, -0.5266923741751567, -0.007793031747817565, 0.6654016917783345, 0.48398417303010444, 0.38246106152416626, -0.4831635526922957, 0.05542430386181096, 0.33646433606714987, 0.3808589809094469, 0.48436865096108794, 0.1961289801778257, -0.14840101338488587, 0.6084596009567733, -0.6932763367270557, -0.7739302881607647, 0.5795616178178006, 0.32594806796902226, 0.02726168393711924, 0.9695687132683691, -0.7010802529335927, 0.4927903495517233, -0.497264908962616},
    {-0.6353137464732095, 0.29666559956077654, -0.14491431534602303, -0.37177020061455257, 0.6003591437829663, 0.4173440173595228, -0.15826601534464757, -0.4396851615100721, 0.6255589583096842, -0.5987675508017336, -0.1526406396952555, -0.144586130014725, 0.9100096665389242, -0.06813716359690013, 0.39104657106290974, -0.3570474374448111, -0.5614964434548367, 1.0581401521004712, 0.1041540870785704, 0.5530579259643453, -0.690225783629288, 0.5337434227878824, 0.3570397958153581, 0.3484523373387184, 0.7265399278958836, -0.4907395781834836, 0.5878452772191409, 0.5698610135536292, 0.5084629697468801, 0.5905567402348979, -0.17138976368014927, -0.42128074181157754, 0.5838677380224105, 0.4626889209960708, 0.36545292167198185, -0.5147716519308159, -0.6954900808253079, 0.17631508920828565, 0.47130687340328975, -0.531865346800088, 0.42321540297081545, 0.021084789206488968, -0.552175267081502, -0.23541898243865922, 0.739843949956456, 0.5459478023411095, 0.5498421713233416, -0.5680920030753775, -0.08672302643366567, 0.4145125914829693, 0.26050307670068834, 0.5650894847541884, 0.4009521027973025, -0.5942494993529822, 0.5514867157284893, -0.5365410150259887, -0.5268075525019319, 0.5993737809941904, 0.0342796236496915, 0.2396029896747879, 0.5897958029914739, -0.44514108827292614, 0.4762019828394345, -0.6520272963555455},
    {-0.6506121178238194, 0.5585662058869874, -0.09410623035603366, -0.5914282033268587, 0.23456557225543734, 0.2934927399990177, -0.1856237273104829, -0.45867200434979366, 0.5370215020061817, -0.31332582906345763, -0.14531485050859963, 0.15656802394955185, 0.2851154459524811, 0.09000051641819949, 0.386946867604684, -0.7810330502170898, -0.5446642167689171, 0.6707215613447812, 0.002726201935377622, 0.3619319681631842, -0.7293774324717779, 0.4611972076879425, 0.5780073541426859, 0.6635498663673126, 0.47874303087918024, -0.4773163108175812, 0.5854210622141238, 0.5012695175538799, 0.2124388986414898, 0.43139415655978125, -0.13260897846362762, -0.12188072941772345, 0.193643253182161, 0.2940376875358917, 0.36576222013762233, -0.4144058777198484, -0.5332751047105264, 0.2599090148741979, 0.6220577023406875, -0.8386087221625255, 0.38301557765431465, -0.2811372861679185, -0.6026336187834964, -0.2852008226272896, 0.6926089532110399, 0.6950671372311444, 0.3990053961725705, -0.5758707016290615, -0.009414429515716177, 0.18558806691219887, -0.04070262483231849, 0.6527443876068455, 0.3776329347690665, -0.20375807251857503, 0.4159416306284636, -0.5852844616865747, -0.6415384969614633, 0.7157165363919455, 0.045598051769158, 0.1255672143709243, 0.6711728693414243, -0.4710302624765826, 0.6034694449366454, -0.6122598331497344},
    {-0.6734948784237279, 0.5119114116280673, 0.10914840562783171, -0.5702697102812999, 0.5236401140926407, 0.3070108723277386, -0.36667180718862347, -0.16884209400904937, 0.5890511396636811, -0.7627191094603208, -0.1542762371756961, 0.21530980724025972, 0.6219183821080618, -0.37153512862555726, 0.6432628448291035, -0.5584713248740028, -0.34389056623929726, 0.47947061753232617, -0.14713276741652415, 0.5796666683666029, -0.7463702611407296, 0.6186701798478911, 0.5386357188719096, 0.5588528755725559, 0.541460542939098, -0.48641990293437587, 0.688631788474468, 0.04233625139728715, 0.5676081533224715, 0.3685100413409823, -0.1593791672768775, -0.269867202193774, 0.2095999675768677, 0.5226609647140269, 0.5099749421559069, -0.48261895857993997, -0.21776380239193677, 0.48922429337229223, 0.5900014719210752, -0.5157749097442, 0.5146071371041981, -0.3509421934053499, -0.693940052651763, -0.22888188990415118, 0.497453225604274, 0.5747145583578454, 0.5952062821071499, -0.4932214247189413, -0.06657946987538398, 0.49984564904347856, 0.067486936430624, 0.38696912933429645, 0.3631655013987675, -0.352445318560726, 0.4590295828795224, -0.36427731103114863, -0.774363693783409, 0.7696662625069298, 0.19147660800197466, -0.10634815742877472, 0.7399432428756862, -0.4559379728850757, -0.06697049884416871, -0.5272359757911871},
    {-0.8279050898234213, 0.48242850828512923, -0.0027014962701720664, -0.7018812389343643, 0.759477664812089, 0.7865153409962284, -0.1847793131878939, -0.25416835523995723, 0.8825371345029969, -0.8584191654413171, -0.6741029163439355, 0.09370422417023842, 0.7279189302216491, -0.0911858526845407, 0.33706346719753333, -0.29443365054097836, -0.38251069177946956, 0.7053395350660072, -0.2586639772833152, 0.4593297348182489, -0.7867669695405103, 0.6372618900793817, 0.3055882225013144, 0.5520919971686326, 0.9647793819449508, -0.42625016038846936, 0.5951181168504907, 0.3287974012207621, 0.43592087153821624, 0.5922846216516002, -0.3572771915307267, 0.1318539037995651, 0.6659606259636819, 0.754126316128817, 0.35826757621527183, -0.7248803304441668, -0.12498207464821572, 0.5095570693863443, 0.8625161408261092, -0.7626558030941903, 0.47122838146089446, -0.16569373370660653, -0.6104814924603004, -0.08307439264251398, 0.44337488122564617, 0.3952436477182409, 0.3994412349213383, -0.5973853176802697, -0.08623457638610679, 0.3836671354565588, 0.34019455408614946, 0.48094316064252607, 0.3515890057682915, -0.6021994686503128, 0.5672276651323482, -0.8366331901044104, -0.778289945996097, 0.6090552974723773, 0.10630463213559288, -0.061944575990886624, 0.7390696852604951, -0.6393599614091722, 0.06112697606619327, -0.5879474561948679},
    {-0.6967204461976078, 0.9295904566478447, -0.03865370309170215, -0.5768809058209952, 0.7122009688379882, 0.4972816243763067, -0.37024109756912205, -0.39763771505966483, 0.6060033597060066, -0.10812672993722769, -0.31390682101708745, 0.25143361469604913, 0.6108168884942231, -0.3487197011446037, 0.5673393386792122, -0.6873324578055368, -0.3524192880015233, 0.956741083380184, -0.13487152775483874, 0.6908477935150036, -0.4706188280238597, 0.7844524444798552, 0.38762121047693177, 0.6832740881991386, 0.929546644322771, -0.41753200697807774, 0.5294271089915595, 0.4976593690638494, 0.3193015372879002, 0.46045966374655195, -0.0976445635931904, 0.06608178646426581, 0.577315823688031, 0.661186954049003, 0.6409736065276633, -0.46090162861071277, -0.5766539736968724, 0.06306059161737393, 0.6004206637425626, -0.7317548877621115, 0.4697606567302537, -0.031117891006103505, -0.8555615753015291, 0.06662154082251873, 0.5891172394128402, 0.703153164371647, 0.32207021056853835, -0.5564209335618976, 0.17967370738924773, 0.7652576454730086, 0.23953570515984937, 0.5798533707445793, 0.2849651478693476, -0.531747287484969, 0.4963474495575839, -0.9030497146875333, -0.6189038663467784, 0.849522550577422, 0.014444152975028659, -0.057451732107455106, 0.7767053981312646, -0.38592137718481023, 0.012817275359120127, -0.7371143674795773},
    {-0.4814955611996035, 0.8286945848190214, 0.17047731949983422, -0.7373826976830424, 0.2283813600458294, 0.470371859698298, -0.6354555387929185, -0.6628478809274334, 0.20321420316481964, -0.33402042960506884, -0.10931155128696389, 0.2601198588109953, 0.6487240519845705, -0.5458855831644118, 0.8249834811311749, -0.47958756647825407, -0.5829439502679781, 0.8095611905860234, 0.19823893454604802, 0.6709139361837269, -0.8948913157385769, 0.5625300429448661, 0.26018998077266137, 0.5428298789054286, 0.5184765718084329, -0.49470504078210814, 0.5682000185299327, 0.3642898182872056, 0.5405509823931488, 0.36167638446671857, -0.389718249095924, -0.35066456847522953, 0.348255289704986, 0.2294648541233429, 0.578047862349302, -0.2666533708526568, -0.22717638186016484, 0.15230323321219913, 0.6690306005334871, -0.7083112738236548, 0.7471175070514221, 0.23121180502081523, -0.6043337872596544, -0.42333304784135817, 0.6437675407879897, 0.4012236793767386, 0.40521695317262924, -0.6105756889943206, -0.39416963864477456, 0.3979887014160373, 0.2840726827983822, 0.6786145734005288, 0.5123528067255452, -0.2766345303245831, 0.6189439138731295, -0.8414730443803914, -0.6042735223218451, 0.4674636528718443, 0.128717706642008, 0.017501541949844726, 0.7170815093692794, -0.49791971349677383, 0.3659574882573412, -0.5304518893742338},
    {-0.816203743746406, 0.7139963142780739, -0.1629570830450765, -0.4055237056103426, 0.5581406493100396, 0.3952586557081546, -0.5337360481202653, -0.3465495160776419, 0.5968185479486705, -0.5250570157869339, -0.03325368802241408, 0.1913829062026442, 0.8401573045050796, -0.20141959760954334, 0.7269711310120138, -0.5866508595599362, -0.41409343028650325, 0.6084127379915958, -0.13404541764324054, 0.7262683685757865, -0.43546647792032117, 0.5331619567756799, 0.5281340856283775, 0.48280434903620395, 0.6727984297712757, -0.30487606803154577, 0.4814290450200875, 0.4402958198886121, 0.27236667568740935, 0.6398229810711566, -0.6190643072586945, -0.10435008962659124, 0.3967466488941357, 0.3232765668799943, 0.4024207075525047, -0.47250236073406054, -0.23806325989519841, 0.26190897610716385, 0.6698074948529465, -0.9337848428752061, 0.3882388431192915, 0.13260493478894556, -0.6295502570804781, -0.47905975335310486, 0.7055831007511407, 0.1393577799817029, 0.41230353822003407, -0.34640213822684074, -0.15813342663673127, 0.43778566904866395, 0.1551136919961847, 0.4762642047507596, 0.2971829935309974, -0.1581037367839331, 0.7235065744379654, -0.7100283959195626, -0.4081969403006702, 0.7037693572682293, 0.1188262041081296, -0.2349072047467193, 0.7508280611139153, -0.5471886969689387, -0.014927609693509614, -0.7005068192823648},
    {-0.6821114518424051, 0.5789643054329949, -0.43484241101249277, -0.7249627778639662, 0.5980631596749293, 0.6951128348651192, -0.3957890394595658, -0.5018274862915646, 0.8047767024874607, -0.6189850737135788, -0.27450063080127396, 0.06024092786432089, 0.8535272050234857, -0.058671964367531616, 0.6418345800366461, -0.5248896272308776, -0.2648460376812142, 0.4926832343781327, -0.01191150837371955, 0.7586872261615144, -0.7328386173521576, 0.8279993178456233, 0.5914709870880537, 0.5159415215141532, 0.6655460460741467, -0.20377971771487216, 0.5266721357104008, 0.30063015984272345, 0.5820873582965215, 0.8380608390435146, -0.20854754613703508, -0.2095445363385422, 0.40009717866606825, 0.4706749553124477, 0.6207544707659898, -0.5270203813011112, -0.23291352882169475, 0.32708781872539733, 0.46205506843813676, -0.5074689511788085, 0.3469224043887695, 0.08980491853333934, -0.4320269554508784, -0.2542239565536501, 0.9445199425471004, 0.34076511578088925, 0.6646754058651714, -0.6738673203711495, -0.23844756251618032, 0.36118828278301734, 0.2916704190924998, 0.4713228318874668, 0.4137285811421883, -0.245735373978914, 0.5487075248819976, -0.6613366986482966, -0.393166053809937, 0.6719989584458546, 0.32481321115432144, -0.27513364530130424, 0.8893166183196083, -0.6068027192642995, -0.15287794738417482, -0.5645537013440041},
    {0.5626844746954466, 0.005826647121507296, 0.08708507534869764, 0.33701535666342564, 0.30142680526061544, 0.5356186336040942, -0.11407048564866652, -0.538159202832565, 0.15041309129889593, 0.3413368184713175, 0.7135687752291311, -0.3343702044814332, 0.4775881542971395, 0.5839956044465378, -0.07608377874751739, 0.3428453746712329, 0.13508788725870277, 0.09585244583954013, 0.47943714819348676, 0.4773782893225161, 0.05616683254029795, 0.15144120629032523, 0.3612940308334088, 0.055406213028419235, -0.1548682662728564, 0.317082333391914, 0.26294086896736935, -0.21028681953012227, 0.6639425670481568, -0.21164658706771622, 0.3022523386600975, 0.5358112087090009, -0.4321772455581155, -0.30154481438034453, 0.459462171027829, 0.02129156740072327, -0.26775532544511316, 0.28471482811006543, -0.05711906175827874, 0.5908787467298424, 0.6247196386817655, 0.22947350388912566, 0.027351266554323697, 0.2872328042658599, 0.7748950500809426, 0.421989137164162, 0.3658722343363985, 0.3593921328643588, 0.43701481668573783, 0.47090265452168995, -0.6585772652142113, -0.030701670584529165, -0.13112622110745298, 0.2847968593909771, 0.3130522219097967, 0.0036190953485760275, 0.22235549661949122, -0.6870411451477235, -0.6990314833507671, 0.6910465172268384, -0.1987065646839936, 0.028998912613493372, 0.43522473745487994, 0.2718659316892685},
    {0.30057944882799664, 0.20658359613041205, -0.4754489096673908, 0.17034802911699143, 0.275718858309412, 0.41013668079891313, -0.06497486457306482, 0.132280859649961, 0.36619095761868975, 0.22270140692986848, -0.13582341873880951, -0.07668550445117903, 0.13765775700596153, -0.027531564701335092, -0.08895570201410907, 0.039960687861272756, 0.457964304895615, 0.1174013755875423, 0.19384472517298795, -0.09874383905645794, -0.02056808152989722, 0.08035724395295224, 0.21534016420671553, 0.17588864508868526, 0.012060161959855764, -0.09131083175763671, -0.12514673073806667, 0.22388449141519068, 0.12319440519605786, -0.1424531730794279, -0.14925300880850012, -0.11576726996768924, -0.08191059864241203, 0.24586835435967364, 0.27184134847089947, -0.25913559160096133, 0.46045071065540893, 0.20759112729713464, 0.28606008084006657, 0.007869037855625455, 0.44976546354273383, 0.00656052010647142, 0.14267079841320215, -0.06800988588447349, 0.08681056472013429, 0.2800999794198123, -0.015743386190371692, 0.0872878141666355, 0.0894059011325747, 0.19540839523442685, 0.07659080709701767, 0.2448761511979448, 0.04613005977595784, 0.41029196640791743, 0.07382085184356625, 0.08370777994454899, 0.07587659800103667, 0.4931386610127608, 0.14082379326156685, 0.27446074652527, 0.3068984142112972, 0.054047262776573214, 0.1376824082025662, 0.1789730244980684},
    {0.11665013595940722, -0.4733491510074042, -0.6114177339895043, 0.12476709114812264, 0.17531979930222358, 0.24005518827142283, -0.8620619732500456, -0.6635848448240516, 0.13655731835352958, -0.09191478021315483, -0.01774352918102739, -0.5389808672931911, -0.3517953321196559, -0.26022434894932794, -0.19178089447969143, -0.5803092989124182, 0.04975219088757258, -0.17144015521342332, -0.009556252576767784, -0.19570991736316923, -0.10707103659994402, -0.6249385067886899, -0.06722494690713847, -0.25824212814722736, -0.3680178227337611, 0.3818397106985782, -0.3928256929561151, -0.3908683024121379, 0.04397560136251349, -0.4815128407722327, 0.04119399671544957, -0.04363511504749397, -0.7285890360718238, -0.5939539154299395, -0.020845100153562147, -0.2755046672554329, -0.26144542559892436, 0.011806199993880575, -0.2935429208967866, -0.2800074450573483, -0.14957099380217218, -0.06472138934440966, -0.4314267537020199, -0.1497338637006671, 0.004533101357507168, -0.02983818991295322, -0.020596754825769458, -0.5608556441481484, -0.33715543052690916, -0.06379670324476949, -0.5894947589744054, -0.3909501498120843, -0.430574131747945, 0.11517487984531641, -0.29666198764010243, -0.12228445823796727, -0.19556242073832805, -0.28871579434196165, -0.29634774904372, -0.07965902912149672, -0.301135114942637, -0.3653739095202521, -0.38834212506669186, 0.09921427743761038},
    {0.15976746471582273, -0.8551205771804569, -0.24898130915857833, 0.006472370191735572, -0.27516083971869937, -0.1367579759304476, -0.4376604024953933, -0.22758982925143315, -0.29267116808678134, -0.17223945053996828, -0.05443204785289102, -0.42266567061551924, 0.1145492687105722, 0.10263377195946138, -0.2653859985559724, -0.3128267556935313, -0.35049486542178, -0.2590506454272758, -0.021781684205502735, -0.2820330325797424, -0.4388429764806474, -0.2989883265394508, -0.32813167850221536, -0.37026954333348916, -0.7508345188700766, 0.5039571083147558, 0.006697504091845043, -0.17891649944339205, 0.14967555131334703, -0.46452542443109557, 0.3365449933466492, -0.32514881064612905, -0.3642442286296822, -0.4104418788256168, -0.13693782120473072, -0.2274668711791589, -0.3292093207227452, -0.0015733769115185829, -0.5569901006278729, -0.1813665703735025, -0.10201779541502987, -0.3391130008200201, -0.5459015068247884, -0.15330944696831889, -0.3413431326292312, 0.07666597095411254, 0.025879532142208356, -0.1774976509707962, -0.16140507430836964, -0.23671128739760766, -0.6880958838904091, -0.3635592189751545, -0.2280176837429225, -0.08307372125500986, -0.3571028916066969, -0.26927458746636057, -0.13690882172364233, -0.22576121434722196, -0.2535143546622214, -0.004787212455751697, -0.3041355802617624, -0.4435943800242217, -0.17430563616661351, 0.1675573659881749},
    {-0.012650303900005867, -0.5235178198387028, -0.46858963244382607, -0.41575786718725105, -0.733449083470983, -0.3413074856397143, -0.4211546080550421, -0.0499850005745907, -0.468212960291021, -0.3626646376927065, -0.5161485122951868, -0.624683170722419, -0.5092200320862095, -0.4842697226799238, -0.20265992019775664, -0.8142228977201805, -0.30671913054080485, -0.2572774512301825, -0.25074899191029987, -0.33466587113879487, -0.5457225840914902, -0.5508994460300544, -0.36438484063535537, -0.173325723028178, -0.360686241935666, -0.17687908827234475, -0.3188563536771461, 0.13414284488342929, -0.06252966222714876, -0.13140507300275348, -0.1654895711814362, -0.3357825704493876, -0.007190725966820145, -0.6070806722550404, -0.453545063650871, -0.8703923177294005, 0.06425450388228933, 0.07899577966421399, -0.48702112814113824, -0.11838339697030412, -0.590233204714853, -0.006991472120966631, -0.6064451500405735, -0.42621693321308185, -0.49883844356581014, -0.6517898776085047, -0.5874109941312085, -0.5774492761854562, -0.673107878308547, -0.6824914352683578, -0.17049057300517353, -0.37998442779650193, -0.4659476136485072, 0.30714871996667575, -0.32445377316556007, -0.7606826986755265, -0.40091171591303826, 0.21438581546503094, 0.08150924795498714, -0.29978031558352436, 0.1193781347495689, -0.4087966375751734, -0.3301509163706413, -0.46979622039019453},
    {-0.04467288332012905, -0.12017323043360713, -0.35182974052663435, -0.10699968989301162, -0.2445367864535345, -0.044151074211134254, -0.19351563975863478, -0.0007043529432636068, -0.24706641056868878, -0.09645041168559161, -0.18529672423990073, -0.512467057878161, -0.32728631867561137, -0.2508032050325998, 0.008528472185441323, -0.4317283021317111, 0.2997427016923309, -0.4362275696121597, -0.321723456625007, -0.6351691572924411, -0.2458650486805799, -0.6583927237487092, -0.03565161045524697, -0.6517670448912072, -0.43642674825678107, 0.0713802151161997, -0.5238444948407601, 0.03306475068779861, -0.15693767908392012, -0.01333300893346733, -0.11397722270427213, -0.3458778098083382, 0.08353003727034748, -0.38783827948308625, -0.42222908086891814, -0.1749673136157639, 0.23410884409802968, 0.42208348014069147, -0.5235240823095488, 0.21939659112459234, -0.02844429849178229, 0.059491691138879, -0.3278894815656692, -0.38324584856580146, -0.4349445283856832, -0.5911409806693662, -0.5456365724349302, -0.5015092541254286, -0.3129037011090628, -0.470882590075537, 0.17154890505698062, -0.3795116800273806, -0.4661666957520199, 0.25908529380203843, -0.6949745374907493, -0.3343270445330766, -0.13106961702986075, -0.057461774401201496, 0.044648944892647854, -0.34481211063641176, -0.23135251202160126, -0.5129067701016713, -0.2925289665883118, -0.06536597424651736},
    {0.2886413857561974, 0.03674087595420674, -0.36442367559924355, -0.1890458057442665, -0.25461775845637197, -0.1643920837595087, -0.5700763884494153, -0.25849944472189845, -0.28562015669446295, -0.43866531720587526, -0.30871240206106043, -0.5722337279504813, -0.23587115270088668, -0.2640061082612055, 0.17883190025695694, -0.6158065857584284, -0.3556207198482668, -0.4727465390336589, -0.4885948885850777, -0.45327317416013363, -0.5634622209539023, -0.41616815676674856, -0.44947903790880533, -0.6407785270908736, -0.301536289996544, -0.18210892590654226, -0.37899313369540255, -0.025857477489662592, -0.3322097797167555, -0.23151830636907614, -0.36533389530769, -0.3722172945315971, 0.0362378041838469, -0.52642251299258, -0.5750754615822335, -0.44697847608855146, 0.34879881185089906, 0.08837620181820842, -0.27802047230506693, -0.14663252583571632, -0.1240997883420159, 0.5109545790967258, -0.4285415296386192, -0.4808076796837091, -0.5271644319885345, -0.7310744952067781, -0.3394976279299425, -0.4874495876639603, -0.426169134325858, -0.722823854283448, -0.35019031333300865, -0.4338461286749806, -0.4569888816032979, -0.018936122434745517, -0.5012204197171894, -0.22372878303856764, -0.33992566425634413, -0.34225934462780927, -0.2777694994061212, -0.17236825871801933, -0.2910663292794069, -0.17479228540037162, -0.3432585134869057, -0.0008686393101218751},
    {-0.392246088153737, -0.14897075436015808, -0.30951860229941475, -0.3083067330587158, -0.36565769542282056, -0.24901549166321485, -0.3662053258392993, -0.2217707052679535, -0.2684642208577621, -0.6879514298194803, -0.1427572048894252, -0.12795434059610863, -0.39545907103830097, 0.04891425185521396, -0.08350660429872969, -0.6070912910226637, -0.16261054837840305, -0.38105637709213935, -0.20968480959423022, -0.5848576483628041, -0.6723834499348115, -0.2036969412552748, -0.3173074798671759, -0.20123232315471823, -0.34891916502833037, 0.08522861976115663, -0.4116898438801002, -0.35591705831766995, -0.21982665028679127, -0.4422568086516633, -0.37249452618546874, -0.33857738686879296, -0.025186978408474628, -0.5107217580443744, -0.4478910555182632, -0.5372108755407512, 0.2770236565703507, 0.5183421788323157, -0.6050045529631634, 0.02014518359807349, -0.2517822009897121, 0.0403991009436657, -0.3789984564631964, -0.23526126182200277, -0.42365859446334164, -0.5618988575036037, -0.07638433045304169, -0.5668241225416598, -0.3592021383747449, -0.22058644063518612, -0.5958896144768713, -0.4344111731194076, -0.29820929010022396, 0.15904003794825952, -0.2853915447172325, -0.3268006388277287, -0.16790670815806338, 0.011974646806781682, -0.021090645764768292, -0.25566668030074435, -0.24033965624629092, -0.3406345926032602, -0.3207328262599725, 0.016648858810674544},
    {-0.41445590424409756, -0.30272935653439736, -0.48120551434164854, -0.2317769123270016, -0.5996588002295914, -0.3446850599190157, -0.7689901763932342, -0.4538497894372398, -0.3294790674072893, 0.005732943643251361, -0.24766003029219325, -0.3355539176774114, -0.5275480787287562, -0.4370927672263181, 0.05801834027706499, -0.42873403270209415, -0.14512191698830135, -0.21214715637283135, -0.2642089776017957, -0.44061345419167447, -0.0013375538362348915, -0.2638954693813428, -0.6233040429135026, -0.18552587620718297, -0.33300698398608836, 0.11074052648880207, -0.5026698078609129, -0.08812904928392282, -0.1415518118628051, -0.7952588496793778, 0.08284810067139904, -0.3105189983462473, 0.016394956997386356, -0.615131415615439, -0.27931670338126746, -0.2805371733912717, -0.04542926097017333, 0.10468069794278222, -0.2329191062420924, -0.18843984527919397, -0.4640078447765465, -0.14648108802282686, -0.13783004382099873, -0.3954273531653359, -0.43899306297962853, -0.3541875642898039, -0.2532487534950574, -0.6212933068405821, -0.09693211924984942, -0.28083553454075416, -0.4103971518038673, -0.26724754033847825, -0.007812703287418976, 0.3236491995496246, -0.5699481287796689, -0.6414066099713115, -0.12978046399683074, -0.19593076070128423, -0.40962553167045396, 0.01848102861352305, -0.22222651362765827, -0.5760613396508539, -0.6735358238036643, -0.33836441181429805},
    {-0.11404991613832603, -0.3671302661287817, -0.49379580821914915, 0.18491305884476567, -0.4498602878056674, -0.6188744653987016, -0.4219117954759897, 0.0024022244455683362, -0.29921349387233726, -0.5448022010503526, -0.21146461384954482, -0.6833762929539371, -0.05138760676786326, -0.4134005361727691, 0.21352507638054544, -0.5479892945183851, 0.13274816377701434, -0.3623944433038482, -0.40572142763826385, -0.2529015033475216, -0.3190257220122296, -0.6857232554268731, -0.6045365942696426, -0.5447810163175165, -0.2039095672768579, -0.007815483956693443, -0.06611904520292844, -0.019514313824984017, 0.5315745004420879, -0.10867933755912339, 0.04931853605663532, 0.06315795851457362, 0.027464994693257305, -0.5330930196284392, -0.16993768475022614, -0.5694471543646493, 0.6310139775997315, 0.3095037054665888, -0.3851045944999302, -0.17070182682916035, -0.4551192904005728, 0.5099986316152375, -0.4274580366029719, -0.7234800630498053, -0.15439907778192424, -0.36295750696938667, -0.1818425473798214, -0.47094084312551093, -0.4138586905889895, -0.5238180076997869, -0.3535882584783673, -0.33412702654270626, -0.600042616609216, 0.5582901169793455, -0.49793709471726266, -0.1687422348644214, -0.03093321967265093, 0.22442282566352173, -0.04877095555143954, -0.4029709626054995, -0.3817737734947009, -0.6456039937048146, -0.39546673258302545, -0.2022658217456996},
    {0.4332779886424913, -0.27174791492088046, -0.5168253172320596, 0.21343930064805222, -0.11567642663597098, -0.1302075787827728, -0.29197712538386816, -0.1435507823851373, -0.3554470076086279, -0.4924997367542067, 0.09568052533120773, -0.6483702530614955, -0.2687417947014456, -0.12511458444468485, 0.07632357175368515, -0.026664912194528528, 0.14971251540126432, 0.0754499058595284, -0.04587558301278073, -0.318053483057833, -0.4954099166413426, -0.34058629135790597, -0.3157192830492961, -0.47834546418469465, -0.5184649168378308, 0.22176654687793446, -0.03742956716596395, -0.5105947511185442, 0.17776732188456362, -0.08049731527929647, -0.47493853147873877, 0.24736472652221841, -0.24969256670758264, 0.16213266892387052, 0.008579849763872695, -0.4098454920326686, -0.1667117868772557, -0.006431941044624577, -0.5761130335191172, 0.22239715125678164, -0.0037352603016232652, 0.10851741150338562, -0.37311855089600676, 0.028473859242632224, -0.21225742221875402, -0.4422628373249941, -0.204135096116791, -0.21303745640072813, -0.379835442926559, -0.3506307872968596, -0.37647375039538084, -0.7047228483714831, -0.27148801600776057, 0.17523822041671147, -0.17049192839448987, 0.08253514781861238, -0.06254195499249289, -0.4775601676978263, -0.5297668267439462, 0.039161614594379154, -0.09190100749933518, -0.580457195224463, -0.057718912384474345, 0.16737570001457072},
    {0.1839516262480626, -0.3675475714846106, -0.13620394714223966, 0.3703278451799156, -0.26605188219707376, -0.18844854354718038, -0.6957464581054974, 0.16298281755386482, -0.3375066024847979, -0.10147135650588772, 0.016247669554875693, -0.6884405867527285, -0.14256935287471245, 0.050958935687130724, 0.05218513763580049, -0.24175267835027858, -0.1145160541643523, -0.16638855356072707, 0.03924810463876609, -0.1732735607808759, -0.4803469170464569, -0.4498543990154855, -0.3963118788826035, -0.4069592330210385, -0.23833000651019368, 0.4961097917217731, 0.035672885745127114, -0.017354247833317002, 0.4708075187184784, -0.4182995580572988, -0.3651117102077568, -0.17894117815775726, -0.143179731817168, -0.38805847668609533, -0.24208267171559442, -0.24571175670191786, 0.3727347456618459, 0.3306358226036226, -0.40669552543047494, 0.257475730502386, -0.3476199436116855, 0.42020383563934954, -0.3605849804590951, -0.40722420667277714, -0.056962632627671934, -0.3212991306013489, -0.3407516905673534, -0.3088937586299576, -0.12643856173445864, -0.3471167973173884, -0.2310213068132665, -0.18542173105247414, -0.5688150350510648, 0.16712521200982802, -0.5167041866085649, -0.30722084456063864, -0.16430374060922467, -0.4933648918971533, -0.23984755272736558, -0.20186208080040285, -0.3810702790242418, -0.4699470457619104, 0.09928543903170516, 0.060514739323480816},
    {-0.0368600624539076, -0.37301298312167047, -0.5874541392758525, 0.05146909572655825, -0.601896360445068, -0.16070546351428946, -0.32686616902576243, 0.03489302963320822, -0.15821440003481668, 0.08053445744198433, -0.13159678136688127, -0.4858106508315322, -0.45906114350949867, -0.29910644002786996, -0.035946125795966795, -0.221454288175094, 0.055070264195271564, -0.3703674613495684, -0.16823863876286665, -0.23317240872273673, -0.6410739687203942, -0.12765071704713235, -0.06295455525353325, -0.35883438381062155, -0.6614829163449802, 0.21263642394750665, -0.1348737905172447, -0.03188585754296485, 0.23068880450987128, -0.3230018808576669, 0.07858672208087066, -0.0925558608083681, -0.3724058893920063, -0.5492984323763238, -0.28046696865618753, -0.48735812761182234, 0.14674544281746968, 0.51682500220669, -0.6034944031905335, 0.05920967150572152, -0.1840703300741821, 0.3985782836269159, -0.5576053498699552, -0.33763807062618784, -0.1540923575060906, -0.0971547132334473, -0.3499553669738042, -0.6600464804208004, -0.4376077615521834, -0.44309807168599363, -0.1070992501498697, -0.16839152654367245, -0.3556022199913207, 0.2719858890664972, -0.43272592119604314, -0.33704428465848985, -0.2771014512531863, -0.4484724764612909, -0.4229066513784977, 0.22770010554992998, -0.3753627726833798, -0.5565215467828242, 0.016760330140493204, 0.09128662819806492},
    {0.04067123716850644, -0.43963749173284067, -0.12482476015798719, -0.2162098166934574, -0.6633889047469764, -0.24947544016364134, -0.7294384225981777, -0.21458436376061849, -0.6219884690546674, -0.26380018183981224, 0.018126689650974994, -0.20326219445768634, -0.4405162905051072, -0.40541744360594106, -0.24610682095758293, -0.20456632504458322, -0.22251399812594413, -0.1321490959730459, -0.565595151543476, -0.437894683499569, -0.3288503454214078, -0.5561647707026955, -0.3979117114219727, -0.5208845030456418, -0.6104276902897515, 0.21834676322512475, -0.42964107214950314, 0.04231660934472616, 0.04929312435177773, -0.6267648438498734, 0.2064587819602468, -0.2192810142112804, -0.5261791515291163, -0.6992057528068649, -0.3458569975430909, -0.681238403845233, 0.3078310386190839, -0.07353025370302906, -0.5461964708413384, 0.06252989843530725, -0.3990435170041218, 0.326460461532919, -0.4496659250712152, -0.4648883340809017, 0.005861589062038694, -0.4411416452951292, -0.3882605604698417, -0.2265097654041868, -0.4369972608238903, -0.42781471320731707, -0.4809161328868384, -0.5802282151285927, -0.6262944752372951, 0.20656974210144896, -0.4203278652896582, -0.0004235069267385385, -0.047097633219868276, -0.3784746201560683, -0.344858611380881, 0.08108221871812328, -0.5253347165632867, -0.5770152082117476, -0.26311320669843585, 0.37061902779416134},
    {0.13648864489583923, -0.6491670034937382, -0.5914983167189568, -0.04982541416955624, -0.1914302140488478, -0.3457797335322336, -0.6847494277465126, -0.2829348370489684, -0.5480164278286649, -0.2331633887412137, 0.4301645177117154, -0.586118225393018, -0.28201198970388014, -0.2511884763061252, -0.28937570066773144, -0.21827481645459762, 0.04937647292980942, -0.2764317381484919, -0.5663367677067874, -0.5515271280834102, -0.3363192331979406, -0.22011004139518456, -0.5307981844757033, -0.05225042762729397, -0.6600937856517495, 0.0696454271099781, -0.09612953684570022, -0.19328889978770916, 0.4449054516225875, -0.6085749336163393, 0.3888325935074571, -0.3201211487931466, -0.5082091582224684, -0.05518953336352795, -0.049619780312545395, -0.3373822650787637, 0.5567749549709541, 0.3818875398863575, -0.48565900107269944, 0.12935840376993712, -0.19026125260684906, 0.005891780926720662, -0.2095143892310902, -0.49445680899036104, -0.17063789828945852, -0.3136285813654397, 0.16780760610284254, -0.5275312846524854, -0.4655574906312058, -0.36602600668637547, -0.469229630622264, -0.35521211798781915, -0.6339201495204669, 0.4095660668769383, -0.3559411455936534, -0.1919989237341079, 0.008724715826516202, -0.3861676527470451, -0.2853388845001846, 0.2787546037286678, -0.6571971032439246, -0.3937164689352927, -0.3928161497306837, 0.0684833030042974},
    {0.22492359877492288, -0.444256019669184, -0.43003763005110907, 0.14980497749217392, -0.4075536641486417, -0.10968976818599763, -0.7406484174926432, -0.3567125714783842, -0.13721813870086155, -0.12942135140535577, 0.0801139865853473, -0.6359504058928975, 0.0075405650371564836, -0.41536156294293447, -0.43674188282997234, -0.4053306008943835, 0.07083226010739092, -0.13176557905009104, -0.4326324757646178, -0.22450695501089216, -0.3351472129026649, -0.5422794175652167, -0.15686470483669795, -0.28218609748538037, -0.3895403181666842, 0.17037199904358952, -0.32987717188327925, -0.2477477055271227, 0.03611072401820468, -0.10447429229923438, -0.21375387821942546, -0.375704375797703, -0.06725264906368877, -0.2632609051762489, 0.020066239083627913, -0.3021340650533752, 0.4531307025411764, 0.35055926558589307, -0.3979446979552415, -0.45332082773738774, -0.2912894766801568, 0.2672349878124299, -0.40168985460267786, -0.5740405523459162, -0.11936464619078435, -0.23975666599260737, 0.11714810226697152, -0.6781393186895324, -0.5143319907691779, -0.23890683125607803, -0.4430989818747236, -0.3677419027322199, -0.1459317246681331, 0.5089538328231101, -0.474376870541839, -0.07365331176609614, -0.4305249786476738, -0.2989497983008217, -0.3161276821531341, -0.24081315953627208, -0.3342908970771492, -0.5460152373638958, -0.5482158027928078, -0.09122436790721225},
    {0.21355900092278904, -0.4129382481230054, -0.22229884009188236, 0.1917884233517893, -0.614340829249722, -0.37067908863981064, -0.7060170498510572, -0.7271507806337083, -0.03989435260975767, -0.36696072352477116, 0.05529694062176009, -0.3684563311333892, -0.2404380474147572, -0.1314086085718789, -0.2695325439116752, -0.41406211268873433, -0.11649260282047351, -0.22207339624533318, -0.541401622275638, -0.2493892603655552, -0.5252112566369408, -0.4224072883779595, -0.37585540215613716, -0.528768197513277, -0.7373608422379283, 0.284250181148494, -0.21730660457303613, -0.34282689943996253, 0.07646018266732707, -0.30565741463153967, -0.39310032462890276, -0.24525634188536907, -0.06005991828437998, -0.6218321047676995, -0.14185134445764644, -0.4959870098624288, 0.18057529037475548, -0.023969054849244362, -0.21714260364444873, 0.03579117422772794, -0.4821072122378659, 0.3746256300286154, -0.5548737781353141, -0.32927841969331323, -0.22070415411458041, -0.3563316651462181, -0.19974575824895432, -0.42923039628292053, -0.30835167850094497, -0.21013761790306681, -0.6146410232868369, -0.7728750984234929, -0.18640949139918617, 0.16597898367035846, -0.20067522049635692, -0.4589689917089292, -0.3397109380937023, 0.07955255739820666, -0.4991294964893516, -0.34295180471644, -0.33271460195786456, -0.6575646279684725, -0.4035469079885692, -0.3301236895089023},
    {0.2484028598121507, -0.5699349588206881, -0.436861621372198, 0.04225045606481225, -0.4898801540807254, -0.35183688187213324, -0.5970326613912382, -0.6802606321596752, -0.2701666069406504, -0.6025332403132825, 0.10628867432061044, -0.6043342146654036, -0.3985627311613738, -0.09543572001575068, -0.14977235251327584, -0.43572436948779225, 0.1840618668271657, -0.34803632688514247, -0.28298413269958783, -0.6307725087363615, -0.6429257930464959, -0.4186018474418706, -0.3996926179918163, -0.3003223753720876, -0.5727891916117764, 0.2529556309950817, -0.1330522191021399, -0.25764093628455437, 0.2619250678709045, -0.8045459029741653, -0.10261602076150743, 0.10084747795921913, -0.3086171036001823, -0.6456756799779687, -0.31326026203429796, -0.5404421980816936, 0.38488346467693846, 0.5079951879160637, -0.09789411079195875, -0.21823558343469882, -0.4407939616642393, 0.35239832265420257, -0.10386947234794237, -0.4336497385125362, -0.12827551787460423, -0.47168116392888904, -0.045381518457511844, -0.6104915780894545, -0.4552669854746784, 0.0836080159174244, -0.29644506633891654, -0.5398060343621822, -0.11884768684147375, 0.44151476582871996, -0.4568565194319645, -0.43306157169029014, -0.6098469180022192, -0.005685038778132977, -0.279134950350659, -0.3347094891925856, -0.22533765991849533, -0.8070426818631984, -0.8174856610557756, 0.09090792109847287},
    {-0.2694212783511736, -0.034487743223168, -0.7481333221962836, 0.31658418263692994, -0.310417732582208, -0.43113266241503, -0.4491495482121984, -0.5764812804697118, -0.5008736116358776, -0.24742666014464904, 0.06112594225842302, -0.427680610169394, -0.43781453075909676, -0.06709176868003128, -0.44245540843665765, -0.3325878621953202, -0.08037654922131135, -0.12735433082783879, -0.36781358076447973, -0.07824652409081286, -0.4446541408828976, -0.4134421075760016, -0.005315789854992737, -0.29446023952290473, -0.5256065057436673, 0.09636837876508282, -0.513488464938297, -0.4119847936816722, 0.31407175901235557, -0.6770020039871075, 0.01297417407438973, -0.0547252611656035, -0.29627696470100917, -0.34586162469928133, 0.0812636733759768, -0.6904595201403534, 0.31578792479086387, 0.35263589844822496, -0.5438113392730326, 0.020642373714157548, -0.11928678488529862, 0.30012515546276025, -0.3985288320022975, -0.4827516103391516, -0.1812792301466529, -0.20109579891603163, -0.3004274603707757, -0.5510386091679476, -0.3055852307308681, -0.12504350331438852, -0.5616342906418608, -0.5567188385687127, -0.5839770776035642, 0.36539698079357735, -0.20137705478904885, 0.017869995326162062, -0.6274249637800323, -0.3920477750120002, -0.35568011529282006, -0.0346736184570426, -0.23509627896379204, -0.6555527570259531, -0.25421439044243166, 0.03710780813391571},
    {0.15598610778426508, -0.42453398200923087, -0.513164346087611, 0.1900455213724271, -0.5311682238395127, -0.25604698896928474, -0.7790872686530353, -0.3151820397812348, -0.45076343586120776, -0.31827710901670225, 0.36454990990340086, -0.4979371714349802, -0.6418390701403252, -0.39577089077587724, -0.14946093557404755, -0.38228984597187654, -0.30677684163651464, 0.1425863126995074, -0.3304367052844621, -0.6863582985515733, -0.42922180104120744, -0.5996746428171317, -0.23444920502771072, -0.38683744793634645, -0.7138039397180788, 0.3044791350800407, -0.35769033061574024, -0.47428042397886566, 0.35734757690851465, -0.46416100009607897, -0.13799802180774137, 0.17132660035932906, -0.4699904111543557, -0.3626761614446429, -0.1819286429003386, -0.6650714340374239, 0.179171727233598, 0.6084044385216616, -0.5656531743035068, -0.18765037166267085, -0.198639866501225, 0.4695399882982574, -0.4140577431781902, -0.4589696735331237, -0.23151724090243617, -0.5324562365879769, -0.09417630216188266, -0.407655082360148, -0.4000203865083214, -0.5517986686695482, -0.74747299568779, -0.6754031435628269, -0.8371670362739281, 0.47257476763400824, -0.3781858132434625, -0.3673983131777555, -0.4714746331737747, -0.16982864405214793, -0.45370222714655645, -0.36375092132555553, -0.630668976391486, -0.6585261552325653, -0.5028837279936693, 0.34214991050141597},
    {-0.08608937941194501, -0.8203946596270442, -0.4427216129417743, 0.24714260794378862, -0.4981195320663367, -0.5332510793900557, -0.6821704144076695, -0.5330375840406181, -0.5367955854942452, -0.7353414917713136, 0.0703003453996971, -1.005343625791153, -0.736158140591198, -0.22272158587477098, -0.03389694701391927, -0.9267237029012524, -0.048549623846911145, -0.1491706771046487, -0.2503685653457807, -0.4094410281899972, -0.7015289296281089, -0.7639392637828228, -0.4511784933428357, -0.45002382924091383, -0.546938168278267, 0.25319163702545344, -0.3130489581169992, -0.40168696029567097, 0.3319203943326965, -0.4305913062559536, 0.13050988373999686, 0.006923568372078967, -0.4597918662047611, -0.6559728382733433, -0.46497745350944003, -0.5073650471284973, 0.22773927186922077, 0.023080504846286074, -0.5746548774955221, -0.1466031144836388, -0.024375085843787482, 0.42612936818156383, -0.5943618414877495, -0.3899310643763073, -0.40009903062939, -0.29500288533251495, -0.42522087484000837, -0.393139334600392, -0.7780739668748033, -0.488129864493724, -0.7241850028457396, -0.6301114816498788, -0.44855917269816886, 0.14445049086561326, -0.41846973154850114, -0.7894655419185701, -0.41180672368990556, -0.2394522116098998, -0.5593754578280732, -0.14522822629114102, -0.5477119093283823, -0.9535252780718884, -0.40960717010878367, 0.0691701539658376},
    {0.047223283395962025, -0.5361572968326749, -0.48262747273412776, 0.22013545176488078, -0.3388515563148197, -0.4077961298393515, -0.7322741909224291, -0.6027148614640061, -0.21577642102115507, -0.5284142362385776, -0.05670805343431809, -0.5992996085672546, -0.33870064614695367, -0.02001103831264105, -0.4270198127173425, -0.6191924781829127, 0.0661154725600985, -0.23182332785290555, -0.539221595075697, -0.7298697074294925, -0.4138396218339432, -0.34073586983821585, -0.4590063797883327, -0.5262244728903153, -0.5190220389423433, 0.3468651047212809, -0.2338835591245082, -0.32896425009606556, 0.45576171186349507, -0.5687381158723669, 0.0738767624360336, 0.5117214548576505, -0.5499281721003895, -0.5560277421772764, -0.05975662059821291, -0.7049100162963227, 0.3763777735159925, 0.4714275654652699, -0.27144373618060635, -0.006931391245269735, -0.08588633779321853, 0.5074563096044766, -0.5597239600294625, -0.5517095453554814, -0.47863814800777843, -0.5030109731912307, 0.16807468613362708, -0.42410102697256397, -0.4369693866326415, -0.14071834004390302, -0.5118892535102015, -0.6199216256565894, -0.3062541858061084, 0.7342557210191316, -0.7301237222446055, -0.4743597037970184, -0.4867496252367631, -0.017843032138286263, -0.8668180768887553, 0.07130690690061563, -0.29963589516219946, -0.5987944688271294, -0.5431963457074942, -0.12959735517891566},
    {0.41506002143037385, -0.14945589187553573, -0.5283245020942262, 0.2754121771951712, -0.10195164276205766, 0.29483053963783923, -0.7860189249245306, -0.6581105265283976, -0.4426924311893326, -0.5065820478266754, 0.5020643088232661, -0.72365414980089, 0.12710219877904216, -0.1299584077708219, -0.39203428569081306, -0.4709875456088576, 0.02011505402457636, -0.1991671899179727, 0.045974280401729864, -0.17041943992404926, -0.2925934414490909, -0.3944338437737024, -0.022264505093535576, -0.23049135374917698, -0.5457879303386385, 0.3195392549917057, -0.30438494210139505, -0.2123870660546698, 0.5544472309194114, -0.9000690856445253, 0.8268640144751359, 0.488609493837651, -0.5186208077646878, -0.35281884092680776, 0.10640361550299653, -0.6258931629679337, 0.5050034873818279, 0.5323383437350643, 0.027854363527040685, 0.16217047875144705, 0.09484818268907112, 0.5787902906264848, -0.39300005679859423, -0.16131236963247314, -0.15093765622998664, 0.08325667638662261, 0.41284245377609924, -0.2268703333939812, -0.0759505963463324, 0.05914302367616118, -0.7944106288792404, -0.5357509954655587, -0.3479638176056914, 1.006543080435361, -0.20589467215743737, -0.27497294107536935, -0.4428384644948345, -0.08617925652620075, -0.6567083051338116, 0.31749251705950154, -0.3733218266898691, -0.5427450283778547, -0.49443347301250445, 0.231035570098698},
    {0.7643731516760548, -0.3010835980904024, -0.6651324249357835, 0.44005767966952064, -0.049135752427923465, 0.39023267860326444, -0.8169493543302374, -0.8521542888441893, -0.13085775477545716, -0.21070361146448074, 0.2924825941665202, -0.8814240507385434, -0.2067320633469314, 0.03181032552162627, -0.33339512741178046, -0.7939651497498499, 0.6071911862187145, -0.07848705325919893, -0.0628214392385774, -0.19905829926233318, -0.40651931371662203, -0.22894861484289875, -0.39398924440661465, -0.4820371853924117, -0.39158273214770273, 0.4751519866184813, -0.4052522082535047, -0.3512031421489447, 0.3122974915159786, -0.8718485780239579, 0.4990689865466483, 0.7024942179069237, -0.41081135178693423, -0.013641836253475953, 0.07745430251522654, -0.48856280907408106, 0.20150136912387115, 0.35354818118315706, -0.3518170202261237, 0.10117693660961138, -0.09736388645820572, 0.40979944057537393, -0.43458762854142186, -0.3378494307924282, -0.1562604577230271, 0.26105485649419014, 0.37799143946640934, -0.21189530080294422, -0.3981974026924405, -0.05707012029562518, -0.7826022795757136, -0.7961849658051426, -0.43642335544173755, 0.38102226618327134, -0.7120670151267319, -0.28771339791501666, -0.23123201210575714, -0.3693259942560425, -0.6593581657296275, 0.44961191254325616, -0.5992628137770813, -0.48680882199575315, -0.4621042177353579, 0.30717484860242616},
    {0.22811510559469866, -0.5830220121231291, -0.19767661675680587, 0.20337040993295588, -0.41319774348436134, -0.185362300305495, -0.6129592534058, -0.1588683672336509, -0.3295601630588528, -0.3020892509178912, 0.0020636917663517935, -0.5551827319206647, -0.13265357859870403, 0.07009092339814003, -0.3241997163889158, -0.5414866741292576, 0.11157363704200193, -0.041522804119592714, -0.3369193897355112, -0.08199665361020958, -0.4596950832677666, -0.5264797845277387, -0.4126521382691969, -0.3447133571218548, -0.6883104394809255, 0.3292404557427644, -0.3460727573657535, -0.23294586306330728, 0.4285871218955017, -0.6392463283977999, 0.031290484749530015, -0.16970777772361662, -0.6131615651917768, -0.39510874636591553, -0.1912199838931973, -0.3398304191691312, 0.5253164383205916, 0.5971381396471385, -0.3478676501258736, 0.11838835616163393, -0.2713319509285378, 0.5986435563296894, -0.5304622568016751, -0.40458742995110847, -0.28643162391650245, -0.16425666822607418, 0.03030946816801243, -0.682893352409728, -0.5926338179230457, -0.45537926384736266, -0.5110698710442194, -0.5845606402763976, -0.39054344364986926, 0.17329342066512832, -0.3894491747523426, -0.7026757549276192, -0.3049287616538457, -0.36107506640763165, -0.5195264288825365, 0.12746838280170203, -0.5241970417508972, -0.6417308873603814, -0.3682655619660738, 0.10258577694129441},
    {0.2062410597399914, -0.18343139412949214, -0.6324034290736241, 0.6338424694014663, -0.28225089683368176, 0.07823128053443344, -0.6285405505427877, -0.6730776050157518, -0.4048967317180279, -0.3407387456820367, 0.28668128811413146, -0.739947780384758, -0.1762111137821094, 0.4178144820257678, -0.155937585666819, -0.5851530947731258, 0.329520875113461, 0.035362343265543085, 0.13534113354285848, -0.08303857866610864, -0.6274291768006782, -0.6472462419437758, -0.053457768852326046, -0.5929683820651108, -0.5352258690186472, 0.2596740117735797, -0.15436475629489502, -0.16763091143629252, 0.6029401778211522, -0.6682982380656945, 0.2768268411782725, 0.1826031934542833, -0.5444202012817797, -0.3340874462542343, 0.010391572596537469, -0.6563360631043267, 0.4103109099112193, 0.560608020402504, -0.3331874846270316, -0.23347839991695252, 0.02228039257077013, 0.4847846504665947, -0.5774941567134793, -0.32713885004547116, -0.06087071620457573, 0.005092608476200971, 0.4241273780642291, -0.36196658703920515, -0.1673759466760454, 0.05301805304685333, -0.8392070803630616, -0.8051714121355894, -0.5418805167523586, 0.49665194933950474, -0.19707073223139834, -0.41306026646861604, -0.4274287680563513, -0.37306866590640103, -0.5902229245851712, 0.17994888799821485, -0.5100682898102167, -0.8444130350751138, -0.36881756436215946, 0.3579767309333386},
    {0.5759472132490769, -0.0869391253576669, -0.7420508259161709, 0.42975485965875265, -0.1579409824481169, 0.08037092968138262, -0.41721537880244997, -0.747600533870297, -0.08965856925493038, -0.25367447264699644, 0.4331923352434221, -0.647171720184553, 0.03720324817438297, 0.010917979140135722, -0.02607963078814511, -0.3010008982270088, 0.3600065577432555, 0.10882691809189948, 0.26471705742201845, 0.0502803774817273, -0.33987355894741683, -0.20795213241144647, -0.11029502043695072, -0.38576900826258403, -0.60363378221263, 0.3228584197614741, -0.05269465242891386, -0.3042155064462805, 0.7482256711807086, -0.7391585246197399, 0.22912166784619645, 0.22668366671666582, -0.4147962939102727, -0.5087963754286936, 0.10406449082333508, -0.488459152500451, 0.30467275051639603, 0.7400152637980023, -0.37816284318484894, -0.049186186925421156, 0.06828055111603128, 0.8628388357125678, -0.5033699760425833, -0.3910984368835433, -0.2433504043450759, -0.13272077839497426, 0.5525976552924132, -0.4089243216283337, -0.22277512955248402, -0.02914441917616109, -0.6440556787695005, -0.687615872386802, -0.5208497606680561, 0.4943180533072602, -0.07883051215118579, -0.18882206145103897, -0.23224242485404534, -0.32887464907176217, -0.830433088732549, 0.5470531556656658, -0.5853316417063706, -0.6642720199937966, -0.25394540119344344, 0.6874869506932282},
    {0.442876810335848, -0.2899855879476185, -0.7155910003743151, 0.3255106838761426, -0.1617848089922383, 0.19154050089521735, -0.589738128141708, -0.7566235315109024, -0.20594841729926378, -0.2966130133111482, 0.08734491606313698, -0.8759610550353609, 0.0007227578297912998, 0.06422104070020691, -0.1794927552054516, -0.6500878173546103, 0.262226550043567, -0.3110480942613351, 0.22563830154853742, -0.3155376674152504, -0.2590148087236634, -0.37359510127365286, -0.264622520627727, -0.5259324256954014, -0.5487320535342909, 0.4067564453468002, 0.03900137027816595, -0.4301261004858026, 0.5189678145741835, -0.8995739825662974, 0.11031373708480459, 0.29297005048593955, -0.49910643660442844, -0.5247005532792042, 0.14284117218299047, -0.7924047391770526, 0.23491838175959584, 0.48135882530003116, -0.5873178186183357, -0.10277750007715925, 0.021547481222781016, 0.731734496683968, -0.40266790622607257, -0.5043659299241077, -0.21433936148245553, -0.13343966903571092, 0.30453106950250813, -0.36338762254242885, -0.3950211669126298, -0.2176151461905116, -0.6638143072266983, -0.7208122080006105, -0.5464938468334946, 0.3198980547703853, -0.40364797002253827, -0.30172143799970047, -0.4858900908787589, -0.46938313956149597, -0.8021281931750575, 0.2752131063679896, -0.5017911406626563, -0.7548868150054158, -0.35172621376210755, 0.22850803616554394},
    {0.43999490882016745, -0.3246281766999951, -0.8536593660890895, 0.43044858504726624, -0.3540570316086552, 0.26805277831858054, -1.0949350196622927, -0.7730215344713134, -0.20050186145736307, -0.3215124884487817, -0.07749437569041777, -0.5819693269971686, 0.4380717198426784, -0.003823238994635439, -0.31574923642093694, -0.46980256557251815, 0.2406085770626353, -0.1830496301073135, 0.028450461581803067, -0.04982499935127911, -0.2720387073748316, -0.3312107260934515, -0.0981820624840614, -0.5146214915897991, -0.7450983255853956, 0.3462839138659073, 0.093729292291541, -0.05438545702019459, 0.5831431213756199, -0.7132046313763805, 0.33102375729400285, 0.4060745536067252, -0.6222768165527423, -0.36388644703513245, 0.34403557375023724, -0.5934747812004819, 0.37011590511246933, 0.32661305584230754, -0.22163191941882698, 0.16521385233804567, 0.19863893477249173, 0.566663672158516, -0.15080295964697857, -0.4757219454284937, 0.2218707126646196, 0.2285270852525035, 0.2114990225420733, -0.24245555578389055, -0.3211508098402561, -0.06754009565959448, -0.7944208664035052, -0.7089906360742311, -0.7319401124207575, 0.5291311891485155, -0.2537352764196011, -0.26837410035477577, -0.4502634463889005, -0.3089787857019406, -0.9266006230248652, 0.4314726902755979, -0.453375011585322, -0.9940918009985278, -0.4019932244973275, 0.31160698315239216},
    {0.373629587480575, -0.27758990038422676, -0.35446163002839, 0.2524153559359591, -0.12990640723605215, -0.15901159740633453, -0.7471896139316009, -0.7613081840621357, -0.08065301475825941, -0.204512492160721, 0.4274036330166822, -0.6749266028262485, -0.11869420583010153, 0.10382783368619368, 0.0389826733832168, -0.4474680145683228, 0.08328575913715724, -0.06972168798564608, -0.016717074856043273, -0.17788553670700297, -0.5179006671975104, -0.38432292723023065, 0.011890810210235544, -0.40783118583731537, -0.684561275348776, 0.5256228381297933, -0.04315704190565295, -0.39648786259963176, 0.6266652311408017, -0.5609633544938647, 0.41241204081613075, 0.4857930658801523, -0.5836748451115813, -0.2570278963379135, 0.5244454011441194, -0.26557210897020467, 0.32297231728103737, 0.8298687720960861, -0.5141327967647081, -0.22357542490624158, -0.17512158469559846, 0.6696337095380072, -0.27396252717590297, -0.2233527054399417, -0.02904743673661567, -0.050130885261212066, 0.2489871259008678, -0.22457171649553284, -0.4445402276271842, 0.0432649889295611, -0.6642417880692844, -0.6924377489344266, -0.38571819121032186, 0.661354539741626, -0.37580005808718214, -0.22516356529406498, -0.11808954717005081, -0.41375085012280355, -0.9289223502512377, 0.35092087718798753, -0.6228593083369782, -0.6926204441820352, -0.2587669396635433, 0.43231312036041103}
};

static const float b1[64] = {0.968883204722976, 0.8899045666420694, 0.723264859677974, 0.8496898836467829, 0.9133479167438936, 0.8887987727190418, 0.9391742327319433, 0.9257213313129352, 0.8333747031211751, 0.924041373358199, 0.8060982202576717, 0.9045628179298659, 0.8845116318747588, 0.848745571598754, 0.9332595286334273, 0.9374080091615735, 0.9020778988552677, 0.8559469688591149, 0.9095536866856272, 0.9090597713397222, 0.9353252256546541, 0.8925203929139156, 0.8367345128984388, 0.8292798086934862, 0.9522039373304322, 0.6623477225011305, 0.8983825751698166, 0.9774659981385626, 0.9856110343460806, 0.9408084795559446, 0.9148635405459022, 0.9013959695910487, 0.9075808535957522, 0.8877838938997187, 0.8977771544699292, 0.8913000885979102, 1.027918920479597, 0.9349002270738672, 0.7818824032904845, 0.9463781995031871, 0.861242407878071, 1.0153110714056806, 0.8960653484861599, 0.800063223183422, 0.91492096429638, 0.8854733079066027, 0.9024702123487295, 0.9357785623809691, 0.8817900302567447, 0.8595158934195734, 1.0000016912164755, 0.9029086596028216, 0.8837926279317513, 0.9539468335910756, 0.8488111313426958, 0.9507242082872321, 0.8989143655816544, 1.000900255696778, 0.9880515913088895, 0.8623246513812488, 0.9322431939598391, 0.9407921330808351, 0.892528565878122, 0.9178557043037721};

static const float w2[64][32] = {
    {1.1139591501177804, 0.8007144472657197, 1.063964988762047, 0.430594027928619, 0.8284650152819679, 0.9984696262401741, 0.21609770986221133, -0.38771432636236813, 0.8542101340333931, 0.8327192905795983, 0.9073951300604268, 0.8835495410170231, 0.07272482247226159, -0.18637427043548432, 1.0502011799834567, -0.09609511225721061, 1.0431618800559124, 0.7693306159949513, 1.0743678582960694, 0.6101119202361229, 0.9361599594773085, 0.9203895087419544, 1.3060008867607438, 0.841440058642359, 0.5028132049643715, 0.5854605442385642, 0.4971934968238532, 0.7590439430004011, 0.0604434174964292, 0.7025946069619944, -0.17156036651969284, 0.9404964693931603},
    {0.9276603727274226, 0.6326117894442422, 0.9093539628127731, 0.5604814507515333, 0.5089389861963798, 1.1528392043533509, 0.06182704200678167, -0.01664287466039209, 0.8913775314582184, 0.6841344876001486, 0.33585384621296693, 0.9247022646676145, 0.47457214320467506, -0.0794416420159933, 0.8599729749451145, 0.001642967447520634, 0.511235162299656, 0.41128807589491856, 0.6042653378892818, 1.09211747190385, 0.8871697096610708, 1.0269952192882628, 0.6357714634046507, 1.0129471644253052, 0.8454141747021396, 0.8720503701805445, 0.5872328723889835, 1.1789622230838048, -0.2643763880467202, 0.8267998138504806, -0.07541007963011763, 1.1239216724151446},
    {0.8807595140584099, 0.5944271818383088, 0.89577524453075, 0.5145612292445922, 0.4797549759963494, 0.6322930165777508, 0.0731861578972194, -0.017800349088511865, 1.0894765551499517, 0.6202137049505169, 0.5190251886506694, 0.9088822017619328, 0.6113174877824197, 0.05200323286037193, 0.6543900343602915, 0.1960882471349467, 0.5134784191415999, 0.6396689548642394, 0.9108724455375755, 0.5996635069924064, 0.8521439476613645, 0.3493062101165039, 0.8013581632178849, 0.5850886236173309, 0.8649550036805287, 0.8154329286381592, 0.5261621994530016, 0.6992737094103366, -0.07516296134279458, 0.5532573017828515, 0.039183144858495035, 0.6231998224407027},
    {0.726881708664259, 0.821588602457922, 0.3972679268847628, 0.7312966909754506, 0.824244924106355, 0.808425277829361, -0.06757111651021071, 0.1277690597605916, 0.9211275162522641, 0.5987835120516746, 0.6299350187274, 0.601576170962533, 0.4587576561539314, -0.07319435587154612, 0.8339696662194828, -0.0029420780576922853, 0.8162827139287759, 0.6188867658377041, 0.4305288312189475, 0.9873882188800307, 0.40219240857848254, 1.0471356319192313, 0.8338777710222087, 0.8716956172688136, 0.9769243711188161, 0.868906950179012, 0.6477248730419125, 0.8967209264983285, 0.01845365080843618, 0.8690688093246765, -0.05900004972865609, 0.8866138076856985},
    {0.8900964812477101, 0.7253628093765749, 0.6933004342114534, 0.6946877149288797, 0.7376531896555648, 0.8231480963775192, -0.0927893624099984, 0.07585954892270343, 0.8501079716779346, 0.6495492654732415, 0.5955676009883303, 0.9659382855275064, 0.3773271054845735, 0.04250410053560395, 0.9368822155339329, -0.0501494338730929, 0.7936635653476998, 0.7909308002287123, 0.4129966743297441, 0.8529158762811133, 0.5645638539938811, 0.747898935531679, 0.7285501762448661, 0.781160463662247, 0.5546189162527714, 0.489376261404861, 0.44622358870854223, 0.9371605780810692, -0.15788101813985836, 0.8291449950432411, 0.13355348091143254, 0.8158966532839329},
    {1.0955184039273298, 0.8849072241806996, 0.9682744488272478, 0.541793980487074, 0.6839057797179474, 0.8419987927382035, -0.0014581049966329983, -0.3398228693398404, 1.1256120867346424, 0.3683318066884541, 0.4319374405215379, 1.1007260666284149, 0.27728122456869575, -0.3444649409670159, 0.7301337923584115, -0.2568465965557012, 0.737759527462131, 0.8368248579555679, 0.6273023490333145, 0.7666968614587225, 0.2617846249220835, 0.5305355383994216, 0.7855642765094344, 0.5058774406159001, 0.68741042475193, 0.43574195236476865, 1.1290368015604741, 0.9604538070264684, -0.194354621656723, 0.9386666459736384, -0.22235426094945265, 0.8239676353721459},
    {0.8312138237540108, 0.6935305877786164, 0.797485148164345, 1.1433208888956696, 0.7221243882226619, 0.8366284471047712, 0.24377545248063145, 0.17697122434258217, 0.8199481222594718, 1.1894069008127885, 0.5877594754208653, 0.9790152252813115, 0.594052343910515, -0.32577108197902666, 0.8771647298018327, 0.11671794486944302, 0.8661728092043663, 0.8722872247848301, 0.49044933157291715, 0.8480316471582616, 0.4653507155510958, 1.0415549058906792, 0.6894880623860999, 0.7559214884748567, 0.7908579746894401, 0.7776123800509509, 1.014677554508825, 1.1617977352163227, -0.38558215767771925, 0.5645093466644792, -0.2098899123122643, 0.9620142310012687},
    {0.9015642409290106, 0.7816379096343713, 0.8589638478303361, 0.7935380050210253, 0.8735569642576999, 1.1106298479274324, 0.19758228385841659, -0.2674155993721321, 1.1742621916867584, 0.8289149209621316, 0.9911882987980525, 0.6430627473342825, 0.539742391813781, -0.12901830394784358, 0.9067797477070342, 0.15281634117094195, 0.8959688432938027, 1.023189633195758, 0.7594938914153799, 1.1393977962533643, 0.8259832204747997, 0.8333463048689841, 0.7385354284968674, 0.9445026341880148, 0.7576880504419777, 0.9868632781267436, 0.8920635290141561, 1.1273231877321623, -0.23048898408177132, 1.116344121916952, -0.004973066057714875, 0.963636541945626},
    {0.3710296607075645, 0.7420780637567685, 0.7733137648161056, 0.36264794130212186, 0.5902724799231515, 0.5874716399335804, 0.3551381650296511, -0.06518873290332537, 1.0680464946396524, 0.529999270612876, 0.573977889461271, 0.8847894521627934, 0.4436060708323911, -0.21439277649708635, 0.9791587058901745, 0.0894050578055265, 0.9038075150886649, 0.6559430460639027, 0.5764959373435712, 0.5341882152302158, 0.7552041411641439, 0.6661449658772957, 1.025091615600811, 0.6317238225440427, 0.6537455373567871, 0.3796782067194641, 0.7622252385135639, 1.2232022958315465, 0.29653357806494823, 0.7975648572683518, -0.41526205816581213, 0.7887067600561198},
    {0.7608285288925364, 1.0066535806142336, 0.515791510358579, 0.2414319781852012, 0.6575282340143904, 0.869046026969097, 0.14402683538366529, -0.13901604916679788, 0.5395746251283946, 0.978794349923678, 0.6933037517912461, 0.7907185027495942, 0.3186287211613843, 0.008017822388413089, 0.88278569512355, -0.23447155063638428, 0.6305833726621917, 1.0015410787006922, 0.7162323284102564, 0.8341604778833679, 0.3437688486313496, 0.9465614235079679, 0.8725035168295664, 0.5691975903508996, 0.35412264288821677, 0.9068790955328353, 0.6467768883272585, 0.7288475898569577, 0.08274572720226768, 0.8345650598939556, 0.1884685887033307, 0.3846360201396503},
    {0.8982767760246495, 0.6340006365297934, 0.6646784539624925, 0.7869447255128126, 1.0075063213257487, 0.8262022353840371, -0.08236617731660952, 0.206504704715562, 0.5633465066067145, 0.6106736948731416, 0.8331386310171668, 0.6500310104467822, 0.4410497837995459, -0.30460554513130944, 0.7822249314902888, -0.24354046632688892, 0.6508523138103092, 0.6746982807680497, 0.26637569774447784, 0.44428740262661043, 0.526055993316485, 0.6779290236471206, 0.7408063771644432, 0.9376764065751969, 0.6923868298881315, 0.7350825984034194, 0.7405186522911581, 0.6745277150769293, 0.23968810269746896, 0.9606009532721559, 0.1787125589148439, 1.0000679487130828},
    {0.8649437066110589, 0.8520077546333745, 0.7550459736430624, 0.8338908553390503, 0.9395622602682344, 0.7908210669936356, 0.16825327721417754, 0.13790029278938165, 0.9452983655754437, 0.9902080532917515, 0.9609942349138098, 1.0509099755544875, 0.41014325769023463, -0.2314710871051212, 0.8070266346542547, -0.06725578045173873, 0.5666357184079865, 0.6009115552139773, 0.6345514536003888, 0.7834021462176731, 0.8806702505365096, 0.9504537941629316, 0.6183917138538774, 1.0041576038704028, 0.9313843419244161, 0.8755220614736052, 0.9611132263784604, 0.9739768755416782, -0.09578385303782078, 0.8773318463959688, -0.2734454375586729, 1.0510644037415204},
    {0.8308489954330089, 0.8749320058874325, 0.614461895138605, 0.4305394379324307, 0.8508949333559529, 1.0407277067246656, 0.19439279282281485, 0.1764866686643889, 0.7367444271604783, 1.0187191562686566, 0.6892447318156898, 1.2345044997176995, 0.49400915719017485, 0.0986326017818439, 0.7213240567376764, 0.017975964711148068, 0.8323219165776813, 1.1202250962803522, 0.21066746104211725, 0.7819040004206259, 0.6085182947289776, 0.5969356099569066, 0.6774515458369493, 0.7806871339090972, 0.7717093852332313, 0.36516733493750947, 0.7857718495883698, 0.9565910719074604, -0.3078586213140194, 0.43421707184330716, -0.12181386872336698, 0.802904534150549},
    {0.7262962231734533, 0.8537984823607373, 0.4608814615107464, 0.5638366442841459, 0.6746443286908426, 0.7937436692876011, 0.09384632419025125, -0.058807822425583224, 0.769692782807854, 1.0085753256510064, 0.6547508793222996, 0.9570222929624391, 0.36649848406989044, -0.5376370342385418, 0.7260409623075784, 0.30877943755225495, 0.7944721941349231, 0.677353525458148, 0.5619001812183367, 0.4724362134821435, 0.7311321727619564, 0.8399167565443264, 0.5805337286644628, 0.6480551127610652, 1.0143520214801054, 0.6626416926791884, 0.8336751222732951, 0.8958302380223265, 0.023945850594113784, 0.6389678884903381, -0.017428187411357675, 0.8572605741500621},
    {0.9687278753647228, 0.8600183887918196, 1.1243044715188262, 0.8596821796658305, 0.7841897172881176, 0.5975394640598541, 0.036751347852080604, 0.10338600186971626, 1.1409214108015484, 0.8460834617978101, 1.1601769149051175, 1.0859867028935473, 0.3843725231456525, 0.05820400869614576, 0.9181102787154455, -0.05072743129842489, 0.7064316149036465, 1.0134070971829234, 0.7694908242250041, 0.7193830726911273, 0.7145095971619859, 1.0292160361304787, 0.6315627490566939, 0.8106687844945835, 1.1859218459108938, 0.8995906418582877, 0.7334196762880408, 0.8802090317187065, 0.056854959493368065, 0.8985820188213298, 0.05560365654237771, 1.065961869602379},
    {0.8462153126998924, 0.6306983855442237, 0.6830718895042237, 0.5620644824253322, 0.6187948753216201, 1.2211046545527913, 0.10546776019741104, -0.0928910624447354, 1.0096614636246406, 0.9491358862189514, 0.9048050812362689, 0.8985346960830691, 0.15314474045912518, 0.060552516618162106, 0.9017240759727578, 0.035326062641363495, 0.7765244822798354, 0.7043173984089457, 0.8286820855544653, 0.7865928922147528, 0.6066194801819725, 0.6328919286488695, 0.692831662737961, 1.020730253926404, 0.7588539152744946, 0.456796949498115, 0.9377551576234004, 0.5712543662034937, -0.14014463663337806, 0.7003460738374686, 0.1414947709110255, 0.7296832312378217},
    {0.7901249786757835, 0.8112686784247236, 0.9776352113529587, 0.5056644742550185, 0.9359954254597811, 0.8554478313443633, 0.07844673870820097, -0.31177969617963575, 0.7557196121188787, 0.773009336216367, 0.9930148491310431, 1.0262057923604901, 0.6091911937852064, -0.2291351614375534, 1.04257455464529, 0.02632861782720612, 0.8356600802325503, 0.9681595075197491, 0.8492669434710393, 1.1598698167267338, 0.8152624831627528, 0.951739354249503, 0.9653204580546764, 0.9147800776332561, 0.8593913129996034, 0.6935771250679603, 0.8520017588368005, 0.9367165941251665, -0.31052364618226286, 0.8962991697121862, 0.10386647998501386, 0.7069014194630774},
    {0.6710045693816706, 0.9674671957309684, 0.49064549492127424, 0.6383959425971357, 0.8192193877546146, 0.882199301322774, 0.23240266952956054, 0.05476593144230537, 0.8190711641341077, 0.9242118451318098, 0.6083341542407378, 1.0503368824543593, 0.49049451561103613, -0.0059453925303700654, 0.7958022561217043, -0.21035675446356547, 0.8843083137264096, 0.6672380352072901, 0.6916811971645579, 0.9102127552529846, 0.3970613311255759, 0.8296951188624144, 0.6471767698311518, 0.7103952115234843, 0.7538756581345876, 0.5070913551371471, 0.6566790600282614, 0.6215778219014374, -0.04678634373501085, 1.0860163837776144, -0.08682623761678626, 0.9005162493374773},
    {0.7741030391164785, 0.9424316023384587, 0.6649948564293624, 0.5454199836488145, 0.4727466344176324, 0.6263547340964242, 0.07489866564662301, 0.14892162782452256, 1.1745699628187303, 1.0302250831729254, 0.617025400324646, 0.7145123419491496, 0.5398171125402222, -0.005890502909215655, 0.8541732184955351, -0.03240974738172557, 0.5193245566921202, 0.7162747909522688, 0.6338499877442889, 0.7093611982931441, 0.6617719467892241, 0.24357427394377132, 0.9792892838381346, 0.7449712672570401, 0.6498821229065945, 0.49963360106040816, 0.8031027360082429, 0.8287851247648693, -0.2429539387158014, 0.7962865327939048, -0.0016492818869085846, 0.45213661592141874},
    {0.6624823916857171, 1.0844700521621198, 0.45234348693421844, 0.484465740578188, 0.6796327123280878, 0.607889469133972, 0.1030174825913893, -0.1252585668194804, 1.207852795525941, 0.8950314119402641, 0.5018171444052902, 1.0615023721657448, 0.19097388673540738, 0.14576095274967438, 0.5013621202594157, -0.09968949124682933, 0.7978808857216454, 0.8384999465148935, 0.4866982264900006, 0.3708747256565632, 0.5374963432320625, 1.1061407645784118, 0.7722759685727952, 0.765815111519134, 0.590682751578318, 0.4626316254386014, 1.0939621382529416, 0.7697008311326686, 0.2022492270602387, 0.8557724608789216, -0.044412374302874646, 0.9052968872766014},
    {1.1603341110727614, 1.1095836808140247, 1.093604658462347, 0.4820245957375219, 0.7594900258787858, 0.9359197700565622, -0.2694706220839592, -0.28631813516306703, 0.8656769808278657, 0.6471770471890776, 0.6132389387484732, 0.9101483138587722, 0.242363707662224, 0.023524251857241944, 1.1155853156053177, -0.020152582940180144, 0.848217039867599, 0.8150654930151636, 0.9168565190349002, 0.7140128675206828, 0.66930021642551, 1.0587823827268734, 0.7883642462263204, 0.5608298373991182, 0.35268845792449655, 0.6149485926919963, 0.824535324506098, 0.9131888232936227, 0.21993847005695305, 0.8079915794619936, 0.05774113873749848, 0.9070451609694951},
    {0.4883411963571737, 0.786323302891494, 0.678132488161916, 0.6128638910370245, 0.6629735017178903, 0.627853787076361, -0.1604227964185236, -0.33253416344842057, 0.6625042575549864, 1.270284335838231, 0.7165966187197089, 0.5817397331323444, 0.3462550430481836, -0.2643487504497988, 1.0879003697209617, -0.18192031025462513, 0.6575987794750401, 0.7717121674851423, 0.52983081621662, 0.7660249056981946, 0.5862770978064543, 0.9671037521077026, 0.6549586386938605, 0.7161245818596256, 0.8797555538477874, 0.7332412003573702, 0.8253823093944453, 0.8014939926077383, 0.01007873780707083, 1.1957030659431895, -0.03530360913333457, 0.7961923473242338},
    {0.7175550729476807, 0.9762725232537716, 0.84129581378342, 0.7913880931949496, 0.7394471244547757, 1.0746675402489907, -0.03294905869905374, -0.16965470282676126, 0.6324311508203665, 0.6175542289363283, 0.73613582786956, 0.6455173241169316, 0.1569912207107121, -0.013990991720576636, 0.6874739027511866, -0.4898314406722584, 0.5476555486842994, 0.8037084941254251, 0.4635290362884007, 0.7014077186629339, 0.7909735571858996, 0.9649923765552475, 0.6087518572749819, 0.8142198930013779, 0.7148570311751778, 0.3220727564671292, 0.5647096530026532, 0.5314039423243081, -0.09145543857507785, 0.6938400193840807, 0.07858942943748268, 0.5658223665875517},
    {0.9295133007105788, 0.7470596544800239, 0.761486869833696, 0.8108341359331322, 0.6185097158553439, 0.6836780554039648, -0.15763928590678447, 0.024252171780793395, 0.9133209229615954, 0.738359024659809, 0.8964809228441404, 0.9679152511904949, 0.24062119074843977, -0.23614224599737155, 0.8111412057159076, 0.05281438570236224, 0.767892140255692, 0.7760936752485574, 0.9141209532598402, 1.2477084852577602, 0.8287561760764356, 0.6609693138547853, 0.5926857897543479, 0.9232687948358748, 0.7830260516923956, 0.7009131857223867, 0.9663303042579237, 0.6215796449691678, 0.035711994490688515, 0.8742684858885883, 0.010742623588673736, 0.7208640797008615},
    {0.9483180802079245, 0.811077550413367, 1.0179909830605152, 0.46372161309342586, 0.8893503132383583, 0.8727727320507425, -0.25415534355312686, 0.26069875868458037, 1.039991138645805, 0.6226957513269444, 0.5670246371197544, 0.9154811520292263, 0.43770138069973064, -0.1877380545446026, 0.8041204341641749, -0.001823114255711093, 0.9250259492547528, 0.5626033734053129, 0.5799814747947256, 0.9334954668286349, 0.533515923106858, 0.9356608498369983, 0.9213289418627849, 0.8282094623310723, 0.58839296604086, 0.6813148975700202, 0.7711519254652028, 0.9196639106732718, 0.1232790025148818, 0.6979240608514857, 0.02121847135943245, 0.8716379029237434},
    {0.5967209765105288, 0.7678090683652552, 0.8026974325690458, 0.8720188070634245, 0.819522571427402, 0.36837118130889945, -0.10962257120880355, 0.32894364384540237, 0.6854743195458759, 0.42681202581989786, 0.8138050380174823, 0.777769687414003, 0.2061497692650267, 0.12006465996079267, 0.7930121322967476, 0.10286108127072496, 0.8209975428035118, 0.5424112827364426, 0.6906670125356678, 0.7302976324932784, 0.7651589934659886, 0.6947378706623152, 0.8337374053423495, 0.7119453361443028, 0.5024683834301629, 0.8937288240154854, 0.8887859821240811, 0.8200193906915404, -0.03630276199186596, 0.6528453953880867, -0.09115159758395404, 0.7076068223512644},
    {0.9093158191487386, 0.6354890673260063, 0.7423298183209708, 0.7242321419275598, 0.8892037566224795, 0.6581402584057685, -0.452827005294335, 0.03183277152066674, 0.7539002161266944, 0.7936130217117718, 0.6740537464371221, 0.8247250119346853, 0.20387722171266806, -0.10309268703718472, 0.8902408912243533, -0.01824210208669636, 0.6471063839048521, 0.8683237259971799, 0.6460562544048933, 0.3470349447179564, 0.5964376276231954, 0.4825664649608836, 0.5606618200478347, 0.6880866885894572, 0.7812360241414347, 0.949036877829002, 0.5916403476660953, 0.9688185388967604, 0.3478239704014292, 0.7146967629292464, -0.2817915300713608, 0.9219401109152701},
    {1.0763168242915244, 1.0463997458003307, 0.7946357582928492, 0.8033538170078078, 1.3644568456257906, 0.9112423309245044, -0.07924342862159334, -0.46844768652261326, 0.7038075460306416, 0.727519703263172, 0.8963570583653412, 1.179077605936605, 0.36068016379470524, -0.032819343801784334, 1.072026588558622, 0.03368792528588347, 1.1203806809625447, 0.9189263113890198, 0.8693233644535284, 0.7187885018081157, 0.7110501694246881, 0.8647322503633779, 0.7236471076551546, 0.8694219377315543, 0.6549691167548917, 0.6901280430028204, 0.7940706283456322, 0.5730487321216429, -0.13054884436740882, 1.0790200884214796, 0.01481946559920774, 1.0624480595590937},
    {0.8282372228821034, 0.8537512034407971, 0.5476597434870732, 0.7425069656055505, 0.5253850391286968, 0.9830989700314903, 0.11264001751162632, 0.0055576634179289345, 0.8487847849758913, 1.1052113621619668, 0.8081722463955094, 0.7673508795083055, 0.35791688542689465, 0.04265368018156351, 0.9163236018415436, -0.22740217545001, 0.889361666933983, 0.8774877995134504, 0.7571556438220556, 0.2591176918573317, 0.6382967922500687, 0.961853754014395, 0.827943167835293, 0.6430284496202194, 0.3681497339305381, 0.723090420538987, 1.0176971817483274, 0.7871414045862719, -0.08266857975739855, 0.8440628703667495, 0.09769595735813044, 1.0766778588014756},
    {1.0023383790622509, 1.0038182804269014, 0.9833189800254001, 0.7174213861452159, 1.2314270763849837, 0.8028950023739942, -0.109269976369412, -0.27821211105898347, 0.9456059450594161, 0.9372972930844505, 0.966919830293803, 0.9247628972107662, 0.48109509302508063, -0.1738035527756984, 0.7803006569151892, -0.02800765963731121, 0.6003577987989375, 0.6396248337433885, 0.6212981099482926, 0.961560005277849, 0.7238764417636443, 0.9147687978458444, 0.7196495075522907, 0.7044914547053535, 0.9129189401007215, 0.7171814724122103, 0.6423078555292157, 0.9033857735777399, 0.007296713647917695, 0.8983554299864178, -0.03433421117949029, 1.2052504619002877},
    {0.9192400773906161, 0.41805874743751115, 1.0500593564809453, 0.540555087821971, 0.6442875910592237, 0.7264493938182128, -0.009671932592939227, -0.15872312051177442, 0.9960869385990462, 1.2197922352249446, 0.6552071450229798, 0.968081040539764, 0.2605590139225066, 0.16419081289002435, 0.635969230579528, 0.014283393732454646, 0.9938512126740807, 0.789264280078488, 0.7314080994686284, 0.8123090883356272, 0.402641166192546, 1.2123669182928332, 0.646594225536375, 0.841739664012439, 0.7482961833454456, 0.6383245132053473, 0.9829102849476153, 0.7927474853791657, 0.18846335569496628, 0.6113183549349975, -0.44947845225964694, 0.7554288445167718},
    {0.6869416786333268, 0.6692498927346134, 0.641348939664882, 0.6048156394072934, 0.8583664894602175, 1.1501040859347453, 0.044620268136774076, -0.24953852273921398, 0.8644197438258128, 0.9236140618287159, 1.0318110227370418, 0.9212171819199909, 0.22379630076254625, -0.09331371670546416, 0.7419953419295636, -0.23451916497799094, 1.1298816790757245, 0.7598861998416758, 0.02577799289948289, 0.7476332044065049, 0.685017621560572, 0.9385942103116204, 0.9283610310227275, 0.7795674987628344, 0.5553379660441876, 0.5378756334209606, 0.6399424685426366, 0.6846397809608142, 0.07283894595651084, 0.6730253912815065, -0.06964973207624209, 0.6753181344987514},
    {1.1239066244933484, 0.5286586286566849, 1.063226910915674, 0.4468488345020605, 0.9734720889463294, 0.8669834630376504, 0.0625350185571143, -0.15338811054562682, 0.5775399297499147, 0.5390566556749941, 0.9512686031725951, 0.6814854783828855, 0.6537006713025915, 0.032518845852734866, 0.9617427359916711, 0.002777982203264925, 0.715210662846096, 1.0598015434913728, 0.6249572928254464, 0.9875950407996207, 1.0086924102958594, 0.8579099687469705, 0.8491236338958601, 0.9401840002085149, 0.7077946585754784, 0.6950758149306511, 0.6408451114192392, 0.9136195853401194, 0.11929235435410605, 1.082273214665395, 0.07173830813943248, 1.005972008462569},
    {1.1198722004973265, 0.6508416781232464, 0.7052826519366959, 0.6672810437496178, 0.7765666254419796, 0.965075008865863, -0.036790271270531194, 0.09314571579667112, 0.7866882884104454, 0.7603703506307076, 0.7870627011541029, 0.49817962529744736, 0.46348876231734754, 0.09411591491077281, 0.7922385583284838, 0.3445349519763768, 0.6701661213017887, 0.9317202273660172, 0.1265095593295525, 0.571895880195439, 0.2749409362169279, 0.856437759358583, 0.9216422667077354, 0.6694343424300286, 1.1149778647869777, 0.6329558105219028, 0.9319182162914598, 0.7803654794859755, -0.03045558356688364, 0.7274642685915, -0.0028484393749744806, 0.902903222321515},
    {0.524432645482945, 0.8203621462475877, 0.46586680556427407, 0.7130871588908424, 0.7133944036246734, 0.865259005207298, -0.16376089444069644, -0.2137490400967446, 0.882136397547915, 0.6034484606691782, 0.8680608842409782, 1.1682854722728317, 0.14949572348349474, -0.12767972519622714, 0.5095621327808614, -0.09866594908317697, 1.1661682115615901, 1.0400982665184522, 0.7545022087508187, 0.9067553471186285, 0.5829497071233661, 0.8289130631575407, 1.234072339985931, 0.7396802898278447, 0.6495398998804489, 0.743218117426204, 0.9941447192140447, 0.8815926564969505, -0.493020786888072, 0.809000088969444, -0.2566819117277307, 0.6727838531083286},
    {0.8602730043986336, 0.7553959821400881, 0.5516246024786443, 0.9774194902450158, 0.71660892308849, 1.1074582781050997, -0.18496603869817885, 0.08360907025638789, 1.2873462143464443, 0.7070158178147451, 0.5049025463454044, 0.7889690778168847, 0.13338842300298437, 0.020492492730064805, 1.1682148701545032, 0.21002133225859365, 0.8341399958481852, 0.5857822579947239, 0.5405885305900745, 1.032829292455854, 0.4403648918991724, 0.826153024430316, 0.7532171677190265, 0.9687842575205856, 0.8580319500082654, 0.7132778027822884, 0.5735370941332679, 0.8739571456337974, 0.19352716329809355, 0.800658531658207, -0.15885743324011342, 0.7651604897638621},
    {0.7068937286493145, 0.8956675008846208, 0.7694096779655206, 0.6826283917170075, 0.7664335593251044, 0.649088126611559, -0.2681587938799181, -0.10732930179479305, 1.111256566222263, 0.9695856213848603, 0.9224667221679504, 0.8957992802383321, 0.5570303960733194, 0.2103380703379553, 1.0322294462786121, -0.3452031695063979, 1.202116330842664, 0.9002330473361299, 0.6880216540041733, 1.1107913566243697, 0.9074215821228384, 0.7620886932607883, 1.055588375855037, 0.8509639139446478, 0.5707168678631139, 0.972449452579655, 0.8926779846588755, 0.6525292894345004, -0.14684852570176124, 1.1518891212844318, -0.28427039189136893, 1.2213813708890937},
    {0.55950816715855, 0.6057655027919564, 0.7958964895452277, 0.6929084776721275, 0.7199288758093422, 0.9039262451264753, -0.09961110613472093, -0.27608518201912247, 1.1343584500524713, 0.9085258166367299, 1.175597834408964, 1.070072236591029, 0.32601761112225336, -0.00906101488055701, 1.0043072294248185, 0.09210881388542745, 1.1073114573317218, 0.8956708939182967, 0.8376514015485211, 0.924750076138523, 0.9110139097346188, 0.7462882845002696, 1.0670742124032873, 0.7648325210861245, 0.9688084931851038, 0.6400832212159886, 0.9922823527927009, 0.838495437422317, 0.09078747840266944, 0.9465466993431361, -0.12044534330079668, 0.6923702011442636},
    {0.6136141420073037, 0.8527359145786794, 0.8644765054266429, 0.6828948445435294, 0.777255208424229, 0.38021926782346027, -0.18315414147406178, -0.07635582035337395, 0.8808086968604099, 0.675682508643713, 0.8698606187436405, 1.1126702710473935, 0.23684750118877895, -0.14916396713337432, 0.8453234563994475, 0.019874512340746622, 0.6972602991444323, 0.8108859600387096, 0.4981249585886846, 0.5450223088132234, 0.5600925145395294, 0.627747311981068, 0.9101309745759508, 0.45310719125048027, 0.6925495553808173, 0.5763260958969202, 0.7003469672774137, 0.8008815007628883, 0.13339990064020568, 0.9024203414544965, -0.3058109282931637, 0.5349537241704138},
    {0.5519199817552527, 0.9842869709347404, 0.8400573627674608, 0.6273031049728329, 0.36324813452141164, 0.7896962407391593, -0.25305202845935737, -0.34219712062084934, 0.8966095898050154, 0.89454785521618, 0.3260743253572857, 0.7269676204524195, 0.26478188698453026, -0.12653965478846038, 0.6791436407394956, 0.059043005855859, 1.0145264007391321, 0.7582971752859643, 0.5919794005591328, 0.7514537541531704, 0.5386278121981931, 0.8110127041919292, 0.8967627143436918, 0.9452088389175047, 0.8317972954898863, 0.6954538514278011, 0.4711801258854146, 0.815864620250108, -0.31986143528657707, 1.0051238350300324, -0.08776457829715108, 0.6475934347104112},
    {0.5130797697918038, 0.7778527515305067, 0.47105052863141345, 0.6837462787665842, 0.390592137856633, 0.8105233791029058, -0.0011304984918420454, 0.045931764634506274, 0.8577647202884765, 0.9585043003079042, 0.9752757240614999, 0.616687090879122, 0.5975399078504763, 0.1735991245742304, 0.6437577885758303, 0.14475587339425725, 0.9396251669433314, 0.8405759766443198, 0.3918478759250275, 0.6484201245801231, 0.4901693724428004, 0.7814213917118317, 0.6786521445671224, 0.7410471260321577, 0.6371290800215821, 0.8787824307055853, 0.49799507500496115, 0.7649681818069339, -0.3560170329411587, 0.8301249957200612, 0.17667458946260603, 0.9471773591705687},
    {0.4958599860139982, 1.0349487844313892, 0.801418519051397, 0.8947680431488424, 0.9417609337347024, 1.2048194392624367, -0.18731113949923683, -0.006561656465403685, 1.0427686188347172, 0.9509441913071072, 1.012440006767141, 1.1113242078882315, 0.39278684528415914, -0.26628701453310805, 1.0658533187528574, -0.3255523242218501, 1.1440389799028126, 0.8569430721053122, 0.8546601555227937, 0.8219044567460049, 0.4254498624076471, 0.7155561781726731, 0.9201370661169661, 0.7856453505428019, 0.9984403723604272, 0.7024749117504426, 0.99238631873803, 0.6971963121881576, -0.13063564986277848, 0.6655824596956786, -0.24696392060979244, 0.7410252289086237},
    {0.934521068725124, 0.957759446683634, 0.7905743403990492, 0.5197032734642172, 0.8141501046521147, 1.132608254344799, 0.09381832727829453, -0.31211676105285635, 0.7989745418601035, 1.0206995744945722, 0.44782871103451105, 0.6964127805384636, 0.2697301273347203, -0.17131766955887168, 0.71939560357487, -0.05760384216742739, 0.7830718310622818, 0.9353258738497433, 0.22997080050404006, 0.9755845430741341, 0.49105163763893606, 0.7938425502516832, 1.0745772653997874, 1.107387515919541, 0.6491314311950686, 0.6433663431160122, 0.7763316464094506, 0.6540169249477438, -0.2153316306254796, 1.1586962178195261, -0.04407633765416805, 1.1085625630118896},
    {0.641504916895346, 0.3706316784301232, 0.578617368524124, 0.6178930145701028, 0.9044576643680411, 0.5122890131796536, -0.0621933002956113, 0.05706853595528809, 1.0768798812736744, 0.43574107223003183, 0.8664310669331905, 0.909987168988716, 0.26152229486289597, -0.03891938758322031, 0.936076489594126, 0.04062276032048159, 0.7830290017382932, 0.8068300901459745, 0.5094196399648858, 0.747782886380565, 0.6650643655310812, 0.4564579770391635, 0.645239652359885, 0.9778391965750057, 0.6615696787926878, 0.44866405507009444, 0.7265269548285853, 0.9958671857691195, -0.17831815192480355, 0.44970019443466597, -0.06716693522044276, 0.738649903319565},
    {0.8023516785303247, 0.9355020301076529, 0.6029141430430304, 0.49606563941205983, 0.5657572371078264, 0.981423873399757, 0.005236852789588246, 0.29777812769385964, 0.7294686132860624, 0.8513381792880846, 0.5293137795535043, 0.7820239686632068, 0.4890418804328582, 0.19198765125728937, 0.737477275540214, 0.21537657347197398, 0.8657175078190599, 0.8576958270607772, 0.40773263864597853, 0.6484716467060299, 0.6029418513937551, 0.9091602261928167, 0.8794559384024984, 0.5041419595590056, 0.6510991921422324, 0.6011911124777756, 0.7815914448986591, 0.6232740064930367, -0.05836338387567412, 0.6228321345227619, 0.3869245184450142, 0.8864791610062671},
    {0.7681533653707023, 1.1454311784580413, 0.9305519998763018, 0.5679807204466494, 0.7109893842198559, 0.7181908341627291, 0.23588824183759186, -0.06650142647861568, 0.7384484940964662, 0.9619804903887449, 0.7078407567045563, 0.9670037665426539, 0.4004534266695207, -0.012731634431622145, 0.7756341607065084, -0.1888208171553001, 0.584938683925744, 0.8501606007411361, 0.728121032355925, 1.0934852037436107, 0.39303634250078967, 0.95866759699137, 0.6651429737313193, 0.9828683369011131, 0.8055285569748867, 0.7447760580348527, 0.8239785182168907, 0.9083809208629765, -0.017030569400487073, 0.6562458386771219, -0.3353073309699831, 0.41806692598350337},
    {0.7766031432028397, 0.5189072409143719, 0.8300074791697679, 0.5990070027954014, 0.7048562579302146, 0.9043226550783527, 0.09505565233504157, -0.2806589716680385, 0.8060359503791673, 0.925241848086276, 0.9624734153258224, 0.7406710004762546, 0.34874727630813646, 0.09417428528871756, 0.650016221990714, -0.14862463909908513, 0.7158344162861814, 1.278291888130339, 0.5679402656547988, 0.59549710429254, 0.762273852309731, 0.9751328740213423, 0.6806212319003246, 0.6434242110201469, 0.7299834796439911, 0.7343453090920415, 0.7873799542983992, 0.6577042100577261, -0.07537571071106412, 0.8762551325410204, -0.1403427758946464, 0.719725206004288},
    {1.0286676789193452, 0.5902710455231852, 0.754510975063859, 0.3889875736666629, 0.5911368663549902, 0.535152041807227, -0.2133723165891262, 0.1743090979338573, 0.7944912599982963, 1.0471950120840614, 0.7774948154749979, 0.6383522519933118, 0.36995310484927235, -0.20997159502261228, 0.6516921285109195, 0.11038804080723688, 1.0424927334545098, 0.9595863072997849, 0.2568261981939011, 0.6932457860170925, 0.6149320231849701, 0.5474053571894834, 0.5463621190870351, 1.0061931781995839, 0.675897943929997, 0.6370549031373297, 0.8519907111034147, 1.036823232767916, -0.2201751349033434, 0.7340021528760956, 0.04769457352029243, 0.8465840035688208},
    {0.6266904970313335, 0.7046384408510283, 0.5519395940978022, 0.426291122096151, 0.6482588681341646, 0.9567328327751324, -0.18828515502743629, -0.1439754640557738, 0.9396347010198381, 0.9716881644160311, 0.7061317943932911, 0.8186921953532971, 0.19133959170402476, -0.05523722119638538, 1.0682514413900979, -0.0852727871291538, 0.8331363392637877, 0.7149826615909913, 0.586823457860336, 0.7342102577392432, 0.8277377792855446, 0.9849625391811709, 0.4923256412890564, 0.8040582938775538, 0.788033506361336, 0.5809898006610049, 0.1708833636843267, 0.6164370538613222, 0.05739415295441822, 0.8707747161340442, -0.16952856249488277, 1.0228911168491819},
    {0.8939651047983147, 0.8992827572778201, 0.7854358970727007, 0.3257736879003794, 0.7104074832207864, 0.6295406687485986, -0.4484157727355637, -0.010841246340277055, 0.9095525044785303, 0.8813397692947196, 0.8596667562998198, 0.6356194781089699, 0.3400656741888378, 0.105790119993451, 0.7547714742872889, -0.1082208682946507, 1.0910268592194892, 0.6686517395814902, 0.4822249964145539, 0.6121569641801643, 0.5827998418429534, 0.8385364102907887, 0.7368194939016434, 0.6129168631754974, 0.8358510676651765, 0.6365415771147672, 0.8032219730744051, 0.8688500178479821, -0.0840807734361929, 0.8219075251950002, -0.0856091101625903, 0.39758288130213515},
    {1.126786136966901, 1.1202855416276791, 0.8149738547292075, 0.6166442217890482, 0.9027224564350593, 0.8494974918901153, -0.18289468038608458, -0.3816180425582426, 1.4358215718035037, 1.0416442625316322, 1.0669808655041286, 1.218701434387524, 0.7409837702797142, -0.03859772195318985, 0.8971726003465409, -0.33432223863680494, 0.8913924187091757, 0.8223692006940185, 0.7053571331233393, 1.0650413309727644, 0.665991692040653, 0.8096447682762906, 0.8533751420886633, 0.9806165688101475, 0.8453691224685201, 0.6874088500518862, 1.0992813522625227, 1.160681013556757, -0.14182276581968115, 0.8359249658728463, 0.22972850947669435, 0.58587315844519},
    {1.0058401136946893, 0.8750432562838076, 0.875138005013246, 0.8336777412573599, 1.1864289308801308, 0.5109173107026074, -0.13505159455288282, 0.34267077304418164, 0.631575098032049, 0.8424897242117472, 0.38031785907661986, 0.4281536030906539, 0.6374840852159839, -0.277710388871132, 0.6963836206822265, -0.11328101897058201, 0.7063127080160482, 1.094000057323991, 0.5100425725217638, 0.7010105428626384, 0.4281608338091647, 0.864499187251222, 1.168649510549055, 0.967220430103302, 0.9526163503797391, 0.770847782242256, 0.9442392425515712, 0.7174318154824327, -0.011744140539277751, 0.6050823458094149, -0.2694396385981793, 0.638224131790561},
    {0.7161318142218932, 0.6830549563963506, 0.8983235305865493, 0.4088553060305569, 0.5700896672025532, 0.8417348409714799, -0.02460069667326842, 0.036227942705755564, 0.7289342622667805, 0.708877823711536, 0.45200047105272884, 0.971309815373477, 0.38120758526433346, -0.0026882989254783337, 0.7791570948375484, -0.030252859396513617, 0.7593984655910547, 0.5630792295373168, 0.7623484657253838, 0.6587068541370857, 0.8413646752102016, 0.7775459526160997, 0.6217255136589435, 1.0757034638467085, 0.718919870662512, 1.0192052601816521, 0.5670766900298994, 0.7817637831187195, -0.2741896063127797, 0.7353515364626471, -0.033999592780482465, 0.5609167024200177},
    {0.8361432247645599, 0.8821481771497716, 0.6399853165815325, 0.8122848517292613, 1.0457176506737913, 0.8166693107086267, 0.013463051527064701, -0.1700902939938973, 0.6620227009860089, 0.8532027303789864, 0.9334437850338552, 0.8866038336999174, 0.25054073485281564, -0.4092883976372407, 0.6637300984482124, 0.06726167884452355, 1.0856734745442775, 0.726891673964264, 1.063078066694392, 0.8180443641543304, 0.9401846349017317, 1.1129270019694484, 1.0699872778883268, 1.1295046410879799, 0.49900503073751645, 0.8251047059013603, 0.9678864005433158, 0.56447115521305, -0.36340901681671667, 0.9666981336030945, -0.23652416388275502, 1.0809625156430624},
    {0.8928398903263955, 0.8710814464962899, 0.503567175733493, 0.4219262292953483, 0.49664030512612406, 0.7595510608824197, -0.07660002013452301, 0.07518984299855506, 0.5755298569447529, 0.6342063906624725, 0.7212115349573981, 0.8490427971266821, 0.7047369384142935, 0.15493863724929133, 0.9760061657949592, 0.19059804229906607, 0.6791587787266464, 1.0506505422690908, 0.7029484270233872, 0.8897545566216515, 0.3805844117492337, 0.9121529859232137, 0.7041623735489718, 0.7119524345202186, 0.910528628903037, 1.013482752528783, 0.7782224332063353, 0.8990850894614083, 0.24478171350801384, 0.9845738228404559, 0.013597103663679212, 0.9820023699752011},
    {0.9050701352028142, 0.9230038064049287, 0.5966991553154749, 0.3410798865667782, 0.8525394898976307, 1.1099571444152538, -0.1863433283688572, -0.17397493466676145, 0.7591116781547086, 0.8372344600884896, 0.8186785502879, 0.6593074063669137, 0.2331481727085789, 0.09183828196913522, 0.826898397350845, -0.2517615750056636, 0.7908998590966043, 0.7439561368755019, 0.8178297204509769, 0.6030803253138094, 0.5500292901166006, 0.7740870040733601, 0.6897097085913821, 0.9825912511121963, 0.6874699820216635, 0.6386515171069768, 0.64395406631381, 0.9105324914267497, 0.05435640066312492, 1.0794584785679533, 0.032242811663651026, 0.6261236980400654},
    {0.9128789592042227, 1.2050012675404258, 0.7658879462262104, 0.6109795095141568, 0.6932419282109861, 0.6827256211645946, -0.14809151217766947, -0.06334950487393383, 1.0070661524571198, 0.8203732858744311, 0.88100267132416, 1.0046626669196597, 0.36960064229939554, 0.2139997394819968, 1.0138596693133328, -0.027538791060322008, 0.7903354580977735, 0.9630167779227419, 0.5401204659278627, 1.1627271699243191, 0.6772791356350809, 1.1257070727718606, 0.5490088265090821, 0.9960758658377842, 0.5938312808516677, 0.7536070820720896, 0.6212459204500618, 0.9467459368464305, 0.21921754576689112, 0.9088641113285314, -0.12419964429115322, 0.8559018352372247},
    {1.139073267937936, 0.7758150220032662, 0.9522114762160816, 0.6337438596580184, 0.5596530080626608, 0.9428585392225318, -0.13194636557750083, -0.11025028900966355, 1.396555835727408, 1.1919114057123341, 1.3038997033484312, 1.0205167338169117, 0.4998985802892334, 0.13672264543263, 0.7374229755766019, -0.08457493402544838, 1.0381170022623616, 1.164346868553672, 0.8094573101051153, 0.4878268585877051, 1.0508407736245406, 0.9926681047638978, 0.8954104252800881, 1.110905530963527, 0.8996877927136073, 1.1638277813943618, 1.093076464508974, 0.9457718237614269, 0.022201923202583695, 0.9059503506217399, -0.0533800251713858, 0.6773862514195832},
    {1.1341447598397167, 0.881712696234842, 1.1635516852720067, 0.9826424416109434, 1.1791060375815015, 0.8823328069488479, -0.45238505130697, 0.26511057108349273, 1.209347473397818, 0.8171701508152521, 1.178919089905929, 1.0025094215443817, 0.6615197588013607, -0.23285128931484836, 0.8982934347912043, 0.05235338500724277, 1.0804964019386523, 1.0233105307218948, 0.972268257942902, 0.7612157366838879, 0.6772061910877715, 0.890912704783892, 0.7257129227635547, 0.8979580544356006, 0.7102409829113971, 1.0241499370067784, 0.9219141598605509, 1.0988453503360154, 0.03745957965171401, 0.7738402979048437, -0.16469703805148675, 1.0633492473313666},
    {0.5716853307603498, 0.49135803131848843, 0.8208017081137068, 0.6323387490233536, 0.6847994651556412, 0.6683873038549037, -0.4092250429329162, 0.2606633948410601, 1.0225697678395722, 0.6858308929271077, 0.565465089691315, 1.0100420787173832, 0.2444388057705528, -0.1630558267908904, 1.109404838266441, 0.04429817950375628, 1.0878581624500103, 0.509980829982449, 0.5413793179261553, 1.1158768283889613, 0.6002659629253805, 0.8108588132023021, 0.8102537674308072, 0.8552545519672556, 0.3634350750740164, 0.7062907914862501, 0.8855594549596614, 0.8480552140519332, -0.02902603122514923, 0.8462176392414424, -0.028787904626862246, 0.9430831703644259},
    {0.9360564789701008, 0.8193830367167442, 0.971032983968489, 0.8616068168346807, 0.7518707940306919, 0.9211698469932701, 0.2700314139439594, -0.12284627261110781, 0.9677823814632692, 0.9085808774725606, 0.9545174129429903, 0.8672944616570949, 0.34699749873256724, -0.390724689473673, 0.9521006335620928, -0.2057085235101533, 0.9573086366375732, 0.6245749239604586, 0.4570967410453023, 0.9131167190921298, 0.6261365128870046, 0.6222403840201655, 0.6029776783854087, 0.7413602793746571, 0.6248502519162905, 1.0374184953985834, 0.8809106988778731, 0.9544308582724786, -0.2651984563613582, 0.6847288392237493, -0.2952454289771362, 0.7714562735765008},
    {1.0184946096509178, 0.9904438112698856, 1.0231686290242852, 0.6863068039517927, 0.5685578597743443, 0.7353964551772616, 0.050411796895429774, 0.08924733634523577, 0.7915388365226176, 0.639367949691191, 0.83737355150399, 0.9282879713371068, 0.7358115942247672, 0.006767327117477427, 1.143102411488951, -0.09671659836931813, 0.8621994974370849, 0.9433982720653511, 0.816807275865358, 0.6589379350619636, 0.7892727230286436, 0.5416081859065321, 0.7657563312693397, 1.0289195555089181, 1.0250305013798666, 0.44133089828879946, 0.5899773508744521, 0.5055509494499961, -0.07257813426816746, 0.6501780359270121, -0.27278132100716157, 0.8104731951779051},
    {0.7181124268344939, 0.9742230604392627, 0.47518524548648317, 0.239503394052266, 0.822589309897615, 0.6941055618977786, -0.15295327808025308, -0.0921707154778793, 0.6227338814776047, 0.8312836626636703, 0.6150446450301127, 0.9399131201132819, 0.4296234594780661, -0.28525839740753794, 1.0039871114293413, -0.012909923343291687, 0.7952234400731701, 0.9588674986925159, 0.5888429078976835, 0.4359942984209785, 0.688541300310069, 0.6901597770334352, 0.4855520188106459, 0.8708405484226511, 0.7021055911976283, 0.3703820537904134, 0.7515957136341814, 0.8057725471614552, 0.04142393034489005, 0.9424503488301855, 0.06819766131164132, 0.45470690905122496},
    {0.9328470097373495, 0.8606571292037086, 0.6400690830497789, 0.6578301020800912, 0.7677284166414268, 1.102580222014849, 0.22982042226074778, 0.02002661656402651, 0.8446073875230753, 0.6302177042490774, 0.6822034117843038, 1.053844266718472, 0.48767125335631745, -0.327786037253256, 0.616584324773248, -0.20818541700783222, 1.059871329863218, 0.735417757034189, 0.24515351869058236, 0.9746082468907842, 0.531081386620369, 0.665637210514944, 1.0721395119259365, 0.8544764262478513, 0.5410709764917279, 0.5077174019131355, 0.735043481893779, 0.8766084347918098, -0.1632592078131344, 0.8882497988306933, -0.07240876544142814, 0.926941338418591}
};

static const float b2[32] = {0.804928822873265, 0.8150478160758949, 0.7962091091721529, 0.7357332833639878, 0.7565441440737108, 0.7446728294039062, -0.07753779002584096, -0.0574272477105983, 0.8371893110527271, 0.7688360560868707, 0.7457718245574514, 0.824872691224363, 0.45819380181485064, -0.03285302996930632, 0.8149124180066271, -0.05599434147392645, 0.8002925958215369, 0.8238895641000816, 0.7439044639411779, 0.7549462683059422, 0.7605897557740566, 0.8269300744868634, 0.7991525398484681, 0.8404668936829827, 0.7596953167446702, 0.8324120885123786, 0.8064498435068828, 0.8150234426297428, -0.06569345378540424, 0.742476656186363, -0.053876599328560114, 0.7988346372935963};

static const float w3[32][16] = {
    {0.13886461855596463, 0.9981579061289458, 0.5660550874878898, 0.6393038660866854, 1.3202218057669612, 1.0022859776990876, 0.13253872897338811, -0.07234924456648309, 0.22555081949354405, -0.21387355181898574, 1.040168554609786, 0.6918819869200309, -0.25360149536111853, 1.0930502842332148, 0.03807644488588003, 0.021011751448207622},
    {-0.1955725507473212, 0.6908972317940452, 0.9365805146514494, 0.8933196447684497, 0.9969906979183966, 0.6232685038133627, -0.1444158663798104, -0.1961307305478649, -0.26218769039246737, -0.35124940051407716, 0.6584523833636481, 0.7730932950925594, -0.23467706456536713, 0.6547011638862328, 0.1279625629683988, -0.46212132053475186},
    {-0.6299083351609097, 0.8080358293188067, 0.9427353544526383, 1.0569021333943684, 1.3788471622051441, 1.1251035545761994, -0.006459304514605348, 0.245028396588697, -0.15946317197880877, -0.10385385892519135, 0.575414583628831, 1.3362685844689082, -0.41333198269928423, 0.5243450575008782, -0.4313174452083441, -0.17375254253325545},
    {-0.2540139322729798, 0.9470055313354532, 0.9324689404925369, 1.028641382891534, 0.44162504308485434, 0.4755530387791973, -0.16735718080975942, 0.29471862849489716, 0.290748821263888, -0.3236084841893366, 0.7325249191604533, 1.1531599151989482, -0.638471322711032, 0.863850581974516, -0.027018865532856273, -0.2995321444218765},
    {-0.13404301061975923, 0.8276759771702072, 1.227683820146272, 0.615792363332393, 0.8804238467311032, 0.8765614170203297, -0.22550511587836256, 0.4287267984980269, 0.24953742054336253, 0.24157118232202052, 0.6418163645175492, 1.0283101311110523, -0.07738824812011796, 0.7956330624695548, 0.2789060692193355, 0.177666159819649},
    {-0.21207399807417565, 0.7847070849090202, 1.188479232279358, 1.2892738188467472, 1.3022669395187874, 0.2678136063882762, -0.002981058447566806, -0.1821720942299734, -0.32770941086898897, -0.17762249463976695, 0.6002585807241485, 1.1358273350853343, 0.21230029979213907, 0.8802331744648976, -0.21161119777213677, 0.16904958173591392},
    {-0.07732125141538831, -0.1548980450972091, 0.3098639633276341, -0.07961064042819921, -0.3538100055172577, 0.11019817442047986, 0.2715715278994669, 0.2982528465927599, -0.3614919240798537, -0.14587602450560336, 0.15974469454413542, -0.02839985820085402, -0.2387074337238264, -0.031089639388275667, -0.06387158188757612, 0.12605010083618962},
    {0.20571635996781235, 0.03556511640236811, -0.06479305839298218, 0.22341514720260466, -0.10354504632718933, -0.2325401415195333, 0.16801674200158415, -0.201425605662844, -0.11797946669656557, -0.2302204852775414, 0.06318664171173059, 0.020993118177251913, -0.12851095312472738, 0.02743411575514663, 0.2356165627200095, 0.13896253424200974},
    {0.07886500199954638, 1.2201840640386068, 0.9754860937410632, 0.6894876942581719, 0.9369804864189165, 0.812500755599296, 0.07219441703971119, -0.3133500061167417, -0.02390029339172662, 0.0012772392177496476, 0.751585728978677, 1.032166903478674, -0.23592062609265627, 0.9006121133752509, -0.08781277630127542, -0.11993516821588569},
    {-0.0027108120025102116, 0.5787485821607615, 0.8565576869162483, 0.951881618926975, 1.182917160475351, 0.3022521267525886, -0.01274805476249521, 0.2344132465085408, 0.02304510617180044, -0.1980226641627289, 0.7966716754379987, 1.0971600077712689, -0.047960827294418425, 1.0841336631718272, -0.1648047298062402, -0.022766381791968687},
    {-0.19227698723510483, 0.9967342145358151, 1.2058373540394052, 1.292441719058332, 0.7229203165924821, 0.648677311024316, -0.023957336169116442, 0.4738534017469499, -0.5874427330966266, 0.2405565465988693, 0.8248869253386714, 0.8046215640656345, -0.16832170878948616, 0.6472060800199124, 0.053044957300439906, -0.044215196555059386},
    {-0.32407894230986234, 0.689984233688178, 1.1724654381261672, 1.1698159137796553, 0.8947947619974934, 0.9928075711851775, -0.07233881875810211, -0.3708789188834726, -0.0438068661308264, -0.09697141529079271, 0.8415281562565656, 1.0448088888941365, 0.3805203875209921, 0.7751582001497122, -0.15242964048386592, 0.12338020246141904},
    {0.007879988158712018, 0.6293906200876451, 0.6152476798877048, 0.7667525532613662, 0.7913178546455255, 0.7410831928257956, 0.3826238419012662, -0.26349368502101306, 0.3025425233803458, 0.20250970400790935, 0.038290377837024485, 0.3607653427706045, 0.17101658499527705, 1.0837012571295335, -0.040829390366466885, 0.6285844780291099},
    {-0.1848852153169311, 0.20022337099954732, 0.3561304742718574, 0.07506230047176572, -0.4063801147438748, -0.402457636669915, 0.25608445677639485, -0.09446756691858063, 0.18078305528988217, -0.06536267633432023, 0.07116527065317897, -0.41137992257266587, -0.039119648987670425, -0.10063647519958285, 0.07379825690228285, 0.1909329708393208},
    {0.2655359623622765, 1.0981210110672204, 0.9414143748252732, 1.336899322599368, 1.0459651686184426, 1.1051020495804944, -0.4054177022417443, -0.4289177645477355, -0.16211191971861877, 0.007575723428316002, 0.8928445068381575, 0.28729246053101803, -0.5616324996085365, 0.4691247536581418, -0.09660174173634983, -0.1857575981058524},
    {-0.5280087038413719, 0.24706876469247274, -0.027651851918337217, -0.03658657770858444, -0.28018334236582926, -0.563227527021904, -0.3716143398821262, -0.05420097263471236, 0.018311044822928627, 0.31753741242541994, -0.10428250650091583, -0.18486791240511877, -0.3119584163644943, 0.07707007416775426, -0.2880826485467569, -0.42297595120442566},
    {-0.24600401721723475, 0.8982277565123274, 1.3738011402786796, 0.9821018325443583, 0.8011358165046085, 0.542230070351181, -0.35193876419905273, -0.1255659284547085, 0.0632975467314682, -0.04190805133528112, 0.6244480727018048, 0.753927544283092, -0.12119062098905985, 0.6392134549273368, 0.1414907640739924, -0.24137567717158398},
    {-0.0060112972475345125, 1.1806568278817893, 1.1917127463067323, 0.671555923246935, 1.2522542769049123, 0.8623312854802045, -0.03987875881690894, 0.00866608006998047, 0.09548001089612654, -0.12309162684288699, 0.5594349182487129, 0.934232296830565, -0.1720694426512559, 0.8456289184717811, -0.0995111685847427, -0.22167374143249793},
    {0.03509197760664547, 0.8459181010371444, 0.9336225813422603, 0.5944504561097528, 1.031370564761356, 0.9761376141018134, 0.05697075313076996, -0.19269958389186367, -0.15239113772710275, 0.03686944107091197, 0.799586262247219, 0.5925284522173384, -0.07110810616664918, 1.0898734993395862, -0.2262051506058921, 0.22702164563012306},
    {0.11542116282837345, 0.849700567567, 1.14895608813969, 1.3301370415407592, 0.7456069672364849, 0.7479656027945392, 0.2165316640990797, 0.1655345938551034, -0.2541563054785645, -0.05127470000003506, 1.2895742579085605, 0.4644112753224112, -0.004400140148799858, 0.7077841877842167, -0.32298856835118894, 0.22613549875505548},
    {-0.11488485347937337, 0.851756532486374, 0.5253045162740325, 0.7035043747627089, 0.5418139583465328, 1.112754494824829, -0.39685496175849566, -0.03163333101477956, -0.0664859592367843, -0.32542493101136394, 0.6463817930945568, 1.0908537462740597, 0.050661980883424315, 0.9887264142945068, -0.13322746480915085, 0.07521397889153092},
    {-0.07188800596424622, 0.8177595642004459, 0.6957991495507382, 1.300960199245593, 0.9314647958884419, 0.5540785887662519, -0.0111004392310369, -0.2340089527014243, 0.33716942318366916, 0.19214191675570302, 0.659063658431957, 0.8953905051204379, 0.11449562866107876, 0.7796252411841457, -0.047848638559243074, 0.004142352262757058},
    {-0.03081718364899786, 1.1948957845263306, 0.7459045909518053, 0.8029597404501084, 1.6359906769225818, 0.6329339390426236, 0.45603276477713517, -0.06924799450464397, 0.10056025383063191, -0.3097089606107858, 0.5267903538256619, 0.5662876574109114, -0.14931599589720504, 0.8055444779338111, -0.1766210739391623, 0.010635719035229373},
    {-0.22584856623841354, 0.5442241539533366, 0.9420570126523465, 1.0617869856775777, 1.1667206751541066, 1.0420084771788207, -0.07346016551638233, -0.3434593393723125, -0.4391874512807842, -0.046157499303021335, 0.6793726810642403, 0.8713575826236716, 0.03503005001304341, 0.8035687587365015, -0.3053425628418134, 0.1956436626928833},
    {-0.04539629354113182, 1.7153610714920182, 1.0171270610219978, 0.6049576357322953, 0.7006206200958661, 0.9787700225111696, 0.0617861424299031, 0.1399069667731632, 0.18055498843205658, 0.1389324659234289, 0.6665844268291359, 0.6752405701288788, -0.12134278600567965, 0.14024639956405258, -0.18827506667612265, 0.24570914802204596},
    {-0.13026480385864994, 0.8345074994973017, 0.10717456044749753, 0.8722490721756077, 0.841889864490114, 0.9723775209475658, -0.3610742743376921, -0.06112676867705406, -0.533638271741866, -0.3856160901155043, 0.834032124583618, 1.061431438832918, 0.02928272910285205, 0.9546014280887464, 0.07370680362040492, 0.1191585870671454},
    {0.34286022232793373, 0.9747587958712376, 0.5990735364063862, 1.1848235263147808, 0.9749929820751946, 0.9232746219122091, 0.10908689856697068, 0.15852388683993068, -0.06170021832855189, 0.051573230652000604, 0.5228310286324162, 0.5304466746622076, -0.060429297770695, 1.0815447502765798, -0.14712946912334798, -0.07541380503126262},
    {-0.18922097259417747, 0.8850684297075181, 0.659440114321451, 0.8998141862295276, 1.1494604524833343, 0.9050031147492665, -0.3874915409496286, -0.15992689802099289, -0.036746031370149805, 0.0139708097279725, 1.0104274147375425, 0.7967126022499503, -0.08692463353529112, 0.7008955013641839, 0.30814070962381174, -0.19484015987822437},
    {-0.2824931112540134, -0.010284231670959503, -0.058523115537240364, 0.04731484972457096, 0.12447003057740061, -0.09006532100622315, 0.12332557805203466, -0.1344232354837495, 0.33173992939232044, 0.33814118510931207, 0.03960435629373743, -0.5578040684136949, 0.28789199115976016, 0.1922482854708197, 0.09321841529499943, -0.010608356770490922},
    {0.42357233671785577, 0.738226060367322, 1.0649046177788868, 1.2744520795099954, 0.9028302040219702, 0.5324727019787959, -0.1514141799047893, 0.20764757037958073, -0.21407836654391113, 0.41647668431001755, 1.2908761531270971, 0.5070763710019168, -0.26735672326484805, 0.8224891712639274, 0.07887616692485427, -0.003116785695378468},
    {-0.07937483885896468, -0.041159947998527305, 0.20599127936560582, 0.046230992099391376, -0.5218598182357257, -0.03765857687891417, 0.07476903971811752, 0.2754563260174251, 0.07735760363685586, -0.016803231170567676, 0.05046659791831074, 0.4505138423108906, 0.3931865784383819, 0.044840119628877746, 0.08564900714109826, -0.3381048109137799},
    {0.07242560273752595, 0.829708390937341, 0.566251145695727, 0.9977167257261471, 1.3215019192757511, 1.0664828946449567, 0.2036173739989113, 0.007093344162581471, 0.03919090982838836, -0.3075551268614401, 1.005018513217001, 0.8268978917043386, -0.07750477878065778, 1.2216612078799496, -0.35294773343350866, -0.10312817112953786}
};

static const float b3[16] = {0.03200787496627471, 0.5780753637551783, 0.5989801390973344, 0.5435703575988671, 0.5077490066014009, 0.697488158191573, -0.025882497536900865, 0.008248997710814901, -0.013336684278031677, -0.012176081265264878, 0.5349781467825213, 0.5856270795548234, -0.01613549403022654, 0.5317343303464003, -0.015080901287812204, -0.0282063744379147};

static const float w4[16][12] = {
    {0.38270948209062544, 0.15538605576488573, -0.5624780991580771, -0.26930751401755054, -0.38514090064021045, -0.3582061341302386, -0.044040674420779496, -0.09821219474164555, -0.05509090400724423, 0.033929446271200085, 0.4305174220851404, -0.3065526964210581},
    {-0.3718701816430692, -0.2173378821021707, -0.3869203038801652, -0.8036637825893562, -0.7084372695944738, -0.9872249366323123, -0.25438525396383244, -0.36859261566143536, -0.7511899493683007, -0.8063127671989239, -1.1214192235296634, -0.5120166908799031},
    {-1.165106162312863, -0.4127895115655901, -1.0853515711500108, -0.5249279055933909, -0.6514596389569864, -0.47128118863507734, -0.8160267569691589, -0.8378118249131276, -0.44141874945291865, -0.873509573613828, -0.7511177034626776, -0.5541762866077065},
    {-0.8435029992953952, -0.5086929103992099, -0.4606364830698068, -0.6040734312558115, -0.3826769661237277, -0.725566055902635, -0.6235101820752547, -0.895406119624935, -0.591392801217001, -0.8064291599306692, -0.14176529853616385, -0.3657455410065737},
    {-1.1137831511381926, -1.1708361789444328, -0.5512904011666169, -0.720291254493193, -0.9738410914400115, -0.6385414723845177, -1.190329265887693, -0.4576479078995148, -0.8341350637452848, -0.9587279425519806, -1.1760305239651194, -0.9832437626441675},
    {-0.29370196664015014, -0.7605825579736132, -1.1958711025143667, -1.0034650035461181, -0.8495730822446425, -1.0429717922051922, -0.8084369752670021, -0.1483448639950367, -0.5400111307068535, -0.6930665437875386, -0.40263446311994683, -1.0494760993429046},
    {0.09299648528390134, 0.3242709690993481, -0.15507456718330612, 0.6066332723723179, 0.1963007335741807, 0.2973509235581147, 0.22185669848207998, 0.2950718207122304, 0.40954304907340444, 0.16099951800691975, -0.12214463669775595, 0.44167284617907776},
    {-0.4897635412847983, -0.01762301084892962, -0.16657980846525008, 0.16497693498499277, -0.333141729443516, -0.3268915112422168, 0.0410092000867745, -0.4945537371286224, 0.055330682062400764, 0.18794537327523517, 0.013049085854260931, -0.049820352660966565},
    {0.6316634192943864, 0.1735885363597207, -0.5613997604222064, -0.10552198233383263, 0.3983230471613082, 0.2812030800386131, -0.36392135268409775, 0.0718312674055865, -0.13654592176887081, -0.5450527716240473, 0.32162588619613375, 0.041800783597305366},
    {-0.2320328186891065, -0.09559573551868568, -0.2786356165594206, 0.35442441006944153, -0.3755020087200245, -0.5269565488395583, 0.08338521351032577, 0.829980651895825, 0.019621377384021074, 0.5728676585197514, 0.41625550101237463, -0.0723948842435281},
    {-0.4593005696739108, -0.6130630710688479, -0.648559244011087, -0.6521321493276273, 0.14924795398009386, -0.774613362586149, -1.0166716126716269, -1.1035818945272553, -1.2426886103704367, -0.1984973158245715, -0.3029568681980654, -0.8103231628761081},
    {-0.7388268569459486, -1.0591635422928865, -1.065656728174288, -0.9219598109320366, -1.41980479833798, 0.12631363945027677, -0.39957140118592893, -1.418857121224658, -1.0424295341898204, -0.9668027103253369, -0.5740544503343508, -0.7934266339413455},
    {0.4594038571024499, -0.16437744496561701, 0.08497040157100948, -0.33969245017830724, 0.4592514241844373, 0.020644765843082957, 0.3097174607476497, 0.08074609904909691, 0.07226493610993345, 1.0367758803261182, 0.26080389990344627, 0.19766429831606805},
    {-0.5148406380613959, -0.8998899505716921, -0.3953511468770589, -0.5306701570412209, -0.8215301801683531, -1.204812308735683, -0.5565981601401636, -0.4588291799003761, -0.2808393603765686, -0.33597673462374067, -1.2137008429921288, -0.6014794022370844},
    {-0.14384430849977786, -0.08777763397512447, 0.6793033023792205, -0.31604425938046676, -0.2971531010905215, -0.07895910794810895, 0.21494429621852496, 0.5294843445858068, -0.2514318421373576, 0.29242245842684367, -0.2899197403398558, 0.45434206935981836},
    {-0.18496456259732766, -0.3526309459314698, -0.27090592062758295, -0.03477599487293209, -0.4435482122876754, 0.2122581661597763, -0.7084430496437648, 0.2805909599433477, 0.13779592470661733, 0.2667494222672458, -0.08879388124222994, -0.15849148263956567}
};

static const float b4[12] = {-0.3386734092833331, -0.30335169746257107, -0.2905100504429, -0.212115324065708, -0.2719139777836668, -0.21014887480638722, -0.3081641345177937, -0.26975944115330236, -0.2458408348807043, -0.3016365588442706, -0.21946139757129565, -0.18087043456778643};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
