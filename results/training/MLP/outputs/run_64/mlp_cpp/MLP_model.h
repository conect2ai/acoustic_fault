#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.35573183995405466, -3.5717879164674415, -3.800200014839025, -2.745140439131105, -1.2940016387127433, -0.02878615530916974, -3.5550911540473185, -4.255130405778665, -5.5843734986379046, -2.930534119865082, -4.5173409970282705, -2.4548888266319433, -1.5863024234591574, -2.1475602683088666, -2.2656945933503674, -1.6449245547524902},
    {1.2001614339396862, 0.690086791313554, 1.587917553204809, 2.061662015775601, -0.10975834783962166, 0.9944109912902097, 4.964412398348118, -0.23081082636567915, 0.8575669263219089, -0.7856489145207762, 1.4784402080900887, 5.318895882032176, -1.505564788512168, -0.3026107187346934, 0.27677671935782827, -3.8788008466602037},
    {-1.9891921689854979, 3.008335813617553, -0.6012117872779922, 2.0601803267128282, 2.423646128906653, -0.48092763227136043, 0.7124256895726351, 0.6462617017394675, -0.701392947657667, -0.6582402765998657, -2.2030874103266345, 1.71302702985902, -1.8501040018731385, -1.16093912046964, -1.2393928070133693, -1.441969056637296},
    {-3.253752634816666, 0.9705761651341607, -1.1365965859928657, 0.028552504772361497, 1.4515727576590545, 0.8630738319789829, -0.31818131479697503, -0.3826608492140627, -2.418663228908848, -0.38072945268190445, 0.9292503789063663, 1.6029881794350302, 0.9382682389803488, -0.44559161957429644, -0.2436883117920762, 1.0971471967475883},
    {-3.1767967841273377, 0.5640266735268876, 1.273213499564073, -0.33122328260749845, 0.7231103371417299, -4.376421133564227, -0.8866922831481865, 1.2907093440985933, 1.9962509106765836, -1.7292626287825443, -1.6856419420613429, 1.1607264531071841, -4.873520424575321, -1.5175577147420782, -3.6702418236210654, -1.5258017756212408},
    {1.1126807580809537, 2.3561318578722705, 4.9558970229783865, 3.108303189845007, 4.491490186184066, -0.14277765340933712, 1.525043934879276, 3.4994830107200863, 4.262694783014678, 1.5707244402870988, -0.29127941722721107, 1.692900616446547, 2.305848611056857, 2.3311899581802114, -0.4019816778723976, 2.505731012247586},
    {-0.6766032785229663, 2.9896403861565672, 5.301164052276973, 5.000471676772712, 5.953178737597679, 1.0329974992264221, 1.961570339205661, 4.1668666361382645, 4.183868421472787, 1.5631979459855354, -3.4655728935399863, 2.3636937565704104, 3.5729015888502995, -0.08197940709955698, 0.7532910064885832, 2.9348378361217353},
    {-0.379143928346371, 0.7915294844595859, -0.5886005747572437, 1.414892944189363, 3.076065318262105, -2.490583544682138, 0.7316645871754539, -0.590585764605765, 0.5592053534581806, -0.34419846092167694, -1.8992244314227669, 1.7965733068599148, -0.4997395562977126, -0.47122428222634455, 0.4603228495584213, 0.007216209922722404},
    {-1.2897645174392434, 4.326272977803357, 0.8404599642163207, 3.0230529142543405, 3.5780255615751884, 0.07395227448271063, 3.7428844599837445, 0.9986959913176406, 0.2973652860846548, 1.4453364258893626, 1.186326437008179, 1.3759438522799146, -1.3399531301498653, -0.08212006144526597, 1.2576838488148476, -0.40025089485461457},
    {1.778820379503691, 2.2223562054375448, 1.9069843457869993, 0.5089237457613008, 1.1837726335349785, -0.3169378993989432, 2.0478013177708783, 1.186099943803608, 2.8208920051017556, 0.3004459994830394, 1.3718500046193218, 3.628062856603546, 2.4501528809644464, 1.4569330098675681, 1.510758439466258, 4.033416466669803},
    {-0.20060207859372386, 1.2736771577513768, 1.4477356927465481, 3.78283142144081, -0.041408164535298234, 0.9523805887968695, 1.1198303415958784, 0.8115285177948676, 0.9179914285777058, 0.6301798831847891, 0.8797957158703518, -1.3766632441588404, 6.142007540085438, 3.6310907629732863, 2.3179377972873403, 1.2723723483572151},
    {0.9883934417234131, -0.36639923046467404, -0.28812674529701804, -1.4143621282632066, -1.305304209979454, 1.4784516652165975, -0.5819025356850229, -2.059131346822226, -0.49605346782625376, -0.26792829148239394, 1.9458338288856387, 2.849893950701665, 0.15803044743844905, 3.9506835810670284, 1.038667397091146, 0.516272900724624},
    {3.616405938102268, 3.1118254409313515, 2.665698185515103, 3.6170369449197737, 1.2473053466639996, 2.435763312058044, 4.038346761009089, -0.016650963048591507, 1.4656135907028487, 1.4534802180165889, 0.804464208041959, 2.1372490491880782, 4.225495653788257, -0.054177720104690144, 3.210334987537556, -0.8080218751547851},
    {0.3134008004906129, 3.1514406097506047, 1.9872612008349322, 1.532855992250268, 2.5988828290919046, 2.752793667776938, 3.20518255857771, 1.705375422887568, -0.3318955603718697, 2.457862952178167, 2.3550565296676353, 4.526830665697574, 2.904326687928349, 4.779652630531721, 3.568754853635157, 4.696015276145167},
    {2.4453065615355705, 5.469171642838192, 2.5898485006298895, 4.098376493649955, 2.41494610685971, 3.9931376729213737, 0.988210268460791, 2.1454767230394913, -1.6397606637365978, 4.853062440749291, 1.9382858227268964, 1.7289598393178045, 3.8626621999122466, -0.10823100741983656, 3.1966320999697087, 5.708830661276085},
    {3.840322080663308, 2.6471320944688443, 3.0089860504584207, 3.685771796497854, 2.5338829112145898, 2.675417381931688, 2.5607222936969842, -1.3288238192181525, 0.45944682213114435, 3.3297315388325095, 3.6391317744369442, 1.827342308325851, 2.1121152871026667, 1.8713302916039638, 2.510381756948203, 2.2312065412276616},
    {2.0705507777126413, 3.9134151989001564, 0.5913021522409506, 2.877389467345183, 2.1396394710715794, 2.673771132210549, 1.7533302711063536, 1.6251893688993146, 2.0880675988023594, 2.4063060471548376, 1.7032587605651934, 4.030632017637173, 5.0817704178033685, 1.7231091887611194, 2.904281949182036, 6.45068366429247},
    {1.304835279349503, 1.643627900490425, 3.352784233056386, 1.378239960547947, 2.583757732128394, 3.4825873073764675, 2.8938560907424398, 0.4296685524973357, 1.137732483643153, 4.183549320695869, 1.5824335142654264, 3.253453641531048, 4.914017970677264, 1.9689539886132474, 3.4442381093758065, 2.5689417016866853},
    {5.583606260205761, -0.19782753179086698, 1.8517545112057952, 0.9901296212468617, 1.0757592341452782, 2.1441384990854897, 2.2899852584764893, 0.28635562454445634, -0.8813166838498393, 1.3145230997578374, 3.0005021374419862, -0.1564212231523341, -0.3104098979831974, 2.2789195280454324, 0.6139815143459549, 2.0511441861731674},
    {0.41419309453307124, 1.365895737699741, -2.286535284610266, 2.033801358279394, -1.0011349414053583, 0.5331257706726531, -3.6227006608438783, -1.9532586580439066, -0.40584552445278144, -1.1978921349433527, -1.3617582981160377, 1.325690638416434, 2.2038397102847274, 0.765079200164207, 1.6581673217265842, 3.6355963607353923},
    {2.208311239534256, 4.363070109067369, 0.2781419721617253, -1.6028439566981354, -1.089049933098522, 1.6319555689875793, -1.2373083357049455, 0.9777438073713801, -0.9817024434267211, 1.5377458643299353, 3.5858708154508605, -0.11470310000991205, 0.7582453195042822, 0.27957765679270824, 1.1142131110686266, 2.613763918604326},
    {2.1750444215040177, 0.9025258659727047, -0.6496368390187796, -0.41297667425602635, 1.8926394784944272, 0.9693406446361034, 0.06475937782167943, 1.1600001225999892, 0.09028775344063499, 2.3049263135939406, 2.941076148950551, -1.182867310599885, 2.3453452910658386, 1.9576773373081713, 3.8331456429357433, 3.2514115005417894},
    {3.6891880840653886, -0.9628257490158835, 0.584376229592921, -0.4407274713692391, -1.7585330854886583, 4.845434903870955, 2.167829900081388, -1.6506740901189092, -1.6393364198933882, 0.30736942434191006, 1.893936834849679, -0.552446813116386, -0.2503068750827192, 1.4490915892284577, -0.5748282446370662, 0.9248034896745027},
    {-0.9447961068433014, -2.0396832966756597, -2.872972347130683, -3.1170101918000186, -3.053197268906971, 0.43701144126679803, -2.4391714339890975, -1.327089828289549, 1.3311947818865215, -1.961149809723694, -0.13991702661276093, -0.2597328949429741, -0.8917094699890318, -0.6531035080592433, -0.9643428453993254, 0.6777002182363647},
    {-0.08109672787103699, -0.47670026579282315, -1.8749778710487077, -1.4812914901497662, -2.4087750984037766, 1.0765200142006948, -5.229111013613593, -1.4014355599845385, 0.37223541441526875, 1.7706573515012682, -0.4967036543947082, 1.5901752732162016, 1.9819918228300144, 1.4736985617695817, -1.415612483965468, 1.6786880100427999},
    {-0.7863537608780319, -2.8338531522158883, -3.6713429651574137, -3.6318913164223017, -1.8291469322456178, -1.027608622460452, -1.8014174316379186, -3.8223919252423153, 0.18400873737955603, -2.490696656375979, -1.1991622227180834, -1.0731115091760295, 1.1316583069869917, 0.9810879443358992, -2.162429289884326, -0.22661786323818345},
    {1.9316558263656296, -2.854070910304779, -2.647948435139555, -6.667421059387464, -4.2953359856145354, -1.3578170206334796, -2.2300583738284363, -2.379508792732269, -1.489495792256152, 0.13327127588328583, 1.4027746979154505, -0.8072933392366195, 0.05024750706183995, -1.0528538564532854, 0.09151117892530404, 1.7666242084927355},
    {-1.9387561333269676, -0.9225080987727788, -3.6968581852012647, -3.349815891501601, -3.5358259826918266, -0.33905497331062, -3.509644219080313, -2.0026570870819125, -0.07049683511431641, -1.950743924213693, -1.251893512852961, 1.3812556795040059, -0.7169648587587358, -1.8266423163405092, -2.0280510527896367, -0.7637739806326589},
    {-1.8186157759865729, -2.1785532227161775, -1.569128145707599, -2.4201660494118604, -1.433753636599289, -1.2743655135774403, -1.8644975412760167, 0.19093132211128494, 1.6777240557538573, -1.231851874499671, -2.758755975026016, 0.27194840773356616, 3.431757859546919, -1.3296585657201085, -0.9581141326060703, 3.549595340397509},
    {-0.584613698854934, -0.1882960573095274, -0.3166821098454022, -2.004069246603357, -3.2396568224822646, 1.290792474481124, -1.1608054160849057, -1.0788162492583389, 0.5247583974269588, 0.1149104962034547, 1.4094674366611906, 1.8594001569364713, 0.6977664990852205, -1.1888975778261546, -1.6839016838789482, 1.511921756932861},
    {0.20000946239533082, -5.331623681401719, -5.787742565216759, -3.326167782634271, -3.3290851434422173, -0.6605439857269344, -5.143711901779127, -4.4346898911604145, -3.4894768067982445, -5.746518171168546, -4.0520479969910115, -0.31189193387556385, 0.238776355397846, -0.30905533057356177, 0.29778654817528505, 1.5738412358307898},
    {-1.8155242619720637, -2.8855615968720825, -3.001790215298175, -3.7074854152077825, -2.369191759327166, -0.021742442634935955, 0.05188202939324418, -5.160995725905145, -4.592108012560395, -1.629919035308018, -0.5785094366839751, 0.9241847041414105, 1.0657327863937782, -1.3118336041932654, 1.8945297215521504, 1.250916761444022},
    {0.13026438500205242, -4.490461959088933, -2.0744623549600574, -0.01503724716793645, -2.472605781796378, 1.37400500499931, -0.04436475280044568, -3.229738479128709, -3.5984868351964643, -3.699163686707513, -1.5162473860275851, 0.5768531616901749, -0.5329376321468737, 0.4501806017280154, -1.4291436613455422, -0.9616995161197454},
    {0.43617144323013457, -0.368469787671325, -2.8830548397382034, 0.7907946617919711, -1.894071028218267, -0.2615175459191969, -1.1749091544021026, -2.526836079097936, -0.347920397326741, -1.9304132574087174, -3.6963066791226167, 0.664860190372717, -0.08360870123843935, -0.43000599909500575, 1.2689474604492479, 0.6741553146055747},
    {-0.07799498493126164, -0.9899382131870811, -2.8428871358631795, -0.7537915339735803, 0.14611196649013952, -2.7873668067192257, -2.835814576654786, -0.29509577787094216, -1.1958143718692114, -1.5736238698285516, -4.054964249709527, -1.2326136947741748, 0.6529250980531999, -1.0100071636084773, 0.3080947175587712, -0.5077951089848862},
    {-0.40397114191301975, -1.3792854711227855, 0.9204258323082954, -1.676990855241358, -1.9281784629250882, -3.8604869384058786, -0.5260201092353521, -1.4587220588693897, 0.6788320390096375, -2.0218260714225345, -2.9874439514726476, -0.4995931386843732, -1.4758782231553387, -0.7909004317801357, 0.5068149529790594, -0.47054938782453165},
    {-0.962312418413184, -0.24223550666188126, -0.3224491045874902, -0.2884428736374169, -0.438097387510081, -1.863500492678464, 1.1196903624457057, -0.21611029503902027, -0.9485058084399481, 0.9768885398085894, -1.0510764753865987, 1.9810360015958037, 0.23732722263206277, -0.37385307313761884, 0.8514352072972455, -0.3066530928182227},
    {-0.7116446468019445, -3.8173394134353105, -1.8898967248868406, -0.6579969985239525, -0.3726013052634734, -2.4901210811377235, -1.4693625897241624, -0.925742954603731, -0.6156461296459984, -0.78455021828536, -0.8492978097530929, -0.7608020092867629, -3.160572112981809, -1.7059504809665695, -0.8090381046988522, -0.9731006157678634},
    {-1.0937455360542734, -3.6677554921175455, -2.5167991859182783, -0.4971203903904565, 1.5162404309071538, -0.7511810062215665, -1.2983549105443708, -2.6303737807443706, -1.3602097720858093, -2.0231311239152188, 8.314461481218191e-05, -0.4117252811146912, 0.43905920248679947, -1.7869066177143273, -0.052644650786254674, 1.439949190720334},
    {-1.6060686563688884, 0.6403635145912229, -1.9148356712337808, -1.703103693287701, -0.2948814366842792, -0.4335487733949745, -0.4372826878355957, -0.12306876268199751, -1.305299279094451, 1.2104499363754233, 1.2908188000833214, 0.7957621222642748, 0.7372105211070251, -4.081412253909615, 0.3341967327036625, -0.8646349485522854},
    {1.093546352141956, -0.7206922896025655, -0.10551620800630339, -0.9008502190099736, -0.28209913552705707, -0.41174622260308474, -0.1967598846743117, 1.89558836472926, -1.9514961436078346, -1.9698223849890855, -0.7944057976734104, 0.8810240733952056, 0.7686199221893756, 1.2713673394847562, 0.03954348470661141, -3.742190282271904},
    {3.7315809037647933, -0.5872666475698876, 1.9045892482472444, -2.3740867509695245, -1.6802731194410023, 0.760640420802672, 0.367128634336249, -0.8263355985741262, -1.2788167581005883, -1.6828589795308215, -0.42098017018173195, -1.2254908063371686, -2.1150069139242413, 3.3796817635109138, 2.0593142083163674, -1.6536699653615838},
    {-3.4504279143121535, -2.7753406825385025, -2.485794796914131, -1.184199709434781, 0.47540369559192874, -0.7771839961181488, -1.3449843042636933, -2.3872760413395917, 0.7668071725171542, 0.5713156934613411, -1.9696457606067976, -1.1696196825637875, -1.0322790827486883, -1.3206764483674471, 2.3526256715721754, 0.4681376008903293},
    {2.4490822775155796, -0.7092923434490471, -0.7640668194370407, -1.5569953108877466, -0.1909949770844019, 0.7671829579102891, 0.4701030248530764, 1.0669566652498124, -0.11343527247968238, -0.6938256438192547, 2.632193147228147, 1.1860462202757809, -0.43058304017927373, 0.02283325061190778, -0.05313915681832426, -1.4822630166408743},
    {2.5292398966906657, 0.0949405335092664, -1.2149776592457153, -1.6930533819788414, -0.21079460364217673, 2.0538912181080424, -0.8746071758029557, -0.4028389034289137, 1.1840684438837268, -1.7175586255810344, 0.05810235219227232, 1.4496247825986381, -1.8317209418813765, -1.0213346807281078, 1.7308500649020628, -2.3912188476729996},
    {-0.41449604623534864, 0.7418385391499266, -0.49512098822031947, -2.3043724621550776, -0.7119431612198746, -2.416621745964338, -1.3483284525815487, 0.3681733459032378, 0.7811999371306954, -2.1397677136692326, 1.099973988190853, 0.9668714062900908, -0.6036646720232358, -3.4054035869066883, -0.6683039849020094, 2.637794900229171},
    {1.797787936032283, -1.5383145555877282, 0.07683232592983225, -2.952805449136758, -0.5323852726026669, 1.7251177833599185, -4.034630413300441, -2.8782420782598206, 1.755016743935497, 2.1189814368643054, 1.5915436756391823, 0.604847571479644, -1.1967621083548698, 0.405056781969016, 2.915356753317141, 1.1300646463870327},
    {-3.03337187774287, -0.6030751384611543, 1.3020154959611212, 2.1335138513780456, 0.4027830171181919, -1.0966991809068043, 1.6494593797282169, 0.5801021381553756, -0.13982440666537996, -1.3812226039425208, -1.453469553093255, -2.001823878821077, 0.19376649295469558, -0.2429756107767305, -2.7937272652473446, 0.4716480090312169},
    {2.2450327950562103, -0.27942223194182636, 0.4054401020673789, 1.4645109807749517, 1.2740098186933695, 0.9673551539271317, 1.1808470123788126, -1.8584737219406167, 1.9903175554912862, -0.5403543373560591, -2.660792104092024, 2.858029812502611, -0.07920215086221347, 0.7930707176539121, 1.3121765248196688, -3.8306851319832433},
    {-1.4655785703195492, 1.9866208438409905, -1.1368499136491856, -1.2290519456519235, 0.5468877780861968, -1.666665419323944, -2.3061815361456617, 1.4012399394934503, 0.4430328190240158, 1.1947517696422978, 0.576165485890176, -0.5657164185112881, -0.0740582317356603, -1.5194730783075168, -2.5731098427484147, -1.8560695504947258},
    {-0.8781903851092911, -1.9767270090418547, -1.0253758373925181, 0.5673754452340466, 2.587445199961374, -2.5498821500052924, -0.22600823461878178, -0.8086692244511757, -0.5194324843318909, 1.7861127900782972, -0.689951604739182, 1.0840475945053762, -1.831158183506049, 0.6959613433260947, -0.8972845410989053, -1.0215967273413085},
    {-1.3419891179339674, 2.884633860397827, 0.06938662234878257, -0.00864309430674225, 0.7673039320741661, 0.741400272188062, 0.5806408816993011, 0.9604941234623646, 0.3789087149282108, 2.297798529871006, 0.938409251246206, 1.0741066808335193, 2.8201555893613337, 0.12303989558403047, -1.1971060590818174, 0.302342750819246},
    {-2.349896600165387, -1.8615016156355653, 0.5564099729680548, 0.9471157892289261, -0.2251217944514032, 2.5565983358841544, 0.2858613460331339, -1.251700322573966, 1.851956095692395, -1.4359862685502127, -2.2654445096692504, -0.24029936555193102, 0.27138745456111124, -2.1783920920362245, 0.1440665522830785, -1.3670307647547009},
    {-0.3263267210637042, -0.946528578106855, -0.86063198468226, 0.7557973874622, -1.9502825707250642, 1.0002531269267787, -0.46436662745584295, -2.700164135442117, -1.0014660640494224, 1.781811493896394, 0.5930534652160394, -0.8065772382262278, 1.8507575291087672, 1.4744027507246644, 1.4755751409559525, 3.3304034166665897},
    {1.001855736042887, 3.061176745913221, -3.62481837749402, -0.6870270880818035, 0.644296931321608, 1.1776375194769748, -1.5254423914857664, -1.2463071533338537, 1.1291102531573207, -0.4656316991851544, -1.677939274285943, 0.9230984453570245, -2.438149195975722, 0.5190302869416551, -1.1269865116892444, -1.599556674596637},
    {-2.6206990985923637, -0.41214743422408723, 0.20228441139836617, 2.5197486795796853, 0.9303994021617271, -0.5457756946441277, -0.02785074188892212, 0.8225254719553255, 0.1114562883121983, 1.2121842096983124, -2.807933506283266, 0.2764010863736037, 0.9675076391325488, 0.4192485079043197, -0.47352991677457607, -1.096609027542833},
    {-0.3002320337927056, 1.2070646994164331, -3.6086133635041437, 2.8338514445165432, 1.0192705230561045, 1.7310937152444779, 1.2815288204169353, 1.8656471173572913, 0.29469154101673944, 2.884883267732201, 1.5120016477231182, 2.0748270316284843, 2.635847769978145, 0.46714110192748487, -2.333743359021846, 2.348845012370194},
    {-1.8188418988650046, -1.794824020032395, -0.206668461963359, -0.22613701723179896, 0.09497322457106538, -2.743119660616504, -2.084207938961232, -1.667958846337928, 0.6794731610186824, 0.6296024625127118, -0.19290009621084458, -2.2470412442301773, 1.7951559539942077, -0.27424940764459566, -0.7579432917316643, 2.4196679816419784},
    {1.4679916052691242, 1.1845513218506158, 1.8303160547752246, 0.493266635611733, 1.8957337454813081, -2.4340842023217446, -1.4997444912345113, -0.08258483684649169, 2.180117685180105, 1.0408424567550012, -0.9925216003215155, 0.3655576185738795, 0.25009724083800355, 2.06930210594661, 1.1531415122767035, -0.3302688140944366},
    {-2.342766917821368, 0.7012534811869525, 1.5096156721429592, -1.9020961643616818, -0.7872763397208986, 0.8268372452783938, -1.6009950511327609, -0.5418304918874214, 0.8653571524596083, -3.4703219592994485, -2.234068009750807, -2.262788100108333, 1.2657698465729292, 0.07934374458229122, -1.564320130247435, 0.024736810329652748},
    {-1.0880785119108327, -3.302146380792535, 0.5830297265591623, 0.14278398582712326, 0.961381160526635, -1.8341621104988621, -0.09183881741774766, 1.6803462764023454, -2.493134834919349, 0.7185655834754882, 1.0032841376252133, -1.4372262882544034, -0.04752146063809045, -1.3972989606366266, -0.23882831028034798, -3.259045604730102},
    {2.9954375396309554, 2.5292267547704115, -2.85268268933137, 1.5526091199068497, 2.4083885084327123, -0.7903578809533381, -1.2087353568475638, 1.3981789418129886, -1.378308754627431, 1.3754220768851078, 2.0734955940114936, 1.951134768631567, -0.18099515193386603, 1.379947833039306, 2.9977487389447344, 1.2473079584908038},
    {-0.5884352985605844, -0.6200132720514021, -0.21030832523399695, 1.2760296677042697, 1.2027220985813591, 2.8493817969869566, 0.005641251715450484, 0.8301720785087722, 0.09591241916513274, 0.4707153984968656, 0.7989389944754809, 0.7166202715160036, 2.0725835337855547, -0.5367197755220554, 0.12146917870767623, 0.4528470157446139},
    {0.5951388746560076, -0.1680857284262969, 0.5196943617169597, 1.6573582193887553, 0.3595631509947631, -1.6830898612522636, -0.6781857816329316, 1.3240119268585473, -0.27009931662296155, -0.6912861860804825, 0.8445454252241826, -2.865872762759301, -0.5988172682066942, 1.1581136262565752, 0.3408854126665954, -1.2646552074186457},
    {-1.86457012991964, 0.13462379526388618, 2.4571807916966626, -4.342972310454313, -0.40848488992590465, -2.3570667036481363, -1.2276514033558268, -0.668198859646781, 0.8622763895068375, 0.5776210533691504, -1.6839483656383387, 0.05363524268931781, 0.40992910976969316, -1.2757628633426348, 0.12121078025284099, -2.136549637753717},
    {2.085699931947543, -0.24337694845810115, 2.551527298785699, 0.41975530111838444, 1.2177148579848938, 2.346879716162339, 2.265499115579394, 1.739019780355562, 0.4690268258734786, -2.517568718877766, -0.9724828145877886, -0.7488919212920482, 0.37784725937369756, 1.7808741487144122, -0.8073924664708919, -1.6110367775668035},
    {-1.3228611673867927, 0.8769800147647979, -0.3662714522223105, 0.18560323958002448, -1.4968520328669515, 1.0698230988595399, 0.8886319218859611, -0.5558412763863714, 2.2070935065695165, -1.0777339129431638, -2.2759776275275696, 1.5576407345529972, 0.34084634096219313, 1.2604336933364537, 0.2091517285771549, -0.4912444412964138},
    {1.1572079387301446, 0.40773960857366925, 0.8466470281523955, 0.042195795321464745, 0.349024748697712, 1.4324963859110567, 2.4487036867204304, 1.1753465513962595, -0.31417129631118634, 3.573544434559268, -0.5282952721434827, -1.5629599833135748, 3.404712646821389, 1.4233721282633969, 1.124518082065741, 0.3908769286025135},
    {-2.4433748953506855, -1.997568786856271, 2.245694765274176, -0.03629004504946371, -1.3475992283676306, -2.8394210919954723, -1.8579695963414264, -1.5299122820796598, 1.1543044188290168, -1.7927312542879823, -1.9250327231663806, 0.9634594336343076, 0.9614921101613233, 0.01744776429558479, -1.627592539867731, 1.639728605978306},
    {-0.6831711164514835, 1.9886045740919165, 0.32597905047624653, -1.565197292963573, -0.5016939767455012, -1.7806196333847557, -1.1679697016400283, -1.4934887187727959, -0.733782495574197, -0.17470995942268738, -0.6773376354297184, -0.9331875288671423, -2.4065798238450338, 0.2996751505036367, 0.6611188068035908, 0.616066288201326},
    {2.456586109776594, -1.0348391458536619, -1.7018080323656009, 1.1260875665444263, -0.45084129486655394, 1.5773711624850821, -1.3411413171880122, 0.3790570413057896, -0.8525335022020103, -0.6694173147966008, 0.3075411011778224, -0.08806417292795606, 0.6317562021276244, 0.16031535709353487, -0.41197447338173726, -0.714862972298924},
    {-0.3299268647879768, 1.439567190827301, -2.0938004447101264, 2.391584293669517, 0.3147325538839612, 1.0061719546236856, -2.7001591099881894, -1.0526296224781375, 2.598546625895463, -1.5695752130099396, -0.4292536220550902, 0.24973184083765185, -2.010272943420738, 0.4565923202195907, -0.7506253631537001, -0.7209774756764549},
    {1.4736695409953282, -1.4977837362252946, -1.1867453709138231, -1.0523707354163208, 1.1394512177672382, 0.9689213333470749, -0.8140734874209157, 1.5797231499372621, -1.3592042394446555, 0.815692888073658, 0.9446634156814169, 0.2886602516353534, -1.7227597728330712, 0.8984450436705824, -0.7355175858274341, 0.9399031282771352},
    {0.2389293414187275, -1.8571052121767553, 0.5854014634207388, -2.7265810587163846, 1.3333241549851715, -0.2319028964337947, 1.2174023298786822, -0.8808626830124495, -0.7178636934234518, 0.707858345847712, 2.690700513770998, 1.4215859804449031, 0.7213806435029659, -0.3990146012600685, 0.38593609065610096, 1.125126904114187},
    {1.207793649629263, -0.27919124694950115, -0.19539141689837217, -0.7540942944056369, 1.9674029729125495, -1.1171610619979473, 1.377898675668734, 1.2484744554615206, -1.9639905500082828, 1.4011849930700715, 1.1776518476685571, 0.09542251312471779, -0.48682818564386504, 0.6805250364495888, 1.4978912806742417, 1.1551304010223502},
    {4.745833789443542, 1.7871374596801357, -0.6082614223286663, 0.0035226114800834996, -2.2769796080888987, 0.2631300796742873, 1.0515347896932334, 1.5859437188607401, -0.374136831449312, 2.5930708554951685, -0.11979951065368492, 1.6056401842861507, 0.8304722960249773, 3.7574853307426714, 1.3154669980523017, 0.22668553434396005},
    {-0.29067744003650753, -1.309653199113824, 0.6523110432070606, 0.3026069321425691, 0.5249764250866109, 0.666252929293376, 0.8285416928083789, -1.2439946012151506, -0.09156843685398437, -1.1281308857433774, -0.4948917521891179, -0.43094514828993985, -1.4594713838205655, -1.1752612538820946, -0.4409152480645688, -1.6361129288153946},
    {1.3597195979247738, -2.095376799114067, -0.3102420091582226, -2.1351570654820944, -0.4699511935190111, -1.4671881014097419, -2.0052428756533045, -1.6833929668730643, -1.2358146134599255, -0.6363031255787737, 0.14686676274342628, -0.7576820537419084, 0.3055353000376379, 1.1409510521352753, -0.8167604421683986, -0.08682906581167907},
    {4.155523189608936, 0.2653027993376555, 1.354763796302639, 2.925322140689104, 1.8829852409224057, -1.7824843386788343, -0.2888888864040221, 3.1266598577745026, -2.098405287911292, -1.0225171807791897, 0.7881950315605064, -1.4281562281978897, 0.9156854099261782, 2.8557406828971184, 0.1651616359668598, -0.809313557323044},
    {-0.6421817686197265, 1.5202775273069882, -2.2875645987759374, 2.408205244620665, 2.3063700466810406, -0.2347823049246702, -0.5728595449050962, -2.3068477296792067, 1.308618329568387, 4.687496798300359, 0.7240644020849314, -0.29447922871561066, 2.0059036308873335, -1.2594293636295988, 1.9732456865330341, 1.9034428416936633},
    {-1.9198090917506632, -0.28832827939363936, 0.5890965986949543, -2.638288428052442, -0.49932719581197826, -0.3381269618491362, 0.5891223679092391, -1.4459804543136188, 2.5955465793382073, 0.6830783769613903, -0.7884153391533153, 1.7921109745632968, 0.07517583695662822, -2.0114406519555788, 1.6535115630392276, -1.7519151857236916},
    {-1.29840011250689, -0.15204642902113877, -1.57543810297768, 1.9692286033600161, -2.2048363654600056, -0.9514925564327487, -0.06855788819974207, -0.7600677770539913, 0.5192044579033434, -0.13642852263790844, -1.885301707287748, -0.4071383100128156, 1.72515600857931, -0.9107099981946473, -0.7473708007677144, 1.123687378858632},
    {-1.0967881732426623, -1.4585743426250013, -0.11013500347882163, -0.15154544963165978, 1.2123212736663846, 0.949651784589197, 1.8724976249517082, 0.4233644613378268, 3.5386328001671012, 1.7215705814405056, 0.15609434453760443, 1.8520247411392678, 1.6651626004476783, -0.41486156218558573, 1.2996874007087242, -0.10372027966057093},
    {0.752472191760037, 0.37738277809750415, 0.06649525129825205, -0.44237516823357176, 2.298397120390574, -2.341544749018158, 0.8411883317308655, 0.27922670313344483, -1.280405557298588, 0.4947931482188428, -2.3731855370905377, 1.3606982617656305, 1.3171886336348682, -0.2190729133092343, 0.5364707044283232, -1.1825890932969512},
    {-1.413398578422585, -0.2681807544826102, 1.7765882554778392, 0.11783935033048575, -1.3035964545974328, -0.7805618960510478, 2.17829651278111, 0.41684603473156234, 0.06616707015102068, -1.0281511264686722, -1.2330324608784675, 0.41596811442168935, 0.9348829712153467, -0.2750912002090941, 2.716641344581857, 1.5665526487013441},
    {0.11357540345267456, -0.46741512699697546, 1.3600849644521484, 0.08161968812668179, -1.0460862882735262, 0.04764597879564953, -0.11415353956534713, 1.090152691981191, -0.2007326331233424, -2.0750859405042155, -0.011321299146529696, 0.7834790153147415, -0.0215400351392627, 0.32443322730318014, -1.1912010204457604, -0.03634125842967748},
    {1.2400175291074351, 1.0115049414932427, -0.7801377316616169, 0.9982731279610016, 0.12829072191322555, -1.1995226635754754, -0.30008596223650513, -1.2187435674022098, 0.4575001204184114, -2.3761637909091835, -0.7572809676256251, 0.8790147079443268, 0.4407567481855355, 1.0922450291334922, -0.2107163593449302, -0.37322475400616617},
    {1.3941985295964718, 4.349264659323527, -1.5876629463667438, 1.8454655202441794, 1.6514277351832292, -0.3175594346136004, -2.4200046417331853, -1.189580010841362, 0.1388477068207526, 1.7756498600686519, 0.2210922059649811, -1.3146240422534867, -0.10977398026249673, -0.6434223127245854, 3.7227575976486693, 2.0948124555136713},
    {-0.7147800396412451, 0.5615055987125248, 0.39018661336222143, -1.782121719999642, 0.01778212760130392, -2.9924888097133846, -3.059270560390692, -0.8791427678161832, 2.5572455209155023, -1.5438612916453693, -1.803549885069718, -0.2578873226217155, -1.0074275267210004, 1.8691624953745805, -3.2873928709088727, -2.5001717270263217},
    {-0.6718982542361094, 0.35766777339289396, -2.198427874674916, -1.4739004310071662, -1.907482981449672, -1.3516272210854878, -1.6124240782199433, -1.879500757429524, -2.1505839582984443, -2.4767117543759425, -1.458894674892822, -0.42634239026338216, -1.9303618447631474, -1.0418163230989972, -1.5590765670792972, -0.39625192397312825},
    {2.049957339826672, -3.3575376739782974, -3.9993584039533605, -1.0255701195095985, -2.301913193885977, 1.4742996311333885, -2.2852603378610947, -2.0615496783397957, -0.700036191550772, -2.7593261915187655, -1.2416108946665794, 0.4245815972821814, 2.7947215881125054, -1.451873307764034, 0.5512137932391402, 1.251374162591045},
    {0.6677546920070055, -0.19155344816269368, -3.3087313692348226, -2.0084329393441234, -1.4256100813418895, -0.28670446283428436, -0.5109909701387696, -3.1762316877586456, -4.218815973281002, -0.03331261201631602, -1.2610054305432734, 2.5560493602282612, 3.4895701676825617, -1.3510092575907466, 2.0662637608250334, 3.7064974055891002},
    {-1.3452378250578605, -1.5411355627250605, -1.0182183814849006, 1.1218906276369691, -0.8437722424782248, -0.7024826044143861, -1.1638355571434431, -0.48096261833666976, -0.49537604905718985, -1.070198178946585, -1.9457161547980921, -1.2909670706041618, -2.0586349230450223, 1.1065625443538976, 1.0893553928608968, 1.4402109103304572},
    {-1.9767357167890185, -0.707168244183721, -0.8783266119912214, -2.0141704950849846, -1.2777609503878835, 0.07611399750587615, -2.1685594923791003, -2.9748718154596574, -0.8675994447275687, -2.165029845033946, -3.7132422013785686, -1.2775132385686578, -0.15283983822705588, -0.007716312109882585, -0.8741242441855173, -0.23562375225458293},
    {0.125229378966791, -0.9543939663360932, 0.1593114614898109, 0.22077064088147488, -1.1866936628459586, 1.0084199608009312, -4.340454547412593, -1.429227583962607, 1.0064676174519318, -1.9145517046214808, -1.7455987396552408, -2.008285980403199, -1.132154406573643, 1.158634110951075, 0.9822693195237091, 1.104238611612611},
    {0.1803421942299845, -2.0548961404683896, -1.2183120494297106, -0.865038582063237, -1.5389945800566653, -1.738726509261276, -0.9114352625163286, -3.2242936301651537, -0.8749585608865739, -2.413152720827525, -0.9816083367795109, -1.9831916491215649, 1.4279427579955746, -1.4757007277513305, 1.2748934268692411, 0.8869053797809069},
    {-0.6023897560945128, 1.0811867866510334, 0.30570995965526715, 0.7007578505236294, -3.1092386346228116, 1.2152306589811752, -1.8624463729161016, -1.807918693477075, -0.37532490947641745, -0.726725380879176, 0.2207445898419938, -0.7120881071034544, 1.0840579483018664, 0.7727974833599693, -0.49331416609707923, 2.0169710541091344},
    {-1.0517282657435092, -1.5703687662803951, -0.5242758137489452, 0.6482698886635521, -0.5899577500663588, -2.1431129813718983, 2.255928150629693, -3.1352186492361236, 0.6073008113635582, 0.12332536206517081, -2.1851566891653187, 1.6121514185637764, -1.858240630735207, -1.0000049989535071, 0.30781479274968016, 0.459238304536273},
    {-0.30229733007221415, -1.2248011232973162, -0.7409406823022477, -1.013743125457769, 0.9782771871260733, 1.0239067623968308, 0.26436926973400066, -1.6702988104498517, 2.274165172687128, -0.8835157930803562, -1.7500251974443042, 3.8225191961788214, 0.9164741484228105, -0.6942670769790166, -1.0269926374500913, 0.858716529294877},
    {-1.4556672068812146, -0.7656348106629436, -2.475846519150954, -0.6417039877841739, 2.958548892903935, -0.7079393201996651, -0.3380316038216858, -0.12282369258455098, -0.7617717168345632, 0.8650506766966326, 0.12387063433707375, 0.4218838789939244, -0.5728973696691447, -3.375949285508459, 0.35795655833516477, -0.5618773486945149},
    {2.5308030771539, 0.3332797507364883, -1.95767386578585, -0.500799129359208, -0.36254884267897547, -1.7255161014339349, -0.8034935793579937, 2.146869431817003, -0.007981868562687249, -2.036039088042531, -2.1982430648957636, -0.12391377038689924, -1.4617422518361225, 2.3402639521790385, -1.448402118361481, -2.0243772675179272},
    {2.9819009217588635, 1.074910856780271, 0.5948795732252965, 1.2593806449826908, -0.4468666820255509, 0.5112224260700451, -1.6572731167884758, -0.7240185077873996, 0.9393379754280476, 0.1661915350910446, 0.5458390023306464, 0.15330525737874956, -1.8732967964126108, 1.423364685487652, 2.6498526187929645, -1.123490698708912},
    {-0.7485644191412568, -0.9492382741520387, -2.747820689419677, -1.1370147893749618, -0.07570392917660303, -0.9168649784607918, -3.0330950113519566, -0.6288609181325828, 1.7778498290280964, 1.3838901396581957, -0.4804665698425149, 1.1029060315599661, -1.502672644020885, -0.9217497995289868, 0.13424367231328416, -0.4413345819124209},
    {2.2252657142708827, -1.4251293887195653, -1.531603641417476, -1.9062081388752399, -1.1410579027861238, -2.1174393947212766, -3.956828276880343, -2.6647076960515754, -0.10370787162716265, 0.9458338636971999, 0.8444979492220129, 0.15994167473630283, -0.14651423622066523, 1.9436254644127346, 1.0292290981909402, -0.11838677447657676},
    {0.9469210375129917, -0.6688504780684995, 1.244050975631411, -2.5187281094393774, -1.6021655103447527, 0.9479987730793022, 0.10823193878399766, -1.2298551929323072, 1.1184869657471812, -1.5332541409905471, -1.5750609473539432, 1.5565104372747907, -1.5581626970147961, 0.8581214434645343, 0.08621627258910049, -1.9627044027307479},
    {-0.41692299886449724, 0.6187499926604583, -1.0692196749929086, -1.6120499195673248, -1.193109212584177, -0.19629104960994098, -1.3668848092953665, 0.7809929480144978, 1.016924585693875, -3.0992477730769803, 0.1640663334277249, -0.06838235476827807, 1.0469568590898535, -0.7371644408395679, -2.3453554198001627, 0.4530314905028153},
    {0.7102462976850232, -1.481893409982379, -1.0002702998397335, -1.580591478341986, 0.14265133973084984, -1.0809319322597732, -1.332841983284119, -2.7612147834900678, 2.638746608635848, 1.273702415143185, 1.28614405527231, 2.2691184873391244, 2.561131316794894, -0.4214446557147126, 2.1329014459342646, 0.7737407177680218},
    {-0.1190534503332318, -3.442371977991257, 0.686182470664203, 0.4217266118683991, 0.0028088032215639464, 1.0350645907150298, -0.6349856794112704, -0.5609845903932086, -1.4842792628083632, -0.205024412233414, 0.7543962460870026, 0.33925048437060196, 2.6650341945730585, 1.317344315042878, -1.9324787967942494, 0.6389196044506625},
    {0.8252569141127665, -2.3610492161946626, -1.1676139368870417, 2.325840947535613, 1.0334604456651706, 0.5521921802126184, 1.7843009390200564, -0.5219181028748976, 0.8512842229335588, 1.1180696133879418, 1.0365219560469678, 1.2062480701557872, -0.5846127650528885, 2.4170678208366247, 0.47682059392888765, -0.47272515543767596},
    {1.906123423839555, -0.5871389576746489, -0.24951205636527596, -2.630066676909023, -0.12258198072553556, -2.1502602391948495, -2.478840444197467, 0.6627477595548823, 2.1998194026462805, 0.5031653017938039, 0.32370764056505824, -0.48075793012138635, 1.6402047907614563, 2.0489468507653976, -1.980782673588902, -1.1964783690565999},
    {0.5275392584330189, -1.1998996336638872, -0.451885701001764, 2.496131435830411, -1.7475653008728398, -4.06327009912913, 1.4634734799358815, 0.4921542097975257, -1.314158028115585, 1.6044287704469697, -0.9240408652267025, -0.48699183276843644, 0.7218137916988157, 1.8718729712159115, -0.21138047768557974, -1.8394424288328668},
    {1.1990327263782605, -0.11329700612882651, -1.161083908956405, 1.4222849022004314, 2.006212072883725, -0.12400083681519398, -0.550719046226339, 3.5043697356498167, 2.1547004616303873, 1.6674756519838456, 1.554942747669238, 1.1081106515050234, 0.07596472325161198, 0.08189042916865785, -1.8210987240087098, -1.0591640694297177},
    {-0.731945983092089, -0.8179162585179549, -0.055382634104103184, 1.5160219058501565, -0.5084498973359516, 1.4710878170528676, 1.697245847024881, 0.32873929146590675, -0.40942309569391727, -1.777409694847018, 0.36003067041866166, -0.264924591315301, 1.5802483669879046, 1.2690737827689171, 0.2739897497684887, -0.3062537504790028},
    {-2.400974085302035, 2.284381240511199, -1.7281220020418508, -1.1185562337614305, 0.8557230124364601, -1.6051505606029024, -2.416191509722041, -0.5130373141602462, -0.6862047409428267, 1.9858263030859087, 1.3426618386076445, 1.3251891127343811, 3.2366294296820484, -1.159765802143592, 0.445295968634671, 1.8555626129517155},
    {-0.2707619346391466, 0.5492759603642704, -1.7674195245865225, -2.331895010965758, -2.214030448132418, 3.4166869828305706, -0.7207534703407604, 1.1334406239817354, 0.5839298527544328, -1.6977154625912203, -0.9164981941617292, -0.3732371970678368, -0.35394283938529925, -0.664458457351227, -1.9445768831520907, 0.6009938093902035},
    {-2.823756485482328, 3.731361048963851, 1.6166476020434002, 1.2691142630356975, 0.9252602065961921, -2.8530812171504647, -2.3834296218627453, 2.5796375586656097, 2.839445631473351, 0.3764691385926066, -3.018728978638815, -2.6265420014007774, 0.41181794282418305, -1.7348703883181773, -0.5000584736371496, 1.144098205664277},
    {-0.8170371570641086, -1.3579480823671268, -1.0110670753889133, 0.6100313517876164, 0.15412027490034433, -2.429662241069141, 0.9225305819751378, -1.3626444026718127, -0.48115953480512336, 1.952772570465958, 2.9151250548966505, -0.09454156533610736, 0.20938867081000673, -0.3292582469431707, 1.3914848604142804, 0.4683361980293366},
    {-3.4461475062639506, 0.053562157327486995, -1.5069738519681197, -0.7170100756312053, -1.030099558066923, 2.1561809547255684, 0.7991043641185421, 0.20756059904924684, 0.9918680487432373, 1.4504164352821671, 0.9841637669705032, 0.3801005579499495, -0.5238561236022337, -1.7635725799969881, -1.8946645423373967, 1.9395767005106397},
    {2.888562356434359, 2.4393908103458117, 0.04140380583070105, -1.76278938000288, 0.8009165029882449, -1.2220140147330147, -0.37641725894621786, 1.0184305936709894, 3.027029489610601, -0.9034802217099805, -2.3344038986512814, 2.134725111027151, 1.2623871834775757, 0.8845872463292727, 2.3971577387950966, 0.5250441857898883},
    {-1.5310273244560917, 0.8974143314655861, 4.0407315065740885, -1.77676510986441, -0.14311438773656646, -0.4837275977280688, -0.9612792370995092, 0.05012214504708267, 0.7165786079670408, -1.4757523084709805, 0.5206456255994857, 1.4393752313318062, 1.3226058330093324, 0.2645751100514808, -0.5835718580933471, 0.5342754585842997}
};

static const float b1[16] = {7.234944442545019, 7.87170043586508, 6.948794781003232, 8.056675877645443, 5.968531348886694, 6.902253866647824, 6.9478158132426895, 6.316024067419419, 6.402870077242459, 7.389858715753256, 6.2748137203073115, 5.577226579213522, 7.948908272209228, 6.962474235850248, 6.467066523619783, 7.714189437068471};

static const float w2[16][12] = {
    {-3.2955033681814925, -3.2073923060223213, -4.5124932461739995, -5.512907889730761, -3.081532056732194, -4.2208430021580305, -3.830422628384886, -3.0111624798817243, -4.0493910291590005, -3.5621012737624107, -3.573582790947674, -4.937747977745591},
    {-3.9257326008872724, -4.469691802553462, -5.434721977643243, -3.8398105807558216, -4.286491681267628, -4.299878356023526, -3.2470807717387333, -3.903579412401569, -3.3865432142505765, -4.511720706834776, -6.363055859634897, -4.156793628876285},
    {-3.4959050786156203, -3.8283933869194366, -4.05273167007732, -4.36199063542507, -3.1380616938063817, -3.8461694471924726, -4.246515037891891, -4.27216186224365, -3.9247540114763457, -2.4048816496678027, -4.7661343792700075, -4.217511560087047},
    {-4.976231068998608, -4.932444858716306, -4.831713604024595, -3.988174666393269, -4.193939333888786, -4.253722536912466, -5.69630529770245, -3.2117230427813177, -5.139054997039119, -3.3987676499768438, -4.6150579770341595, -4.572318500673514},
    {-3.525902539560288, -2.9685249605107216, -4.004558759572481, -4.915847177921268, -3.7347883276587663, -2.1418481839982486, -1.2435522911981953, -3.562008196607273, -3.7716514707144353, -4.035769340566794, -3.562366981070477, -2.7619101477839383},
    {-3.7811279319724993, -3.645958450298932, -3.456088480274204, -4.5722238240340936, -3.745485169661564, -4.557452785335792, -2.7668374648738046, -4.453998037168849, -2.6455877762431417, -3.157544862560502, -4.185092907041413, -3.5549714997374444},
    {-3.156045468125081, -3.307521770310946, -4.3832682773099245, -2.86647619701858, -3.6435570698844977, -3.355560415160801, -3.142034380897538, -3.28523109321729, -3.492122443557691, -5.358356739137006, -3.7407819820594868, -3.076700177226306},
    {-4.135650087496898, -3.43492992161415, -2.0755126062651432, -3.2089530688595094, -3.8270785936983693, -4.945466429162746, -4.4140508737007, -4.441099356506482, -5.138454420447765, -3.7737246813307266, -1.7137833466073866, -4.575254075868182},
    {-3.381569300489759, -3.403372483084803, -3.3226913235612145, -3.169709440966727, -3.2342571757146645, -3.69576746673483, -4.38125707487139, -4.701724152683914, -4.296819700705152, -4.952550639229444, -3.1800731919537357, -4.294499233393992},
    {-3.3989519776262718, -4.240073615447868, -3.9605704968061053, -5.471992501384816, -3.4740294621706047, -5.402410194813175, -4.31650264248556, -4.257460741570093, -5.032444139495124, -2.8670072210664164, -5.395613541486225, -3.7433025571507796},
    {-4.365207296468262, -3.772099105787883, -3.575197908904225, -1.546038432242057, -3.35030473078526, -2.393841753624215, -4.22370500836314, -2.078510332984091, -3.2761395802870616, -3.7894897558202776, -4.1378160973290505, -3.702987015841006},
    {-3.6646360559664455, -4.411713577699292, -3.5181321027265393, -3.955020821818932, -3.35920842293231, -3.289375800656324, -4.460986285766207, -3.8211315608364216, -3.522354447659339, -2.225183821695078, -3.029122056471212, -1.935189201044429},
    {-4.540849724940612, -4.07940157018148, -5.022409440127152, -4.28053226573112, -5.039073944845128, -3.9178812238407303, -5.2825103581450765, -3.7795047393392833, -2.9559434916616882, -4.169694838167542, -3.3941175612757415, -5.950352662747524},
    {-4.031516207312999, -4.9126559672879795, -3.443610768549062, -3.320624689983329, -5.044270439343163, -3.0201996126573136, -3.428202188175192, -4.823653437609437, -4.3170898919693865, -4.820092761493008, -3.565998923899937, -1.993432266916685},
    {-3.767593735604302, -3.8165692017434725, -2.977256642467159, -2.2943608897649623, -4.712786915164933, -4.598074188699056, -5.1009027816492045, -5.326621119119112, -3.8274633023873053, -4.844398413348577, -3.17202457377311, -5.006267876175878},
    {-4.012823090911806, -3.3273497560336738, -3.1809929143374505, -5.309045229516387, -4.112154225926201, -4.015507976547652, -3.156947821700975, -4.620757978529368, -4.2485740612670035, -4.713439869763467, -4.042970294889889, -3.9217631274865408}
};

static const float b2[12] = {-5.431581932048281, -4.813727072242666, -4.79547568334835, -4.289257999844775, -5.011452033258394, -5.286433807648391, -4.43181041847828, -4.21422422908737, -4.535088940354864, -4.696064072755286, -3.857644705605128, -3.965313480447165};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
