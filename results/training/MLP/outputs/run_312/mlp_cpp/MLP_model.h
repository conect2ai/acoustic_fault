#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {3.250913892548086, 3.3705612284013187, -0.6022861176128285, -1.0826680479426325, 3.404402830928352, 4.333403565866423, -1.3325695198861793, 0.8791465006712873, -0.3510143597542326, 4.127753815875433, 0.3359079344916539, -2.0109964683371158, -0.3815016405876066, 5.100887581597604, -0.5169966201268336, 4.942822961878963},
    {2.0529505364097407, 1.8439955331053721, -2.49894844649386, -2.2274834504598098, 3.0551244840720577, 2.7397234274453868, -4.056986281987663, -2.9724172589443474, -2.8095130589109534, 1.8117463900598128, -3.174233943713608, -2.315770715875073, -1.6644248939224957, 3.7025358481060295, -3.3721509154237634, 1.9703651893728562},
    {0.39801245031380633, 1.9785757892097087, -4.245518751265264, -3.3679723553071095, 1.3877432609833513, 2.6012392680873178, -5.399284260054568, -5.571818632491071, -4.759571944782907, 2.947377714820294, -5.009239205441577, -3.7182138889022336, -5.388743872911154, 2.860963567985336, -5.557152257844224, 0.7511093497872906},
    {1.5835960864628786, 3.126797998034778, -3.5240533470043705, -4.360192895501858, 3.514237287422316, 4.3734879250272165, -5.355440737628439, -4.497155310207403, -5.19243151072921, 3.7688712535606315, -4.787400717560221, -4.9996041755298615, -4.624518583825189, 3.39000393759651, -4.31349130259908, 2.526929579974893},
    {-0.3182535221426358, 1.8552849655391794, -3.8903846077458795, -4.541750049439042, 2.5499866263413216, 2.480311638200045, -5.991242943448967, -5.308439243693592, -5.343213356057933, 3.0890386090878152, -4.958854164151876, -5.147393802485034, -5.36772823474305, 2.037238619245812, -5.741375975888257, 1.5425096509289622},
    {-2.035143569221094, 0.640733047560501, -3.363737629568209, -4.054475847189237, 0.923599734990223, 0.383375799295345, -5.5484590823796545, -5.3259309842323175, -5.010332658128076, 1.8620253696459146, -4.899045951722353, -4.225181975486487, -5.107287996050648, 1.1874815946031638, -5.765233766167152, 0.41092115624210623},
    {-2.373769900428786, -0.17168536908827167, -2.728490477983057, -4.070959454349617, 0.3599242617225958, -0.06206888562783157, -5.7185505684575935, -4.890607422583764, -4.926006492615343, 1.662713157699291, -4.89347138051699, -3.6829516005222036, -4.3242317925147065, 1.57064049809051, -5.587430292247213, -0.11980860617840178},
    {0.05114331966869743, 1.9233747667131247, -1.744731816886308, -3.824873309344577, 1.7322030273883169, 2.8314728074480926, -4.3628283298822845, -3.881971403685688, -4.383797787678805, 2.9411293167159647, -3.441996994421975, -3.5037921699473924, -3.759292958599424, 2.9232134674976007, -4.313317192408343, 2.0011308215782044},
    {2.1887649272739558, 3.330519014197143, -0.28388551167814263, -2.8332000023633164, 3.39517570166633, 4.018355788261636, -3.662395815992753, -2.7717718770443946, -2.945722056681393, 3.5374756224237944, -1.9213996341648425, -2.961872298840619, -2.570804037872614, 3.2740969005115383, -2.808491931557302, 2.7941590049502283},
    {2.216902816792204, 3.581624041789992, -1.590229210313535, -3.2731409897300847, 3.956967336953003, 4.025904937786506, -4.350943348134779, -3.76823359905536, -3.2762839718760306, 3.4164369542610493, -3.1517561020012077, -3.292891668668779, -3.1514744833445296, 3.443922494175202, -3.991317405842015, 2.5538444251640326},
    {1.7857160254216518, 3.803704621004903, -1.2049591393732062, -3.598424337466816, 4.271573350506105, 4.068270847907981, -4.6697277568962425, -4.117688832011773, -3.7229354411541107, 1.9991019960119514, -4.044239097764277, -2.992891214720587, -3.757213879186372, 3.4302736260330144, -4.0372320396502, 3.3570451505579038},
    {2.06034769246299, 4.24823124527645, -0.8278433232678062, -4.8546931833984095, 4.4031490947452845, 4.668151367252713, -4.6045338410113565, -4.16058178133291, -3.974291347789008, 2.725536463560049, -3.9584885002925225, -3.5526798933233534, -4.358907655385676, 3.0177227143037317, -3.6783706085018126, 3.4826764844505647},
    {2.31206676852043, 4.3242721292013915, -1.2748362190914668, -5.324736526875803, 4.034990583140542, 4.545610019944092, -5.132684268409619, -4.791525823487708, -4.350278931435597, 2.880618841684559, -4.5679642637702065, -3.9027309052981924, -4.8876348157964085, 3.2474117630150596, -4.79217614422848, 3.143935753997907},
    {1.995271822417045, 4.031580882093278, -1.8523976414435988, -5.647581778810427, 3.407531337924589, 4.194184869853429, -5.391298945804563, -5.2779341059717755, -5.057097342193458, 2.7936686591680733, -5.069399767708605, -4.688952573634513, -5.293147520417424, 3.143264387579659, -5.44950335776763, 2.6379435054581006},
    {1.5944729277131533, 3.9270386649706386, -1.4214737006035163, -4.872942107233088, 3.0887894417952735, 3.8961481067275607, -5.310440779094088, -5.207334287453095, -4.7666267437397405, 3.4958019314048605, -4.632044089513555, -4.321662382396285, -5.005223450576799, 3.7805119185773113, -5.546601583091625, 2.7142924544620612},
    {1.5526418767167127, 2.9606081609228454, -2.8892970247897116, -4.554812241217772, 2.589838130317076, 3.6798958724638307, -5.706825650126933, -5.473802694101887, -4.945620802275869, 3.727358774342176, -5.01197496871609, -4.5287448278648785, -4.787669804016178, 3.132639590005322, -5.602215055589036, 1.4721050597750072},
    {1.6609239488831766, 3.3285042724152287, -3.0962461121406992, -4.562840657681546, 2.664356999477802, 4.3044340784749755, -5.483438132578121, -5.603801923374065, -5.113395684123298, 3.9166028272820825, -5.128676080990446, -4.987645233885708, -4.978570912321658, 3.1872382149924516, -5.71873545812061, 1.7193744468732557},
    {1.8157696317451093, 3.7832694389709878, -2.668251372949582, -4.7973081623623495, 2.858239196794178, 4.236045723867559, -5.083118975186331, -5.296706401105341, -4.756824686740243, 4.4811779687905755, -4.472407841830103, -4.822402629062617, -5.51803168597014, 3.689677552097217, -5.4096174074615035, 2.5737317005232607},
    {1.5623615961200468, 3.894805540740434, -2.790238660555133, -5.304006376621887, 2.6753532029868565, 4.603839200621005, -5.2533142783568065, -5.198855439955833, -5.189525883243392, 4.428130571108908, -4.388752916547185, -4.715596712316087, -5.590542534378084, 3.2432066188142623, -4.981557924769845, 2.6572942771849335},
    {2.0871227082959805, 4.063028199245403, -3.10425461397153, -5.239309780748803, 3.4757105295443154, 4.421958653871117, -5.844078851544307, -5.106057531032623, -5.247545613500201, 4.252817686620212, -5.084609375306388, -5.187521034845455, -5.4792689596425035, 3.128591795430103, -5.2171304893758945, 2.670793560754366},
    {2.126654182464036, 3.7351051561669766, -2.573359457557878, -5.303345054545127, 4.028781283660379, 4.765372692661705, -5.622210287785718, -5.20934547955512, -4.875545625798335, 4.0194979121014205, -5.3945299782149565, -5.637240014899412, -5.276869058628927, 3.6241616035169035, -5.2358383623763025, 2.3811905815287484},
    {2.803567099504795, 4.120103262979524, -2.8898627670819383, -4.963309409763219, 3.857503280782223, 5.076261184623528, -5.278263529037685, -4.814893998942279, -4.963908216658879, 4.849509305286552, -5.024210067773686, -5.059163978869021, -4.940842887588951, 4.44887919916596, -4.411400483095123, 3.7445072221137203},
    {3.348942759504536, 4.482747811780373, -2.59450142842278, -4.535609060101698, 3.8268991675996307, 5.2342082620336905, -4.802637735042165, -4.158688930471268, -4.512688090516995, 4.549404903746972, -4.5972463558848, -4.737735391798957, -4.616036072839604, 4.780225558318985, -4.418863710805872, 4.298666547232633},
    {2.6665853319820747, 3.973178482746545, -2.9514278926581468, -4.443129370056581, 3.771710954823315, 4.571123363378155, -5.0739994472581005, -4.437670998945388, -4.677771770515183, 4.007856603875904, -4.62761337554722, -4.450229926053765, -4.523860532946252, 4.183259691173521, -4.547978957937744, 3.4545153117632497},
    {2.5840601795569897, 3.6514594049547844, -2.9822657245918744, -4.1616130234715545, 4.078556052038582, 4.461897218878456, -5.139607458589798, -4.771784296735465, -4.034845832123377, 3.5762222653120856, -4.598597725125806, -4.287909469760134, -4.650047736993305, 3.601705748182728, -4.17079290899692, 2.7249344177837935},
    {3.1846300199257604, 4.192439383915754, -2.6272299614841175, -3.925820151269694, 4.259900614742624, 4.814866504063173, -4.696606075875223, -4.749095730225418, -3.8908889733363905, 4.572132376472582, -4.12095573714678, -4.070020893525796, -4.229331175347347, 3.7538612576515518, -4.23927566252737, 3.676864135024825},
    {2.973605103059141, 4.005517665093105, -3.4119784494863437, -3.96669902738277, 4.287043074959624, 4.727337600160643, -4.887468406364494, -4.999198026287752, -4.451175176302165, 4.390587224576657, -4.508947630029215, -4.029511081610848, -4.392138748345355, 4.442625014935336, -4.804129039557154, 3.4670635381614208},
    {2.0485516671464516, 3.4487194393380856, -3.8014691285232973, -4.5266173690296885, 3.4167071455149927, 4.142394985932515, -5.299967206265572, -5.231409451738387, -4.480846054023292, 3.526995645908951, -4.941176666960137, -4.801669169482948, -5.03601456571821, 3.9949561788734855, -5.005403538073611, 2.898304502222938},
    {1.9720630113154496, 3.2274734708913266, -3.409550418152421, -4.229495903144504, 3.308573720953717, 3.5019640760282185, -4.987581053456999, -5.177213241423712, -4.084486989983895, 3.286067735584257, -4.883266107322525, -4.256697894026576, -4.8354036160369, 3.5863505994206957, -5.2163340839902315, 2.663048071102373},
    {2.1037310251193966, 2.761132510340283, -3.520234856835702, -4.347798484350692, 3.249685243958986, 4.154642537866622, -5.330699822121455, -4.86488049789295, -3.943959269980879, 3.2506689368575437, -4.667969035932683, -4.676487334989266, -4.3063291608945695, 2.4469614176055767, -4.76149259154431, 1.6439187756011475},
    {-1.5017859527668214, -1.3400617849548144, -2.8892093240058037, -1.4050084921277175, -0.4905899311526679, -1.8794784733758771, -2.3147284159120924, -2.7806004841228438, -1.0094066218529856, -0.9142539680612922, -1.8617206910552977, -0.2723435232331597, -2.030311057175026, -1.114053793315792, -1.189187799665705, -0.925229847316056},
    {-1.5311686119407875, -1.897278760473001, -3.1350938126442225, -1.4901810140089358, -1.4189239075766678, -1.2178383404246604, -2.866004546521906, -1.379174903932254, -2.2142976530593956, -1.500347251941524, -1.6687552889272559, -1.1914491013672617, -2.63849564795343, 0.9095226197824958, -2.6240132841985497, 0.3939657295022955},
    {-2.6800979225073935, -1.3422570711811663, -2.0983184021474086, -2.395198076577432, -2.0819515253102745, -1.5474982186082051, -1.629139306215536, -2.063032336908856, -2.4525157929066768, -1.009991369354436, -1.908956327071986, -2.093285268264309, -2.753063619702717, -2.2229909593304984, -2.6003205277766472, -0.4159179804818701},
    {-0.6061147401037024, 0.4577471517003509, -0.6535497229146829, -1.2806172747796032, 0.3944677664004759, 1.0156942776110434, -0.15748881334032416, -0.44657841399961307, -0.6290144970338297, -0.25687456205377807, -0.38887488890872834, -0.5848631137522942, -0.511474275138021, 0.264019078519777, -0.7154172332788348, 1.585846026816102},
    {-2.1595425474587344, -0.7258349635255514, -3.042602567374235, -1.7274243914152263, -0.31589799454599293, -0.26246953246281235, -2.72423659242855, -3.2927187513041565, -2.582264168633939, -0.886892468599183, -1.9297097641890155, -2.2291871173476734, -2.9429010435201364, 0.2646155027837233, -2.5399243974042505, 0.6690084933123582},
    {-1.6280695059473465, -1.7574744156349078, -2.463029437887652, -1.189712290574706, -1.743855238127103, -1.118975989333954, -1.7298464977326793, -1.7473705839440838, -1.4074228965120152, -1.2179906093396062, -0.751984526643337, -1.1557189949299853, -1.5617390585973778, -0.7427041085418903, -2.074573176995478, 0.1531161032851211},
    {-2.0857527580556305, -1.4971135701803986, -3.133655704137284, -2.2742107993114544, -0.9146360646593871, -1.3783613413508842, -2.4086764607258804, -2.836574394310144, -2.3709771845246084, -1.058127354809305, -1.6535230093884445, -1.4250490799740076, -2.381255178676931, -0.7003050222672513, -2.78621076918137, -0.005104269293370297},
    {-1.5587894412110541, -1.6601012221858968, -3.2370407201379776, -2.121304674758496, -1.2277843044118226, -0.5371425175708644, -1.9553154227649154, -2.8822476292085826, -2.5815300025999206, -1.1132326309688478, -1.0359456961833524, -1.7276855179292023, -2.895251076041796, -0.5097975272532288, -2.4586026392588844, 0.41255540475092145},
    {-1.190396691232178, -0.43244056677698783, -2.01413317500957, -1.280863852166959, -0.4010878931540001, 0.32730229799970945, -1.5841560592693917, -1.4794529336721896, -1.217544388553936, -0.10219377953966803, -0.8554092689784982, -0.8478983523546236, -1.7251954917098704, 0.5906354427359187, -1.9682901302226041, 1.2525210438361178},
    {-2.797995659444345, -1.9151964671568653, -3.8391645841292923, -2.9668809119883326, -1.5308955618836617, -1.0727779943911993, -3.4072573738391885, -3.450271607395595, -3.22347805685512, -0.5777709636725289, -2.5456203570998297, -2.448085081289321, -3.3269913072264026, -0.9136878812869075, -3.526160097697375, -0.6791281657352276},
    {-2.6942585818370897, -1.9638807432652032, -3.239545881587675, -2.448955627063537, -1.7175718287616508, -2.2352801426782247, -2.696255332615966, -3.0828554761428735, -2.492314849102174, -2.1135606442293824, -3.0166189796911165, -1.9973026701334955, -2.55733905624886, -1.341981798639078, -2.4267845705212863, -0.010894523135038022},
    {-2.8286074003345334, -1.4620760135370006, -2.3485036909242116, -2.451393397314853, -1.8987202523369073, -1.2346805819759705, -1.9354863365289459, -2.836390188037407, -1.9355062248736545, -1.2519289198417718, -1.8701691737232116, -1.6396343748547444, -2.281054256647946, -1.3402296784413987, -2.4045953088817424, 0.35992762598699585},
    {-2.534751917772615, -1.918479293603107, -3.451277943262922, -3.0675324653692746, -1.61425830827439, -1.4603000213466029, -3.023197869608427, -3.422844220580877, -3.258020828204932, -1.4059835558659237, -3.38980249435602, -2.58930591364139, -3.536701355848182, -1.1766063506664093, -3.2791825897917346, -0.020202561272591922},
    {-2.6711348118888694, -1.817900299850959, -3.2538408458534147, -2.6710636160316037, -1.8525515283730933, -1.2807601787838478, -2.9995605382820885, -2.856306519203005, -2.7435729857564737, -1.1491590018047457, -2.6308894646655476, -2.4230880837255513, -2.982769665090652, -1.3220695619316263, -2.8715927402146977, -0.4814641260974996},
    {-2.266680151017598, -1.8118531949462011, -3.398347216764332, -2.440025085360916, -1.897876329021547, -1.5061446025120766, -2.8527775293443414, -2.9843510604787915, -2.4417904972685216, -0.8121974866508823, -2.156995566930964, -2.1619043532272824, -2.7187483403348263, -0.9394373329258521, -2.7250513188837817, 0.401863470094469},
    {-3.6690616999482546, -3.3292492575059747, -3.6216531481811027, -2.2006086174017363, -3.0635777978521315, -2.724695752688023, -2.8164609510596437, -3.1236121523999882, -2.776949050556964, -1.3934354442614996, -1.9175544129774498, -2.4779540347095845, -2.9937196284480754, -2.4156229322314204, -3.226409583689812, -0.40881042625629366},
    {-2.3068220062746043, -1.8556910536030804, -3.6747874037648893, -3.009913252084258, -2.1965412562331785, -1.1855505910793367, -2.2586761854599904, -3.6498372717317547, -3.3265163477605624, -1.110758199233878, -2.880674902412584, -2.7891268673038074, -3.0602344801583294, -0.827264929922916, -3.2922042949277, 0.26008731904351284},
    {-2.2120980252216356, -1.6846724826357145, -3.2344754530755857, -2.695109641536189, -2.3396471044127183, -0.7372811642841008, -2.976339226174249, -3.356251537153063, -2.6913205745948536, -1.2960953392245342, -1.848448006965184, -2.4302871024730317, -3.200591876533432, -0.3843920821189287, -3.3628356898437355, 0.5688196986981301},
    {-3.3076815176867282, -2.7054020222336774, -3.528605324467471, -2.329349484208534, -3.407940448719301, -2.674154317033974, -2.7027733861047927, -3.532025211188683, -2.8297728770563575, -1.4680822236199176, -2.0221449296803184, -2.600608903776409, -2.975455097923321, -1.7802181654446414, -3.060926211845975, 0.18834951923572796},
    {-4.094401175468434, -3.590423943072638, -4.710928903611501, -2.984156788255217, -3.5827690582555345, -3.040606019865156, -3.7868397252224346, -3.997188186311887, -3.3495307032853723, -2.2427533694591495, -2.504566065714729, -2.999465250850429, -3.3315283736533634, -2.5948284814275997, -3.963311955373557, 0.015562242673343999},
    {-3.982523883431953, -2.2932736824702578, -4.995192951223244, -3.9369569017034576, -2.0851115368114828, -2.093051943980334, -4.551984988457927, -4.961556952169279, -4.229825026944759, -2.0331219699370884, -3.985765430555206, -4.288041248543126, -4.434312362046171, -2.3407375010732747, -4.80114678110527, 0.48192059387456354},
    {-4.416061398260972, -3.0553761293622492, -5.382653555772479, -4.05015295695709, -2.7626646907125756, -2.6429466516412656, -4.914701787277972, -4.7682835456351045, -4.324503757649501, -1.370636621494679, -4.367575822905415, -4.2006749906656635, -4.836262789328858, -1.8560277295165968, -4.809076469133995, 0.6449045081669524},
    {-3.9117595834264556, -3.457375852974741, -4.640490127310529, -2.8142554602357768, -3.786370248298431, -3.4029082311395777, -3.100895282291838, -3.701767985898685, -3.1424564882074, -0.7493214105320856, -2.5351322615165373, -2.3146234027344175, -3.7641923578154888, -2.0786242442900438, -3.5521891007529627, 1.1492959005445993},
    {-3.013820285432583, -1.8751649418187752, -4.198161447152066, -2.9160560328006637, -2.162434447531789, -1.856191838455466, -2.979944769091433, -3.8982485845946613, -3.4015651978951236, 0.03476762048243163, -2.62891806326296, -2.223013779466767, -3.521160508088082, -0.6974909140203842, -3.6982506522780216, 0.8109113192664223},
    {-1.9987201643666324, -1.9114306042536215, -4.5415816281884736, -3.440560747031235, -2.00015636191612, -1.488052201854309, -3.495931701291741, -4.520117615969607, -3.6641003032117987, -0.5064480795999595, -2.763650052667864, -2.642646585209696, -3.4054941331946296, -0.8290058804064245, -3.487227890276692, 0.9306284416256291},
    {-2.6473473498286886, -1.2020608518625362, -4.361356496907298, -2.6252661921646046, -1.3850245098514309, -0.9525956574868356, -1.908895050996604, -3.8085028717500875, -2.5084940182820303, 0.21669259074842878, -2.131092138424228, -1.906271204778457, -3.3488396477693056, -0.9934515678806565, -2.9884750814909706, 2.4165315603928894},
    {-3.700632230794935, -2.880167354056241, -5.357067437923176, -2.3904875250395548, -2.7658011047097197, -3.136083211970883, -3.304200909561611, -4.265944362216886, -3.039574394807642, -0.9806785443727096, -2.2334007911204283, -2.0737796899517935, -3.3320204210702866, -0.9426640413067204, -3.4484728654104604, 1.0328314974307022},
    {-3.0258438880746334, -3.043543883456159, -4.5363218626078226, -2.0306925716071462, -2.3231094740600704, -2.6735793663219036, -1.7978661149255444, -3.4638074224916546, -1.4961873759735231, -0.8050962156539796, -1.5281890412722523, -1.4384241116965248, -2.24286360734579, -1.0801710250084808, -2.3075015920693716, 1.0703715629904869},
    {-3.514631472376611, -2.850462645181405, -4.405820297061386, -1.9436794091253653, -3.1047550240319044, -3.0812570551504317, -2.05860970694041, -3.5927273456880178, -2.2742126431686422, -0.6261080193516009, -1.7604039492973644, -1.6978622157467707, -3.3886824735393453, -1.3585583733694968, -3.1145187399081378, 1.0035427687054637},
    {-3.207146109694108, -3.240349284644344, -4.588148383288049, -2.3129628601127923, -2.545444774878239, -2.0226088247199674, -2.703886442130011, -3.3726398626764817, -2.4431255510375673, -0.11548246962766087, -1.3204461394590155, -2.3094294102754387, -1.9963045461181137, -1.4414981104920057, -2.5623072086932743, 0.8843751278907042},
    {-2.0490128110475174, -1.6343635301010955, 1.585257191339502, 2.6979111725052376, -1.736957369477179, -2.0212691187867367, 1.5647147771299694, 2.1654025618414123, 2.5023472351884952, -1.3090498273989852, 2.926940775329651, 1.345804364608922, 2.019163717175202, -1.6153979509727854, 2.205354859140805, -0.8404706526447155},
    {-1.4857663157235765, -1.719845915198531, 0.9623447034310324, 2.1461350268084574, -1.937898744353437, -1.7752639418709844, 0.8310381551772706, 1.4402593084990971, 2.1093330920295212, -1.0972818447304076, 2.505334485936027, 1.2515283947128297, 1.4303811240656144, -1.4347632785084792, 1.7472182727237602, -1.3045954602461138},
    {-1.8677309856235456, -2.487549207003261, 2.046599292815591, 3.0459147899719414, -2.1238887026871, -2.194357919923229, 2.162776603337666, 2.372145894309639, 2.7670209278798477, -1.1986568675795148, 3.713756586111005, 2.280756834709914, 2.110309242166981, -1.5268967872836663, 2.6645132051145883, -0.42064826141534056},
    {-0.9658286084470035, -1.9478612121376877, 1.9069624826334035, 2.7141969364897895, -1.6222861140960037, -1.6608712289386234, 1.8432054778374993, 2.212997405960588, 2.377248861885602, -1.5258225475522857, 3.504684356339907, 1.869803090846504, 2.075436386030735, -1.7083809138892265, 2.3003399272579794, -0.7882609428742868},
    {-1.655337577712672, -2.2048742607153686, 1.7233654980817408, 2.2107629529960504, -1.806451756664607, -1.8538429821433227, 1.555600361890689, 1.8845913405606922, 2.078393216056773, -1.8426621895372843, 2.953895470012168, 1.3925278986605252, 1.985895504784129, -1.6894949474292322, 1.9638047752139502, -1.3759011108720733},
    {-2.2306351354220904, -2.818875369926034, 0.6385522287142187, 2.795751682438145, -2.2199671112465142, -2.3372694613534266, 1.8323582118258968, 2.050197418124604, 2.4042241580303725, -2.2075780247774603, 3.4219423744841935, 1.987312607371014, 1.9026748081248963, -1.7089676098935154, 2.2812704549881557, -1.0010149912467026},
    {-2.4895422199731048, -2.9815461255362137, 0.3117878481674842, 2.8258481686399244, -2.6931472170253885, -2.5009051638427056, 1.3600118090508213, 1.9867997635193013, 2.3305666459510523, -2.34759513765254, 3.508401058029359, 1.8465001107262495, 1.8342301845697024, -2.0169236871834624, 1.988226741038815, -1.051678877711097},
    {-2.888517470393503, -3.181148926790868, 0.6496130895108014, 2.294202936033248, -2.7197972311131924, -2.9898144278952707, 1.2679840206259634, 1.2486792345682816, 1.852833297616436, -2.797343086666322, 3.041580846291374, 1.3849522407317556, 1.436555614465085, -2.6637990989883953, 1.7535004755545538, -2.5288622801796077},
    {-2.5808583922170865, -3.0232267981284386, 1.0866117480441384, 2.79405742889108, -2.8526467855434943, -2.8021555981760082, 2.116921754753055, 2.319606921612536, 2.686575441901996, -2.6733244008153756, 3.6831457078065917, 2.004977401901812, 2.1609952766020633, -2.43797634982693, 2.535563038215549, -2.4883413420424914},
    {-2.9339111341926642, -3.3995842887187706, 0.1536737173395139, 2.5800097319607387, -2.902487291429685, -2.761233553604771, 1.2748890157621824, 1.7488214068543813, 2.1463037706775654, -2.628317693656019, 3.076477583473786, 1.5031306246570695, 1.7778935343825613, -2.7243081110064042, 2.074980386969891, -2.3777426329458953},
    {-2.8510717229671187, -2.7584885188338206, 0.15979310157425133, 2.2486143994216805, -2.403455802789367, -2.382537791723563, 1.2906247050126718, 1.4353315557312598, 2.0487309981529727, -2.186814166873311, 2.959930857906144, 1.4528008803010704, 1.4783752672849961, -1.8832236301524325, 1.80198213857155, -1.5990748849103376},
    {-2.1611097423015275, -2.0531566289919034, 0.7365361241865617, 2.5878895581249246, -2.1103119825359817, -2.156420902542773, 1.374342333558178, 1.6674582945084997, 2.2857667685968686, -1.389468384954489, 3.139004220061544, 1.6326518113535609, 1.6239492050461704, -1.8338527672992275, 1.9837533727810166, -1.5142390821748812},
    {-2.114096416667172, -2.148102556696468, 0.05224401681604943, 1.951617086368129, -2.267641062562152, -1.9064317239525477, 0.3974498781662807, 0.7765277621703367, 1.4657622267250394, -1.7703214171335977, 2.599093669166072, 1.0827321503978475, 1.0992529952940444, -1.9490619491472119, 1.5560385351414807, -1.8030332444774626},
    {-1.9960435547425708, -2.5379146913750033, -0.5531637266628313, 0.8927466196356322, -2.6121761224218094, -2.5243735841044166, -0.008977159469947137, 0.38560084264756517, 0.8066019495144034, -2.265440064979338, 1.4826400319583404, 0.17396227990848923, 0.40753265104764874, -2.2171982589028825, 0.5797925180806471, -1.7842990104814769},
    {-1.8985933061558475, -2.508994403030029, 0.21266184074338138, 1.6384123565289974, -2.223482030535954, -2.543641358556442, 0.8509774550029233, 0.9445596579147045, 1.262167375013105, -1.7633159626835258, 1.79970521152465, 1.0443116463821012, 0.9946433024690086, -2.1952601808569048, 1.1737668613910446, -1.2899547414670007},
    {-2.145947870232383, -2.923270602302498, 1.1756093931921197, 3.018101937194999, -2.36315428133436, -2.645583189039849, 1.8406748031304787, 2.460789796394879, 2.476945835879581, -2.3807665339860655, 3.289747685889031, 2.1376460489007307, 2.075044576234701, -2.2315053309677997, 2.454140686912367, -1.32337279699284},
    {-2.2922691957878865, -2.246279786742762, 1.172558528276534, 3.1918485066729154, -2.1753538967233887, -2.1141500464796574, 1.837347637600735, 2.725482242142783, 2.6303420768499834, -1.4415207668039083, 3.8921266027017003, 2.309159747429173, 2.2166617223118514, -1.5380220659969235, 2.511711217131359, -1.2048367077342985},
    {-2.5419883988207324, -3.0919857059540363, 0.5522029732806478, 2.565589242163057, -2.6513769858115324, -2.861355398989467, 1.5117174672943636, 1.927578914711075, 2.1699769694078883, -2.0380142015353253, 3.1516185632783857, 1.5195403721950473, 1.9927201132303267, -2.2518662412998913, 1.7786285142398544, -1.547344590831786},
    {-1.9083635641189178, -2.3488905299466523, 0.7070925675952975, 2.7668449226029206, -2.3364023675948262, -2.233177952946753, 1.4643224506739883, 1.7417339547443755, 2.217962451952317, -1.6235830113496488, 3.1051558105672274, 1.4995764925987736, 1.2836553084420932, -1.2167601509193677, 1.8900660214652063, -0.9087950724753429},
    {-2.296686228453851, -2.9273449284373463, 1.215837025388578, 3.363524767375798, -2.4877197140332097, -2.5312295304619954, 1.965224118506009, 2.6831289777992353, 3.0458530397267487, -2.073927455250727, 3.837953433161135, 2.134602682638964, 2.4354324126966835, -2.1010329421670635, 2.601400551726531, -1.3148737072964818},
    {-1.6300791281140485, -2.645902178366322, 1.7277709140337234, 2.9043123367342405, -2.234191279258666, -2.200762667833049, 1.9295743516107446, 2.554894429778352, 2.596468185987649, -2.6724877170418884, 3.8324694350116735, 1.8252331914317457, 2.0868859680540184, -2.4829916929306393, 2.4722160698361795, -1.3701696400967032},
    {-1.8586349054687312, -2.4426681136749786, 1.1513559478721858, 3.1483729114109433, -2.2398875533504605, -2.279803449654601, 1.7932651575469587, 2.340423977514814, 2.5202845178105435, -1.7853567242474924, 3.638322437023704, 1.843822732150836, 1.7827061374800415, -1.8020906812501991, 2.2081092645926175, -0.7305379986228855},
    {-1.526990194885322, -1.9577897955196244, 1.6150521078687379, 3.0552894007572617, -1.8216065352313535, -1.5941730614080067, 1.680110500760419, 2.461480321561461, 2.526773786259155, -1.1578120826252432, 3.861256555442081, 1.8403425179808848, 1.8680141932520478, -1.4525600992290075, 2.5648051934840526, -0.6832280463191189},
    {-2.3945382019030395, -2.3863334758104453, 1.0236776797066525, 2.591412007067032, -2.656732518241821, -2.336046683003856, 0.9976244111577612, 1.7451263214423978, 2.3835716539971914, -2.037216065083505, 3.5851096741710897, 1.5439462033806706, 1.4885658090533285, -2.1574234840642377, 1.951233781148788, -1.6591964654440603},
    {-2.1638389717367508, -2.66668631685786, 1.5821039999581452, 2.4305794149500186, -2.493556726284939, -2.045912424841632, 0.8652848121906862, 1.6814825573565766, 2.014371964712721, -2.0805179684721495, 2.9076376249722515, 1.2992091381203839, 1.1294283438920163, -2.1248824555959986, 1.664684939945535, -0.9311144503322549},
    {-3.2007439525007237, -3.34810877632356, 1.0453124119229285, 2.8958673012561733, -3.3458410056905183, -3.320779253418394, 0.8917438673848566, 2.167340802981066, 2.0230504466176016, -2.5892942113325117, 3.2531579457422346, 1.3307604197150185, 1.4547613691113537, -2.8613314488363035, 1.692227551618806, -1.9329570653595387},
    {-3.118093743136792, -3.3133866162791255, 0.5314898362520551, 2.7930127154781093, -3.5485832440554055, -3.2889353690389758, 1.503958002453563, 2.556997408587288, 2.5868288614734842, -2.401241175367529, 3.800458107869354, 1.5458231858531386, 1.9646669217165715, -2.940797058395577, 2.1859282497178594, -1.5098387172785288},
    {-3.176735671515795, -2.934379763357158, 1.0467014317224093, 3.5428768149819763, -2.893067108311768, -2.68535427557683, 2.2141987283171956, 2.7612673885818695, 3.1416950934924626, -1.9938790914616917, 3.7761510402980014, 2.621257004596146, 2.4832650319648075, -2.217517196918387, 2.7414838036765983, -0.7651641093872446},
    {-3.1238577591812775, -2.9587485451450815, 0.519891344112494, 2.8502711717856237, -2.9039291711170594, -2.7120164537993934, 1.6664339729886521, 2.422223897391993, 2.2656747992146333, -1.6217175931877992, 3.397544046731861, 2.043316281969155, 1.781998093830501, -2.2993439193817595, 2.3347727036511676, -1.0149421666018728},
    {-3.2853119890471727, -3.5620257231373413, 1.294949941338456, 3.335909100149886, -3.1575026366699217, -3.1728058352307396, 1.8331260656166046, 3.0112805324023526, 3.00506088488049, -2.591351979655145, 3.9719367695766477, 2.277472209414893, 2.177867959952398, -2.6651945154894947, 2.561368141106189, -1.5496171063169917},
    {-0.21204155874204803, 0.08610438502183348, -0.6741873507751847, -0.11923577332851712, 0.7161869223901522, -0.20450601222297765, 0.5233521036416281, -0.6913188973818434, -0.381654791606887, 1.033432915723512, 0.49166966168668996, 0.8499640068378039, 0.9458423830806676, 0.19209861783476173, 1.8464584290876782, 1.0626965016101764},
    {-2.4571260951862093, -0.4189129224947655, -0.8691227221685918, -1.074114499574172, -1.2605071838788016, -1.4434426848769548, -0.2769598089575139, -1.7428270418048137, -1.4817773445880416, -0.9409816679633792, -1.2233007373324745, -1.239561316565821, -2.4974210233699714, -0.4079974733638011, -2.495818776156004, 0.8629155855795773},
    {-1.1238993713857557, -1.12553400946762, -1.4897540976477026, -1.3304352147776268, -0.7588007448425922, -0.3518569440098425, -1.3494343694298565, -1.1134979006989059, -0.6872731343478933, -0.19356582842202194, -0.5081221813902282, -0.898496354506222, -0.4703130743921591, -1.6708675988936281, -1.2036654369580206, 0.4185065926864492},
    {0.16095100844655744, -0.18077621073408726, -0.41336408697078825, -0.5172176220594787, -0.1820646502834995, 0.444125524343164, 0.25405368443237214, 0.037508789269209974, -0.20367460632768195, 0.49841836657347416, 0.3138426071794219, 0.3983221260194697, 0.028666961199503516, 0.49437814245959555, 0.009783359613621296, 1.3306963762043278},
    {-2.3771009015233417, -2.4107198342752247, -3.3779237080140128, -0.9826574779251991, -1.4537365451635746, -1.398475573366347, -2.2366276283907127, -2.7577091860364407, -1.8070923634486833, -0.8479979662741174, -1.2183918474614075, -1.5929006394752923, -2.026960581439306, -1.1722497137966856, -2.1665954776755147, -0.03755131939489495},
    {-1.421164719539812, -1.101953546632541, -2.4628758798996873, -1.3304047878997498, -1.093167834304236, -0.7989053679998125, -1.5472400978842307, -2.1098602988516966, -1.8264147171627272, -0.6384610818559198, -0.926838804780987, -1.921805730586948, -1.8985365574160278, -0.5748396663230253, -1.7400099476588031, -0.10296797715914674},
    {-1.8747936644113665, -1.2692360839365675, -2.2040487468087018, -1.0809165988099145, -0.3205730279219562, -0.646153404481905, -1.1691810354969185, -1.8660012137525162, -1.6161225940114554, -0.48320080462971043, -0.7085580169926291, -0.9093723015192576, -1.3126386968436972, -0.5052270019769779, -1.4990800959064967, 0.4791493253918934},
    {-1.1412767530757169, -1.0828128929618592, -2.7635014936409217, -2.0625097761784428, -0.453267929308176, -0.05586114105334575, -1.625602371049486, -2.53433984660607, -2.0657304870656845, -0.4087597123632285, -1.0934869350842666, -1.448697361669429, -1.8990897911016758, 0.16991079961997768, -2.16163214573595, 0.36361940401233706},
    {-1.0661419990094942, -0.4690377525665773, -2.0046944968482783, -1.4985787387931278, -0.31586271337951743, -0.16434697623503033, -1.132797358650482, -1.816523934069611, -1.2900272247557976, -0.5124416281789229, -1.0231597885306676, -1.1465528212321874, -1.6419446958168638, -0.27138626312498254, -1.6078326043696396, 0.5626720726807737},
    {-2.1823921286079013, -1.4386557360390015, -2.831837046612356, -1.527332490338155, -1.0628073810983951, -1.2024209260537684, -1.8257439228313208, -1.9851424196817138, -1.7723350097634993, -0.8108413113020307, -1.1396997106065192, -1.3807371634631822, -1.9311844905593742, -1.3755198262848818, -1.9578038522861372, -0.4033307235833633},
    {-1.9294629728764716, -1.4561376140341458, -2.0195521201065754, -1.5867801962343073, -1.4325799378741964, -1.6641086621949992, -1.4475663193176262, -1.9533549932938843, -1.4282670819732517, -1.1396848680521807, -1.5766433434717817, -0.5424496873100149, -1.4710056561315874, -0.9497412068982912, -1.6051791348546327, -0.35871778823242023},
    {-2.824871611173959, -2.147624665803562, -3.2069041630479975, -2.445097203072046, -2.3893236675672584, -2.237267227161638, -2.339307593396308, -3.0389795206983266, -2.410908060186608, -1.7106295106109484, -1.8969465360802813, -2.0202199776356906, -2.1145327807038856, -1.7198007660403012, -2.46095411578003, -0.14198264034181152},
    {-1.8342734194078478, -1.3544609104597363, -2.7989331830093342, -2.556039008562162, -1.0787695342387251, -1.3246613817282606, -2.2429561041354256, -2.981157350478375, -3.03070384910899, -0.530812632386123, -3.1612348683355664, -2.1210743953465045, -2.4842560394734274, -0.6129316285761505, -2.8972814890364416, 0.545144342527204},
    {-2.499988094795976, -1.8083885474433818, -2.898472306456001, -2.7134411042350126, -1.8630267854090579, -1.3484288224614873, -2.320132833503281, -2.8626969417497254, -2.685098069203514, -0.3800633557173601, -2.966154852095592, -2.3265608871281107, -2.400619425361232, -1.5293124176781914, -2.8668532785088416, -0.10173914176527037},
    {-2.740567896752867, -1.6481575827991184, -3.2791587930420802, -2.118716132831818, -1.8814063889438386, -1.36653519605885, -2.285522387727987, -2.823693434140885, -2.351446567264698, 0.3293733633841489, -1.8114475588012595, -1.861654094270443, -2.6010113921425466, -0.9568192872797914, -2.6236926721361096, 0.4646212133426055},
    {-2.67594331146865, -2.299090998105524, -2.799177633020241, -1.373871850169756, -2.3522356603473593, -2.3350432243363684, -1.0123134521262707, -1.7819363795458565, -1.279925327160929, -0.5666408891515721, -0.6453430326861048, -0.7600498592781963, -1.3460972428416218, -1.7931622009937456, -1.629536097048084, 0.31808524360955875},
    {-2.788044846498554, -1.791381828041705, -3.759709108266236, -2.810559825687911, -2.0871647441334016, -1.7525033992741796, -1.9917019854013356, -3.395526386523053, -2.8368196319997114, -0.8011523848566909, -2.7103497222745565, -2.3279005188689648, -1.9967069318443207, -1.4536513853142714, -2.9850407506109495, 0.420346250988182},
    {-3.4536944147678668, -2.6156863590021424, -3.3602906132474315, -2.2543242901091913, -2.543781658622526, -2.0698191716524956, -2.0525429575700804, -2.786050994127704, -2.4720662354190672, -0.9658548393521195, -2.50061780732759, -2.3275794614831775, -2.233916569444457, -2.364963338172161, -2.6721001049231905, 0.6008042227785453},
    {-2.8431320222984104, -2.485758886729334, -2.4865244982205006, -1.3585553504922703, -2.2883655817165107, -2.008824394304402, -1.407091612736062, -2.3819014121073288, -1.4696373314116868, -0.5000572877453393, -0.6746501395764082, -0.9505335947017615, -1.765362591434764, -1.5194383195544887, -1.7897809231541941, 1.0773882935050132},
    {-3.60384831671925, -3.3332490538270974, -3.5524959739367965, -1.6553815075076244, -3.147859930496724, -2.81349610194592, -1.9569903613990014, -2.7105580252075883, -2.3134467751050067, -1.5118394272830051, -1.0086232046826245, -1.3707326932735293, -2.0159254969305005, -2.6068726872331873, -2.2194203838413777, 0.35484385443570626},
    {-3.435768225122749, -2.7474962924232496, -4.104951988173967, -2.621703394413837, -2.6915267924658495, -2.7430025591301197, -2.509757525275338, -3.726903038007224, -2.7307339142511675, -0.6966495853977722, -2.606952330860403, -2.0566160715063027, -2.1310563411604693, -2.308768417120714, -2.8389559394021298, 0.7347028140649359},
    {-3.8686790818306456, -3.8565757303966066, -4.3376417304482295, -2.7046991843405106, -3.855308057945915, -3.649728090018532, -2.758348540871296, -3.1843041786150286, -2.7244121717123626, -0.6236545494630418, -2.567917434020554, -2.8155901559721066, -2.2770698890132763, -3.8375647945709077, -3.141499766661886, 0.6700934688538485},
    {-3.4132614594342914, -3.3928803247886363, -2.728399057136079, -1.393600486805205, -3.1504675712868653, -3.159339510899121, -0.34193886401122964, -1.5498917750583703, -1.0345687477395393, 0.0023011202412406345, 0.13855592988330473, -0.5214042665074422, -1.0237104377227468, -2.6312353346663646, -1.1275236776951072, 1.5417896640206534},
    {-3.0322860376670038, -2.5804024234203893, -2.8716197956085026, -1.5353325278009173, -2.2753265574303194, -2.5549941937325773, -1.003713338893445, -2.152527312386581, -1.7347213374625874, 0.0022500416144757805, -0.9879070906825083, -1.0014279816299627, -1.3369258974564235, -2.1924690859792215, -2.0539589318644706, 1.2998900438450216},
    {-3.2184361730604665, -3.0133063689749835, -3.9356227740743566, -2.3913312705387284, -2.75395907350007, -2.9612588484426046, -2.552440565557646, -3.0373257725777365, -2.4480382953156274, -0.7923950878106677, -2.029536416733465, -1.9712921427241603, -2.33965301128262, -2.4775866196150407, -2.546103500461142, 0.7570774691346169},
    {-3.160155061295837, -2.0246405710725455, -3.3659841551431513, -1.144162247890291, -1.9760927494518519, -2.5986051308668814, -0.09381878394722315, -1.7597544262351792, -0.7226272066011749, 0.4632914112771341, -0.01644034945236421, -0.6088990736556681, -1.5265875509852573, -2.392314996118007, -1.4027819588734372, 2.8830038289278423},
    {-4.267124467013533, -3.426729134568423, -4.613181822065567, -1.8172819654299606, -3.290713917419449, -4.0208724059668866, -1.741419771843621, -3.4140524881370085, -2.2483271960418723, -0.1977938570275935, -1.2726838661940225, -1.280373795724464, -2.318690258589113, -3.079881829008841, -2.658257899926256, 1.0909592111684634},
    {-3.778104333649227, -3.480057569998742, -3.8804391940979728, -1.6944212553978426, -2.8757841504151207, -3.3018849855227352, -0.9586102397771555, -2.370554964129695, -1.2198910414566198, -0.14521361081494763, -0.6979208725393271, -0.7958234341651029, -1.1188903570043904, -2.884083003861324, -1.4920677175117896, 1.020423671584478},
    {-3.908222044120727, -3.147263067643398, -3.7648329413472053, -1.8531698871171611, -3.318247518646993, -3.8924902116411255, -1.2896186094448214, -2.9586501643271195, -2.0434818095997356, 0.0483538180045005, -0.8074403721913601, -1.0809245139373305, -2.2143439634134165, -2.8418251299551542, -2.359285481991077, 1.8055136608840316},
    {-3.5829710001676185, -3.2462408924574206, -4.14859267604242, -2.0330810748243486, -3.215534382949873, -3.1951634361408194, -1.6270318054335602, -2.9012936316378855, -2.3370585220904214, 0.8208269364589353, -0.6689870799987043, -1.840529576904059, -0.41605760462330355, -2.8377780492399123, -1.860947287632832, 0.835191198466406}
};

static const float b1[16] = {5.857067094337152, 5.694033469406523, 5.931877594003622, 6.02872147766601, 5.723194047459916, 5.826089907554063, 6.170926861444731, 5.898435812780896, 5.8077008139714525, 6.377602668559101, 6.3476819623167655, 5.595046814837697, 5.753995369916362, 6.072252667127685, 5.8316190180052825, 6.239105611348994};

static const float w2[16][12] = {
    {-2.9923739694603877, -3.2519256369737244, -2.9076131819123963, -2.7348160100835477, -2.5679991360916525, -2.697647944755005, -2.5135875505410143, -3.346068465120832, -2.4859304769040143, -3.033903398546386, -2.895862539664668, -2.9609651528460312},
    {-2.493896256702986, -2.529946096959264, -1.9461659976652845, -2.8441322994697655, -3.234607191572348, -3.127609453515585, -3.2159714959377546, -2.8421040581205093, -3.0814870975869195, -2.7339056838054665, -2.515003898232643, -2.964917395333854},
    {-2.390770587183348, -2.6698402400747168, -2.3096422044787066, -2.2668388156170023, -2.5816329803867193, -2.7700163030477265, -2.6517363151930455, -2.416214206369984, -2.7169691131213756, -2.7100163109361817, -2.5329382657253925, -2.471698229566674},
    {-3.342288945480683, -3.4832420239376547, -2.280363282917605, -2.3477982250636393, -2.5351651437896594, -2.9300209873171528, -2.858859412775779, -2.603493998182892, -2.547030852406662, -2.676049344886387, -3.1155480288745707, -1.75272899203836},
    {-2.659109702662326, -2.5527921001644214, -3.5661565792852845, -2.276538674940521, -2.0436901784243613, -2.7141102377974313, -3.5196368340769704, -2.5714712754415334, -3.504442808632364, -2.108703746714544, -2.480784995454807, -2.9179129854553527},
    {-3.0324757471596833, -2.725469068027792, -2.8738528538173487, -3.1517077658487826, -2.662363156864065, -3.0327855711848284, -2.6379683553745963, -2.2989514313559183, -2.5127296154375216, -2.6563579565693356, -4.021392722873298, -3.365037890530781},
    {-2.54888784036434, -2.134292336742254, -2.028371053405775, -2.4799116049493937, -2.659271773107718, -2.5928321896478654, -3.2918905836851424, -3.0840645996614064, -2.659131923138597, -2.8448557857931798, -2.9782521810581732, -3.329051663258376},
    {-1.9839671087791981, -2.6686620098184313, -3.1089263990441602, -3.014149707048438, -2.8188814484820583, -2.6784407158550607, -2.290011629578207, -2.997064841752172, -2.56540583390714, -2.5849390979597837, -3.330923132486666, -2.2468958402336727},
    {-3.133746753612357, -1.9224341393599174, -2.321519423260624, -2.3602155328622905, -2.7732082401576896, -2.984094747870491, -1.7006280376503389, -2.6978154249403814, -3.0270838800899478, -1.39001054455129, -2.957423305569101, -2.7780321508243184},
    {-3.289451256493948, -3.421899268790014, -3.7212420814763543, -3.119144428371127, -3.644874491590109, -2.7557270462715717, -3.1988355513183864, -2.880752838505386, -1.9613402278079555, -4.087575255244789, -1.9607495430441146, -3.3790406829581143},
    {-2.3550071832533463, -2.269237525757855, -2.5345611573128513, -2.683732479703041, -2.607836258405984, -2.290379840346445, -2.452806405363732, -2.7236237390938203, -2.01205900769877, -2.714211207910655, -2.3846248302996425, -3.1056700279988982},
    {-2.4582852272710976, -2.292205684537908, -3.2885782134114074, -1.7968322494251279, -1.9339149868537553, -3.201980449222053, -3.4580032409096297, -2.513366289155707, -3.2233064256688744, -3.978300629408696, -1.3269667054317176, -1.981158691567928},
    {-2.986470819123442, -2.9573639736793016, -3.09436582029297, -2.3784359142413223, -2.559903266297394, -1.5016600049094537, -2.0634635839119273, -2.505045442633241, -2.908342639575967, -2.4415663503295613, -3.1846331998726076, -2.9511850560589976},
    {-2.9481490212215338, -3.307193330403934, -2.3932709392256264, -2.99086514562755, -3.5216350174105533, -2.8571728603622426, -2.019382282845391, -3.0940125698246566, -3.641185726240677, -2.899191141308421, -3.0307749863787965, -1.6506017849580743},
    {-2.29289366011164, -3.09441071286535, -2.552195432613693, -3.904622438033192, -2.9032605603617805, -2.6388251621457965, -3.136394486536026, -2.096338620105673, -2.349836812663897, -2.471042898206654, -1.5984057945755104, -2.917147308673392},
    {-3.0505824317124772, -2.0097270561383316, -2.776923382014594, -3.4827371847260276, -2.7003311838910493, -2.532830998752027, -2.6712108196210065, -3.316801227559456, -2.616239232735129, -2.5355689488455027, -3.045532572165388, -2.5061274374721965}
};

static const float b2[12] = {-2.4962479929025427, -3.7245557941657013, -1.5172131578549128, -2.2976278109478576, -2.455698311690078, -1.833160589485102, -2.121049104370428, -2.8680394174017163, -1.5919919358083148, -2.152793718468427, -1.47274445262408, -2.14047872004587};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
