#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.6584246454296684, -0.41719230311887046, 0.23731739576784538, -0.8850195683355714, -0.6021519469353165, -0.8523664499486344, 0.368032614863917, -0.39815693093904525, -0.7650146135859062, -0.3743194335815273, -0.7165081895610567, -0.5592687894803734, -0.632301573021236, -0.7419910661920893, -0.8368377159885222, -0.27678794769073584, -0.3129184094216981, -0.6278753300934302, -0.6406645119137814, 0.38292597543355555, -0.47668862657516897, -0.18732451640343184, 0.21461976397011087, -0.6195994024577469, 0.5938040037632698, -0.8436111578577395, -0.7011808184857408, 0.23155577387296675, 0.277503129581934, -0.8086105108110587, -0.6073356240994265, -0.65821323652121, 0.5289930332078481, -0.6374476934567161, 0.035719387544668094, 0.7660936581417905, -0.1612676001406829, 0.6103002639728946, -0.50622512957582, -0.6410730033813026, -0.6539488203741873, -0.6122207715038372, -0.4878642927657978, -0.1188612211239601, -0.479891502727922, -0.39915245605315464, -0.5223090072463357, 0.23993236319519926, -0.7291138178249169, -0.4402752819979251, -0.4967735556064706, -0.4084108084721225, -0.8695252089823438, -0.8333553021447901, 0.6431937050515821, -0.6920788521432923, 0.22139368689812564, -0.5709062760257371, 0.37485340508799503, -0.5736955574125505, -0.8612625853997323, -0.023453365682135418, -0.14705170574338344, -0.3813829515603424},
    {-0.07803277056246481, 0.3573453767071749, 0.36047419042853585, 0.4574146507691154, 0.44339671974076383, 0.32352844385556595, -0.789826811004195, -0.2742561786478644, -0.2830219138743441, -0.18563992211568217, 0.5727222524022101, 0.7933882620701183, 0.23734821360857097, -0.003020695625447559, 0.4358224332748491, 0.28971552336924605, 0.3985345463066457, -0.49650510287917043, -0.1831897489039869, -0.7231798296632105, -0.3041806534155688, -0.26944066557889934, -0.7321410139602933, 0.31407115517857565, -0.21884351663346516, 0.6800402031481032, 0.599683926278417, -0.41979229510868565, -0.10029887663052114, 0.5763354716923982, 0.3184122848873124, 0.7026871829623433, -0.22298860756629596, 0.4948497499893497, 0.46156072857624875, -0.6991085747808827, -0.2545289922123699, -0.7884762058863735, -0.28210740814388824, 0.43004376814883605, 0.06463561926137981, 0.4898330827189118, 0.2896563889555984, -0.6741439028793484, -0.23451534384870112, 0.5498511615862733, 0.5360578850463038, -0.2239458820831699, -0.00970186395596598, 0.3593883673856596, -0.5283216205880544, 0.3630819767262347, -0.06025656950522715, 0.21549490643794417, -0.163373960004722, -0.29797699547255313, -0.48963835172027337, 0.7261924011494608, -0.49550213881483607, 0.5714369146606579, 0.4417342954420467, 3.390753664696383e-05, 0.2137962250841669, 0.2858661552823725},
    {0.6008133994348318, 0.5970319346755499, -0.28179761219798266, 0.07835699652504295, 0.6166694442697898, -0.06565790949900642, 0.5577946078164933, -0.5778799331865435, 0.3122437369172538, 0.5859013864783593, 0.4403147398310957, 0.41377235762431924, 0.1549527890382819, 0.6572537173127365, 0.5727147813395642, 0.3457453806097884, 0.3403385796069284, 0.3866516152317616, 0.11634597902163257, 0.27054490951510685, 0.2595831687774494, -0.4432435595871566, -0.5260752674442399, 0.20208147703907176, 0.09307960959314067, -0.2277750057555133, 0.4238307931670843, -0.2704296235591932, -0.5847151338754084, 0.26169943891376907, 0.12100208812416256, -0.06157082267887481, -0.28459628320328423, 0.08531641984534749, 0.08494774230246066, -0.16182480006080713, -0.17163279346543908, -0.25543207204144447, -0.055592850291451786, 0.45783334433847483, 0.05032354515559751, -0.11780497518702374, 0.5186556515297638, 0.27986752156123407, 0.02353286878675433, -0.2942214587190163, 0.553645581404033, 0.2577523616443733, 0.22597350902437463, 0.16821439504158953, 0.24782107223198743, 0.4092398270690017, 0.3184099704174991, 0.6816185277086644, -0.0056947206632511045, 0.04647134216536387, -0.23935954583198304, 0.7730834137994004, 0.15253294538549803, 0.6083673865473603, 0.8041037458923602, -0.26146342059869326, 0.6742039918875872, -0.2402326011909141},
    {0.5957622964490621, 0.45898818557109744, 0.2773829644168009, -0.21539923342771394, -0.27748715275220526, 0.2501024588479078, 0.8019803521814094, -0.17260861123977392, 0.7370347377002513, 0.7946289576653989, -0.740919383214236, -0.47036730987063186, 0.2701379316044519, 0.7443183818986356, -0.1510122450289181, -0.28499931148799196, 0.6182394633952362, 0.6370671276810597, 0.6203826144011504, 0.7307032137483532, 0.4773888052225274, -0.21764627256503383, 0.14396278552323247, 0.4276431576143943, 0.4733690552267179, -0.31802903201832466, 0.47653247813391847, 0.5671883096969068, -0.27059885304288944, 0.48622194276893244, -0.6075891656027007, -0.3899192314000779, -0.29673680850978196, -0.542537392169669, 0.4877830407165303, 0.5875051883215314, -0.31042851722122206, 0.2291224758299309, 0.7043429438879759, 0.4108674152090223, 0.5685737293977081, -0.608324474991896, 0.39614135326201416, 0.6551677061723227, 0.47236380303891246, -0.49289718762282075, 0.4893935552893069, 0.7496714517977655, -0.557665661716285, -0.5960549875784661, 0.8615684970652328, -0.28748014449925796, 0.5169156944495967, 0.04090926793056257, 0.006703171138564728, 0.680578838024151, -0.048001934337341234, 0.1613312686277867, 0.6292619976748688, 0.8026896970098414, 0.3865266136850849, -0.5926942113943198, 0.18595020147008198, -0.332367014277575},
    {0.24844698821698802, -0.06905819279035509, -0.4109061465273106, 0.27088359103845283, 0.4455208466980805, 0.01931485582086401, 0.3058441735865553, 0.09653821512078635, 0.05759485624813816, 0.44601557534460834, -0.3612411254195877, -0.0003312344338593485, 0.4054063199620098, 0.6654998646212007, 0.021095505484145523, 0.05195837724567175, -0.4839297501101571, 0.12850986460939895, 0.593454688878364, -0.17035326638991005, 0.3535700467064488, -0.000645183381985001, -0.39359890988102036, 0.347075500024652, -0.5226026867705268, -0.09335384406520668, -0.19111973429804055, -0.40513261710383125, -0.8124787548285989, 0.6826684042027726, 0.07425833786592206, -0.49189432496602914, -0.3030772339187892, 0.23194505500548587, -0.234547833840074, -0.21979391105218177, -0.4240376015749867, -0.45802032592809483, -0.09615248964867251, -0.15689169381322893, 0.41314129163466984, 0.09642730991544747, 0.17562000492882554, -0.13177570830214286, -0.3234145540293587, -0.40312297289364085, 0.5553334666850855, 0.1161198587060614, 0.0031292510147555696, -0.2938128113019976, 0.8182920091889497, 0.520056437560501, 0.49358217322801157, 0.32685299861207223, -0.7376516682605304, 0.04935952739527108, -0.2312004000151179, -0.3460671889795853, 0.0900826167633063, 0.19198673618158693, 0.7184848203952386, -0.022907497111092533, 0.3294361461221258, -0.0557530306996243},
    {0.7483241334246759, -0.01249420953078344, -0.57274726779825, 0.737496309462525, 0.8651834642371309, 0.3896289003481522, 0.3997697654612602, 0.4975926514963451, 0.28808139897396573, 0.7569930598850769, 0.4646470502582422, 0.14885243619345953, 0.4977238486382302, 0.7297057058639402, 0.6293822421464632, 0.3101644018688594, -0.3683680005006647, 0.7415400505374313, 0.6679404427377083, 0.11516912470402191, 0.5643633775105243, 0.6056203711531101, -0.08260184171405086, 0.8483138739583864, -0.6808810544344156, 0.5853925872710379, 0.48631512180852043, -0.18444030716341944, -0.8119869484372532, 0.6435965613079372, 0.5021222123431001, -0.11009950576855974, -0.4760137941222416, 0.7818286939494894, -0.566079033961913, -0.5215101142161916, -0.18961610565804207, -0.2969995572012563, 0.4428181321163908, -0.004212897649438753, 0.6626875917609373, 0.38461499799215065, 0.8446294842534113, 0.5759145315821792, -0.31034148742738055, 0.08490433534643689, 0.36964257116068133, -0.22084865005574555, 0.5562970363378917, 0.14937656669629862, 0.8171780710463046, 0.756633093549002, 0.5563042850696251, 0.664983030922244, -0.5010255878204758, 0.3170393618900776, 0.4603293140092436, 0.20286691252052014, -0.09465259062656951, 0.5819675058550347, 0.7279211863707615, 0.033829104628617615, 0.32904178407266277, 0.4436775124676828},
    {0.6431919580611759, 0.21461610463147512, -0.4533810003481029, 0.5182408115500557, 0.7208008422602331, 0.4476443604285328, 0.15385185225201223, 0.08749429075458934, 0.6021909217036241, 0.7379049140502116, 0.3228524835248439, 0.11870508237368287, 0.8262180428661906, 0.7412548060579496, 0.818348861852948, -0.06748005333010561, -0.13996802271557512, 0.8868545902286441, 0.5381607105741064, -0.10691007299435891, 0.7595219527998249, 0.6020203934214604, 0.16583230049789166, 0.7848636474045065, -0.603868786028785, 0.3626930294405556, 0.5883069775777271, 0.13980585355172515, -0.7519224922550634, 0.43689049637716015, 0.22658734494534213, -0.06970636831175388, -0.33945410900006023, 0.7221096527925247, -0.11676002715949522, -0.6001196300440598, -0.235639597880716, -0.2503219802462904, 0.32928673394907, 0.2012784378686066, 0.4657917097363121, 0.22335400512044998, 0.8210353894593394, 0.48917909418430294, -0.14228307590573125, 0.1021961569850773, 0.5334456528245405, -0.2537480115992241, 0.4489151480581583, 0.3210994913550928, 0.8225984635519002, 0.712002420794123, 0.867426111192479, 0.8054032540498196, -0.6278051844133351, 0.5844243058338443, 0.168182408581085, 0.16390949052960987, -0.32961180270811075, 0.5692889836717554, 0.8790406492959705, -0.07780728124558442, 0.09620414450621098, 0.27558453000154975},
    {0.3938714357072741, 0.01008564962153488, -0.6024677908319509, 0.4016011996134182, 0.5788835838419438, -0.24879704998858956, -0.3525974970237368, -0.6781343949869294, 0.14411169108972868, -0.03930830081014364, 0.18297018565990825, 0.3402961320215908, 0.5592557942124735, 0.39623227537636097, 0.023131592700325113, -0.07918687751036897, -0.6573133674893592, -0.025198021410092572, 0.25356486788715976, -0.5445687077526147, -0.037354711826300846, -0.5357566060531852, -0.5122268099563634, 0.062374016813058555, -0.5078896094648353, -0.3117266924181264, -0.12401905216080517, -0.5409162041490005, -0.29338937982696156, 0.47600602260788916, -0.3712290407097539, 0.3555887596926435, -0.29746122992798846, 0.2069973991685362, -0.3582333266596012, -0.28122728146520537, -0.6510555071690654, -0.6130033339087672, -0.5443211895187928, -0.27265461596873186, 0.4302554908082368, -0.1764620652108792, 0.5484376367693685, -0.5461934017785313, -0.2548266328479033, -0.23983488146356707, 0.560352283670655, -0.1385025631155107, -0.39497507032373985, -0.3948349414897388, 0.2332499976319622, -0.1436376882839992, -0.20012262636975223, -0.2499817196143321, -0.33430099622417797, -0.6189947658379312, -0.08450193786953078, 0.1189401678765471, -0.3255179899353827, 0.4604556999406181, 0.23300245521186863, -0.09367808297463538, 0.622535371724377, -0.3298641287370328},
    {0.016627253643951435, 0.16109840471396353, -0.10990614202232978, 0.5172920691956966, 0.14488536712568667, 0.1359503165449986, -0.2977815342353944, -0.4021591564937486, 0.07768089836516633, -0.44206702697992983, 0.3834886128468245, 0.4581181397791524, 0.3781023960926275, 0.5618939625143816, -0.3492537137025942, 0.2709879960791581, -0.535981784879287, -0.20681696150762993, 0.3842876533472228, -0.3859581857060987, -0.26549500437460916, -0.2800206382503059, -0.4088038163511348, 0.3193408750221831, -0.6535454492486259, 0.3092284665777105, 0.07105938370804202, -0.6470882411597161, -0.5712186684629429, -0.04017169358233675, 0.1756406377946396, 0.17302683611817787, -0.6702442362955355, 0.3085779294730154, -0.18228824378713218, -0.1419428048734807, -0.6194324817985541, -0.6270343272411435, -0.46904982978950344, -0.22938033912502429, 0.45290054964654414, -0.2134504278994297, 0.43993584419872994, -0.6529147553697623, -0.44989216165068424, 0.2117730584510328, 0.5125871946394223, 0.08813528923294682, -0.10298372623914773, 0.11285299763856056, -0.3878300642095027, -0.09042673457202385, 0.1513262370035091, -0.16073476866439876, -0.6224400377904429, -0.6218533722219509, -0.3209846327216351, 0.08231285575298655, -0.26682896495877245, 0.10843453814802338, 0.07467686246760823, -0.5004817302662742, 0.6664475267973138, -0.023513831986857636},
    {0.23580768893232634, -0.005780978561037098, 0.0633264653268092, 0.20159501240928512, 0.43943851344734286, 0.3518668608795466, -0.38329677384533356, 0.005223635035746284, -0.17902474465672605, -0.4297207809117702, 0.5607945937055485, 0.4793025831022634, 0.5805754113244486, 0.2795150816306879, -0.05762979284433177, 0.1557707525978298, -0.3368742589149676, -0.23907488481765085, -0.0010079761207962901, -0.6496585373546859, -0.19909578008822884, 0.27462161338206564, -0.38141457441645943, -0.048906381865089874, -0.16519242462149739, 0.5646241734440305, 0.4315029692493232, -0.5778187150306334, 0.25031062639741675, -0.05120604858687479, 0.3943826780903387, 0.6424587745328963, -0.6183678684909552, 0.4818254389680582, 0.0010437620335522514, -0.4674192805825018, -0.027297163892945144, -0.5925584447665903, -0.5992776086294007, 0.13363379125064456, 0.468620259557361, 0.2010279721897291, -0.04214920440436481, -0.5917017314876825, -0.08278264881055337, 0.43620539680538667, 0.23695682011742472, 0.21590550144885953, 0.15354785886268357, -0.06127692145168395, -0.3652214281729471, -0.2560845064553455, 0.15963922260100583, -0.32513715455777814, -0.3683262764429596, -0.39870947642312204, -0.12832187497184694, 0.25041586939693583, 0.07256601358287047, 0.3627564083482036, -0.05156187817352276, 0.12247523385712243, -0.16716669746856794, 0.38684228663879927},
    {0.4409774880126631, -0.15655454413579376, -0.241902615220356, 0.5212577562350093, 0.41353199438005855, 0.5067885333566462, -0.21081873111639463, 0.12711443747711085, 0.41876160827899434, -0.11874660102784912, -0.13303006502683726, 0.23058191789068053, 0.026584273580124416, 0.3668693331006668, 0.43336024639214876, 0.10730734164314645, -0.10209577591976607, 0.4702907152195597, 0.20027653158353168, -0.2309908509413676, -0.12211682549659936, 0.4122362557243778, 0.22445005596808423, 0.492752423993043, -0.49931507363775457, 0.5937171880600358, 0.6024787465303325, -0.3977754071593202, 0.34873967425873753, 0.21449128212427135, 0.255941898336955, 0.5851549426007664, -0.1611858500957541, 0.44833332892269423, -0.13300353208021032, -0.5241551374460925, -0.3716249395380563, 0.044650473008964284, -0.044850098689086446, 0.44195354995154684, 0.13339626572958915, -0.03309263892438751, -0.18756331205627397, -0.05738569660287242, 0.4981233626927366, -0.0321288185382302, 0.3965811088413059, 0.2608511792488268, 0.18600468278723042, -0.12401557030316739, 0.2207867965052214, 0.08623060330230073, 0.5002696022758398, 0.316153006216054, -0.6958600735608326, 0.3879612454521658, 0.43290096435168357, 0.12963327173230085, 0.4387874639568448, 0.29708249098273015, 0.16314994856478296, -0.4181473368793121, -0.11063308652932492, 0.36465094667038367},
    {0.5316458668371049, 0.43711752131933107, 0.746265348522069, -0.12975304732689025, 0.14198719740375665, 0.5999378358162227, 0.23404926180087887, -0.11886604275539278, 0.4938524991702787, -0.08332774691636781, 0.026423088440949163, 0.24634206590396654, 0.05565990230602453, -0.029189212199762515, 0.26250103779144973, 0.4620705680720924, 0.7806225587292963, -0.23734333711100958, 0.5473823257080173, 0.6350250335290504, 0.6522917424944757, 0.1985112186043422, 0.23069512631823186, -0.15603662457258818, 0.6186151956372321, 0.08506102329833899, 0.5811066474526515, 0.21012618740751815, 0.4378992558324391, 0.13505054416185433, -0.08571453532713391, 0.1766334042964434, -0.274546358100276, -0.3000073590432118, 0.6784819216254849, 0.777216386334865, -0.31881491751537266, -0.015267177456774573, 0.09048996794451622, 0.7505607051307198, -0.12222474784172219, 0.2921614644816205, 0.2733281287784852, 0.2380568904894165, 0.2911253110882762, 0.48857703332269614, 0.2735575480122052, 0.3360090132265561, 0.3939705301365488, -0.1995962217763045, -0.3757355537257014, 0.2093806326772653, -0.15154354231283862, -0.4464690380162187, 0.5882856230773374, 0.28096913782302824, 0.2993516118187969, 0.5753719959280279, 0.22192951847780704, 0.5671702706969307, 0.07553678602559731, 0.29791563145678557, 0.17632774186891043, 0.367146849146483},
    {0.07695281281879054, -0.3765917619312232, -0.35461713254329186, 0.4798559489570345, 0.439853612164903, 0.17605828396435444, -0.7687563453122057, 0.11850358601450486, -0.3386645414526341, -0.4631031871478493, 0.8489938169169233, 0.7882653840353677, -0.47529782134178167, -0.05851957651445519, 0.576558337155358, 0.489002223174756, -0.1420222646850654, -0.3024447933943628, -0.32609111859757506, -0.797786737988821, -0.40892731517683656, 0.2700626146932702, -0.3722979808540089, 0.30647958954960336, -0.7184810181747171, 0.5568916338652281, 0.3328883743134652, -0.06692570689732198, 0.05195729404141118, 0.13782368703664793, 0.8008405888945213, 0.4626217426934322, 0.33308258449630657, 0.4121686769290854, -0.4853737001989569, -0.6465703900836909, 0.13112024463940408, -0.22189823294889566, -0.5461533691444597, -0.19411576934599642, -0.3165655423906013, 0.661891518531882, -0.19270103052240317, -0.15129179995240144, -0.0953470141406077, 0.5001875901431059, 0.4576800544503, -0.7780156590497167, 0.42140163012328435, 0.45233767334156216, -0.320340207121477, 0.631677822424181, -0.265803599807998, 0.7008188846054494, -0.20998973144407573, -0.018281657350474875, 0.23669713935595094, 0.3167588514564984, -0.5292598325454053, -0.6494542533484415, 0.32625826587571316, 0.36087411975196687, -0.260626126240733, 0.6638151432166054},
    {0.4571667678743395, 0.8172374798422929, 0.6930289578525455, 0.2502942704501924, 0.21840240345712839, 0.7051011344746886, 0.47263090635618693, 0.6612425745923851, 0.7397010814753519, 0.6236673966499738, -0.21807855480026747, -0.2099106661530169, 0.4212785389615921, 0.6984942790987722, 0.3949584047136122, 0.2648736669937023, 0.8065920403887356, 0.7412639674414242, 0.5419033792056784, 0.8194791096295265, 0.6256508681216643, 0.42977188254730286, 0.5266567981106589, 0.7801903591735755, 0.7394034167244236, 0.48792122578305125, 0.788468400669254, 0.6047552685325197, -0.02065056361452067, 0.659741457085568, 0.1851441201934289, 0.36150944377091154, 0.03283338934129418, 0.14525097324334227, 0.6767644768135691, 0.5705311528462194, -0.3888301129260566, 0.4041889537450367, 0.5593102994500957, 0.7102739614979857, 0.4138336580203555, 0.4804679075216532, 0.7016378665824267, 0.6947030843941624, 0.6767516650098433, 0.1538225116987745, 0.14390153203888378, 0.6813420441670468, 0.3666557235050552, -0.09716266703526012, 0.6597471324920444, 0.3082765811992704, 0.6542632390007365, 0.3470366432265884, 0.5655604933891497, 0.6242516836424074, 0.6124910904330114, 0.4835198945061328, 0.34817179906879253, 0.7225448311946531, 0.2417165223775774, -0.07642116695024329, -0.21716371241323384, 0.3331245572056719},
    {0.29491137482006585, 0.2864662433831024, -0.032705876074968145, 0.1401885698225622, 0.12307186916401348, -0.008720221275802261, 0.5739282721723756, 0.7355560752091179, 0.6816776224505606, 0.7978959402113984, -0.4702719762056066, -0.6849715681341895, -0.09917636507128477, 0.305883984964626, 0.08224099782867327, 0.30865182203407265, 0.5028619336093803, 0.9694026832093293, 0.5152897091605105, 0.48348104515177553, 0.580999995159153, 0.6343421569011085, 0.49763947091375677, 0.5830202101247728, 0.10738741057584711, 0.4043998098577075, 0.5563197492452757, 0.6834680880474439, 0.11269974591598782, -0.04527573516850748, 0.3610879334533969, -0.012736437476258045, 0.557560618202763, -0.2191712480250049, -0.27525837969917344, 0.5101335768676366, -0.15856715296127302, 0.8371887515793771, 0.5178202153060137, -0.003975575365261351, 0.2084470700202275, 0.565387243643065, 0.26038526691205655, 0.7772064788557415, 0.445510876221453, 0.30421342317242, -0.3852518097696852, 0.10366902213103683, 0.6690055315262576, 0.04597592028508227, 0.9261765297715173, 0.5611993982802795, 0.278147432277206, 0.18640318033142947, -0.11874140256711188, 0.7754965203556683, 0.6021015794895118, -0.03848536595270965, 0.028577049947369527, 0.08105990078195612, -0.48742663783116164, 0.014285159515021623, -0.4543719712074996, 0.24570876864899815},
    {0.09375831041069384, 0.3475355155268904, 0.139867144342758, 0.48906414887970456, 0.22087904891861374, 0.273631251044405, -0.7134765202232183, 0.7017214106559535, -0.23499460004037573, 0.22625131522091113, 0.4272898499374792, -0.02289296559016452, -0.2198082963810676, -0.04201204394312474, 0.5060072277378369, 0.6860928626350543, 0.3610068146242299, 0.5536714726842317, 0.12692200095820766, -0.4707797462941565, -0.10511321421592963, 0.7862959482014548, 0.11294375471090445, 0.4506785965038908, -0.2721360025148316, 0.5848848421853077, 0.5279343612210649, 0.43432395232232, 0.31889955771871786, -0.12007145357901376, 0.8062054402056209, 0.35344075529161834, 0.5077394363568764, 0.5069215505482773, -0.04390407994479901, 0.10914508845009213, 0.29177433749890147, 0.7057797029383205, 0.4908102373847043, -0.3776432500615478, 0.3463527006738826, 0.8001333007101549, 0.18381835773425412, 0.40122655392134055, 0.29058468771550344, 0.8147915058671887, -0.1608671403353347, -0.46229848888298086, 0.7293368269669033, 0.5101149088459003, 0.3047673496075489, 0.7787851519331233, 0.0055489397002375165, 0.6651444156198089, -0.23124507843333678, 0.27542174594741475, 0.7585315523933479, 0.3960635268789392, -0.6560238268452453, -0.28123514045615905, -0.20935961151320204, 0.6329620062691814, -0.3396730587299055, 0.32966522847498253},
    {0.446978698807299, 0.37061077673853987, 0.10301044326189544, 0.5940746584537762, 0.24553649022383975, 0.6299564300849952, 0.3584410174541349, 0.30396913589610397, 0.7084856294773733, 0.7856073567210132, -0.16429655813097296, -0.2988375989378707, 0.6441586453072937, 0.5238061875968003, 0.5477739430382126, -0.1617324335077995, 0.5821190611569512, 0.8508974669839057, 0.7661826957604864, 0.5045405689692963, 0.41910557899469086, 0.7474500813279699, 0.5520987549624323, 0.8689185245101633, -0.005058715732347383, 0.6101001927841535, 0.511155378069805, 0.6223053478142158, 0.13520361130886765, 0.6983514766631288, 0.3779882256241219, 0.1327025345380005, -0.21748531712912847, 0.28058949972039077, 0.0965294326780115, 0.36274082198265245, -0.4405029488788384, 0.4505882625507774, 0.9028096913907714, 0.5827521635934148, 0.5269877083171917, 0.2240633100244163, 0.6688862227713632, 0.877458038985472, 0.49576302339263834, 0.060919896410799985, 0.02466550020782209, 0.6552985812373557, 0.42492731511271803, -0.30995905385534234, 0.7799887109411812, 0.47799055291550824, 0.5613657569137104, 0.5535515975807475, -0.021853750101278623, 0.6212329817980708, 0.6067965427052784, 0.13809740408093762, 0.3478525363706422, 0.7925888661902386, -0.08554393680118531, -0.14514959930409463, -0.6319021087506045, 0.4237037847906355},
    {0.42171559138212245, 0.1490688407914495, 0.06100192489755225, 0.6320753116442, 0.33076408001637597, 0.7324357391699424, -0.028180431486598885, 0.5823971285798702, 0.4043268406947144, 0.4443114216308707, 0.11800664402614096, -0.3109333389420948, 0.4937985198851671, 0.6520377086002271, 0.45115280413988, 0.11023895723919531, 0.27891294944727824, 0.5117252959956143, 0.5813729025452286, 0.3411896399741326, 0.4700925733283602, 0.6119046254473903, 0.41836806742254445, 0.5027873220158039, -0.05644709695552501, 0.7153909180617456, 0.5483931782676981, 0.30002218162259287, 0.0071932973445313275, 0.3780476603700627, 0.5497032006672161, 0.08270879012418458, -0.23391426474003796, 0.14356329707065268, -0.10246610201647967, -0.050374910540882056, -0.30080755242416096, 0.6862832981189151, 0.643663957196855, 0.3496528645637576, 0.6408672828849353, 0.4961866689959709, 0.37114130424539693, 0.7001450602685995, 0.47014406686386134, 0.6758581254370303, 0.271112138876091, 0.30549598660784844, 0.7585295142284544, 0.1717759670610481, 0.7603056261420271, 0.4471690812280439, 0.3841097264411128, 0.6129919623832523, -0.33530625095698724, 0.7535290808130595, 0.7178658205134617, -0.11609755641591862, 0.5211424090708159, 0.570787884152574, 0.08772730807295447, 0.11138839883286623, -0.34245269583211996, 0.4047445333845735},
    {0.15230046117267587, -0.10644233433254131, 0.43836247300923686, -0.15603639352195617, -0.221523180704189, -0.17843627854579638, 0.3967161824298064, 0.39401773097020776, 0.6386975906230499, 0.13517247152840464, -0.20582962445796135, -0.20815197056356438, -0.24517928756949228, -0.14018810940144094, 0.5304100021350739, 0.004466747443442553, 0.6813018956695632, 0.3050134361635049, 0.2179789919330351, 0.4804571782777946, 0.3956991222003168, -0.13030001356589313, 0.5583427792740795, 0.34886502639575456, 0.33901920201148295, 0.2791751704910357, 0.5810160986879157, 0.46140249066724714, 0.07634164526756361, 0.21558359474524133, -0.32293128447178443, 0.0961943644590002, 0.3262842047187877, -0.04499913943384708, 0.2394265088017898, 0.5140680766581611, 0.07911986305858637, 0.3501376147012228, 0.5391277137106207, 0.310584694085018, -0.4508227422015809, -0.2447764250740231, 0.37638299169140593, 0.49124321180149844, 0.38283489150881883, 0.2777964107854705, -0.2942202657406542, 0.14641033391211158, 0.018631671681523413, -0.16571696053204046, 0.5394244886641407, -0.15871598459891845, 0.06687446057055367, -0.20405006578130128, 0.5141272569300804, 0.3240935781762083, 0.5258830653065312, 0.04543179913014759, -0.3779016999225837, 0.442390458057829, -0.4818642683142584, -0.15125865933127927, -0.12357511615309809, -0.2395339757473183},
    {-0.23228689649909393, 0.09113072491285472, 0.3214274412667755, -0.5062816215524062, 0.10051128127061794, -0.18312106464115369, 0.2219399154440652, -0.5352515699142103, 0.6198389208775369, 0.18805007944670082, -0.1976755887725648, -0.03210593453511829, 0.18133476980444438, -0.5342557513401455, 0.18393944918481547, -0.3509734958554468, 0.4588257236173553, 0.6216133970615082, -0.1580537611339039, 0.6932702599251038, 0.2922542124182389, -0.27453204263520276, -0.0015095194572081877, 0.17528294920244264, 0.4950386953160263, -0.08955161665399429, 0.020806262867788805, 0.5833553137059636, 0.3373568757116059, -0.04015854202813991, -0.6436096840889757, 0.25571060693843417, 0.027622924078820204, -0.4604201529410609, 0.4872586196720294, 0.4778213267471558, -0.17720762417993186, 0.08678345834167377, 0.4602012530075326, 0.472852097057333, -0.3250335529936463, -0.6562270814827846, 0.2722811707232866, 0.4228594768847434, 0.6237646933539169, -0.2990063849129899, -0.14556729692322729, 0.282860023653487, -0.5350721462275043, -0.05154178789006009, -0.021215706869237027, -0.21834678530744672, 0.5501828826105091, -0.2149879038242518, 0.38963565473006045, 0.024987665870712782, 0.2306753945734966, 0.43946907615590697, 0.4242290948514472, 0.618271285732891, -0.34891578042004656, -0.6156651896188499, -0.7156047434498595, -0.45444574610121674},
    {-0.28087713203392783, 0.37340856925980354, 0.683146865908419, -0.43572308181264224, -0.34011946378455415, -0.2968614573429833, 0.47156890821319636, 0.014300377217735817, 0.7300250689531903, 0.45382870214226007, -0.690626583778292, -0.5490182060890016, -0.258999151226133, -0.28710956910929253, -0.28483996374530657, -0.40052025611552194, 0.41852578859433703, 0.8368917568720934, 0.18548277217656134, 0.8172997670542274, 0.36704612916199697, -0.14112348125695745, 0.5005181854359818, -0.2062168831191397, 0.6999912870383561, -0.3555755894642929, -0.08047238855417303, 0.6930588210188586, 0.41435658040221646, -0.19412569112500608, -0.433335646848926, -0.015518857150014873, 0.5165416573979363, -0.3879426183452022, 0.3164909610772641, 0.7962365531389695, -0.04351037650943898, 0.2890818291778233, 0.6093602943636607, 0.25910479449736423, -0.25497540724071194, -0.5104771028284381, 0.3838423548570726, 0.5584475254896065, 0.38581205374228855, -0.3603465394400867, -0.4229305261426672, 0.5283536262127202, -0.2599248423373232, -0.05994709133740101, 0.5518950280579796, -0.46500106224401117, -0.041748740651629104, 0.12207267285064718, 0.3973358703469814, 0.41919603374873343, 0.2984507207600521, 0.2425298817009562, 0.14556656246146338, 0.13995345972597079, -0.6212796825363399, -0.29535559626400343, -0.6003928087902577, -0.3922355273264178},
    {-0.033740961609204256, 0.15955953366673475, 0.6362049493793283, -0.42754066980060423, -0.49188931484634907, 0.43404049303275183, 0.4466592719629222, 0.3306828462127011, 0.7309296749133981, 0.7554116727967626, -0.7830971087981585, -0.6389775249667473, 0.2204497097181381, -0.06415454945784217, 0.008327508974348757, -0.30337020871886283, 0.5132013718286256, 0.8104305275682467, -0.01711909187970222, 0.5510404570572524, 0.432403492282689, 0.0031538648598726103, 0.5178928858765283, 0.16188875827538185, 0.6976353106998803, 0.12022673288459959, -0.17098292551607241, 0.7750410232400272, 0.05860977047169635, 0.3623688946010996, -0.3279278130442168, -0.5383925016332196, 0.35325930589429666, -0.343628284040892, 0.48062868482032833, 0.5659832332967322, 0.00839379431599657, 0.33800038465983356, 0.8627282053743521, 0.6181716821348526, 0.2829491934420058, -0.11371090906330435, 0.5124322216119337, 0.7251955170603184, 0.7775595093594921, -0.6161788962203336, -0.16771344239114602, 0.6833129545339133, -0.4377627439559217, -0.5867396194239561, 0.6629881476377667, -0.4032570970655997, 0.2495334456856688, -0.395133015186545, 0.23148286923065103, 0.31017340083436395, 0.27414976723004764, -0.08191290337729748, 0.5704369739940746, 0.3703598109499408, -0.3341509954544003, -0.4407177537575488, -0.7710084222744124, -0.05997108349762137},
    {-0.042136354023721005, 0.6057632983135354, 0.6769107047951195, -0.5602474177189304, -0.2996891476989401, -0.034570210064545394, 0.3141107049943749, 0.39625516305832803, 0.5965431836274138, 0.751124135800142, -0.5915484193195202, -0.5574803563385561, -0.11234791360859464, -0.5134252462734782, 0.31365428115518584, -0.35168379744444206, 0.8176695776541066, 0.5745588875382632, -0.0011909506058944402, 0.6742069706237496, 0.33036891417728265, -0.3751900233187585, 0.7113858870446254, 0.11886583233507265, 0.7449262112786996, 0.03174917270903704, -0.11701242528645085, 0.6584717026420148, 0.10154685621971034, 0.5652994122336037, -0.40035930184819457, 0.1250782602528879, 0.5702242062051216, -0.456789785095354, 0.5383619975922203, 0.6818355078666566, 0.3389302068661369, 0.4432576805568075, 0.6982141791297254, 0.6510069685567332, 0.22053110778707594, -0.1915068475652792, 0.4560601174106185, 0.6462817481282298, 0.8017927761077095, -0.18978666773364145, -0.12017902171407698, 0.2510041905472569, -0.3678542629712295, -0.34422005883211926, 0.5769330180822457, -0.038154818162627495, 0.43162884451589745, 0.17509366294563533, 0.6949993932513602, 0.7193094805363364, 0.3322763031919901, 0.6393183518217643, 0.3828318617210601, 0.3665920468972507, -0.4759133984487067, -0.3381068919408259, -0.44978390333968943, -0.21984261566603286},
    {-0.4702082942019437, 0.05012382481534566, 0.4626962341886907, -0.326385615167504, -0.3304703075938994, -0.029216269246172516, 0.15250577095971277, -0.3379080854368178, 0.5441847611722767, 0.3492348474667696, -0.38498917966800283, -0.26163709434367954, 0.4312372118920575, -0.6603808412546934, -0.033899856589129904, -0.7020265274260704, 0.4308492551715146, 0.20024656272952993, -0.24795840891038964, 0.5794072118926125, 0.12464108531354207, -0.5869995430549457, 0.43066348022843304, -0.6007023448099137, 0.6959758708388204, -0.666020937167156, -0.574190339040025, 0.34401862742206823, -0.06860174289113044, 0.3736631842624954, -0.7257160898592033, -0.36845347187038774, -0.06286826154348381, -0.6288138950079561, 0.6515772840980586, 0.4215682254331862, 0.3623236875866625, -0.36204210920509344, 0.6423756897648601, 0.7167655739878751, -0.05751922963313212, -0.5222446609783058, 0.07918517474116078, 0.08970089526708858, 0.25134784517170794, -0.6357612919284603, -0.43705174674604813, 0.5467715058925817, -0.8248914615527198, -0.6310423709549172, -0.07391996716083495, -0.8301631780825041, 0.25892123126201144, -0.2310550693179465, 0.7336009541114734, 0.09753309559154427, -0.5425282993415121, -0.13562118919444868, 0.7046075187786702, 0.6394553875021326, -0.33802754646241817, -0.5146656761885856, -0.6859931549413163, -0.6440120675834058},
    {0.19290986313603395, 0.7357399104433126, 0.8605085088102976, -0.41219893461864743, -0.17874049627302854, 0.5678694322307556, 0.8605007991033236, -0.17712297652825743, 0.8124153819539663, 0.43097758155934224, -0.5382028624841868, -0.251619798955597, 0.48373038076989855, -0.09100441925797152, -0.18467289354665659, -0.6320449647389318, 0.6095581029057577, 0.8956458744627176, 0.004957115164647344, 0.8816589864813147, 0.7513403150274695, -0.32713684850666935, 0.6582596099132358, -0.08974851618959138, 0.5594185574210183, -0.5768687998799621, 0.031310725323699704, 0.5113258361440997, -0.20574913330360567, 0.47598403434585435, -0.7637209022333937, -0.4339954686474787, -0.2655146312459548, -0.6751277942694878, 0.7103933611484431, 0.8044744233906904, 0.19070445934552008, 0.24855591707450256, 0.764548743151819, 0.9322003863918259, 0.2181913320592607, -0.6567206993249797, -0.04882175059250286, 0.3916364703765548, 0.7218284066287666, -0.45374270865983446, 0.07820222826921557, 0.7858536039983438, -0.7123812158438797, -0.4790849971658159, 0.3066272672247641, -0.6700212606481678, 0.6791483681752175, -0.1572812159549663, 0.5656992216024935, 0.3028242238357585, -0.06559092214035882, 0.24432691653542088, 0.8006420584942988, 0.8530740299671493, 0.01863818241559456, -0.6373633424114863, -0.11183056101912346, -0.5594230151218145},
    {-0.5169965581232057, 0.13620367820487564, 0.8049840340838306, -0.5610961071028551, -0.5614722415005611, -0.0833681122783947, 0.9272172470486417, -0.7124263439255575, 0.6212039702130825, 0.08930868977615346, -0.7259054242722075, -0.5565013506655405, 0.16249281668131757, -0.7582157265840805, -0.5302935265886054, -0.467038222346828, 0.20403936459761415, 0.1726136566968397, -0.14146107586128195, 0.7296113585659936, -0.1696598666794119, -0.8035792857667899, 0.4416419791475211, -0.8098707586006489, 0.860594355489731, -0.6234908702103714, -0.6742799518578445, 0.501414016890947, 0.514265616367332, -0.5198682571648265, -0.8013531170200122, -0.22342166047076542, -0.09413161902355001, -0.705059926710523, 0.6455691264151218, 0.7548037971638472, 0.1793455250118326, -0.22867495656731343, -0.10326707976302683, 0.6516602752137581, -0.3929169263588701, -0.6482111672847617, -0.5608026291133664, 0.08921350097813377, 0.5309498778474364, -0.5123400231474448, -0.3916956192549827, 0.4435036543432667, -0.8650571494882865, -0.7860423543094409, -0.3467753796359991, -0.6900296832545212, 0.062314173685364634, -0.5376379698311106, 0.8626561189353774, -0.17711388370944722, -0.536949165465074, 0.21985462123174865, 0.7731627292157344, 0.1878882904883691, -0.44197015945434337, -0.44805553417538924, -0.26101957548770405, -0.7576208488069651},
    {-0.6420562823329715, 0.47240489777596467, 0.5977297949251258, -0.6502808809535997, -0.892098845962993, 0.2331058958612004, 0.6369688717852477, -0.23003397379119103, 0.7272346213295643, 0.07305849299871361, -0.8972999187087227, -0.4748004570447215, 0.27140197140411715, -0.7487960059655236, -0.32968204104361415, -0.3834106077212671, 0.4808379462064174, 0.7111614663589383, 0.04455298725938553, 0.5357502688966657, 0.4551770548880454, -0.5770981718218332, 0.6109667101463422, -0.7267393453630571, 0.4380517833763002, -0.4843569423673568, -0.5626884548329317, 0.32726581356554807, 0.5113657984864495, -0.5271355141576644, -0.5909674673521061, -0.49340921573309626, 0.3823699555648442, -0.7902797503235237, 0.3001237664671448, 0.7117008735926437, 0.4305207659467076, 0.22288579392859387, 0.3915607413804824, 0.4383838470359224, -0.3257615965786171, -0.7154423459361389, -0.5735337763542746, 0.3662724390761111, 0.4620887696591208, -0.4695883610406093, -0.7209349629019404, 0.3504798239314502, -0.5847659247222361, -0.7608680867532697, -0.30878214501505064, -0.9150721822314729, 0.01886526535666294, -0.8267974220363308, 0.4154967587427172, 0.3789714607076647, -0.044506337269148835, -0.3919748242238521, 0.6154434227985195, 0.14341675284769878, -0.8444956636640809, -0.5261884469106193, -0.755336412975253, -0.7177422050848887},
    {-0.45288113823363824, 0.3116547123015605, 0.4109039213554586, -0.2458502219086406, -0.5020314297234227, 0.018884629918602503, 0.5884871892926007, -0.4232915342923475, 0.330209251683532, 0.2425099880123812, -0.44907501661988947, 0.1675433746402995, 0.2946668843558834, -0.6906657850255865, 0.02629009985317827, -0.6319326538304256, -0.0331151421698158, 0.2719804554981783, -0.421498797561616, 0.04425611072756065, 0.011130559423802625, -0.8253476908526134, -0.17157540896658174, -0.5694600527532648, 0.21755023056539768, -0.6337850610530766, -0.6055941613744836, -0.22354238513399083, -0.05316617386701034, -0.10759941334948143, -0.5351974962172527, -0.5127104916810035, 0.265596661649593, -0.5762937679196984, 0.44332272177587045, 0.22645135393455734, 0.6901127502968747, -0.13284741861176544, -0.3160801855955609, 0.5758143780376525, -0.4544909117571814, -0.42886727603441654, -0.5112228930595349, -0.2779993677448223, 0.5205724218287657, -0.5225832349549269, -0.31007756778169987, 0.02371924539557098, -0.43505068544177483, -0.3230782818621, -0.4831839573823846, -0.4247515683572145, -0.1053241004220527, -0.1629971548780614, 0.5983130904724521, 0.08485748684958512, -0.7124790212037626, 0.3805357623947187, 0.5522435627649317, -0.20146911321296637, -0.30516978602185485, -0.4140728933140131, -0.48176642718065227, -0.44571857080667854},
    {0.006972413547812683, 0.2689350056574659, 0.6164912487049444, -0.3020022480499975, -0.47878707313543434, 0.5748689178343537, 0.8879881629761758, -0.146928547102201, 0.882739878835032, 0.7308386225103126, -0.5409401721908794, -0.5372899254118205, 0.44108301276809936, 0.23826343273051578, 0.16714078403700633, -0.7264650645650891, 0.6268621611963517, 0.6538872567617993, 0.3891370658625682, 0.6488637114870496, 0.7860234290069491, -0.3650787046002705, 0.5248015076782144, -0.11103776518230107, 0.3230247695301034, -0.5811158836594139, -0.025742916637200446, 0.5173357514523232, 0.06824816525979593, 0.37487961213739873, -0.5356070095551979, -0.6422720990010014, -0.2398745463351885, -0.7165467856459521, 0.48923271281709196, 0.7118381782297347, -0.2762299354033304, 0.07069109702207559, 0.7361200255094108, 0.8659471734836106, 0.3607835221282027, -0.47223015701105187, -0.11997117943618857, 0.39911232609476294, 0.765981634079525, -0.47979760930224585, -0.17159419337073029, 0.5725508865068624, -0.644978386257536, -0.8161077843055367, 0.3351083445851002, -0.5714581438906294, 0.5894937410716453, -0.137657125129354, 0.3355079774645092, 0.5476351668318069, 0.101751461490337, 0.29854182579208144, 0.8927845460432585, 0.7307676149443583, -0.3347004729305603, -0.47870293550079546, -0.28837444513087107, -0.4448101555457033},
    {-0.07499736854347588, 0.31667145236922584, 0.5410381396289604, -0.36771484864818266, -0.05427623937636906, 0.33166184929524684, 0.6815110835941292, 0.40293442374788074, 0.8403469452495064, 0.5185948325817696, -0.4730775333140639, -0.46107992340109655, 0.5668459127594443, 0.00452060191345605, 0.1990599230779419, -0.19542541322194054, 0.2352079386105405, 0.7375800975315282, 0.6013156852251084, 0.7766767664078318, 0.6223625384980064, -0.3748211771281976, 0.7504945731432486, -0.0698813199527689, 0.4993837528989217, -0.3176696189365124, -0.06594575368957942, 0.12822148361859098, -0.32586901475001867, 0.614113970240969, -0.18581122132506467, -0.6095061089976911, -0.04803245165486524, -0.5188048217576647, 0.43642222602737896, 0.37409746882096323, 0.0845464759333954, 0.42701865424769103, 0.3057584169485769, 0.6513584787516534, 0.40594079206810557, -0.19698806075691988, 0.3896377498061919, 0.6754804492822915, 0.45316647626575357, -0.46421680672191, -0.17614966070784507, 0.6200172453464683, -0.27722815955845853, -0.5947838900504728, 0.4309553286540438, -0.13979419455096723, 0.23958613687490823, -0.3323181812240296, 0.3688213462828087, 0.3990734084339095, -0.24489436545928472, 0.07778715313466715, 0.33124199079332783, 0.5678699509652594, 0.09392197715153089, -0.1968369315601586, -0.5821547260091773, 0.15766987989307096},
    {-0.6799433605176781, -0.8237721108888492, 0.1136135110086047, -0.7998384922614186, -0.6965500834591268, -0.8099361468758647, 0.6198872486926945, -0.7082410977464427, -0.6938026567938446, -0.6589567638052279, -0.7382227741156007, -0.37929189564495885, -0.6320285427785696, -0.8413132219087404, -0.8705871012006114, -0.617327884881446, -0.7348836422046885, -0.5723922999869309, -0.6779234582799145, 0.49064279233666364, -0.7104376212274861, -0.12253701101536477, 0.26849369954242697, -0.8496231728299699, 0.172716274036632, -0.415477817082243, -0.8132363616438165, 0.09043841503172753, 0.23650566721148933, -0.771304256754993, -0.8369204377126348, -0.495727102221487, 0.34008160496481044, -0.6250978819088248, 0.12627474493658944, 0.3418622267688155, -0.1379288669417464, 0.2530643918563392, -0.7267878730360607, -0.7199772162108231, -0.8994860175331061, -0.8520883663755648, -0.6850652224895925, 0.04882118181708882, -0.24051868171101706, -0.6867421868461385, -0.772744800564901, 0.47932536051843266, -0.9229509599118613, -0.9287286963086528, -0.6834571269642605, -0.8200883382810521, -0.5736871168198001, -0.8960438798629575, 0.3889293660662399, -0.7642273625135451, 0.18013635313609772, -0.7709550236978979, 0.358872659018786, -0.5182169629968321, -0.7779025220240541, -0.32388957129474255, -0.9137266158052127, -0.841416900495607},
    {-0.550774874515664, -0.005409392829698728, 0.36830199649908013, -0.6299246955235906, -0.6042018867818306, -0.7182401002639707, 0.6050525085473731, -0.5277714808553691, -0.0007137853172340077, -0.3878401303091678, -0.4877239384553347, -0.19576290805674296, -0.24182907032339568, -0.3904691685739717, -0.7453011475165299, -0.5653211561274297, -0.08145851229193894, -0.46851298647762546, -0.4177764053218087, 0.7464168249477564, -0.42123641192207273, -0.3577051041928923, 0.20341216802791548, -0.5925011684832028, 0.24598110471355628, -0.823723757008042, -0.30907633369172727, 0.24561244006003466, 0.523067960420709, -0.7758945769780344, -0.6241817051640578, -0.6405537591004903, -0.0893208796335135, -0.5949100213454024, 0.1309559792089834, 0.5562088272097924, -0.5077882458861569, 0.49664909078987557, -0.5759074244062489, -0.47405945876926353, -0.5269132719394196, -0.750435353445355, -0.6414708501982711, 0.35844306508790835, -0.1675403957513594, -0.9083727318327421, -0.7140382579528572, 0.707689308357657, -0.8404773933091084, -0.8166978184677011, -0.5893775441148656, -0.6371496300334941, -0.6041933569240943, -0.8680055691629953, 0.49356807878132625, -0.5540245462453846, 0.21036064283555558, -0.1905711122744794, 0.5882341497859082, 0.05421633397016912, -0.9171333279209035, -0.56357463612455, -0.5966769218699188, -0.7581281941406858},
    {-0.13034977030095724, -0.7343267450453238, -0.13158133458181076, -0.5371786049939593, -0.7144278951567687, 0.038484065673737834, 0.5437950597526698, -0.24767268085169938, -0.42794322534047735, -0.19236386133784564, 0.02444911773880408, -0.013611935897994854, 0.019108339935399506, -0.4015515594047829, -0.3942969604658048, -0.6164044753417742, -0.478946668653367, -0.7502468898602839, -0.3088075272977074, 0.30318323324208607, -0.23504969127572267, 0.26266868949457506, 0.3575974755627127, -0.6789269225788866, 0.10986711862600611, -0.39250706002047225, -0.5962572152239984, 0.11637801677747976, 0.14668385482830507, -0.6198548520384152, -0.016503854001595014, -0.0040350736873018545, -0.1911178147991664, -0.419751638822704, 0.41048013712326664, 0.5614596618885176, -0.5659902866839813, 0.5741017349248663, -0.30724563646455183, -0.7677592534906985, -0.41696169398662897, -0.7119852590540101, -0.3957957161810536, 0.10647582919217184, 0.24303423904146623, -0.5953293997846931, -0.5676816592653032, 0.38993186011046865, -0.39068708288273296, -0.29238159720133744, -0.5124004856431735, -0.529930645109484, -0.6330914263654455, -0.2994114879971037, 0.6972937458063443, -0.4974432443146306, 0.29128386516510985, -0.3612811238872253, 0.658747870054298, -0.10637005448349182, -0.6690735885272263, 0.22385177038315635, -0.09607576297386038, -0.21721230781907985},
    {-0.21587899026471055, -0.5565313545009493, 0.09564228975295587, -0.6193433867900109, -0.7751308694652714, -0.3996552749417762, 0.472228004831349, -0.07093159761153614, -0.5986888108934425, -0.5563619987983194, -0.1236048292312732, -0.05168424857337345, -0.3821909960784303, -0.35217849359267384, -0.3313505581476833, -0.5117584491434897, -0.4462278033721854, -0.38716767172771455, -0.23271811626039182, 0.3578612925059223, -0.6785622662213372, -0.16980583580721853, 0.31959307658433506, -0.3042904191191075, 0.6544435345140699, -0.6510990772918123, -0.35066854934762937, 0.16009917072795696, 0.47414242637699794, -0.6464120649971213, -0.41673290845217087, -0.3816951506755064, -0.057565023675727744, -0.7497650533285866, 0.026522933094673188, 0.4850905801404911, 0.052103263276501194, 0.5076201930179569, -0.5597957623170022, -0.6686970877898524, -0.16030976749052073, -0.3729931609690519, -0.38943066255802783, -0.08216176856398595, -0.16989157690952392, -0.7185396939290206, -0.4508519083279096, 0.4503117721907469, -0.3793652958987073, -0.5357080796057043, -0.6854214688001907, -0.13301968554440455, -0.6491612417661492, -0.5190240817121621, 0.6004726126792727, -0.7928120714978654, 0.2963418227057155, 0.05160453424965353, 0.4964549374487163, -0.29651669716163126, -0.670766196253606, 0.24315972727647242, 0.1496756468506903, -0.2438666220791012},
    {-0.12088221622087077, -0.40024460317553284, 0.12336141433114371, -0.5247430942185759, -0.6638388887726249, 0.07515764954079661, 0.5084560398894491, -0.041216080091152935, -0.5623269148915035, -0.27160053638446285, -0.5459981244294814, -0.27689879624853986, 0.05525415951444134, -0.5284936690364815, -0.3067021764270914, -0.27574101996493294, -0.6084884608170269, -0.5306301644801877, -0.11339042987732964, 0.16156878061393012, -0.5424996494771496, -0.4868538987220758, -0.05636316753833203, -0.5029390969439623, 0.23963456475811473, -0.09701339318358038, -0.5441757173371271, 0.47688553085287316, 0.5900480570931206, -0.09619305973566325, -0.2187055646740775, -0.5458408573436342, 0.326327283020218, -0.4797027517749501, -0.09114469810781052, 0.37047389840702677, 0.054144920627067515, -0.22054873156274027, -0.5688904968763296, -0.6206533048473218, -0.7775072558539158, -0.4738722361996173, -0.3209620391406837, -0.08086242655809302, 0.325583042608056, -0.3458780510210853, -0.23408319824044826, 0.07693293211855175, -0.07459428619706125, -0.08169986602641283, -0.446850950150178, 0.03661000318401992, -0.19581525518895362, -0.21221712248180824, 0.511339582862511, -0.7225283677125777, 0.2879601507152527, 0.20621374832003714, 0.38650751633395886, -0.3130142160587514, -0.6040758542337522, 0.11424431668991904, -0.45364974473772995, -0.6582388490018817},
    {-0.17357004693144917, -0.23795307915155786, -0.2101158770937066, -0.042056438072858755, -0.3058082141341494, -0.1374215936894068, 0.5147553181575513, -0.6295055492356453, -0.565260600469141, -0.2976935978085042, 0.018330426944068248, -0.210653841887085, 0.16793107237529678, -0.6344071435254351, -0.30666935168402354, -0.36140322527789964, -0.07797099879117192, -0.523876697168612, -0.3981239531307206, 0.5449390917469248, 0.0039062977081061835, -0.4837011200823979, -0.002977717545198001, -0.5319311177994447, -0.18028778305668677, -0.3841025572780874, -0.36931541703009135, -0.0015970019165050034, 0.21147490900751567, -0.40567334833278385, -0.2123185610353292, -0.34875553301797824, -0.3358928500134197, -0.0868662032916812, 0.004915906028515494, 0.37916396071983866, -0.3923746349950188, -0.4541637035591931, -0.25698208343417556, -0.43808550145787734, -0.6493894963169244, -0.6078541492867587, -0.1356310218501033, -0.5180747743641992, -0.46621617457516, -0.5205244078573772, -0.3832780426244671, 0.3822063722859802, -0.4279382756576558, -0.41581418070036574, -0.6287978348149061, -0.5496609996497789, -0.1580101057241818, -0.7257133804206929, -0.027039383749690584, -0.17213799313291453, 0.4027622411003912, -0.3494937384346743, 0.14885079401790338, 0.12987487208424428, -0.18944040498357803, -0.14728088967616934, -0.45669324392507565, -0.3898132155334577},
    {-0.4217621759280493, 0.3181496613132999, 0.3599902017772259, -0.39265897600151434, -0.4384489256829935, -0.3242530584244371, 0.2639031693749784, -0.35243668434568765, -0.4208987864063555, 0.2546872593931976, 0.10721348411700246, -0.41914263462770024, -0.2206103068373903, -0.2998204679535263, -0.12330448287311675, -0.09766473881055188, -0.2701343517207734, -0.5501832776795704, -0.27766962708773696, 0.3938920929900863, -0.15009461184707745, 0.3204444775366989, 0.05452187256514202, -0.09051257717246611, -0.00290581982196019, -0.16140922354267276, -0.12447045351502375, 0.36613776004860776, 0.07874754966121501, -0.49614183132074596, -0.1361203652773279, -0.17721428252570315, -0.286757452988471, 0.14035569355200908, -0.11168391148485451, 0.24627976626667702, 0.26190012860544754, 0.556431332184592, -0.14979202083016743, 0.09730477041977285, -0.18697624981700636, -0.3753503532871194, 0.17551751063870658, 0.5104203449190219, 0.5024827001090425, -0.6467314644757652, -0.6431601442860925, 0.5361396251926126, 0.0013082089306413326, 0.005013228740886476, -0.44164148925578023, -0.5281757810841377, -0.19071999280179686, -0.36253460843076524, 0.40818763094910937, -0.6693289663140936, -0.05211290498570681, 0.1721226568178402, 0.4413340892020317, -0.1465895147376642, -0.5176094838375289, 0.2589146272810171, -0.11317996914665711, 0.009245518761426912},
    {0.27092578873131695, -0.11929538168369379, -0.04217799964605757, -0.014244655587305251, -0.57776241047367, -0.11264574869747696, 0.29922401576719077, -0.011484048023329422, 0.020747130633667076, 0.021875369658129595, -0.31441599743161763, -0.4805501867090811, 0.2133203550132394, 0.38616070374148265, -0.2229810349772967, -0.22280822615251733, 0.1465941362722486, 0.4784976710568317, -0.4019178680942166, 0.5426672658553549, 0.06800462780139346, -0.06480441807406383, 0.4975188418872537, -0.1969002987552466, 0.2311518297213367, -0.5174463552267164, -0.10712327331120616, 0.25727642905618986, -0.009414747289354089, 0.3338825600482336, -0.29144747730550175, -0.6702306133801311, 0.2605667444331493, -0.4728995250854194, -0.46542915836073273, 0.6333144779862995, -0.2594753945485947, 0.5959928830444892, -0.1866522873082852, -0.30061980691332885, 0.10849746605912561, -0.06324158462803521, -0.11138711787965372, 0.04493964446632605, 0.44294513479060144, 0.08801395151924774, -0.5908073275828228, 0.3900086595847784, 0.2785183812007347, -0.4001771663298733, 0.06827943466785902, 0.06386283985456619, -0.4480847650212109, -0.5083441669398105, 0.14227278556913334, -0.011966578937344182, 0.02752557097716945, -0.38049668091671557, 0.5634394034684976, 0.12116366442901534, -0.05181693593976037, -0.2682029717369402, 0.20731274417492757, -0.13578902266458534},
    {-0.18274795893791704, -0.41622517828629985, 0.07603117748085272, -0.5359978320411464, -0.60192951763894, -0.41533520503708143, 0.26289366281851523, -0.5061171304178534, -0.09073527288845784, -0.17957209986425895, -0.5623971759306092, -0.39298389164957637, -0.2941733343800121, -0.05324934365651253, -0.7069579679255502, -0.2789023331221257, -0.08361907322741843, 0.29693774243138993, -0.2736317785609478, 0.017731187483641418, -0.30502621842483474, -0.25247397200681154, 0.386556074473018, -0.19247582733148377, 0.18767844378876583, -0.17317739797222786, -0.38265600200924943, -0.03542071160298399, -0.36612723915515005, -0.1526462764781963, -0.07844225396310468, 0.14515870655624272, 0.41336551805486693, 0.12545839133217312, -0.10054643274293201, 0.761274701595364, 0.01926202717448799, 0.3699573681773185, 0.4630706862940135, -0.21718497788375485, -0.24366817710200459, -0.631647918840248, 0.26982366015643194, 0.2175912046393992, 0.0135353412140256, -0.5781200220894327, -0.5658657519642369, 0.6679273402688695, -0.045627168960259853, -0.6822784428940798, -0.17618586353641177, -0.031097782510667717, -0.14806196724912277, 0.03479006116442209, 0.02377878589931964, -0.13793664011243445, -0.012877719428793313, 0.11008765037036615, 0.48377852653039594, 0.40944827533845646, -0.6345088830730173, -0.6468789347433439, -0.4803665597551776, -0.35060934146241934},
    {-0.1972797153013398, -0.46067488764561326, -0.06395549632452498, -0.01681760453516756, 0.05046746474963033, -0.14664246665961703, 0.24296847378100328, -0.3125943097723363, -0.41689764654061073, 0.019443140055472343, -0.22508907271780385, -0.35333175238653114, -0.30078763362799554, -0.3371625694397831, -0.11867469214550722, -0.568804373160856, -0.31588107301647894, -0.08842218609176619, 0.24123744612412767, 0.22726799592182542, -0.5010823033025809, -0.04695821191502205, 0.02725577709314283, -0.006382591346848501, 0.12011052287764169, -0.4766243496158947, -0.03355139816473678, -0.00020174531510034686, 0.3324732684425715, -0.18303371210637703, -0.025708068095207284, 0.1001269128799515, -0.40378513681560574, -0.5644583256746649, 0.021368782795036987, 0.17074949954138424, -0.40175252328532707, -0.47144353049701593, -0.12387165377972961, -0.36991729678108065, 0.14624719191453123, -0.40947838914041035, -0.5579625382301703, 0.15525943898215966, -0.0018491178215579687, -0.361349278119781, -0.01964408472440287, 0.22204558738124985, 0.40757794995863067, -0.26870321520062973, 0.002760565017022996, -0.054036186149366595, -0.3586121216525223, -0.4175231947797285, 0.4098540741041582, -0.35196536254846716, 0.24227462512131184, 0.4562977020143641, 0.2460935247267248, -0.16769505216220745, 0.15309351211567643, -0.43222349932417875, 0.10838694364991565, 0.06342892447186425},
    {0.07726615105788245, -0.35474844050582927, -0.0200074280927255, 0.07727430943167979, -0.3394063443211372, 0.17775218886411243, -0.2301915823531598, -0.3825070463037855, 0.15351214015899728, -0.07496104931192497, -0.15536784412703677, 0.13742164930759396, 0.3135837868671474, 0.2757547104668745, -0.19642534904993234, -0.20354350169163898, 0.15469161969027134, -0.19669934903324723, -0.36004772412853764, 0.20404828176198253, 0.4422357733869892, 0.3470481574582284, -0.5059884101781743, -0.13163546437112023, 0.0013910913543113683, -0.05180662612584499, -0.33323747277101645, 0.2095600610213032, -0.1459313153526658, 0.07501673249316348, -0.16763075479019962, -0.22530243067987477, 0.03316023812654435, -0.09584284953690826, 0.5689611106971386, 0.41645561615237675, -0.4498330519198048, 0.5361903787284891, -0.3576697781162228, -0.30849556536539696, -0.0213489447785417, 0.20755017840133008, 0.20875392129293327, -0.13904074318432555, 0.304427673008494, 0.5141061201411414, 0.4898969942254218, 0.39170935701726173, 0.4213708457269858, -0.25462315961577464, -0.47976919249943384, -0.09737940770196706, -0.5883624358972717, 0.04068100083893935, 0.5074127799847509, -0.2981682259969662, -0.26645346621167465, -0.08906658869575913, 0.17720267474700724, -0.40294672693201167, -0.08058614806264032, 0.2733186845062677, 0.5069611829046877, -0.4320640180188986},
    {0.1878240701149536, 0.4775779761566789, 0.14466393475591738, -0.19102841654780944, -0.3785148680809104, 0.5128027275864192, 0.04917575051484304, 0.15107273630495677, 0.0010554248176158237, -0.32248280090959336, 0.25603043224927363, -0.049942546895603485, 0.13225931219832987, -0.0004637922847193701, 0.14485438196953068, 0.11255307113463392, 0.17188300107597948, -0.07543413326114731, 0.33779338699826106, 0.05398509814368083, 0.23899613033542935, 0.156005333052847, 0.2255222962729169, -0.08130204335583104, 0.08958897375832489, -0.37768617865998544, -0.39249642023161363, -0.38258876887422616, -0.00880818561261851, 0.16233118906828667, 0.23663494981028155, 0.38210048833569, -0.006619277456983268, -0.6194728679434183, 0.17181909509498972, 0.2911064484486785, 0.32615704360875647, 0.19210636014890317, -0.13655120340678878, -0.030553013718240953, 0.1164032378766837, -0.02364092219402743, -0.46868468396404434, -0.23326309785567415, -0.06806891830862313, -0.31210144484240904, 0.013543840336223014, 0.48132868205998397, 0.4514485939644581, -0.3519977291688853, -0.14875428515611921, -0.029752503725080003, 0.0005848600605233404, 0.32077777741015806, 0.3933046349180807, -0.13412237948702999, 0.3631865220513683, 0.4315721519851815, 0.14841020135933888, -0.3833250684218636, -0.2743431554522414, -0.0013170290595094526, 0.31441006871958627, 0.05216525520190398},
    {0.3253471047549917, 0.07990160636754016, 0.25076549190511344, 0.14427019357562326, -0.20083722211599775, 0.20772376985577928, 0.09447127560407576, 0.3901982294570599, 0.4939790858747974, 0.25025314192973963, 0.09428813228417732, -0.4928829856507064, 0.1236259753828735, 0.5153400069959644, -0.25684064743860563, -0.3696371695172279, 0.03661968065352466, 0.21422564188919302, 0.4958179676846824, 0.5364500464040535, 0.038738763144604726, -0.20266978591463664, 0.25706182165674574, 0.10115281512027659, 0.389494841800579, -0.13835485726676414, 0.3566489823750032, 0.2506111797870675, -0.3205958323386201, 0.5731921248108878, -0.3126607859158723, -0.20043537270958595, -0.20549601571032497, -0.10171010528739476, -0.018964259770892167, 0.706727908860126, -0.36946846771034, -0.16622545426483948, 0.06997064500910424, -0.0735010637150683, 0.619110306930273, -0.38184394530273313, 0.15431884563646683, 0.06983349558262664, 0.2811572557500937, -0.2098870536846339, -0.07359070624053578, 0.6939513156092332, -0.3336406839079911, -0.45216767381679734, 0.3379135456854254, -0.27559580908616854, 0.16705031721658442, -0.21862767477631487, 0.6100152511624536, 0.11657338704087601, 0.05870696480234699, -0.42267740866278064, 0.4774593275736589, 0.535791779570204, 0.027551667204530575, -0.41099841179855645, 0.4688296338580586, -0.4207107256302726},
    {-0.39909127824928514, 0.3381559934921548, 0.36005603751743326, -0.46949142744547623, -0.27683360209805025, -0.42903646047444943, -0.14406996250861567, -0.133673070847664, -0.1454340611414139, -0.04226946100449043, 0.15221043374648238, -0.5279294871112291, -0.419350441373753, -0.11325794104124388, -0.048104391735960865, -0.07677306145219984, -0.4024766655539886, 0.10016205193035138, -0.66466526068189, 0.1290290162473665, -0.3201456743391796, -0.3931627417830862, 0.4773574344872932, -0.46027128409791446, -0.14321125450535874, -0.48270654637337296, 0.03643315957065494, -0.48907139682396145, 0.14857405403359492, 0.10974807182490263, -0.22947903173218245, -0.27803613185480286, 0.2612050324426091, -0.11335279832091394, -0.2357546217323139, -0.15966116666465344, -0.08767100001187056, 0.38831678285719257, 0.2960581792397293, -0.2744677004267874, -0.1749793426498289, -0.18551554380583465, 0.04130461407813381, 0.3577424197878132, 0.3892171820251581, 0.3216452063259215, -0.22877145484388917, 0.14276730513665567, 0.310855761714958, -0.14197403763478997, 0.26540178579895124, -0.364890091433503, -0.07867569273664766, -0.15590554912161503, 0.09271009953068036, 0.4272092267687322, 0.28922254818049575, 0.011362467934441288, 0.05188518932810199, -0.27672329120126415, -0.48239517541949295, 0.02375079712182659, 0.43602129934886447, -0.3278672133974417},
    {0.057935521738407034, 0.20013818964183258, -0.24971717564740445, -0.19437977405578208, -0.3957430507081914, 0.19512657239221434, 0.02040183544335221, -0.21221247393885442, -0.1720794205511839, -0.13222212763982152, -0.25577112291548154, -0.45549609650535755, 0.3461172117463676, 0.12018339455387299, -0.11505054555932244, -0.3280718424859577, 0.270018795994205, 0.1169423667559322, -0.4829369928224736, -0.1682381391062623, -0.20520780545137635, 0.12373656936311875, 0.11948954163037208, 0.06355483084364213, -0.30908727011496084, -0.4780213274704764, 0.3211202812379569, -0.3617110640759865, 0.3375990734801175, 0.2673946043765305, -0.3881659785134058, 0.34027692847394486, -0.5599827999355927, -0.294381596774816, 0.326740312353029, 0.2091732721764306, -0.45942515894975455, -0.32615867355419337, 0.06448181610447475, 0.33223639909137753, 0.10148895977658175, -0.05019126022808248, 0.4008865559197425, -0.2605196014726245, 0.17297670780263202, -0.0900682313614717, 0.22233163791458682, 0.5403602274346723, 0.015796091021092896, -0.05329774188130184, -0.1303505027687603, -0.11146870515734716, -0.0099892148851032, -0.12026673687810847, 0.04046632973457681, -0.007778780688890136, -0.37453838905204867, 0.46257615363924626, -0.025534653859882125, 0.1346776511132018, 0.24102862758031074, -0.35472367274990446, 0.5448653145973787, -0.17006549667871182},
    {0.22065012612640916, 0.21572189369419645, 0.02883648460812315, 0.10613598819716079, -0.4101281805713274, 0.4367029770409178, 0.44833594720898295, 0.14382253493936273, 0.5263751516575845, -0.2286534208980302, -0.42825743901920166, -0.6203135522382905, 0.2441090249159621, 0.2646772202357356, -0.6983817863411109, -0.5556917092012272, -0.2473719707258539, -0.08750346149717708, -0.06198977259311054, 0.13965390510639425, 0.19366195474021533, 0.03258705806204456, -0.02996887395934065, 0.2519552179185712, -0.1402150671204386, -0.27987037707002643, -0.22166664787786772, 0.3132726280642368, -0.5242171151434272, 0.3684568007449069, -0.7142451292456526, 0.3803009736511157, -0.1497324666706095, -0.5927026803322001, 0.6046151763452926, 0.5243618730756672, -0.4058327743962836, -0.0693552178514355, -0.18395310890928862, 0.3165240953920592, -0.010178699528247927, -0.717412911371543, 0.38805696019860536, -0.2659795948750546, -0.33020453641340125, -0.505277992774404, -0.5926079643696727, 0.6178102591557747, -0.07052553435100659, -0.07269602954180335, -0.28769139414861317, 0.057535215460311616, 0.09559592620601744, -0.44733539340184686, 0.3758991422628343, -0.11751131150880018, -0.43313896569598576, -0.3324727641138426, 0.30738055436406886, 0.4649223826673195, -0.3991403439350513, -0.4098598980810883, 0.40415091194567904, -0.09152462056809449},
    {0.16421927898080396, 0.1701685780503761, 0.2613056092924663, -0.4101537757264857, 0.11031734265248246, -0.2819577686245386, -0.2801728485457446, -0.23461473581387435, -0.07945018074697739, -0.03113806540618624, -0.22588300338317077, -0.24896445650972024, 0.08603321502351606, 0.0864172008861017, -0.19741090551041232, 0.38861398523939217, 0.3005431390000437, -0.04634766528285087, -0.4034881916390825, 0.3440157681709464, -0.2467405066891801, -0.011248121729691248, -0.012823748155312044, -0.1912036754741921, 0.5641466171645961, 0.26785349461659125, 0.4544669824847824, 0.18625558336817108, 0.5548470572418301, 0.021116111979884142, -0.1604564681025771, -0.12983372426256085, -0.46146254225443156, 0.14788600124579168, 0.0490177909991114, 0.27044094180119005, -0.3842250262231563, 0.22520238369703338, -0.017135709452708293, -0.3012560053569318, -0.036509097342650565, -0.49206101131091956, 0.03692565593577457, 0.08841400194171195, -0.20631373037751216, 0.13266311507082523, 0.2115208089876316, 0.4015825187474106, -0.4971120645921387, 0.13876535214107324, -0.07670433568583428, 0.36542249427590034, 0.28340305770466423, -0.2086199750418299, -0.09036892065085426, -0.4021097011973533, 0.4362107471993401, 0.5894576694172992, 0.1829744227829969, 0.605536024717906, 0.17417482145266097, 0.2067798048616275, 0.4543117722052828, 0.3510062394810358},
    {0.38298128045118507, -0.18670223990262466, 0.3805099321462783, 0.1143347543308133, -0.3214126128315738, -0.19949012551414455, 0.04420503961978883, -0.09722946042824113, -0.3183755015950226, 0.10671721396091272, -0.20863425030893348, 0.5021136890944113, -0.2415139243992312, -0.3661012886884495, -0.11090104377979977, -0.2411839233379996, 0.44749065724844606, -0.2490530939080878, -0.5114222749485631, 0.3331122229984875, -0.5537569234418319, 0.23996908658133728, -0.5929931470699857, -0.005695215141306851, 0.6200306117845873, -0.20485277604664853, -0.18707782803545306, 0.1373233502538771, 0.23725833418131143, -0.18045576975328756, -0.18410118849638119, 0.46642579750271074, -0.13335071110383911, 0.13067295787977698, 0.4755031164705242, -0.0945899277375675, -0.6144701106575348, -0.14851727188731978, 0.039969580277095525, 0.06343053649180704, 0.1150630238976627, -0.4963999781179758, 0.16857021914217354, -0.013532429744273307, 0.15164109971730563, -0.3056747818723388, -0.07188726349007946, 0.5297809087761876, 0.21551726667145796, 0.17494526169393657, -0.1668262079877994, -0.323373013051791, -0.42650356863469646, -0.22261831812430216, 0.5061755201976983, -0.07531945214578392, 0.38848502195480583, 0.5781751608140732, -0.00900716608160685, 0.27949750554331126, 0.08988660552613326, 0.4294525969634007, 0.4284912996542002, -0.34828502609504297},
    {0.24209166745945815, 0.3404665087016016, 0.3612541540574436, 0.2851065013890695, 0.08272219684317232, 0.4780000276341765, -0.34878273811371424, -0.43708536068212406, -0.4042432614966255, 0.09816841942377035, 0.5190775980639456, 0.28992703560997163, -0.3000586070319985, 0.4569581641638727, -0.11705665486141771, 0.26940488450380523, 0.04542005562324068, -0.03810895154791046, -0.46555803807558815, -0.37631644463409347, -0.46499473410525227, 0.3358191003831708, 0.0564965574862974, 0.6067696859571179, 0.010819062589486401, -0.24148495819230964, 0.3290420877765848, -0.3653801335845052, 0.25861510955042316, 0.39911146489950616, 0.42722934450222577, 0.3915209576992995, -0.14979313646500955, -0.04348181314239975, -0.00149724604865574, -0.04964278488307377, -0.5376822769187738, 0.03692491485662879, -0.5060769750241259, -0.3367500632985275, 0.5968579724964858, -0.1003520242089228, 0.623711740477604, -0.5376642019320929, 0.05987292852542554, 0.2935983326892849, 0.08597208438960992, 0.5097306316275413, 0.41450694675112965, 0.0328335312562786, -0.2971431433398869, 0.10380137838248067, -0.13667340982678408, 0.41239592979601425, 0.2341035231720844, -0.16192349696946054, 0.0465846587826496, -0.07731760289394107, -0.1645915925175767, 0.1119532518178929, 0.5688535131939986, 0.22915970367819688, 0.5032402402280367, 0.12632722667482768},
    {0.2584259989571346, -0.2889901877594106, -0.17699958440940763, 0.23440060047487135, 0.1275104698978941, -0.09998612746281253, -0.04919979856812393, -0.721614703991936, -0.09690902953412975, -0.13585136938819983, -0.1990462984370984, 0.3977433255731464, 0.015432820786375161, -0.546491373876015, -0.0729813256970502, 0.5082433818182079, 0.48317371775400264, -0.5018238072174891, -0.2458514667556088, -0.079957885828244, 0.05605823396236655, -0.6671228907527321, -0.5956943039933715, 0.2744194505612745, -0.1725737130281282, -0.41649530611300145, 0.3443350769839018, -0.4808995786849646, -0.31927838443898804, 0.25372900075016985, -0.018561915923206076, 0.3121537617602088, -0.22433105737595255, 0.20709097579415697, -0.2874406116719767, -0.3568901551324028, 0.1299280621531139, -0.6036383896001113, -0.41282620288580835, 0.08829672550211572, -0.2970750787554919, 0.23601625570231502, 0.28403993128813065, -0.35949889689428866, 0.23560735774041214, 0.20206509718253804, -0.08676030353505243, 0.189268519452628, 0.4289842262930723, 0.10134179244864373, -0.4456335740355975, 0.34796979502745495, -0.3796044012698529, -0.32693359291505375, 0.4828145539854036, -0.11864208977032367, 0.09914465510770416, 0.5291583131604309, -0.31883127643974635, 0.3861872572376242, 0.3375093767782298, 0.11555633611257735, 0.46720826325403625, 0.10931047675745424},
    {0.3238203576151585, 0.17276334321041978, 0.6769514451671471, 0.26931248582910383, 0.03454250474738716, 0.442516759101328, -0.1688900841199738, -0.019329714284330238, 0.4408574816218705, -0.1398777915989795, -0.047010461078007666, 0.6676825198467464, -0.13265154758527298, -0.36196105265276424, 0.0052341414754482046, 0.32778834986731614, 0.3205533151640982, -0.30495722333569153, -0.11558674418732295, -0.25223383083479856, 0.299248579327384, -0.32708519080538084, -0.6402014234975878, -0.29219142527428615, 0.3094720532209854, 0.19652297959688017, 0.1338190513011652, 0.34560849310907427, 0.01836647551307186, 0.2926883785816268, 0.174264047906287, 0.43782656441367784, 0.10825414491589985, 0.4905500072084068, 0.4290355912500371, 0.2984584645648163, 0.14623960451703918, -0.5175523239409997, -0.517535220492688, 0.21813355911320143, -0.21951047141062, -0.182511980927832, 0.31964025744960095, 0.17493645061504767, 0.36184939704263425, -0.10937776829091098, 0.5021599122863799, 0.04145801312795522, -0.3091700552379222, 0.2782097936299055, -0.00402739162815264, 0.415324509911581, -0.0989629069253724, 0.14715838106919008, 0.5325761272831901, -0.13838413649405712, -0.19570156704742223, 0.5444985277593876, -0.16261040785146302, 0.3829033203897603, -0.18930663358308505, 0.5927931653094372, 0.5188626285145967, 0.08747297043965573},
    {0.545037055980069, 0.5097138206983349, 0.04112875929761777, 0.4129440567723138, -0.0596516736603813, 0.6255031438205342, 0.3428897475392101, -0.34750954410910795, 0.5903641356227101, 0.03765039883070539, 0.18343092960160448, 0.17015767591924422, 0.4577700216254732, 0.23384991664794283, 0.04480145386348948, -0.28725600761268727, 0.33779465209504167, -0.19973274019837717, 0.23763496219171382, 0.030037663033021144, 0.5726450968462024, 0.536858748975198, -0.2506886436621313, 0.05036683371046202, -0.39910649079247734, 0.08055553964799814, 0.06599775593898881, -0.2043983964095151, -0.15889931763928372, 0.17905771733188827, 0.433602525639688, 0.711270383663862, -0.5739704383757865, 0.3319275470852297, 0.0460947375698869, 0.5349587179847626, -0.309809515723377, -0.3779046113747321, 0.1991559022271023, 0.49271739282093585, 0.008468228924524675, -0.13752494605726287, 0.5738111040072155, -0.2042978183493793, 0.2752328250399222, 0.1855234697940158, 0.09743833613109615, 0.3168408487340188, 0.452436529907972, 0.028759586977502027, -0.05622743862853249, -0.17029830366970092, -0.25498331501112287, -0.02357460390673519, -0.1881338112953386, 0.06068592915352742, -0.3312556969308328, 0.04503378152645911, 0.08139636942005804, 0.6261456001605097, 0.07672947381183862, -0.07301693660310722, 0.4078076724743887, 0.07266203540237119},
    {0.1906817496961126, -0.2135047095315722, -0.4517662090640441, 0.18479296564586492, -0.18492604537636814, -0.09454887894587724, 0.2223174950805488, 0.14177072027159124, -0.26135283933898423, 0.30704123443429165, -0.09492569812072729, 0.2666691361504117, -0.2513803564896661, 0.06361613765564815, -0.29887258853273985, 0.17589401809584115, -0.19384939047291633, 0.053296209956757996, -0.44843089711257306, -0.2866541502880386, 0.16247941441910266, 0.21681674281423566, -0.18044350211358567, -0.00907101285446974, -0.29378270713132926, -0.38319985387877004, -0.1118949695278821, 0.1630945135182601, 0.6036345096430359, 0.13924888334107696, 0.3652341647840174, 0.36444160380372853, -0.4716223152485007, -0.22657995099419023, -0.22249214012911975, -0.008031954952316851, -0.4522720908037153, -0.21590482221709686, -0.017446388720528623, -0.48192987640836377, 0.05357816399579702, -0.1613762399170547, -0.08771846218191678, -0.06863536871244716, 0.5716461040220201, 0.21040347690021044, 0.23832955982813675, -0.08196368260767142, 0.5415038637104749, 0.406255521802967, 0.22308953584302738, -0.26618339788183026, -0.08099296279516427, 0.01423982298168738, -0.29021346659476455, -0.23184043925429093, 0.2005617711332275, 0.3866825574727509, 0.2522419110180584, 0.415812930113044, 0.4571593535212797, -0.2945674121944851, 0.3564654938964303, -0.2645561104151727},
    {-0.12542796418182606, 0.3770276104145613, 0.4050012242970229, 0.08952295656722924, -0.247659189456659, 0.5627354643806928, -0.18131843023899397, 0.16215346246221587, 0.5419355486835594, -0.008090161994923285, -0.44603501868254897, 0.19086471589556075, -0.05267538977575742, 0.33600503325570424, 0.4604352217025066, 0.31082352962274074, 0.11395333787706971, -0.2596900610335403, 0.15186579749940687, 0.16658682279661607, 0.175952850635603, 0.22616727543358697, 0.0878550471383673, 0.42512991014889057, 0.2294028327148982, 0.006505964104222956, -0.005302162009759732, 0.14721196191257144, 0.19150428140581874, -0.0734293586625925, 0.12301343474865527, 0.11824236020511934, -0.5734434638419849, 0.2796008377779102, 0.04651158635162863, 0.39224366162658764, -0.6117763142549673, -0.18129038869028538, 0.37804686059841597, -0.012247428338496682, -0.3311265462446498, -0.06078330884540053, -0.22985087207572588, 0.32358190305979445, 0.4027469706962262, 0.45055144398161423, -0.32976498959863565, 0.05749020369262334, 0.27244513211839716, -0.10361123300660567, 0.06434648712124444, 0.2193038163039746, 0.2710403388474192, 0.18946387979502918, 0.21707870982802738, 0.013279904117125005, 0.3253500960192374, -0.08171502325853537, 0.4262779239925025, 0.10327483698838964, -0.5052955918876414, 0.1700056126700467, -0.2647889755239903, 0.06242965392833518},
    {0.41364672380165707, 0.4778371909792997, 0.3936145186227506, -0.1697979228672057, -0.02276867501181373, 0.011266344852179444, 0.45056613147668684, 0.4761526105964168, 0.058689541205486855, 0.1101706393939606, -0.21292993118318762, -0.20016588431455068, 0.13337498364950698, -0.2805388819501239, -0.046643654472097125, 0.22191712761980342, 0.41118653329211435, 0.3122070544221358, 0.6146031519451309, 0.22364802537037673, 0.5586559696996899, -0.07375044185985802, -0.16851264221862403, 0.11450476132603829, -0.01639318930306006, 0.2547209206853291, -0.01784817507337931, 0.5300967358362011, -0.3002733231373259, 0.05013737956335486, 0.24424603827712393, -0.26098194691986226, -0.5299247716712072, 0.1501791887792194, 0.34726771334379986, 0.5525590879150518, -0.4594157628122919, -0.23165889226816758, -0.1458700912926604, 0.2080338321428998, 0.1577995491005374, 0.294442145954097, -0.4249399713401653, 0.37930029438598223, 0.24657784718169284, -0.25046023515333915, 0.10644082753970814, 0.23727739494635788, -0.13398266478147786, -0.20238713175733813, 0.43998412438178264, 0.2263828144733309, 0.07080112242975184, 0.16893265622370943, -0.07596180294355263, -0.11140794878563601, 0.055292550497432674, -0.016890024969585072, -0.3642523373923754, -0.21208070416790611, -0.21971264892882922, 0.10518067287306898, 0.21886320673149598, -0.12101517690947776},
    {0.33807679750365704, -0.4823129887419792, -0.08583522373946859, -0.06931144810115972, -0.22998301627951345, 0.16990160397908352, -0.42005685787176644, -0.06637909130289182, 0.27349913616963073, -0.3272694628219955, -0.055578938207393416, -0.241137311303414, 0.3953948870343542, -0.06902074916141329, -0.36161449840596377, -0.08671450776322798, 0.3930401102981542, 0.24416384474935707, -0.1512381617720679, -0.3440534129377478, -0.078775430550074, -0.3472836462603311, -0.20319758707918134, -0.11910483808171494, 0.44376619926405136, -0.2331544122171085, 0.47793703565008183, -0.22378409831754278, 0.38801710243727416, 0.1046710862425853, 0.12479046269409426, 0.12178765871047556, -0.2437796617424091, 0.0981423255758423, -0.2604142070514596, -0.02494306437460089, -0.6329534339940529, -0.41347089210929283, -0.08465381265310969, 0.4007537274790553, -0.18167540826221892, 0.18410087083137128, 0.0891707572567402, -0.3485176267740186, 0.04100552831828202, 0.0441028486155749, -0.3916008156875342, 0.285107380042599, -0.07149295981711146, -0.08561091339834584, 0.05647047288658165, -0.4488630622888408, -0.2254699100375968, 0.04505631150990914, -0.4302420957347859, 0.2483060594637775, -0.19845661531728542, -0.033589104127080306, 0.43015333370241393, 0.4912205556533454, 0.10342118855641658, -0.22518379624845963, 0.14845023889790684, 0.3138901332650336},
    {-0.2177992478151154, 0.5848622957689419, 0.6140210249707788, -0.49897430523475395, 0.022566172210088227, 0.26707591785504653, 0.4968885393353421, 0.13383481907405326, 0.05647488209491822, 0.34334432073503884, 0.2705598588225515, -0.4127460454091253, 0.10273404048821222, 0.05673969084112452, -0.336841605029803, 0.013978412751922293, -0.060160169114982606, 0.1536559777394872, 0.009719865869206513, -0.13958517472999538, -0.34720855137142015, -0.11765003655952093, 0.05572814349048088, 0.2268434273892481, -0.031427639836451, 0.36386240682835935, 0.400111206819928, 0.134516128368899, -0.21429775415278687, -0.24954466128100183, -0.22733376694237317, 0.2835978660499209, -0.3967423633419385, -0.40480070144081454, 0.42817986114738354, 0.09240490320707663, -0.013123261535313457, 0.1561420798122179, 0.57144698998774, 0.20737182646179994, 0.5222560534266394, 0.3073236382749883, -0.16719878417690712, 0.2574259747139198, 0.5609680138547524, -0.09765772347073977, -0.3337380679837453, 0.5043969712702905, -0.3162765874188745, -0.13825419517612325, -0.0833990949255597, -0.3929211367704524, 0.2438448743116597, -0.25209075963742233, 0.342515159179892, -0.25714804918105433, 0.40094872571564955, 0.22621060568311394, 0.05757642184145694, 0.5168674810504617, -0.05112585888830883, -0.0809191430619002, 0.17834694699906942, -0.05294841691499987},
    {-0.09814308659820933, 0.6348637401773704, 0.49676402341048226, -0.16357468189656302, -0.07820412304429276, 0.628136323321401, 0.18290063674889273, -0.31047326297621436, 0.4469882552672059, 0.2055534384535967, -0.3773252023755178, 0.05930721007554749, -0.1970877490006772, -0.2610983213272826, 0.09543203719933784, 0.10660225430759399, -0.3148990932252328, 0.29758909568968633, 0.6134063875781699, 0.3183382554904781, -0.038719680796607224, 0.2492993523218191, 0.57230159125355, 0.045639293645095357, 0.679808575990507, -0.47054576621036026, -0.2381274077083053, 0.1904177779710119, 0.5722168136275909, -0.05472634088316462, 0.20389021457606718, 0.49493678325511564, -0.06457002821061038, -0.24373347227096334, 0.560608260354861, -0.16989372304810924, -0.05998494193238243, 0.010167485052357117, 0.5836617115979321, 0.4958285800723523, 0.5657786736328002, 0.3194441316949377, -0.41958608523102414, 0.03757877051668059, -0.05036966385722219, -0.11829301895198424, -0.4640399791759364, 0.3415762773828359, 0.06020786330648591, -0.4712907211747398, 0.3287674307159947, 0.04827234027113613, 0.5532157676440052, 0.1769083973517159, 0.002158675887858578, 0.3273882026141309, -0.007482995972902213, 0.189859635011636, 0.19146194575166262, 0.13051450294631753, -0.374434854139643, 0.08875320948622964, 0.05189658598385466, -0.32875676766852746},
    {0.40458707899244595, 0.05163822653167788, 0.38285777241784735, -0.09211107330984226, -0.027462105176384602, -0.20368347864862432, 0.5345946451465593, -0.13268353193152585, 0.2398694177458352, 0.38433361658168164, 0.1065556035399986, 0.03081626947233475, 0.4436048568446724, 0.35793897714710676, 0.09129886261117355, 0.029185882403885234, 0.3045797786468417, 0.052429710774103716, 0.3601954267271885, 0.023726707297606835, 0.2859595434179453, 0.18279391783869792, -0.015272039763945056, -0.35387662133927317, 0.3562460630157802, -0.2072572951389607, 0.5304324847489807, 0.06537473318594182, -0.32310358884314283, 0.551566171039866, -0.47790033563168616, 0.060825498755510174, -0.2808456051454735, -0.09602926821939334, 0.4977602319400855, 0.45504333625850196, 0.19319074383149346, 0.17377573282221462, 0.2028005278309041, 0.4277185420609379, 0.10635598034561412, 0.06489679369854397, -0.010358617563143154, 0.042575417019323956, 0.33950327221456617, 0.03857960107834106, -0.12351860780166483, 0.6226850196261972, -0.0002845836138261438, -0.0703929794755701, -0.18479443586674574, -0.35097171939543415, 0.10088043672794228, -0.020215146867906195, 0.2310932107690445, 0.011344566269772734, 0.2666158455226473, -0.3636462214984303, 0.48939423163001555, 0.7069802361760199, -0.27392549047532816, -0.6855511634307617, 0.012847255995733716, -0.11177798710341698},
    {0.4058007089149136, 0.08253584359165579, 0.4602576119955532, -0.21819413762120907, 0.3547109727539629, 0.43496409988702045, 0.6037330439263533, 0.05351401590217973, 0.44311873219848746, 0.12431866150328022, 0.25649927673997613, -0.2773215378102238, 0.36709840491084894, 0.13471457430975717, -0.360085559791063, -0.2454833564192043, 0.4193798048821082, 0.05573622202277964, 0.18649409463282893, 0.35220026798871795, -0.01039100994914457, -0.0030001937023218924, -0.19033038486930798, -0.11675989795756557, 0.6214543623391793, -0.15219846709239684, 0.17082124256758852, 0.3156261033900415, -0.21343312878165374, 0.27961868122596373, 0.22803439426684868, -0.10248676988763762, -0.6461550118811278, 0.3734019290182402, -0.2530700706991404, 0.16484577265971004, -0.6803994115057307, 0.33369100322956985, 0.4286386487994834, 0.7130503593210543, 0.13952826839969365, -0.47897061517027145, 0.41634841546777085, 0.29754900396882433, 0.16073781985681654, -0.13509668303354777, -0.055330548015073366, -0.1260465793890899, -0.3163114221753009, -0.09480724667394803, 0.31638744602768754, 0.03436402022530981, -0.049618706581945934, 0.4055417669969784, -0.14267578661932667, 0.16273596233823703, -0.23910208892067922, 0.4308145167941712, -0.0932300729651866, 0.6807417807349251, -0.18524949404324975, -0.5537260606466181, 0.28523802284789035, 0.265692772932307},
    {-0.007139561373919343, 0.0647916969265966, -0.34108784472019055, -0.23845423850490702, 0.225132314371513, 0.21446499519450168, -0.07065249641331203, 0.22594202632367996, 0.33248275868332905, 0.30728465191468113, -0.17334990616661416, -0.12366441439016149, 0.25038507942275473, 0.33370310863449304, 0.2834330584124709, -0.16705819490319176, -0.10951963913879682, 0.04699799692166315, 0.19546624092195714, -0.14701442315922514, -0.07271501814736335, -0.09540864138049468, -0.15378252454295305, 0.33804215016875966, -0.22207176180981517, -0.15755396127928387, 0.329782556798722, -0.2361401854398481, -0.3072272503881592, -0.22550474445832, 0.16558826500981683, -0.0825185149343186, -0.4561287530549691, -0.10100927947583972, -0.17647790934099758, -0.1587386015799408, -0.15861019587798494, -0.36103430287693866, 0.3859639766721071, 0.46870717811050383, -0.28537360964923136, -0.19298895555684836, 0.36302116174344773, -0.22199244394446127, 0.35557107959604584, 0.34380097946952054, 0.05679470010424304, -0.2773474928322092, 0.27866878472253037, 0.337032883014911, -0.28680064334619454, -0.01674131251103339, 0.2106986262435972, -0.14674270705547815, -0.0018050448066022568, -0.2996497704780722, -0.2569831677500422, 0.2952128052257902, 0.08546076108034033, -0.39838052592348105, -0.19615443819403672, -0.18772275754596646, 0.059760152224957716, -0.18820476483012924},
    {-0.3638380763534696, 0.030938453232542705, 0.43279802530823885, -0.2478583694832358, -0.632061834239789, -0.296705408185947, 0.40467582624967585, 0.23350563914139366, -0.19120170637630787, -0.17560137668078415, -0.006523832349264261, -0.3838853358269719, -0.2682896659784244, -0.2137973404856011, 0.32765059628491905, 0.4737242524250777, 0.11655596832357197, 0.11312681798903146, 0.20260102510895744, -0.11301446493964264, 0.2571688693886797, 0.4527703892362389, -0.07921419014776598, -0.44862939396527834, 0.0658004466807361, 0.0737691997302783, 0.017660879514065263, -0.11481153854964705, -0.41412986792361045, -0.13403960411624433, 0.31236426741447515, 0.026781315299762874, 0.4778105304832531, -0.0572674959316407, 0.28954958504152817, 0.25432295237510905, 0.35152792031407426, 0.0627462860615186, 0.28898444657121086, -0.267470836363822, -0.3687371582022223, 0.34923655783858026, 0.12035955179888623, 0.3066983745078626, -0.13981263924459156, -0.04090485363338645, 0.1648046344032622, -0.27736261436894594, 0.01644221283508029, 0.034907408593863, 0.2528000437289728, 0.39078792118552885, -0.5114491303096365, 0.38448464220602063, 0.3358263760814975, 0.3192114493056431, -0.26575749408641386, 0.14056938142539166, -0.23342856715926422, -0.3534951242291706, 0.09911163883994847, 0.5158759238586894, -0.37040525877320685, 0.08986023638660644},
    {0.07158622366967658, -0.1759776078932567, 0.3479575072662826, -0.029995267883386332, -0.49210542816462427, -0.01892489935200409, 0.12432506724099016, 0.44255706075656964, -0.07973394093110237, 0.15288094148851789, 0.15898346811190273, -0.412804914039197, -0.002611892871055731, -0.3337661419661301, -0.029735656938671747, 0.32786917157515144, 0.12478643912358146, 0.07494722672995296, -0.35222375787186677, -0.11201387334418786, -0.19354948174947906, 0.08459910855520968, 0.2199709326667205, -0.45979217867420225, 0.10390535875245697, -0.2481705835689277, -0.04901586440184506, 0.04796574647223707, -0.031188506073025316, -0.0014638663352227485, 0.2652910562839619, 0.13464310114227593, 0.529888072600565, 0.42729542704341666, 0.1242766344629521, 0.02231889291206172, -0.05653751973169311, 0.4008916979607262, -0.29240943511270584, -0.39306622097095256, -0.38169012733847657, 0.07758129589322077, -0.1554936222054484, 0.22532621734805777, 0.19220380393165806, -0.09428449237057164, -0.4219085500041584, -0.4549846811860005, -0.18607048094537618, 0.2940420979127, 0.11001604490430007, 0.36974930303680764, 0.020815854068509766, 0.33070931887984545, 0.2030798100797248, 0.24999229401665995, 0.15176290112898919, -0.2521920838347394, -0.1567246606308576, 0.17264410102030106, -0.1553316229469085, 0.3083901153628843, -0.37806482533629754, 0.19233935814492073},
    {0.32388542758844396, -0.32048632757463974, -0.3447887835565761, 0.0869277117870967, 0.3257185560758643, -0.46327227357044376, 0.25985274199279557, 0.20533222037576276, 0.14463603199199207, 0.025768276483604, -0.15863269517414078, -0.3195160935502765, -0.060635161905895386, -0.021491573996814634, -0.39158132127502, -0.24660370058611233, -0.08162524655560624, 0.03532771265364543, -0.5491684439060807, 0.25349362026191474, 0.09072921333732005, -0.4189950558340804, 0.35165912974518737, 0.3202392570770807, -0.1329847787247881, -0.07249240602738928, -0.4121806423908356, 0.13371149186574288, 0.6204655315025202, 0.2303105831396051, -0.35533694540375577, 0.13049598236842896, 0.360431407743692, -0.17862722190034303, 0.03399902201487789, -0.20365789118004474, 0.06113049451546632, 0.06522324160391102, -0.1407285563302023, -0.045949680165859416, 0.2670234871017832, -0.1763209663872536, -0.27411415983117204, 0.20348169234248586, 0.28682307802117835, 0.16086343549168625, -0.5149942379476311, -0.2761677394087585, -0.3920815896573809, -0.11029570300429697, 0.20769801011909092, -0.23726019957075026, 0.05870094926975187, 0.057722882339915134, -0.2954281039197459, 0.012948362902662124, 0.23470876008470046, -0.33589013460375206, -0.0060567014309017885, 0.40181070207852143, -0.3688316799562606, -0.5045206698583725, 0.2371380423955672, 0.34786644188294513},
    {-0.1384883938823331, 0.30919352361773894, 0.07845687201587186, 0.19712593151434069, 0.4896425282556651, -0.10807547839998337, 0.009209314114492242, 0.15480928432321625, 0.21619321225621035, -0.24705300669739438, -0.4305321989291309, 0.32205634443201, -0.3091619364007, -0.016431158042958558, -0.03839909148319968, -0.26481328511223073, -0.2840245833596793, 0.11475243530560518, -0.11023293961004602, 0.22838408183999048, -0.018616638265025045, -0.510625174515773, -0.11032990169324246, 0.2563312988028989, -0.368647556191184, 0.3310625352328057, -0.35823098024708216, -0.45196922858438626, 0.18805947405405948, -0.07747001109371703, -0.2907182711062075, 0.055756896401357205, -0.1370571859730188, -0.15354732693415019, -0.2031237196839725, 0.029422325563604763, -0.20443474352941252, -0.23887260755779777, -0.23635468652678604, -0.390495832965624, 0.3713140646392879, -0.3025918064406193, -0.3057661682379717, -0.1163190580596252, -0.4529546422902111, -0.29060535645640667, 0.14378417774699961, 0.15117021913294465, 0.10868327048555118, -0.4628353409754805, -0.29516473303067114, -0.2580253815824721, 0.21499353950628525, -0.0872504083947191, -0.18430549339828442, -0.4693679587714735, 0.21317869059281555, -0.3684655781447727, -0.12334789998859953, 0.2940954117279346, 0.09448555513833926, -0.5500483353341683, 0.3090737420663939, 0.3600691667292104},
    {-0.00645935727825621, 0.1482153081613401, 0.4179315136771685, 0.08943847177785279, 0.4666387893896165, 0.36785853487004655, -0.29727584549713887, -0.44648097714907165, 0.08926728533435817, 0.2782658206009814, 0.20348538990281875, 0.024690478683488653, 0.34146008912309644, 0.23461328140291896, 0.12544843777619508, -0.33352035281484577, -0.0263255731155572, -0.14242250405233822, -0.15336720724119032, 0.06562190412823732, 0.5170717474621694, -0.2714918619145181, 0.328973721656685, 0.34057013166179717, -0.3184668799880539, 0.1391677601314125, -0.14625788140327917, -0.10734803170338184, -0.2839381726847992, -0.3617521903099728, 0.06409393676304169, 0.2638803171342632, -0.46611993662762374, -0.04020690932525224, -0.456974051236465, -0.20136133179936497, 0.04850924841719101, -0.29172530430736665, 0.3342599022506727, 0.23070246571891867, 0.6243457232479448, 0.02336126833047635, -0.3956218125524761, -0.09948183924415932, -0.5174828447504325, -0.211010882617534, 0.19998041998583896, 0.5805791189344093, 0.3197973783132809, 0.062445265165845316, 0.2024015842294778, 0.08238445917899952, 0.31151812638222853, -0.12891589926292665, -0.23319045890487883, -0.10873925347919049, -0.20363772956303844, -0.1943769291393611, 0.4360197765759, 0.28652615808224685, 0.3270265026433814, -0.19124916676772538, 0.10247799714078548, -0.2847259913992609},
    {0.19586263729235828, 0.25008197693884576, 0.22944760103307027, 0.24827646804257805, 0.14402351662985902, 0.46297678874122067, 0.09777194959946375, -0.42516160434042705, -0.1580899755357243, 0.15324335108597353, 0.3502633512442218, 0.267186636452287, 0.09625617385491125, 0.2870432415737538, 0.3022813614076293, 0.13836138845071863, 0.24631791739098163, -0.013897147964237105, -0.24872438949305792, -0.35297322346673454, 0.4114193035970882, -0.15359025934659618, 0.3650739123689841, 0.2979328563874751, -0.10772506877101651, -0.20195919931687126, 0.4205572062380679, 0.17858087197987063, -0.30328493199082585, -0.01745768031980015, -0.4661994278267694, -0.1074641718575183, -0.2397612561836755, -0.00871475222527701, -0.4465197962053857, -0.26655259011416144, 0.12146374625192113, -0.4548432943618664, -0.2071879384405734, 0.46609598016940224, 0.3953671102246762, 0.41741983049338627, -0.4190149679947804, -0.28744983479765657, -0.23886793305361043, -0.23346551692260542, -0.1811262318657727, 0.35056096108597284, 0.0751472765223023, -0.14355156973921193, 0.05308002446752643, -0.251843850778734, 0.4041800582449403, -0.03985500148748475, 0.5471370695104504, 0.2124159131755665, 0.3762429258413368, 0.07878970401643075, 0.45088661774781075, 0.33798908829208657, -0.16548647527515714, 0.43299060491738606, -0.22159114056859264, -0.2817520531723701},
    {0.11527063408147467, -0.4642824125032391, 0.21398267526017836, -0.4267801191439677, -0.05937270829411256, -0.4536953177883516, 0.029457886998158135, 0.16159718887305982, -0.10956208655986292, 0.17867668854946783, 0.28182324340684994, 0.4391435633312251, -0.12283218402405045, -0.40970926563208354, 0.0072684040330054074, -0.3794047591320515, -0.1768445524238614, -0.20750288620170346, -0.01203684582164963, -0.4823049915895611, 0.2027605852218137, 0.1892287622371033, -0.09347157281646341, -0.5005681203322276, -0.18148441979291516, 0.2197545258511178, -0.13903792032204315, -0.19616127901367272, 0.0821481324675269, -0.31741823358029325, -0.4918522940076889, -0.5101272498660189, -0.086246285483288, -0.2878953311378534, -0.6005095471064289, 0.26742590613461065, 0.2189680756555728, -0.3670346560088869, -0.00019082984648105295, -0.018241468558346918, 0.030706927179560285, 0.24484180557758672, -0.35229910866342756, -0.49563106917933497, -0.29211922488757086, -0.390419865970444, -0.1408260775639297, -0.25620089839148447, -0.20195717324639645, 0.13077942697455544, -0.4746147497490936, -0.09227802357069434, -0.08379737786034505, -0.29851009075085344, 0.10177648460517588, 0.06868670624719161, 0.5112912435313072, 0.0963905279482573, -0.10868598404346147, 0.2571379896104855, 0.19576652834631958, 0.13637982836960758, 0.12926578157100838, -0.12391117550404196},
    {-0.05952763282073826, -0.09816253313499039, -0.34155047131715033, -0.19352652036127063, 0.14579859197723347, -0.380484799020362, 0.07117725575093188, 0.3399939439611392, -0.2910979703074827, -0.10703393677317496, 0.0521941436020294, 0.29722737648200104, -0.3394844206596745, -0.35418519300712303, -0.32778908049288835, -0.25337552916459904, -0.043938545844299175, -0.0814168999275024, 0.03947855411902274, -0.4352048343773701, -0.46665141009186867, -0.26769676005738535, 0.5252551486136566, -0.49057500707159457, 0.09563520547963034, 0.26050212098874254, -0.17244146119426695, 0.38334837681654155, -0.07874928376760607, 0.4114046771915559, 0.05563433910664234, -0.35392365042043794, 0.08888448376670866, 0.23219429264144764, -0.2308306687984093, 0.23301059877765568, -0.060137904803518646, -0.3169339487181698, -0.27183837471128797, -0.2454280583870538, 0.2815080423259861, -0.0393622385724043, 0.04680360447160243, 0.294934312972991, 0.024859704776890198, 0.11256235438092745, -0.20372570568808965, -0.3256446182754034, -0.07098696021897334, 0.08037169152954006, 0.046246136194846334, -0.3150826539635432, 0.3866726138235715, -0.07215779406053421, -0.3425745595059925, -0.09004304325295129, 0.2665891064996787, 0.2397361631528435, -0.332151708714046, 0.1615834708042151, 0.1431093035790511, -0.24134521001227677, -0.33355718156157027, -0.2672635612849133},
    {-0.11415156278872474, -0.538159713539816, -0.23631094960595125, 0.18324382359585983, 0.029959129466277764, -0.03814702068672557, -0.2906456702571779, -0.12154921142018904, -0.07249956428041282, -0.3069276293192603, 0.001273498528955551, -0.1659267448987151, 0.12210720799006067, -0.032734045361043344, -0.13171433324724202, 0.22148507201589981, -0.24482084816553734, -0.06823006231222002, -0.2932175691037036, -0.45504984705522206, -0.2508240065261985, 0.16577342283019672, 0.530398010671795, -0.21564421840884745, -0.05349755199549567, -0.08548693858346024, -0.21703748991590283, 0.1927005928805321, 0.2809033969000395, -0.08723400885476548, 0.06508412463205891, -0.3653889065597994, 0.2695919556025869, 0.062387089977056914, 0.4820245984084722, -0.0032398542275859817, 0.0554479402433859, -0.08928432610181321, -0.07673997253803135, -0.4158158902707343, 0.045740228837101264, -0.2202449594703833, -0.49432693750044543, 0.35031137944993684, 0.16689363818608646, -0.026348648178409286, -0.369906545611283, 0.005284644510909593, -0.20557612744042753, 0.24711947336379564, 0.1498226179435697, 0.0708604195380338, -0.23609059487965173, -0.025376799933965456, -0.2928790487324094, -0.28277929179655636, 0.1980864315425528, -0.25629036148916584, -0.4267209316692289, -0.21763250617840613, 0.13149416945030798, -0.2847771845791838, -0.43160461098335157, 0.021449245062465955},
    {-0.3222238755756748, 0.04091246031674852, 0.19109465674302495, 0.2529357608484254, -0.25919903341237355, 0.1918991723089805, -0.08669155346140872, -0.13965184151445623, 0.19749521686160548, -0.25472076415082984, 0.08832820118746798, -0.08208773153048508, -0.26946849580368026, -0.04504424527403319, 0.3077194647981342, 0.1766588076112854, -0.35458947893280673, -0.04210780338495003, 0.42326544429038543, -0.38867650682193955, 0.1753712923967826, -0.4195545891638122, 0.02794934784391093, 0.37541135880193793, -0.4455705951807957, 0.1224012257917916, 0.2101805162633693, 0.037143558273871405, -0.18450380020075877, -0.32914318202465304, 0.11850015854677372, -0.13417038741583462, 0.24177517801790455, -0.028142593424682182, 0.5182710309061112, 0.023880854954899416, 0.15375404922869323, 0.18630551225910302, -0.21296666282346485, -0.41401926139822404, -0.4803532640933434, 0.24191416465184565, -0.37771086707149026, 0.21428607735134372, 0.09013280062830424, 0.19702077867960788, 0.34258326060566585, -0.13139666304006073, -0.05744751582237809, 0.09494645684455848, -0.17249898915621428, 0.05445210990605466, -0.49986701740556094, -0.39153380775661556, 0.44853039460544897, -0.19866518071659345, -0.20578367362110864, -0.17005918880884152, 0.24391434997141925, -0.46537861557675453, 0.09792848276603168, -0.17432575213525492, 0.39296020333624065, -0.03289754353462435},
    {0.06910107976641228, 0.141139113537917, -0.11375145059897689, -0.0070593659490895124, 0.19514057010040747, 0.2727874258807916, -0.22943041736072725, -0.5201454780755662, -0.2483266742944142, -0.09131697398661215, 0.2959492228271981, 0.4653034776668403, -0.21273763145334884, -0.235071218413239, -0.13233126668978648, -0.3581194300831079, 0.19810127404562478, -0.14714585517173778, 0.21638715880705353, 0.13846134139397467, 0.04872324755194065, -0.24004954584573915, -0.15988596553983458, 0.33521371816894785, 0.02842148386152536, 0.2081910188837216, -0.2707556331702888, -0.17812962811820532, -0.05828713355749475, -0.25990541774821246, -0.26199176485039677, 0.3573277624130885, -0.4313579902463518, -0.2626243319527033, 0.20030794118210293, -0.3421197089385172, 0.3087233781888888, 0.1868954745790195, -0.09594670540285283, 0.06339113304158286, 0.1331406392235854, -0.03531289917978457, 0.014081769112045894, 0.00868187502714894, -0.0926858609053138, -0.11023119868670285, 0.4751773010742039, -0.0855278200090941, 0.14472876962588624, 0.2941882834361355, 0.23406120831263122, -0.20450515519260867, 0.04960751891663865, 0.008496787166351159, -0.1377480084606768, 0.15593536217309745, 0.15396666457498095, 0.42616824663573344, 0.4778332636890577, -0.3218401750064501, -0.30160986926708677, -0.08240562149631855, 0.3817943045473542, -0.2309541975143492},
    {0.034752901411664566, 0.13083873381153188, 0.22591176255894763, -0.21275779344117526, -0.18087256568829418, -0.428063229269359, -0.09934571944036705, -0.2406274502020563, -0.2259631889637359, -0.16479742722890578, -0.4657055711740481, -0.13436591689116528, 0.10922441333681884, -0.19268796599517513, 0.10672887444299566, -0.16607334022962367, -0.32941615641161115, 0.061771400374511065, -0.1874323043616815, 0.22110163270325628, 0.12501295597287576, -0.22321228522065675, 0.14364027904605772, -0.18815835869774647, 0.133496279813387, -0.16237385335359647, -0.44826467554007055, -0.38383159981257714, -0.07964777543893202, 0.23581430678223866, -0.02579883769829828, -0.1653727892954087, -0.22631522990959693, 0.041825322244112985, -0.0193605972754774, -0.0897628560164432, 0.21280856699426534, 0.4948813448571918, 0.37798342379992667, -0.0521169873631999, 0.20578082170211823, 0.3214417168285208, 0.2140467123740262, -0.22367996665308745, 0.042619525244189764, -0.14487213996549095, -0.14977256638575526, -0.22109700736400953, 0.11428369824507217, 0.282729165163282, 0.12131936149191046, 0.21688364099159776, 0.13350107447786885, 0.16869565840269893, -0.18715441407320837, -0.15684223477560036, 0.0713005383267733, 0.4319345497294342, -0.3204508803677571, 0.061043286414301935, -0.2570654563840644, -0.2502780518332166, -0.37668961049877, 0.24199177621942922},
    {0.050203024010564555, 0.0730472519641166, -0.07908340032639087, -0.3391246634918847, 0.06288020218862335, -0.04603731537953622, -0.24531682260706708, 0.20334023339677532, -0.24625824751148867, 0.1532920147119668, 0.17395055430771064, -0.2992811035194832, 0.17211555838515447, 0.22268930654604166, -0.014659408747424243, 0.032284527993923055, -0.4588301201161335, -0.16033052458495686, -0.15691830458181563, 0.01570512569685016, -0.12518916682000533, -0.1601524751245934, -0.17307069645863904, -0.4003922171677657, -0.15653784518336802, -0.2664053754862313, -0.13364375286060548, 0.14284556095355375, -0.21300036703103192, 0.33396008886422934, 0.40455570877976077, -0.08359374248252469, 0.4104833229351915, 0.011891852918761813, 0.15652202130358336, 0.4062994805717352, -0.11621002119998464, 0.08634354960840208, 0.35003750915029663, -0.155796938773343, 0.49044364845181865, 0.3129291809353867, 0.11492082169384325, 0.1053796283255817, -0.0056020990376780605, 0.03291250741768758, -0.27339830805351345, 0.25518301788396264, -0.1915870086433638, 0.368226860601507, 0.04432912542604209, -0.03408135493778898, 0.023608901598671354, -0.05953425823798633, -0.2563151591535561, 0.09151216004153509, 0.031179113033610775, -0.3914681919363073, -0.3913059323956254, 0.3442362485232413, 0.3785656490819209, 0.45653557944264334, -0.16030359618331844, 0.3994853880176638},
    {0.10994445514974506, -0.10768107190801468, 0.14306583765704473, 0.29729905696047954, -0.11020547471423259, -0.033809290805722175, 0.08932993573033698, -0.06043218271863688, 0.14252027116198326, 0.05899066911471002, 0.18692741165506016, -0.062415525930057114, -0.18660735948596588, -0.13825529911687254, 0.02972445924181955, 0.12591818648124617, -0.20843485062894584, -0.01031456680491379, -0.2079976519218848, 0.25350103595081547, 0.3301695859323427, 0.3325457403376289, 0.08216900458222953, -0.34341329616082855, 0.19718841795864644, 0.26916379731221063, 0.1989686435508276, -0.026054621697785423, 0.045764997062411085, -0.07715796732201215, 0.2016484796934235, -0.11654138582310286, 0.11282285151610935, -0.05031919420269763, 0.4153310098718416, 0.2684054145880042, -0.26164172448087386, -0.19853767366117692, -0.020066406615029047, 0.30289743670684627, -0.23488816550332095, -0.16418272904944167, -0.1078171505961246, 0.15427245219594163, -0.31211597455963563, 0.1758652323854956, 0.40097458618549425, 0.35581708787576355, 0.2206959176407863, 0.1238009715523775, -0.1959895524151406, -0.08036106602423028, -0.2694963178144571, 0.2806787577560531, -0.13424887777283964, 0.4337840809739679, -0.1831040763284503, 0.08369221792699859, -0.356075104252003, -0.38847881264186596, 0.18731431041022492, 0.03629152757376093, -0.15443210563522347, -0.2532563075218363},
    {-0.1417109604517703, 0.39077606336201803, 0.14015037759643606, 0.43366685669057375, -0.1560824013770103, -0.142717543781142, -0.24473068437356568, -0.17203710048371654, -0.09844972664362622, -0.36762355875044717, 0.33280730236732825, -0.22873407469221124, -0.008081023312005437, -0.18267679756061062, 0.2556461003290862, 0.22289419339765432, 0.2819518376210699, 0.2467179618635337, 0.23377932928240203, -0.02052773733852213, 0.014266692331572482, -0.07883434880094614, -0.014645091480483853, -0.14418967970042795, -0.07063060305328685, 0.43753717456818375, -0.023097653221135727, 0.2503959333130339, -0.2772145930314102, 0.43209311546340123, 0.3177545161399784, -0.26191328634771943, 0.11909630122139711, 0.16508097767691568, -0.3656354892667266, -0.03160967936145977, 0.4010284673492228, 0.2960175122045018, -0.4114848713962233, -0.17745551588533437, -0.3742684052360849, -0.05109951242295527, 0.4001934470480416, 0.25803176438385855, -0.11140710735767645, 0.2434875690614481, 0.2286307291971, 0.19908077587261339, 0.38135402998115875, 0.17100449894568243, 0.366645789741096, -0.013928089188207296, -0.18889069927331548, 0.46124199673841304, 0.34266967107906543, 0.06566126263529369, 0.20182713216344353, 0.17844158650602746, 0.2123069132920646, -0.4260633675231922, -0.09217096581347904, -0.19069907232650762, -0.19324621626553182, 0.2791890156392019},
    {0.3574184074460791, 0.2606309537825896, 0.14154515597634962, 0.10496666281814897, 0.05144343268950777, -0.16960146677524948, -0.28894766964263946, -0.1147762465767967, 0.20956143135584943, -0.10158923377826033, 0.33996042434698204, 0.18546359714515254, 0.31000803065071914, -0.067437254890616, -0.2648928344098637, -0.08800168859403457, 0.4332599648879477, 0.37001620717379496, -0.3161080635346809, 0.03340752026256524, -0.19868329732462692, -0.14938387780615064, 0.2902076053910496, 0.25786408361580465, 0.23472517953960995, 0.20506836220692715, 0.2614419970879473, -0.296497742871447, -0.2080891495755971, -0.031107242977321897, 0.09626972376045521, -0.06976962837097951, -0.328101275009165, -0.3315137386036796, -0.3338293193045732, -0.19480126926603925, 0.19106382330607205, -0.4075434760860424, -0.08932974700647646, -0.11891005347033609, 0.4794456913160293, 0.02776775158327305, 0.4490997378832606, 0.30787833942089765, -0.05270929197316831, 0.07488920508942747, -0.22740550995767803, -0.16019666358223755, 0.28158684883363194, 0.1146058777947215, 0.3192987785454698, -0.23768133243004974, -0.0653907556887274, 0.18782727875660893, -0.3100913551781358, -0.04791911140582121, -0.21750918279053555, -0.16306542527168844, 0.4305289367379026, -0.09408930680796755, 0.03678086714139233, 0.14051189025482816, 0.3674235497339483, 0.26568346498697964},
    {0.003066392310577223, 0.0975255609527644, 0.11538728961579892, 0.10292081661887766, -0.3717237170062322, 0.16820381329768172, -0.24414948056853092, -0.5134255634766203, 0.09907247820965619, -0.11224401031637124, -0.08199007928754348, -0.1820700789073575, -0.25971568416652724, 0.10017351320448524, -0.21154985620798467, -0.40747642187045346, 0.279797745802408, -0.20697393766502675, -0.07101136360071097, 0.08477501636984869, 0.23216133447062262, 0.2695603864303315, -0.37591063276402353, -0.09566931800264306, 0.15311891918362636, -0.07234659306115034, -0.1048063792634934, -0.11273805872736556, 0.28135894991470656, -0.486658706458745, 0.06044837280491531, 0.21452625485465054, -0.3925783484727688, -0.20539983652307586, 0.22509527495687498, 0.24142813862225385, -0.2740605371710031, -0.21841200576970407, 0.27954679390624554, 0.014795627636866733, -0.4271761833412241, 0.05824986905154696, -0.4516266600994896, 0.16241721711377594, 0.48494567652136505, -0.03547822444087702, -0.3210201647058158, 0.2746586950520773, 0.11058983418969763, -0.24320439926855467, 0.2585486242606461, -0.26907777400344324, -0.15013348756744502, 0.08405293667017548, -0.08571391169584082, -0.3031642255476348, 0.003093809959502581, -0.03481715847373854, 0.523101149103481, 0.24771165838526538, -0.3552334537529294, -0.3191961622277022, 0.2573142628511379, 0.30035695080669605},
    {-0.09070298024427324, 0.36070312912433655, -0.16593865003167232, 0.3988000078672336, 0.05713817132576143, 0.24325280817394535, 0.2311196902982166, -0.21509227423797403, -0.15342513484451947, -0.11374318823874426, -0.10704450291366739, 0.38735348357425503, 0.06647573550613983, 0.02228804787414739, 0.297070589134396, -0.007293747952624712, -0.1333710409397462, 0.01613742433551366, 0.11383977995042525, 0.3632242901297814, 0.09005420490360413, 0.23563422181791935, -0.06292133962934647, -0.12585598136460366, -0.22615208144712906, -0.3387209677340389, -0.00973755757222735, 0.30083173898177634, 0.1087603632262837, -0.32112282937721076, -0.11130413226388568, -0.07413659164653101, 0.34036891762536403, -0.07818103733313535, -0.32973093353058136, -0.0383047127763676, -0.469896093470489, -0.013340800474949606, -0.27846156179839876, -0.0722613614667145, -0.3024038565117046, 0.329086737310421, -0.33356358678562914, 0.25451794089386603, 0.13259182018345908, 0.016331993690934132, 0.14475099110963707, 0.02487917100437572, 0.4538247394125732, 0.26477072842476684, -0.14429750068302985, -0.13127264319716006, 0.21919926821607405, 0.25088215340920605, -0.09736923306751542, -0.1372596608226051, 0.08234092942948142, 0.23621732979493587, 0.2316689718304316, 0.23339138814720528, -0.13990069505785774, 0.09875339600384354, 0.022362253330703102, -0.31052647609403966},
    {0.12427521336633504, 0.4554646930037583, 0.0073540932852688675, -0.20286471689888158, 0.05882516204793974, 0.3884910678327943, 0.14480049133262768, 0.3284705446263048, 0.4527414571498992, -0.035737373648589796, -0.20652526292787743, 0.11288457972903787, 0.3366138857846474, 0.11852702511773815, -0.19425250911482592, 0.3254987431213549, 0.14611946378678617, -0.265004061627373, 0.15291966529517087, 0.26742337684282974, -0.07310579839764303, 0.17791952644783118, 0.04794419097004568, -0.32018361691931674, -0.15348856587109289, -0.320558349732898, -0.15424972817033214, 0.2977081968842559, 0.12708084040995757, -0.29830999798886426, 0.21418597662798303, 0.2852542824071996, 0.31457453639123667, -0.25536831584071107, 0.4096900843344269, 0.11714693855523407, 0.38675729270692705, -0.19546048054796708, -0.053004904798058694, -0.11506509603591204, 0.37416433273164607, -0.21196904916058878, 0.130345217047948, -0.027116328224378893, -0.24989971736602334, -0.06860418088406865, -0.35750606018366277, 0.04316210751315114, -0.020829116608347655, -0.06509818815183978, 0.01929287917349521, 0.11787683600444544, 0.25746571973384497, 0.086085541051102, 0.09754415297764414, 0.39568425670435764, 0.1394418775564063, -0.4209476949677198, -0.06315441982303854, 0.06268421902161717, 0.22676002166852002, 0.023625194518663753, 0.23037399747657117, -0.34317839348960666},
    {-0.09361165308207535, 0.256122340963363, 0.4860418035062509, -0.23580078698063933, -0.04694812408887896, -0.06605612667212613, -0.0967103680456072, 0.22803648654203312, 0.0029842322013849303, -0.34915445390630684, 0.040900848410228605, 0.014290892433860308, -0.23489271958146682, -0.3841407099377126, -0.1679712106968531, 0.2729913297017853, -0.3923723494201532, -0.3367392736197336, 0.17525341184228663, 0.2885964731298186, -0.3513419610993813, 0.37563317549689884, -0.23516570865447686, -0.5555805452916954, -0.012622360649152576, -0.007515485791500844, 0.2807723068948566, 0.29111759395296616, 0.3896348940841386, -0.11475559360079685, -0.09932932146275417, -0.12078149258492551, 0.008237589473048835, 0.37990089214093725, 0.45595278200497996, 0.3369859059459565, 0.03640894066079628, 0.09557335979382538, 0.17463522154187283, -0.0346757701282607, -0.1463588541058165, -0.07763296278300104, -0.09398418981292825, -0.0034062857066767685, -0.45653847034370176, -0.4079421753211769, -0.21281794321718023, -0.22669693477354913, -0.2663655009212494, 0.10587816918805001, -0.02961110830852538, 0.11108929675220129, -0.33530385238967875, 0.3229617518408621, 0.2607512142030965, 0.3595889396381754, -0.4071017487676224, -0.43688016019897286, -0.00397521384109893, 0.24802958457020555, 0.1770754021979454, -0.2730243750060734, -0.1414536717490538, -0.3029147101986073},
    {-0.1465925788191984, -0.11415203135280853, 0.2094702810513665, 0.14720589552842336, -0.03505264188900632, -0.4172573026619301, 0.379348919659978, 0.24628575809691994, -0.12062190499696282, -0.1366643500295274, -0.38590448298138613, -0.3245752673245075, -0.02078681562026108, 0.1085702086927448, 0.3057494920632573, -0.27629035408162833, -0.0042914113852456914, -0.09471973561079869, 0.3977912536205907, 0.10760513390489349, -0.30698511037375426, 0.2242211952219342, 0.4190992639340817, 0.1705385253176963, -0.19785208084472378, 0.11348110977934384, -0.14929057813079277, 0.1043382112647743, 0.21126889737562482, 0.2566017040500052, -0.1672234777472769, 0.24149362636929314, 0.23129638177392597, -0.14647498655862676, 0.29595344119902034, 0.273619192204213, -0.2901456708895695, -0.278684956063904, -0.10230157194933509, 0.10300695188040246, 0.16901888065297674, 0.04479382601327257, 0.26955273585889056, -0.3736101279297236, -0.4074872194776741, 0.2179666896398015, -0.15043424629217597, -0.41983222208802806, 0.16005435717289382, 0.13301236408077965, -0.280334456519704, 0.146773668186315, 0.11988961300753012, 0.2052390248969482, -0.37228804366410284, 0.25378683238042016, 0.3014839214660067, -0.014767304891296018, -0.24114939779022324, -0.3882420032521878, -0.07834823873651103, -0.048397737709633695, -0.41424749734787053, 0.13292222451615984},
    {-0.07666826179275903, -0.46838645183963185, -0.14746623364042272, 0.06853555944263251, 0.16897643036132143, 0.5828816468484529, -0.23002762937824636, -0.2664402842722307, -0.13188909986618508, 0.3268800928249992, 0.2665233230690336, 0.35202006324210694, -0.03623964441257271, 0.41414102243572953, -0.05391404396853456, -0.44010156447504534, -0.3444017102037415, 0.26234196899857337, 0.6093368889150361, -0.04514720538335153, -0.25877652894150505, 0.41151048703540405, -0.31692323350378543, 0.32417505212321773, 0.48688130221239617, -0.018829042738872117, -0.33782208698696076, 0.0958764285708179, 0.2879244798745765, 0.337423815557134, 0.3447507183607639, 0.3604337193015754, 0.03873098228769081, -0.03646005150964111, 0.23536473514036313, 0.3480466036348527, -0.24762974600386953, -0.18726795271962318, -0.2011461883801075, 0.25019789831179645, 0.23498198331636952, -0.10205113046426754, -0.3753188046408113, -0.056895317733770975, 0.09220630067171202, 0.2470021727871158, 0.04463121642272961, 0.25181455865519586, -0.18710624539954646, -0.3851771176756399, 0.14425190534118876, -0.1425411736693424, 0.163198688318372, -0.45182148038404263, 0.02360660874671259, 0.46317838951037127, 0.3499647963041323, 0.1925173207239078, 0.3516877117318811, 0.024004565369124268, -0.12046149170764264, 0.22744553873022152, 0.3422352139981485, 0.11396068543306787},
    {0.2830784082277913, -0.03074717915127385, -0.14664118930051978, -0.16789221854896402, -0.19907669316772258, 0.47730992137824674, -0.3055332478749398, -0.5416077749323844, 0.1633833737350642, -0.06055830482787152, -0.29107185262259894, 0.14514861407480936, -0.026311165931249585, -0.39197954889062997, -0.1827316375821774, -0.09147925734219438, -0.11396870077553807, -0.09923822420510271, 0.3626670655852276, 0.2172013504259744, 0.30293024066654045, -0.2548448650571497, -5.943649503854268e-05, -0.20237993915095198, -0.3498841047451383, -0.11078540188804051, -0.2582320011338812, 0.20732059156931293, 0.1870596447044449, 0.445644443628557, -0.16725642682807842, 0.4344463937463284, -0.3272083944161883, 0.3492402162223381, 0.32563711531478146, 0.1978356679774007, -0.5343676111227161, 0.031731506818928994, -0.19505519610258304, -0.047343395083116725, -0.004315285239244326, -0.1072018172671915, -0.2630421134279482, 0.22475534690931534, 0.03742741012238668, 0.3835674448362994, 0.1755834056769387, 0.20272570504583345, 0.14754195797225492, 0.32337690016729154, -0.2102893337657911, -0.348327988546249, -0.24798340254527354, 0.08914487111930337, -0.38887257027775507, 0.27884444032146416, -0.40366679154254737, 0.16731919665195807, 0.27246058028821146, 0.32716174334845394, 0.29430107999520344, 0.03188899436800765, -0.08389810885912495, -0.12427685702007386},
    {-0.21398748749852747, 0.26030669636879467, -0.5501715935571487, 0.3041847036492866, 0.22020523184254587, -0.10981062045086436, -0.08973066266324863, 0.055928897498253125, -0.11153841902195566, -0.24104406027461472, -0.4977166887369306, 0.06831722325139364, 0.43196722940325044, -0.22041355707321014, -0.03520837290207809, -0.31890601197966423, 0.2031259832881494, 0.176591094304746, 0.17481701182403428, 0.2166989991318778, -0.26138746389749073, -0.43522209286848657, 0.15917804369050184, 0.24048018763333492, -0.2534136398031414, 0.1950176888364706, -0.13526332181224765, -0.40835951377093943, 0.21358677212924473, -0.2995400050780488, -0.08129054824456503, 0.38729899108314714, -0.09733106292747361, -0.34701319372121764, -0.1145863567750499, -0.12617507136047373, -0.5439607120009415, -0.2624010764701963, -0.4042152387088624, -0.09250465834664366, 0.15581438001258904, -0.3738670746543903, 0.4048179835923767, 0.09693506179811752, -0.13324385879290976, 0.26442605839567057, -0.20216737942075452, 0.13446489662547573, -0.3528812368690132, 0.18451439152146623, -0.11957054427809338, 0.05313404967879333, -0.20907862198624388, 0.06673201709581487, -0.6138585862289415, -0.5709172688079064, -0.4866421101728098, -0.033327850384439174, 0.33763968045857884, 0.17190887798590163, 0.35052357636644, -0.27495631656810127, -0.12557515125362687, 0.26275321171669774},
    {0.1057081670856609, -0.11016846532607409, -0.08158501847902781, 0.3650785465169921, -0.2418019205229821, -0.012521496267272732, -0.09978053477706965, 0.32724995270207785, 0.3196055536534555, 0.24214805192821284, -0.35293274239108424, 0.2709060712733589, -0.1748267188570801, 0.08600877910429694, -0.0925007716634224, -0.09117754412514271, 0.39110340106127445, -0.008991931377707716, 0.4216129360222385, 0.10252760286789438, 0.052844345306132495, 0.11157003125570235, -0.029946687174243165, -0.062340917910538446, 0.40946890793991714, 0.047820608679851634, 0.288111400354082, -0.09806375520243958, -0.24992892466404362, -0.11155607378730231, 0.1640414948128933, 0.4120391738926381, 0.14308714446592574, -0.21666430771082965, -0.06061637125062029, -0.1504583709800076, 0.13646159437053734, -0.16077668250612012, 0.30666169817455735, -0.07372589003801908, -0.32360072403877266, -0.06730147159491233, -0.2604668560249477, -0.10719440973540759, -0.1141177821531932, -0.13061977223198462, -0.17238298314041547, 0.4951558257739307, 0.20787914099059493, 0.23728110945279077, -0.22003001255799062, 0.009694777735818894, 0.20138326996893288, -0.19321819189939943, 0.03224213420551821, -0.24751673479370248, 0.09918362594584619, -0.06100386003913255, 0.43500271491928777, -0.07791294577270787, 0.19520495473415314, 0.33167634554349035, -0.3947550154042388, -0.07974642506419657},
    {-0.31808947993787196, 0.4171964755372845, -0.2751503424558035, -0.5133923202462414, -0.4328649428303156, 0.040593777050614864, -0.07516563824035798, -0.1723906911507534, 0.22722572190155033, -0.3110739471720461, 0.11326297318440141, -0.25473562058889565, -0.08921519473931691, 0.10719616983778227, 0.054518074211315354, -0.26168196423565204, 0.05635593778669365, -0.17853468211898432, -0.07100858695108078, -0.04958313324341261, -0.17750692807901258, 0.24539168308538759, 0.13920954511034755, -0.39771986578388974, -0.2978816967068255, -0.23827981220619418, -0.18025720208599616, 0.20473770408618353, 0.3063738382157898, 0.15611283431782522, -0.007833199296189655, -0.3830868751868109, 0.2769021800009844, 0.08742383771170886, -0.1573213150377569, -0.07695389088069728, -0.17525138944553065, 0.01162319161275183, -0.022517684138149512, -0.021642691913741137, 0.08443678819837118, -0.5004506330737852, -0.08410138971527731, 0.16242668256340745, -0.23444224165151512, -0.4614118597396025, -0.18642686053530577, 0.44777127430680125, -0.3341566607637249, -0.38273665977138255, 0.03111484276934447, -0.2936524618984937, 0.019034655540965527, 0.032143888360368876, 0.22282792558238096, 0.3159548915966672, 0.15186928318273152, 0.20654082202422624, 0.3717308685626475, 0.15194502233859603, -0.3875213465071382, -0.34598713400550407, 0.05603127592155852, -0.42642324108744045},
    {0.2074882010481726, 0.020637355423708845, 0.18181785280644533, -0.05776370992000702, 0.28881994845126757, -0.3670181781263921, -0.3058007001632266, 0.19186004599453266, -0.2874499062694978, 0.15185535025211458, 0.4360137725043829, 0.24094415019302654, 0.021504649546646704, -0.3056652693047458, -0.02101907700453496, 0.1389495236596735, -0.08107296982537077, 0.239135957276116, -0.1623883451078337, 0.3025654423665791, -0.24802502053510442, -0.19016224340021748, 0.08326572862118366, 0.04292570668284978, -0.3202753257307251, -0.16899259201003586, 0.13186810375395897, -0.3141092422252358, -0.22499179163838953, 0.2552401813502421, 0.25880985791858463, 0.26413919941521546, -0.012026095765195342, -0.11589699032997185, 0.26539772527638267, -0.223916437218011, -0.026082664285876633, -0.1235120515106936, 0.08545711443743348, -0.2654074235740745, 0.26444249175247614, 0.1056746655950886, 0.1903093059903951, 0.17516105140209673, -0.3223447366099867, 0.3497473168887056, 0.285945597937446, -0.17209366418024286, -0.34774660774213845, 0.1770212596571297, 0.280501498413795, -0.15446337281876416, 0.14896111539159032, -0.22464813727504193, -0.11286075239384533, 0.41395011069139387, 0.22720358904009233, 0.34048698134968247, 0.06017235658426955, -0.07177511802208397, 0.2702658881552102, 0.46410440605765363, -0.2833801192264937, -0.1534199446977808},
    {0.14191656559269572, -0.4251783038754694, 0.09951890313299619, 0.19216111315018058, -0.25125600845301116, -0.38788601112106613, -0.2174662630042971, 0.41780312102978384, 0.2626251275290191, 0.1653203408590932, 0.32523796359037915, -0.30409203588356554, -0.18467999742189384, -0.22168975544369823, -0.18619765029050814, 0.18083757637356745, -0.10596387314587163, 0.15771801483644649, -0.40176004165216983, -0.46708313787935396, -0.32491492871475086, -0.3203893131871236, -0.21929992828598602, 0.039327057609355155, -0.1269939462589753, 0.04758006378314231, -0.2656628511571418, -0.3617246060709599, 0.30923586335600683, 0.18921650751946462, 0.025501352453539013, -0.3014899826863826, 0.10007941328081336, 0.29843984840825993, 0.27046576911571674, 0.2532754662886322, 0.13720731703844005, 0.29799723861977695, -0.3519432286631252, -0.1069297978282939, -0.06524916026436686, -0.05637025903449334, 0.18553038394535382, 0.207847454846089, -0.26540313553142264, 0.046697180983380944, 0.31381422654915364, -0.1252838274771053, 0.07349647951731499, 0.35793322824998125, -0.15958648299317726, -0.19711203557646012, -0.12850985425879047, -0.012286463073010945, 0.35600793704396544, -0.09251563999752975, -0.19896743203545317, -0.01668452692519106, 0.24489931240192112, -0.02901207416721185, -0.3217336855751184, -0.3299979665710625, -0.2882225789271145, 0.30808357568267036},
    {-0.07487340275406132, -0.1518340020376641, -0.4484045336954626, 0.2792403234906186, -0.06859776713411794, -0.003894751104689083, -0.12870536549405398, 0.3574233346709161, 0.2554778602798577, 0.05726173195491827, -0.376971190663387, -0.13622123230102334, -0.3564157795491384, 0.2813087108742735, 0.08912878759002593, -0.5255550536491762, 0.09758038915994327, -0.1458267609324471, -0.3658431701576552, -0.1936353623466136, -0.22322804123924653, 0.28843691201108645, 0.08842851463841925, 0.1786756066094337, 0.04729323818318456, -0.36777383712079814, -0.176574617273981, 0.2349090072604596, 0.08785581057561959, 0.04875885140794133, 0.1277631850305102, 0.15798323170244993, -0.19352562895479478, -0.19668883447303792, -0.32337742776870554, -0.21466346120585458, 0.36404691050402016, 0.32066803944204314, -0.11931438206184347, 0.07116321913958831, 0.18807777841307927, 0.06672238739781791, 0.3209603000808813, -0.10479279804817278, -0.04653374973369337, -0.2693992199989589, -0.4007140506400668, -0.2585204029703455, 0.21368722916733293, -0.09242007738943517, -0.09745020131814079, 0.15344774881091097, 0.259932832755506, 0.13205504281027186, -0.06393053923324209, 0.1616417139664679, -0.3518026062587369, 0.16166300261684852, -0.01815252177529658, 0.33172875410212305, 0.021537016327426207, -0.3816109042977494, 0.2944391642325181, 0.0380009232108512},
    {-0.6204152393922259, -0.7133563258599612, 0.16189802126857042, -0.6843550894880669, -0.6976259738109432, -0.5383458724171227, 0.6004201343581491, -0.5105831002180174, -0.5768604082833949, -0.4727997095044979, -0.6760500908904792, -0.31244809934364587, -0.22994899291279727, -0.8479626665448323, -0.7459970459419436, -0.48789310966883215, -0.6551100894747787, -0.602222782299033, -0.3246233492784362, 0.31287539294499556, -0.6262541524901972, -0.35520298223664115, 0.28550496629303235, -0.5515684489960391, -0.04780565211936407, -0.462012379035588, -0.6360213376520121, -0.02382840173154086, 0.39318148382271084, -0.7833657093068322, -0.6799027814548717, -0.3995799260611608, 0.2695868020798052, -0.7888252454028672, -0.19365157552353224, 0.3079244562617238, -0.3009718416162011, 0.12443896872202266, -0.4908645632677828, -0.5833255449256767, -0.7764202812015568, -0.6180102764061721, -0.43535931954303203, 0.24539672614229976, -0.4211129563533556, -0.8401149683770377, -0.7398085881044277, 0.6197304291331545, -0.8452905375497702, -0.9217203584429422, -0.4414943785298841, -0.8099406291155582, -0.4251317813692057, -0.869898880705529, 0.25967149275405194, -0.667694215259401, 0.07453230215696366, -0.673269937357631, 0.5989782113015754, 0.03462544517098548, -0.7308332012456248, -0.2938851719419968, -0.9317181870701033, -0.6836965070064435},
    {-0.32311335584542084, -0.05791393987400425, 0.37029278072523886, -0.6448609834585713, -0.7507842107706494, -0.6991085207503985, 0.5807672101957816, -0.6766951329004088, 0.10937441234562817, -0.17162494288003197, -0.8561341632904161, -0.31893633906965574, -0.5428525828775114, -0.41519842306674165, -0.6323603940424777, -0.6413616394874101, -0.34077957683251586, -0.02997778753996443, -0.5518674166266134, 0.6546733583409944, -0.1233275233387311, -0.3776684795182573, 0.44231711047897754, -0.741175700915709, 0.06452680801185756, -0.6665633509449063, -0.14181070434557733, 0.2743854520039639, 0.26005104723208894, -0.7345738675398098, -0.6260203829780515, -0.6604282697332297, 0.03239935242417889, -0.578048215597727, 0.11802852726458547, 0.7734175420462807, -0.21709148225319125, 0.3491447944761131, -0.32989269241571334, -0.03761351288431992, -0.5352348662193563, -0.6567684460305382, -0.3494478010037517, 0.36862014339616034, -0.10426958459218684, -0.9267649965238024, -0.5462346648702266, 0.741065648330409, -0.7205466459900381, -0.624779123678256, -0.4870330557379015, -0.8681595941028881, -0.6686385371225932, -0.7928042163938066, 0.5490638332999556, -0.6080108498708406, -0.3205876936353667, -0.07033171695196815, 0.7330099355343948, 0.35580509300484253, -0.8744129144875115, -0.5662996982541666, -0.6439143097795107, -0.6369628274213673},
    {0.06036585704846569, -0.6058239553871322, 0.2535795629167959, -0.2929849621785147, -0.7377152034410894, 0.04599419134713876, 0.5487821282802882, -0.16031796225843092, -0.386578640528069, -0.3759106671325777, -0.16555295723639957, -0.09609352760572398, 0.06564369560306679, -0.6457029808371714, -0.48809565105868186, -0.5630812555029427, -0.22937844050833361, -0.6322917743272756, -0.5616833724243809, -0.0157237947296064, -0.4282895121869365, -0.1438694793301819, -0.007959483140419468, -0.5898897665158008, -0.020604324837631558, -0.13989484118043807, -0.4607779366125921, 0.3714173663806173, -0.13094060453398151, -0.41793333182071357, -0.015611496332179677, -0.05223468023665151, -0.27728172648129296, -0.22035640685080807, 0.4443302820376544, 0.6657437563895439, -0.5555933384729739, 0.2582532427750393, -0.35402171238062907, -0.6243490893913876, -0.5986136169545052, -0.7751711720888411, -0.6198037070896788, -0.13540058666236462, -0.12996215135209865, -0.6064380081426411, -0.7311919948101328, 0.27873049645767817, -0.3953659832193213, -0.48267878390166, -0.3908688258180243, -0.523155656109819, -0.6069613806097472, -0.7495189630676963, 0.6136596839807207, -0.45737412593788646, 0.13891864226866538, -0.23205652036928248, 0.4633478887109794, -0.39150946795904346, -0.8326055340025758, -0.014498544615973372, -0.2065942443223662, -0.3971947923231352},
    {-0.2638687019853028, -0.04124747522718804, 0.26017439765952016, -0.6585473287217538, -0.5984103706770385, -0.2114010338534751, 0.2610603936152177, 0.030872436365548643, -0.38634456392040706, -0.43088185987301064, 0.01622794797101915, -0.15997512914143172, -0.30735573359703366, -0.16017278904112442, -0.46829193466207986, -0.2277887447139568, -0.44947997242517035, -0.24807680518388014, -0.25135854326867546, 0.32780005761614717, -0.6344038253004406, -0.331788140272819, 0.1974579763932842, -0.2236342166244312, 0.5845366427174223, -0.6088650954505811, -0.5451390517159985, 0.3940700457948583, 0.1698532347963879, -0.2537411954525209, -0.411766082190519, -0.4277521977346398, 0.20660478761405454, -0.5706428676300048, 0.1212211920828462, 0.17399782204163475, 0.059782106267948554, 0.18326160058463628, -0.19579921474213405, -0.27995760511143386, -0.30695271468494884, -0.38698177522190325, -0.10572719662018648, -0.2441818797938223, -0.03975482561749245, -0.6501303386197058, -0.5288183716268433, 0.4089324606398367, -0.20540666037260544, -0.5484146763494498, -0.7202230893280525, -0.22354497061767536, -0.5911862049934079, -0.7125828236380032, 0.6805838122331355, -0.6800284603276875, 0.10224670072063947, -0.03430007632990072, 0.2992700199618472, 0.1117613730930543, -0.23538711588811856, 0.04402665488939124, -0.20830840438518913, -0.22747458818673583},
    {-0.07583730922801421, -0.20263875296856218, 0.3834364884477219, -0.5187405584149292, -0.5601866401353679, 0.11148429908868221, 0.36622311980659034, -0.18964618417370332, -0.3145740820109406, -0.39565256335912685, -0.47672349442030243, 0.05921993717379598, 0.060235358977085214, -0.3824855100093449, -0.34506864649757346, -0.39160208653925527, -0.4481015056098162, -0.46149959704579036, -0.044415106919824254, 0.5718407881773923, -0.506552128486626, -0.3729136300438484, 0.3656069586177217, -0.2216564067807728, 0.15174140160807625, 0.022167710653645287, -0.27016351077844325, 0.5751849328160299, 0.5648783076828968, -0.0493819376183486, -0.5190636996977234, -0.5905764347860278, 0.39551880360628966, -0.35230851532882707, -0.0655286229105096, 0.3580783024174671, -0.15972171700333512, -0.17965684242342006, -0.20334557439810633, -0.564206143117022, -0.495927383222018, -0.5591248086676518, 0.029319916502672762, 0.1282232459102748, 0.30931131964924274, -0.6598908995912932, -0.16228392617814724, -0.17928212321483564, 0.040200726228965755, -0.1170723086169581, -0.5754496145096355, 0.08824586157538128, -0.30898294082202854, -0.4727922761872555, 0.17594342394938553, -0.6927549787415345, 0.24088254070400447, 0.2486688716135357, 0.498289424969138, -0.2683036209249677, -0.49986455454785095, -0.05588173082262699, -0.562574138646617, -0.5871569459713515},
    {-0.10361983399678343, -0.3508286539029735, -0.4570827298382115, 0.019748040317622496, -0.47484267350133846, -0.31230046963788916, 0.5131395691279736, -0.43351264839353315, -0.4033784251434187, -0.45636793504268225, 0.0152429355625231, 0.0375048631532062, -0.17745187883080338, -0.2597014091367542, -0.46522346486851057, -0.3932241695640476, -0.24087744157407837, -0.3388757769081495, -0.3479409619244964, 0.4207087573236751, -0.11815179554086654, -0.14847681418192019, 0.22973978447347573, -0.14608849964951545, -0.39268583578675054, -0.16183229010969918, 0.004006179163057281, -0.14696990579373, 0.0802369347321106, -0.5429627663501335, 0.09905748383944246, -0.364066657877435, -0.44901519573773313, -0.3694343695559816, 0.037389129101923484, 0.5097638475600964, -0.3554629009565234, -0.4115566113569369, -0.5127900434200457, -0.5930790639253677, -0.2890034937207717, -0.23026570251425665, -0.34341277440673934, -0.40728703263733734, -0.2764709226439231, -0.3707477055160108, -0.0491778592901289, 0.6089698259695947, 0.07052714782620267, -0.3453794173682326, -0.529812791738934, -0.4654726669571591, -0.1896411853276685, -0.5858053943710751, -0.16804640537707846, -0.14433996644508226, 0.20317598643680598, -0.19284644186177952, 0.18500317611960396, 0.04830612451693519, -0.5385785320476107, -0.443478050707818, -0.5253293783905659, -0.1636281588970594},
    {-0.25653557059730603, 0.33396032871797476, 0.1820181483736242, -0.39139549292915665, -0.03571014999802708, -0.23978931460879585, 0.40441840020707504, -0.25458845753592746, 0.10218064633300628, 0.3595289903166309, 0.18845861140466655, -0.5363676731833673, -0.2045410592130498, 0.2900218806864205, -0.042243921653161716, 0.09825506619244022, 0.2012433562029667, -0.25378278707197993, -0.32751288812996276, 0.48719811793348905, -0.14182772302618815, 0.07589426414392508, 0.29558805262321824, 0.045111972930164716, 0.3422782812039863, 0.051276636829545565, 0.20613193837389765, 0.34134483511031977, 0.23884062804578207, -0.17512295939409991, -0.21753232931255945, -0.3369324606743713, -0.37802318362861015, 0.1823243523028492, -0.4079758619829838, 0.07913938758276483, -0.023640789634514405, 0.5460973100158926, 0.28393174496081613, 0.2889258478844129, -0.30349049613290296, -0.19555891881002857, 0.2582370307455583, 0.5799775399503724, 0.5101590387727103, -0.6365304356449898, -0.5671532793783367, 0.4563459989626627, 0.2132315381328465, -0.2681964362215882, -0.052381926953716317, -0.5763849722988379, -0.18293282926513113, -0.1657442641746634, 0.301051150090967, -0.4212927863762915, 0.4075049084603982, -0.10636021972462568, 0.4710093331770049, -0.2511180870569755, -0.5779735208136716, -0.21298315319675368, -0.10252717993679189, 0.28825118664668214},
    {0.06406721844303549, -0.12873651366030958, -0.38849367402718604, 0.174767284406862, -0.3444578324699171, 0.1169465217192923, 0.3646651467983861, -0.05305955895835449, -0.0558204009813493, -0.1701089969251053, -0.5351216412123263, -0.4278198138154434, 0.07678961418441126, 0.16231526422376297, -0.2515843706797151, -0.007497210337859287, 0.2876783441782523, 0.5385288239409022, -0.5402212361363099, 0.29738553066923556, 0.3792921866305058, 0.2623305757923999, 0.6278893445333842, -0.15820359657739186, 0.07631544669572854, -0.3357342840830512, -0.020990314811252058, 0.37265305615728866, -0.30090388229343035, 0.10688311322812381, -0.5342388758404772, -0.4968225500214575, -0.08131792428986763, -0.10822847596644511, -0.5091753353466424, 0.22008689459821526, -0.4373926340177768, 0.2002587649037944, 0.24489425998861708, -0.1372992364180769, -0.07917525168471594, 0.11616060469390369, 0.14960398002443062, 0.06534852369008376, 0.2764333923962504, -0.05130673710735232, -0.36415516020555466, 0.5583280519857039, 0.1570883202559493, -0.3046238539666456, -0.08447120782887478, -0.07736247275619887, -0.3519099478223457, -0.4249152174997713, 0.49609927541241017, -0.16670120384482257, -0.12966657455010464, 0.13091673973398874, 0.37131428454933224, 0.44600649617768257, 0.0898480982139913, -0.5316569944653148, 0.06955957673778744, -0.3785315354604827},
    {0.0843050898719294, -0.27758687984794195, 0.12594694232281592, -0.39000861019621014, -0.2912742836475533, 0.036932585224971025, 0.5173699113641287, -0.6301971045928518, 0.4252399000731584, 0.20288498479098377, -0.517843627775456, -0.3535636947836597, -0.028039061825999835, 0.16359303738854714, -0.6647847673659101, -0.5446521033620603, 0.25761839445114887, 0.40488133062643566, -0.25592300865718787, 0.11617572414992054, -0.1303404398355065, -0.15579089853045422, 0.008453474496036152, -0.20758331429378418, 0.23204270184701276, -0.15114934566237004, 0.03629574091222482, 0.014795213803604998, -0.29291239332380525, -0.10715361637056973, 0.04943398933310033, 0.08792972505925202, 0.2620258359049369, 0.24358038542965302, -0.14642288927561073, 0.7217676490705799, -0.1948621100178643, 0.4454915362553613, 0.5262484086425414, -0.2787266861214386, -0.3961075648031952, -0.6863824801515446, 0.45630926600166316, 0.42509498911737637, -0.24284871278260087, -0.47501478426275245, -0.419742919900474, 0.7491107288487507, -0.27530973424345784, -0.7609226199633877, -0.3009092943033566, -0.29226343640985275, -0.27160330939451993, -0.08071526186056625, 0.31544221470961825, 0.0716483082092355, 0.24298193533695603, 0.166643928863409, 0.16235893144974842, 0.32851583292905445, -0.5242663406356297, -0.44059210483436884, -0.4054596462857958, -0.46877504129926867},
    {-0.2699991396985023, -0.19021632571845834, -0.30313385649333463, -0.26704326616176316, 0.15869722360410798, 0.004222210554808174, 0.06739569760042699, -0.48737492903175017, -0.22255048847668119, 0.2184573492474457, -0.017814241750703515, -0.38904337470965245, -0.468788029070946, -0.001969086448167462, -0.19075901771077153, -0.5821393590059508, 0.013516706984325434, 0.046425396014064306, 0.15546437288040055, -0.22068276479886048, -0.6019311728144061, 0.23802572401160083, -0.05482657233300805, -0.25506615165530244, -0.19674733465730285, -0.35006629877455664, 0.0375018704595659, 0.003965648390175067, 0.31822425091446976, -0.09955619574134597, -0.1760518416343812, -0.13579437461853697, -0.19929433702258026, -0.4348024597010068, -0.15589558770663506, 0.2712692632137017, 0.05929091893904996, -0.4900833035775523, -0.06218143598720578, -0.2022516240485149, 0.2923743764847093, 0.04886719555788502, -0.32449520415987315, 0.21174687701068595, 0.043172634815612, 0.08960213899874744, 0.048353721828171194, 0.4290642052582511, 0.43181101630464963, -0.01359601879756658, -0.3615676300133803, -0.4307240089714213, -0.05376328349539382, -0.2677049440021711, 0.392303951610868, 0.09291450048254847, 0.15220486140437028, 0.4055695965681978, 0.3053143955287954, 0.13016232878103784, 0.3172089229374196, -0.14617871582974462, -0.07385013469762569, -0.07407710421636632},
    {-0.22152326212214768, -0.07624102822306779, -0.0636376381123875, -0.07634277293271882, -0.41669279745191706, 0.09664204704410698, -0.24199896312837998, -0.12979244933159015, 0.20281190907465899, -0.39226050806458873, -0.24305358149633066, -0.35355726271345306, 0.13178004962671136, 0.17536672623137523, 0.012037967311966947, -0.3731672723205585, -0.30490801408406365, -0.44712883931682085, -0.2728227835871327, -0.21545812861493707, 0.2547318913813607, 0.35929118470705873, -0.5192290208581535, -0.1520830433118437, -0.12506371579989845, -0.339096868479264, -0.3755896069235918, 0.15832480823238204, 0.13357421926132892, -0.35948043735899626, 0.0016254197689335686, 0.09916605587543638, -0.18286556351048408, 0.13266471136380048, 0.4879519083699442, 0.07026523127167993, -0.46673285350637383, 0.35206900182702366, -0.0744851687448075, -0.06231937363810654, 0.16743946447753236, -0.016390978161403648, 0.2772232468699035, 0.14466261753583193, -0.27814716414119756, 0.09282836291282463, 0.2656809091013144, 0.16960687963136897, 0.4448303039531012, -0.27995284554594285, -0.3556038377399226, -0.3465464719949155, -0.4785847721097449, -0.19204922373808167, 0.42642687894436987, -0.4851212751560067, -0.4317750267932314, -0.27752976816127395, 0.42338695368712276, 0.05493926034974225, -0.40411991054533314, 0.16125540860848095, 0.184148717248047, -0.3964781268808403},
    {-0.034044164720468756, 0.13678978481496626, -0.23937951662701484, 0.13752458663626949, -0.15637860963714678, 0.22032608314719718, -0.1810215459798846, 0.2750462571099036, 0.35272289672650714, 0.055919296290722315, -0.07651377675230925, -0.13386161448643943, -0.10165916480487035, 0.0933886877124228, 0.2638610465295314, -0.2947129623439091, 0.3097353054943192, 0.011790408651129985, 0.5421001071223969, 0.2664898985793136, 0.3395922202866251, 0.4704241425403726, 0.08009461905489998, -0.05593123681705753, 0.08813178106826423, -0.16321405082815407, -0.17761665823985157, -0.3295012441443485, 0.16749340451648337, 0.04563733376571861, 0.1777972882337104, 0.49689882473587943, -0.07510495113569299, -0.49790056707978964, 0.35296263170225145, 0.23799267642457322, -0.10864673100061037, -0.21873146179181793, 0.13956463226560462, -0.3925148414260536, 0.24169708327441777, 0.17486583105976544, -0.28361189919945695, -0.16793003295755626, -0.2879555090469779, -0.09750117356305783, -0.25891141623111813, 0.2947880735689374, 0.28155172356393954, -0.45642865189268866, 0.17387673680905458, -0.23420930310767513, 0.01908692520085868, 0.06240580811451745, 0.20705574104656824, 0.24368815543045313, 0.4435046248398649, 0.2666456266269048, 0.22735349382669934, -0.0742048045673759, -0.0642142809917026, 0.15820468860741232, 0.006879780374691546, -0.08446328384939067},
    {0.25323334201980463, 0.2345473038307636, -0.15566383019228447, 0.3721649896859952, 0.05230462842019423, 0.49382520331562885, 0.15853274914598497, 0.15607538404468096, 0.34004928461229544, 0.15089061539812307, -0.13998207477998045, -0.501250496442306, 0.42685471970033595, 0.31014249972525354, -0.5908984089545757, -0.450084560613199, 0.44329135459306385, 0.12072299860217793, 0.0816132028638504, 0.29892521007438494, 0.4369534664635347, 0.3002741656440698, 0.4428169055323833, 0.30912159728821914, 0.12200737793601645, -0.05338372224824983, 0.23425218095350955, -0.15086620254707725, -0.3665520868344294, 0.2619734612473696, -0.4497832344734719, -0.4701635854460531, -0.21078677874757373, -0.09647214795086492, -0.3068879929742949, 0.6190788340963702, -0.000874378652460542, 0.05014461257040679, 0.2680375845961582, -0.2784552078838476, 0.4268790125828516, -0.3978987244756738, -0.08572789242511178, -0.1602627807001775, -0.07626958165639894, -0.29715487559755566, -0.13730709563593593, 0.553212092604498, -0.361256003193463, -0.4813644347481416, 0.2708708544929494, -0.4756301725374944, 0.13837680204443398, -0.05350458650310984, 0.4783806048437458, -0.21057408838620603, -0.3355928899409271, -0.5580313711661744, 0.22061174330045358, 0.07772478097139011, 0.19032977695232162, -0.5359259494649754, 0.08716272016524018, 0.07918292246849849},
    {-0.36668268583913344, 0.032649769099927305, 0.11831989316458796, -0.47320129230714897, -0.13607229988658567, -0.21170476069348937, -0.1605746547503026, -0.22450234858819215, 0.11867363857150086, -0.2500726020460946, 0.12536523270317887, -0.47490193975349393, -0.4776141974951614, 0.11273149396511942, -0.2211035397348191, -0.4220620449672693, -0.2658758889994434, -0.10328868598025744, -0.7045721872731798, -0.021937937948358296, -0.4680218675782568, -0.14989080175645525, 0.48148680401969635, -0.47387378712501843, 0.20412392984650443, -0.3837085178810686, -0.1777684817215377, -0.44626736739625533, 0.29860448004579654, -0.3105684703361786, -0.3966018387981505, -0.014023433917835976, 0.05903285648764664, -0.45863932895114073, 0.1157677671094262, -0.09962681756599046, 0.02494218309553754, 0.17298138532972024, 0.0772291570313316, -0.12970709105030045, -0.27807746326358745, -0.012926933015132158, -0.08861939439670193, 0.4541496366469604, 0.13332842449694268, 0.32646519423207027, -0.21054580671376183, 0.23269076100278455, 0.02266258821297413, -0.3019315326197673, 0.3254125787524291, -0.48320768983642426, -0.306345430619667, -0.1748660718733248, 0.5171859971276958, 0.4167610185224897, 0.1650547067557485, -0.10573487682683633, -0.144872067132258, 0.028224187740280966, -0.4214178530183039, -0.13765148950514022, 0.2820010134212174, -0.36765502847769516},
    {0.06662863445486694, 0.49888652380803034, -0.24782514882366816, 0.08077005840267361, -0.37022389978366077, 0.049701766647453176, -0.095136029697887, -0.29130715129890933, 0.08450144968887244, -0.05906770843660257, -0.10115271240397856, -0.5382393086202847, 0.07471802188342948, 0.006912848898243115, 0.05277766079965197, -0.2769216447743286, 0.27144296089049946, -0.016637682010857538, -0.31546870007317623, 0.20336599432893412, 0.19897322154273797, 0.004803399198050471, 0.4675794478406736, 0.04254540339132605, -0.30875219691407546, -0.19054097683094598, 0.2782561952442925, -0.5200822883283521, 0.3682376966869057, 0.41464920006126743, -0.40995681171758963, 0.4054268542367229, -0.2096726296737474, -0.3072648503140268, -0.06826521763697507, 0.31012321795515463, -0.07447334071803412, 0.09967412535912167, -0.009001639482650498, -0.09127681786671932, -0.2589335289475753, -0.3767385879253895, 0.4708226951624657, 0.027136133769386343, -0.04255328803687244, 0.2566251605143514, -0.024452462882816658, 0.3519258241651045, 0.1279046502423754, -0.41439136078937655, -0.3231162594301223, -0.35796905256278433, -0.310583856409361, 0.15474034394453498, 0.06908121997730476, 0.03576838075297627, -0.29098011144736347, 0.39942065984312924, -0.18204027087848385, 0.27952834489598455, -0.08679731574731496, -0.3513191554019339, 0.3285550080458386, -0.2865432550886154},
    {-0.07562879306377425, 0.34037490174203666, 0.1978067022226083, 0.09268272361043639, 0.07684980992703393, 0.46345607137842754, 0.2016685272799739, 0.03731672153588096, 0.15884059820480834, -0.31242723233080094, -0.06408788076193744, -0.6814117268998064, 0.3048709232899981, 0.22008730177390765, -0.6105254462718308, -0.11574334116899557, -0.22635780197807015, -0.17636100069281724, -0.21924381033202842, 0.2933798522614108, -0.0534980568564922, 0.23793952630502754, 0.34302800161745656, 0.29314943752061373, -0.04775477159202553, -0.12211655612730332, -0.040975966438682766, 0.1703098321322891, -0.5656359054500051, 0.10987707817437621, -0.5756192581121459, 0.277959690562627, -0.29504806167910397, -0.32733313429895994, 0.584995647414198, 0.17915901637239015, -0.28139388097844104, -0.25977529949817074, -0.20023068634129673, 0.48727622054723485, 0.343427499213389, -0.5983937832562782, 0.16193694863262303, 0.2466102438137821, -0.5121199981407775, -0.48667337082937256, -0.6123115884332928, 0.6645971621160088, -0.17575383263156694, 0.03583796167067432, -0.1055915446937773, 0.15440260791404045, -0.21797203826425857, -0.5943271544196209, -0.08060502561601848, 0.2200058920340445, -0.34154147512402744, -0.28657533673663793, 0.1476350615297803, 0.3850940859464703, -0.16040225946613934, -0.06444335137960923, 0.07783115584880079, -0.3533965248992851},
    {-0.2702827876618338, -0.3378698464432364, 0.29408564282414984, -0.487950908255088, -0.09275347090253129, -0.041590788388148475, -0.2088176164315503, -0.11058505479691284, -0.09273585317322586, -0.1731740954575092, -0.38069642944447774, 0.05030759027433724, -0.0713480112069182, 0.009876154340092412, -0.31231321324326256, -0.1441515779030351, -0.2444491364423529, -0.04094609107138074, -0.5996716552926652, 0.14377394771390473, -0.2983300119363808, -0.11513852756751324, 0.3149150783144534, -0.496829053799867, 0.2614053709391254, 0.07003672408264978, 0.3122861411604259, 0.3383282714504435, 0.5888464338731857, 0.004226959071539063, -0.6219627679994262, -0.08204542295749727, -0.2828463966426277, -0.393386181810489, 0.21572249293579115, -0.21138426337065527, -0.1403687066667462, -0.09968699347690003, -0.07257451437590545, -0.24240401042564821, -0.3741209183339056, -0.5995962950603331, -0.04618028505581524, -0.3633604493792629, -0.44578601332994333, -0.013789910146137521, -0.12316170327842396, 0.32987323950727965, -0.42341522906411844, -0.0899039461115754, -0.260372875308257, 0.1782022691256346, 0.18048360100753755, -0.027889537724765653, 0.13597321876524512, -0.24395067853356647, 0.4142122896210254, 0.40064114649296667, 0.33525718861703907, 0.39965996822763145, -0.3980778876984043, -0.07536604853005585, -0.1860886724175777, 0.1967913446363054},
    {0.14735281094359637, -0.2722072690483525, 0.5070934401382989, -0.2914458061096483, -0.36606118893595463, -0.2366497458676466, -0.16828310105334324, -0.3824316612276277, 0.0699121624834965, 0.06617594100696074, -0.31695971682076196, 0.14953202730689488, -0.3074743788335982, -0.49939340568849855, -0.0527433117302293, -0.5297876387431495, -0.12493087519679798, 0.030253631185679582, -0.4792412920635019, 0.21227733690654518, -0.4770457984320592, 0.09301427251832901, -0.5237186693873631, -0.4689826768497578, 0.5850226798698408, -0.2956753376118648, -0.10468217305754697, 0.048114834060132367, 0.6736212588953542, -0.4508164981493057, -0.23771792251998974, 0.48355493603894517, 0.2140927255327324, -0.008043995410927663, 0.5158809100664983, 0.18385373822492135, -0.5873734437866608, -0.07927138885008207, 0.23445753175300754, -0.2830769392189634, -0.11771685375113491, -0.5242336179010861, -0.1398019425418536, -0.12402898986253699, 0.1556264212480398, -0.44611717870219963, -0.4458392504056879, 0.28403779110551897, -0.05001050135551682, -0.21502470774274798, -0.42403458225077206, -0.32342605981455386, -0.12850839783149293, -0.29419402786159027, 0.3133538117556907, 0.10345483510030004, 0.3470051448611688, 0.32274413191479706, 0.07950005267019375, 0.16739935574335585, 0.05618731005991402, 0.0683230493205411, -0.025701096965514498, -0.233085323540573},
    {0.020229724282213937, 0.014776227712145975, 0.23630477075194134, -0.1474840992251685, -0.055040316399368946, 0.035229883206044504, -0.1429281912825481, -0.21661101497960902, -0.25801840140998344, -0.06893357917909171, -0.2967718257277137, 0.40062580009084464, -0.21515931310482148, 0.0058405429705400275, -0.49024412408689316, -0.23926314205441315, 0.2950920847024377, 0.1045160208919299, -0.16568829564007975, -0.17838187652543744, -0.20191071830254997, 0.3652295626166089, 0.11404769240316864, 0.3809450759099501, -0.3476430093502359, -0.008785751063206034, 0.2562272957916504, -0.0020651212578714113, -0.11695669938022396, 0.1749981198978491, -0.18674275461338824, 0.4031762784578079, -0.5055608035357366, 0.07713048724154434, 0.14233867070477646, 0.04560886351409291, -0.2047024073314879, 0.15277517705269508, -0.05473660491695329, -0.38642386371769966, 0.451974046360815, 0.001502818400533485, 0.23675656431750158, -0.3327177334296399, -0.22548160479225912, 0.23803727126435564, -0.1741389999655346, 0.1643605119199395, -0.1579914803440342, -0.20444850431566589, -0.28931760193449224, -0.3211829268577747, -0.12368302460432135, 0.024963383855548135, 0.29030825652157044, 0.03337750536379829, 0.2171733298654585, -0.1300790903597631, 0.3506027094687594, 0.36075171047959637, 0.3866187305874229, -0.03581841942441156, 0.17930368314011538, -0.3762843031380157},
    {0.08035944881314122, -0.29515371131744705, -0.21779179445247746, -0.061257675538689486, 0.22926635866696551, -0.332688070420624, -0.19226108323876662, -0.5373911760763823, 0.03823027826942001, -0.00014668584977753387, -0.20104948907241643, 0.24001880211399132, -0.24386707140042005, -0.6387830528663098, -0.0897271269465489, 0.32146996424983104, 0.3763862709284048, -0.15770002478504183, -0.0022387657163828257, 0.0672210726955226, 0.004802367587377524, -0.7245800816655473, -0.12986199286748668, -0.10100087549989845, 0.05745473427157369, -0.30849600622167744, 0.1356798483258563, -0.03541792173445128, 0.18352590986642242, 0.21964546829995138, 0.09809407783572699, -0.004008042553984889, 0.0881254617758962, -0.006259110191715162, -0.2636127993905753, -0.2948361968976366, -0.26909145080806307, -0.36699799038011616, -0.19287599364841077, -0.28006652413537747, 0.03606728079070328, -0.0009284971647958479, 0.18018501029772618, -0.35227889515483746, -0.008243461265608635, 0.29188533439996756, -0.10774597639797338, 0.1813809510908378, 0.18152201570077936, 0.2146789059151894, -0.2983538268521759, 0.23041106786153268, -0.5674973084729973, -0.16314688071080197, 0.4111976380003649, -0.2855454846549771, -0.2704000453926452, 0.3334631772764262, -0.12811246511287758, 0.415934881715429, 0.12700628106541995, -0.3297317897849744, 0.20633580960046638, 0.07940861153404485},
    {0.3647762005964398, -0.22157125087875593, 0.5375240406130658, 0.12096670742742353, 0.030952065276058857, 0.2861797304809394, -0.3256388756429038, -0.05110319607470492, 0.45584210913756507, -0.3783653560214756, -0.23625297650210533, 0.6268365661903925, -0.10980167024287163, -0.6135099020953145, -0.06904439225896233, 0.0304684730657146, 0.14599494010660996, -0.39023727891203663, -0.0007956963650265517, -0.36418998592283025, -0.2813131920571957, -0.0029563636255005013, -0.2535394018423207, -0.23718704817626593, 0.3420114312044034, 0.14244099236208163, 0.11920831819869541, 0.3628719369825261, 0.30622075246460406, 0.4148331653888798, -0.3497460464832847, -0.0692651771721834, 0.06082442437471906, 0.16552554345683157, 0.5525399053397816, -0.17316601698375134, 0.37160610069582756, -0.6699370013285347, -0.5655313088787561, -0.2419074091437961, -0.01860300182210229, -0.24639301532341665, -0.07218555905308806, 0.057704317796738736, -0.08238468291446666, -0.008510913549101632, 0.4346136304790885, 0.2549556351305574, -0.43015301304477593, 0.1626687433495138, -0.32384023337678075, -0.30456419888994946, -0.10968242390275196, -0.3371707526411141, 0.3479812592286326, 0.03624820057586266, -0.043050816854243376, 0.14852686207962185, -0.2099793397621871, 0.07687347522167685, -0.4726722466408011, 0.44749010532936045, 0.11293749177133382, 0.10475970726165691},
    {0.021001444662849183, 0.4918969302100792, 0.3717110216456225, 0.28729797753882796, -0.2678353851887686, 0.26190647145701235, 0.12904266888701701, -0.3221709014239147, 0.516070658880934, 0.03860844233249681, -0.03516698388905688, -0.01727534231516153, -0.12119225318371488, 0.09534992883693807, -0.40255012329806084, -0.3827500245592253, -0.019747053512734, -0.280692476022731, 0.4561772676757392, 0.037388720655035186, 0.5012415077564386, 0.36703314723335395, -0.39911307246095334, 0.04897795925836881, -0.34111217973974123, -0.42854247294234726, 0.1462239174293002, -0.3278374792515405, 0.10859633395770568, 0.08661130546267089, 0.09010464021876026, 0.6041180360271162, -0.5600125826889282, 0.2068286981997397, 0.17556213024190534, 0.4183326565509582, 0.10929950180022624, -0.4362089745138868, -0.13342307428005706, 0.16968479592306682, -0.30144312401784323, 0.18042257429704636, 0.21813261148122884, -0.20769052411605451, 0.25477537935487665, 0.17803155016883243, 0.30090954276428317, 0.12917857531175553, 0.46182044899513985, 0.10508537642414557, 0.14472168009203867, -0.2727775577354882, -0.4620894147623099, -0.42841368434515625, -0.10934241577198181, 0.24833575215383183, -0.40445465609368914, -0.15389013382360353, 0.057475521596922124, 0.1456614806427601, 0.17248740971587043, 0.2105031852794773, 0.29602325979394634, -0.03542821128037212},
    {0.2798361186931064, -0.10803730843941804, -0.48182861620832307, -0.30414575862381876, -0.10222912739429554, 0.10255415557112177, 0.10367921172222856, -0.0046174378461396924, -0.264990079819307, 0.3656088101083834, 0.21908716724068786, 0.382844773668844, -0.15834208312943127, 0.08398212780401881, -0.28320576110366247, -0.01513287831264696, -0.09493965357633591, -0.2245591423980086, -0.4744865416486654, -0.25744800249768957, -0.07534699562592354, 0.3829395239341112, -0.23401983950170227, 0.13359108796609037, -0.13465744934285037, -0.4546169592537468, -0.11002615639709641, -0.24485557374990893, 0.6080262995711172, 0.1523005921228579, -0.16178369887288016, 0.20039015162931992, -0.3403154330402728, -0.4536702878684884, -0.266853788099759, 0.07486268499732551, 0.1420099964842438, 0.19110455689805214, -0.18971109731220262, -0.4177859407599856, -0.17039726879515746, 0.12297057346565078, 0.048884616068866085, 0.04396992671175948, 0.5271965296305045, -0.021774578105134605, 0.34977145423559985, 0.07809215754958675, 0.19044928160795951, 0.07171395816273736, -0.22026738360905665, -0.459241868082353, -0.4009480139279776, -0.1897548627057239, -0.27585550925464675, 0.018681537783383377, 0.2021748327485348, 0.17623222891516438, 0.18717492702310704, -0.008413600867351064, 0.2536340417530381, -0.11726189562403032, 0.3328022955444728, -0.34358991347547946},
    {0.048642931301493525, 0.09016809396625178, -0.1455577172626403, 0.04693116471994782, -0.5850415644987275, 0.4496167552561288, 0.10570999593075758, 0.13621197744196964, 0.3051336201188766, -0.2572663104067222, -0.4496191249499755, 0.2293733247146796, 0.14105760287475502, -0.24119838459484091, 0.1335883278248491, 0.2000106659082946, 0.21281637120066138, -0.2620025474021793, 0.279722459432835, 0.22649792360441498, 0.25379110091159884, -0.04167446772664634, 0.28093109067351296, 0.30585303521370644, -0.06554325107581138, -0.38435795439211196, -0.0812545513165686, 0.34052267952209314, 0.03567215284839719, 0.23590388163950804, 0.13797290125623193, -0.10571418727169417, -0.613925805327367, 0.20616888157333835, -0.21086716573706807, 0.3078270736835983, -0.6193276565802794, -0.03624754755261022, 0.0006081991356235327, 0.04393239348257319, -0.4746975458310157, -0.016801267608791012, -0.524060506633629, 0.08019571074104286, -0.009372170218827506, 0.21608262623539415, -0.5101341948117708, 0.060729424728793446, -0.1393211675012747, 0.21833455635147336, -0.13204866655265093, 0.1764088134816412, -0.04575503004511576, -0.21997337557895294, 0.22608975951498908, -0.37096209159450355, -0.060368255282219625, 0.21321438580558383, 0.34421993224372177, 0.04560067271871409, -0.46250452682183824, -0.061855024157243595, 0.08588134648536866, -0.24094200885411818},
    {0.3198931633105662, 0.47884896989692355, 0.30535966936663195, -0.2699374477329133, -0.3202934766082138, -0.09606207486540837, 0.2955537417096227, 0.3329855541555773, 0.046882187952240334, 0.22279846290656866, -0.02305884709453125, -0.5129268310120925, 0.179540310978351, -0.1047127036824388, -0.2068402640188736, -0.14711513156183317, -0.22487628192686035, 0.3096528368870633, 0.37859497318327606, 0.10658871604894085, 0.3735996911826141, 0.019439128256699863, -0.366490845040405, 0.05093239275395422, -0.22384380575312865, 0.0784720694923236, 0.1473397978253324, 0.30534622557023816, 0.06267520186580823, -0.32516138143991247, -0.11376428246575808, -0.39447137945658944, -0.5830364640624878, -0.14696170497038114, 0.37194626322506025, 0.23848477502810186, -0.3078036678506266, -0.026896095197037548, 0.04915980434608542, -0.17637732526370975, -0.05341222457961028, 0.10665242952865724, -0.5242837327116776, 0.33216577536823383, 0.3681551328823409, -0.19069378689226263, -0.1446541133054822, -0.005653615053515725, -0.07351183326246435, -0.2534880430120808, 0.21230062939380825, 0.19032942828724875, 0.17945954741266346, -0.338899293572374, -0.2143870139528341, -0.2906877279916082, -0.4566321705583827, 0.07590931929404492, -0.21237095561684755, -0.2602702909575397, -0.03137573343849673, 0.1253331617360522, 0.2431403447865566, 0.022012708702260242},
    {-0.07807956352589887, -0.29640864280314383, -0.19180073889502147, -0.2790592267898574, -0.33107080088824514, 0.4125390911049723, -0.1341282097443156, 0.1938773450398607, 0.13156411992010547, -0.416538357236175, -0.29349189972104794, -0.38158121290076025, 0.3702236078022821, 0.06107192920220645, -0.4945947950187267, 0.07916181539447072, 0.19577543134434638, 0.12264687659286225, -0.13741178641112833, 0.05008291436572228, 0.1685992129467118, -0.03763690790985243, -0.40061944206361955, 0.007804443770680192, 0.4465389052059326, -0.20769178790579576, 0.28914546994469964, -0.36677236722169065, 0.39688754612547306, -0.3742575186841757, -0.16476791544190247, -0.12171496963984409, -0.5894721962267696, -0.3868104900634206, -0.25142738900651684, -0.12076087760043325, -0.5303883666944089, -0.30228752522620983, -0.09135646552307757, 0.41602481361064675, 0.0037193174082023822, -0.15998760801713785, -0.0860508381601392, 0.05698630799171187, 0.36198881720437837, 0.12632806953007286, -0.12721727289291043, 0.289158601214951, -0.2287558229702563, 0.18184141302451456, -0.026831625169343072, -0.4367944264401089, -0.3446238661433969, -0.3086950279555712, -0.3277525476095425, -0.11204046770122213, -0.11595341395254483, -0.07608462251233791, 0.44068847606534334, 0.4515325502649513, 0.10267472174711703, -0.0949493929356358, 0.34691980655961613, 0.13342022605017834},
    {-0.29670043698413767, 0.2271328198004616, 0.6483599978492963, -0.21303215802233733, -0.026720796473973237, 0.29018591919841247, 0.411021979137611, -0.08284120753741618, -0.2894997411667156, -0.2263040697520028, 0.25558578536881754, -0.34223630437178154, 0.17362421546916063, -0.42150743545741726, -0.5339264644924536, -0.3375848279519991, -0.06966467752374118, -0.0732243147040094, -0.018504394113663357, 0.09040516462177031, -0.4019680524890021, -0.21473339278117165, 0.3244760544743589, 0.20513908161150737, 0.0018446255646347566, 0.1860461493997786, 0.5179872682059269, 0.30982237940084795, -0.3162283768806214, -0.37249895482704853, -0.4622065698573116, 0.28831146847270633, -0.4790232394600718, -0.08104067941719328, 0.19172490946646814, 0.44456216192854137, -0.2864987986794893, 0.26567571335651863, 0.4313187298775039, -0.067131443270909, 0.1630979756292208, -0.004848009922721167, -0.29513965747360044, 0.3332071149002464, 0.18277547830291513, -0.2445236587415424, -0.14514501623411707, 0.4049240187147168, -0.302777830966016, -0.3674641793935469, -0.013681178985679969, -0.40685434217504146, 0.14925977344174604, -0.4977349821326352, 0.19340881900534965, -0.32509723190409096, 0.2683527081396002, 0.08103359211734368, 0.18649318526499695, 0.21132042668775122, -0.2296231511149948, -0.2816184438985276, 0.20985657703735153, 0.022763545952428663},
    {-0.09742835325134125, 0.4461481272336631, 0.5169995661503943, -0.364578808395733, -0.40918893974531195, 0.4794588239105717, 0.1909296917989986, -0.5908436559946861, 0.35109603547060964, 0.015934572907895916, -0.46046834974059153, 0.2799716960236678, -0.2817168317228916, -0.5972344541703632, 0.32963807019453534, 0.24777737072261824, -0.37662593476037926, 0.08023996954062054, 0.20043158491017957, 0.39791810162451346, -0.16975506929706832, -0.014744998092261208, 0.5083094237541149, -0.3258066272272534, 0.598271072843458, -0.5548767920427281, -0.035872934371475394, -0.16979906451534818, 0.163106923500451, 0.1681860903026201, -0.24054688565091908, 0.2352002727806385, 0.15975712503462539, -0.00010370928849921381, 0.0853038540998989, -0.2548862517563647, 0.12242696436430033, 0.2869295463266038, 0.2549390819574688, 0.3248718690914845, 0.49641081173537865, 0.05589957981118884, -0.5179723157130987, 0.014188019390087398, -0.18489861786443057, -0.012882258721731299, -0.5871288778446299, 0.32697395426466275, -0.020606671688594803, -0.5315322681217644, -0.15638028466542594, -0.3806629059770038, 0.26907563830138026, -0.3798656667153357, 0.3233164500939915, 0.20540231485984026, -0.3725138893322591, 0.06576735327668966, 0.027370818338541898, -0.012197986718124502, -0.022793799050433824, -0.18492567152894998, 0.012851505856980049, -0.30540436798835296},
    {0.22958093294801032, 0.41204648972348146, 0.24421232573651142, -0.29010583851533767, 0.09565637397044838, -0.4495465469851085, 0.2077054178492788, -0.1457383680259134, -0.017084040992677015, 0.3853936633654962, 0.20252819282426915, -0.131686595585091, -0.058844495145428735, 0.41947937094499377, 0.330468889916643, 0.3874366828320415, 0.18907040639114422, -0.17266513409244588, 0.14177064443911483, 0.022258829726137148, 0.39486774473501385, 0.4190517936320972, 0.0008114342503617507, -0.19763618533627103, 0.045173966144434065, -0.1751904880929213, 0.32475831198781674, -0.016861132378929777, -0.1594806880974255, 0.5067073217013816, -0.36014866142855756, 0.3066565370326957, -0.41274551768349266, 0.08506800996923751, 0.3796423209957879, 0.4166466822672794, 0.12795398629041943, 0.17502668212589925, -0.16138350142424246, -0.04761889393923342, 0.006541951611937542, 0.19103342148041216, 0.043795246023544274, 0.008106329565186619, 0.02344551432525791, 0.27651343779309595, 0.12984563685443362, 0.5010791766062294, -0.19024721138038891, -0.07438870889996821, -0.11323904455735168, 0.03480866904239953, -0.2719647990261017, -0.1324880627374072, -0.0866694019554374, -0.17071598165390758, 0.45346995234814536, -0.18837702451031085, 0.33072533933654197, 0.460598059850017, -0.2624797542326511, -0.6142485838760944, -0.17363370963417835, -0.06918918088688931},
    {-0.0481795277629456, -0.15635783636735387, 0.3129843865441009, -0.04343821744949406, -0.06843670450555213, 0.5154454103470524, 0.2816255969789821, -0.26838459536140025, 0.4607112714908646, 0.28668474923104686, 0.24095213624351783, 0.06341216765907909, 0.2626571433217032, -0.26820950434416796, -0.47824008278073815, -0.3821642261094993, 0.42064093685523485, -0.011123871410570196, 0.3203962148933051, 0.31594443889178053, -0.14738823207137322, -0.20804352555787775, -0.08448179419545694, 0.13007180580776478, 0.27075995769253974, -0.03166674019427622, 0.3050254955528284, 0.26422529676890255, 0.15576892859154348, -0.03277062238192399, -0.00942433198368553, 0.06380970916624068, -0.5023417631396097, 0.2622795339734365, -0.16052241896058253, 0.29824161832740037, -0.6851408999474672, 0.13955811714210056, 0.1516640375622231, 0.6093098040967136, 0.07858888990296288, -0.46475784928466174, 0.4605105528687176, -0.11924071395488273, -0.09551511783572729, -0.24142409088444347, -0.07642450776840519, -0.3185839768213257, -0.06644959327007674, -0.49903213635243326, -0.24669040627143152, -0.0918757721236645, -0.3964968652521778, 0.04591736726484273, 0.08820989951614622, -0.00500196595281163, -0.5129233631913789, 0.497325759992832, -0.20887119735085985, 0.5079594996873539, -0.28487410123202606, -0.5381452019515006, 0.28256456409697456, 0.08243751029579409}
};

static const float b1[64] = {0.6642065635055066, 0.8821406765167373, 0.9040233396970238, 0.8408042468626535, 0.9022423193670973, 0.8569100221333724, 0.9255178191972825, 0.9040033356753512, 0.870307439731174, 0.7357309030405947, 0.9213741425479285, 0.900373583135884, 0.720108611049305, 0.9106226559485153, 0.8508038368018319, 0.8549308618688768, 0.8136999358886369, 0.9332082164047009, 0.9179585128016103, 0.911788626746863, 0.8868214598549379, 0.9319595719637496, 0.8960651674784949, 0.9145483771225409, 0.8649184531465132, 0.7822164662451855, 0.8421117829895123, 0.8141202611706816, 0.9180013853476775, 0.9231336346426823, 0.870195825368144, 0.8792242376199311, 0.8246710002612677, 0.8107382127642542, 0.9483439643912978, 0.9331659358325978, 0.9110610462902703, 0.8635484357423263, 0.8909617289532761, 0.9090815376585192, 0.9152784934379925, 0.8654659140010635, 0.910532560440761, 0.8541301266279266, 0.8526179050665205, 0.9201052378368527, 0.9159756776167575, 0.8991969037340012, 0.9203318494080576, 0.8328147676639055, 0.8957705327653754, 0.9034544880682581, 0.8364377079650184, 0.8610545862497792, 0.910743580343795, 0.9045021814904435, 0.8877902827233126, 0.8182555451827568, 0.8981745511085385, 0.9273591168928387, 0.9200680088425394, 0.8239718335667372, 0.8827727914277647, 0.7322787771211355};

static const float w2[64][32] = {
    {0.6907936828969995, 0.09936488493238298, 0.9353121364642281, 0.5189791408080442, 0.7099672962249479, 0.661323595371304, 0.06176535150607021, 0.41751749775656805, 0.5679986561801715, 0.6898654308464856, 0.8802731812185635, 0.7002523179239039, 0.6475012081001312, 0.6629109991594725, 0.8269473231710004, 0.6856684251092127, 0.6298779437801709, 0.7806895294361529, 0.7805428201584512, 0.06955807143728865, 0.8232779860219869, 0.7599090791915291, 0.6955244533382899, 0.18003141524717556, 0.6931576955890537, 0.7539059290894117, 0.688773645715707, 0.7674580788506129, 0.7003929973544213, 0.7682518645123809, 0.6010249736344828, 0.787931574899262},
    {0.9192087193609635, 0.14967422442515405, 0.8371029874145757, 0.6221755652513302, 0.8281155256279745, 0.9377682879795943, -0.0768884393593677, 0.48627945763638764, 0.5088397150688101, 0.9819324226448014, 0.7358626078809577, 0.6803383258810812, 0.3996905956140801, 0.9716563726722232, 0.7161005063442031, 0.876088546236634, 0.7308043948269173, 0.7239288770345687, 0.8947909081909283, -0.02878133892639508, 0.5126565333200244, 1.0858116022344189, 0.8277997221594009, 0.04927506957718556, 0.5565710748226924, 0.7111249488480095, 0.9405359263179982, 0.5327987263180024, 0.8897370656226714, 0.8055732120804344, 1.061678752361808, 0.5345942461077121},
    {1.0025529017815367, 0.061971014183415205, 0.7651675574551807, 0.48324219424305664, 0.6034393365807368, 1.0428818865319047, 0.1890370689145189, 0.4601120517420652, 0.9604420272835166, 0.9320196550609353, 0.6593273677456338, 0.7888610007529678, 0.47149906417616416, 0.8589592685729954, 0.9612018269125, 0.7055029053885572, 0.4554180336474537, 0.9922623527584061, 0.7139721423669032, -0.10155869380769895, 0.8313673502090938, 1.0248737365488436, 0.6504156526991707, 0.15851216671862237, 0.6307305678026353, 0.925689046911253, 0.6167337091722622, 0.904728021253857, 0.6038524439555033, 0.9075884078714668, 0.870268519862933, 0.5340535778353794},
    {0.85520956732265, 0.13445427151980063, 0.9495606646070835, 0.8589906592320226, 0.8157178859675652, 0.7119267117069525, -0.09052089335096536, 0.39845524395926, 0.6720813902071909, 0.7191102512683079, 0.7070485025182732, 0.7540354273317132, 0.2744541851713696, 0.9102881591310069, 0.8513963749104501, 1.010465218948596, 0.49854916201148136, 0.97006718337119, 0.5260384312355425, -0.16423752908628933, 0.9223117621130744, 0.6690429722099484, 0.6154520516340257, 0.022627385495330884, 0.7537011771591708, 0.8492820336210458, 0.7379507269514513, 0.544593093565014, 0.6209956650801426, 0.7927158605801451, 1.0065662668519504, 0.4946547429257316},
    {0.794743957095887, -0.0771532271739616, 0.6876597491035796, 0.5064260665698386, 0.8189895845681142, 0.7406009208096017, 0.18997014074104984, 0.39589368812010517, 0.5066122163677612, 0.7700303379901895, 0.791945172461995, 0.8390084835769214, 0.5751067155243368, 0.9930018191746497, 0.7234391978823239, 0.6057451861298835, 0.8399087054770521, 0.8820450621469583, 0.5500259984508128, -0.2639409306818026, 0.9066671053814958, 0.8112717364085709, 0.8445944101756313, -0.16740735651424005, 0.3624541599621955, 0.9627392863417494, 0.825788477650694, 0.5609158187398651, 0.9172675005854283, 1.0104749211524304, 0.8646532178124501, 0.6492659231032545},
    {1.033483829592109, -0.179724380547241, 0.7340298912329709, 0.8018497671512578, 0.6999691030117707, 1.0089733448489735, 0.06465869202426905, 0.7348451449961235, 0.6388340400641522, 0.8686262254364243, 0.6811960826306823, 0.7172728621414325, 0.6690547086844268, 0.9612035290166626, 0.7149545943059709, 0.827644586539604, 0.7635514375546041, 0.7133514176530185, 0.8122652599973413, -0.26399257127991577, 0.7353398172598469, 0.6617135628736566, 0.5810191844612783, -0.2307373629713869, 0.8258789287760432, 0.6461051820522073, 0.791332722386708, 0.7923186764776211, 1.010071549412749, 0.7592723779082733, 1.0429683361942248, 0.5671252537960568},
    {0.6225745109293356, -0.2229667490117205, 0.7179045435058956, 0.5446216026954177, 0.8670198232604331, 0.878230994871611, -0.024340456312948722, 0.922858371941214, 0.8957229677239795, 0.7357876007615548, 0.8889595924330705, 1.0275081912162627, 0.4553756198562557, 0.7896920233596104, 0.9277633959385208, 1.0364409429718253, 0.7311251661079493, 0.5946840968592311, 0.716862905375215, -0.2741314983315651, 0.8251918723383009, 1.0735100051968613, 1.0157380969625986, -0.22711773296832705, 0.5595833351340033, 0.7180810539654519, 1.0692560805476605, 0.8989467267195755, 0.8706263228194919, 0.7847406417789927, 0.7334205964691701, 0.7155742797806721},
    {0.9063001706631905, -0.19756895695104043, 0.6872493761995007, 0.4936308745056685, 1.0230041477956777, 1.031007851829817, 0.06847169551514745, 0.6316423590730196, 0.6602295290025391, 0.8536434450645463, 1.0704277698307476, 0.8327650571412971, 0.5798743608118022, 0.6126921843181538, 0.8265075706205572, 0.9612658481168045, 0.437308473942339, 1.0379076323702117, 0.609225358863045, -0.23896899589713708, 0.8431237652436725, 0.6727595990650059, 0.8868237459591928, 0.10662895657103715, 0.4765698383838344, 1.051086041846718, 0.7374647985301324, 0.500941670183002, 0.8884602594952917, 0.8749526156265649, 0.5579712016959748, 0.21890991630741394},
    {0.6356433658713126, -0.14445383766495964, 1.016986790245067, 0.8553624436068892, 0.9050395535622466, 0.8961244578676072, -0.08505184425747807, 0.8700202582557335, 0.48841546093179034, 0.6515383062698503, 0.8193014646528546, 1.015978969121943, 0.7434362589206488, 0.5517753960501073, 0.9193829221208469, 0.7629401605051415, 0.46282909183068804, 0.77643755012821, 0.9617790837282343, -0.09269402068979975, 0.8238557666583882, 0.6797432661953619, 0.8603676927743457, -0.06776592139468922, 0.45875268548549697, 1.0298287700821178, 0.6333211947018377, 0.6743493477516725, 0.9773526430601266, 0.9144991706033937, 0.9238495136565726, 0.4553248246884854},
    {0.6687371467583747, 0.16626777408855134, 0.6735837829032386, 0.5164802289039301, 0.8337545772978324, 0.6073038848989967, 0.14468520592134998, 0.8148286088520218, 0.6512993499497945, 0.612544174626786, 1.0702551543419951, 0.6946277399515691, 0.41743595599195144, 0.6128900193834634, 1.051505373072331, 0.7499655507679132, 0.654767179569219, 0.9345574532905416, 0.7498467575093334, 0.07851924848318577, 0.5699098805507432, 0.6778720306484349, 0.978557379407095, -0.24236546370134007, 0.6580146081079765, 0.8553076310753882, 0.8840301968767956, 0.7593564955255183, 0.910746854739413, 0.5978264886099904, 0.9558011708441757, 0.7241948915041286},
    {0.8833559831079189, -0.26483847687117473, 0.5813997312553902, 0.7870336838534335, 0.599722775474507, 1.052652889019529, -0.2108790413042957, 0.7515241039068626, 0.6452692223327724, 0.9912246463200621, 0.7459366717207523, 1.0013165788244964, 0.5237997215638573, 0.6780586396456727, 0.8719801778392835, 1.0110023626969076, 0.6348884737876378, 0.6372849375536188, 0.8262305873976133, -0.05667243872485107, 0.4736563754995742, 0.7929972638116528, 0.858748923996593, 0.050596007405223714, 0.7138537010405971, 0.9194568092366201, 0.5892953206707976, 0.6664176931156085, 0.6607143950568171, 1.0000173659109046, 0.5738526105038428, 0.6651324063284554},
    {0.7054436663454892, -0.2164644496961586, 0.6249589870759735, 0.45119075353180343, 0.808154373112503, 0.7597519442334719, -0.10225353325357583, 0.5353994221282333, 0.7804532126927364, 0.8003795872769716, 0.9165672374743395, 0.5900609196215403, 0.38186566427484, 0.9668331905542213, 0.9714392626110143, 0.9480773900402419, 0.8442641628933388, 0.7890180028567148, 0.7583381583201826, -0.22971655202696328, 0.8447539216305151, 0.9384867166939466, 0.6659366154897064, -0.24535826334264177, 0.45098776537889457, 0.8956778309696642, 0.9127229338148167, 0.9302365497203128, 0.8763965087764636, 0.7060443549274433, 0.8310240150540953, 0.6944529561250913},
    {0.6930227574074136, -0.13522301137058285, 0.7480808723408721, 0.4593243092611368, 0.7462561008353883, 0.8113651602984912, -0.22144879692146432, 0.6410533649311012, 0.5960794282572408, 0.671704291755772, 0.8624979061587873, 0.6584052980023787, 0.5080707431084847, 0.5656263293169435, 0.6215700362377623, 0.8771050945455687, 0.7175163995284322, 0.7076617417929087, 0.6412236563303335, -0.19495908357454875, 0.9582703224419317, 0.6860494476336911, 0.8049413027104892, -0.03395099312613027, 0.8080347738680808, 0.9149189442852329, 0.9329332017467734, 1.0270784310772005, 1.0094148212427536, 0.6265345105881328, 1.0609254314523142, 0.629307050563875},
    {0.9806257027179133, 0.000676841299774565, 0.5958552263152648, 0.45163107573084765, 0.8622307189373029, 0.9558818833679146, -0.09091458396730831, 0.816160966614571, 0.9065933983224664, 1.0299011331351406, 1.006839395415159, 1.0134672154628666, 0.5341362158145165, 0.7389128020171432, 0.7337643389721206, 1.0152410303800834, 0.840144122680975, 0.937733982525448, 0.8109807706791489, -0.20761975020270565, 0.6862075376042346, 0.7351516696032395, 0.9334525459888307, -0.0006208915734847316, 0.7923960579329732, 0.8128534833620806, 0.8242405222884849, 0.7223056863615782, 0.9122918766976652, 0.8487303761565046, 1.0514848139587618, 0.36712437772518997},
    {0.8488179927061809, 0.023172468554464525, 0.69299601616697, 0.5994676007453992, 0.7790004076543104, 1.0484840431076803, 0.08218141262373004, 0.8729769998998044, 0.6614915869289792, 0.5877593198059121, 0.935799638756804, 0.6687458449193081, 0.4261888190706496, 0.9376707653930307, 0.8227829512148258, 1.0179458200972333, 0.7957241932141068, 0.8912475621073894, 0.776756966465858, 0.02242449974486885, 0.5565588511104742, 0.9142898506744425, 0.9257340888672106, -0.264381526101039, 0.8108721810105862, 0.852958925087081, 0.949210682195095, 0.8408643731721241, 0.8237654114794695, 0.8246672545477942, 0.9533215002790413, 0.4023036213993853},
    {0.9537292689382334, 0.07297441268465081, 0.6030458270296436, 0.8292273924885306, 0.9597933664102634, 0.9086910699119176, 0.190445488826535, 0.5249326486108783, 0.5420280743223437, 0.7676947654724161, 0.8900255919783747, 0.8398430379788255, 0.33539575966352975, 0.8903916666640532, 1.0462327402840297, 0.9322080563980658, 0.6877467395766605, 0.8024437967911259, 0.8543487871785914, -0.06230700446827904, 0.8831336317184529, 0.9151720194333371, 0.7080225631329347, -0.14656122445909653, 0.49997983681185343, 0.8801605753880882, 0.7325291084130636, 0.7438046475789535, 0.571488927949405, 0.5915307259897047, 0.8781229320134288, 0.6222251452467225},
    {0.6246762284965287, -0.23348399808546497, 0.9671161860769474, 0.4299715614976557, 0.9297844725823915, 0.9404595920786397, 0.12786116872011913, 0.7385377898082498, 0.7911929483750084, 0.831651669955053, 0.6325816266880105, 0.7093686994349352, 0.5528249722528518, 0.9238086686881458, 0.6189461066415358, 1.0353772094174247, 0.5669823374733173, 0.6335861654326914, 0.5306362074218771, -0.15500009144036878, 0.7461698490304256, 1.0451881094143511, 0.7389928703879438, 0.06826806286070919, 0.7313287030541383, 1.0170788975072198, 0.593046876809374, 0.5332983821575817, 0.8736708193076442, 0.6040562408688283, 0.7059169085249474, 0.6126376132997396},
    {0.6987646590606418, -0.03273291717953612, 0.5695178759676998, 0.6695737418210653, 0.9248922034216619, 0.874533427531276, -0.11920054587211529, 0.532707212897178, 0.8726349319952935, 0.8998821282304296, 0.616543091718007, 1.016636442988829, 0.4260806988904684, 0.5820373213600055, 0.8066415706561544, 0.7259664787388334, 0.7901683521101633, 0.7380406483550584, 0.8634819084023585, 0.08214450254614317, 0.9028822004142908, 1.006621451565593, 0.772348470219192, -0.05984237529086882, 0.5622080056585484, 0.8705086140686719, 0.7194961691846387, 0.5617672671977068, 0.812918542058497, 0.9633970391458045, 0.7683216552100905, 0.2992215451150315},
    {1.051583445413613, 0.15222779707600237, 0.665557092214609, 0.6199919052707503, 0.5833211547517426, 1.0514876993195166, 0.058601541199749814, 0.6046808663032256, 0.8787489416013915, 0.7199621222529488, 0.827109113002984, 0.8030514044390955, 0.7208057843076555, 0.7113602193430227, 0.6739504212094579, 0.7036997940355205, 0.785481000832501, 0.830967509948692, 0.7244978012086449, -0.03343126928963437, 0.6738695592810484, 0.7978413116531338, 0.7269997884951307, -0.15255390379336742, 0.4958861981362283, 1.0093540499654379, 0.7252938482157313, 0.8652962001218958, 0.9105903246633523, 0.7307899716196575, 0.9712145503569947, 0.29833861281161306},
    {0.6128088503311115, -0.19546523092074933, 0.9638054444920189, 0.42860889774461775, 0.7309028884752108, 0.7799280131999836, 0.007656341029016116, 0.4938277526301353, 0.5608634419128553, 0.8310302863451753, 0.7625054868776091, 0.7238590814758691, 0.4229320754592796, 0.5663184903779225, 0.631339264876104, 0.6613833257992664, 0.5097765083865937, 0.7952524419002545, 0.5685751999186966, 0.15295750762036897, 0.6064883584424174, 0.8489268672702514, 1.0830463668022159, 0.16761541476404723, 0.4602363816659091, 1.0469505968563344, 0.8315414861918661, 0.9883422007950491, 0.7993260669663874, 1.0405996432535403, 1.0655732914140232, 0.6723266148349135},
    {0.760964257193944, -0.2554964384881788, 0.9420783793921966, 0.7648011563670659, 0.8817864416001002, 1.075764446042096, 0.04716178965897559, 0.41142896263640605, 0.7879883366276788, 0.7104323515498068, 0.9495893381673703, 0.8891922020941719, 0.514462782606692, 1.011991328140585, 0.9106308389647512, 0.7828509745679803, 0.765894162905734, 0.6698572284046147, 0.8129395587079766, -0.0708096482943894, 0.943093733292414, 0.8746930996908656, 0.720622218475551, 0.1403199894855284, 0.8447795183341862, 0.8325913674085273, 0.6789683055854303, 0.6156014562106626, 0.9621346780177221, 0.9074106136124767, 0.7501607279904704, 0.46315438660457553},
    {0.6945983927348273, -0.25097154221940104, 0.606323507614272, 0.7665196508794967, 1.0074866080311904, 0.7478463529789278, -0.17421682363155844, 0.6562833288393396, 0.9536839144551326, 0.765704693435533, 0.8272852681324881, 0.710041289328343, 0.617710013181899, 0.9629812469209765, 0.9204405000280195, 0.8016402880810694, 0.7738068240981811, 0.9422954029968549, 0.4959055669270074, 0.08915772948998353, 0.636563239054437, 0.789004155750552, 0.7952782842146638, 0.14421234380581616, 0.5665204133235949, 0.9344200779467339, 0.639478636531207, 0.5498375322402619, 0.9755622425789482, 0.8972934622605445, 0.7297129579227324, 0.712573274192308},
    {0.7076383430894808, 0.06805224038164563, 0.9919273441575587, 0.8908513552545237, 0.6935614288168458, 1.0433868639783688, 0.04333903003574324, 0.8752832606440512, 0.5487233898678469, 0.9828033556938244, 1.0500406395756765, 0.9861517352839686, 0.4579181658656651, 0.9972672471810115, 0.6765390748653498, 0.9139297136708542, 0.9260524405628764, 0.8174163498732234, 0.8445936452592765, 0.13783164639108889, 0.612708353028722, 0.9663940494032491, 0.8200901822044363, -0.004344768055361408, 0.6747407975036052, 0.8379715649316346, 0.8673929738811459, 0.7093581277429376, 0.88097613184463, 1.010436861553867, 0.6879752367240892, 0.482422738408028},
    {0.8611522570338868, -0.18071123790843308, 0.7059403363685288, 0.40371179742150043, 0.53594829543318, 0.6384370828243959, -0.08002116387782332, 0.4811582167725449, 0.6426487140301526, 0.9155975109815647, 0.7636801467664605, 0.9210700953369824, 0.6195955594042338, 0.7961046108257769, 0.9922848473570921, 0.9270145751553387, 0.8011259605774173, 1.01137208483122, 0.6504094274230929, 0.17445374490965498, 0.6231024467057397, 0.9071232027199677, 0.7257013876238256, -0.13723269973589464, 0.33738766556875854, 1.0141866303046814, 0.9945965979296129, 0.5217222438214032, 0.8379267524234723, 0.7315618903971295, 0.7440142365412802, 0.4789693358098751},
    {0.9220194876786053, -0.13767320261918273, 0.9759787252818702, 0.8576781473768416, 0.865109191167743, 0.7878061613857894, 0.06386272546222962, 0.6345097236346201, 0.6878758996312248, 0.6357478685138607, 1.0442881496499339, 0.7101373608931186, 0.7419050177327395, 0.855846492333813, 0.9041711929580327, 0.9349543928061582, 0.8055400276220591, 0.6751018419353318, 0.5786128863895157, -0.14441658051388362, 0.7984075393157661, 0.7271890616759201, 0.7911212144502265, -0.13952282369803887, 0.7537315715048845, 0.9515333353798491, 0.6019320769964678, 0.7660597820140602, 1.054302899429842, 0.9272140763296026, 1.0274228704558463, 0.3573184815848843},
    {0.7545814627815511, -0.009918241062487444, 0.8403370051302366, 0.44215275871686566, 0.8453486015486741, 0.7838917489811705, -0.2554967326250548, 0.6804116000831355, 0.7809693793474316, 0.7203026249677151, 0.6841128419400881, 0.7540167185051927, 0.5819270331659311, 0.7571516115832841, 0.7561929381090263, 0.9968162474872436, 0.5441288647042262, 0.8127789497771375, 0.555233005777093, -0.08052985525341179, 0.9165539727372232, 0.5732805542011357, 0.7920889795922897, -0.13045929373542337, 0.7219865374024891, 0.8326910209147351, 0.6704724489535943, 0.711324731772876, 0.9906533817492421, 0.5950102809202469, 1.0443709446954734, 0.3204209135596948},
    {0.9404686045034907, 0.17406869623230076, 0.8644604310256369, 0.8615726953384095, 0.7050055223868639, 0.7375896945822453, -0.2480548398641676, 0.8468784184318218, 0.5102947611309044, 0.7098158437418396, 1.0732002728953496, 0.6169889178498869, 0.5382922235271266, 0.9895958172568737, 0.8083051160288472, 0.8578186547846701, 0.9076006843685253, 0.7833773434572554, 0.8967828204313606, -0.21867406252523613, 0.583234608597726, 0.943996586029558, 0.8792703116795602, -0.06682575321240823, 0.3528892311723312, 1.0134801990236337, 0.5666381988484125, 0.6147627906966561, 0.7220103714341826, 0.9568713046912068, 0.5965927933782306, 0.5125580648664284},
    {0.619737370033463, 0.03231148110445384, 0.8378429473768978, 0.48937848384758076, 0.9627508058623271, 0.59240510361335, -0.15937132473053273, 0.5861788306234649, 0.5433219798648843, 0.7134609528349599, 0.8939683587560852, 0.838853296125761, 0.5985543896643256, 0.7736164931550824, 0.8511243851777973, 0.8695184109156363, 0.7349616010173847, 0.9129813307278427, 0.6003856489233087, -0.16543656146556782, 0.7524049342299407, 0.9312623111114272, 0.6030628196990283, 0.11009962842317313, 0.8056421101928768, 0.7328170722332825, 1.0378700295745722, 0.9437871136519859, 0.8504718047926724, 0.6705160406103202, 0.8705559288340553, 0.38386920951959347},
    {0.7720251982963549, 0.0893274323109595, 0.6967357195064411, 0.6512629818125499, 0.7571141236076071, 0.9258032668606206, 0.10105262307283448, 0.7590478539536712, 0.7094774796782254, 0.8493311533786431, 0.8560434727831694, 1.032646859323005, 0.6372893041349189, 0.7640516103205692, 1.0656740407987229, 1.0322087515137084, 0.6485495899732386, 0.9500109188176711, 0.7816204197786956, 0.15057943866022164, 0.5338863034892487, 0.7586110340337198, 0.6825555479136328, -0.23875165936945647, 0.682102799375398, 0.6834837883558728, 1.034150753496175, 0.9637167330449101, 0.8895476034022332, 1.0332516608592803, 0.6832277618761469, 0.7650817417597884},
    {0.6108878621814186, -0.11823048661778279, 0.8756264928735834, 0.6617875955194592, 0.9799147364943613, 1.0497217225059898, -0.11114515468085398, 0.6192814198691202, 0.7197423511193259, 0.851388896580878, 0.9000647308833918, 1.0713545205875359, 0.46291734968612935, 0.7052472470537561, 0.6729838599954223, 0.5970351121404274, 0.534660533300563, 0.9861475764305296, 0.6533706663764929, -0.11569370003728484, 0.7886419482659337, 0.6445124533099873, 0.8064087100419088, 0.08524024746788092, 0.7156840950800933, 1.0153087599730628, 0.786832652565371, 0.8147232835657454, 0.8512104839231132, 0.7893327568452099, 0.9990302401040628, 0.650550375010729},
    {0.7607940552999267, -0.05568773206152163, 0.6561515462332836, 0.8035135984906623, 0.5908377605869338, 0.9481160643310684, -0.016632979962261426, 0.45685615837354115, 0.9113105828801227, 0.8029526601624456, 1.0185117770261731, 0.8083156055040622, 0.2895666350977398, 0.9688869483151813, 0.9667066877176104, 0.7511578498998936, 0.8943481747310585, 0.5328490711831557, 0.8911278535414054, 0.16603580180215194, 0.7833618360781136, 0.6578013244389599, 0.9462312454636739, -0.23408078824652898, 0.5454268159355404, 0.6027282098218537, 0.9815688350760715, 0.5731334454532381, 0.7897586748043358, 0.9993081415995146, 0.879268335739072, 0.3489129377959514},
    {1.021073513757943, 0.0967982540091226, 0.9223711760908664, 0.7764179175382105, 1.020864494179737, 0.8688053934569441, -0.14337051428234157, 0.6648391548759767, 0.8319296579488031, 0.7728954960049425, 1.0729814048065704, 0.7315723212236327, 0.7028980929314668, 0.7641464759839388, 0.9541140543004175, 0.9271443142936517, 0.589718408413803, 0.9406809451257402, 0.7076953524633353, 0.11863031341178105, 0.8840726682916454, 0.7098443224703276, 0.5983958757216233, 0.11993124749276791, 0.8424279658366106, 0.8110525724557346, 0.7828562193369644, 0.7781172155796423, 0.8668560524802971, 1.0036004076957339, 0.6892505643775233, 0.7821830667471},
    {0.5969192863982952, -0.06183728456990197, 0.9479414025420498, 0.678923355663839, 0.9035664480200807, 0.7132179371149058, 0.04336672311836581, 0.7152660764973231, 0.6884589124516697, 0.8922486970388539, 0.7756114200263522, 0.8341910619269581, 0.5025627192282713, 0.6403640362416404, 0.6729244352035887, 0.8031269232849714, 0.5888273804059495, 1.0305904014184244, 0.8608986821812878, -0.03462688772502401, 0.7905760720622377, 0.7653203670251773, 0.8169208920230667, -0.0026791800795205683, 0.7758103869898042, 1.0522065362971709, 0.7055682575197189, 0.5780945855460236, 0.8757812545078654, 0.6875436614513328, 0.8905233936714237, 0.6077094131408479},
    {0.7709719440399371, -0.2598072074484628, 0.8302701855909531, 0.8350318804941601, 1.0118634122498527, 0.7285712343667011, -0.01633568231402356, 0.8385283285781899, 0.6685192708371377, 0.9732753810720132, 0.6449165675578462, 0.9183899529085598, 0.5807848813971862, 0.9312692692684786, 0.856866254449651, 0.9486238828448534, 0.8538044091240964, 0.7814113860852364, 0.8088955016424277, -0.1627796516029624, 0.7917298277368691, 0.8219614301936629, 0.5727306159155184, -0.006328171236351034, 0.7588711530402817, 0.7362979688020436, 0.8947985717915823, 0.9504474991684135, 1.0108051183364857, 0.6536088395155192, 0.7375658084093403, 0.6831170407570922},
    {0.7775443599056091, 0.06313451773557255, 0.9930143097515663, 0.7001755346604478, 0.6967531951515848, 0.92506901184323, -0.13807903074591854, 0.8635584416659935, 0.7054732882639119, 1.0004132443499105, 0.7728992314285451, 0.933515503578115, 0.691461430209355, 0.948835664958567, 0.6559017613929452, 0.774045557230548, 0.7366320699608004, 0.6348307463318595, 0.6603192633352116, -0.09192270148780775, 0.5404094043367287, 0.9113245536229266, 0.5727869827021707, -0.2487375279876647, 0.6924537431130253, 1.0813985816585443, 0.6639400023797359, 0.8128661487088245, 0.6490897890912954, 0.8318582473748457, 0.7587907476138429, 0.7881135555243228},
    {1.0540865813546878, -0.007281847669706644, 0.7232377615369657, 0.5355689969156066, 0.9043412699424411, 0.7162776942932955, -0.1253324201099912, 0.4963189932799091, 0.8773161047660829, 1.0309619674566393, 0.7987216784426924, 1.0898283722307358, 0.7466879499778298, 0.6371881558881562, 0.7139728269846166, 0.7527665798464789, 0.9085939634252858, 0.9359892707768662, 0.9798531573694332, -0.2363718355136951, 0.6076105946285082, 1.0334435658653736, 0.8828440553113296, -0.2793493239643915, 0.8031418865787, 1.022077937830038, 1.0381542182127592, 0.5260070162438972, 0.8503364065312334, 1.0253257306871093, 0.5874781022352273, 0.6058218223372107},
    {0.6000932265843766, -0.26115925689320446, 0.746576033971295, 0.4654052983122131, 0.8584764875899257, 0.7141667638888336, -0.1561956040330015, 0.5562723488902309, 0.7635432936682424, 1.0497737155881952, 0.631309388390832, 0.9067807037378784, 0.5141254805471819, 0.8592294968961558, 0.9834567957476922, 0.7177638540470346, 0.4659250980626803, 0.6371692264894224, 0.6882827351742475, -0.10970097367520111, 0.7166094622796823, 1.071520029682922, 1.0771175675978775, -0.16873829445121455, 0.8344407546878628, 0.7565094506185106, 0.85397601463247, 0.9353777393422867, 0.7601185128786536, 0.6164816563100612, 0.6324220040472018, 0.5575822446358164},
    {0.6531404335093041, 0.08515844363716268, 0.6009273275753987, 0.7971681065148085, 0.603885835836156, 1.0682386594205495, 0.09052335804193593, 0.4202928122218108, 0.9204879655249003, 1.0845571868084534, 1.0109862507610212, 0.7844550141864773, 0.6752963347570439, 0.9409472079994474, 1.0396170574281598, 0.5694420417727204, 0.7678124442196677, 0.7917797875541887, 0.9677757905674875, -0.2351335141025035, 0.7373959787697024, 0.8434896931918842, 0.6140342480985785, 0.18255238293411255, 0.7984590118297988, 0.7011900542240331, 0.9394655496982032, 0.9296585716636807, 0.7649308034813886, 0.6368059828414904, 0.6627581455796303, 0.3409161290080319},
    {0.9354049928404288, 0.031417467677283366, 1.0001971435919317, 0.7267597988884592, 0.8631409953120956, 0.6539549640962194, -0.055158993914863924, 0.5085545091705503, 0.8102166589664028, 1.0106714263611776, 0.6124159253181883, 0.8820820916298796, 0.293521388623584, 0.8076392483607164, 0.8555119159917607, 0.9106357672209154, 0.942180238900965, 0.8079816208151285, 0.825102298961463, 0.048169052669396195, 0.700033986453345, 0.8824475845083679, 0.8671114181017296, -0.038283511360845734, 0.413493954260009, 0.7195546239677695, 1.0335929820967622, 0.8332765706983443, 0.8816259656636958, 1.0485087471361325, 0.611305226753766, 0.709856927320745},
    {0.7056726007873344, -0.11129093101979962, 0.7660850142401371, 0.5472851799329298, 0.9153396600536287, 1.0288172882235758, -0.13528535834064326, 0.6618648126387954, 0.5379175077338175, 0.8054214710333895, 0.6029062695639652, 0.5924553088413792, 0.49140966127498287, 0.8520984472523871, 0.7285189863484257, 0.6464404103388977, 0.44945048315234054, 0.8178408826755369, 0.6630729581265693, -0.03555187266267818, 0.6208045326023864, 0.9659919535277336, 0.7958015649799892, 0.06400214540014912, 0.4549295838503729, 1.0804077087507293, 0.9290159621452282, 0.9687610159534019, 0.873340210476803, 0.8127154879293977, 1.0009011010701736, 0.6013803064457082},
    {0.7656984884944592, -0.23505718514162272, 0.9482455165463922, 0.435964103230769, 0.6705711441318074, 0.9093260387114773, 0.03096574181175196, 0.6009609458128533, 0.8239889421671892, 0.6670380908462263, 0.9988170566900864, 0.8502790241539673, 0.3496744119365924, 0.7432350917440964, 0.8635329741099086, 0.7766446228407666, 0.886442360710066, 0.6211102197395741, 0.6833279462738986, 0.12692923477022164, 0.552168183916506, 0.592540718242478, 0.7844215609222822, -0.2545329166740314, 0.6830376091043154, 1.0028999551327795, 1.0354896266069737, 0.6090782662658106, 0.8551795756870881, 0.9842082139162333, 0.9997781935590471, 0.5934238410219083},
    {0.9042520483578331, -0.09112836161685055, 0.6514697009319873, 0.8587118863354163, 0.726939322183343, 0.7031121027226918, 0.13587905908418937, 0.7939581011245578, 0.8450793299368804, 0.8921324158031279, 0.8833885862486789, 0.732553483247474, 0.324287427880012, 0.6024257552747205, 0.8299170780040568, 0.9395345645241685, 0.8387424851105469, 0.8167678532099787, 0.7369849722570211, 0.11530695497286068, 0.7119487327810504, 0.8181983825574682, 0.9143437167119262, -0.15143092318431736, 0.5559174676447927, 0.6978931907126599, 0.5374098176582134, 0.907040422558258, 0.7577414863290639, 0.8793070397571503, 0.8328957055550897, 0.28132731880144457},
    {1.0244186620361928, -0.11606329934201963, 0.9861177429605691, 0.8138518421119457, 0.7732561199339792, 0.8332361520403415, -0.042378498028341066, 0.6583262814674423, 0.7046314673614128, 0.6237069174391425, 1.059190487792685, 1.048242369074838, 0.3661236897223468, 0.6641786322527216, 1.0478125874355582, 0.8153842458190876, 0.6953564110927448, 0.5909267990049824, 0.7710625287909718, -0.018050760703872775, 0.7031211282565731, 0.8588431503362366, 0.918879017664992, -0.1294574213240044, 0.5390407750066514, 0.74141665988492, 0.8385294456343613, 0.6614601532520928, 0.8238363377738168, 0.8477836840618171, 0.9618539176040597, 0.4836524757604159},
    {1.002321958313629, 0.050866581784645495, 0.8110891551447026, 0.6847783367073634, 0.6716014418821271, 0.7283765466113893, 0.03427394909579655, 0.8307132168247859, 0.7061590759562031, 0.6606407813108119, 0.7091310429209903, 1.030652615303272, 0.6381483296369919, 0.7743560561328084, 0.6749378135119575, 0.5779942752229109, 0.8978109845464739, 1.030405258196466, 0.8527875567277634, -0.24531179834059966, 0.5072648027443908, 1.0837546305019157, 0.6613527936475612, 0.13919699175079164, 0.47114606934489345, 0.8249129332151275, 0.7665301971310939, 0.5833391355903348, 0.935378010808225, 0.8544168834907878, 0.7766373700625384, 0.476718811885844},
    {0.6813248079426374, 0.03813440227637767, 0.6857959288213056, 0.708430703184303, 0.6207178218263305, 1.0557515837817448, -0.1272396885636674, 0.5450703943123385, 0.7934445680242002, 0.6778844872042116, 0.6316024828734531, 0.6053326264939287, 0.7752100075010149, 1.0086931948158637, 0.8437264180199555, 0.9163606287976015, 0.9290926192070675, 0.766466602473318, 0.6426715952787802, 0.11584029798532941, 0.7280549095453004, 0.7315970843391156, 0.6340803454470991, -0.012910593989423536, 0.5696002727669468, 0.9321382862472681, 0.7391131889078097, 0.5568236677562516, 0.652156135325748, 1.024477419002138, 0.720155039634909, 0.5860920080986107},
    {1.06233095552218, -0.23710117771194913, 0.5906135011484626, 0.8067004738031855, 0.5702589503348839, 0.8834972181294091, -0.17456771339679342, 0.4611110881026526, 0.8206753617870747, 0.9774297703094369, 0.826946243855367, 0.9392946970316314, 0.27953244654386034, 0.6227486794542354, 0.5663007144221891, 0.7248841571224749, 0.4802266721488433, 0.6735077470736016, 0.9629850287225574, -0.280160462688003, 0.9219614436318684, 0.6666949230373802, 0.8755951402211541, -0.17392429177226912, 0.3789450844624606, 0.6096325258079638, 0.5979972319742092, 0.8050241292583816, 0.6027179753831176, 0.9525763618740603, 0.7172227127191476, 0.5075327176841621},
    {0.776042345445644, -0.015299401959753987, 0.8012202353980528, 0.4599868112111073, 0.6940866030783163, 1.0023913933578479, -0.2282778106193105, 0.8732413417017552, 0.5744889976528539, 0.9599460736948315, 0.9519773251264967, 0.8020631954050941, 0.7831232063581199, 0.850967019127419, 0.9529621273825135, 1.0575419545539932, 0.6775835905456155, 0.6260552444596744, 0.8375773507983791, -0.2505107960797233, 0.6738778611760525, 0.7973932786898704, 0.7191597516369256, -0.07874711152437242, 0.6234369149910531, 0.8155821782794567, 0.6686949398654692, 1.0189411737834917, 0.9586639097792612, 0.8075347240142863, 0.7381115039575894, 0.6106917173950104},
    {0.7443727614021282, -0.04018136581914969, 0.8413995768409968, 0.7175770064426227, 0.9297228534556923, 1.0614934827354883, 0.19214328244070408, 0.889357640255195, 0.6007431540386844, 0.9650251742036542, 0.6463919160965801, 1.0046861216301934, 0.3458479313679368, 0.8168775397736365, 1.044298836283799, 1.0628207927037514, 0.7212182149452907, 1.0372372084291992, 0.848324236631937, -0.08415459342744558, 0.7495774383308044, 0.6775717833153735, 0.8310431001035363, 0.12212741210750466, 0.4277952103358692, 0.8141523385509823, 0.6299832772720211, 0.6344267615201281, 0.85311040520712, 1.0968469861517514, 0.7839688660426828, 0.5089027192398076},
    {1.0031413894476107, 0.16846527535774242, 0.7064228599520143, 0.5504544851096633, 0.7206708051706284, 0.9723541373496909, -0.0411730900476795, 0.40140873436883656, 0.8936092708514168, 0.949175961585213, 0.791573177382343, 0.5861190584127111, 0.4839699422841827, 0.7093003261404033, 0.6245016823634305, 0.9797449685111073, 0.7505359140447736, 0.9071800672283853, 0.6501182536760047, -0.30070171077718744, 0.8166297606106827, 0.6606665641603637, 0.9912464285601416, -0.20354160421983414, 0.5049072597684344, 0.9426134012941749, 0.5359248541495769, 0.910822195552937, 0.9975130859389969, 0.9279080170711014, 0.8385114622617114, 0.6353422357094134},
    {1.0598939736276978, 0.014130554020708553, 0.8973983080395103, 0.507739086954356, 0.7532547920192542, 0.6717063426840607, 0.08719896445686398, 0.6981347646690902, 0.7720959541624063, 0.6437498644713529, 1.0298120687476122, 0.5725141876902888, 0.3401227390418753, 0.8557512739669173, 0.9394266042191267, 0.9525683601702797, 0.6071111763309872, 1.0008027390327061, 0.682264900336909, 0.10434813233896921, 0.8528922097008167, 0.7412181671824003, 0.5918215344771076, -0.266412116517644, 0.46754350364898783, 0.7113648166486292, 0.7466459851768386, 0.9647142903068789, 0.7673128909952666, 0.7929789080205395, 0.7759199353474131, 0.5194713036547112},
    {0.7644184574430984, -0.06914659135327489, 0.8939363345182465, 0.5402600802851328, 0.9403833980823684, 0.6685951002863392, -0.04072978640487689, 0.7619636347594723, 0.848117122460109, 0.9892013772757955, 1.0062635047868556, 1.0319750709446869, 0.769434151435506, 0.6409238665816985, 0.6853966897994022, 0.81332041043987, 0.4436615873214904, 0.7909317103733259, 0.9193986578028103, -0.21281408306148195, 0.8255586256861446, 0.8168891102993749, 0.7610521263450024, 0.02172782086402455, 0.3494189174254995, 1.0670819727828253, 0.9419136088350774, 0.7801916412716614, 0.7877906888447823, 0.6238256520656682, 0.9602293557950605, 0.3288824112605831},
    {0.7351660727534958, -0.004233870487614853, 0.5160146294886683, 0.5622694342728667, 0.983163467287462, 0.7531033701644241, -0.20144334651622156, 0.8584333209047676, 0.6661144088482475, 0.9726595199418141, 0.847911074335687, 1.008341018610217, 0.3616337006079689, 0.8360037675923827, 0.8182679320659914, 0.7401028252256789, 0.6343708269325059, 0.8403317054871362, 0.90248157904887, -0.06639297530887313, 0.7951754009450287, 0.8647971826772791, 0.7650067167291452, -0.09593678935880354, 0.3792035599393109, 0.9215804980749817, 0.6309605243955642, 0.779544889545762, 1.0118347180045855, 0.5959084302653875, 0.9901844907348689, 0.2436965302371438},
    {0.7889548985199886, 0.11277235805920872, 0.5450158890760296, 0.8582289884612629, 0.5932965747658002, 0.6890801902532854, -0.08223505997881127, 0.8473890212094356, 0.7337083815477038, 0.7926320473843311, 0.9919930415331218, 0.9107796245595294, 0.44213898613134844, 0.5623138023499706, 0.7617349895979456, 1.0027045370851753, 0.8078960539776019, 0.6858561798011436, 0.8527763078491152, -0.26397278788452144, 0.6629273571801048, 0.7377151423751327, 0.5920041469764392, 0.1316538146097334, 0.8844302080006816, 0.6357058945501874, 0.6125356688182563, 0.817266315501235, 0.9078605276933047, 0.8699949744945569, 1.0222971005071886, 0.5074662279669713},
    {0.6323138941567326, -0.20496827645107618, 0.7921463025129494, 0.49209767344084954, 0.8321959035695007, 0.8576452176583209, -0.1238033995921283, 0.6062502651336972, 0.5170344105996362, 1.0388635938815327, 0.7624024656748046, 0.8014863835160014, 0.35955757088985374, 0.7616335157923021, 0.9932335807933589, 0.7059879761801753, 0.46265072201453505, 1.0336195403623507, 0.9255460283324001, 0.05512748452921874, 0.5838902309048932, 0.9516373148507672, 0.6796932729427979, -0.1883530078814306, 0.7878108198408106, 0.8562958152587665, 0.604449466145573, 0.8024484935296137, 0.6767888348553626, 0.596799570686265, 0.8852291441583623, 0.5203536034911075},
    {0.6460234576340562, 0.05783694454486648, 0.668641656509478, 0.8446945497967028, 0.7375211808723557, 0.7559809812317481, -0.25679448064300353, 0.43685147463783963, 0.6574466435035015, 1.0956170947209043, 0.6787880964930364, 0.7284270696427669, 0.7000982289291416, 0.7221038536777183, 0.8893749884617649, 1.0297407271958634, 0.7033046879477705, 0.8926486039572464, 0.9304239371868102, -0.056469927401617964, 0.6346993622104005, 0.9412850065125379, 0.8273541963836961, -0.16151271474174098, 0.433329038562656, 0.7784017085300973, 0.6259621188496408, 0.5047732068057408, 0.7163859145840937, 0.870830557905918, 0.9151938972233634, 0.570820671950746},
    {0.8743874606142957, 0.17333394534475755, 0.880583143313529, 0.5034828268535632, 0.8802698753015435, 0.7143316405510626, 0.08221925812651633, 0.6019355259721013, 0.5239453224798681, 1.077582920994483, 1.0446551181884076, 0.9649796382402289, 0.4057140310781916, 0.8696611239896582, 0.9389541898857727, 0.6970358707669481, 0.6012116156422956, 0.7167584097956231, 0.7416991810462905, -0.08337382054920675, 0.4703726761605227, 0.6983903244732342, 0.787422342514493, 0.02116890635579389, 0.6089189013757564, 0.6053304801957002, 0.8073935239253739, 0.592957055933218, 0.644876179468741, 0.9594904120373354, 0.6770933672604716, 0.39778664502625577},
    {0.7947478003553605, -0.10720585155707299, 0.5575596659051538, 0.6514368380055539, 0.8515698932335429, 0.7313049955182405, 0.17129254683751882, 0.614041192155631, 0.6186834534633031, 1.0645382561307777, 1.0666318426110317, 0.6747513676384266, 0.2980199308185558, 0.6149219183524821, 0.5923502089609943, 0.8954529234111359, 0.599107231528642, 0.8923107864607102, 0.5297636358267381, 0.09058433187543062, 0.8512105018239171, 0.7980913657088523, 0.6088434761798073, 0.01945863582084971, 0.3850173966381609, 0.7141417077340958, 0.6913830557509987, 0.5135890570924109, 0.5959808403531582, 0.872541380036809, 0.7053471452588919, 0.5874373816863078},
    {0.627499421431149, -0.27259072252621935, 0.9154165564244502, 0.4845399673570546, 0.5760621102398171, 0.6943147773157011, -0.25511102458764195, 0.5412134758995579, 0.9171757442041704, 0.5991534905832151, 0.7938396330792452, 0.6518447713519614, 0.38259283077916345, 0.9775465039881098, 0.7617005760122079, 0.5779974525438714, 0.5634485163901368, 0.9644669818935554, 0.7092504808060116, -0.28001234192351787, 0.6433524500912939, 0.6939150446794715, 0.8606653716203847, 0.03275969042333933, 0.7796404836218538, 0.7914664104613179, 0.7658502926564348, 0.8309783853862871, 0.8381719030265188, 1.05441502488406, 1.048727465010252, 0.5154241511007821},
    {0.6790928926592124, -0.12099773945023547, 0.8273809103022959, 0.5611357985857379, 0.9009413424841141, 0.9066320558724923, -0.02638358912524019, 0.9303879137392771, 0.9503138653222638, 0.8451148441586926, 1.0248754593593357, 0.9519149791192046, 0.6610927548380316, 1.0494016803842294, 0.9544467308368614, 0.9477112533906775, 0.5811619737388335, 0.9296438148643111, 0.8012305895864745, -0.29104271325103864, 0.8482171061864545, 0.6647385953138001, 0.8028335443442922, -0.20196235580238783, 0.9211758495966041, 0.8258005590061663, 0.6308000052722048, 0.8646912704501187, 0.789975428748369, 0.9895164984536031, 0.9440521361949638, 0.7708737385907891},
    {0.9689174215852967, -0.08901969020005517, 0.6796156915405314, 0.8185407618405698, 0.8191772693117668, 0.7487483350919802, -0.16055595874453252, 0.8713923810284346, 0.6852072784430857, 0.9627335977625886, 0.9024474466871123, 1.061315273369428, 0.7009105293433682, 0.950566184405925, 0.7060064962304257, 0.8135039919711041, 0.7852339690531239, 0.7516879699882539, 0.7089384657976495, -0.22145719942717526, 0.5613134160918714, 1.0863918395722132, 0.8905175356400467, -0.06938842612145538, 0.7460400153665984, 0.7332160101706175, 0.59215809460257, 0.9012317553940025, 0.7584898553916896, 1.0226548597187952, 0.7164948278589334, 0.61536836003644},
    {1.006894323065297, 0.08156847556455821, 0.5599676583086663, 0.6991877873466178, 0.8911863487186568, 0.8585442647002997, -0.14067727835224605, 0.4471321344867405, 0.7469368477502879, 0.9565688315724912, 1.0297310602447893, 0.8758508539488095, 0.5266635900565811, 0.6378427183696868, 0.6804731735665974, 0.9629108939840059, 0.90002149384236, 0.7911954204836992, 0.6664189029966174, 0.013191031355484743, 0.5812704347764871, 0.6499346582759628, 0.9215258388528, -0.18012978850467698, 0.717868357277986, 0.9212656588076985, 1.0160259284292605, 0.8380631439714421, 0.6283392620262056, 0.8406426076532207, 0.7248063360145591, 0.4218078354409149},
    {0.938311688454111, 0.11447860718565171, 0.5956467383124437, 0.5435872776534455, 0.8006623504249993, 0.9879355564633838, -0.2651656751143082, 0.44850004875487415, 0.903008527694468, 0.584312022868331, 0.60457846642406, 0.5753257391776061, 0.39769575295470294, 0.9337486269938228, 0.9684232291085069, 0.6673833535858618, 0.5564117026199847, 0.8763196290406059, 0.59523511014586, 0.12068034381851767, 0.7380766063957603, 0.8502002301293231, 0.9903766055437304, -0.24147680409827885, 0.7178214466696088, 0.7837969905298704, 0.5901306760037827, 0.9310959471838451, 0.8430111573981444, 0.7099788415674545, 0.5611492570950597, 0.6257567370223462},
    {0.7174046546085197, -0.07147303471182564, 0.9337426036303167, 0.6684366665640049, 0.6620730520815011, 0.8488451950045154, 0.18058141760835125, 0.7374806049792328, 0.7510267737272328, 1.0640048007186005, 1.0060033557520405, 0.6366737290705602, 0.6213021618699356, 0.5985433870823798, 1.041484354948861, 1.0426771375369694, 0.5324996337755562, 1.0422662055876146, 0.6239010883482018, -0.09759352373585475, 0.8139714396082558, 0.8795962418218501, 0.6521665677140726, 0.038750020080818494, 0.7230863366666139, 0.9240089773310928, 0.6529502728482219, 0.680648257503491, 0.9195108425608816, 0.5875751181696247, 0.8750368625030958, 0.43375437356793445},
    {0.8758773119839169, 0.0838881622526466, 0.6645303754853253, 0.7761453764002393, 0.7061897644337563, 0.8550270264178061, -0.22528671987729304, 0.8400272703938109, 0.8319440230298678, 0.7433860383854805, 0.715288325313343, 0.623477848679321, 0.53391337507253, 0.77327444773035, 0.6672600121186874, 0.7798183350382597, 0.730582604150694, 0.6657877243891435, 0.9377324971150485, 0.09014218089553946, 0.8997384918008065, 0.6461932936554386, 0.833955669077036, 0.1812626335520669, 0.6217183772614671, 1.0292866825336413, 0.7418314329666272, 0.9110645906535604, 0.5751309040626241, 0.7312313147830521, 0.6524498481265243, 0.48190540462529496}
};

static const float b2[32] = {0.77847079811221, -0.03759275953393237, 0.751790415404648, 0.6518012692595, 0.7901028423422244, 0.8150219643029946, -0.06338067013456836, 0.6215905717721231, 0.7055480116534143, 0.8011555714939386, 0.8267334208055657, 0.7669864105148017, 0.5289132267193445, 0.7456853514687258, 0.7773304825892094, 0.7547341600146567, 0.6732085746438927, 0.7729392280792693, 0.6609210913821993, -0.03925531597847459, 0.6865194568062349, 0.7801615200549056, 0.8026492508639184, -0.058217374258414216, 0.6030278576872499, 0.8204220006752505, 0.7847649286753317, 0.7467676223959178, 0.816762122839118, 0.7668807173235738, 0.7642774101547176, 0.5473827993200467};

static const float w3[32][16] = {
    {0.07018001065213945, 0.2964969776002692, 1.113465276768485, 0.7002386532612933, -0.03436292291049476, 0.029316881201941158, 0.9546289905472664, 0.02238599549378356, 1.1900350845313408, 1.0778682216810906, 0.7658439807126846, 0.20113760636827757, 0.5592946401715793, 0.6582181539637315, 0.07150540398449177, -0.30323647336609777},
    {-0.31802859538962724, -0.06952334949298633, 0.2745613405399793, 0.1756480831313636, -0.041725408359768436, -0.08992916729154996, 0.10489042125892, -0.05923311949972765, -0.12940165048577623, -0.16740529887489342, -0.036811033373840715, 0.24036151944216644, -0.21509886815458282, 0.12753561173139893, -0.06259474316261358, 0.2416624342974977},
    {-0.18658531503060738, 0.1770664301434051, 1.1111169170227047, 0.9133415887134375, 0.29429159678219674, -0.18615819383921292, 0.6767972186109456, -0.2260944186443071, 1.1893424239348063, 0.7402779166605863, 0.8315175976544809, 0.20802857057266597, 0.7896724019593727, 0.8603031354443488, -0.20223695753335605, 0.2983862099353406},
    {-0.0644141862380271, -0.048773678076561, 1.0917699667043643, 0.985585830301405, -0.18988074087597528, -0.16667569353890443, 0.8601450569248741, -0.3007969143603434, 0.6785720279536128, 0.5921511953475538, 1.0146667728277594, 0.1786800995079165, 1.0938757847963314, 0.8974110565183836, -0.12491405711259046, -0.23397361662741561},
    {-0.302552065395218, 0.18439178031133457, 0.5681197690462967, 0.5837669233124172, -0.12808775064086905, 0.24495996916246576, 1.1363693687758543, -0.07399236798942664, 0.73610202381734, 1.0761664340341133, 1.0384130874796644, -0.3380722690313845, 0.8383466635956256, 0.8374430182729223, -0.027435063580684732, -0.34940115848174214},
    {0.03596148274877668, 0.12096329583466874, 0.8578636641608519, 0.5770495620260478, -0.04202994327172047, -0.056811907849442456, 0.9030115888575996, -0.21525642993562297, 1.1642819137655867, 0.6261956061160819, 0.5783307269528235, -0.3959744903379534, 0.9193171022001294, 1.1791373443080655, 0.055625709104011704, 0.2320847238087104},
    {-0.23157665230417535, -0.30936434698927967, 0.4012489984006457, -0.09369562490961024, -0.37150550416608513, 0.05554572126933413, 0.3121735351585744, -0.2928212128722974, -0.2064944447660112, -0.19211677700607488, 0.1990309204593069, 0.07611075494867231, -0.13409623852165958, 0.22937155280955165, -0.16853636840649242, 0.21455482967683634},
    {0.1989097789527634, -0.18230262731630967, 0.9825916724528245, 0.8580440667776246, -0.12345465098715536, 0.14029071796871284, 1.0210021195915022, 0.12585370030778756, 0.6322488286328108, 0.7592849447532164, 0.8170224284495602, 0.12003010551144663, 0.8211681155608777, 0.740391649045396, -0.020034097275989184, 0.1394120414536608},
    {-0.015134263081565548, 0.056366082140145955, 0.8844558245571252, 0.4844803011918911, 0.2987804275194005, -0.016349424863458053, 0.6881012564709265, 0.20519829160505998, 0.8253370905063373, 1.167603931585521, 0.5776933508359243, 0.19361200810745102, 0.48727998376629583, 0.919848335795998, -0.27847623269028676, 0.14367377303013668},
    {-0.30269837821393203, -0.03943267339643793, 0.5744725603217222, 0.6043978935890617, 0.11225283230534189, 0.2746435380088696, 0.5707740542969735, -0.2532737288959119, 1.1338818549543617, 1.0158329486968238, 0.9151959635022244, -0.309896610814925, 0.8598721794645443, 0.6915295306452093, 0.05475444590984275, -0.38193338153860473},
    {-0.029461330705473833, -0.2748913256925444, 0.6951001389108308, 1.1488229329464446, -0.20397916976946331, -0.1093281278754046, 0.6346802683827816, -0.2805458866364081, 1.074913976120233, 0.5337639303550094, 1.0141887932980427, -0.14984152201421738, 1.0827458738188684, 0.48969263829817417, -0.0831608868167673, -0.1992700417132252},
    {-0.2931367727632464, 0.034694967454108265, 0.980875559554568, 1.0388685129689048, -0.0788204668585568, -0.24344993757997535, 1.0389927219307538, -0.2936031112421045, 1.052726643709832, 0.6145488728619891, 0.4292844074299247, -0.2045024379729175, 1.214771860408034, 0.9346676829970124, -0.36046100816906596, -0.10403233420391633},
    {0.18199574650080066, 0.06675211488995508, 0.31136066699293163, 0.5371938038447855, 0.1419052667987819, -0.26111729592106697, 0.9868505605995529, -0.16169529885225276, 0.3972256388048659, 0.8348294016113573, 0.6743913679237558, -0.090020268516013, 0.8569170200574794, 0.4023652847836511, -0.18440226671247067, -0.24399988945278595},
    {-0.28934737122034176, -0.1857467202399785, 0.8191626033994519, 1.1062061140310566, 0.20004152064472916, -0.3083217942107734, 1.153825585417188, -0.17156846369845485, 1.0988818624825178, 0.5655740553674523, 0.623662897622369, 0.1304578709864838, 0.5761319742725, 1.1359869255158157, -0.26761770957215586, 0.1798998571184391},
    {-0.09104904591507668, -0.11455298443532883, 0.5486250288780641, 1.056592542659781, -0.023437830784281802, 0.03810600760926319, 0.7315196196697126, -0.24907660326055242, 1.1370992036284429, 0.851015911811094, 1.0676076249006006, 0.2684347855009328, 1.035495521483272, 0.8158359351551147, 0.13587840701791976, -0.32314525414629686},
    {0.025188610029825195, 0.10072359083058678, 0.8986189880294975, 0.6258554626045041, -0.20930842394611932, -0.11119614863419958, 0.4816799642732239, 0.21324832278497285, 0.915103757949576, 1.0740924800425966, 0.8769105885589205, 0.037852341326813914, 0.8093070407600711, 1.1573350397373967, 0.026726928690393933, 0.3068949852725492},
    {-0.08967598298144927, -0.319875779077638, 0.7088468100559008, 1.0082491253161356, -0.052564686896746544, 0.06938676283079993, 1.0775868249492524, -0.1939543916592815, 0.9555488951004404, 0.6202988335803385, 0.6016951381044244, -0.2637685421307718, 0.5391184016895361, 0.4916057901478295, 0.23414489162430574, 0.06891350686581278},
    {-0.03321565746745388, 0.23395505093670593, 1.0343527987191365, 1.0701898249326278, -0.01793908022336062, 0.26171695213268825, 0.9881799343197738, -0.1470749111399151, 0.8103451704931675, 1.1161654857443264, 0.39974689083667864, 0.25700866240953857, 0.9949129146133622, 0.5046033710709108, -0.22761281997088983, -0.013093238168610489},
    {0.22770595064627822, -0.1614754997783717, 1.1872505763226533, 1.1840924268059656, 0.24184287932357912, 0.16071304523792662, 0.8400193610340398, -0.026182561755801335, 0.756603942291469, 1.2322811385045072, 0.961448471364985, 0.3004172478164823, 0.7132401366896174, 0.47794092141984795, -0.04998536642501541, 0.2547687399831111},
    {0.18527745721566535, 0.004667706934568046, 0.08285145191994367, -0.15990903069671378, 0.2598402851713657, 0.009588482500669187, -0.1914208466587291, 0.08807679049677343, 0.0476623127170164, -0.03073830182175349, -0.16702304543309815, 0.10924948018606086, -0.124320933667188, 0.1325108807448433, -0.17785002859190607, 0.09244620921200343},
    {-0.021190506920746165, 0.04955735340051773, 1.1317782692945972, 1.1560252788384686, 0.2910125315600464, -0.2376421065301261, 0.5401401284964233, 0.22566995232597828, 0.8436754517460241, 0.7357623088747584, 0.6434072624490713, -0.3156933047047834, 0.7558650292754523, 0.7941270624913257, 0.14547022553123917, 0.31567724319781365},
    {0.053363701504065775, 0.03357016011911215, 1.0490492894043724, 1.024890985504289, 0.25832350292440937, -0.2687005872417385, 0.8610724624343895, -0.015762822629325032, 1.2016273244339868, 1.1316028977086157, 0.7499156336607563, -0.23199224159977497, 1.0124798709133498, 0.5684028391446536, -0.31917849906335005, -0.3136166807748547},
    {0.13497682518491141, 0.24021019091080098, 0.7690095260213095, 0.9173139685153263, -0.29200698372982875, -0.197718186636826, 1.0139737933903814, -0.08894202343937459, 0.9603058925497893, 0.5810106623944694, 0.42131618800613435, -0.042610422545750835, 0.842452489171621, 0.9633664101134359, -0.1480064403190727, -0.1187316905177566},
    {-0.20304825947639663, -0.3423180224480006, -0.10907029652104899, 0.008957673881909309, -0.16124360186455322, 0.12574405756369786, -0.2252607575491863, 0.26266789925499484, -0.16775916902785015, 0.031929611111422895, -0.34934548882785316, 0.2311141658710369, -0.26985661775512476, -0.09784474158218871, -0.34937526139377545, 0.32454537839750364},
    {0.07884500354867585, -0.27641013051605834, 0.3815185131182122, 0.8164251011095537, 0.010596599341608986, 0.29849663824446, 0.7395832827572398, -0.07288446466639621, 0.449960367187875, 1.0586630734049527, 0.3575382515893789, 0.27608283204879885, 0.6018808772055805, 1.120562101106909, 0.30299444634160905, 0.039179707419707374},
    {-0.19487487697155512, -0.24619299096452127, 0.5872912306489986, 0.7998692745601775, -0.4178463835405176, -0.1403186780320614, 0.6277709593624555, 0.3361968303987102, 0.8627347014753555, 1.1261387166855679, 0.6100135246456513, 0.2638179631708252, 0.6748637549485703, 0.7593041385558997, -0.3059383155487306, -0.16865333681438768},
    {-0.25623123230260697, -0.03987536353997052, 0.823909924054911, 1.0137014581025703, 0.022477301165455706, -0.10672811753923736, 0.5441618150642463, -0.06947865106801156, 0.8811230046993347, 1.1616810009358653, 0.8265294013661438, 0.09665701630836504, 0.8944793255068958, 0.526924029583243, -0.1503071318046594, 0.06129416554021576},
    {-0.3718191826538812, -0.3083764503930641, 1.1486715866145374, 1.0671252873880415, 0.0246026653491336, -0.062311359896104326, 0.4919155048635874, 0.17624385583318194, 0.5807092264646284, 1.0160236844358752, 0.8356659014984965, -0.3196473124732945, 1.1214145503669115, 1.1636667686319688, 0.05340478964769092, -0.10087278114410536},
    {0.3104667008179819, -0.23715398404610843, 0.86076158107038, 0.9388623743060144, -0.03678677589408646, -0.08173251766714609, 0.5911531946667818, -0.20281084160131901, 0.8805460398190914, 0.7354335165954589, 0.8731221364501363, -0.3444451054421232, 1.026653042153528, 0.835643286963873, -0.23627285574840873, 0.13315979724976387},
    {0.07090967228720525, -0.1798095348561395, 0.7137433004289087, 0.6607144283003362, 0.24018183967392076, 0.031515510326419076, 1.1457150443359196, -0.06951527607692005, 1.1839107222876843, 1.0181695158378388, 0.5996202478216343, -0.08224057425287574, 1.177944338242683, 0.7734810629105341, 0.1939012003068155, -0.03052123189873262},
    {0.08065070893892472, -0.2941160058960975, 0.53619169445535, 0.8001800835933627, -0.38417633369761117, -0.2856786456323406, 0.9464540782184606, -0.06642050594342816, 1.0631744342419915, 1.1528909794438997, 0.7527550607563356, 0.2875635473426986, 0.5519631642570269, 0.7443717559417792, 0.14398858775905032, -0.03640375677083834},
    {-0.31114876544571174, -0.23162219640534737, 0.40077343298959, 0.8959190194335419, -0.20930956304363268, 0.01217124554517884, 0.6887026357894251, 0.25551405926110704, 0.3926529486232155, 0.6740261636485816, 0.4713531219498067, -0.15356857468852086, 0.6714264612037315, 0.7901555641241591, -0.032341414214309715, 0.1337664400235834}
};

static const float b3[16] = {-0.03689267728792352, -0.04043880607900343, 0.6222055498043776, 0.6639136532468319, -0.05341934928989584, 0.036971371121742036, 0.5900917055792878, 0.039815450389458336, 0.5481726557998898, 0.5989824151859063, 0.4847058492169148, -0.01859515271383998, 0.6348996107323338, 0.6328002941393613, -0.03306506276980555, -0.020817359029639014};

static const float w4[16][12] = {
    {0.3294653757918998, 0.357812240957182, 0.23496042175256335, -0.16455133302033254, 0.3050716586436195, 0.07930441245946221, 0.026937489890536206, -0.1367159129770397, -0.027783212378062555, -0.3020062725597456, 0.04694937571181711, 0.05404621499521393},
    {-0.2706085735879957, -0.24006747972062945, -0.3993621822231823, -0.3747409553083858, 0.06273699397811451, -0.1541522446837384, 0.37224688903305336, 0.25171562859310237, 0.26594502358473593, -0.48153952771371045, 0.2900937882440217, -0.3752165875271595},
    {-0.5589082527736507, -0.8640771439053813, -1.06198947717761, -0.525761979962594, -0.778460553208746, -0.6265685376746115, -0.4369059925681764, -0.23143193084291278, -0.5453045668398191, -0.7528035831580954, -0.8657594059092878, -0.7957042537411645},
    {-0.565947604560317, -1.0864619974778698, -0.30716348299289725, -0.9559396327924307, -0.378750819347682, -0.5760709813479383, -1.0057142423140895, -1.2145955550977257, -0.8079712016268705, -0.5663255576725233, -0.6222831456461461, -1.071640825667933},
    {-0.1191942152663997, -0.13554844762092216, 0.3121650823229692, 0.1336917788916217, -0.29714763340700656, -0.34032006764939887, 0.07159889916218849, 0.28407449640036614, 0.11036233145776278, 0.2637648562073946, 0.33409355130651774, -0.198385851607678},
    {0.045732255162287704, 0.06051778038413593, -0.3880501106029305, -0.11920493510792479, -0.4766951818696112, 0.30898735760391954, -0.49927814911007723, 0.04907707764091812, 0.05357293540496914, -0.058444403863265784, 0.10687143794857953, 0.06048192174087321},
    {-0.9136857983765018, -0.5897158427458543, -0.6353056505162342, -1.2400879666821234, -0.337367858912067, -0.548606770119555, -1.1874676835681388, -1.1380200792273563, -0.6081833352806026, -0.3190008739511813, -0.7255863039192505, -0.5248388485708912},
    {-0.1312674568271617, -0.2004842737550379, 0.3642969183921703, 0.3468903418548359, -0.2703150048712903, -0.40229245437304634, -0.43862681906539136, -0.408039646819388, 0.0783540249800275, -0.48761005762544246, 0.24912361767318442, 0.04085671976287395},
    {-0.5138322511339478, -0.8544306323593476, -0.6367747110458336, -0.9270072909873102, -0.854327694860621, -0.6186125870641292, -1.0098752478187114, -0.8443019168569014, -1.0802166047243789, -0.7174919300196484, -0.9059542381855866, -0.7781194065777378},
    {-0.8991150775534552, -0.35008600645948573, -1.0837603528647748, -0.46005287330011, -0.8822854736247083, -1.2098958779890163, -0.5579147036604486, -0.8010846085776978, -0.4486286139648268, -0.8742685892836994, -0.9257035485533521, -0.8201979228452865},
    {-0.8577046606822614, -0.4594218103434403, -0.30788646684834287, -0.33794263252898027, -0.7594246149127422, -0.58192593562694, -0.4568974348543684, -0.32674681786516185, -0.6322480052254172, -0.9752060987789375, -1.0775144342699292, -0.24873082101198396},
    {0.2723839763711087, -0.43172175313510497, 0.2918364443291351, 0.12683757761946052, 0.2672326917818972, 0.11181764967506183, 0.15040061970441912, 0.3251693397096195, 0.20837467995719267, -0.399800931761771, 0.2071212595516776, 0.26146288253126204},
    {-0.790629656465071, -0.7927076256083248, -0.8023502453789111, -0.9658411979201001, -1.1979810366916985, -1.0056473422836385, -0.4492588075254089, -0.6311195835399654, -0.8382739336131639, -0.9388164365757847, -0.47882935150167205, -1.0279229252060347},
    {-0.9479253822572071, -0.9393010898506378, -1.1228939711329604, -0.49008005031279345, -0.8234646366612373, -0.8022535444077975, -0.9017733544520229, -0.7707405176270499, -0.94614822328077, -0.9258190291989434, -0.36404266639943705, -0.5863361815950414},
    {0.25787497803699927, -0.290979967778022, -0.299555489113142, 0.2548832324317394, -0.23395909540301646, -0.2530419731662246, 0.4180348923983759, 0.12225276598428803, -0.23902305418853942, 0.3328862551005344, 0.33461032774394744, -0.38975231052707915},
    {0.10789859409934462, 0.4298088249824573, 0.05658797669178986, 0.029409361782329693, 0.29366792454568613, 0.3414989207288515, -0.026459923734866036, 0.0711555769413959, -0.17054033517963504, -0.33353734667373264, 0.026526236038821482, 0.009422533181268577}
};

static const float b4[12] = {-0.1491345261142676, -0.24921693139405476, -0.1483705829255123, -0.2839408871223969, -0.26684242638557376, -0.31277487102328255, -0.38316911661068975, -0.33371844343048934, -0.244979914875693, -0.25770525425796686, -0.31220877275904174, -0.26587177509771315};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
