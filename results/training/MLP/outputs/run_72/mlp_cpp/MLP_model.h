#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.48852211689723063, -1.3986818585010543, 0.9088007556368707, 1.5917769140459195, 0.6505407579561578, 0.7971981144251413, 0.11707668945909694, -0.14541515781905706, -0.30850147670394884, -1.109030911656948, 0.3641444963987384, 0.2312429894036706, -0.984833286912793, 1.4079731121773829, 1.5296282069288951, 1.4605118545236149},
    {0.22562122215276045, -0.2734998120666263, -1.8197081703883442, -1.0252148627630076, -1.8306870333112035, -0.8283944884416153, -0.507859571170471, 1.0486949095178928, 0.5740977751278639, 0.9382496014634344, 0.29520429220685707, 1.473042651116656, 0.11679179976735847, -0.5427760537297203, -1.1495088271088971, -0.46664781093887775},
    {0.8915737672059322, -0.436552388151585, -0.5860355046957757, -0.34022151135463435, 1.4444302508394573, -1.0048287736044224, -0.7901166983148269, 0.2301642047935993, -1.3393539355519328, 0.6334838972364574, 0.15786236745729482, -1.0953674337719341, 0.1461027945217321, -0.11668262601808752, -1.9542956524219242, 0.10708585217566063},
    {0.779157171931963, -0.6925687969135855, -0.6344249937462089, 0.6860028002532427, 1.0894028205550885, -0.13660658578960902, -0.2838970681216041, -0.27073264705204136, -0.5830780134787658, 0.5632380653612478, 0.9569021479310261, 0.10782661784577714, -1.1468413336590813, 0.5759191307733873, -0.13877409170342217, 0.6148088938916555},
    {0.2520616547454508, -0.9278281211596431, -0.305479727340792, -0.1957683749366155, 0.8631530188442608, -1.2073014989484179, -0.40095350101341787, -0.4028545362026228, -0.9739636960097271, 0.1312465154522584, -0.562814647588755, -0.975919535614651, 0.3787025542931963, -0.7927440559489554, -0.6340913925108348, -0.29897789792889373},
    {0.6852713868736829, -0.7033033240766517, -0.22605895724920422, -0.815107159198712, 1.304505942947578, 0.1846738626578933, 0.5083068885564213, -1.079359126773838, -0.29963008313187, -0.3155435536857209, -1.0916185077338776, 0.8957692685755598, 1.0439221340436469, -0.9416347662962599, 0.28647650938849817, -0.9715282405790265},
    {-0.03375680961977156, -0.2866485405044569, -0.28596150962911043, -0.7029612303126886, 1.7029599056258582, 0.16310152554377672, 0.01848814990163483, -1.2129682217625626, -0.7560333284870576, -0.8574335417820897, -0.8011677646972237, 0.9764524263408023, -0.19954679127115763, -0.6174537637763229, -0.5539793057362806, -0.29485353928392194},
    {0.825329045003898, -0.26504168908753417, -1.3630197612514103, -0.0876618652733124, -0.09772989199426724, -1.2795019789333957, -0.3918668066102531, -0.06951448613960448, -0.9504078136129748, 0.2357300286065466, -0.6833145702756381, -0.2613419658173636, 0.006099344650445384, -0.445783205628374, -0.07809844784162466, -0.647829306635574},
    {1.5991762876911222, 0.168641855930851, -1.7486035399692135, -0.38388541185481967, 0.8509303892135088, -1.579743834854544, -0.6904679481395158, 0.31667166236838545, -1.3899564232328452, -0.23811322433862703, 0.15193839457553987, 0.48136241691597476, -0.9409290064644561, -0.6365596864039317, -0.5543224749252984, 0.21912979711531508},
    {0.3070880669556466, 0.6663526939345942, -0.09112994013684819, 0.24298506190764077, -1.0010495142398184, 1.5934495373270792, -0.33283008403452974, 1.4052273910976296, 1.0219418905386743, -0.004564512923035114, -0.44180331399956235, 1.3480887487739825, -0.2375045240494922, 0.2240045550988049, 0.7111594464139872, -0.8046294944019236},
    {-0.3573933281259632, -0.3157058636641652, 0.0342075801990935, -0.4427802967997238, -0.6521191683296431, 0.8143125908322876, 1.023325971720773, -0.4349679051474988, 0.12576478462110202, -0.14430119832991864, -0.1044491229303873, 0.12665997982965585, -0.3566475314902612, -0.2594216335623248, 0.17269378495329127, -0.5112630345163236},
    {-0.2661507803937161, -0.25268723824041034, -0.1644219724428796, -0.3340726485165236, 0.33918508437421885, -1.2021995696065688, 0.1806243618531861, 0.5924652416061991, -1.0241039074678526, 0.4430915045416203, -0.3371545868535531, 0.34248869237680674, -1.5593720379382252, -0.8467963035369126, -0.9990278187295044, -0.25419559509544387},
    {-0.5197924344321426, 0.9036682163903196, 0.20879165130116858, -1.0841285664028935, -0.5346735567171257, 0.06070337221973487, -0.36274768257251966, 0.11959939022480427, -0.32561924547810456, -0.7723946872237409, -0.4517563109341492, 0.43827671657694117, 0.3505722846863937, 0.5226728914552632, -1.0958079561866099, -0.3259587527482396},
    {-0.16419249135533204, -0.4750191708195087, -1.785359141414526, -0.9686449325522196, 0.4463367059724468, 0.1978598994556978, 1.1986475674744808, -1.0448440491443254, -0.6736103482325857, 0.48140023001893356, -0.20280949114574723, 1.357122713222871, -0.8623521194396975, -0.5660110713265754, -0.6450346319613138, -0.925905714704064},
    {0.21129327831341002, 0.1770858703837483, 0.07616536274224452, -1.2732598739868506, 1.375881453540777, -0.7895355460273251, 1.1313711455505864, -1.8392964653144848, -1.4841280149337932, -0.7809460762402299, 0.05192945032150592, -0.27567492602713906, -0.31162352782190483, 0.1320787808590972, 0.327565620718048, -0.5546079893563363},
    {0.1729978731985396, 1.24107282003337, -0.2286322735316146, -1.1205773940700443, 0.17593932023298586, -0.244758860998363, 0.47070821378162786, -0.8736723800684355, -0.163899366529903, -0.39375234175038165, 0.17958314790625393, 1.0049139499056758, -0.29649056420011854, 0.4096646024944283, -0.81301620004678, -0.4857184801427858},
    {0.15386177987463784, -0.27648020696810127, -1.787647465951605, -0.810752951907625, 0.5523390560670344, 0.31229011973098164, 1.2628093404240912, -2.060443122523555, -0.1810070518302459, 0.07128777834079945, 0.3719490907530759, 1.1381885938053151, -0.203144050648963, -0.25137803198327124, 0.7421725903118276, -0.7422591215139425},
    {-0.3399024068418041, -0.23751288349954858, -0.6704423462269868, -0.9609533435282088, 0.22070354246762677, 0.09034314871491164, 0.9053223761473209, -1.0273680226948887, 0.11612510649313099, -0.22897491446348564, -0.040363897230860646, 0.8922751148821229, -0.6311406216646943, -0.892805980302042, -0.37341807939475, -0.6177108383722764},
    {-0.25793332082674353, -0.0239165750689613, -1.0157400870102369, -0.7986936487924391, -0.13030297392290646, -1.979923737505944, -0.21347715402651526, -0.8018316834526623, -0.7689242927494093, -0.12771108566103717, 0.6303443145345052, 0.16334108571180103, 0.1391213330589897, -0.3178674791621125, -0.3114859679640816, -0.018360022675885705},
    {-0.009723725075262753, -0.8992889786238453, -0.16798656072417115, 0.42619194200052446, 0.3686308716157028, 0.10134247723091924, 0.6348574279966914, 0.2225080044561884, -0.36037577958692074, 0.4504068874155892, 0.0779164179802399, 0.3845100328182836, -0.12748334932926134, 0.29224089812380943, -0.06368786871663443, -0.4017788951332013},
    {-0.2291657574584006, -0.6416446100522706, -0.9246767553103258, -0.8165399256932416, 0.08029330919574998, -1.4331346291630978, 0.3182415858511029, -1.554063706343754, -0.8721152030358433, -0.15969551981655244, 0.09448112681168845, -0.4645866388548488, -0.4470538079405034, -0.23507225591126088, -0.5532733761509403, -0.42629183701044104},
    {-1.2971299574941961, -0.5279595164833076, -1.2553439958376935, -0.8298131602337546, 0.13550509444089776, -0.21564635194399137, 1.2820123768355287, -1.700984741452195, -1.0774391195819573, 0.4137417457293266, -0.8735263233779255, 0.7210607131257238, -1.0629352800118268, 0.10780354478701462, 0.4029232013990319, -1.7886557849770046},
    {-0.23443446580245608, 0.3153988059687839, -0.2594614038516149, -0.12074214207830979, 0.5131978258268585, 0.3795414347634703, 0.7247682471865586, -0.9192335027119032, 0.34219484288122026, -0.09839002586268912, 0.6908485219784164, -0.7641971722366315, 0.10170742576942071, 0.818679270645694, -0.816795641021804, -0.46852524606334245},
    {-0.9231117170802285, 0.006629797814917969, -1.0504364633082086, 0.11729484004378524, -0.3642948581145573, -0.3261580447247304, 0.8740808692365036, 0.27335209990289006, 0.3276979208853132, 1.664900787926132, -0.16646966991730505, -0.1035306884689961, 0.2883242284315606, 0.7560252809863873, 0.5140693172320022, -1.1713270960671942},
    {-0.3412561451933046, -1.0319872250797661, -1.1859383239240995, 0.2785496970664934, 0.19180481681656023, 0.3755316483423769, 0.6349066240480035, -0.3388414996006564, -0.7600428891729881, 0.07763722884903734, 0.12592948837916992, -0.32658705297559476, -0.20479463602469297, -0.08340690016661169, 0.516352740541397, -0.39882435831274415},
    {-0.16173203142727888, -0.5862670483305726, 0.018632329658011954, 1.0646246145405007, -0.1560358401919055, -0.34456661126251664, -0.24832981298879703, 0.34697804297500995, 0.4264686708013331, 0.5351554324707114, 1.1340857068674244, -0.6295014522187649, -0.29452582748424816, 0.6861705724338959, 0.19085646638970682, 0.4452514526341867},
    {-1.8203026891861018, 0.023834980946652092, 0.2854547753252414, 0.12450239997160341, -0.14994494718461876, 0.16740463886328383, 0.46920513365827876, -1.0162221522142718, -0.48024189689751295, 0.25854850939307716, 0.3395028977236564, -0.2905020396606899, -1.1347528194754186, -0.18713293131682757, 0.016195988131076783, -1.237279521349009},
    {-0.4425244971770703, -0.23629698783282232, 0.9693774734625998, 0.611282313726733, -0.04391307650301811, 0.4012255937825853, 0.248040870240482, 0.5270380777076038, 0.4309919336206332, 0.1643421644242589, 1.220262526296068, -0.5959530251060275, 1.151037910359651, 0.8829745749794179, -0.06266848759149954, 0.46667308789264206},
    {-1.1134835590253618, -0.7394640227666982, -1.2660133839484327, -0.5568962837945156, -0.0319233787968775, -0.24271891765090778, 0.9650973775780096, -1.0810209403675357, 0.10378060561023704, 0.71905821998404, 0.06734208949189109, -0.19639720744606431, -1.082056509516415, -1.062061745211668, -0.24894248408909894, -1.0652325466288988},
    {-0.5795112001839376, -0.24835895064674543, -0.6164404291407926, -0.748255361502304, 0.337322579388236, -0.37799607048334777, 0.11697275264293185, -0.7838104293504395, -0.79133709810347, 0.05671802071387499, -0.06696536436338964, -0.4079426142010521, -0.00364612762236362, -1.0224827209675804, 0.14082843997955383, -0.48406763800653785},
    {0.5345248603308184, -0.96436589492158, 1.2975551326697194, 1.4802784697487879, -1.4002136630404456, 1.9507404240081625, 0.7740601263740893, 0.5476514975150181, 1.2066716318620265, -1.4419936247551506, 1.1130670352516039, 0.7461337455289351, 1.0893473536301261, 1.3312306970391017, 1.51320259565598, 1.3115564116906946},
    {0.8312443631069577, -0.44119496003385494, 0.8934767477860028, 1.6190314136958284, -0.8425113058803622, 1.3193296866230682, 0.15842522722536928, 0.9536956175369561, 0.45148725196738343, 0.3311847707955407, 1.1127479216256113, 0.4091870774731129, 0.7575336554878611, 1.80129972223659, 1.314919560765742, 1.484626604726917},
    {0.11423579116942384, -0.30416355996718286, 0.5340066505691659, 1.164124972377515, -0.5819674050214939, 1.41949240691814, -0.14510977136204042, 0.9730863393962002, 1.0722200027620015, -0.9379008743268202, 0.6534532095685669, -0.11095090025867536, 0.6162291557711487, 1.083657907815589, 0.9384814193212553, 1.1708360418045787},
    {0.8102206403436736, -0.49072996062437335, 0.8384833524579677, 0.9960969285754869, -1.1348141470807696, 1.6475253245649406, 0.004455376887784759, 1.3672873486874868, 1.1738774862175974, -1.0664418527925452, 0.8351971832534121, 0.25478610467555, 1.1002142559544108, 1.3265515445546867, 1.3701274943728738, 1.4050426300082386},
    {0.33377611335034896, -0.21392931557546915, 0.6067484927478695, 1.2696548360473865, -0.1363321879161342, 1.0428684601231795, 0.5415845305498278, 0.41763793222490664, 0.6350828127448646, -0.5522507128741798, 0.7812355341143099, 0.5219587376234313, 0.5552956669305161, 0.9478430431084506, 0.30684105056336086, 0.4172921126468042},
    {-0.054860283849288705, -0.26967531357501523, 0.5260508003892372, 1.1154405010589297, -0.1031307746677157, 0.9857129111108334, 0.1228263254368919, 0.3578737752805175, 0.3592733030042874, -0.2436215967735598, 0.31330781066836244, 0.161519445858955, 0.09457202357890124, 0.5543767426913585, 0.41243267800279176, 0.3088794667585381},
    {-0.11790763920584184, -0.1989837953252184, 0.516550020936097, 0.18448715331787693, -0.2393948461667159, 0.5993803639770748, -0.19139901932299944, 0.12098003623549386, 0.39094575962829564, -0.45030212723613716, 0.3678338649849679, -0.25149189482771195, -0.07875305422064817, 0.25450111889835186, 0.3163529032567709, 0.3964805669740408},
    {-0.3113777748261335, -0.11488546050205733, 0.44155427898128946, -0.5007416200898909, 0.5690997420577956, -0.07546801240745002, 0.28701472275492096, -0.06440071114335176, 0.2661180320903588, 0.0296359092940478, -0.15793471129681008, -0.1343731153560175, 0.2403366800800379, -0.08632589488474421, 0.6065358507031378, 0.36721031595313725},
    {-0.07358784667228968, -0.22123305495280207, 0.2996831375348152, 0.40534445912952555, 0.09566354410142905, 0.44999801136830864, 0.12045432415667695, 0.16348886798183312, 0.12149836561617415, -0.2966340152777119, 0.311747460753689, -0.07555314641280146, 0.2362030475135701, 0.32489460427620287, 0.30588103899552743, 0.6832828343271639},
    {0.18532575252922973, -0.17015816159641842, 0.03943783390925907, -0.12740470429592463, -0.5491511097256568, 0.34992433237100556, -0.20167008054264557, -0.0831420298111067, -0.33451871971165587, -0.20823987854659837, -0.022331445467165166, -0.007980702826961804, 0.060151294211239666, -0.07253588447523511, 0.33501116637002293, 0.022127244085782302},
    {-0.22519202083966477, 0.03164708338170331, -0.1141131617632895, -0.6652382083526059, -0.33938867321495686, -0.15894561784589725, -0.2987662101336342, 0.22690177872660652, -0.667714940192299, 0.03897042870047999, -0.4413394458735592, 0.04050274648379121, -0.7470340144077033, -0.32645292893768085, -0.3287540922779, -0.6159523696030081},
    {-0.025315886648746507, 0.09997857966901415, 0.20207036544185528, -0.11123211661285057, 0.04321770400055015, 0.6568119639035241, -0.3807870959013282, 0.3048498596221236, 0.4759799974646145, 0.0007915990855212086, -0.03574944426089441, -0.04392847225219855, 0.1048204211175696, 0.6418192650958106, 0.35203173438301694, 0.3177925283379265},
    {-0.27432383005398614, 0.14258216669578902, -0.8768791202997676, -0.49658883389370345, 0.07941539438753864, -0.5841055741246178, -0.12817148733011072, -0.36626036057093275, -0.5207093402673081, 0.456313473060363, -0.5042058705081309, 0.07891432192005365, -0.5684694040718348, -0.3896578120482761, -0.23298596800519317, -0.5807452793510117},
    {0.12783469447891688, 0.08941591668601434, 0.22582327527071933, -0.034060245679739205, 0.23579018285533979, 0.3270409860574205, 0.26551301347046585, 0.48704845939283875, 0.40538587532930476, -0.016144043961219753, 0.3198141690450829, -0.1338986683814493, 0.09416424341016921, 0.48208365063073266, 0.47719769753315866, 0.44366730329139287},
    {0.43969148433550526, 0.022417833341104358, 0.34108681030738974, 0.6707629646806937, 0.10276336180568833, 0.8601297502649654, 0.07792952331651166, 0.7865239386871384, 0.38720593588532193, 0.2816402867869252, 0.4587573825463464, -0.02653079164995615, 0.24587311724228111, 0.6311964225034863, 0.48232722926701666, 0.8575883483831948},
    {0.18509177921247585, 0.1720447998564497, 0.061607410172104936, 1.2304440678495103, 0.37518534511616436, -0.12100733392774826, 0.31051307281914675, 0.765518534007866, 0.11136839743815875, 0.4508335691717971, 0.45736278934682945, 0.26517877028985964, 0.19848173308416334, 0.41248014774299246, -0.4330233060412476, 0.16612554169406318},
    {0.33099441981672123, 0.02916453105162074, -0.16299388220864663, 0.2939270831369157, 0.18857011465525403, 0.09801956870744613, 0.04890099959617309, 0.7441529936223154, 0.24213912893003767, 0.05651737433553319, 0.16901817907164543, -0.003976437257708608, 0.46677848712880976, 0.09000984184622529, 0.09072579152410984, 0.015819173150249603},
    {-0.06703187797750233, -0.32556155875061304, -0.7163822805935136, -0.4076335152296061, -0.44239875061174777, -0.9191591155114082, -0.33234151246338023, -0.3024197175359735, -0.29808777960628435, -0.36831808619523193, -0.6353553956215319, -0.2976955839714789, -0.2605305100060125, -0.8529288501827144, -0.8050575176287126, -0.39521481866806396},
    {-0.20899177372478922, -0.3009078516573136, -0.5036039964520034, -0.0344280278352991, 0.08926573242550184, -0.26929331088560854, -0.6211716812232462, 0.22040870522548545, -0.26819996435444377, 0.04236134261470757, -0.22678229382101414, -0.22786541670875854, -0.38132737977173986, -0.7057773833410937, -0.23180289700619625, -0.17477968707547248},
    {0.032899046935332105, -0.20548446868360862, -0.17659535374867866, -0.2804101126873997, -0.002842449194640473, 0.34597873723777883, -0.2580540472446388, -0.1046851439462777, -0.7186254636986278, -0.09491494372464872, -0.19762751878743515, -0.7116338317091053, 0.15090356184986659, -0.3181908958786396, -0.5335803355285916, 0.19423788500967862},
    {-0.04208063884225532, -0.04604388515374674, -0.7120137108628991, -0.560897801465033, 0.24797429740898297, -0.95088376346813, -0.1881803514106338, -0.31279619320834834, -0.6456091972482522, 0.20960762691849594, -0.5729284916777216, -0.32734654639047334, -0.28915808341481997, -0.6229299372298474, -1.129762607845593, -0.4918952622694237},
    {0.1091951132997476, 0.056683174785377925, -0.2542821360679411, -0.03474816722254351, 0.08020179173526625, 0.12090912412946155, 0.2606920401543676, -0.03389974965030118, 0.2308326516087708, -0.027255911105920582, 0.1436793735696057, -0.03489519652120068, 0.31690124953775173, -0.22320583353521523, -0.530764461366397, 0.019160485808322327},
    {0.5361109635555047, 0.19041862684515626, 0.12726695752546185, 0.7713300460132864, -0.23728845929209905, 0.3317618022977072, -0.08544132419975474, 0.013106676241414617, 0.6651453369254701, 0.018865248792180267, 0.33732733468949117, -0.09554503062167619, 0.17521265085519278, 0.4055706347283227, -0.07120649570470737, 0.5096382639839766},
    {-0.190982448810934, 0.10943957426206836, -0.13624316360425928, 0.13978938628475618, -0.1865375139098288, 0.5592301188860681, -0.21002626576086636, 0.09024412827903164, -0.2813995798844973, -0.16219183024255587, 0.6353203072977743, -0.11441240042637663, -0.18856071464801258, -0.0770345391660924, 0.256172250775726, -0.12543433593856618},
    {0.000141757919596614, -0.3698548864341504, -0.29184880966865623, -0.43103513102880503, -0.08838451348902275, -0.08933708268976952, -0.2264507282837818, -0.7004766929204795, -0.16561058560280886, -0.04162066637731354, 0.10989272850048583, -0.4505464314531006, -0.0501735663043442, -0.2008857809390561, -0.18162414795729065, 0.16346249203470062},
    {-0.14705467785051127, -0.17228692496853554, -0.20955138812283364, 0.3791042142565176, 0.5349808150596872, -0.07420831816832561, -0.08448797844154599, -0.09270558661245958, -0.45754775974328005, 0.8956986522962305, -0.10687144776496361, 0.11906488600083952, -0.10860429086113184, -0.24498099663378128, -0.528623490223379, -0.3300012293244269},
    {-0.13376425405908346, -0.10860628248739165, 0.011145107197355241, -0.46227996326229315, 0.20022481789265056, -0.27219381257789627, -0.26349535732960166, -0.5042826599763303, -0.3425208357882299, 0.001333900383489678, 0.04958993730062775, -0.17359853760575303, -0.1649416665767364, -0.6038680320501886, -0.4933279763089973, -0.21042741019825836},
    {-0.2548017279974818, 0.02330785235166429, 0.20993748811577087, -0.008472688305100305, -0.053308825994665146, -0.4438571422811075, -0.01081630062273883, -0.18421727993339393, -0.5277438343715335, 0.054779237295957545, 0.362003082819845, -0.1503878782376739, 0.03454176950305738, -0.5340053772234203, -0.5256111576804792, -0.29519379025949033},
    {0.3793154495832945, -0.084204427131071, 0.264958134991842, 0.8600119052067186, 0.11582015501244008, 0.7988180948863, -0.17610598155748963, 0.7647027149317042, 0.3705853738794717, 0.34653067806350407, 0.6266398026207147, 0.0726003851992936, 0.14975635919404282, 0.3874672587916444, 0.3103067449041405, 0.43377032913941066},
    {0.21443979290302645, -0.38826952656397257, -0.14974793479552032, -0.4607757452925878, 0.33003730347724325, -0.28784463816546657, -0.13391482732884397, -0.37369590650095397, -0.27744113536824233, 0.45585159158931776, 0.03144403743092753, -0.16903578912974906, -0.03352641502147816, -0.3533533624014719, -0.12903531058346412, -0.12087299669419767},
    {-0.2706566289202968, 0.19895353017370274, -0.9550316554849628, -1.397485647513269, 0.13701682567420476, -0.75788113070623, -0.6656871486855958, -0.4901634614966004, -1.3163727400169014, 0.3667609995446697, -0.9663708016718261, -0.619863849634933, -0.8608669241432654, -1.292947875975909, -0.9303588692457746, -1.2281405577981759},
    {0.28401385805033674, -0.38894081029664207, 0.5437763936016934, 0.3522282666696574, -0.0824105627230672, 0.022138820952972513, -0.1668626987666178, -0.0573797861642559, 0.32366218311079964, 0.06160842085862626, 0.27449986601140974, 0.1814347536438771, -0.010093691070288754, 0.11837052213586692, -0.13541410812739257, 0.285920661774081},
    {0.36030442326202344, 0.12750718534180688, 0.8011640224810698, 1.222933278694354, -0.15566332403263772, 1.1302302519307685, 0.5430377917603858, 0.8721876555557636, 0.8262678844737169, -0.5265342731638103, 0.8327893661723655, 0.540146737165566, 0.7250781214264803, 1.2091711257029143, 0.8733330555655924, 0.7862062162677336},
    {0.18786133698587276, 0.36336109819532025, 0.5781009053401752, 0.5421328431046649, 0.16235761179347347, 0.7453968410779842, 0.6552052628311994, 0.7538027093691939, 1.100272406507764, 0.06081942060009792, 0.8552972379491054, 0.4847333789527387, 0.6283590471114059, 1.1522011421086975, 0.7474261711533341, 1.143069707085863},
    {0.21713768809547812, -0.05669180081733504, 0.4720786880086555, 0.17746297819322304, 0.2058200964881845, 0.5379783725138821, 0.4552278410661148, 0.499114332468075, 0.9134942707155261, 0.07205326721154291, 0.7119732880169608, 0.1998581249630868, 0.5333447755777138, 0.5907195614003445, 0.5357858562887797, 0.739105247630632},
    {0.10969860647886782, -0.02404269896783432, -0.06377282878722183, 0.4636265080504797, -0.12602801231258207, 0.23304509885225153, 0.016643891175501826, 0.011606275719948938, 0.8278691642568462, -0.07246971487109809, 0.22181938741930804, -0.13730709015579545, 0.46992120448991287, 0.31204545530650596, 0.6761076133653334, 0.4751339462292905},
    {0.37668426847075226, 0.08341295276468784, 0.4756318764962711, 0.7656751973666811, 0.5447341876920132, 0.8832680888905986, 0.6836836388217095, 0.7105951469289477, 0.7201516457728944, 0.2087725989313124, 0.5473910848231937, 0.6294978127496925, 0.12449193427968683, 0.3675109935226131, 0.10910027802390163, 0.3913165064572153},
    {0.07472277137723632, 0.39668710948196656, -0.08649450962570615, 0.4402233898496199, -0.26806241487567173, 0.0014213096897542192, 0.2822512454763518, 0.4262385877280545, 0.04885800936437561, -0.1504650299303479, 0.2935593815709533, 0.12308840672060534, 0.21920418732402072, 0.20229066624280967, -0.16760277936345275, -0.009606569258062763},
    {0.12417152412443702, 0.12982925251617564, 0.23070754563614965, 0.3579982949740527, -0.023071727709978087, 0.05738832029546441, 0.03833491719096619, -0.09048674908639612, 0.29919156982525213, 0.108399475874103, 0.30220360070534213, 0.19584298316684615, 0.27213923493692793, 0.18168400781843555, 0.12987208515880774, 0.5723760640393605},
    {0.4472658874710929, 0.04215682559371824, 0.6792858828876038, 0.9723817901349049, 0.17388929549997367, 1.1776677150732926, 0.1475828652842565, 0.6714200812974673, 0.7315838993451336, 0.24145611030695482, 0.5185575652521611, 0.26101127597076446, 0.3548613793224609, 1.0688019145971712, 0.6131612019767403, 0.2133402422567493},
    {0.3488032042615358, 0.18453573523972713, 0.4487628881719199, 0.7620470901939587, 0.12918979666460376, 0.6482453057957842, 0.4125597515983846, 0.8952052659370152, 0.5250332242591528, -0.13743338913303635, 1.0619050684827493, 0.08983377519873859, -0.014006940687166371, 0.8236186127618013, 0.6199188487807922, 0.22883704549492917},
    {0.28066251111613694, -0.11239562181431861, 0.3463810611885642, 1.1154023085195048, 0.05362199011564345, 0.24673825071673888, 0.5075948664292422, 0.3788585681909672, 0.6518653891592785, 0.33711244804187857, 0.6532855605913704, 0.16494978727096166, 0.16307365682524355, 0.5848076696392689, -0.0967783976907887, 0.6572475827328381},
    {0.4437139486034713, 0.1564568307800639, 0.5443580575190251, 0.6326506587202683, -0.2149337432265836, 0.08065642304234087, -0.09402719743478484, 0.19331058224420225, 0.627769517336241, 0.1691430054831776, 0.4626052442107272, 0.12421274094601759, 0.510452611994677, 0.5128809729694247, 0.30405266785361945, 0.8244234486674391},
    {0.25560950858526543, -0.06084644381763277, 0.5505171381640707, 0.49426478224762094, 0.40073169469997905, 0.048526182729169365, -0.09386514346830402, 0.2078555815590111, 0.5677506053116574, 0.24520341623200304, 0.10944689317849371, 0.1786764817993378, 0.13127876663233895, 0.326218505917854, 0.22204247000662294, 0.29940110235143885},
    {-0.39212065838698196, -0.2571447728099199, -0.3759899720312882, -0.48916666477479476, -0.02451291271314749, -0.8270137831063507, 0.0956526630662208, -0.6957136698785366, -0.30191448080681416, -0.17776533804806718, -0.027608801041673882, 0.42217388758703417, -0.06959848798355756, -0.5229803966918295, -0.5361925151083645, -0.0913591310344926},
    {0.04075426509366513, 0.11180606195916976, -0.08790984837839613, 0.44518998733032006, 0.19501881489449677, 0.06538356920358546, -0.06655830158983396, 0.19855500345344862, -0.3171631691964764, -0.04899558312518668, -0.1415684459042273, 0.07854615395559737, -0.04377564307868868, -0.21204998880795858, -0.15513563607200292, 0.2400556765285891},
    {-0.15943305619877501, 0.023951038256255195, 0.1709646444109803, -0.304861568900832, -0.19088962613976046, 0.2540813661059619, 0.09848658484641606, 0.04058401077936372, 0.7734833623672023, -0.47138316898194627, 0.2856497244368681, -0.13924174594113695, 0.31030769771631717, -0.23530172793599285, 0.29633132170285775, 0.15445000214864124},
    {0.19682854380195555, -0.009667354465653028, 0.15009873109364155, -0.046792592308064325, -0.08916112953761338, 0.6574422177972131, -0.07909092842148706, 0.27173794026057535, 0.581664218142368, -0.09317386301745964, 0.3718722791386288, -0.3235117972246501, -0.06542305588409422, 0.20570689354813873, 0.6624283271696656, 0.30906030632459597},
    {0.17549273391237, 0.39243637019880306, -0.13422645312472112, -0.11996851315460554, -0.20595227162426696, 0.06377698861850908, 0.157660137688862, -0.2047326392095179, 0.47173926258276405, 0.14927163319179976, 0.08749955758536812, -0.11952250296977297, 0.014418266190403385, -0.3971741393952738, -0.22051056147322207, 0.223635195064357},
    {0.7892233124917125, 0.11734349254361698, 0.7720259387028138, 0.8995147557634737, 0.2618985707258805, 0.7604084843755625, 0.10767389899629931, 0.5806637041400591, 1.1877467557362291, 0.44473359550717145, 0.4150042662127465, 0.05323099929658137, 0.3682037251268691, 1.2642507131303988, 0.4988796085518355, 0.8182948069042265},
    {-0.3790211707491472, -0.057451443409898884, -0.27723623550428805, -0.08962398032895906, -0.16900649718500688, -0.08349485835143934, -0.09434996395421684, 0.1684211750373873, 0.06427186707809862, -0.5942562898741022, 0.22332948698817015, 0.21971896437563485, 0.08355062249734542, 0.3027114264367352, 0.33823440697474183, 0.23871187943748537},
    {0.05191446990042648, -0.0015500672504608502, -0.1038448413364271, -0.08135523569496517, -0.22346799582920263, 0.20908281909062007, -0.0005404983800121661, -0.4071072949520141, -0.20919292790346017, -0.27884540327023505, 0.03341608656770683, -0.018885744254802144, 0.04423140733598516, -0.12035486147329896, 0.6600880305836746, -0.020222091634072164},
    {0.14378347589865462, 0.2102116400719742, 0.484324003461972, 1.0257541982147966, 0.22596705480312382, 0.6050365654843165, 0.30117674958164203, 0.8640622590171103, 0.3297782805108894, 0.32021885713723647, 0.2834588271590167, 0.3252527318016123, 0.2662113460722727, 0.6211247614432625, -0.028714860688185462, 0.33286007205463014},
    {0.13309147883754774, -0.22874075459794854, 0.21955769785132598, -0.30951647120453707, -0.16008074676567013, 0.3279869718534676, -0.1838439171137603, -0.20825485587700265, 0.4186787186849918, -0.007062331443721519, 0.04758374143891282, -0.2684352932151785, -0.07717170296130212, -0.11046801298553612, 0.16769422758288977, -0.12285284398457391},
    {0.19991005340916304, 0.10288230861252742, 0.41845932713698175, 0.011722956135623724, -0.018236457192353055, 0.7678015906308459, 0.16143172843125, 0.4688362787880301, 0.8864441558373363, 0.06542662909941041, 0.44555692032398814, 0.3450360462849951, 0.37825439211705936, 0.7636026237766637, 0.7829954247915568, 0.4399597444507684},
    {0.20940872497879498, 0.0011062891407050588, -0.050810857577595056, 0.19820074832900308, -0.17222843195753582, 0.2918516914884222, 0.010000576357964357, 0.03581155962493189, -0.11477918231540553, -0.47509862794912994, -0.11376688650773412, -0.35238959227466077, 0.11111239748700363, 0.15677988093816742, -0.19868528440627484, 0.058379686653455304},
    {-0.3498745173039299, 0.08122497190788676, -0.3905736793581001, -0.37263801562190674, -0.5011489617139914, -0.34493842901229316, -0.3380664729480242, -0.6833179509799219, -0.6687700788431332, -0.14972483916231705, -0.18007551663420246, -0.33669075515333474, -0.4529940780003994, -0.23252441211904062, -0.607161033957834, -0.821153895633377},
    {0.5832177805232072, 0.009512130694471052, 0.28567629665784683, -0.10400115762328305, -0.3783077950870869, 0.38778248488424083, -0.3558121887997543, 0.3764353521860904, 0.4912326891303641, -0.4617619500575992, -0.1259012632301479, -0.2857638494016737, 0.20714438696193702, 0.33563635262848673, 0.43494128737124854, 0.5074159194344675},
    {0.5051568096199905, -0.10374676740042092, 0.4051286981079246, 0.4716839637201219, 0.004285254399748487, 0.9283732490470609, 0.25558375209527345, 0.3631725094056718, 0.7260754887613057, 0.1448612505612037, 0.4559244566322046, -0.18116666291967737, 0.07509991746111667, 0.679736679247303, 0.09826712105003639, 0.45306013505536985},
    {-0.30080301145961513, -0.21153836063435713, -0.03599632612413163, -0.3096707579127733, 0.025144489185713957, -0.7825567843043489, 0.27100975347350104, -0.4973658459666337, 0.08933512859732419, -0.10905955093476993, -0.05894972656328324, -0.1863950872886711, -0.3308783192602454, -0.38373618421808464, -0.6001756990676437, -0.4684825687426821},
    {0.6021643410265232, -1.9162382834843361, 1.2716328698407962, 1.3358385626911344, -1.8919588404676237, 1.430561289651101, 0.7030542682479376, 0.5187176344546379, 1.3405967206112546, -0.9709564051190841, 1.3943676750483556, 1.2713255406571906, 1.3320288906784816, 1.6085162928139258, 1.7910345784379544, 0.9957868566270706},
    {0.3187817861494283, -0.9037534657743955, 0.9894069807555529, 1.2727173347161045, -1.1889337288752928, 1.025074392861714, -0.4732682448875003, 0.9049710022501665, 0.17864389997608912, 0.10045651037122123, 1.6195872851703976, 1.1514020266960303, 0.94352869464988, 1.4644560590922988, 1.3138739488991082, 0.4875305787500127},
    {0.3618646866270348, -0.04433660178690811, 0.4679479911979177, 1.0386203900562385, -0.2941355084510661, 1.284034925004238, 0.3019239757399342, 0.8064966931898524, 1.1306701691011722, -0.5857626780960827, 0.6741052470203284, 0.5763967360069381, 0.7109158855909399, 1.2721967754836956, 1.1658020009307184, 0.9736838801539955},
    {0.05007400209131781, -0.3326873003955253, 0.7052391065222593, 1.2319706441492484, -0.6702058967742779, 1.4194778147051992, -0.23613216225646153, 0.4699709879977486, 0.8869057748100966, -0.454743815599175, 0.3109207021627647, 0.13790144960513617, 0.8325084148480948, 1.0422231928884376, 1.1498390163687264, 0.9984159476181838},
    {0.39688895480695296, -0.04735694575128436, 0.7964714229573945, 0.9445168940617514, -0.22558267654813605, 0.8539423485179791, 0.24832583190499127, 0.9477108681580091, 0.8463726347206273, -0.14215609502542792, 0.8375957139411753, 0.6354854418512963, 0.5361181237298437, 0.9506356538018561, 0.8315075008516637, 0.979657890302831},
    {0.5515827369200936, 0.004070562670565801, 0.4785742746995386, 0.8401156103828391, -0.5307945411525731, 1.2348001002639586, 0.43400410709995596, 0.713086724859477, 0.35343268415867696, -0.29800708798006637, 0.5219340659871023, 0.20062888164194584, 0.277329826025704, 1.0554768007266582, 1.0687616103123625, 0.35938600748782085},
    {0.1528300716676057, -0.23270701407478325, -0.16220921148441084, -0.10956063700612352, -0.15862943793516973, 0.3519872221212747, 0.0012301700805142472, -0.009891596210074665, 0.2292577612580847, -0.4357564502650236, 0.23737029210813473, 0.3562015324203878, 0.3280911644684747, 0.1123883857661852, 0.3625352406085818, 0.38388002111799396},
    {0.1296849633899244, -0.16926522997060942, -0.48297120353493295, -0.20805841542708392, -0.38923493880835813, -0.5174900570996906, 0.07272965897199189, -0.27202626404259944, -0.2892864172001532, 0.29837634272006863, -0.034025720941430186, 0.17209927316630436, -0.05541011371498467, -0.0009695118939853304, 0.72206886925843, -0.06605492291192194},
    {-0.13103107814336779, -0.06785496360859962, 0.19836483911943192, 0.39717046759010055, 0.14160620691351195, 0.23465582960341252, 0.03199897543540915, 0.18224253285894274, 0.3045722454052746, 0.38010519531983133, 0.6893157446859068, 0.42947488568312014, 0.32313600325272934, 0.5847714909556466, 0.30915068293487, 0.038598871561678114},
    {0.05936585853060975, 0.09689313728780939, -0.14867727219544546, -0.18083491341304556, 0.13722864454130324, 0.14589667752111274, -0.3015914668819965, 0.1554319218848784, -0.2017625170303361, -0.14353089378410405, -0.27332413799549155, 0.1183771397542384, -0.13711055273980582, 0.3785588788973951, 0.6010375595009402, -0.26212704000383985},
    {0.06271209162545877, -0.4452853542495281, -0.27785999130475814, -0.3245291539725909, -0.6723072572604405, -0.5991985980332035, -0.39657896867567205, -0.8200646119335244, -0.5741424496576633, -0.41251770700454277, -0.30264774762810875, -0.4191544087940928, -0.1949300905999345, -0.7984922123713397, -0.25316846938255544, -0.759693671535619},
    {0.4434023551797687, -0.07635994375423762, 0.6780919805554585, 0.9410933988908782, -0.10305062570148972, 1.2270934154606095, 0.1432635457567837, 0.7612163518725157, 1.2080458091937416, -0.24432030574377023, 0.9110869881927859, 0.14428609598823403, 0.466022060146558, 0.9689711453684435, 0.670837295495157, 1.01321007911741},
    {0.1256199082712795, -0.15777507304910873, -0.05859221522079586, 0.2903026218029829, 0.23351180906546457, -0.08706444405465794, 0.18248647004326304, 0.05442073445848628, -0.0882154458243341, 0.05453204370921909, -0.4102465648525483, 0.12291338326721175, -0.010573162069818929, -0.3095005663818705, -0.12338184192741154, -0.7089518712906213},
    {0.0009683840385699433, -0.18609522030880296, 0.03028704054391667, 0.16094701816495569, -0.04343004371239612, 0.33600968357061545, 0.13020892602275932, 0.29674168002374474, 0.2671479736064355, -0.31737033682396953, 0.009616977537859426, 0.15901913842487725, 0.002720703030097662, 0.2454628561395248, 0.19790456788667332, 0.06251835253630222},
    {-0.295412245020022, 0.0687598728295585, -0.35376514284792676, 0.0761917640543735, 0.13484323622159233, 0.09727962622854527, 0.14408762998218508, -0.2659570528242181, -0.10647128910452541, 0.2869159709089193, -0.29255911108105587, 0.28679226897867255, 0.1967522012857426, -0.3805764081047407, -0.2590950313992123, -0.1427660454118988},
    {-0.259313933656906, -0.04970058463896639, -0.4220868532387351, 0.19790541865155709, 0.26824985568475396, -0.22715081504574525, 0.07853922321107937, -0.47574706831476365, -0.8509856136405298, 0.23927104498390586, -0.2829007049548595, 0.39319508377541357, -0.24589619912761612, -0.24084646430145804, -0.4340153797776118, -0.8117677338162539},
    {-0.3684863167539685, -0.08349574307042597, -0.4466867297827104, -0.7018069595788488, 0.30144706690212925, -0.09340980439790839, -0.28548875792728456, -0.3385561090434501, -0.9233563151252521, 0.05176646540761804, -0.33978095010172515, 0.13039943505736426, -0.5690035651219355, -0.522631338092918, -0.5079030276771226, -1.1239897009868653},
    {-0.46979627817419445, -0.16805419144532982, -0.15443559930675135, -0.2690379908382778, -0.391560692632356, -0.6922370779405824, -0.13550269677695798, -0.6845838017626232, -0.3781637690105664, -0.09279520300837024, 0.1581195130701673, -0.05583871442159792, -0.0406904089420192, -0.7151611531884325, -0.47818175616970965, -0.4713912056855017},
    {0.0968210185983922, 0.00922082991294779, 0.03711873698957836, 0.07257095256771844, 0.23121236284202742, 0.1090171706725106, -0.3450380464699861, -0.3306604590114189, -0.3228296518936019, 0.07627259834615367, 0.20773530350868258, 0.21139833246000816, 0.09223193532331062, 0.2932589817656244, 0.37197698948544566, -0.20055669060518555},
    {0.03599502806663502, -0.058767765861758456, -0.16768058473616268, -0.03168320768095258, -0.5337199801481208, 0.37715716359597184, 0.047634255706178956, -0.07875018142869082, -0.7176390492861948, 0.26087767890949287, 0.2358016842348782, 0.026400236921159007, 0.26455453325284267, -0.3757402514375301, -0.2281391783181518, -0.020816180335429955},
    {0.0904841424556431, 0.02809446843277368, 0.1569353140615019, 0.3383077421232681, 0.25398849479901875, -0.6502336053550531, -0.04832383521125272, 0.23801053060715877, -0.06757857119197304, 0.589993484792171, -0.7668223226143744, 0.045156679803247446, -0.33983726768413464, -0.04657173459636805, -0.8556244405015065, -0.6650486963805896},
    {-0.28355405292956953, 0.17843145882268777, 0.06380830377250905, 0.6029420781695058, -0.18536403487603573, 0.3106316135355608, 0.2544650252238577, 0.3429332947859612, -0.1456949009183941, -0.25627729040321184, 0.12523606356177933, 0.18464853311325963, 0.061540776741488744, -0.10617159285180809, 0.3116757599050456, -0.12600823445507667},
    {-0.2541402467600403, 0.2098259678702688, 0.11299974785030532, 0.42880291958232336, 0.21744345063696616, 0.2966927684743933, 0.04284096926241161, -0.17784249030023833, 0.12711903885285206, 0.7307159242238686, 0.08809313284990637, 0.04787462480697909, 0.04952134676826192, 0.13381859866437135, -0.05633995075767272, 0.31714291088355395},
    {0.008164465438782477, -0.07431912929271396, 0.19695696450240488, 0.056968460141352865, -0.26615816082160215, 0.2143434022808649, -0.27138909699647157, 0.4466058634100555, 0.22171942509598724, -0.17659085928842844, 0.36190927689554947, -0.13365916339559444, 0.014215172470918252, 0.21813634089321587, 0.3181413970618347, 0.4300264220400604},
    {-0.02684879317622225, -0.24578328988977563, 0.03548164003432054, 0.11385332226832497, -0.4924269191301042, 0.36696211260825484, -0.41933697426852484, 0.009073087353737984, -0.3829908260303717, -0.04045527913994107, 0.2091944962262936, -0.1128517185921947, 0.0589791179535387, 0.021751369031264775, 0.22018963257045557, 0.0033288410001392106},
    {-0.038850642606968085, 0.29986409446537765, 0.19156635422310936, 0.36314181537647205, 0.4658629331173523, -0.25024635755619146, 0.2404311714349313, -0.052534049882359046, -0.25767283184471806, 0.648282259173287, 0.04172419157070548, 0.1502462328115918, -0.5114773945189357, -0.1515014941543518, -0.4970807079070476, -0.3816742211888183},
    {0.17981844547037165, -0.1037844945521791, 0.6125339624388549, 0.6244013032389748, -0.23981371916603453, 0.5229591228870172, 0.015323320608401985, 0.42044587523434385, 0.3066324400796531, -0.05972227447059737, 0.6726607258843973, 0.1992969085038811, 0.2514791762507526, 0.5542627736151085, 0.4858393680394042, 0.1489713636925644},
    {-0.022799737671729204, -0.22621142485684068, 0.24516567823752536, -0.13334508711308324, -0.02163342389243252, -0.18800783977915808, 0.27982349875222257, 0.3461198188134297, 0.054560207336602114, 0.20530683125892862, 0.560270869801868, -0.5204893078389368, -0.17536218155691247, -0.1611903293383165, -0.05507300144134822, 0.11981726615774582},
    {-0.1594946325833969, 0.09043586182720854, 0.3127568028532039, 0.21164053525938137, -0.18418689830754642, 0.6290125122015129, 0.006849223573657025, 0.000483659759536775, 0.0777663144775844, 0.002171491343059778, 0.5238828663559816, -0.12401482613020823, 0.22932480862885146, 0.31597666053187423, 0.18230499939612527, -0.0007250383219269664},
    {-0.07890592525809258, 0.2845151794144794, -0.5138268101612585, -0.7100205653319523, -0.15785806033105493, -1.0445014298572208, -0.2568042192538624, -0.1965109929846609, -0.48734972699297024, -0.32528149633497316, -0.2563084831086898, -0.2386756703321755, -0.44876934951296926, -0.9165405471805058, -0.7075481272418547, -0.3905774090376813}
};

static const float b1[16] = {1.6132501090450178, 1.2298919761941887, 2.531216644476092, 2.256855432337564, 1.3825070012520837, 2.3012518091919434, 1.4148437557014737, 2.4005408810447397, 2.257398429330029, 1.6260213507815935, 1.9497418564523772, 1.9595078457489308, 2.298693221335602, 1.4093814267981817, 2.2952096709850887, 2.123746365792232};

static const float w2[16][12] = {
    {-0.8904540264166311, -0.7975120805106021, -1.436300475493939, -2.044524682772681, -0.32385022219247883, -0.043549104578408854, -0.11600110488159565, -1.2445653201483005, -0.885780816783712, -1.853317129430983, -1.2881656733860667, -0.5939231168044884},
    {0.20383956367952522, -2.6360800847903456, -2.1779318770944034, -0.09120584701056549, -0.10058751310232919, -0.5849867251603736, -1.0839503393922425, 0.925818288942096, -1.3116971280301633, -0.7045202059063702, -1.2254920323262692, -1.7197163134302733},
    {-1.9013868486504857, -0.7006412333279697, -2.174574923975908, -1.3731321464734962, -1.357794665549494, -1.4444164773607904, -1.9512025407530398, -0.5547436721093607, -1.7391711651586368, 0.031793334999126614, -0.3932202243448993, -1.795993728626469},
    {-1.3471619792811287, -1.6154825659102259, -1.0042245574570063, -1.3985734621924828, -1.812456914519618, -1.9018882968825699, -0.8193725737935549, -1.2536573984535377, -1.3688225053782013, -1.8849556346598306, -0.7057325513200475, -0.9739955884602156},
    {-1.1775395301379346, -1.0100386427342276, -0.5180807995317935, -1.8433835002323204, -0.8600835031034526, -0.7607169474768305, -0.1433962277159219, -1.9338769971979335, -1.5968398585224457, 0.11201407408718823, -1.417557094146403, -0.8462275977852697},
    {-0.3338209878681165, -0.7967807883296532, -0.9398095567745206, -1.6042821398993616, -1.562847934278093, -1.668291229645091, -1.6779504247478654, -1.6966861320479782, -1.386191375084527, -0.9134508392925776, -1.1505121013370199, -1.2366899805833949},
    {-0.9870222045812114, -0.4674786908801972, -0.23009241335473177, -1.3878114433175677, -0.42476763494337627, -2.268567315623459, -1.2068974921190925, -1.1788690000759852, -0.7050834214728556, -0.7049569954208206, -1.0969407309606756, -1.050135399369593},
    {-2.0992512060227835, -2.0455791505167533, -2.2341799846124863, -0.16405025162446762, -1.2579034916797582, -1.5196630870303638, -1.9850530979806194, -1.3821686554029804, -1.599628752065169, -1.7379487201954775, -0.9852989363039834, -0.3663832847959455},
    {-0.39512712478323464, -1.755306425381466, -0.8640511653294446, -0.9811120884583584, -0.9207496001781249, -1.849281470749065, -1.5605540762014531, -1.3467325157063805, -1.6941335248200329, -1.5716787307395974, -0.7234138572217386, -0.8264870993995748},
    {-1.289891389264532, -0.7023600387642498, -0.567906869223246, -0.3252709471179466, -0.7353018430626319, -1.1544878535526641, -1.1331694215145183, -1.7864561313278051, -0.31622311135627634, -2.1888020152325374, -0.3603795177878945, -0.3648518186852681},
    {-1.4403083033226547, -1.9658018348375161, -0.9799098841803167, -2.2295488609990555, -1.3129621329878158, -0.1275113670477921, -1.0143340604623297, -0.9600259029175802, -0.04234900548009461, -1.1993032788867504, -1.2503290144869368, -1.2282840914755477},
    {-0.10659599485296258, -0.10564005275373936, -2.2874106147215834, -1.084864653249168, -1.8280746684068088, 0.10159413842940261, -1.6795808383887763, -1.5685059314353467, -1.1831186261859914, -1.8111620590075288, -1.7515149691732788, -1.3356579927764196},
    {-2.0669735272522622, -1.7066888423296147, -1.6220036495490024, -0.8012025805689664, 0.5696286707869708, -1.2079819634743754, -1.4896700943046217, -1.574677914772825, -2.008080404087917, -0.8263009227657159, -0.6968568101228209, -2.2356244234877756},
    {-1.9209613822319573, -0.7935165937705373, -1.6750716031847628, -0.8774465026380316, -0.7195131349739321, -0.9607177457221839, -0.9156808162402869, -1.256056095730127, 0.04098627997258625, -1.2731601375534927, -2.073366832727453, -1.9859227646085211},
    {-2.4167075688702417, -0.38605190114347415, -0.11887300207621919, -1.342990811887782, -1.7606397097828774, -0.5405802696908701, -1.0104083881650203, -1.4321162426802336, -1.3225042248631884, -1.9669026431097973, -1.1170886083948297, -1.8500967135284159},
    {-0.8937645452169047, -2.1714431024962453, -1.3090268947964676, -1.2045445660446985, -2.1040175527219276, -1.642142334131386, -0.48886934262527987, -0.6201261432644264, -1.8497328268570044, -0.7764394945504607, -2.7598238343511965, -0.19824169647221296}
};

static const float b2[12] = {-0.7994064260068334, -0.618911947677844, -1.1676872510566882, -0.9044405821251958, -0.6338423176510724, -0.6496535793948773, -0.6853454560014164, -1.1209901857786928, -0.7782780856748782, -0.5281489060072355, -0.24868472742561726, -0.4496329229223104};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
