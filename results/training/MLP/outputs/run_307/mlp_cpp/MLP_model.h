#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-2.8812538413695736, 3.8197276268204425, -2.723787230865, -3.336599109994215, -3.1340215379405496, -1.5036588790876153, -3.046688644860736, -3.5528142600468895, -3.5743987397417953, -0.8990861384338321, -4.929064672766767, 6.155570832623683, -3.389497326093127, -3.4622637679487194, -2.5673995805664838, 4.588408863372564},
    {-4.563902744903144, 2.444819958372874, -4.788478164405368, -5.621902466815689, -3.2403966298142417, 0.6031232970445299, -2.2920175662405167, -2.4210744762881427, -3.8897189308322693, -0.9538029866106819, -3.7986523731312793, 4.130466327527408, -3.1146867132715124, -2.8077818558817778, -0.7749099521027576, 3.0270190793902176},
    {-6.133976958630912, 5.595646695351267, -5.233602224285415, -4.853027988103246, -3.9719232188769604, -2.1594238575579303, -4.704630323635118, -4.150545319218709, -4.722955928379979, -2.1601084072827264, -5.541048716786831, 6.334543294752779, -4.0296824854379105, -4.059880730224183, -3.729857405544604, 4.3614978220428},
    {-6.53047208973858, 4.335108100909835, -6.682529258360153, -6.554994965150353, -6.285685917615583, -4.014578759809975, -6.335474343348229, -6.159357869671273, -5.755833541700185, -3.7659552074697302, -7.130692557957762, 5.857790082346205, -5.531722978492706, -6.076207700110842, -5.568343551127263, 5.316022553114989},
    {-5.578744880892378, 3.8040644057216775, -6.890872658276823, -3.855950665485551, -5.89995423769973, -3.4988033280801933, -6.733697028798965, -6.8938018002366945, -6.2460891400045595, -5.557556593986576, -6.719452498895777, 4.771873806059401, -7.519670698556211, -5.858462238598166, -5.451100792700883, 5.278634038700383},
    {-6.127864362239197, 3.1204278416131794, -6.307402884564692, -3.615801881736004, -5.298952858499358, -4.075044147165097, -5.108056830677474, -6.1063224855317815, -6.375344897364585, -3.9910440161903824, -6.297204288550605, 2.1129576005846467, -6.987977657616156, -5.40997705299566, -4.621688595705939, 1.7506425671432602},
    {-5.763877688131787, 0.1397245725364558, -5.872232913569535, -4.047553784229671, -6.898708642120716, -3.6848484802520516, -5.340449718427023, -6.104420118507668, -4.759029955926299, -4.739401073285164, -6.103440117781665, 0.23265451867140138, -7.13819526029358, -4.859145944081246, -5.719864616742611, 1.6945620607044856},
    {-6.2707096195634335, 2.319149580587838, -6.110521397397632, -4.980946440929251, -6.878662093358481, -4.607996455293039, -6.197710577298253, -6.813309273063042, -6.380922706199773, -6.199215112607168, -7.13903154650584, 1.184825507550361, -7.014337847801859, -6.95201630033402, -5.452271008828926, 2.236449821967139},
    {-6.128447461994902, 1.3917886304363665, -6.642444502571681, -6.230919384011114, -7.40345937552601, -3.4864346917885105, -5.237082431673928, -7.227577199753963, -7.413353441975606, -4.93063685491716, -7.175914538599031, 3.890704248541316, -7.434218503294788, -7.1742378496918855, -6.0259146706220506, 4.451712673414801},
    {-5.91351933467167, 2.15732008424557, -6.065573203010504, -6.318088943139482, -5.520957228961715, -2.740097840514076, -5.047063074869974, -6.334656316473406, -5.371704300760113, -4.423742026161458, -6.065456770227114, 2.689228512601844, -6.37431173496567, -6.48529286163639, -5.668583405582262, 4.52072464523511},
    {-6.2833704413983575, 1.5630234683104738, -5.704226247857736, -6.607261222131053, -4.809709149972718, -2.7665939759973317, -5.680783613431516, -5.356078621032679, -4.516179432470987, -3.1847065288521694, -5.046862446431771, 2.5742940280195095, -5.479526118012853, -6.417281095791013, -4.61584254793697, 2.6962802773537695},
    {-7.084253774763495, 1.414466066075528, -6.019554982143499, -6.720658884210854, -6.102818211492938, -3.202112948781038, -5.1556902517006655, -6.884252768067703, -6.738323358541378, -4.288691094822553, -6.430133830836183, 1.2671024252200411, -6.78112325737279, -5.718689389089786, -4.930185380977857, 4.851958039023945},
    {-6.213143250872676, 1.8516316227667733, -6.445442842825138, -6.886050501639089, -5.690306330765783, -4.079979176490534, -5.81118916421247, -6.4452096190551735, -5.427803604365546, -4.905425146384456, -5.575698692209497, 2.1500223901146773, -6.928627677666781, -6.092809253322951, -5.644130727026843, 4.898514863683767},
    {-7.809554241613889, 1.559320890575672, -6.019149078245553, -6.098661494182467, -7.447525896801831, -3.1572740842979496, -6.105366952921802, -7.6723464425975925, -6.659104791158355, -5.570776891936524, -5.674733772849228, 2.80351082908949, -5.87117790775498, -6.326787888240403, -6.132680274397267, 3.340125837448132},
    {-6.688335665501376, 2.9258637312165714, -6.438428974021531, -6.77240301613739, -6.419095253623517, -2.925730893614109, -6.071130403791923, -5.835575830099009, -6.078228647841811, -4.41019285397888, -6.295739606767507, 3.4490364085819563, -6.4130909432064405, -6.522107679426267, -4.807684869793253, 3.5430289996422655},
    {-6.060100501308766, 2.318585938302513, -6.686146720883814, -6.190270909538605, -6.134519434982679, -3.6080087917151875, -5.651033010791278, -6.660775763525135, -5.337109660542321, -5.192024384422638, -7.540721032213196, 3.335279326109433, -5.847602585920836, -5.447914554971475, -6.449425667851863, 3.1515846895053867},
    {-7.242971761676952, 5.276011053251454, -6.60092843638179, -5.039644478665241, -6.323283381037294, -1.8226356273426472, -3.9604468237504893, -6.254333743759943, -5.681330004289046, -3.3320126431274506, -6.8110350937196085, 5.882877100931043, -5.152444668337692, -5.7691690538007325, -5.852507155609007, 4.642884576261892},
    {-5.7452102085547745, 5.2702165901935185, -5.401239488667635, -5.526394776667601, -4.435741955234074, -2.219233946882003, -3.1559342230216076, -6.068980693304163, -4.8819230134637115, -2.07126836696348, -5.046242962621887, 7.427199753890864, -3.989970449229376, -4.835260815582277, -4.194461542519391, 6.27977546043986},
    {-5.311338670993683, 5.024517717999485, -5.915623450565987, -5.348489385558206, -6.593555293499165, -2.4445826470593746, -4.7400310048582295, -6.402128909386937, -5.40800801921001, -2.966308466532343, -5.735869173016763, 6.988327886322244, -4.102558163515201, -5.816295179871797, -3.975924808164884, 6.235910304542983},
    {-6.0213572016351815, 5.428827860116215, -7.14696338278116, -5.669433976148584, -6.632788501620902, -3.258800411786929, -5.539177933364732, -7.046953172681671, -6.103743709696104, -3.0494650929558103, -5.638166206302555, 5.792257202837821, -6.273002104105231, -6.458058971722752, -4.372650886112171, 5.597616013935293},
    {-6.517333794752648, 3.955939907953681, -6.94446337159725, -6.988674095032088, -4.841243170483139, -2.7240363404572028, -4.040078724466155, -6.08621918367536, -5.080231796218168, -3.5904301494843778, -6.134595769330987, 5.525239078681571, -4.826376863324203, -6.389713032503701, -4.047922508161143, 6.982537526840535},
    {-6.486135541818831, 6.26555720073465, -5.374135049400133, -6.818851536523389, -4.92800150821106, -1.8961132756859727, -3.7823622264184245, -4.326844683739652, -5.280780907215375, -2.174055026144754, -5.88524097467721, 6.872913832108387, -4.527589824445693, -4.832700346372096, -3.379512211959207, 7.354055566818859},
    {-4.8337613240242545, 6.285895574211443, -5.313315559762274, -4.215670214987591, -4.208731984815492, -1.8245940827153362, -2.7812496566957465, -4.164460219713443, -5.631439306440092, -2.467115162049325, -5.745611037081148, 7.43307424874254, -3.7528531640535983, -5.769256286642346, -2.673271683850145, 7.803429153309572},
    {-6.367134449836649, 5.281375558506773, -5.519617812121471, -6.549506536711269, -4.221406312497896, -2.1660842169845154, -4.3228521927783286, -4.875496173479352, -4.545622993512896, -2.294461348612097, -5.629192182785068, 7.294264650389095, -4.363915006704425, -5.797360977153231, -3.776005800705704, 6.946918222296641},
    {-6.517628089329562, 4.897906018877228, -4.724376913816668, -5.739463403079895, -5.062037560245012, -2.2050154847515087, -3.8473524302708184, -4.185653204533776, -5.742650132531433, -2.239409219777911, -6.517452099876584, 5.131062772749916, -5.1368524339638535, -4.860352724738481, -3.901570064111539, 5.140282960514219},
    {-5.96182287741736, 5.010369728590123, -6.533821648348588, -7.149575032130305, -5.940640875781364, -1.6215092235516513, -3.750754261939864, -5.448821221726206, -5.975172423314664, -2.5849338270803424, -5.88849276679748, 5.810217090124386, -4.252512880938904, -6.717063685916739, -3.245409400346735, 6.3548832077687045},
    {-6.099201144074536, 5.16467864870807, -6.2215352585402774, -6.465474363674382, -5.078570742356534, -1.4338045987141448, -4.517927141599691, -5.933864624157288, -5.8708917351996055, -3.3323073293308028, -6.398628496348153, 6.978975614348742, -5.599538958425702, -6.578541744191567, -3.1717771037869893, 6.6979344289223945},
    {-5.937706484466471, 6.410196471484176, -5.788605575910194, -5.728238182914361, -6.217500949843284, -2.7036951135215044, -5.000677766847727, -4.807187618583925, -4.777391405943549, -3.487378061066577, -6.742033129220908, 6.399019966379303, -5.7378894905110585, -6.913075690326973, -4.539873553757705, 6.097729788721023},
    {-5.51780044832146, 4.879453521883442, -4.555083253703245, -7.233987691667404, -5.067084734219465, -0.0943055325120271, -4.029056814841001, -3.9795089068093, -5.431784203781854, -2.5382429460041283, -4.959003114354935, 6.360893821197535, -3.260329370090531, -6.191660096853281, -2.5843858094999588, 5.413120675261006},
    {-5.412991144217911, 4.417730553116162, -5.580580205477521, -6.332073657867155, -4.606990931648659, -1.321502436695354, -2.3283838005728845, -4.051414512550307, -5.867813256686504, -0.9729061073699278, -4.998871599102993, 6.4687142963951985, -3.4806194690522037, -5.525291842617845, -2.034705850722368, 5.482493389146784},
    {-3.1568222543746285, 0.24808080483532602, -2.629782852789956, -3.7479099411491292, -3.976570808516491, -3.291744154591616, -3.252672426909138, -3.252121373416783, -1.442340887053392, -1.4406042536636774, -1.056535679917636, -1.0580174086199765, -3.7047985215555657, -1.330276684804072, -3.885989543552152, -1.351378686517793},
    {-5.388579694227277, 1.3208799837569591, -3.294526304771427, -4.99226289589927, -4.214402574406071, -2.615096443703831, -3.7089955566132913, -4.827161320813328, -3.0275373578130305, -2.882335458429871, -4.70935760330019, 2.5163215439845676, -5.583023753412633, -4.4947464257845136, -3.7008734277582604, 0.7091694147639509},
    {-3.4441683621813213, 0.13257358674367348, -3.2658357826444617, -1.632471976748548, -5.15328282434014, -3.4914545406336845, -4.281280642375481, -4.385535344974843, -3.108259308093928, -3.015034449972641, -2.4823427487555354, 0.2939679149415702, -3.5848652483678016, -3.215216171658023, -4.546259279234293, 0.3654274706017193},
    {-1.372584422289013, 0.9119954609337467, -2.412636147640453, -1.7234295131406687, -2.544044355012773, -2.695423506605877, -2.8600011216086196, -1.0409628088324194, -2.4627727628689366, -1.679046490996008, -1.6309806690457782, 0.42795332697049243, -0.8756070595877704, -2.5512647740098697, -1.346064137283835, 1.002344613589081},
    {-3.7148540753726635, 2.598596082715094, -2.4659896673054478, -4.072967303388501, -3.890983762623113, -1.482192497691356, -2.7048126472121865, -3.521781294477755, -2.1689063008473735, -1.704828069864139, -2.8429649256576677, 2.4396130396823525, -3.3524220950013164, -3.935465102893931, -3.6292714434473665, 2.80950419608762},
    {-2.217332383992019, 0.3715117845858811, -3.5532969807306896, -0.9521827506787753, -2.959181154514932, -3.2992393621819316, -2.652903313552468, -2.480602495994375, -2.1886544752335544, -2.36134995585431, -2.958473446933114, 1.0013984029524257, -2.913456923573295, -2.3531356610001737, -2.7452337763874923, 0.6686264432572301},
    {-2.7790788228011927, -0.33932807751521804, -2.775059197924818, -2.481551212016775, -2.5097382559525903, -1.8641063786518512, -4.158171299916838, -1.8380371717791473, -2.1043625506768926, -1.0890673785671574, -2.020585314178561, 0.2623373057712492, -3.869620144965499, -4.350513900397934, -1.6757667289517952, 1.340392774715532},
    {-4.304216994394916, 1.3051284202189233, -3.3203462011145257, -2.57273196975528, -4.085703967026696, -3.4753870721510656, -2.7367278344394577, -4.337169545096132, -3.4196071668387105, -1.3082141517507913, -2.911976815343565, 1.434839272634016, -4.372395279325233, -3.8913476968055583, -3.626679619967478, 1.6428474946768767},
    {-4.293047672170455, 0.9576169769373778, -3.408194236691771, -2.3183926953592104, -4.890985908922352, -3.8657166795524223, -4.005889613035956, -3.589840150033056, -2.9843477190879804, -3.640486179647475, -3.1295199687651776, 0.7712242427326871, -3.958230553388719, -4.591765525813607, -3.66872545339451, 1.4862447781202013},
    {-5.823898688863838, 1.5475524629302353, -5.0491781112975085, -3.752038534489426, -4.740388207357898, -3.731941775149264, -3.8712715959426065, -4.7679532784050105, -4.827412133194123, -2.6012854036989155, -4.982111809377678, 1.675971601072001, -5.018601936317519, -4.936766629432065, -4.085918843793559, 1.915097953148116},
    {-4.701796906979244, 0.7462178378362764, -3.913086956766597, -2.7529524726175167, -4.475898601275788, -2.8015326895001156, -3.4189396902651508, -2.9784807191660705, -2.9195533231438615, -3.788613354903939, -3.5779546016756343, 0.8522950265118524, -3.547644348723231, -3.2054169800473855, -3.8031086362770585, 0.4691730188063047},
    {-3.05757007944851, 0.5664396373433758, -4.19908538266195, -1.934998470540269, -3.685029907806745, -3.2003635922216858, -3.5618976199727466, -3.313763448256783, -3.411934042167681, -2.565473870315029, -2.189495846021537, 0.46567175270357675, -4.7695614355137295, -4.0029144788528805, -4.418556689106199, 0.30462839637995176},
    {-5.76057159141567, 0.6337364610141917, -6.024271190729367, -3.846926322276578, -5.348257859116235, -4.07767300178997, -5.758430899086476, -5.154107956247289, -3.653840093800701, -4.269153433332002, -4.115885774574753, 0.39142095065194205, -4.569454286328165, -6.287930067740607, -4.867197562813428, -0.9920049875528446},
    {-4.567126456871085, -0.6077944153325836, -5.235528147860653, -2.797686856123138, -6.069305019885043, -4.666334482973125, -5.726901473181458, -4.483967123511235, -4.541178367193192, -4.070119397293664, -4.549558024120094, -0.9753499735207892, -4.979394047231142, -5.5444757594336425, -4.67639289089686, -0.3733017745026343},
    {-5.855678358449282, -0.1566647481595373, -4.39964230261528, -2.3638902405806235, -5.3428807099424915, -5.63952834145508, -4.841413172478322, -5.209310787329974, -3.7865816069211253, -3.6170301268553837, -3.303673987272678, -0.18602273964845936, -6.105771275456922, -4.090774099389414, -4.990788094140771, 1.4007787898050792},
    {-3.8769868721623837, -0.6524968407219409, -3.855821508540939, -2.0929592882466297, -3.7734962661429754, -3.7117309151441624, -4.849120524614747, -4.9655258273667515, -4.023275414014038, -2.862579388031681, -3.6503668483889067, 0.07387595904651165, -4.672704538509781, -4.460179901607006, -3.994114720054177, -0.31121521999774787},
    {-3.783710253924603, 0.4272408492606554, -5.04852503756937, -1.5462932367375974, -4.338429335797664, -5.051400644940453, -3.59346885850606, -3.103582527871443, -2.5270901799106364, -3.072386163138318, -3.755951127107282, 0.5127511239453041, -3.942240772513692, -4.306209795239818, -3.9692784291603305, 1.5791804758558403},
    {-4.043860134678844, -0.3704497230251286, -3.8245913081507434, -1.7473573201537635, -4.052583835517558, -5.443402824815886, -3.1250294067198583, -3.2645968794155857, -3.521064255411656, -4.225173501455515, -2.920578322805066, 0.6569103246785369, -4.576328866705707, -4.717764539052466, -3.877540159359933, 0.43089375703181},
    {-3.9532054426266914, 0.5243403128735178, -2.6133599575482056, -1.917423207241689, -5.061930089242541, -4.044172649705282, -4.58197901663629, -3.7049686735131844, -3.620840814099015, -3.421695764268672, -1.9782956357838593, 1.1781548603891665, -4.655062021136131, -3.4616463729955123, -4.419868703436159, 1.1020807426883108},
    {-5.235428969133004, -0.23962361759779688, -4.474085619839334, -1.6935176892874297, -5.733759194925279, -5.032572187339132, -4.671936120864824, -5.498904025818509, -3.6172759439141084, -3.9113423752818055, -3.1559742117310505, -0.980466119560779, -4.998872023139787, -4.582643016647125, -4.376297176697878, -1.0488859609288166},
    {-4.979838016941619, 0.8161815286144541, -6.450946575493397, -4.337966986647683, -6.405987113277446, -4.726425606957995, -5.684028470145969, -4.743598073586084, -4.558683387401974, -4.69782067341535, -4.587958366334234, -0.3150915967120782, -4.633916018850853, -5.39296645072372, -4.954664252658184, 0.8565155957656507},
    {-6.610716377619146, 1.1058801348616163, -6.362979043418141, -2.380647562089768, -5.2715250864427725, -6.06221735371709, -5.264811896320738, -6.199876777578737, -4.908475742284779, -3.675833997988175, -5.629007806927413, 1.295378605932241, -5.628614506571881, -4.90937887007319, -5.442742974235411, 1.2755428810933551},
    {-6.2301821662187455, 0.7463020715409339, -4.9995602403171, -2.2777860752865617, -5.712951415490415, -7.0778575603085665, -6.002924873129602, -6.421297313865982, -4.146953409105064, -4.921280633250473, -4.1339033429856995, 1.8539020841073508, -6.612461646391791, -3.6609975315999352, -5.7672819754044236, 0.6990471047747521},
    {-6.0514257869936445, 0.358979244532062, -5.089715864301705, -1.7356691001852607, -6.11162386438923, -7.22629835364626, -6.6861293613836565, -6.515173686305077, -4.6697857724279865, -5.63798499516174, -4.756046221002598, 0.10981355225579686, -6.510036183430786, -5.258176621154389, -7.037213756804429, -0.500294572646951},
    {-6.5088340338560835, 0.8869131377018984, -5.237978179345397, -3.4728864430839135, -5.549503342794168, -5.905976452402732, -7.025568805187396, -6.3099017188084385, -4.999706584404139, -5.994462374146811, -5.160505547404058, -0.8588946404906693, -5.99935281476568, -5.542734402911542, -7.128465877574418, -0.911107962712287},
    {-4.169018221032455, 0.6418215080287181, -5.379220057020963, -1.088452680312905, -6.131418969733064, -5.252768764406409, -5.314678304066817, -6.447700937082831, -4.485721605339147, -3.785327246886011, -3.6330548240564027, 0.18552879667726804, -6.273325856830504, -4.436412367667337, -5.863171355304877, 1.1848502371761496},
    {-6.571165167764053, -0.49305224528625635, -6.229210001232623, -2.590317381034482, -7.3600859754920585, -5.971801629587282, -6.078525731749628, -6.623323060942619, -4.111647596161318, -5.002959910842528, -4.268967998999973, 0.19720486251803362, -6.60784387985485, -5.450680664916624, -5.510304707304473, -0.22051875576680502},
    {-6.907563118925569, -0.5018611323970846, -5.4581598992625535, -4.182071458762231, -7.658582325168661, -6.674694400192112, -7.275721557325234, -5.792387308493565, -5.369164845462202, -6.0656598408123905, -4.971782514540475, 0.16942207364635675, -5.90490229434729, -7.133375634075925, -5.291200775775581, -0.37936299200914037},
    {-5.402661307889829, 1.0881122578534574, -5.996086838033042, -1.5181543808281128, -6.843768251886728, -6.525617468801945, -7.114565937066054, -5.5493816297081064, -4.320972149723947, -4.630324743221156, -4.407676711309781, 1.2836851291019824, -6.977832094751724, -5.085602515402737, -6.07810685685676, 0.45689354516855024},
    {-6.763850097044638, 0.850279918330148, -6.3851663975197255, -3.5070371399151745, -7.126223492542056, -7.59379018712386, -4.882466985345878, -6.477315634593424, -5.424119120591821, -5.869061406615423, -5.462526105381267, 0.03250319490083702, -7.436304335996234, -6.0879729210454645, -6.138983179218369, -1.1451729917395443},
    {2.755825650209474, -4.504815353043563, 2.2341997955127884, -0.3071295167490419, 2.0415683783681433, 0.5670997345496505, 2.3176061653644826, 0.5026215679613019, -1.5530579995925655, 1.756007174455507, 0.8117129877204623, -3.2718985928402358, 1.0808932848372719, 2.3618333927849253, -0.7290296285610176, -0.4596651695821245},
    {1.5649034286390937, -2.619836335340262, 0.6042653143301769, -0.7558235862047005, 1.794708135639176, 1.5573548841882974, 0.8151426975890661, 0.2544084916045714, -0.849708590130423, 2.1215410087883155, 0.58185848622782, -2.4054957969111634, 1.590824010477602, 2.1335524429870443, 0.09532379490654641, -1.033285495824353},
    {1.9818766152186826, -3.729875040780854, 1.6267692418012896, 1.2188509391752478, 3.149536735911512, 1.9509690002155524, 1.4024433884705145, 1.5241465608179856, -1.4427929729132536, 2.8381860436493214, 1.1471883789761532, -2.4151014387831204, 1.5242056809503983, 3.1088528626770078, 0.8337243719748058, 0.7509547943740712},
    {1.0373120733094883, -3.4491402456844718, 0.4596500681691748, 0.7538685485313621, 1.8002045293388191, 1.5837577840668038, 2.3587322778700504, 0.6337461781214669, -1.632548712655884, 3.1723631554461464, 1.5188043521575316, -2.7236067645979354, 2.2023112103397953, 2.0939410361316444, 0.29171108527965595, 0.13551293645338164},
    {1.2281646809016853, -2.5352450877007326, 0.9457632172616158, 0.5928498245328445, 1.1651829430796175, 2.0232442465965965, 0.251437163841861, 1.9739580595319752, -1.9294192397508576, 2.200836774461035, 0.8627078027341846, -1.2539477166484425, 0.8574496036752015, 1.8209956385073824, 1.13567522831435, 0.31995110757740636},
    {2.5198896000514464, -4.4759700143358465, 0.02924446287798455, -0.6205072888651495, 2.334531409663154, 0.4772657688934966, 1.890748183464461, 0.3319636516269721, -2.785130551401811, 2.9611182587970704, 1.3363066087425202, -3.79040936471883, 2.131132102097847, 1.6470059322514277, 0.04496364805874409, -0.19166325465098444},
    {2.9014575832704153, -6.0176882862533105, 0.18258868302578707, -1.3736848521796996, 1.5520257258216137, 0.7194823865216324, 1.886131052218927, 0.6929758780676912, -3.3194732255630064, 2.732821813997151, 0.7613454417886775, -2.6264095821675135, 1.2365130942918299, 1.3432994351337861, 0.6805978291148825, -1.132952916462408},
    {1.7871390822226836, -4.449906125600601, 1.0094904861021985, 0.20944807561302783, 2.2395942751622564, 1.4923377289117585, 0.8290910721793717, 1.6253376030495155, -3.188296016561354, 1.6939512778445294, 1.6393075229577763, -3.7001743897169828, 2.408057094352642, 2.510477752711533, 0.6594125501865286, -1.2401553527535898},
    {2.7025668124558453, -5.557486608999445, 1.0779691914400182, 0.15335025224050255, 1.8748943554013868, 0.11327415840046942, 1.5032359031383755, 1.445667775956341, -1.556737335672828, 2.1960727667208486, 0.7186634351457639, -3.5191522646760185, 2.2638666554089504, 2.8124823380307324, 0.1470367188104012, -0.14573013413168556},
    {2.1271380742579433, -4.216246321662624, 1.0438066681075235, 0.9873331938767825, 1.189605653798324, -0.9095698009839953, 1.6034287482989995, 0.7320337448994535, -1.519851941861214, 2.846951088206565, 1.882492771457989, -2.6218075004335324, 1.675132243353203, 3.2640650651684027, 0.5335412925474542, -0.7999936988173914},
    {0.5903394140427652, -4.886728971901383, 1.2116777770035463, 0.045498963233200414, 0.5608921918174583, -0.22199164894736592, 0.9497007138653002, 1.0474652276871883, -2.4558210782296745, 2.983733455492016, 0.6049198103326879, -1.8511612299359879, 0.764453589326005, 2.774390931761489, 0.4906060723368729, 1.3697300931386136},
    {3.1688334282743837, -5.054710915721399, 1.823955875266085, -0.3416034520327796, 2.826399707810225, 0.6310034779920213, 2.3844401775075226, 1.2394439626403069, -2.714264015852065, 3.7066701686856134, 1.6832736835778985, -3.058375714198437, 2.376332532449729, 3.438975790982456, 1.0868529072019335, -0.009081172253981133},
    {3.9059150229399835, -5.35918191946593, 1.230277383871841, -0.3267461733533143, 1.813985623941733, 0.02643790623975063, 1.6048450941967483, 1.9248453096159064, -3.3564834641181034, 2.1262052261749953, 2.8889944644515615, -2.6453278375093507, 2.5457155811826624, 3.674286599771475, -0.22057067054247909, 1.0467792963545135},
    {3.8537486313131804, -4.144407641862962, 1.579254376155111, 0.28557855345276134, 3.0094124465062646, 0.7092285744125646, 1.7361511157231817, 1.7116550362864118, -1.686070793278769, 2.908037109975358, 2.4180958714533967, -2.690990414514119, 1.958097129207689, 2.2644532083831277, -0.9918807864697198, 0.7910833609510761},
    {1.9747218944949934, -3.282543529200625, 1.8386894871815334, 0.8254327444737599, 1.6420522353564062, 0.47753851320170526, 2.303356927405634, 0.34963918830248003, -1.1506678679461209, 2.55158888899842, 0.8493995342609949, -2.3350394959159813, 0.7196051450269779, 3.47743660866033, -0.15736514069576987, 1.1218526497471748},
    {2.0097578265214784, -3.7383622870844646, 1.2485319481683308, 0.9112201247384947, 1.8990211928679277, 1.060633178034983, 3.0757044206360327, 0.9566878379395575, -1.772950567855391, 2.3025969128052632, 1.034870486078497, -2.2921730437949446, 2.36184175703665, 3.226745906235728, 0.18562748916818586, -0.17882968016641337},
    {3.0562045142165633, -3.362457709394214, 2.053427537653919, 0.04081057801308864, 2.5025365550515204, 1.1668851420183008, 1.8129657504130596, 1.1638198364334773, -2.505364093754247, 2.904302035122945, 0.6198426093137706, -0.8525628822963668, 2.0277943651986967, 4.17420762731652, -0.45518461680825867, 0.07715078635078478},
    {2.7929904796869964, -4.795189033620234, 0.8311089195828211, 1.4337726293130528, 2.358688840820047, 0.14887885091069925, 1.88573250032969, 0.4055402743360592, -1.3643643986004976, 3.421740722807167, 1.72597947368844, -3.2153326241715483, 1.8347295688578298, 2.0611326241800243, -0.8248869643208259, -0.5146723064484564},
    {1.8851419380135963, -4.898360125065966, 1.1969727525433318, 0.8209229916006682, 0.8149585077182151, -1.3268731079470915, 1.2267711072684775, 1.4202348003960528, -1.8824736745265345, 1.2703526048417697, 1.0681775654650887, -1.5394853345933828, 1.0308889101938785, 3.0076433155055264, 0.12375623892712206, -0.5674018514712302},
    {3.2968817925775955, -5.103789232203324, 2.2475500855963455, 0.8342617807162318, 2.0962884198332707, 1.276619120675966, 3.4705045982161544, 1.7260203686025235, -2.173757180706326, 2.6864331214949573, 2.610006076071825, -2.4039254732545583, 2.5678328134740904, 3.743039950063496, 0.708239933010668, 0.6541856774979989},
    {4.607358929906648, -3.8247548446456188, 2.1640029512161414, 2.270590264927233, 3.22919910440188, 2.060845520468426, 2.5011089195477236, 2.0736807976236435, -0.48318766213835573, 3.267821980443074, 3.105782979445917, -3.044231242451024, 2.81111201139203, 3.6717203541191483, 0.9759368444075285, 0.5275248252446675},
    {4.319702361485109, -2.611819213789183, 3.2410356340255126, 2.897835519992635, 4.081257367155199, 2.808230523005877, 3.782425364901729, 2.346249533908298, 0.2234721627961232, 4.123814046277418, 3.6075283392473416, -1.4433739404775858, 3.540600940754651, 4.469522348913558, 1.159408474339532, 0.7542190920339051},
    {3.660224575396367, -4.623754513519267, 3.302064981810882, 1.1350593976834291, 2.947136807365512, 1.4283127452078699, 2.921097453729429, 1.6535906052646876, -2.1893375597430977, 3.2297826493032185, 2.2517559043041007, -2.6027036699755155, 1.516697811962803, 3.51434485406686, -0.1890405417808719, 1.503450836343506},
    {4.100851291466539, -4.722545431899385, 2.487816193666088, 0.3775879185648954, 2.6778867375543802, 1.9616466557758863, 4.048940297834812, 1.7449108955532964, -2.8724437039155375, 3.400684933428846, 1.6723982009352736, -1.8549173643235077, 2.4191190382410066, 3.8095489574627006, 1.3264571962293032, 0.7182551804313968},
    {2.1333894597318785, -5.094766959434749, 2.8994763473388496, 0.8639045390554436, 2.118586541086624, 0.3567387286339789, 3.5140847485102253, 1.8499835720189184, -0.7753484279384493, 3.3711333346719754, 0.9848237460972857, -3.124711981573631, 2.742551462211189, 4.192465335882819, 1.1286985704295207, -0.880825349931028},
    {2.1909874553367814, -5.998708260141516, 1.8616636511337428, 0.6779652325575676, 2.3651350371991415, 1.2640924193361818, 2.0492827420132254, 0.9751058605969556, -2.0874562769303964, 3.6555218116525716, 0.5234033539839313, -3.228412374996361, 1.6202984190535255, 3.9533937993637047, -1.0355795448569503, -0.5980977245288495},
    {2.4716034889115117, -4.272050650316623, 3.048731977703783, 2.5586053531763855, 3.911770736802564, 2.5028098718047733, 2.9731968781821547, 2.3003595718442345, -0.8896046673337605, 3.8902525087465993, 2.268058071936032, -2.5504286802352354, 3.1276462048659948, 5.030964068736438, 0.44609978175294795, 0.3869744496892731},
    {3.4241014887878687, -4.55753440487633, 3.05339833750557, 0.5390009798049766, 2.6023577016381707, 1.517509694225041, 3.0138082191497717, 2.5856899954598656, -2.2670067553892035, 3.979842578506444, 2.622838494093662, -3.071286038721694, 2.503514143368988, 4.02291534484015, -0.3853035340706123, 0.3627769764393947},
    {2.264511028922429, -4.299335092639448, 2.3906894549366395, 0.05387872093796807, 2.719140436120167, 0.7765467175031275, 1.9013217807070393, 1.568449660257653, -2.243879231838784, 3.052337841275747, 1.494792228398046, -2.592013164881239, 2.1252754128606757, 3.758392503409822, -0.9032256993851491, 0.6754622238222129},
    {4.7056188494642806, -5.4148053371470075, 3.8362637723623507, 0.9781649401497815, 4.041511208910948, 1.0768863103732755, 3.650974077826069, 3.029932659081463, -1.867459093879114, 4.209534258429443, 2.5308816146602595, -2.6210269409749256, 2.745923223283445, 4.018336785387827, -0.7555475082972698, 0.3588153076823852},
    {-2.48791041663428, 0.5274241581911302, -3.2869226467413903, -3.449620689034706, -4.73529124399276, -5.503807173938554, -3.6247510617394703, -3.6940046083205442, -3.1574938185762753, -3.4326642830067344, -1.6149840945513738, -0.7848175269575015, -3.7590120762689967, -2.1548624055005523, -4.859639524852696, -0.44994700190456705},
    {0.79955248080029, 1.8161317962792225, 1.9171872741146585, 2.2324934094473456, 0.7007375154413089, 0.3520131183093901, -0.44903263903368235, 0.6913372757247771, 1.469192284635955, 1.3817911419189983, 1.038364902396919, 1.9005954777021197, 1.6483093726850349, 0.5294870437650897, 1.6628258949750256, 3.1217963483617104},
    {-3.36391263632442, -0.30062366745978836, -3.267211931269032, -0.7637323417388654, -3.4698252245138206, -4.49193564440855, -3.4277880990965626, -4.163256874364103, -1.7072138818078602, -4.277853008846772, -3.1106771421404664, -1.426560259765512, -4.871259964745525, -3.334330960237103, -3.5036693493972346, -0.1887896561164724},
    {-4.145523893921531, -0.1378626041260307, -2.87264819484707, -2.5901648102875314, -3.846412438889272, -2.864510234575214, -3.8841704425869366, -4.04061355768999, -2.328436600330143, -2.6574099954277552, -2.9021213903792034, -0.8075622965816879, -3.7223911690037945, -3.5803505495513903, -3.600171500037969, -1.3041004278308852},
    {-3.9507043014582512, 1.2395890111975312, -2.8205870857113426, -1.927824888811347, -2.3498401213560585, -1.8054750334988527, -2.3626091288893734, -3.1007772944792165, -3.6719295722729446, -1.9187179432759391, -3.4339080724336752, 1.3903877792295385, -3.992147974665349, -1.914887945380482, -4.300957210253526, 0.9593566443561079},
    {-1.9823578116839244, 1.4919454665991554, -2.1840446174526895, -1.2735320129695875, -1.7103483249014726, -1.2028298868742726, -1.0479651155526784, -2.329849857397799, -2.389750353043641, -0.8700743774618803, -1.9445786696339598, 0.6849214597579822, -1.7773020549839018, -2.787129968896829, -1.6159700281048002, 2.028378346173154},
    {-1.9641969184301897, -0.9203035336196533, -2.899480070827765, -2.3101164202504423, -2.4158413227051816, -2.7089636892186335, -2.673289501289575, -2.2104896384697894, -2.6758479907120662, -2.0104596319600225, -1.7170678592876407, -0.4206168220730197, -1.959839370807086, -2.64784523166341, -3.1391084793717576, -0.1550891574656959},
    {-1.34892422632475, 1.9897938427249888, -2.248964895455136, 0.06097675918187541, -1.7397989349710778, -2.5769077229188078, -1.1559478351064107, -2.756998017762314, -1.1040496494653627, -2.272199837670893, -2.111419802016644, 1.420312672404577, -2.6860704895174656, -1.4477958473532402, -2.2575551055916003, 1.798054005368682},
    {-2.2987833246629283, 0.019232546909756988, -3.498992562471451, -0.49071280019724517, -2.0719838776554966, -2.213284114960047, -2.7886419826200437, -2.0580943793781477, -1.9949119668264195, -1.2056125756283809, -1.3383987948868494, 0.4760281243808837, -3.0738462373031323, -3.727050263573451, -2.967621491682417, 0.9114216255212159},
    {-5.166054902702535, 0.48581916335608477, -3.5773719557510786, -2.3960697358372482, -4.871003406003854, -4.091114282997479, -4.70083160643388, -3.4999016561244, -2.551045313574827, -2.9817900288588426, -2.894726532020761, -0.0185255362132517, -3.8348767418670158, -3.1720394068852085, -4.07299010429094, 0.9040590662939347},
    {-2.8372526978065875, 0.646470280399153, -2.1679106420213903, -1.831324955303653, -2.966694295976254, -2.068498199527259, -3.3157056067931387, -2.186185414617075, -2.195897845372587, -2.3625592731939538, -1.85261207200916, 0.10069175904803816, -3.323972870460932, -2.292294856889694, -1.5072401352259464, 0.7770172954038891},
    {-3.295327702593949, -0.6292771137653584, -3.125539789710351, -1.3381981344933607, -4.3639230136635065, -3.234381345364431, -4.1546877594223455, -3.621117365759053, -3.890438794615919, -3.181209924698602, -1.8001993569278738, 0.1677582544708919, -3.5006287806217857, -3.43378619180685, -4.559924120904446, -1.6787966601161681},
    {-3.5860663742149512, -1.0160384863954715, -4.583719219775682, -3.2729594019794335, -3.8955420894991017, -3.9758232632658537, -4.201304864596887, -4.671877026506186, -3.859898405499475, -4.395015062109426, -3.1597564883322358, -0.46065178429095843, -5.106824981172029, -3.776092394201531, -3.8272958221686455, -0.21796009380718703},
    {-3.2683901775778197, 0.24932133771402878, -2.8327609618068017, -0.9716455663303498, -4.333574769348191, -4.295845594299243, -2.9675949833812667, -3.2073759898088974, -2.3529322030945523, -3.438137697458626, -1.3075430248467033, 0.22149628893726683, -3.978617936585397, -2.0062301958097897, -4.061256887813772, -1.4700602486184655},
    {-3.7401152373137094, 0.4331568147416174, -2.368768201930608, -0.8452709119205879, -4.830064847375615, -3.622337161013862, -3.421027955854476, -4.838679793848651, -2.527662187837934, -3.1344804043793792, -2.9531972970042806, 0.38291993430707616, -5.309893462647917, -2.5448480388887496, -3.4712276465420318, 1.3227226416504136},
    {-3.356217368291894, 0.5896357617265776, -2.0612877117565196, -0.9049226968683468, -2.76090643151096, -3.106714370789418, -3.0956402833328203, -2.5153348871556824, -1.9022221871130867, -3.704896338807263, -2.7578345121169034, -0.9856478689964078, -4.257315922315258, -1.7381359920259092, -3.282494940866014, 0.1912451021617663},
    {-3.071949188729665, -0.5317475388773522, -3.1973604320254116, 0.7710089366401527, -4.141345238117439, -4.9175039535510505, -4.080914689470354, -3.1897853743236757, -2.3291062187721034, -3.5671109834444437, -2.0077821510185885, 0.45535930148959286, -3.1419018605355005, -1.9319456780342823, -3.5954182121251534, 0.03011113408042471},
    {-3.818368758170807, 0.07399674030345371, -3.4168565515843796, -0.5585661942598519, -4.598242401054474, -5.145336484729097, -4.3942416868367244, -4.444673874891781, -2.0904842579965344, -3.1353650355812315, -2.3507646456313704, 0.7782892220060005, -4.291863815196584, -4.103123801887068, -5.8442755111198785, 0.6844875917698583},
    {-3.7022544088019655, -0.5523873968801568, -2.7881955545408466, 1.144213609946725, -4.432663356666474, -4.115611945467226, -2.564725935419385, -2.94760853458162, -1.3600337327653653, -2.900189054827247, -2.662925404411212, 0.08794623498828907, -4.106576967128284, -1.4603420130591938, -3.1735445478622006, 0.1968733311512784},
    {-2.7884351380560415, -1.7745659313651703, -2.828127700414827, -1.0220955951833146, -3.564915785924734, -5.49718819307456, -4.237897633856836, -3.6788946206401065, -1.9066300906422737, -2.7964888745465015, -2.797515401223824, -1.596181975436195, -4.44422354749788, -2.692023627846452, -4.858298377538562, -0.0382536740777695},
    {-3.152838431614095, 0.3716457640192856, -4.546764609597567, -0.9059331896892093, -4.105432222251102, -4.2332467570729735, -3.907547861255818, -2.5046521730813023, -3.6903272604287336, -3.310051439614467, -2.9176240876861756, -0.08231859457047942, -4.595276263097054, -3.4157012908212656, -4.859097270317438, -0.7734868810205243},
    {-4.630372770472279, -0.09473292047698362, -5.12299492151182, -0.8222198846017897, -6.357967443787981, -6.539855793314503, -4.7670478888434396, -5.803254539367872, -2.8908126154077114, -5.106908920025128, -3.5359690549317215, 0.46673037773596604, -4.990243329278093, -2.9822938516282798, -6.95833514318898, -0.16262676024414816},
    {-3.5276518652457383, 0.8487071084857433, -4.470656916383337, 0.786071541437972, -5.785313738986027, -7.054234547502644, -5.558176774432543, -4.041069802712463, -2.907445682490934, -4.528939414647841, -3.285963294987067, -0.21293679585620473, -5.1397974221115605, -2.6039062238887243, -6.270032961677005, -1.2947945179452516},
    {-4.415678030227931, 0.43142947552225624, -4.720498244476196, 0.7511489181625883, -5.283921312313647, -6.399650253154855, -4.374377565835659, -5.769631783600085, -3.8627022372278645, -5.3778544242019315, -3.670054395560042, -1.2110648052375927, -5.878332901969918, -2.7145574091218383, -7.252941212723339, -2.2805660639682186},
    {-5.849518776088678, 0.41746626208304577, -4.694213438216843, -0.7241052664164854, -6.208302116886794, -5.705996163913388, -6.323505081308008, -5.195414119558689, -3.624681129623116, -4.924573682202619, -3.324853996862297, -0.2095103472120629, -6.641199911772361, -4.331614440440345, -6.5943521738042365, -2.411715114701116},
    {-3.3790663203978126, -0.6143269365408548, -3.3506410550077965, -0.20665919719228074, -6.673899472626589, -6.53649770515011, -4.180586224474574, -5.372621313220398, -3.0777808434749225, -4.926090005385335, -2.360096531333647, -1.5545477523808788, -6.60928506810957, -3.310332074867878, -6.7895909177981055, 0.7099547902801701},
    {-4.734023859702232, 0.14292649667068325, -5.046073265875869, -1.5888440238635853, -6.2272298874838965, -7.606974504787107, -6.5137473180096075, -5.510307886056926, -3.661763369692724, -5.146896425202646, -2.6314512333312408, -0.9465453970615613, -6.253936571731627, -4.831529186922024, -7.225411568414273, -1.916149219253018},
    {-5.238594170993063, 0.10879964618653372, -4.808590558891364, -0.9703890903672932, -6.332656455417864, -6.333045460349144, -5.634722665397896, -4.544167872257083, -5.332024634753003, -6.193306036272988, -3.1926926041394217, -2.2061592289746637, -6.368877416355565, -4.244421968162321, -7.294673165528497, -0.9805326481704212},
    {-4.551241427046528, -0.5591934994661677, -5.683354793105782, -1.1865817253512947, -6.095962650377384, -7.5728719470381725, -6.613372267843523, -6.69319562253181, -4.001381142288224, -6.2575195754813935, -4.3418228643026495, -1.6360045385939874, -5.780140698698676, -4.146892487763714, -7.740483876892169, -1.1741920197797457},
    {-4.40568859183013, -1.7403163472077152, -4.816860702895724, -0.399132299945121, -5.8707591689713405, -7.479982694438427, -4.928067330694619, -3.6211747762185866, -3.3147903423822687, -6.169700934368671, -3.2802485348345147, -2.633209049126423, -6.412104860677947, -3.0412310274365235, -7.2017496727733255, -1.086488513755376}
};

static const float b1[16] = {8.065009067102816, 8.060446415474946, 8.008175577602685, 7.783762263507157, 8.109141051068253, 8.310470168815016, 7.92057765785741, 7.707038534327947, 7.702645711257198, 7.601279858895144, 7.387485244943114, 8.102192126330236, 8.03128039018373, 7.897448948559997, 7.924216938408065, 7.8842962275329205};

static const float w2[16][12] = {
    {-5.18645279837386, -4.775835989959299, -5.4710149010831755, -5.022625749183866, -5.272231333886057, -4.205955975511763, -5.089018710482322, -4.898074405236636, -4.851859302899298, -4.0378942629919, -5.319094730666471, -4.868396237952398},
    {-3.9492237361706404, -4.241318226519467, -4.656646901589952, -4.014419451857883, -3.8398550102304165, -3.8201277919300667, -4.729923899144191, -4.739105082740554, -3.710373591409846, -4.3181496332767155, -3.662225439509694, -4.71053059412762},
    {-3.8195198629838085, -3.615666470408186, -4.056068318330661, -5.096560318611311, -4.512523430649898, -5.915171291958022, -5.78313527421597, -5.707756144962782, -4.104844815469502, -5.008655001250664, -4.757681944019467, -5.423539983721533},
    {-4.115520490209635, -4.015575750790718, -4.40039357252283, -3.671616863082586, -4.890316640716241, -3.959545313688182, -5.194516592875162, -3.9236382799668097, -3.453170082437778, -5.203001553832153, -5.191933899470978, -4.749948879151603},
    {-4.850233116274752, -5.589723111603704, -4.878032472561787, -4.704499573386086, -4.5907493525908585, -5.4801911106033625, -4.076178134520272, -5.832094106473539, -6.1347238202285395, -4.890422582987027, -5.711429865249563, -4.157658062585419},
    {-5.406748762298827, -4.914420727727618, -5.005759065095723, -5.244669618171896, -5.458849098322527, -4.8551619315819154, -4.972220623116656, -3.752223045944239, -4.749495297208617, -5.165355463409471, -5.244680641082682, -4.785856433659283},
    {-4.553033055421797, -6.006600143560692, -4.5747216793671726, -3.8924279359695766, -4.631588448266175, -4.9546430583020395, -3.659172853947842, -4.901319426341304, -4.50931818673526, -5.71927749935193, -5.5498602390165335, -6.08053636048387},
    {-5.094315389497299, -5.397590527151719, -5.364684887833693, -4.209246431061374, -3.787789360256735, -4.101108170135516, -5.429348348228149, -4.8298445921941715, -4.71778821346045, -3.903290857087311, -5.498783792636395, -5.023012457066916},
    {-5.201842223219347, -4.344524484042658, -4.952145267980382, -4.611711295734922, -4.459877398567022, -4.292636346492064, -4.312982910359122, -4.064975139345669, -5.28439567199438, -4.381950541128405, -3.9455265865211997, -4.235105763125993},
    {-5.293876973940443, -4.253543957980918, -5.148140825265058, -4.116066514114251, -4.701085807538124, -5.031412681068303, -4.634845483564711, -5.792599488680482, -4.044828228639296, -4.356647701775279, -4.618574709568301, -4.136811693157316},
    {-3.926528133980528, -4.407459377651204, -4.2440052457130335, -5.096829175883869, -4.0528342331226614, -5.106212463604117, -4.328996240922837, -4.63250420478359, -5.2830263151115835, -5.373786060761186, -3.249887902463929, -4.262046782709383},
    {-5.040613699912833, -4.926391287660195, -4.178267725392957, -5.186124963472201, -5.1331730216957965, -5.393835110794735, -3.5642920794465827, -4.907534927682485, -4.742843981966462, -4.417226176862409, -5.470756857980772, -3.9514627732228433},
    {-4.65277459647543, -4.146332907110429, -3.910749366477408, -5.905060664981218, -5.6380527974204115, -4.810178827041972, -5.0067861853498705, -3.9863416852179414, -4.88237676163834, -5.7418897978726156, -4.370556352993316, -5.744488120547884},
    {-5.829625440363106, -5.311679607854725, -5.569632082431617, -5.730596418569196, -5.293615962767957, -4.399977514005766, -5.163321064281041, -4.82050088219892, -5.487138476122999, -4.559764105126739, -3.9966295687518, -4.322962195499307},
    {-4.650235887939643, -5.599029962844738, -5.0267469945481515, -4.780356678939488, -5.281464819504826, -5.263455806325283, -5.424675326573612, -5.511980460713015, -4.902156779378353, -4.4097000155685455, -5.189676081959766, -4.576506857332969},
    {-4.331975587484089, -4.111343414391066, -4.551172803065196, -4.61920769069546, -4.373120147281638, -4.100951122075383, -5.2010036925779595, -3.8006594795115616, -5.1984166279122475, -4.65682450921103, -4.180691495861395, -4.775846617510546}
};

static const float b2[12] = {-5.202829323287205, -5.849094429865218, -4.767102552031844, -4.809908919407611, -4.963511117207004, -4.383049263360178, -4.749980560601435, -5.609212404515584, -3.9981699479174018, -5.072299745407538, -4.525891120336455, -3.809771094883532};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
