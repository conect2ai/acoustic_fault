#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.9696763789714764, 0.11349919056113479, 1.5417568067128224, 0.7676934999094457, 0.8823242018336473, -1.4432817391484445, 0.5209092746403532, -1.5381520351694724, 0.3331523663517414, -1.4015717301140078, -1.4607496848990797, 0.1949204282793186, -0.7537055464526952, 1.5878934899225834, -0.07456987766950006, 0.7028836259560105, 0.2375184519222311, -1.6317156906532158, -0.9303848693065212, -0.9664551232668751, 0.2765467736348371, 0.17752568761773097, -1.6116176556128003, 0.2540510646680506, -0.2933903720838814, -1.1049220893661607, 1.8112921363023087, -0.6223944458969126, 0.8570961670973309, 0.36980351728618127, -0.9239698583856245, 0.10212371879447066},
    {-1.6097367445315915, 0.9897564673358891, 2.603776995666829, 0.09764278126549558, 1.628646219450667, -1.6181438136272188, 0.9767806059551083, -1.2660934511378406, 1.1315004645379747, -3.75302360686302, -1.680117821544124, -3.0042571945752248, -3.4667061736088227, -1.1325996567623144, 1.1857952857337697, 1.6155723245021343, 1.4918968923456388, -3.748471621619043, -2.0142566661422876, -1.7885775300426974, 0.8660144941948676, 1.0688149185471203, -1.4500258221359665, 1.0310367869221824, 0.4491706297850893, -2.4013365734423804, 1.4172500170721427, 0.5141007774272484, 1.193350680999742, 0.9234311204968876, -3.160747297220436, 0.19663769403012432},
    {-2.6965304526446197, 1.2855350420316607, 3.133825976874009, 1.7306581459705557, 1.813194309187093, -2.4999944514405845, 1.0738266557034057, -1.9355355211451901, 0.5539574120344819, -3.0877776934709296, -2.4875884032268027, -2.0248197441409457, -2.451553701833753, -0.2398787197083432, 1.6114479946244962, 1.5884290566026482, 1.121373154085602, -3.1001759866198433, -2.346505319209111, -1.5100519165130748, 0.9218581915827577, 1.0902359012309748, -2.4661625904355446, 1.67075978780077, 0.19299576355292272, -1.5827927499890018, 3.235594501948372, 0.5192764025606565, 1.6445114402699712, 1.7684593263605433, -2.7241063413436244, 0.5114000906993327},
    {-3.2207087174892006, 0.9755324553317211, 2.7638010138087856, 1.2075940451297051, 1.6326914719757055, -2.150158414104903, 0.9514752665817294, -2.4323543307967532, 0.3364882659562879, -3.856831367095258, -2.638549837157386, -3.386855491108395, -3.3508273460987574, -1.3466352541690587, 1.2527388144951421, 1.4911057540989954, 1.0346342449887413, -3.899771347189337, -3.402019152273069, -1.3497376231175513, 0.6694084866554568, 0.6713205497676937, -2.7214195260709517, 1.0739914003506217, 0.022714778082002, -1.9474541619816927, 2.792865930597269, 0.12112445028542441, 1.9258491222663052, 1.2506483528063308, -3.7793847646006538, 0.38325449528858563},
    {-3.6844402733099186, 0.11541674983558514, 1.6686777558613914, 1.4789184738108203, 0.9905406642818242, -2.6317934156041094, 0.3750856540265728, -2.9183338488941093, -0.07540172392917927, -3.940260385142655, -2.9813100377875776, -3.296877687309731, -3.784524954369687, -1.447758904777736, 0.17191125791709205, 0.44616435393564924, 0.18799229756662486, -3.440597709981865, -3.4608897454591183, -1.467039351579825, 0.24204514249304737, -0.058920047623844694, -2.936480380528164, 0.42933545423532915, -0.3143344459073852, -1.6388587872153466, 2.3469280079198658, -0.6640543147392537, 1.5442074175091056, 0.8553935649169302, -3.7390114749009156, -0.48228095524383435},
    {-3.644232793127673, -0.48388272480352884, 0.5243339425921708, 1.4835856616027283, 0.3011412533811359, -3.0249998040259167, -0.3483075254792189, -3.061925598774564, -0.5834402552679546, -3.6656902594107783, -3.4609619338881794, -2.9410872390306824, -3.312650763434595, -1.5792203331410395, -0.9593181587871262, -0.11011191749029746, -0.6787713857124096, -3.188905777375739, -3.5803855779934537, -1.8832152180973774, -0.14441868836784288, -0.9014797566423082, -3.151698163879643, -0.5459219988862399, -1.3407223174557306, -1.9278040329218742, 1.990109400992949, -0.9446786693778871, 0.8174621393444172, -0.2928866798025798, -3.7416597916125496, -1.1941171412149232},
    {-3.421479248595511, -0.41846757821318287, 0.1889275089974145, 1.2602463716169914, 0.021318399246212122, -3.007494685627046, -0.6691784060394427, -2.43549423646266, -0.9659585406363796, -3.8683406395791686, -2.9105730646398396, -3.353243097947479, -3.701101375355828, -1.5850706743631064, -1.506537713040153, -0.3074494593300635, -0.5925064833269869, -3.3255347136071327, -3.5470701642028355, -2.3996643491583023, -0.693317356530803, -1.4255218590647942, -2.963378640688051, -0.8364690263425968, -1.0994968414880268, -2.270664993355821, 1.6660425449145702, -1.5041355905829141, 0.6290188501846126, -0.7751306144203303, -3.622241032618537, -1.7732630188905942},
    {-3.648811846287335, -0.5089410098796774, 0.3029768612793853, 0.9991219458277311, 0.16219266242522096, -3.010905167464991, -0.344257298579416, -3.118626539440355, -0.640983602696546, -4.0282593418701405, -3.231334806303324, -3.6473292867062863, -3.725003043081648, -1.4781318015478433, -1.1691351218446353, -0.1383983900042085, -0.5534209616998581, -3.5754051318366913, -3.8208014168612414, -2.1705318797254174, -0.5097929236874689, -1.1165028274023137, -3.0149457786993694, -0.9371206886571413, -1.4049313635600924, -2.6395731794326576, 1.3797142791626629, -1.655763501502334, 0.5756955977429764, -0.8304920799800236, -3.875760646454107, -1.2826688630870504},
    {-3.626808287447493, -0.003333956111113983, 0.9375230216913018, 1.254689858532507, 0.25514181934080327, -2.835318073827238, -0.16249334046736977, -2.9820006679703708, -0.5777096589034721, -4.311151091459497, -3.0658953878081787, -3.164390038586931, -4.1794548213057485, -2.0415981257308546, -0.3996394628548599, 0.003972825999919495, -0.18925335522071418, -3.51397779343157, -3.9693683728007985, -1.1027885828620052, -0.3293448237473595, -0.5983086067100868, -2.8547014605651193, -0.07649577607341555, -0.8038826755617671, -2.000433101661894, 2.0160295776040753, -1.0384411128638442, 0.699861833025591, -0.37911311710639994, -4.0589039529142426, -1.0705770936964614},
    {-3.3894964743451914, 0.3102422186100055, 1.623119032913418, 1.332045917438683, 1.040567914044138, -2.8773512635305614, 0.22672380290278368, -2.60784868077516, -0.23952713055485908, -4.739638421401732, -3.006421425289998, -3.500565930450305, -4.332698298276975, -1.8218472535060515, -0.011525844679701776, 0.754458272841324, 0.34054771962560054, -3.8625501641601563, -4.041549635943267, -1.384513484216921, -0.015833106309520697, -0.15570185349664165, -2.7667735122718304, 0.2989820445224848, -0.7398563253914642, -2.1908541893467306, 2.238070102154424, -0.8380288786671164, 1.09150278640465, 0.11078714056073521, -4.141859510000734, -0.6723411620410051},
    {-3.3686459414876864, 0.40456694945092414, 2.0523486791646413, 0.43738500853502893, 1.0393679024704583, -2.5918172942473463, 0.08652142133017283, -2.1488155050156896, 0.017350262129494236, -4.039900203923633, -2.605977787685187, -3.639993884337342, -4.0310044697882095, -1.6807411713853608, 0.5085472018046879, 0.8012570030002002, 0.40402321233734156, -4.208689342632379, -3.4280461593405147, -1.6071310651372885, 0.27532291540707154, -0.19951603348853492, -2.2458557959778642, 0.4521973086674712, -0.568528934012239, -2.063974746819737, 1.3745504790700993, -0.06573047657267601, 0.9427371843194875, 0.614816327942485, -3.718915909127116, 0.08365027919397117},
    {-2.68407031510816, 0.5946681020345367, 1.45285506875954, 0.8339449955833442, 1.205155403004418, -1.7499595157941106, 0.49348941531208873, -1.6738719472351422, 0.11295644245446555, -4.028460200308089, -2.0384050443328556, -3.8229957489452118, -4.102432693908771, -1.5017082361200944, 0.6714073433054604, 0.9777610076111061, 0.6538839274810713, -3.6650149648153683, -3.230507858130198, -1.2042553643519371, 0.6472026665525208, 0.34633083375578677, -1.5131080119254645, 0.39107130744786217, -0.04786642821444008, -1.6158956783465341, 1.50285114833783, 0.14118044163881044, 1.0576787052825194, 0.26305590807467305, -3.7528359832438825, -0.29342946006969867},
    {-2.694411318644158, 0.8659324984233733, 1.7666939421601633, 0.9837633965244229, 1.4891362622671525, -1.716283969945407, 0.9843620482974219, -1.5705672133328066, 0.5510016366608574, -3.8652157187907275, -2.001011725162497, -4.007018749597349, -4.106206938868982, -1.3220132987035293, 0.8548542777214067, 0.8739552936407101, 0.8406012086939623, -3.8654484076346853, -3.0473856445994, -1.2308241625042657, 0.7926524517911292, 0.5440819836401832, -1.4664948845792043, 0.48648934402914407, 0.212232185526835, -1.6940385675765768, 1.6891349254971912, 0.0728022238598258, 1.5620176239426278, 0.6378028681319854, -4.036684040489041, -0.43107169641855836},
    {-2.8626028205782768, 1.0546344998645718, 1.7476945346183537, 0.6738205651571272, 1.3319229746163088, -2.1509538670526274, 0.8507496424219693, -2.0820606002601014, 0.24544407567038096, -4.102642305781325, -2.1046856357673303, -4.143856079899347, -4.103360901971523, -1.8826115281367748, 0.7384365530429248, 1.2043764699220514, 0.5725808604442111, -4.22657274681392, -3.4965290847962374, -1.5975655751234952, 0.7017554775973176, 0.3399485258773457, -2.058340738048956, 0.5049974685841324, -0.23372132751693175, -2.213464320744713, 1.3734549181948386, -0.20199982230475122, 1.2946516877892793, 0.40796634516902425, -4.121553559710505, -0.36448587054335047},
    {-2.987282312600697, 0.9604118148034394, 1.8596240191399047, 1.1404205942772092, 1.3235449404160593, -2.083839039899443, 0.8398585987454036, -2.1788263117336246, 0.2688904794847443, -4.049858201751835, -2.533856490454817, -3.7914039625569544, -3.854481980485114, -1.9093978031698595, 0.7915330209421412, 1.312354426421074, 0.6853209922408016, -3.7661071677074442, -3.395474985123466, -1.5827115908108218, 0.6573200055869716, 0.13658256801072302, -2.081044554441007, 0.5795447400529936, -0.3294528484835744, -1.7733228685767763, 1.737250314245997, 0.059840516502465184, 1.3414253138546894, 0.6435394559829051, -3.996326453083202, -0.2546700852918507},
    {-3.1709457224233057, 0.5650082677331189, 1.874616863107663, 1.2505998736458455, 1.2460846871708042, -2.3180378927140044, 0.4629971678963019, -2.5522174173291607, 0.24583588075515303, -4.215354498977741, -2.6827129211439793, -4.001933773122689, -4.064846291326753, -1.7962179816607704, 0.5121012565658287, 0.9609202283280701, 0.7240332965329057, -4.079766689737057, -3.6072201839419615, -1.7140313643009444, 0.5461909901886719, 0.08610521564826278, -2.377452817629035, 0.5449444197659422, -0.2224979802167666, -2.297662154407432, 2.185955700259167, -0.08908187915635103, 1.1142959434018043, 0.22524675075745634, -3.951174868586515, -0.38312844397202833},
    {-3.140307094827208, 1.279971931709703, 2.5687672835726447, 1.6857928845239927, 1.9696181813028117, -1.9653378707328912, 1.1035687249135397, -2.111824245721192, 0.5594442532036175, -4.002635192452922, -2.329458954333029, -3.543536224245206, -3.6008955285544357, -1.4531957747304107, 1.569925213958393, 1.5014169366859371, 0.9431276633240316, -3.7421960333379136, -3.514451988874534, -0.9236702282880388, 1.0890692549271033, 0.8749073744407155, -2.0607062755409458, 1.0433274753744615, 0.4043767310814366, -1.3617793368508158, 2.8201784079209844, 0.5408693783328685, 1.8630791775364013, 1.2851108711861627, -3.7307046234719032, 0.5021327481618957},
    {-2.560558515850883, 1.6250274739655555, 2.8744459124879547, 2.347653673832026, 2.200790227062031, -1.4323240396671983, 1.7387040379488166, -1.7454571008219955, 1.056640100752434, -3.314476528708766, -1.57606863113387, -2.7569659435571525, -2.9417493565531383, -0.1443447161631365, 1.9633313249240445, 2.0040281405295253, 1.3992751535631947, -3.252661301681511, -2.798628885124479, -0.3443589483937767, 1.525685423473607, 1.4028619348063764, -1.476937297745424, 1.8795771897915272, 0.9027553176126711, -0.9940239319554408, 3.1030710588158716, 0.8093861154677489, 2.538295632419918, 1.8696835566931533, -2.7110758332355753, 0.8467510882660746},
    {-2.601449427690409, 1.2862314159512918, 2.572674126073715, 2.5462923123499697, 1.9814252724563937, -1.8057454943976554, 1.034430872944078, -1.7272664641970474, 0.6610431333357548, -2.924665349638832, -1.934565882054889, -2.3172540584963586, -2.624606832731866, 0.2377309373510379, 1.570532334915982, 1.5359726032560106, 1.019327349889257, -3.0236267720314713, -2.6976099022921787, -0.5327406986700656, 1.3592000904704342, 1.0650480679859677, -1.778293683037354, 1.5474004874582767, 0.47238830390361963, -0.7511591592374728, 3.2472421177569606, 0.5776269805400887, 2.2338342293246782, 1.6019341388072492, -2.803322366734225, 0.5659628009462269},
    {-2.9762139454332517, 1.002768032174574, 2.50811718705069, 1.425484080506022, 1.542957196242576, -2.407097857045155, 0.9998132470632122, -2.0850134804388136, 0.5040716452814822, -3.8587625541986252, -2.4036231985300005, -3.4865589961521675, -3.6892208461636935, -0.7456226445933926, 1.4509654431183157, 1.4111373803720884, 0.9570445384596276, -3.7652824487944754, -2.9312234313601384, -1.524710458013989, 0.9456822267114656, 0.6087976842575928, -2.4031858664552055, 1.3059927040571597, 0.23743005697670314, -1.7853807426952197, 2.8242860273588675, 0.2542767851451396, 1.7387646110857096, 1.2856348227857213, -3.78046713044909, 0.23610857614283406},
    {-2.5786814066792703, 1.3768261008473446, 2.813768198026389, 1.4431364926201102, 2.1377766395419715, -1.252539408465012, 1.8370789333601316, -1.1171802181641246, 1.1901448893925974, -4.1432716709632675, -1.5097366253835023, -3.5854827307399284, -3.917267708866103, -0.7999815964491986, 1.9305182797007183, 2.0162166801900554, 1.4773592326373093, -4.045464102431477, -2.9167513201978337, -0.6063799971386915, 1.6429547398994127, 1.3271374478161033, -1.0780882850814573, 1.626602319460321, 0.9154586774772393, -1.215608691352436, 2.8880312280277165, 1.139976037241838, 2.400067340028313, 1.8624265105647528, -3.6707706184430418, 1.0259199144394757},
    {-2.144868161077572, 1.7690249626570027, 3.36074923374249, 2.5274057472187526, 2.664003872984643, -0.5637919687158505, 2.182180149326731, -0.8279130334545086, 1.4993423312845107, -3.846595660414957, -1.2390672447442024, -2.858999131211234, -3.3696915104404694, -0.04601818580839061, 2.2753630190971865, 2.49207866419764, 1.861681243541428, -3.5955065324011093, -2.5190527247286045, -0.14453699410254423, 1.7513044675306553, 1.6985779563643508, -0.7338904181381944, 2.239362937403003, 1.171991139715321, -0.6478458919157892, 3.459956168221106, 1.5301362511155336, 2.6353950679059275, 2.481070123585779, -3.11070844580916, 1.6316385597721215},
    {-1.8280501227965715, 1.930198469825898, 3.9302911300323173, 2.7629606623821035, 2.556171082467624, -0.6613861176429663, 2.317729182653799, -1.0524985611688629, 2.0263194991884794, -2.889612886048279, -1.1765774554082533, -2.2362264796161972, -2.330270059272836, 0.5224385109988045, 2.5707230632804934, 2.798150564718049, 2.135228095338422, -3.063253376098197, -2.1457628200640015, 0.31390081554123717, 2.1246819736536144, 1.8738136608604756, -0.6580627661751486, 2.3793730910775843, 1.2242629957536595, -0.3816395512014138, 3.7131686140901587, 1.5715809792273758, 2.9485891019085058, 2.554064144659507, -2.0597011210776484, 1.8558661362142574},
    {-2.2468236664975443, 1.9277071303018538, 3.7082346502068373, 2.2072493111453295, 2.544796425835953, -0.9926453602450628, 2.014013707382617, -1.4290306760939975, 1.5332413010144335, -3.3741059105158477, -1.577586517904955, -2.9310917603587563, -3.146803747839726, -0.34486310682392285, 2.5341420651473485, 2.471055158649581, 2.000018186406717, -3.548797463734066, -2.3803726219696992, -0.10804799973321405, 2.094639980189837, 2.058398638126665, -0.9565364123673268, 2.2267766077689664, 1.4110745274269716, -0.8139168869262807, 3.3224046929438487, 1.3014674427185478, 2.4781353586062664, 2.320689399919009, -3.026079105543744, 1.7649007993249282},
    {-2.3773049649743077, 1.4945824416961595, 3.4027571948107114, 1.6600045197382614, 2.199803360267081, -0.8942654737734078, 1.5320282154151972, -1.2085592620352559, 1.0195018420168254, -4.000353819717246, -1.7445575596040632, -3.5665498263801902, -3.62843857540846, -0.821341487633314, 2.4003066310106154, 2.0039036287537315, 1.7013792661793568, -3.843467787209522, -2.554612927865438, -0.42439956625501807, 1.8044168980827033, 1.516096546504761, -1.043254421546892, 2.177099048537821, 0.9595628399600412, -1.195701121602212, 2.816571830376224, 1.220679921663246, 2.205344770692984, 2.2426997720200257, -3.3486752595893297, 1.5785946340847832},
    {-2.1282865471858337, 1.8395097215576988, 3.1743361377986647, 1.9201901162884847, 2.5104441362425614, -0.7454132076226372, 1.7754212882986584, -1.0606358680399208, 1.6551212844701366, -3.244830974804262, -1.0463108729185524, -3.022595701529909, -3.1984837923113445, -0.0653297753960071, 2.2048572558294413, 2.2329216964573018, 1.8389703220235434, -3.640334769680588, -2.4253755496442495, -0.6426641521771562, 1.6836597266104236, 1.4722824003787065, -0.9323651184096916, 1.8812033611943042, 1.2661376401317785, -0.9790219176854913, 3.1613879739807955, 1.2775437165610535, 2.419433234245967, 2.0585677492894305, -3.0088700831967485, 1.1471386174229194},
    {-2.346894533910561, 1.723208474784824, 3.4146236634133293, 2.060591863364043, 2.3068558568819095, -1.2928923827227552, 2.0399492389140432, -1.44763262049985, 1.3014619142996169, -3.3702139287216455, -1.645067549267427, -3.2017405512558397, -3.2658290627162168, -0.35764985099836527, 2.2761957066266123, 2.4758082872307847, 1.7388559055688944, -3.9756279431540023, -2.7787518865734047, -0.7461149556375116, 1.9186727468074911, 1.5910276886157297, -1.4745262529085745, 2.1436968099116065, 0.9946130369871415, -1.302481749740466, 3.200661960909125, 1.0567562511501614, 2.2577912711661767, 2.3276975116679917, -3.095633569025652, 1.1297095553765328},
    {-2.8350429107282156, 1.6175403110411666, 3.2726749745630537, 1.800825484171888, 2.1812210294407546, -1.3830789937383814, 1.7300113113182973, -1.4197476100745887, 1.0107269563046053, -3.890952812481048, -1.8395451658792754, -3.231451564525306, -3.736257722045055, -0.6128121739433261, 2.224686048918657, 1.9684820917891648, 1.5230126099870225, -3.9303237028308877, -2.9625621344386937, -0.8399371437945752, 1.605013682009932, 1.4688625052790947, -1.809377106520998, 1.987830730472488, 0.6039403624288731, -1.2105718622607957, 3.1242876210396635, 1.1157663051584834, 2.1972864437420596, 1.7921547500158703, -3.390725009922208, 0.9720895975420842},
    {-2.797121602744607, 1.5730864382438876, 3.3779272259146804, 1.5087655887570952, 2.4280263196720155, -1.600304184971718, 1.722388911053112, -1.5421174512213147, 1.1793036369119925, -3.8125745682902092, -1.866955035460894, -3.5543883870545305, -3.5303081176874573, -1.0006366117104089, 2.4839903963375156, 2.1735610055706776, 1.6842571609001997, -3.988502609224924, -2.6566792175001823, -0.8914282923011932, 1.655246814352187, 1.4365589953163322, -1.4413048467954679, 1.954935678511815, 1.0575970395142518, -1.5421083156094644, 3.0552634385655866, 0.932035335128203, 2.2198025803278134, 2.1069335807577487, -3.462658812903031, 1.2248229908995518},
    {-1.9129828046698663, 1.892819285002911, 2.9508559393520883, 1.306699781651037, 2.5292378229371275, -1.0229664578015483, 1.7983737925997658, -1.2115708300941723, 1.2507582743925787, -3.950420754456956, -1.2113998149598908, -3.317821692470058, -3.6571597326219227, -0.9545089227866607, 2.1481718344589713, 2.489453062750087, 1.6614483189969187, -4.220985386269195, -2.3501584242350844, -0.9491297479838777, 1.7531959240101063, 1.675238072294621, -1.07220891092293, 1.9250734622771195, 1.256835405998279, -1.5785171982757265, 2.9556305006912402, 1.091309872656911, 2.464228385965088, 2.029308959300956, -3.2493622636950352, 1.3173839384908526},
    {-1.2127878829687213, -0.9460461365023769, -1.7368460872430758, 0.06864969992607158, -0.616651002091939, -1.5343306941192167, -1.5982326575819823, -0.461816585137375, -1.3495357349243433, 0.7486583158852005, -0.7968851920201925, -0.11534955366023085, 0.01420585037873145, 1.114446636470698, -1.9158364809428774, -1.0582084329847259, -1.3056719575354143, 0.8137042487445333, -0.5093190545793225, -1.2608622614806422, -1.4407855501987972, -1.298211624511057, -0.8759980431054812, -2.075163049128082, -1.070118124908116, -1.0752811347316906, -1.039708612147803, -1.0987758134568575, -1.1621248321151028, -1.9369891209023131, 0.09024954641447668, -2.0732101487516124},
    {-2.293881317558651, -1.0440987023333599, -0.2807531005900801, -1.313634827040449, -0.49992352571753373, -2.4334368738727763, -1.7319111124537068, -2.3757724282680397, -1.3192038528793932, -2.5129949078035403, -2.386313837463859, -1.433390319452537, -2.1254739876843884, -0.5147610846677863, -1.351532375409669, -1.0612367106916898, -1.1503011665473841, -2.2927164948530736, -2.0642645128443577, -2.4584292448596803, -1.715164917671546, -1.6820856388709102, -2.5737022923840494, -1.313018041402742, -1.6815249473728173, -2.26129963395228, -0.32694206301483114, -2.01476608967559, -1.1369131043993086, -0.8386505366146833, -1.8592334531780559, -1.1167636164836716},
    {-1.8173584452684175, -0.9219165126191475, -2.4353707114213243, -0.2595215282574888, -0.6199325844477528, -2.1681446869104932, -0.7397276338213243, -2.117665695437183, -1.205140694689816, 0.23684826212155244, -2.0446802729897424, -0.2873624014989597, 0.11733063710744498, 1.0480702750225583, -2.476306682968436, -1.1280033078232758, -1.844427534926845, 1.4927067141798165, -1.4029731106146974, -1.5326058621394176, -1.3747623433067362, -2.250872620581493, -2.033341215695409, -2.0973129918782756, -1.5448005611777103, -1.295298955841734, -0.42212961941459437, -2.6002265900239894, -0.11259314567540306, -2.32419832973408, -0.7091076415408786, -1.9848242832379688},
    {-0.8484953401754018, -0.8014303039255822, -1.5855979806706515, -0.6677028871745362, 0.02351214336426476, -1.198111129500792, -0.002968241110848806, -1.9932906723242427, -0.3292514683662198, -1.0988554547255378, -1.3769619155919268, -1.3068743761611272, -1.1566803261070984, 0.008313444803279847, -1.3417625161860383, -0.47974609585643346, -1.0069690390198012, 0.1671331764740506, -1.3053709053461158, -1.4628597702009254, -0.7606810530493179, -1.6533626781233555, -1.6170497796698957, -1.7872253520237178, -1.1590974579398432, -1.609098405382016, -1.0219350229855229, -1.5839735843203429, 0.2070506293911748, -1.649009503420759, -1.2907496324850611, -1.6475307007339726},
    {-2.1847139881660134, -0.7202339051814244, -0.5102699601843322, -0.6383524838564213, -0.3232643956878634, -2.383974668113624, -0.3133031968197994, -2.5748898299388894, -0.696020572305768, -2.2150249062144654, -2.3098892481445743, -1.7944830220383092, -2.5705371925942764, 0.1625178949788902, -1.085335128134887, -0.627553319237995, -1.1594733525641558, -0.8629573850500126, -2.369701529773581, -2.00431217492771, -0.9013763729526253, -1.513347678268975, -2.5517558475228856, -1.281221762297001, -1.497526474351325, -2.479051681808324, 0.006706804734591676, -1.729835658512854, -0.04443136395469487, -1.0338637486165698, -2.0911634429920714, -1.6349151908652293},
    {-2.1522140105498666, -1.1877698771525282, -1.6385286567165476, -1.0732974779933133, -1.2389660388476929, -2.614924512149673, -1.2528124120639472, -2.381990435240344, -1.4693086722035669, -2.018118157703981, -2.3614194339788988, -1.6130057686741097, -2.3081665623929903, 0.3283406419584622, -1.9739077778363097, -1.1736212985097914, -1.9295743013399858, -0.31945311047822855, -2.313651008193837, -2.4848549177958943, -1.4560091178579517, -2.3057865100674113, -2.9487797122470583, -2.418071703533146, -2.1711555008845136, -2.6193115118257637, -0.6544082466649825, -2.2127122437568922, -0.6780312029934948, -2.254016867744609, -2.577468375769182, -2.3603565068064767},
    {-2.4592543642959686, -1.3864150965967157, -1.5655955140481415, -1.0787129428249422, -0.900522199933421, -2.802004128673435, -1.1279571768621826, -2.5434746210842705, -0.9153890483132554, -2.1536603563050107, -2.8690891744884617, -2.31686475094804, -2.8200071776749267, 0.38084181576068504, -2.268710341079052, -0.9512295446425791, -1.6854337251040339, -0.7115493700867866, -2.441735354517024, -2.839394402679179, -1.5052436231867763, -2.2338316488138776, -3.0470098512136983, -2.161847400713744, -2.1735129218664846, -2.7402167961197303, -0.8759526690445116, -2.4043191122149548, -1.0082697644886478, -2.2458734817315498, -2.6966136559081355, -2.532300833242822},
    {-2.261487665296329, -1.0006271946908476, -1.8204861250703344, -0.9662062954521614, -0.7930648518672935, -2.7764343363542356, -0.910798483616686, -2.4034988500595893, -0.9884966710768038, -1.931195800737552, -2.432744195828665, -1.8399720695204458, -2.3807090428983946, 0.34793768052584473, -2.258121817584299, -0.678649017221849, -1.5277473217076756, -0.5971986608489236, -2.333460571791285, -2.6954480791240716, -1.326288076188895, -2.1527699036833594, -2.542821657792864, -2.1017474736422566, -2.065282570258217, -2.9835385973002637, -0.9172361250365354, -2.4528484115562676, -0.7625329935150787, -1.9517802797138095, -2.462151184499648, -1.683643317511364},
    {-2.104525779187702, -0.6378372548591098, -1.4695520233175925, -0.5647514237294097, -0.5064307780145142, -2.7504440556205845, -0.6057065041738228, -2.58795081586711, -0.911389791919333, -2.400184119080475, -2.5903656027927386, -1.473786526589252, -2.4868032301228062, 0.6656573201387288, -1.9240500554636462, -0.6081561094128319, -1.2332795568960444, -0.4412259955220227, -2.6779494336513077, -2.524846749614738, -0.9417976110825816, -2.5532240761441156, -3.0055662708746893, -2.2071044071118666, -1.763724841549393, -2.816836606231476, -0.7181209094425302, -2.5673924254024385, -0.436193525485032, -2.2440406408678646, -2.495178040221297, -2.533610432154447},
    {-2.3976747055577334, -0.9508236768877139, -1.4588908253237571, -0.6880517543818355, -0.27751366681088047, -2.7114157675977952, -0.6705758864654834, -2.694948913871211, -0.5898440764990385, -2.2134496657226967, -2.7480696626390975, -1.8588236531124365, -2.5904871327575902, 0.6039718302070771, -2.6261311058235366, -0.42870535406671406, -1.5176410489932308, -0.447367766149019, -2.6690429602476526, -2.7022313314670843, -1.0940798063371153, -2.4986362524351304, -3.0506022258173613, -2.5281415948835346, -1.874941347108314, -2.9462162910867726, -0.026238885901692256, -2.3506818875477022, 0.05761822128833503, -2.2710556804477666, -2.71012003450006, -2.748018618273772},
    {-1.8281219751886395, -0.6622468675780401, -1.0880087030627557, -0.9349870031481701, -0.38232651048660016, -2.163739401409642, -0.7426475192559052, -2.3592474006121593, -0.567828313499129, -1.9760745066099892, -2.3774558180099645, -1.6453875532380084, -1.9943480392197788, 0.3730415063996256, -1.9554558224053553, -0.8184590343459288, -1.1630090429623678, -0.49481445772033755, -2.047031027102054, -2.404260904733674, -1.1703701501813009, -2.1860663693856455, -2.410381454049173, -1.8680735607746417, -1.5844529216254202, -2.404816950857759, -0.5911034350960558, -2.201369344537435, -0.4262382858817751, -1.602176201721397, -2.1980202983074837, -1.9133183218379421},
    {-2.1914791353598635, -0.9726838122443445, -1.7762106418211032, -0.7662332721375809, -0.7596484984744795, -2.5425393693730842, -0.6409537326225838, -2.3123092361908277, -0.897477696412678, -1.8081276398298252, -2.5765644026236365, -1.6316251827639667, -2.4631540982480065, 0.6427922518664494, -2.3528144535086684, -0.7449427765860775, -1.4332179437672719, -0.09515228758512274, -2.4775232841646604, -2.5804708673615036, -1.3963372724912388, -1.8662723584753265, -2.783783250488374, -2.508264630186886, -1.8924523141483576, -2.6260269689639575, -0.6452269670597764, -2.6822977371591934, -0.36261063117455555, -2.1093258619244897, -2.400872102790914, -2.2847486031518276},
    {-2.5009987419607436, -0.36451055158845497, -1.3350663263813323, -1.0899494016607103, -0.4656147809993671, -2.862970893500248, -0.5671285683052579, -2.6513924521222325, -0.9087419928620237, -2.0856003007363224, -2.584694731410634, -2.457056484804855, -2.882052966859067, 0.5600425456127134, -2.4407089788759198, -0.523380083286206, -1.6132375206812755, -0.4151701065344965, -2.4315539705050657, -2.7650199104222914, -1.1742643214288193, -2.2277557843795535, -2.842825735639337, -2.682848988513626, -1.662030556835869, -2.944659643131373, -0.5652092609432329, -2.4493382246708895, -0.3815375930705485, -2.54891530716274, -2.996687720851005, -2.696643988350362},
    {-2.699820613813296, -1.184824054200663, -1.849110680576079, -1.2712181950257095, -0.5612111475451205, -2.73180920661139, -0.8151921241982484, -3.0260053031625187, -1.1242905032024426, -2.1462638708909014, -2.724277577686077, -2.2477525462436994, -2.4566854756256356, 0.3823399428911277, -2.5344810379700102, -1.0542972116152538, -2.2434202045982565, -0.6995911393261021, -2.728471355037712, -3.3086084730171974, -1.7193877897233991, -2.63906488530677, -3.405623750303449, -2.5843101958153856, -2.4947498787425926, -3.0703999186869964, -1.2129282458515642, -3.0044460066170897, -0.37274275214883285, -2.9808183927127425, -2.7042182444303187, -2.8812770746919},
    {-2.5119669744512847, -1.4071471691708184, -1.7628247057439534, -0.30118750879381156, -0.3767921165089166, -2.8767572345468477, -1.0227292635196212, -2.9952416218243023, -1.4557385965251035, -1.4918342729287553, -2.603009497872422, -1.6291144317013824, -1.803136577436317, 0.5556233323238644, -3.1267699578498913, -0.7880641239282208, -2.2465836154996968, 0.0016292037132290924, -2.7836994874348173, -2.659401804885359, -1.5384940648612841, -2.6296946753030976, -3.5531004253543146, -2.8638911622629424, -2.280527564030443, -2.8443810514557475, -0.6790132277780491, -3.0523428961507126, -0.569872338813719, -2.8321686080167807, -2.371919051461695, -2.7307173974247614},
    {-2.9989753690363194, -1.5344482009680558, -2.1757437839095632, -0.524536783679312, -0.7414625518254446, -3.2210659374348687, -1.175620753832033, -3.1654762963145484, -1.690441889094966, -1.3208821373666944, -2.7774447064989904, -1.4961236721133844, -1.7781139885806845, 0.767449254171179, -2.8947852630919533, -1.4076116157901688, -2.519940204326183, -0.17569307149548805, -2.8618739766332, -2.7799418726093164, -2.1453367621929122, -3.187424900185315, -3.446888241101456, -3.1763446779954343, -2.5555299893619354, -2.9161573843717754, -0.6831505050846414, -3.0935172873995405, -0.945273483517473, -2.9831433340211904, -2.0890101936122836, -2.986877931666905},
    {-2.446536134283893, -1.1115666394435961, -1.8966109351108031, -0.7958735688091677, -0.8282017744856515, -2.816105012076988, -0.8644048828898978, -2.7809161753107117, -0.8538652370597022, -1.4198331470639702, -2.7133063656729184, -1.4747813684226811, -1.4716702168624143, 0.29670740135850987, -2.4318807940869913, -1.0001408894767891, -2.135671371755484, -0.12315782606060985, -2.5733101385133517, -2.78776274797362, -1.5818686151808548, -2.0402342493538232, -3.1426227360631187, -2.7114250442414054, -2.0419403237044293, -2.729902566261105, -0.1415082901114817, -2.8713376050113775, -0.4218631156753123, -2.718373502787633, -1.8209381218973362, -2.434583776074026},
    {-2.031398590237043, -0.6157389215166147, -1.434520136501817, -0.5754318204242771, -0.34416192143249474, -2.6309260526346523, -0.8298497348858815, -2.7297817906095005, -0.8540820409983367, -0.6371509749580032, -2.557491675905121, -0.8331807815722414, -0.9051556205188281, 0.5105325661635444, -1.9983881746927918, -0.44237743246940836, -1.5649245194476005, 0.31155354396390106, -2.0338117633472117, -2.0133947972508457, -1.1839366979964416, -2.1869616685493565, -2.701222890837539, -2.1472051106718832, -1.8139663264587012, -2.0649946888175257, -0.07160696791011605, -2.546538053006391, -0.33587142638372763, -1.9349298877349068, -1.500186517143877, -1.7988797538358594},
    {-2.2669613324317175, -1.3638241990750524, -2.1533920735139302, -0.36065580665315206, -0.9079387464234145, -2.773517048606366, -1.0740020015780956, -2.6606547023852, -1.1209566847255092, -0.6344746104944585, -2.7013245064592617, -0.7367103343692348, -0.9739583485725359, 0.6738479405957634, -2.8563185665154327, -0.9635491008655755, -2.302152819312379, 0.484438411136647, -2.210124075030508, -2.6926579028375914, -1.780832609008244, -2.6727276071682247, -3.151441205604406, -2.545860526618482, -2.167833749774579, -2.6121408991086814, -0.4840602312882296, -3.003527413877379, -0.4987346357518816, -2.4185423517200073, -1.4467394130195637, -2.712214972165803},
    {-3.149141765496792, -1.6243110123481799, -2.2017487268031344, -1.1351244688255069, -1.1042275528820875, -3.2399538620277366, -1.4228753723536633, -3.4234977000878852, -1.439099774216244, -2.071440964622614, -3.2771998608375954, -2.02939944829208, -2.434995677085034, 0.5271607915519846, -2.882479832184759, -1.2473783825294897, -2.457961051258364, -0.3437021820574902, -2.85395558832859, -3.4711711575640867, -2.1803064748304557, -2.971059571713731, -3.5946944745839806, -3.004269520743893, -2.8772399703677287, -3.5838486355525037, -1.0396523396355357, -3.5685002046714005, -0.8206812974104871, -3.148667922058919, -2.7678552088477564, -3.3625557974497893},
    {-2.7954914327364713, -0.444329427200668, -1.03794383962337, -0.18391727863073448, -0.17858012544706361, -3.2232941502358385, -0.451814832228126, -2.774954995627842, -0.49331865252436097, -2.540315140889216, -3.151395493672485, -2.9320519792672672, -2.79350182473863, -0.033855634080744344, -2.168207829445289, -0.3886861501968501, -1.4840316574619767, -1.0801779024652551, -2.9949716885066984, -3.1198215998018974, -1.129608276896729, -2.2395126294527956, -3.238272458088598, -2.2560858358668354, -1.4963994538172707, -3.099672076582274, -0.13668070796369586, -2.752471937294504, 0.1208705272190332, -2.2552932578923888, -3.0840699742287883, -2.5419372862746705},
    {-3.0113216878934934, -1.0392442623273772, -0.479038285411587, 1.0520084405216659, 0.02032910290583295, -3.271056522794887, -0.6323518382863309, -3.0641774992037067, -0.7993618310541374, -1.3487353890764693, -3.096925772858455, -0.9854874569534838, -1.5786768340195279, 1.605684029373397, -2.234464843268224, -0.3785033918842389, -1.4871699561508471, -0.1677741094691783, -2.7961293777534895, -2.361786425143836, -1.1530243437017107, -1.9186439334825656, -3.315890755284784, -2.2554486813045904, -1.8055890240259371, -2.260433828223655, 1.4154562644525144, -2.6452936027364946, 0.600156910737708, -2.0880542539689286, -1.681574339237052, -2.421157436199265},
    {-2.374271305375732, -1.1974092268732854, -1.7998846234870456, 1.8145022019262889, -0.4109442109788296, -2.93328439835463, -0.7241246294506554, -2.5004424723544765, -0.9029632817887393, 1.2711727409118492, -2.5005788258563104, 0.5106406154226559, 0.5788122456085351, 2.1467087554596804, -3.3620014874850748, -0.5443505352719316, -2.2262718414598908, 1.9067397672122604, -2.235307703464851, -1.727044839086132, -1.4177523034197115, -2.633430823635965, -3.5057732006356908, -3.1035946543965767, -1.9233265824430192, -1.7492609438659625, 0.9811234069419577, -3.146460700657683, 0.6377270147519623, -3.016587285589185, 0.3045819310595569, -2.853566211704352},
    {-2.684649881095791, -1.1127469658250477, -2.1886115641488773, 0.527431196992033, -0.7457527405505495, -3.1396298714423176, -0.7778916645229887, -3.0422791038198604, -1.0375748236492528, 0.3236820377965319, -2.8728737172611365, -0.7637971034032998, -0.8417201486061154, 1.5367125954924221, -3.281450853243104, -0.9270274368808553, -2.3971362949613493, 1.3820107497408172, -2.695303689562387, -2.891507777064234, -1.5781938037774021, -2.8247503880773555, -3.5438092550089793, -3.396186722267518, -2.428124401574226, -2.6989776763329227, -0.09385611937606089, -3.4030294546949147, 0.04070432865610825, -3.270795081471471, -1.303639069527166, -3.6489745277328516},
    {-3.116394139091032, -1.728592365116535, -2.0972973885180455, -0.8886874942885997, -0.9999631423965426, -3.6061680547369166, -1.4651759257898607, -3.1668808009401137, -1.55571693496135, -1.671840825875202, -3.5600500378496607, -2.131760342644543, -2.344698226015001, 0.11385741615030574, -3.274772008722184, -1.2893969175688673, -2.719344179827209, -0.26934943459567146, -3.105859339944223, -3.4871467221022767, -2.100372089460426, -3.020744354597263, -3.6455778985868075, -3.4728244783942905, -2.7808531846441746, -3.4845879768348578, -0.922564935936748, -3.3871532524843984, -0.900560520328115, -3.2065405690026734, -2.633338564851744, -3.4944787304541687},
    {-2.244847194085822, -1.1337634024680021, -2.8227956579618536, 1.047781777821773, -0.6819596049197365, -2.7924721480305115, -0.7994079394620202, -2.844077382046755, -0.9780676169490186, 0.8554964306863541, -2.3355897420632816, 0.18994349046544165, -0.011851753207255898, 1.8544219145735727, -2.9788909511404236, -0.9333235474365333, -2.2370843232077333, 1.4751848628660937, -1.9914824356147263, -2.446029201088975, -1.7478635158208737, -2.7941518472248146, -3.028221326242247, -3.448357171613703, -2.065281354650164, -2.2287057111373323, 0.23245891364574772, -3.0203547366683083, -0.03235122733410962, -3.1378130778075897, -0.603719303297952, -3.5919188955028813},
    {-2.535184771317551, -1.199377367266678, -2.2535291602152134, 0.7221860691053729, -0.3940011009585003, -3.2956919586904165, -0.7762074379374471, -2.834128777428641, -0.8866077943500382, 0.2960087683887295, -2.8478052978572586, -0.7288359601963313, -0.6186401018180999, 1.6473983709578885, -3.0478373307190703, -0.754002056403496, -1.9154381748880722, 0.882332635556484, -2.3978426564019197, -2.938421078253434, -1.669739371193826, -2.9120910762519823, -3.500524811841285, -3.1199380727480155, -2.379161672683076, -2.8658606944481018, 0.05437789888368356, -3.399286903741584, -0.014189303745701555, -3.06501854891573, -0.7876775782866675, -3.527521248990583},
    {-3.1537133864558173, -1.6371558293933564, -2.375422543716724, -0.3248878165506115, -0.41509260832165895, -3.4123969176996027, -0.8863113965039556, -3.471655687163471, -1.5485501170560858, -0.877147326405613, -3.19067003102265, -1.5801101116570542, -1.5808868470024333, 1.2478665462852396, -3.1733065216231005, -1.0646013274853068, -2.714524436973655, 0.4730554848498407, -2.685251503301264, -3.3211585835191864, -2.328068980940526, -3.226362127000432, -3.6543093098211763, -3.5907605470812376, -2.502993210405267, -3.003266492332452, -0.3157488689662449, -3.739545524024079, -0.5032501717404151, -3.6723595757307654, -2.033903352787204, -3.6869312769575497},
    {-2.858508326886343, -1.543812383292597, -2.641200933776516, 0.25560959266750777, -0.8456583047082353, -3.4070325514214783, -1.1789576480672241, -3.1150184322263867, -1.6392120754739858, 0.23751018329115092, -3.0661536697962393, -0.3766444685177816, -0.7229560762813051, 1.3560464598792017, -3.4128225982032876, -1.31333553436537, -2.6222243191370214, 0.8710885465432721, -2.693487715071081, -2.718683408590567, -2.2061283838231285, -3.188852160227825, -3.7502986592067535, -3.3235417226074646, -2.5039345141395386, -2.534686552267428, 0.19625785548741925, -3.4265833235519594, -0.5371186968083453, -3.473779442067913, -1.283649642483982, -3.5955866767940923},
    {-2.6999309893327497, -1.729330326226526, -2.2825915935061234, 0.3144633262071244, -0.3519403856307231, -3.5184212856078947, -0.8787342060647003, -3.080673946455001, -0.8684471591005062, 0.18964742675356927, -3.1155734992367665, -0.41278225689894554, -0.8961233524565014, 1.720487901238096, -3.474809424539309, -0.9964730166743841, -2.6131406418141676, 1.1000299261445232, -2.724574944455374, -2.804562809586082, -1.9885374271063199, -2.8676487801345645, -3.794628370923319, -3.259393432981719, -2.1671562349049953, -2.693384032432546, 0.10759515910808039, -3.166736668355222, 0.05754077141678474, -3.4425210858194153, -1.1404173918160778, -3.285255798003059},
    {-1.9345988033506396, -2.4742309169848737, -0.801718843905636, 2.018488891314938, -2.383455180544487, -1.7636529437161186, -2.579326821423295, -2.1451992364906394, -2.475857204268792, 0.3562864442347489, -1.8663070727916753, 1.7921028733029651, 1.0253481542081793, -2.2851318546735477, -1.0046546733136401, -2.4727539717130367, -1.7881033760489848, 0.06357425427041893, -1.6238721972781696, 1.343587569117994, -2.0236961005152465, -1.3167839837065727, 0.16792783426999877, -0.08752654008121309, -2.1462732929817294, 2.1344386265548745, 1.2033401197637041, -1.4965204461029862, -2.6461118328530455, -0.5268616739743807, 1.2374362658966636, 0.18254977066090913},
    {-2.1037488349365727, -2.2523694905895, -0.4435610467214626, 2.329791112416751, -2.3793353920029228, -1.3690094453907364, -2.104659201002454, -2.1648178323241862, -2.6904075499758116, 0.09225754097572803, -1.7005520437929829, 1.9917493758343543, 1.041493724495131, -2.522050702917418, -0.4817961979908694, -2.3244507574093864, -1.6492043653317272, 0.12964493965781243, -1.8204504176529268, 1.5890307711868126, -2.11481716227427, -1.0704430329310255, 0.04457349828497398, 0.11569005303632077, -1.955772899713233, 1.847860925504545, 1.3944514905816596, -1.2173004082295953, -2.5305198853392152, 0.26853278708336376, 1.7538347180122114, 1.0475251500628506},
    {-2.248943079503231, -2.7495391687282447, -0.7010426180150209, 3.177948955373858, -2.558543710648459, -1.6294765679900693, -2.5200866273366964, -2.2086062508294217, -3.244140919489393, 0.9594906734836196, -2.024096369375083, 2.3511456741695307, 1.8122189287964998, -2.4055855995338224, -1.036152887539451, -2.859224907371236, -2.3127048237447645, 0.7313351023282034, -1.8098969631947972, 2.0373707845969045, -2.543031601197419, -1.929133137961262, -0.11889005660466055, 0.17058343683255695, -2.7393307103411875, 2.1686906637886985, 2.054732975791312, -1.8960172413298264, -2.3828818729148598, 0.5222582793524264, 2.310338739101691, 1.391722546273815},
    {-1.267938803891335, -2.390690559463401, 0.05572847629094661, 3.228992910920279, -2.631367456930998, -1.320588822704111, -2.1522027069966914, -1.8237197982472286, -2.8792511991281176, 1.2745532855636137, -1.7981381581762346, 2.5259348599023936, 1.9331981027340932, -2.057035393490544, -0.46117779717362883, -2.216740042895982, -2.1084128298668943, 1.2600666687656539, -1.9475181335706562, 2.2399716240823286, -2.2492183664530976, -1.3642725964443827, 0.1172228433749157, 0.559083744662071, -2.224440420541171, 2.301761351037274, 2.3760854126929867, -1.3254354413130993, -2.531855865004747, 1.0587315110569506, 2.164121806795982, 1.4489513562168725},
    {-1.4154839556599024, -2.105099512676818, -0.07668912860223337, 2.619154558706935, -2.6616849762773165, -1.0457564435599196, -2.1728735117529063, -1.2389187198155367, -2.5407273266817683, 0.47719724312894896, -1.2288913662754335, 1.915841205468568, 1.4745953217963952, -2.459232508689638, -0.3029018177660365, -2.184173655182025, -2.205325822798069, 0.5736954943530029, -1.5208453877220431, 2.084161585953743, -2.4027019405908714, -1.014353002330824, 0.3536999289810611, 0.9597552350066026, -2.2069003695635696, 2.459444187260713, 1.8480761676416, -1.37578797987735, -2.5538249018598815, 0.9522149354446321, 1.9038000416627032, 1.6039538643172522},
    {-2.0362140879350155, -2.6307823265754178, -0.7901245532617183, 2.7755236540977255, -2.680323444121499, -1.2601905701409097, -2.0869004304674594, -1.5571470607094935, -2.7491224360577027, 0.5289969299415768, -1.7925468379364973, 1.8690205894784768, 1.6080216750162544, -2.9010409386560574, -0.6558370367720073, -2.554334307028289, -2.0868908850279215, 0.5953177938838871, -1.6038339678295503, 2.2293614855799166, -2.474604196616866, -0.9634534494313105, 0.1511237592743477, 0.7683937173953026, -2.0150833590993407, 1.8943494411344037, 1.709386464267345, -1.3060462689825725, -2.4333740271345867, 0.5759195237830517, 1.4121037570512038, 1.6385874258254274},
    {-2.4301387092413336, -2.700020417385506, -0.8703377261245557, 2.8718719929976353, -2.85897672490742, -1.9131922291751862, -2.3667986750980723, -1.9813242861007334, -3.062472919201606, 0.9800308031380172, -2.1774935065045518, 2.0042215214076475, 1.7747973935669243, -2.4896694809371778, -1.0333666455888337, -2.667769908300042, -2.305369979736172, 0.5556631262420252, -2.115845690965792, 2.1051125327332367, -2.6425802070506106, -1.402366471809483, -0.23162549811460775, 0.4226353164630602, -2.4985409397200575, 1.7974338010929483, 1.746943744965086, -2.175530171991272, -2.8415523903818167, -0.1809262741836309, 1.7930515748668723, 0.9985037784635072},
    {-1.8070574753439943, -2.610186951987402, -1.0746743396435328, 2.703929659175948, -2.7332668062165357, -1.6320468258942828, -2.649302746082209, -1.5253701908365824, -3.0243937428849264, 0.9630149774509499, -2.182776003210797, 2.2992378703603533, 1.6788855642538498, -2.820063662045138, -0.5385390349033761, -2.725484337957396, -2.1007409078752777, 0.8405226600218776, -1.895892454312376, 2.5662594205914817, -2.5811529013927252, -1.3204158654389513, 0.6931615790781376, 0.8889127159770458, -2.2559873685462315, 2.158048179036204, 2.2139530877024463, -1.8164185450610375, -2.7498887547659048, 0.795418224705766, 1.8465169450349412, 1.6575876832213983},
    {-2.356101510812643, -2.657449839584007, -0.9928812565487727, 2.9646033310152475, -3.1388286377913617, -1.5573888002500678, -2.8551582453675377, -2.188337835980816, -3.1552795747789375, 1.0361547745178072, -2.117350383552793, 2.4659456079546795, 2.1070693688270934, -2.866636122053904, -0.755249896341907, -3.0010606047109456, -2.4385848387222997, 0.5612248000715772, -2.1570708309160045, 2.611735317222163, -2.7955941417020296, -1.4025625590664172, 0.15973467402932165, 0.41451273162853536, -2.650617441077541, 2.3590609646033367, 2.4343064149455778, -1.9296918253624142, -2.940236207212086, 0.5265687644208077, 1.860892425433809, 1.5054258472715951},
    {-2.0759077408087108, -2.7716108226524105, -1.0011464128420255, 2.9087607242982743, -2.7179666886423273, -1.941641682265701, -3.0068041048029404, -2.0454836352693593, -3.246800495866874, 1.211437771143164, -1.9418176557052114, 2.6959444925687297, 2.3587326533327735, -2.647164166316541, -1.3015263009035394, -3.0871448493946048, -2.6768575291125454, 0.8734360872475564, -2.272547219241558, 2.3496055481307248, -2.5495517045909932, -1.5700763413968057, -0.15819165743640123, -0.01124756931416531, -2.820670259372846, 2.2184094582875526, 2.394433595976645, -2.0060035368238713, -2.838734663616667, -0.10064189001283128, 2.1104172033917536, 1.322534928169302},
    {-1.9830757322272585, -2.6868594867497415, -0.28333278842717097, 2.899502698231611, -2.7412220190348133, -1.516783424142841, -2.708519205606316, -1.7257988222609544, -2.889238988878273, 1.1159709447959631, -1.8545273565348965, 2.2230583748902095, 2.2193384400514162, -2.4751332685132525, -0.9949530279904957, -2.5522132137434665, -1.8925641467999197, 1.1721564121036234, -1.8699683230834887, 2.240529721205653, -2.439667599077347, -1.7690341819872533, 0.3005690261956449, 0.15251002137433328, -2.2291427112792106, 2.0947229669997474, 2.1272429324024076, -1.5385591707218578, -2.45675827660285, 0.018862186904796664, 2.1221339707058435, 1.2194322179178887},
    {-2.1918418201170264, -2.7915401747593216, -0.5948734743986073, 3.202979170549815, -2.7416807700086525, -1.8548767355990907, -2.656509021947411, -2.1232799681031302, -2.9999573502006687, 1.4426855155071148, -2.2391015806258587, 2.6269389470365168, 2.248452558799599, -2.8883661037286985, -0.6576126504442094, -2.8146094347508606, -2.4100436423896787, 1.2974106571138375, -2.0464908099252086, 2.5394969692055778, -2.258469067182295, -1.75713173942623, 0.2516098681999428, 0.6100317234782107, -2.51093452117453, 2.409830981343671, 2.3304788946537283, -1.6422086070296218, -2.99367639364777, 0.3450568922721045, 2.147759128345409, 1.3376854495855561},
    {-2.4405611418341766, -2.453515140568134, -1.1271796109512446, 3.1398263354393277, -2.9761304907253505, -1.6636621520283255, -2.353247185343402, -1.9475692789216634, -2.813245567368099, 1.0967825568323897, -2.2868384105300157, 2.670538462323034, 2.2877023981173528, -2.9697508978190426, -0.791803011300912, -2.400187935195538, -2.755328958688946, 1.177096928458965, -2.048303931248558, 2.76300665298787, -2.4422721194754464, -1.6557276390588282, 0.20934288955359495, 0.5570128256071274, -2.4439010054709045, 2.3847527492927196, 2.533886770999351, -2.0017972800028216, -2.8396780779797632, 0.20393994971279505, 2.3782353297886902, 1.4700436412799656},
    {-2.397896754749531, -2.546754910540844, -1.08104823030945, 3.0490583639796833, -2.699554391744153, -1.9831186544000765, -2.6032017334247914, -2.237310252816858, -3.152512471431954, 1.3870493440874507, -2.4531752629355483, 2.283858715971937, 2.219411928870384, -2.591369855634221, -0.9991812619443575, -2.7434899985947467, -2.6790884073127046, 1.2977773733117497, -1.8212800394661026, 2.2272574910350404, -2.371608365377162, -1.7023190036607818, -0.007159092777374886, 0.14467783102484352, -2.7062513326572084, 2.500783813524905, 2.2710120144665447, -1.7645571479320974, -2.7776835200461183, -0.1449634766090368, 2.4280265292179823, 1.2088713324236275},
    {-2.186401837312664, -2.8558992853841985, -0.9266395220266541, 2.7702222471769895, -2.743970602179884, -1.8413836482470702, -2.639776476713406, -2.1468841651169095, -2.742665698503341, 1.5048114292026253, -2.2256102009975236, 2.522567210037173, 2.409061972792494, -2.353777810803432, -0.9479229862872828, -2.419287893590324, -2.4728212873024256, 1.2521667931698095, -2.011340186365368, 2.3678488433053198, -2.531852106033042, -1.7147628698022914, -0.25109127732608694, 0.28639063801485737, -2.2726532396652113, 2.4006488639736645, 2.030981429639969, -1.7023435171296653, -2.797283358321193, -0.04248866030413459, 2.342385741518303, 0.8112966613654662},
    {-2.417559960804295, -2.9292861585358736, -0.6852988599614618, 3.4735398212812174, -2.867223925155932, -2.0162319161066997, -2.585556541775159, -2.355473163406019, -3.151904839691563, 1.3475005298702367, -2.116990483992335, 2.3401600114373275, 2.1794956075634553, -2.6359861768712167, -1.0703767038792567, -2.9481151855062655, -2.5729717877611487, 1.1926253219354885, -2.3890074741411205, 2.4408604452572895, -2.7187527132299283, -2.42391632655672, -0.12831435021200785, -0.015534689451558765, -2.829567876721166, 2.5618806627343766, 2.7563528468108625, -2.066573757946314, -2.998353004801066, -0.06507342702439016, 2.7704062135565057, 1.4059691014664264},
    {-2.8872083609993147, -2.921963723315896, -0.6057937970757539, 3.4110906914808616, -2.4973546338645805, -2.171919985604732, -2.8478339672814212, -2.6228861888155675, -3.0781760523376644, 1.1112427439016752, -2.501533222933159, 2.523637438921576, 2.3265541809762293, -2.7352614228572842, -0.7382765879473303, -2.8541512132446236, -2.7977466043871555, 0.6959845808868329, -2.481995528933704, 2.5397688462753862, -2.7292611069541715, -2.154834250497366, -0.29397761704041087, 0.4466805567993609, -2.826443659084283, 2.41202975222462, 2.8234897949919455, -1.9093794632168823, -2.694504874842449, 0.3479265377432828, 2.4319096676736183, 1.586316638226758},
    {-2.547895838989197, -2.7868874207928154, -1.116632894207732, 3.5824153531966987, -2.650340493517091, -1.8655456517063853, -2.723622615942732, -2.3727746101033294, -3.2060586214279243, 1.4168219102509825, -2.3651987164137527, 2.600877736834613, 2.40727290318471, -2.614305702806492, -1.0117893340350763, -2.9944244373875053, -2.585337022447434, 0.8283760422126077, -2.4071501126713755, 2.9502909861318014, -2.8528645277130105, -2.0200621646026877, -0.286937163980904, 0.11444893619578056, -2.5371189671908074, 2.5730926082053447, 2.5649877992162566, -1.941905600115501, -2.8131890088675644, 0.0028668012860866444, 2.5442238689869665, 1.554599964593997},
    {-2.2251305100028955, -2.71434863603917, -0.6865532941123847, 3.3654702883748806, -3.1373314456354944, -1.6088474990465105, -2.6114459220557373, -2.17141975187629, -2.9452281240968836, 1.5376983026163007, -2.2796674074492573, 2.5867495026015273, 2.152058248467782, -2.4508131351207156, -0.8928917313963783, -2.779365942410229, -2.7374570567769396, 0.7737831855884042, -2.1292212963322363, 2.766900338495058, -2.8333104261856272, -1.9928331140387154, 0.023322998156560793, 0.6603185309732619, -2.907926863101854, 2.7657779828755076, 2.7361502786201486, -1.8303799300633794, -2.563883334923343, 0.3834724565246648, 2.7418212117293037, 1.460826171920892},
    {-2.190135404210933, -2.7871450487594265, -0.8239723062401475, 3.381763667718738, -2.619470949463511, -1.685054944045623, -2.858926238792062, -2.1598000465982214, -2.8681274451479664, 1.6058282396052754, -1.8973922114638884, 2.7972627545669413, 2.4551322383813603, -2.2716719540585415, -0.7621400034273644, -3.031824159314425, -2.5910491951312276, 1.2365730447439784, -2.0032965273984495, 2.7160237737986823, -2.8522894396505043, -1.6840418253578657, 0.5520015651618045, 0.6223697943364938, -2.921498171583182, 2.965483467813035, 2.9352050906144838, -1.8084866115676304, -2.640447855489484, 0.2733876650890598, 2.7724507981490687, 1.7906725001897625},
    {-2.3329545984994753, -2.912410419704903, -0.6724511710636166, 2.9933054853895555, -2.8569175959704376, -1.9268834927896359, -3.0490031658295185, -2.647654172706611, -3.346832683396957, 1.0742705009570108, -2.1974548128386595, 2.6380951199140097, 2.1701746464768292, -2.8158532019868794, -0.9732698236811878, -2.9353709613518086, -2.713328560841035, 0.42360530685249914, -2.189448450036966, 2.6732450926774542, -2.7519454262651806, -2.3181192267316604, -0.07596289745806221, 0.6023119531758243, -2.8255048880687643, 2.787230670596676, 2.712791832912402, -2.0039828280722976, -2.810965773482892, 0.2117265093409777, 2.365955271779639, 1.5127501988237066},
    {-2.661330889153659, -2.9830217456658117, -0.45512467978276094, 3.658175161200286, -2.666886785892663, -2.2372692302386277, -3.156862616976268, -2.498712359483809, -3.0447034251316416, 1.5310389478933701, -2.501082547025269, 3.1831103787642214, 2.4798283962520236, -2.755885136974841, -1.0346716347020495, -3.1377679141341557, -2.622269263463276, 0.9366769352240356, -2.471267716721829, 2.946557948731229, -2.96542538091362, -2.3090302142064174, 0.3223032609344389, 0.8533753485279941, -2.928273777947279, 3.2373363247993012, 3.1730027321260277, -1.9539919525184108, -3.051973779668308, 0.7001849157081758, 2.5487700250210352, 1.6909416275414564},
    {-2.5654355558073387, -3.4213011955114725, -0.46712098338521857, 3.751342573056309, -3.2600360625209386, -2.483882487665246, -3.2996289622829824, -2.7898777534826045, -3.5495825696664918, 1.8085484911898497, -2.675411584275927, 3.0095567307127085, 2.3378930473741937, -2.743191476921768, -1.0113491632458051, -2.961957544421149, -2.8260260417791554, 1.3040741464215042, -2.5933662945342237, 3.02972480027789, -3.1051250106616, -2.4941189787960716, 0.06438691894617632, 0.5200615444004264, -2.964202745785523, 3.0735447016027178, 3.269169885302434, -2.369162064187875, -3.2827638224808187, 0.46767831363167933, 2.6871891016493183, 1.6518335486488978},
    {-2.7422678062752945, -3.3627861049441603, -0.7323034158144955, 3.703456161847435, -3.1117293592452833, -2.3836335037606524, -3.2669783437568216, -2.5301542492240703, -3.7337577930347465, 1.1514125341863726, -2.868680966038499, 3.0203029429396793, 2.3207221421253896, -2.9129497404194673, -0.8470868298629698, -3.204335710799252, -2.890371564785852, 0.8740475433563021, -2.6683439980480084, 2.9651152544996404, -3.2726546665973713, -2.538651360564859, 0.19622138688840682, 0.5162914825033731, -2.9854187537126085, 3.023168996503273, 3.3076999902443407, -2.5478238768855475, -3.035030076307699, 0.5269787982979656, 2.3883887090565112, 1.747195542692251},
    {-2.7692416713173422, -3.1700014395553717, -0.48664415394647903, 3.507262764054695, -2.7977227135668503, -2.5104027521889134, -2.93339037028725, -2.709108173927983, -3.1802266381206965, 1.4693680376041116, -2.499512992908016, 2.8866060062403527, 2.412934713074672, -2.673057837504148, -0.945088903114645, -3.074016241809118, -2.7476540894022734, 0.8134050199589088, -2.4644247869083826, 2.8444045478126454, -2.727573823528982, -2.11810147908641, 0.31372317356767054, 0.7192308525003941, -3.0971152063235663, 2.858536657085988, 3.1205299899671433, -2.3306432769041994, -3.0734181900725344, 0.6975275420024202, 2.4302423614901363, 1.8534543861826336},
    {-2.8209608601541447, -3.361581538078531, -1.3584292517129517, 3.18067981708277, -2.966374208704917, -2.5500917863836703, -3.4890676772808233, -3.026544116249448, -3.3958891971734078, 1.1466003140077365, -3.049876208655625, 2.8605684298894567, 2.5182070608295146, -2.990978739816295, -1.7501800807318078, -2.994627420960015, -3.055339203803706, 0.5502755013015582, -2.468526158626609, 3.1881904758265613, -3.0496946637442868, -2.605806235069239, -0.5136319695131608, 0.5995764443806679, -3.1821632624348806, 2.8119489476620196, 2.7026515097535624, -2.6295028095640496, -2.909065838229828, 0.08707130203392438, 2.3665221624068242, 1.4507445851912344},
    {-2.676479540195781, -3.304484394765792, -0.8291901552969319, 3.597521157284934, -3.061516490641492, -2.574031018837026, -3.643192066109408, -2.7685028889566987, -3.5527775511951996, 1.5944483784368728, -2.5803920171621444, 2.8974259656800534, 2.248771370397685, -2.4107384732953205, -1.4601090419685092, -3.209496625239756, -2.6378185957551494, 1.4868166605498445, -2.2459756505821327, 3.12799989247944, -2.9536345756154705, -2.744667516094555, -0.12648480708208823, 0.4926334975770206, -2.9598098611258186, 3.0986292102937796, 2.883895749074183, -2.6607238762713328, -2.952248494337041, 0.43051083473604984, 2.684889189294709, 1.7977595587858555},
    {-2.866452382902288, -3.2823450472910056, -1.104900614919346, 3.4472401056682624, -2.821516521463662, -2.3242007019113444, -3.1877259733662022, -2.8934715139421825, -3.5332000712618963, 1.3550213355994325, -2.607966215297021, 3.0661799830021015, 2.3844729265493676, -2.7647091226716145, -1.6055457074768849, -2.915475127299015, -2.726824423407948, 1.371864861583863, -2.436206785222722, 2.954971167863001, -3.1449946305389167, -2.8606311582402433, -0.5161248694795105, 0.10712919615217646, -3.2443775203002354, 2.8669392848316866, 3.0330070277508008, -2.777264257000379, -2.8861466415101398, 0.031312146613352076, 2.503608543352015, 1.2815113188750789},
    {-2.965280540953505, -3.2698855675539606, -1.1362904820383397, 3.4105919835134446, -2.74663501587621, -2.6071034130502633, -3.4530324339092595, -3.1346149665147296, -3.426763551500728, 1.3703541242629935, -2.9222157403546403, 3.094510909893524, 2.4584821602262044, -2.49082566551274, -1.7786064490307993, -3.1512748972548765, -2.865933844552912, 1.2699951468837813, -2.5641602442571867, 3.058406656561208, -3.1195984756675292, -2.838363383037461, -0.47374559306886926, -0.009222401479914462, -3.1080714237960114, 3.056182990470312, 3.0265202381132523, -2.955766877082144, -3.30056581336535, -0.17310897730750907, 2.5715599759607954, 1.2727709604042758},
    {-2.942919572767561, -3.549176681711481, -1.0132389069880892, 3.47677741116585, -3.0327778508423067, -2.7683345434810214, -3.47928634082946, -2.930148442243391, -3.208566881016988, 1.2845244864149752, -2.968847533217012, 3.1057872173273187, 2.41327798437687, -2.6476590424683084, -1.5562080195073205, -2.9084655752968724, -3.038681815053221, 1.3718242424020006, -2.8518741295173733, 2.8716702100621827, -3.4081969132605456, -2.785598367576626, 0.19437592121354405, 0.10389819040075271, -3.3145476879582008, 3.188681440663073, 2.8228331761778147, -3.0101344620768176, -2.7472426718771685, -0.007774560388078671, 2.6456750033340857, 1.6333762621125956},
    {-0.03355353463975252, -0.2461010213743735, -1.7271439633859036, 0.7956804015175273, 0.2434956746587177, -0.6279164577990125, -0.5909128321915399, 0.495673066487684, -0.22733057916142216, 2.101576077873794, 0.374109348871521, 1.1610059969903228, 1.2727559429179844, 1.562595925500446, -1.5788973211300228, -0.4140921449269035, -0.9359978612450142, 2.2665721648265182, 0.2651702943676683, -0.04040432940801631, -0.6974362779909392, -1.0032234990663136, -0.20123067631910305, -2.073040892117723, 0.12827382491167835, 0.3474996234154925, -0.5528959884236606, -0.7132597074732511, 0.23851370802555596, -1.931687041534771, 1.0878078034450833, -1.8142982593144465},
    {-0.7762730175498874, 0.1833670067491521, -0.41557919031420265, 0.9377200350530934, 0.1380288905134349, -0.4479860816533433, 0.0610055522050327, -1.094579115937214, -0.4150251224915168, 1.3569323586815545, -0.6291012983080069, 1.543513967922953, 1.8806222092281903, 0.7402171242844113, -0.5917993259271369, -0.13124920243467847, -0.6624484261946844, 1.154566342835364, -0.3343738089328958, -0.07295007954530466, -0.3796569617349215, -1.0327213084938442, -0.8215889884184329, -0.49907204663564253, -0.5795976139282798, 0.21412114469829416, 0.5822818782883458, -1.1239934852089655, 0.13261152083069871, -0.07236584938189884, 0.9252686007626313, -0.3522026954699625},
    {-1.2357651159180159, -0.5581355925605038, -2.477305820201196, -0.6167884730078929, -0.17983369008319378, -1.6099510400437615, -0.5156276078069936, -2.12980339237177, -0.28714456728516374, 0.1424384652566739, -1.4148971987524304, -0.9995823054347065, -0.5737904781650498, 1.350690856785042, -2.429861308564749, -0.7455217245445619, -1.6237082541525658, 1.1071061240938864, -1.0819859496432296, -2.1005247466545995, -0.7609945753569568, -2.2440134424046785, -2.0732320533380735, -2.779772472889556, -1.0104977292183883, -1.9576199420532452, -1.084022215681287, -2.043181640835448, -0.025680179175454752, -2.7308139663684354, -0.8558143776499371, -2.9028611350738918},
    {-0.4176493102157616, -0.6174754675349465, -2.1626045605628725, -0.6349410674594447, -0.6681212690018266, -0.5870192788664985, -0.17408470282241847, -1.0476158335239032, -0.4573786300212635, -0.04624128061596128, -0.7167601152178046, -0.6487531201123611, -0.4299233801333037, 0.3865155277946774, -1.5517349444578004, -0.8570912833203514, -1.0600868545541866, 1.2111914019705963, -1.103398511566049, -1.3274457930534556, -0.9995823428164431, -1.475040887263017, -1.459007538264282, -2.3616373547046443, -1.0714273706952824, -1.0771288408167394, -1.1223294555247132, -2.035265193147631, 0.06120784223296653, -2.3775261688864893, -0.5285667445288552, -1.740084751207874},
    {-1.7157723687792374, -0.9366833435415367, -0.9849729142839151, 0.120034730491818, -0.7605305372851705, -1.7404933529520237, -0.5575716658294585, -1.9594797806003408, -0.08523380144831612, -1.311687784048176, -1.9287240058893442, -1.0758654755399324, -1.5156209472582653, 0.7000175908413941, -1.1289381808605325, -0.2432071538070128, -1.0241662414855262, -0.2737875936068516, -2.2740216955165367, -1.2769404594243234, -0.6815969844306426, -1.3911770660129057, -2.172305694344693, -1.537954637225627, -1.4362810687419614, -1.618057237838492, 0.027908972759502125, -1.7819192606835335, 0.22467389442158253, -1.256851401676058, -1.919671766245912, -1.5150010073099474},
    {-1.5927932289932956, -0.8846081134969069, -1.077561852550989, -0.9155741325422326, -0.47819872319202156, -1.7990904254825293, -0.596329503563391, -1.8443370190074182, -0.8898693245749505, -1.6300175544807414, -1.8138830664759817, -0.8566773691446636, -1.460060528384632, 0.6626857301192927, -1.1482184880730455, -0.6090330957298732, -1.0764895070160205, -0.06938070013206862, -1.9527152947224637, -1.5831601345466848, -0.9831106040320007, -1.4029021510163808, -1.8667237158829233, -1.3544355273444035, -1.3573555780568647, -1.6162935004919774, -0.272209245317543, -1.519663643368365, -0.4645776407151462, -1.3350614767683369, -1.526863557695936, -1.635147252636199},
    {-2.063317101502282, -0.9518973506850726, -1.3888527927364942, -0.9354519793078451, -0.27761110271480693, -2.1446736116505476, -0.6799380053375534, -1.986733721364334, -0.7486661116370978, -1.7628055185497151, -2.008053813062893, -1.589880160137611, -2.11285326269194, 0.6127708369517318, -1.9806219319482263, -0.4985330666191953, -1.0936117982498645, -0.6156258809830177, -2.1764530038896095, -2.4558675499535063, -1.1710708037183197, -1.9555387669176958, -2.30139053702568, -1.932740650665019, -1.7509046489016409, -2.4262800317612094, -0.6771989718885654, -1.968719736232071, -0.5648122425296644, -2.11768959986428, -2.2433079358426355, -1.983441160486527},
    {-1.4127713970474691, -0.7867492732034275, -1.5512098186974652, -1.1747538360057974, -0.4580202741509686, -1.8204871698571659, -0.3398327280643961, -1.7020823299872705, -0.5529140990410137, -0.8164642688342061, -1.8617305753904536, -1.1764269129273976, -1.39683483501846, 0.9490737896497128, -2.116298869759739, -0.45289777586185126, -1.1224143679845415, 0.2998802413687352, -1.7979375887548295, -2.0287505510862065, -1.0022607712288831, -1.5959541557556094, -2.3436144391035616, -1.5377962225761022, -1.3927241342372758, -2.41843005503141, -1.2185377511332536, -2.1588044739579293, -0.5383547928105643, -1.6738506662353843, -1.5490717032237937, -1.6876512176120002},
    {-1.3724464089300814, -0.5766456113976418, -1.7138683476742353, -0.9808007873563235, -0.39617912489158946, -1.9889988158909955, -0.5893274121900638, -1.8797218478072157, -0.543558547186335, -1.3121203474716487, -1.778301811398348, -0.6906887808156178, -1.7757740794638224, 0.24665130331041052, -1.9963844370511827, -0.40578676211834924, -0.966973883505497, -0.008447389889960102, -2.0901206672642187, -2.0995803536135695, -0.965388198516094, -1.9881302148809865, -2.696398493590492, -1.9300540742193881, -1.5858232908435876, -2.173210848199435, -0.9696732083978499, -2.1809720108834014, -0.5821238547308091, -2.004292672940469, -1.5561291389141592, -2.1816203045998828},
    {-1.999972772976881, -0.6947498016582875, -1.9414108943035866, -0.4195598264295916, -0.21839676619586357, -2.5342042053321285, -0.5097290892812406, -2.1770180240574377, -0.5389203631024764, -1.1512317146484605, -2.068738896191573, -0.4389819388531115, -1.666112924524977, 1.0976288792551596, -2.349259436063609, -0.373791828614174, -1.6225864232293559, 0.25843844150046236, -2.1281343293180237, -2.23001081308215, -1.0142053510088442, -2.1073882388539706, -2.855963567898548, -2.196605818156356, -1.3517575137679556, -2.013769744070221, -0.22358765953107698, -1.93588798416787, 0.1499195027261871, -2.438718720501804, -1.5463511053246017, -2.2196041492636036},
    {-0.8011643994001904, -0.8126388876896028, -1.4660246412198972, -0.2648995302091489, -0.2422965706747461, -1.4915639037836665, -0.5657802197970034, -1.48862137891216, -0.6065949881638055, -0.4253061043032789, -1.5629938379850163, -0.29843254875504366, -0.9967373810695773, 0.8481695744203226, -1.9004672495786463, -0.7750691059465515, -0.8702718408568764, 1.106918349387954, -0.8135398552682644, -1.8226428749812722, -0.7075319427764276, -1.6935084090686698, -1.4603548500556134, -1.9314874816951235, -1.06578976931379, -1.5501836010975605, -0.6242736129305254, -1.6562247892622761, -0.05827703563266483, -1.8411217636753916, -1.0950904422360512, -1.6203123445080638},
    {-1.5634117187989278, -0.6821925577043821, -1.7075587212157228, -0.806306425495838, -0.5344576963320516, -2.042234853942287, -0.790434927307157, -1.5891091769982675, -0.5855495375453633, -0.3120683013252232, -1.7602886640158522, -0.7435306738780557, -1.4083715872913165, 1.3262032050841597, -1.9147949970765412, -0.8126530868104951, -1.4736657895460485, 0.5614620488630657, -1.531806062391727, -2.4434594332689095, -1.2824717125380831, -1.868329830272202, -2.2525107227100096, -2.264608824153273, -1.4944497024679868, -2.0130735613117783, -0.6938706328448491, -2.1005523709078284, -0.2527679959727231, -2.2146684325949595, -1.6321085050040187, -2.0171904970461836},
    {-0.7973034738245832, 0.007870197806289074, -1.5485407673483893, -0.7911525111785711, -0.12948247317432854, -2.167187095646486, -0.5846833086499866, -1.5488037098310259, -0.39456761715095845, -0.8993064764619747, -1.7237194099138176, -1.0880478462462464, -1.271623920378894, 1.1058816279478874, -2.047573415094473, -0.22889178825460457, -0.9506155313382673, 0.6591478965568582, -1.7504691695464194, -2.079554485328359, -1.1790303162348381, -1.511594957804494, -2.3356486677850223, -2.2089789930318733, -0.9156119473602528, -2.36298104635481, -1.0165442374331517, -2.0767998243465255, -0.016168609822076963, -2.291692850576337, -1.8342838253902536, -2.2049305750203048},
    {-1.419431649497034, -0.6063283464321725, -1.171096000855544, -1.1623431970870235, -0.4494369339021913, -2.150663089230871, -0.7070302657469452, -1.9184841597290838, -0.5778215355905574, -0.29562345518261496, -2.0248969858824144, -0.9501238550990702, -1.443901288783842, 0.7046085501756852, -2.37519263522771, -0.5620725659851116, -1.6724347521758662, 0.8165872214266972, -1.8805473495562433, -2.7976891717565437, -0.8621786781229064, -1.7926091876664298, -2.7924424997838733, -2.0786627268512885, -1.5182986805803225, -2.252467423451083, -0.8162936186754919, -2.2043143783759107, -0.13989135045919796, -2.3918476214896747, -1.4187717124638795, -2.7275748803402493},
    {-1.7553087687919393, -0.5920357097986121, -1.4221239144356863, 0.22314369539741616, -0.3292194168305899, -2.2919316772946736, -0.5399440237917325, -1.895171404083196, -0.7329144187534076, -0.20046437053682983, -1.8024709052767436, -0.16314802777227416, -0.5284275946100425, 1.4529118084278168, -2.2052891838568476, -0.5619168415805885, -1.398329072637859, 1.0070322711074047, -1.6644987089051662, -2.063392896228722, -0.8743451775640543, -2.1384984884491542, -2.832102284037894, -2.305884878542825, -1.0300772963369007, -1.6015232588173325, 0.03426670889707316, -2.2508813764503044, 0.3184128534954189, -2.3501630110587364, -0.9926868176454162, -2.4292392613144753},
    {-1.6376509985225596, -0.9586367990131386, -1.697799594071726, 0.06328221566092418, -0.9268422126586653, -2.4002162489073857, -0.4019164179208124, -2.3201351314930316, -1.1156064101977023, 0.21379734826697513, -2.0377466568924314, -0.3415194438580152, -0.2594823502103146, 0.7686463044733872, -2.353045175152402, -0.9030789834662559, -1.7746540474273542, 1.268293523189723, -1.9355264350940329, -1.875509081336364, -1.3526647918373806, -2.3777615041784816, -3.0173521713230262, -2.698834866621468, -1.4154902998887808, -2.0359926658099523, -0.16465160369345247, -2.413696271226381, -0.18029523427878105, -2.64484341620479, -0.6199538013245153, -2.601908299281589},
    {-0.8386415177026209, -0.722498651138301, -2.1261022731254573, 0.23598706033480954, -0.3797716571402667, -2.048393616351548, -0.4377075543639618, -1.8339133918643609, -0.3205974938313057, 0.6800410339015321, -1.544117320616203, -0.4627622617126357, -0.47744458272081697, 1.3762017401541562, -2.390583892792492, -0.30676364472407736, -1.4944890338495564, 1.375914529434959, -1.3968537312635276, -1.7155450482768102, -0.6260305536192359, -1.7408599036733883, -2.4470300879789897, -2.688258488961472, -0.877933651969573, -1.747946749778084, -0.34981381402630957, -2.307396508911451, 0.5401595726192824, -2.809306067713379, -0.7264243620342067, -2.4025462732749943},
    {-1.3349828898351968, -0.6791689742911723, -2.071940143290252, 0.12173400684822673, -0.3646111395598757, -2.3777863717554877, -0.5554112967564467, -2.153542442916691, -0.3399776722839147, 1.050460040753543, -2.0601538516062567, 0.4740876752096364, 0.2440230916709082, 1.798629579607585, -2.770021211076618, -0.3230955172382047, -1.6734566637736992, 1.6318210780241533, -1.4514384906142757, -1.7135267029737327, -1.001516560268711, -1.9843885862063488, -2.9141677108157986, -2.797813823274699, -1.2412610610436687, -1.6336434370805755, -0.18788535239447124, -2.804851802875198, 0.27383459938535537, -2.5234502850437597, -0.11243786552142992, -2.49910109688561},
    {-1.3829604909348794, -1.0563707048284323, -2.1415955955353905, 0.6359753063817525, -0.47876382614166735, -2.1250866112853837, -0.5742610903048735, -1.9266417589094782, -0.72427619488912, 0.9731845772460277, -1.873357320207127, 0.36422564457026924, 0.10837807748157258, 1.5812095644549862, -2.5794484347272855, -0.6485009725419365, -1.5631398426999286, 1.9668361370379672, -1.0440768440399448, -1.8077013971610438, -0.8240781392246129, -2.0738373833590393, -2.3231504167412473, -2.601229420424993, -1.3560314544716239, -1.6531906372264304, 0.000320499069427742, -2.5307109554335407, -0.23481123687736338, -2.6596450485891707, -0.202799103865602, -2.315614677924168},
    {-2.2769333722553387, -1.375091030131948, -2.458438250877172, -0.836375715730184, -1.0375414149406874, -3.064565524129221, -1.1627464031050867, -2.8626640441170625, -1.23921748968945, -0.4431935843885155, -2.4772367198425096, -0.7695659869404611, -1.0773492469652997, 0.7819207085347031, -2.9588821108293892, -1.4390567091105024, -2.3312102135959125, 0.7220285724639348, -1.9904349491397442, -2.981445823620424, -1.910948328361728, -2.7281512875147675, -3.1596474395551857, -3.052266643655636, -2.189361778260915, -3.0294305427815944, -0.9825952337639068, -2.883404869196958, -0.7935653525763177, -2.9834641670604887, -1.5772118542079843, -3.3223359607419876},
    {-2.1783791498379816, -1.062259283593741, -2.4288980907251725, 0.20079334433176016, -0.5088044136034555, -2.8981444991607304, -0.7502309986526244, -2.7945755212334746, -0.42550010643328096, 0.2830267140078134, -2.536522825708952, -0.9650386202325294, -0.9944375288657618, 1.3541107486414026, -2.854783282421592, -1.0675383072525877, -1.9591156624193107, 1.4623665004324535, -2.172291449261388, -2.645539816599203, -1.3766678141641344, -2.4721410524967546, -3.015420677367848, -3.074536064454651, -1.4294795775706086, -2.4363966209429173, -0.27201884570584434, -2.8635739567042062, 0.1737168540851824, -3.24198102990116, -1.549366730012403, -2.8682652715243777},
    {-1.790949238106192, -1.490677222320786, -2.7213543532720212, 1.534408266792716, -0.8526442940881301, -2.6645530175883403, -0.940228820941403, -2.510929995372209, -0.747051830364777, 2.259438856849438, -2.3377685629969007, 0.968918694843668, 1.0524074754428039, 2.4123196943449825, -3.6204095716136426, -1.3621972973061576, -2.2024343289188693, 2.9324981553580662, -1.5851495803969935, -1.7221382929820326, -1.4113821704004745, -2.903130738861266, -3.453078882633083, -3.5173292977352792, -1.5706853727852985, -1.2756689134789312, 0.5199706830877635, -2.959890305180334, 0.20616380061900727, -3.402236267411186, 0.519672602533293, -3.628380715105998},
    {-1.0063371940092174, -1.3208709945958108, -3.3688647559200198, 1.5558840381831907, -0.6536454750052465, -1.8881816934654134, -0.31632025972777583, -1.6837896456759267, -0.22051760341185078, 2.7421995362359675, -1.4620947807349796, 1.979711450994444, 2.0329871451609676, 3.00171230097733, -3.659764850397959, -1.124207816213553, -2.524743817818002, 3.450208145053768, -0.5324594738957883, -1.5329214858186015, -1.3486267459990284, -2.6040202055403476, -3.1715161879408664, -3.9031678395702376, -1.468232536799393, -1.0427281757537106, 0.624281746541251, -2.8707549360252487, 0.40120768527127093, -3.537837400958485, 1.4934477383955842, -3.29933331022374},
    {-1.1916218183854461, -1.1253029814666944, -3.34762997595856, 0.9071319054272777, -0.7427446281496106, -2.618958564259769, -0.6375524627998731, -2.252744176697455, -0.620017045230467, 2.3104659713341595, -2.052508856383081, 0.9759366303348811, 1.0677746389104585, 2.324752983141565, -3.728185376414097, -1.3449723170578651, -2.125507443675007, 2.8864973087512786, -1.1983012027493354, -2.0278658182763736, -1.4410315622546976, -2.672500935306697, -3.5311869415957435, -3.817012107554244, -1.7115211702139634, -1.8613295728445967, -0.18822433278191641, -2.9488236711259983, 0.582645063250699, -3.740583643090569, 0.2811459325429945, -3.711339844650841},
    {-2.285242616841541, -1.6717885806483122, -3.0043624011473478, 0.3591166686954576, -1.3631028823390203, -3.004690739108468, -1.4897757331884516, -2.8958289883383954, -1.4045555208651426, 0.6744210815592085, -2.833228021378595, -0.45420254909595675, -0.19574586977908545, 1.2874655542793223, -3.4431604802666675, -1.5938461075501904, -2.6887211200518615, 1.7663396205094235, -2.6650441226602606, -2.6839048723058445, -1.9247396191492814, -3.1005933422244927, -3.7209538893452065, -3.469081401011628, -2.458468608628762, -2.0769216331094205, -0.8231659290296847, -3.197902061122021, -0.27969090056208695, -3.4877332136086516, -0.8484125181015887, -3.3416924616677868},
    {-1.5349547721304613, -1.346975123889176, -3.20230808367231, 1.526114558090687, -0.3304765016071998, -2.3649681161881246, -0.5480090444255458, -2.198363544061778, -0.5754753365860961, 2.437532140658841, -1.5994503578739592, 1.268740618472812, 1.5039006610738574, 2.369941801034765, -3.5252090778620713, -1.2167787396218346, -2.0175985931675573, 2.591241244383845, -0.9366616152152356, -1.334979065451658, -1.7025760564961008, -3.1199485190802387, -3.0915516749233927, -3.7389791987529666, -1.5970832680800857, -0.8544526498079477, 0.43049851321705596, -2.8252364644867725, 0.39821359752446994, -3.707413491445374, 1.0578851921150787, -3.7667904826325525},
    {-1.792638744365121, -1.3643572744137895, -3.204896236375715, 1.252401446332397, -0.5756760401847726, -2.591541431779662, -0.6238005666534789, -2.2622724051266685, -0.6725907822838643, 2.4609290564762727, -2.1037169862765577, 0.6654341226165373, 1.1487105046464383, 2.618291043495335, -3.764794782422696, -0.7921101132685331, -2.292275222810984, 2.7669139856441842, -1.3362569770023636, -2.1041128644340006, -1.687943058251671, -3.186773239300191, -3.2520257623778925, -3.9932069063831226, -1.7458183134640477, -1.8990136695750128, -0.19928349642653015, -3.249329813557277, 0.28820068309108776, -3.998407627212752, 0.5362990840931121, -3.6708857064105533},
    {-2.073290004820606, -1.7478830753989896, -3.317472469325249, 0.8251660924586186, -0.6929579020828714, -2.8397446584340535, -0.9434771969830115, -2.549560711616653, -1.1755456186239368, 2.1367673685309985, -2.276517250260912, 0.6192786727079144, 0.9647608598671252, 2.3891813111106424, -3.692126207834426, -1.535785736097183, -2.460883540816622, 2.554448291840519, -1.6798000915474929, -2.2064368656495814, -1.6361359634209691, -3.1685620600998696, -3.131766860701906, -4.140590413228459, -1.9376208491190066, -2.0540259676386636, -0.3683022862888821, -3.3672239685886645, -0.2755704460175172, -3.856504598884942, 0.35777555114483445, -3.8766898268184704},
    {-1.9961161135962047, -1.586092034838223, -3.2394465456441317, 1.183864396264676, -0.8534753953886026, -2.655193351944128, -1.1994026562880036, -2.530895103009382, -1.0969446144702384, 2.3322299917318223, -2.1981402249215183, 1.4766406139215194, 1.419615728700454, 2.4563229596961222, -3.850104182154839, -1.4497837484373235, -2.427061740158748, 2.898796139199295, -1.6764968418133568, -2.1240463414563515, -2.23597246288531, -3.037961031834102, -3.1525165740655283, -4.014651065942812, -1.8358272219991145, -1.8258926463780434, 0.03784860442401428, -3.388440053308914, -0.04605728653925553, -3.77784496052733, 0.7884081111535307, -3.5620547976543833},
    {-1.3165471361771823, -1.5466041652914018, -3.1664625867275764, 1.3706568121259413, -0.6744637537779861, -2.6038237855007735, -0.772118554558041, -2.0995900846327835, -0.7561669001126636, 2.5850026867966016, -2.1190814836773977, 1.3535672637193361, 1.6545005292329906, 2.7242929272589347, -4.053582435680036, -1.0031516483407736, -2.6658565704787716, 3.1709759928980343, -1.1119000423843965, -2.1763473418306143, -1.5779414481788148, -2.8068515831058094, -3.1946598354838978, -3.7576292060035374, -1.5435620726009245, -1.5269843035584112, 0.06757976162246938, -2.9005354931285146, 0.03731149803170107, -3.6986272881777063, 1.0673375997673586, -3.7320057483181976}
};

static const float b1[32] = {4.747737647742972, 4.712062346722936, 4.649988639961206, 5.072038097667066, 4.689637360595237, 4.771514423451384, 4.6244689393604705, 4.819620353746034, 4.862021197571317, 4.945593219606091, 4.757812308269743, 4.979817882174155, 4.904944818907279, 4.837297704173986, 4.644146447562201, 4.717934856304204, 4.676091873521297, 5.028881699426258, 4.700444900053494, 4.860403901794068, 4.647976247700278, 4.770900991473606, 4.813964368903419, 4.746046892285726, 4.672711315511629, 4.88600455363701, 5.038901288203758, 4.8048346057292655, 4.847185224292375, 4.680261864877679, 4.867117931072684, 4.870960300251089};

static const float w2[32][16] = {
    {4.230426043133572, 4.380065171485237, 4.251081154971346, 4.470104041917136, 4.343616156117661, 4.671783145339305, 4.88434451101959, 4.155821647267535, 4.231524783942674, 4.368001920030947, 4.778819275738281, 2.872419092603034, 4.748796505806341, 2.593511744763731, 4.603109262556102, 4.646883602692224},
    {3.7943956441332176, 4.216580017373184, 3.7237996159837756, 3.9554629157510677, 4.084429991017197, 4.044878490541818, 3.9582099112916804, 3.8984693480598547, 4.307157399640793, 4.015809708100545, 4.180829044074687, 2.7886854502371037, 4.565865674220475, 2.4260075055454178, 4.080901784345264, 4.267611792812583},
    {4.162020738254171, 3.8379945714744563, 3.9686684900962272, 4.276561466017642, 3.9244890507799095, 4.274570832342509, 3.630728044409167, 4.029157206302305, 4.218754343882273, 4.026772910483997, 4.398217291743699, 3.023766455092431, 4.639037560709701, 2.1550970594599925, 4.330475519143132, 4.098389099130497},
    {4.330571145147937, 4.670264903980643, 4.280766519634926, 4.2224334519921785, 4.287885665618742, 4.173346535160971, 4.382827234694948, 4.110893138117688, 4.8155939491188615, 4.009703259203966, 3.9327039359859546, 3.28477330400276, 4.304255107979361, 2.0201468225825967, 4.523847897862864, 4.224245875480572},
    {4.050172623820924, 4.095593306504941, 3.2962492495179565, 4.063836283468247, 3.9803402741765463, 4.478851660766943, 3.840984728423586, 3.7313414233292543, 4.203264286253792, 3.9524500459701817, 4.369669877198067, 2.924844531694126, 4.110019713524351, 2.057566994957411, 3.9757450125595746, 4.2801665757269935},
    {4.6420138547857315, 4.213863802093753, 4.240668337370542, 4.487503388949522, 4.984471238666414, 4.267683156212342, 4.446320133382183, 4.501459899848656, 4.7282814899215495, 4.334649351595273, 4.26478972829802, 3.1950575944416935, 4.667169544732362, 2.2014190623482843, 4.305204791667858, 4.5991007211839054},
    {4.342515146256034, 3.8652653812255537, 3.838988304951427, 4.153170514605292, 4.0137228469370285, 4.01726175402418, 4.094996957843112, 3.9301474171436546, 4.148434835545755, 3.230990198471038, 3.947764648032396, 2.9686284247971235, 4.087927746922348, 2.3541339249347972, 4.166810490445356, 4.27717367794414},
    {4.797275896066868, 4.213118059204547, 4.068403113422065, 4.221350289401373, 4.609772636482792, 4.6352852258015655, 4.6411459009902964, 4.11599413583611, 4.745651019263592, 4.2760637588837085, 4.543397399339773, 3.156691932241204, 4.562035357823086, 1.9943148342201173, 4.118006834889566, 4.382038726689968},
    {3.976174213007153, 4.297828035681087, 3.5723122670817813, 4.016571547431002, 4.272049822407763, 4.1350155577940795, 3.9075758225861654, 4.010379719846476, 3.8471127856343608, 3.418549850998072, 4.098253808011245, 3.0449613188240305, 4.066546104175124, 2.3438649068308064, 4.650275610841716, 4.036147127005434},
    {4.375194456255384, 4.485636757250052, 3.8590324547292214, 4.549424137341802, 4.880576096794341, 4.960020321622523, 4.53353135109154, 4.124623823095606, 4.96911071763954, 4.391861122072499, 4.60256476967025, 3.1544657827263993, 4.50746497557124, 2.7155712439031374, 4.647937926004385, 4.307447993413588},
    {4.052908060919698, 4.782384134535696, 4.255941405880169, 4.585371596676702, 4.68739607104726, 4.390320446204952, 4.665179464735735, 4.25268689451942, 4.47400063728707, 4.271468442904615, 4.520246328020551, 3.4469987448318093, 4.637404373993489, 2.7322234604301334, 4.692920794799443, 4.9320687249550526},
    {4.522205566625037, 4.453861088464734, 4.15640944898403, 4.629979011818841, 4.984736511005197, 4.330398170095339, 4.693572347098107, 3.959589564673224, 4.477344794078201, 4.282740284479799, 4.475573575179188, 3.160839722264304, 4.893180923383248, 2.220126883127116, 4.97388423912331, 4.332723244509761},
    {4.518739764512543, 4.529320844443754, 4.384927502285774, 4.704336852536275, 4.481220580116387, 4.6101704220527395, 4.8209320705001, 4.196186302797452, 3.9677943977504135, 4.1665303731080385, 4.212986722331881, 3.383443690483673, 4.079979107779789, 2.5688652106836147, 5.096400847728596, 4.759958025318028},
    {3.746971498582481, 3.7910581761176454, 3.333840125514768, 3.951859367580413, 4.237167351599803, 3.7746931717903967, 3.4326741945456627, 3.891182386117307, 4.100754032609571, 3.35187843699653, 3.7583699611903296, 2.701353433055281, 4.307170860625614, 2.0419532371061875, 3.803981240148728, 3.799424764702802},
    {3.9432153286988894, 4.0749588503586915, 4.165136637697615, 4.322413511789687, 3.800520422188339, 4.059133587419955, 3.7808762384568038, 4.256255091685401, 3.9710505886728122, 3.96627084290459, 4.245214755323162, 3.022295515025071, 4.328340353070567, 2.5731767819363096, 4.439467421659582, 4.375596748751079},
    {4.005309285165772, 4.1410666205886235, 3.9805797861698484, 4.011701285890654, 3.734128223211072, 4.121519896331515, 3.7119438130936877, 4.5533502588856285, 4.131595872305543, 3.1670679744526224, 3.621328530716279, 3.127414358136474, 3.9966309832299136, 2.331363925703173, 3.6740193644286876, 4.022473696854362},
    {4.018600635726933, 3.900429605226146, 3.8264400445532982, 4.183483307439379, 4.0867982685748645, 3.908267924358441, 4.310722414792834, 4.397745819019215, 4.42790325365401, 3.941784822526073, 3.989630504618311, 2.426022808025233, 4.353337028057913, 2.555953212941499, 3.980927362093999, 4.278527008998027},
    {4.4371811255449565, 4.861478692765361, 4.4019694101147255, 4.607231283700026, 4.371846513342446, 4.763827320988804, 4.046888159415156, 4.248938443043145, 4.597986029351871, 4.629159538024523, 4.698459928079583, 3.1978242921381366, 4.139675366265453, 2.67426384333721, 4.966991407757513, 4.736517733881356},
    {3.7904422941178755, 4.294752921283397, 4.4849234233799375, 4.290792771243478, 4.66726686137818, 4.716868663908617, 4.389808320871169, 4.657108148683941, 4.422453776323451, 4.498366025621347, 4.636120245709585, 3.2444548679535576, 4.647986279857317, 2.257886273453125, 4.664632458672818, 4.973168732447484},
    {4.347974453855669, 4.493714246748203, 3.9524262195425166, 4.295254285909565, 4.759736567992678, 4.655435796563298, 4.192045525018633, 4.529710254057888, 4.287347607836793, 4.255541566529027, 4.773738288389234, 3.1911535657436803, 4.4784656340852536, 2.4323245089217935, 4.629550088528015, 3.8809720233046288},
    {4.069882046542922, 4.104623615006127, 3.9331496750187545, 3.982743909762636, 4.332142804083814, 4.275163907919533, 3.9115514242756695, 4.077300088421364, 4.135313899969066, 4.280054363889445, 4.028442140342106, 3.116920625374184, 4.513847063326593, 2.581883262330105, 3.8332221749325424, 4.201214650370471},
    {3.968330673663326, 4.379574005797729, 3.6108084831275944, 4.3470708958836, 4.1669206051016365, 4.604233522707943, 4.203102521459342, 4.1377922881630695, 3.877412601022814, 3.9733266696500977, 4.4342058907588555, 3.172038677983645, 4.381889845609435, 2.0950951824751067, 4.2164854365622775, 4.314068689788137},
    {4.249882797327628, 4.319195202738138, 4.514520541083423, 4.273602120707297, 4.870762566259133, 4.01098373466741, 4.673240962251105, 4.444604490073078, 4.722039703064574, 3.5134199860797515, 4.714624353768916, 3.0432751185846003, 4.699937392820506, 2.186654164062482, 4.409817176734256, 4.1534196829910695},
    {3.7102712368498527, 4.463129390544633, 3.980734968985352, 4.336604043238237, 4.452467114714866, 4.312152193289484, 4.035771382419687, 4.695037447925853, 4.442184296112668, 3.9931501231653264, 3.9331788111255084, 3.301749174726749, 4.570243367358152, 2.413606433305109, 4.149250712997083, 4.307822973186726},
    {4.1816555689242705, 3.8609077593976537, 4.155010953443224, 4.070516872496382, 4.418180541328729, 3.927998139972346, 3.9073182523342056, 4.499897784228793, 4.284548559233387, 3.6534975498841016, 3.5590334404681054, 2.8813746116187158, 4.123984313448144, 2.4680577729736193, 4.551984660631249, 4.37025473383616},
    {4.608160728372565, 4.20234735116234, 4.115683147243617, 4.284335175334934, 4.511093618678625, 4.1276101861401555, 4.146309558444398, 4.507060293217695, 4.712871855013402, 4.27823807204489, 4.366080846637271, 3.156287742355686, 4.516849190537705, 2.423346566979073, 4.3228316794371375, 4.149219548899043},
    {4.272753860349312, 4.350358090544805, 3.734057724661159, 4.142297623745907, 4.306316914971978, 4.413479240282697, 3.789107669573784, 4.4201697490523335, 4.396363686892872, 4.079138296463355, 4.457604527426413, 3.249261986943929, 4.438543029357285, 2.249907816176751, 4.25138247426359, 4.2682412397017435},
    {4.368302135936715, 4.286914162747278, 4.185183898851754, 4.233732589272511, 4.401544442434195, 4.017572807500906, 3.761152536460526, 4.4507056720002875, 4.36643696806146, 3.7937548735032958, 4.175704528261554, 2.7717616373181775, 3.9122891574581633, 2.4881801251332205, 4.437802458507428, 3.997155549498481},
    {4.2085792562617925, 3.753322057878994, 3.7988086403485273, 3.4888869750713813, 3.9219343623007084, 3.563151652687181, 3.8286023451858506, 3.6821893062583113, 4.182251063813481, 3.564696923272021, 4.024307225229041, 2.4601390577655287, 3.945845812819694, 2.0304803978528634, 4.266174678483343, 4.08416113032869},
    {3.9680792476219238, 4.272179542074534, 4.472034286031123, 4.065078661175917, 4.25466328235177, 4.599810622087312, 4.280758592571732, 4.301248468913007, 3.900215106089072, 3.720921905398292, 3.853607593216111, 2.775145872158648, 4.465407245363651, 2.8133348975710146, 4.378942089522845, 4.146968513601406},
    {4.74894966316149, 4.867385402628293, 3.9242256576362466, 4.4484840172678055, 4.193975672408365, 4.627658241366555, 4.517480032125723, 4.4503124628135415, 4.347523869542182, 4.759401545224798, 4.745691815981398, 2.9378868961851428, 4.95376932145033, 2.1007731071108346, 4.397050457791862, 4.48850909849297},
    {3.8069963211984876, 4.393384293790303, 3.947632309027995, 4.36109124166796, 4.453995589182611, 4.208774651039562, 4.0846820426934345, 4.6580124814367005, 4.560388019895034, 3.6772600148840624, 4.460150380376597, 3.6655518007321626, 4.03743448760526, 2.5392109505099967, 4.4539450006434755, 4.463040431935177}
};

static const float b2[16] = {3.6363679961871993, 3.82227212914397, 4.1898983951097195, 3.9617499427208864, 3.93230414636659, 3.9641352173165187, 3.9189238491019722, 3.851751221827314, 3.866286121933407, 4.164475611003782, 4.012556404884036, 3.6959392183466107, 3.9034545903885616, 2.7025189153562685, 3.8674144373446984, 3.945776907869186};

static const float w3[16][12] = {
    {-3.4065818731032538, -2.730497484873521, -3.217432392095405, -3.5338018996218894, -2.76183508973477, -2.885801089604724, -4.044893176534914, -2.9296158816575644, -2.89161284773142, -3.136199478969734, -3.3254610857634965, -3.4976102722439033},
    {-3.5065009862995025, -3.2161646359494367, -3.0606430520254695, -2.90425024591913, -4.006052601196751, -3.5310650092920675, -2.8244267524469038, -3.760187954071349, -3.2009898246065283, -3.5540214603458167, -3.7169274388377342, -3.585519999717585},
    {-3.8615972091829946, -3.0523097870225104, -2.9013064779925855, -2.8928654216469734, -3.072139334369019, -3.7501125432468254, -2.9371220020358986, -3.1741724427896703, -3.0745997335569832, -3.3277419236771726, -3.213308149538834, -3.498578201688309},
    {-3.2614670801931855, -3.296196030564801, -4.001340893199062, -3.5160682063485504, -2.9983179754032534, -3.7463770268025955, -2.587533926558402, -3.238275157534486, -3.5324173601793043, -3.084725835216687, -2.792974996538877, -3.0453407047616956},
    {-3.3849469541047834, -4.036154448789716, -3.302951307323911, -2.9876619001424967, -3.151749569339913, -3.436143048470404, -3.4510748972809524, -2.911450884938001, -2.6840940839539575, -3.0256227401576323, -2.9700368610596914, -3.340338269220976},
    {-3.6639783561390398, -3.621821603643919, -3.3159818549248756, -3.3837601935400827, -2.721945136739888, -2.7649477858195524, -3.1067801232038312, -3.2448711394137884, -3.0627950126821886, -3.1236759099979827, -3.057163671744861, -3.0068436030836527},
    {-2.5519552736180717, -3.5154115105654378, -3.214261412834116, -3.082643620876831, -3.3970228956838673, -3.009174771936259, -3.3845895939303605, -3.579600164352223, -3.7279273154733086, -2.7388209984352527, -3.4003491335003124, -3.5557569185568516},
    {-2.8175829871065363, -2.7972006451929174, -3.3438251661422367, -3.5167958929644634, -3.3765096962476173, -3.8124429598494483, -3.0454811220442037, -3.1221981949026008, -3.494151358957168, -4.034527538989507, -3.2183564133828435, -3.134392190692451},
    {-2.9870609121714566, -2.826536570952412, -3.1966306929559165, -3.281280120344344, -3.429026168284667, -3.4829865191643408, -3.3610163785397744, -3.277145701505157, -3.3375789395896702, -2.920539868685974, -2.874045281823995, -2.996995542661023},
    {-3.2208189198325354, -2.6139569406582557, -2.583105964199392, -2.911613838810195, -3.1803791789798543, -3.118881111919572, -3.7601887588704406, -2.859214013084139, -3.4073366646933927, -3.436923288812582, -2.9886550499978326, -3.5082603185098753},
    {-2.8419831976412513, -3.8173471866332096, -3.5212088184176715, -3.3970119603525752, -2.595510279120041, -3.2129522476719647, -2.7703953670909893, -3.434965039316801, -3.6504155069838813, -3.708175830650917, -3.1765539681632116, -3.188229710300601},
    {-2.362768165059765, -2.7487176246174077, -2.529658080649492, -2.4953762702877635, -2.7216530009364357, -1.8524275308243845, -2.0422217395998636, -2.4218139083154777, -2.7823587849571787, -2.034858442307644, -2.671839562018401, -1.9111766370299883},
    {-3.7540492957719147, -3.1083318476050144, -3.332171141279513, -3.0473114443610094, -3.331392329006322, -2.8588554626122247, -3.4172273826957977, -2.820246652504763, -2.865520233044269, -3.0440458277424076, -3.495186278737807, -2.746161546069354},
    {-1.210598676327871, -1.4408152922843946, -1.5793092377648277, -1.849649047223154, -1.9766990188466989, -2.1743227171060524, -1.6351504879420513, -1.6144466665576944, -2.275428835817507, -1.3144293567221692, -2.2353128080667974, -2.0114396117230577},
    {-3.2248279799458013, -3.472864702918457, -3.4839591744659684, -3.205847575600715, -3.3335277761812145, -2.7234356160238327, -3.4448910295523634, -3.2570460284272285, -2.868093899386647, -3.1634157703978256, -3.172570398485983, -3.124093738976461},
    {-2.9342975445347235, -2.9099979463346624, -2.606984357608814, -3.2156859959056723, -3.462725225488447, -2.974222060844154, -3.343620243287671, -3.6397547914421278, -2.875014735625766, -3.407371648220234, -3.2281341406204134, -3.1637046143503635}
};

static const float b3[12] = {-1.5344087662420907, -1.8370644324814833, -1.5267382553635647, -1.1164594589608114, -1.402737026177986, -1.577150040323482, -1.2392579873952745, -1.72179638748688, -1.1067892278729219, -1.240657951620633, -1.5346823798020957, -1.4454026402000013};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
