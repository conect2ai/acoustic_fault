#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.8192014892870748, -0.007678193034620937, -0.3190261873544431, -0.17421991171973586, 0.3932750610913146, -0.244522617004731, 0.19788900265682588, -0.6059025258962374, -0.7570508029252042, 0.04948669788087742, -0.601664701320973, -0.2983699337682941, -0.17832132534573156, -0.2768067261294795, -1.049083556369094, -0.5761750313246121, 0.4263377840007171, 0.35112572450790763, -0.6403994890059773, -0.5693433826269041, 0.15971669624492266, 0.13716365841801895, 0.2776315638764293, -0.774749066508886, 0.023857462237456932, -0.04411740714962923, -0.19314051019111256, -0.546947217432313, -0.7946859820431549, -0.4090361147171491, -0.5197145834409933, -0.6960580740039998, 0.24720187912394845, 0.48475537377468203, 0.04926473037656964, -0.22495589112076367, -0.5739121330443858, -0.8795983751859244, 0.54462599186005, -0.3271540262185011, -0.8411821446782749, 0.3820234457966212, -0.7052341469739948, -0.23859140548260852, -0.6603352334482032, -0.5022468940740632, -0.19825969251665684, -0.3926071806241657, -0.5244647353569761, -0.8317114505498858, -0.7767485333735908, -0.9507181637163435, -0.4754378031028206, -0.5831587947888237, 0.20470389224082755, 0.007393906784622752, -0.4830007676066494, 0.376525707415725, -0.6828313280540785, -0.5729658398172358, 0.03719197645289554, -0.531611413222019, -0.13705687850136525, 0.25684765615514354},
    {0.4271380134950177, 0.5712517890893853, 0.6592431874087875, 0.5702048948525097, 0.12435985518057696, 0.5548026853615984, -0.08350100555803615, 0.36768756813450293, 0.7000598915197072, 0.07831748112561038, 0.5205797314467865, 0.4821166030593725, 0.4094459346812174, 0.5442779371300501, 0.5405388138398801, 0.18614918983627793, 0.2063800483591074, 0.6647413324814127, 0.41279577599943, 0.420117501588024, 0.5034339823826879, 0.3717497821947714, -0.09572009264325308, 0.6370272756960211, -0.36047910992888116, 0.33233964909552993, 0.5552731733149249, 0.2988722449862416, 0.5829542806085913, -0.25267629466707514, 0.5939865782266955, 0.32661560797148137, 0.23203538269216203, -0.25432738531343485, 0.17436362240713854, 0.27373114727303544, 0.033310845088012415, 0.5667793499789404, 0.12946665072124508, 0.64866415524853, 0.19464917024809472, 0.07968951403730976, 0.6666012989159608, 0.66881797177595, 0.5412782585590233, 0.8864001999523189, 0.4328936836789953, 0.5869652965070828, 0.3497871176378134, 0.6387107935676674, 0.8558543953526714, 1.0075973532594225, 0.9548092946138093, 0.7284133096700134, 0.12910604635700543, 0.13975097053887367, 0.5847309589749187, 0.39759052765403063, 0.4415823262901801, 0.005092541078056268, 0.2595564252342188, 0.6415384270619743, 0.1294281620901605, 0.29105495646864427},
    {0.18679115163876256, -0.28782769805889763, 0.034565756829428335, 0.36826091354857815, -0.24940251747493133, 0.573298927670562, -0.33749586619534516, -0.8897929080694907, -0.1245713167638602, -0.7718006160356277, -0.21071522799979112, 0.13862323531889245, -0.3062659947367759, 0.11993472402618807, 0.1112792137964461, -0.18400729153194337, 0.39696728378080914, -0.14428990463710598, 0.48833423695653677, 0.12313647230100173, 0.029588742145497532, 0.1121311444827494, -0.4747221743188875, -0.23502400723139857, -0.22157151593973065, 0.18713550305979954, -0.04519467390388931, 0.41144089056041605, -0.3867605812472986, -0.25841873884329586, 0.05090086903298948, 0.4210751739602929, 0.23642588542676063, 0.7809281912666096, 0.17005601202901274, 0.39958743278974945, -0.5028219931598563, 0.08579791296698976, -0.36587587822444345, -0.10779887105492973, 0.7691688938185419, 0.3078481108407612, -0.00274117068748657, -0.23473284347465867, -0.20501602270654112, 0.2524930158799062, -0.8321915506164717, -0.011251623392933832, -0.5605527495703949, 0.47336647686665806, -0.22447654291042887, 0.03086755425986779, -0.38792995389617463, -0.09515908394026389, 0.41733013265387964, -0.09942556211601705, 0.004024175921599358, 0.022280743100912055, 0.3421290818412826, -0.4031395911263544, -0.49231718607980574, 0.021328210320167705, -0.2509194872532909, -0.18499744734008944},
    {0.3400565748168619, -0.6734840841974731, -0.3643668524396321, -0.3745415700993638, -0.09717777677896115, -0.24605877976207752, -0.37043161423039184, -0.20576283316807364, -0.6532825602949949, -0.5955342026731395, 0.14697411727229132, -0.17359957865670733, -0.8555459559194989, -0.8127532668221576, -0.09620530126215497, -0.5142663697433318, 0.01865746382044326, -0.6084929047077863, 0.4304254986720808, -0.3184930807658127, -0.5232915273545506, -0.06703735050235268, -0.39716225040806546, -0.36532379892780714, -0.6840500325235492, -0.6297096698303143, -0.39683577220895383, -0.668531199064383, -0.8144251915555876, 0.3722142908835518, -0.36013751584359, -0.03464451117192161, -0.2170866962668932, 0.14837494430861023, -0.1532537517438902, 0.20203903925408723, -0.27584666478654113, -0.7103378107575251, -0.688663369388779, -0.8337397128909522, 0.2513676783372373, -0.6365453723798579, -0.3082941132590798, -0.48878541357524824, -0.4000266242524878, 0.10825884236822512, -0.8741731970567989, -0.4961592718899066, -0.6420101398375827, -0.19035053958379253, -0.12055680300938006, -0.11490302444336764, -0.3835262612067177, -0.15893095042971697, -0.048241536481766475, -0.5197361134272943, -0.4472710455182709, -0.5304601332622506, -0.2615939339827929, -0.5744521714400935, -0.6933043624453201, -0.26667224114451393, -0.5655091976414159, -0.17878856856803516},
    {-0.44385717156451854, -0.6625347283825762, -0.05961665272033148, -0.32305752244869645, -0.4155103963007084, -0.1889054600066572, -0.6507317825995466, 0.018975122519243038, -0.1724035860844542, -0.31256632044470833, -0.1377426608902173, -0.2917527698947999, -0.46243750533927624, -0.42195514345530066, 0.14216701293817127, -0.40933178614679483, -0.23296359263896949, -0.6689874376027741, 0.6266379622711631, -0.45339517850713423, -0.29581232503188787, -0.6032045715315683, -0.49678161974633145, 0.04434036741923336, -0.5996542541056408, 0.054258522641228574, -0.41633245417385645, -0.014495831320714483, -0.4521680179726328, -0.0548120839015192, 0.05549607872056268, -0.0369771982211462, -0.17252436981207472, 0.2693143661493569, -0.2847184115361113, 0.1773085096135026, -0.18749726579755202, -0.11555853420374927, -0.491186904780075, -0.5249822033163344, 0.6552065703140246, -0.7305861098666646, 0.06086014154581728, -0.5246674441351893, -0.2957799214070312, 0.04130718123615157, -0.31474867889089053, -0.5258815730905921, -0.24097302914476748, -0.15769445789633882, -0.28727307352956616, -0.24545801961789554, -0.6062016775834458, -0.3503556532357033, 0.6262130767188188, -0.607820644886774, 0.1084895935701482, -0.39088918622250646, 0.15175629555687514, -0.04379892096891527, -0.23837872417781575, -0.14097110241447916, -0.18587067346973282, -0.3131805782895596},
    {0.20335252039911428, -0.43715801824420214, -0.24838173848556433, 0.28099467055898425, -0.4352591363994135, 0.3248007311717672, -0.2028588050679977, -0.007572533924726057, 0.22135332356071896, -0.018444413120907523, -0.03107565374783718, -0.09908953144320257, -0.29387082843473294, 0.050616576854052055, 0.387568924823409, -0.4039054510562751, -0.29077188535702786, -0.4644043349987894, 0.8757245315843913, -0.14611697399844958, -0.11753141340078292, -0.3343674648468036, -0.2579320009292725, 0.5580101521999675, -0.1291242622126506, 0.4783030466905333, -0.016255297385438468, 0.14755361736107733, -0.550557172651694, 0.5061888653990809, 0.6068670791773634, 0.27535277975188566, -0.24073968573917115, 0.3828754243155496, -0.7135862288582194, 0.3726721984269644, 0.5644943333799883, 0.32404296885143, -0.4952074112138873, -0.597349854857238, 0.8460976527359282, -0.6632959441300207, 0.8780696596402865, -0.31754358977732805, -0.1677820295127605, 0.32820982481581773, -0.037443899306848306, -0.3446179461707755, -0.011131906851111041, 0.728865925688487, -0.016518405113317553, 0.475895628206388, -0.6043555683947004, 0.3532691867128004, 0.24936567646610563, -0.2954920562358441, 0.12446370029578979, -0.17617139791409103, 0.36767019026069436, 0.8920282759449576, -0.004405710088055176, 0.21332055740890693, 0.1178468428199551, -0.03813434933686727},
    {0.4776405271403162, -0.49508013734340056, -0.17282281149997747, -0.10743291944648488, -0.4339121015893561, 0.2985348642030839, -0.2877818274453645, 0.16575579908254692, -0.3941394087493323, -0.013283312240530887, -0.10119935834080375, -0.21040823956198978, -0.4912372999238255, -0.5657734370008901, 0.5073701663280626, -0.23012846769943557, -0.22454599582165627, -0.6465825857220107, 0.9332509453109954, -0.30364947427961586, -0.27271889696943574, -0.38492502273308626, -0.3386784537142086, 0.6913918204799853, -0.25810339992537623, -0.0010021526833369882, -0.1443888700902806, 0.3123128865795013, 0.10125979250820655, 0.40761506774472905, 0.4714375526001011, -0.10915397371694928, -0.3500822280671871, 0.3240249112630223, -0.44182655283916594, 0.766104743887602, 0.08832115570328321, 0.2509284044636098, -0.5974309580157292, -0.5747435932298102, 0.5342767809800569, -0.4624263700030227, 0.6153250891251457, -0.4023434167930027, -0.231909904538492, 0.3435488851249626, -0.36520324115443864, -0.40974886567648106, -0.08631083250171559, 0.768997447389604, 0.04106242655474173, 0.2955510010687918, -0.8128066017226852, 0.2741433764882359, 0.09387777971292496, -0.11932090326025166, -0.34113170401924786, -0.4198066524936159, 0.2943133808660704, 0.604427554367108, -0.11440642922351724, 0.47366385610927314, 0.34045522721859867, -0.265264867163771},
    {0.15874198548865223, -0.10338243838199176, -0.47192517121736366, -0.31858140781940114, -0.7535527783086955, 0.3092813760395506, -0.5649485526101504, -0.7387485727999161, -0.025024141638891807, -0.341316652704679, 0.1075874011263689, 0.27551681891294666, -0.3552253660604045, -0.409968002327711, -0.32551420900337197, 0.09566635278180821, -0.22260128321170808, -0.035117937519152424, 0.41889446511135675, -0.37915607888135416, -0.05087671174661248, -0.06685392281064047, -0.3136008750380173, 0.34032833350620384, -0.31408986965706526, 0.04394863672383361, -0.5410164550573999, -0.25872811119776684, -0.6241801538840732, -0.39854421545022645, 0.4785000913586841, -0.05110695514003432, -0.5611652238381607, 0.19563766170031166, -0.4035692037096828, 0.7850753943944707, -0.29778966612386276, 0.09410013331413493, -0.3768223359982672, -0.26165564849422923, -0.3969880349715759, -0.4266868266563709, 0.43325531572065623, -0.2838422120059068, 0.11836894637507019, 0.17841664607033925, -0.31603588133470406, -0.2813210099598151, -0.37282219639396713, 0.20454023352227918, -0.3502816383742615, 0.22832210215160645, -0.29317718684956556, -0.004339354745577394, 0.1525310221106853, -0.022229558937722323, -0.33270421321294114, -0.1285538207847015, 0.24107230886630207, 0.03298625456336644, -0.1635476371595879, -0.1045512069228261, -0.18138958989638426, -0.26952998900009284},
    {-0.07608309116719598, 0.2588184090417984, -0.0730562971891611, 0.43392932181899385, -0.544156229549134, 0.609013916693066, -0.19977914108838699, -0.654204401048857, -0.4459787953772207, 0.3595757778087121, 0.18846546710583575, 0.27847608534459534, -0.19687451012950816, -0.16369016804134176, 0.3219924454903572, 0.2110294546521752, -0.18991069648118536, -0.10598116324974523, 0.6455131193385025, 0.6131112078715061, -0.391234967324229, 0.4344485479404854, -0.4626658249223377, 0.08130106462055184, -0.7671553153390626, 0.30054589759902767, 0.023357604628552707, -0.20628993326074269, -0.558530113211664, 0.19857879980740228, 0.5348182168444393, 0.457696312272612, -0.08480283835197862, 0.15481743596486064, -0.048305084555354934, 0.5229002804609514, -0.18952962897774558, 0.4970082218210369, 0.006569955024813294, -0.003218309932335887, -0.2835322583043587, -0.2743514427646241, 0.5525492218824084, 0.3798830681982899, 0.16929377180392877, 0.3633354512439986, -0.10452360130943242, -0.3719054816786353, -0.17392338672549182, 0.3361263714030837, 0.16359448203034957, 0.682819240025441, 0.6733122806144225, 0.2435525467733481, 0.13932724254687234, 0.35156238329143463, 0.15626375687447558, 0.3097081260783314, -0.17870831893298436, 0.12033670001518695, 0.36578889739507325, 0.10673517858011967, -0.04526502622382007, -0.0006050986833543113},
    {0.27722100573328967, 0.3349299589189454, 0.05405376858538432, 0.27838922325725735, 0.4379068738507815, -0.32199848797714553, -0.29485030616879965, -0.14166367571608696, 0.04552073552699234, 0.2183959231764085, 0.6185707782005649, 0.520191276900997, 0.6668599989769527, 0.4451053166255079, -0.15273050483951445, 0.11900488016248138, -0.4856993172485884, 0.2129247226857178, -0.10047684019444804, 0.007517873371896781, 0.4082258290868064, 0.05755410215909522, 0.5854538169873689, 0.45059637507255035, 0.08362224526545871, 0.18538979391982693, 0.12673350833942762, 0.1497063860172964, 0.3814055025304574, -0.23648709857189654, 0.33239429231328116, 0.6399528177694251, 0.3407712307506113, -0.3275125337662797, 0.32494767739494934, 0.7532688238839894, -0.10755084928680059, 0.20704360747187026, -0.10046223439960351, 0.7247787455543167, 0.18395991370385648, -0.17093161058490905, 0.7041873629728627, 0.4828920010876599, 0.42872755313976346, 0.5016681409043174, 0.2542169164980984, 0.3664457685511297, 0.08788671015267349, 0.24156228955774448, 0.2252676833635491, 0.6457863946601384, 0.6780870598245895, 1.0154544183837502, 0.10692686172314474, 0.4810778927081388, 0.7272462436482182, 0.24895311215085156, 0.09914485862573753, 0.6806788194024632, 0.30600437366546657, -0.27574243456851516, 0.014489789320897822, 0.14072243392277206},
    {0.26757932215861113, -0.09985543794440412, -0.17561017795646472, 0.005761985763863611, 0.39196008864268206, -0.4320238755383583, -0.47599595667972133, -0.001723765994960593, 0.23271297247711817, -0.2900785090598048, -0.018723182226067604, 0.02179474121510822, -0.09890767915635823, 0.15282935940027598, 0.32267951214274515, -0.0007242264869397647, -0.6449471554552576, -0.23515023591032666, -0.26425727464996757, -0.12122298255570775, -0.1359523390272732, -0.3942600371481584, 0.021140073810404815, 0.2889800210474684, -0.053466628762519154, -0.3342711510667218, 0.16727145744962885, -0.49575739441076255, 0.05995283961276003, -0.09684012300640149, 0.31177662079603735, 0.41752656396756616, -0.5015260376151143, -0.4643354592717942, -0.4306141004232228, 0.13710400067230155, 0.26746119023008386, 0.10551399729408174, -0.2881028687925586, 0.057729527726616034, 0.6202256406812043, -0.4756530842630702, 0.3769727829558626, -0.1412564113027897, 0.26062301764011253, 0.2700072568256421, -0.17492065820282743, -0.24977358649071665, -0.30776000342186366, 0.5400909522551258, -0.014867941535005693, 0.21902668585400406, 0.08518513487173279, 0.41007877944648163, -0.04363243614570627, -0.10881847659390051, 0.30592745532854854, 0.21163451849064124, 0.1132049212325488, 0.5242338296353151, 0.06073109738287641, 0.36497199265873265, -0.2528456722558162, -0.2146067661484101},
    {0.2510773733105754, 0.4191490281177376, 0.41874175137382236, 0.3756456299226389, 0.6025544641200344, 0.2641421558938259, 0.010004779497828593, 0.34471379372532973, -0.21193715501793092, -0.013650729316054988, 0.8087988929099428, 0.04220301336026069, -0.46137257409016175, 0.5004134945317703, 0.2602801194824046, 0.20890346743595176, 0.42283802632519435, 0.4571136661760322, 0.003595421401514848, 0.5439890429930834, -0.025949607945165036, 0.8290578332547753, 0.370232926216832, -0.3278765009708625, -0.34983112064006366, -0.18416887460440573, 0.3480730598077215, 0.10629410382430228, 0.20140483254720115, -0.08071969326818437, 0.05064952757162173, 0.21396522062398896, 0.6347327487129276, 0.18025754083635492, 0.3858201326648555, 0.6151138743741161, 0.06664615577228296, 0.1415504597640553, 0.15351505098263335, 0.3175419957410043, -0.04733515050331449, 0.5674836063713756, 0.0030736226724782743, 0.6114293099761753, 0.35072484622187655, 0.6683507816012002, -0.1876063751954754, 0.4453404275227471, 0.07326431117502397, 0.12866495954663387, 0.6360615212323237, 0.4317556672130871, 0.2990647662596427, 0.22323547443228933, 0.030551073918830555, 0.45655074289170133, 0.30150236579010475, 0.37858245328110135, 0.08110546715038278, -0.5704530532400578, 0.02480797929043641, -0.18489627232431186, 0.0003559672450499078, 0.710043984006927},
    {0.5223385035631425, 0.7856723689935269, 0.5845200899530142, 0.5528004001602959, -0.6314401953586577, 0.5804090467026357, 0.288871713419764, -0.0638610768036473, 0.6273970533246711, 0.38875494853526876, -0.30095347122012805, 0.27467919305629185, 0.8088046630698784, 0.7572706868719119, 0.16948884884397697, 0.7844446946869604, 0.36703936293989664, 0.3616169277229336, 0.38672952246999104, 0.4196443390249604, 0.5660871679021667, 0.6101232335714157, -0.07109345176750602, 0.5657132702313109, 0.6650868790251062, 0.6286040029904649, 0.9872639401365898, 0.41587134945033394, 0.8962584462815392, -0.30175514451422103, 0.633526317818097, 0.2006280875964661, 0.10177048478535265, 0.2860394736397381, -0.6453332912931338, -0.20264099320589224, 0.6847001707575722, 0.4285949883719862, 0.47800953607193997, 0.5134872036927093, 0.09964429305601108, 0.15263961287026664, 0.2892333949069344, 0.17494097828181798, 0.6553260747751607, -0.10198200303067867, 0.5037171706052206, 0.5285422937307035, 0.9689396325778679, 0.4244089094110816, 0.453625516776301, 0.3884195706812722, 0.653392628292276, 0.12595220509981062, 0.3666522554133304, 0.3075886678271374, 0.4812239081219029, -0.16424048555605447, 0.09673310333915966, 0.46986009201296747, 0.33664554100203997, 0.5651266850584499, 0.6548220789297592, -0.3132247689834058},
    {0.13253348215992106, -0.5353415080924037, 0.07367287035404714, -0.12554639787462726, -0.0059466062609787665, -0.3948314055799236, -0.137588349474723, 0.893511702960886, -0.664026060330009, 0.12646118780266993, 0.07654633047545911, -0.31933500408683074, -0.3659993197304565, -0.3431388206899539, 0.5790785090409108, -0.007649471342457354, -0.1769088864528027, -0.5580226166335184, -0.09171038213372656, -0.3901919614523921, -0.3668632555343547, -0.030859383612642777, -0.13473287186326527, -0.506376999809535, -0.535203586785667, -0.6835838779104579, -0.018252299830620468, -0.23720159925709275, -0.32329177082578175, 0.7071733771772181, 0.11125062855430251, -0.40144612367390875, -0.32688998251412654, -0.288393442536282, -0.4484723337740541, -0.25953955022798064, 0.23407926521290917, -0.28701946789360616, -0.5167595731182425, -0.7742660887171775, -0.4590468008703854, 0.0680453141222385, 0.41245070816432317, 0.06894090700456322, -0.9016843377165059, 0.6149951738122494, -0.11388212195275324, -0.5144922321300484, -0.2926004389097403, -0.2073062105490601, 0.6915563827607434, 0.6349824079407448, -0.16191480753057477, 0.32580252551166444, -0.5780682984085975, 0.1513276591954015, -0.32168348676045705, -0.5394247649313986, -0.32167469211140653, -0.0932557524787651, 0.36212845163846674, -0.020030530121813012, -0.4683657356222371, 0.3520133531316802},
    {-0.1860778899882857, -0.5451723705048251, -0.31145887353532625, -0.14136219228706756, -0.5283017956294894, 0.09017598649440521, 0.3801353145487506, 0.4451505102866163, -0.29041508955108836, 0.4309521077889693, -0.7787212712084542, -0.46840577855653914, -0.6645018586265427, -0.5207736601462426, 0.4636328495339463, -0.21236502564442267, -0.014577193073328274, -0.7873985929695869, 0.08142893922107858, -0.20935989941051247, -0.7015736670343496, 0.024143994303278817, -0.4289665042630938, -0.3406422439968439, 0.034733469782517006, -0.3444746698815437, 0.1780497821370648, -0.45376883278767727, -0.6004108578722092, 0.8852826097813736, 0.3238799538390643, -0.5419717286616977, -0.3851712235081834, 0.027303414039667045, -0.7299263104809816, -0.3983977836016303, 0.770511570471805, -0.05246163780514221, 0.02993552583897659, -0.7849152158742073, -0.646420928231225, -0.0990044591177607, -0.003043584026571299, -0.22366809558629774, -0.6685692354126754, -0.4390432262329014, -0.08973943647413896, -0.5886489711173822, 0.39911435062002854, -0.1512118603988028, 0.4138428436589545, -0.33754145612375186, -0.590694745138482, -0.08998728644308095, -0.5081083548714619, 0.030496456653284716, -0.8279725360432494, -0.6012974216697093, -0.5080401512251603, -0.002163434757878731, 0.03305242047430068, 0.05934821610821682, 0.02461058872183477, -0.07992141860868271},
    {-0.20864695436602354, 0.4831686061184529, 0.5751742836864199, 0.41942399768953936, -0.6152710047016738, 0.6735540107821644, 0.6610450253337289, 0.36861796013042664, 0.17653759493859478, 0.628175484664051, -0.325789626461005, -0.15070744848160741, 0.39917281330704374, 0.7129624974686694, 0.3866110291169383, 0.6629016763052313, 0.5269609841697565, 0.1054269544522044, -0.045546465701142055, 0.46186659655043893, -0.6546977065240537, 0.45294368665584034, -0.17435396531461933, 0.2874228106301083, 0.5108874290297944, 0.5488980129784091, 0.8748080633673408, 0.18724784460046384, 0.11200633653622476, 0.4423050018622832, 0.48330266183606774, 0.001335902769819775, -0.2017147500226136, 0.3612492436429172, -0.23501516746384093, -0.6895945493955568, 0.47342508442092407, 0.6090079514580451, 0.2393159195051406, 0.010292506997918628, -0.7675821332492485, -0.035177765928071966, 0.26650254732836504, 0.14635330686480943, 0.051966827156404986, 0.08468400953748063, 0.7703699076722689, -0.21047378340340814, 0.7056804081116312, 0.22586908643096837, 0.935371307363961, 0.48132049839048546, 0.26832398250453, 0.024526207492082626, -0.4587158744780275, 0.4949391352219212, 0.21399166367611935, 0.19023303894994753, 0.29722816420790166, 0.571654678501539, 0.28364922883029187, 0.613052721310189, 0.4262432554506591, 0.4404112552044623},
    {0.5719122517249653, -0.6381284269696925, -0.02786560517739275, -0.35206746324849325, -0.5001641530745613, -0.03614686612574715, -0.06709790843748155, 0.6604884084851387, -0.36584937049330013, 0.5734264760776961, 0.15780345808720742, -0.0692391581291778, -0.5476591404596709, -0.5168885636265449, 0.7289746889922647, -0.015478404833507577, -0.2087053600309079, -0.7016403418434156, 0.4467119522356702, -0.36075179375955246, -0.5486491005703982, -0.0332559903167121, -0.16173236555400627, 0.48762163616746274, -0.4098001833138667, -0.32491172425326426, -0.3227919045771297, -0.250284393963249, -0.1923128284995163, 0.6148431389732709, 0.47349573484431806, -0.2069421563747536, -0.38518801097767835, -0.11305002442192534, -0.4848655640247241, 0.5901428681568699, 0.713100606396529, 0.16286759021029354, -0.1693329624678709, -0.8695944241477442, -0.20521842301508922, -0.45974771972481493, 0.5798934226043788, -0.2041593568818839, -0.5925121708977246, 0.7528259073210438, 0.11896754395134652, -0.6317802033831842, 0.15199877089511665, 0.3800071230646337, 0.6340214390523807, 0.3821431926336723, -0.2599414626884018, 0.2998548148375231, -0.4642713655649358, -0.10244484927941434, -0.419045021994953, -0.24354527513827104, -0.3978317476224816, 0.7530829877247884, 0.3879120445218499, 0.38026369454011194, -0.24471901820424208, 0.5747452368634987},
    {0.3609434121294189, 0.21946269490262046, 0.2027001779396034, 0.5270688218589434, -0.27309279159595135, 0.09787256152977765, 0.04722557084201456, 0.6913486346857546, 0.15547702330838795, 0.3480068328835509, 0.018275750053495732, 0.1969926437077982, -0.075312244708994, 0.2125816327911489, 0.6815666100719143, 0.16734313756145044, -0.1525306536774419, -0.5274692938398019, 0.33448160194722804, -0.26703880382289, -0.35590394699714556, 0.37842552758925097, 0.1319355321976414, 0.5272541682039842, -0.23341155221957743, -0.14339956166902232, 0.3829851018610188, 0.21360273632855561, 0.3339770138199456, 0.7460167427939927, 0.08083407552077468, 0.07276500832973617, -0.04783430474939143, 0.18157301737435488, 0.09902638812552743, 0.30314517302702815, 0.5751717013126415, 0.3940457695850863, -0.2703812529588134, -0.5193601553551543, 0.29503671376642693, -0.40102750054733755, 0.6215164705715348, -0.02254314979920238, -0.025768949286218954, 0.4016825559899834, 0.7157957246757527, 0.21521869998437115, 0.5207690603100597, 0.650882603015005, 0.22787132794571904, 0.41259431219618775, 0.22872332396833497, 0.5645050620629207, -0.04691401764797257, 0.12743323218702235, 0.3762522799980522, -0.20905133837711662, 0.447114700817739, 0.7728389186862152, 0.4239300391658407, 0.40080254362919915, 0.19825744674239312, 0.4286707227988172},
    {0.39583726600607455, -0.25260791013169065, -0.25838159274922423, -0.08448069680964487, -0.4181542253386387, -0.3732116468312044, 0.27796421018056516, -0.10844387861879427, -0.23952423286651062, 0.19113790148968754, -0.09704711300947719, 0.11881199343955022, -0.1259358344627256, -0.46835724940292905, 0.4825821362788102, 0.08463618301713428, 0.23683439594738098, -0.2946911998287889, 0.10296197760447509, -0.040802442376652, -0.4636630314295509, 0.6484253107472926, 0.18202185306376123, -0.1341966265875389, -0.38249940355842105, -0.10194181247852176, 0.1139287522958425, -0.025788117715283748, 0.11972723217384784, 0.7968586186475644, 0.05054196194338877, -0.3198423958349297, 0.07041930728301135, 0.02363596151678542, -0.031068689536626077, 0.40505448813277406, 0.6493308814460662, 0.3078578538434786, -0.1375790360461834, -0.5095931762149114, 0.08050661031408828, -0.009381142034808046, -0.06332027076082461, -0.18152165767894943, -0.3910035304569495, 0.3617306133073481, -0.1357797398220594, -0.2751934183299886, 0.20110553706309578, 0.3236312628972377, 0.21976588244545367, -0.049808054131945695, -0.001203172497859613, 0.015330626029092674, -0.07960384463423495, -0.4384376289030864, -0.34604541222896196, -0.3011940613742762, -0.5636553007358819, -0.17682705457218753, -0.48698868347168073, 0.49537567621980155, 0.11296500827838062, 0.28246946539453904},
    {0.4785138231497842, -0.2653035078523119, -0.5620472349678689, -0.6895092373273896, 0.35501593286179195, -0.36204989238779867, -0.2757460120954322, -0.3897031127236591, -0.2099010056724099, -0.09073835939192575, -0.27285125263460713, 0.30356503499629717, -0.288553888788803, -0.40859857058095733, -0.29378458126361745, -0.5265044817944973, 0.14416027630872974, -0.7729535306228115, -0.08817592670178499, -0.47006509086996934, -0.20847247552463288, -0.12451871811313632, 0.33732691580052987, -0.18991700490508362, -0.66782808743223, -0.31682694354199187, -0.251231946120122, -0.18372697037699212, -0.03236216600357295, -0.2607700805113765, -0.3536273727935308, -0.5453801451450987, -0.04795196336500456, -0.3068968664624568, -0.30401062137235424, 0.5135829244465366, 0.31258373349671587, -0.6231356930906792, -0.11282902431516408, -0.23165577138985932, 0.3305147890319866, 0.3150794343534079, -0.32457460382519127, -0.3474187795371366, 0.011456784326693337, 0.3948154037911352, -0.4941953482926189, -0.39351017515344605, -0.4976339419147111, 0.03727655950880074, -0.2841524898126958, -0.4342901698774115, -0.19574967666129217, 0.18889772713063993, -0.20006538025197448, -0.2971299185252317, -0.4927331696922752, -0.38292963326889096, 0.029696210857648234, -0.23466361308999417, 0.21270621356400374, -0.03272969545961339, -0.20324987853000454, -0.07851707129225913},
    {0.42403441106447337, -0.31211917169420816, -0.04814017684102338, -0.40245154927028876, 0.27127569057126166, -0.26170262689067264, 0.27822142173171927, 0.4073224361670737, -0.7638263591014167, -0.2516438426363395, -0.5814019077213706, -0.322079282526177, -0.58044218605264, -0.7783958197715973, -0.3055812423158002, 0.04031313717288588, -0.2715392911803453, -0.5640316069339423, -0.3911235357241005, -0.40354413240305637, -0.46893509440265224, -0.0003109731178792096, -0.2706870350765125, -0.006487252782158959, -0.38576311111239775, -0.5225769903610601, -0.30063989441611194, -0.07362108026959753, -0.6240472336754729, 0.623690759797175, -0.6705833595888689, -0.46563204968752187, -0.19558436510347665, -0.12127594229050304, -0.3210327264538096, -0.39906028598838633, 0.4849013481587732, -0.3906087852325705, 0.41126971099269344, -0.5262530790111197, -0.2686855803894372, -0.48032741422225156, -0.24295497379914532, -0.11176895872857932, -0.6752157000569718, -0.06596547129831344, -0.1595435160692761, -0.3515057461022378, 0.06266606368653549, -0.30582845765417577, -0.021865009882826955, -0.7647097496176352, -0.1196389336472581, -0.21259122927496168, -0.3153429432608656, 0.09962601004550765, -0.7529283140895905, -0.23823239768699722, -0.6280426524209395, -0.6032059828188321, 0.11365700067880202, -0.11628879950805664, -0.15359074575227316, 0.22608119402261057},
    {-0.2513012048308975, -0.6784801602244815, -0.4317556004533509, -0.5011802635378068, 0.19693079629752624, -0.7853305621628242, -0.27057551990329176, 0.6673916739364222, -0.7450176774892817, -0.1273668761399759, -0.1712490246672644, -0.16117349089391264, -0.5976940525207527, -0.4933212352654033, -0.5055259606206118, -0.20849417801006387, -0.6448247343664919, -0.9270770842394138, -0.576766527876729, -0.6642293867694598, -0.8071307104026375, -0.5651773933957596, -0.012650874558850307, -0.292174434600805, -0.5882889184350686, -0.5859728749414596, -0.8033531160284835, -0.5904026583866211, -0.48983002778646106, 0.31264144983148673, -0.6434796443594706, -0.5573517442533138, -0.6454007304124115, -0.6946823195366567, -0.2439823226189049, -0.398871212289293, 0.25904736599640016, -0.5684439801314796, -0.7179460686429147, -0.5953310897342009, -0.5719600711426868, -0.19019016310947517, -0.22626059498930504, -0.5079037748753281, -0.4209997646113066, -0.029092438840785245, -0.10816128516948413, -0.7191290449102068, -0.2076948988237362, -0.3116594711075451, -0.019132079435908663, -0.42542955794258297, -0.4348079380349875, -0.26753793618365207, -0.7517762811538358, -0.3384165458111833, -0.6763528822093648, -0.6777143901047001, -0.4322137480332538, -0.32544036459246306, 0.4503635502085006, -0.5190382397212642, -0.7393488496282685, 0.04773927883054324},
    {0.43638062951660206, -0.0502199084209153, -0.4213609597420466, -0.4613080184469767, -0.21403093385909722, -0.2326636252307209, -0.2496116097210713, 0.8285933311415936, -0.04417271146532652, -0.506882958539908, -0.2769498891824767, -0.15254652594409837, -0.42149174162134645, -0.22665774813072362, -0.23095049126756698, -0.021484248863128014, 0.24526588594854412, -0.39698171894048756, -0.3677904044819544, -0.5982285546533873, -0.7401882511564313, -0.10672819545112681, -0.15231587030696836, -0.2357554261347241, -0.45938571658395594, -0.7601906138243248, -0.3313304510873458, -0.08814304111578507, -0.20948341051943867, 0.20888503816959902, -0.5701738599314197, -0.7962679475794868, -0.28236682123518475, -0.6216011499565223, -0.23586406955626465, -0.39668800891629763, 0.4999691851070407, -0.38460828547385406, -0.12160387526421985, -0.5477548425102517, -0.3282789064460924, 0.2701809082467917, -0.4897954386653798, -0.6541736073302923, -0.5965994823973866, -0.01401610339134633, -0.3087013824784535, -0.4843535972008083, -0.4128445992066553, -0.288157104723149, 0.12017029844509843, -0.45116698015800755, -0.5986561341318914, -0.3139933284675527, -0.4711791773302163, -0.48227120257496014, -0.7078295798224985, -0.5019546496384557, -0.3493989660550607, -0.6028042267585548, -0.3232706235838081, 0.4153747116197894, -0.2402065089369709, 0.29983556752450236},
    {0.025378810032426653, -0.26720222922578113, -0.6666544357027826, -0.8812172970993228, 0.26049290828187555, -0.446797993568822, -0.4940501328049227, 0.6849595898755022, 0.14376844328223506, -0.5986095676975125, -0.283220334866788, 0.2327882823191416, -0.47142706011917745, -0.4174680988840313, -0.2971386790172217, -0.06370829553422133, -0.5484908468834357, -0.2046672608608208, -0.654919027856469, -0.7797390384923317, -0.3012173400336542, -0.4240184491719157, 0.17452153541280033, -0.22485671574469493, -0.5986490400980315, -0.7121522690176523, -0.65054901649366, -0.1051663910365497, -0.29124220881097346, -0.07507870543099723, -0.9102679409938635, -0.5665525378316411, -0.34298636708661095, -0.5883927697629996, 0.2559437150668121, -0.06998907582270747, 0.09627311652813456, -0.4806085720781149, -0.13666689361710768, -0.18358488709420598, 0.23158806808468158, 0.06522480739505987, -0.7703304993381016, -0.3944937626148344, -0.21588021629687532, 0.18235398747684842, -0.36617639135087227, -0.09665809848267637, -0.7571837905404275, -0.6610163373050395, -0.2493411678981418, -0.4313472569891222, -0.3941000537327233, -0.6744520893421492, -0.44026441635529423, -0.43718416138302424, -0.264455643736017, -0.4289342820559058, 0.11516484565300839, -0.47967395980340677, -0.35068064243939884, -0.3622299002292801, -0.47830623557656554, 0.15594007037786434},
    {0.28555523755515333, -0.603670930859063, -0.38250149933067445, -0.6484908286808495, 0.8687752465720647, -0.5453545691600591, -0.22715392125206402, 0.5347589015585628, -0.35666586235933956, -0.5076904461888242, 0.3383939376685698, 0.08250350581854267, -0.42472702344211144, -0.6490148237628679, -0.4220986098522412, -0.7066220082721717, -0.4320816574326324, -0.4920388389107499, -0.2688533139952072, -0.6510078967685282, -0.3382564525918777, -0.2714675769010814, 0.28500814650795814, -0.7315581956107358, -0.3971304606844671, -0.6805254078813788, -0.4915413854803672, -0.12225623044682406, -0.3866645911864885, -0.22493050953063048, -0.5492397652136284, -0.5689447971662677, 0.2707616184178692, -0.2750330801455642, 0.49857238884165644, 0.6785052483347986, 0.3364976281185419, -0.9411896878616741, -0.5645752487855563, -0.3169313524489388, 0.19807931055558586, 0.33301652281636207, -0.22519499867458503, -0.29927448490973124, -0.4553109970626084, 0.6088144307817713, -0.8789123077299805, -0.6633168719735663, -0.6363556542640532, -0.45263901638751863, -0.5025927561654832, -0.18982251986098342, -0.4375490537338852, -0.25315943258734774, -0.4676577919619779, -0.27536381092527196, -0.18003163151283946, -0.44093159441936464, -0.20879651950421615, -0.5484922825261171, -0.5470283335145584, -0.34011541294542613, -0.265395642678095, 0.3854991850932507},
    {0.4921081948389162, -0.6322499538871823, -0.418852332441014, -0.8328565501737439, 0.8697558576829564, -0.545534587809327, -0.11757938334356441, -0.29620428233030466, -0.5064548776329191, -1.0317551133532152, 0.5306766293469662, 0.006253402613266213, -0.4035195900257255, -0.5150281122732457, -0.6650323031188191, -0.3503085398785628, -0.38249764425886595, -0.27793938432427107, -0.4084126563602306, -0.4906794657994212, -0.014612733855731313, -0.3526793222425148, 0.36079217572482625, -0.5375776229314052, -0.22984853767469834, -0.8060395288834603, -0.9936455581040863, -0.6346096941460108, -0.38928731960092766, -0.374810194287892, -0.7012724199297483, -0.6122716089067901, 0.09785270384904458, -0.4558071140430445, 0.732946086465366, 0.4160243903890448, -0.12536268035707135, -0.7058915647664193, 0.06344494008605296, -0.332492815659094, 0.25981199089615387, 0.61636417011668, -0.38901128821088343, -0.3716534473499657, -0.18388926962866978, 0.2878866752472776, -0.736211169419949, -0.19466450373666794, -0.4263717228345032, -0.40853098579732605, -0.5190218133855862, -0.5081507666464867, -0.013564720749660511, -0.3106850840657878, 0.18870415658785944, -0.5040965863536283, -0.12145332651589408, -0.2965399755741442, -0.47780979451590305, -0.49246462821551623, -0.3620728456837663, -0.5363685299928004, -0.6626821464287089, 0.4999658267441633},
    {0.04151921679732661, -0.42558499850696696, 0.10236082678899254, -0.6027247956290416, 0.7064779191410285, -0.7969906757408055, -0.02953315887273099, 0.4593826310509867, -0.7204264312651995, -0.33159376534323404, 0.1842568230654822, -0.2307818038498039, -0.5543218410117478, -0.5552863810521569, -0.6096056816963294, -0.2408636825344552, -0.6483616009373135, -0.052868487731520794, -0.7932450530772235, -0.5227130312955676, -0.5308111723876494, -0.430842938804142, 0.19038169889833673, -0.6578733364695682, -0.37987545637180364, -0.921654947502023, -0.5223425580929738, -0.5635421718227691, -0.4339736607173505, -0.036797497506232534, -0.7625355594959418, -0.48199537832290246, -0.37627480659053036, -0.7555786196110839, 0.6256205590792286, 0.2018536703517406, 0.41147963580316915, -0.9635295157062435, 0.4070142147487248, -0.33387120153745947, -0.6523267056566388, 0.4544324790108978, -0.4273061112636394, -0.44664971004564374, -0.1363762876708521, -0.12318841874377823, -0.4153791526227408, -0.6012934481465708, -0.2543389523885865, -0.7164710006204446, -0.2513682741299574, -0.42486516400705776, 0.008063050917605138, -0.5887853617984076, -0.8093497223903827, -0.3331222830793418, -0.804371993389815, -0.1694619048160261, -0.5515622332565212, -0.5166102356541544, -0.4579376118436557, -0.43462157486301906, -0.4141391093757853, 0.5113139273583182},
    {0.7245031558413224, -0.8112030481924137, -0.2659919692729301, -0.5336184953987092, 0.40164091601946605, -0.6875304814935542, 0.15455452381600518, -0.0740700395755211, -0.16981152161693505, -0.5679245776375718, -0.21356267597217846, -0.1533201265453999, -0.3125358062199603, -0.15436682285108094, -0.3781490390003926, -0.17512896367542, -0.28837759757974013, -0.020346347181646893, -0.08560122657085834, -0.256939695216783, -0.0685477262564453, -0.4507511310485173, -0.25928919392539695, -0.4833903691156175, -0.39458330992347734, -0.4926521520240338, -0.4575837435246275, -0.07738941179833847, 0.008325710411865715, -0.17778659994802212, -0.3015423504064289, -0.4652350572341228, -0.13219500719850202, 0.2089972919976839, 0.1078490001741916, 0.1777923971453082, 0.42883055235874035, -0.4935119652258061, -0.9307925921125205, -0.2894630387235936, 0.5136244226991187, 0.24821286754148492, -0.5601027748242715, -0.40493094208114777, -0.4335185267333921, 0.024542311061265143, -0.9453469827388514, -0.4363095589508912, -0.5675071864766241, -0.19729434335890347, -0.7429909525003675, -0.233462457931915, -0.32452135061193677, -0.6269839239293459, -0.006737253818328977, -0.41789211819712707, -0.4552233981785577, -0.36964361872186463, 0.008456793088348593, -0.1856193463010356, 0.06287350120864083, -0.20130644814295018, -0.36464410422406424, 0.1226075898588679},
    {0.3707391299822258, -0.6535378057501113, -0.4116874610972954, -0.604793181416355, 0.5128090085685565, -0.6651389387620745, -0.6416207209548729, 0.6468435899922136, -0.48990293456569994, -0.5377626827583036, 0.38670057449163653, -0.027899143789057477, -0.8658635455001408, -0.6846344252685582, -0.1496957573312884, -0.5448337264282416, -0.7509377989897091, -0.5906630770844841, -0.3274680996508975, -0.4322949621225341, -0.344114025761651, -0.17936260299755225, 0.37787561621310684, -0.5003683995927293, -0.5144429937723318, -0.9112412192794661, -0.6337039750120825, -0.5483465323369887, -0.7058546511763902, 0.1060640066631073, -0.6438521524004084, -0.3788214535065399, -0.6147015203396393, -0.6549496836697684, 0.4351044226038993, 0.5691873960761348, 0.30465395905279163, -0.7219509938929943, -0.6982213049006456, -0.6172563414873159, 0.045258822305797544, -0.012344275805635262, -0.031998838186807946, -0.3948784718642095, -0.33167164067182336, -0.049357647334435616, -0.78200907606367, -0.497420644332064, -0.6380316306384314, -0.2586926734804929, 0.049956898914593796, -0.32591239543007033, -0.5125308304924177, -0.019287583276594415, -0.22883476536608352, -0.39875454941507377, -0.43584975330921016, -0.579826156491977, -0.102076062677742, 0.34913910500206635, -0.3873674399709234, -0.42121453181717966, -0.6317575828543015, 0.027721530666654604},
    {0.2649397140969541, -0.32916121265746595, -0.2936575651264394, -0.16471703173710783, 0.3142667511178464, -0.3680736519892615, -0.16612027093583556, 0.44250602644213627, -0.33382692968347594, 0.1048077056298982, 0.21912971577580675, -0.4875187878069097, -0.1775187585643438, -0.6049583118592203, 0.06701276227080347, -0.44478466748562734, -0.03428713591817031, -0.5793867178490253, -0.17192123656810288, -0.3533268619594363, -0.5728698880400371, -0.6400800121663955, -0.3738536306208991, -0.44908769744448535, -0.5940315279953312, -0.5309254371102903, -0.4847691433579064, -0.14327708586049773, -0.12149040858568083, 0.7539696816575943, -0.0019321982678142302, -0.1317526026111105, -0.25944988526362156, -0.38504021935762817, 0.2743835546096297, 0.5105059237798065, 0.5816847269448746, 0.030128832117393842, -0.24091902106468374, -0.5859795627805063, 0.24796419575542467, -0.07944818259037979, 0.4175834876561671, -0.5519579948438852, -0.3647385330515151, -0.10951170585704216, -0.10953195864370074, -0.659287151355901, -0.2248032713865929, -0.17760507720228877, 0.05860959418189194, -0.33156537056885593, -0.47315844609370544, -0.22109029629191648, -0.4608723902292067, 0.09177778320728654, -0.5405651372378804, -0.3002698259482316, -0.7468593258053974, -0.13883336723031686, -0.4442398514362406, -0.12369857915688164, -0.6146819436013193, 0.5615939228895995},
    {0.07649278023909893, -0.7076063286855525, -0.7982829295912443, -0.9396973412441978, 0.5043059084532333, -1.0331516402128573, 0.003099416453751234, -0.5460629512748518, -0.5843045793017666, -0.13924672989499437, -0.27841480210246805, 0.11358108182980074, -0.17964981766806973, -0.9320867691914628, -0.9400935502936189, -1.0594320670630328, 0.3679383027396232, -0.4517530674014015, -0.19077010967134012, -0.8004094078128609, -0.11877962502111666, -0.6210882346575206, 0.3332498509354073, -0.6621579068916357, -0.2175597264268954, -0.031974209469825404, -0.8217313598674149, -0.7785799243226936, -0.6597436602373041, -0.660944180035543, -0.9138319140138581, -0.8353515051292024, -0.3498918582900421, -0.13151950563692355, 0.02341126416673261, 0.4649725857298768, -0.06805510475792069, -0.6665161553856207, -0.20205154171357492, -0.577181176328411, -0.7339927880232423, 0.20478821667770286, 0.2762581395939698, -0.6739899139445693, -0.7699771949107868, -0.19078950883015766, 0.1490995228065491, -0.822171834112409, -0.4508134840564829, -0.9288474241737739, -0.8097978789839025, -0.6437129589272219, -0.7658191141433823, -0.14274472119503395, -0.6235347605304224, 0.21230803689343958, -0.5476120318433294, 0.29471484046033525, -1.1464065641431562, 0.04119844180173314, 0.14021040880149327, -0.934408056163478, 0.1256864174444693, 0.23921208161721227},
    {0.051076430102699556, -0.18944413268634996, -0.6305573842954645, -0.7030641790963906, 0.7104207512321078, -0.5604190705327972, -0.28623045955712223, -0.5971228290924159, -0.5807794198787022, 0.22382173170381373, 0.04514026729897339, -0.01026245724852702, -0.5362203678072615, -0.6913194032679324, -0.41193900857037896, -0.2770580522625778, -0.043486907016006285, -0.2073335154095304, -0.578830723970799, -0.26065392062268156, -0.3140095183116783, 0.1280914112729951, 0.28371715842555273, -0.7037739108414783, -0.02494726822421135, -0.09812137483634253, -0.4668486388550844, -0.6111520855250144, -0.8522710792044259, -0.3515302513826501, -0.7118265070944163, -0.26918040490743883, -0.027671156879203136, -0.027770283404284085, 0.44234033827059266, 0.522663083014354, 0.29676856628375636, -0.8017496008762185, -0.040617545313980055, -0.3048764371576271, -0.14640708601835986, 0.6218447472675489, -0.29855865303873924, -0.6163700986073074, -0.19791298912505195, 0.39711054383046157, -0.3519345045517831, -0.9549786645102134, -0.47248056326437965, -0.8372204366036761, -0.3739017942239036, -0.18446140659788937, -0.3748869630947168, 0.17897033846517393, -0.3690850109014285, 0.5013540459809845, -0.5781381560333204, 0.10618754990033305, -0.6787535889269135, 0.23146427119261873, 0.21357028092863156, -0.4798365791189611, -0.04953948053337374, 0.6715218771429646},
    {0.2096413385656775, -0.14435832054691392, -0.5387897241816499, 0.045940887318867855, 0.1966276147924438, -0.5794044300630334, 0.10793527289469587, -0.6917918257410534, -0.7033372729953038, -0.2435235250405835, 0.35973619841442167, 0.2802785545008373, 0.09220531880242282, -0.2855487610349741, -0.6606863121317968, -0.4565432995711336, 0.13485850017061068, 0.3728296254436674, -0.1713714814922814, -0.5637081673231039, 0.4722811605032265, 0.5407285841993528, 0.7999063283902759, -0.595839794412457, 0.2768994780415717, 0.38037069355374176, 0.04483823982501761, -0.5436173127885228, -0.23717016660323886, -0.2078084015894192, -0.3743570749992799, -0.6456627871852484, 0.05199879387661787, 0.29521802798036195, 0.5176472061213759, 0.5300491983246296, -0.10315107127198449, -0.6078983225953472, 0.38085084657294366, 0.10437015142195905, -0.021098219507576153, 0.7062351506072684, -0.6941107891022386, -0.2862985613730105, -0.2666459725037328, -0.6980911325064418, -0.12323820678176411, -0.39040172766312486, -0.3045809808966534, -0.6062244062592096, -0.6228357778787358, -0.21365432541752105, 0.03779771407818172, 0.18551607071885354, -0.5628356866707208, 0.20001372739789644, -0.5191275975457357, 0.4249950280999138, -0.2694193591152205, 0.3285365497486019, 0.1155903886582604, -0.893456959856148, -0.02221784769219769, -0.13358923070421255},
    {-0.02641879749602868, -0.1173757430231151, 0.20905247476091512, -0.04150068712211473, 0.7307321482682855, -0.9498068123426102, 0.5095309287177175, -0.2625968708313447, -0.44339116391930955, -0.03333445189101195, -0.03409752335112823, 0.214198634957999, -0.11347329403452731, -0.08413193107000828, -0.12549585162910482, -0.7347092172324678, 0.837492104045599, -0.025774039753965933, -0.15308699595988415, -0.15766088048744797, 0.5978694729320536, 0.18841079981883396, 0.7108161458504696, -0.47960359505835026, 0.3457049849833584, 0.5788957111939044, -0.1111768455652585, -0.46146709623488624, -0.593373797665561, -0.6240663777187551, -0.2081949885694252, -0.05584206476546446, 0.3644013519217961, 0.5215440955635502, 0.39687806407392506, 0.1611004926744664, -0.018207239841809886, -0.4283389729853336, 0.5749810657662975, 0.3545642030350354, 0.009791675398297315, 0.5759298269248639, 0.05796243656171447, -0.2298115197054092, -0.0745162218170764, 0.08570525794067732, 0.4155979020170459, -0.21587432096581977, -0.2872959219766379, -0.10514860058107961, -0.623040463356444, -0.24393389952318092, -0.1490550803523743, 0.21909839907194587, -0.15660158250243952, 0.6775187754035447, -0.5124405468564277, 0.533904481562383, -0.5719670502978972, 0.09499179877728763, 0.17604620635509063, -0.5834515705997766, 0.1186013872191004, 0.22755031408105664},
    {0.39576774973557977, -0.5273097744023902, -0.23941619131528952, -0.07837935752583493, 0.6615280177926068, -0.4771988693919951, 0.430295482480631, 0.09366773872048821, -0.26927628966394285, 0.24511598691127676, 0.4831453136727696, 0.48390667318952535, 0.1356807576346547, -0.06428240003292601, -0.8000040054823861, -0.5847739584381041, 0.370183142697701, 0.016795414300900154, 0.3423406266893918, 0.35585672943157914, 0.26641772299338484, -0.02866739197995293, 0.5941803601103599, -0.8652583725671523, 0.5058554116577406, 0.28664895694880255, -0.1769906288828768, -0.17314879866482805, -0.5062190344364633, -0.4675477681130009, -0.5337532001453367, 0.12092687587858905, -0.026713416617951884, -0.15913544350012446, 0.06622703872933129, 0.2749467733495099, 0.3309885408664766, -0.5912387890937744, 0.47316184577534254, 0.07883588291860488, 0.4587894795768529, 0.7483374972790806, -0.4831483079528055, -0.19549259233054092, 0.3899828362023203, -0.007732665870940776, -0.08710473707818414, -0.3093768950927943, -0.721250592987886, -0.31547894210111194, -0.32036087485953596, -0.6951570731659606, -0.32338233934856647, 0.09159832235908608, 0.23817916168830555, 0.4679267751585394, -0.5443570731068407, 0.4447473966716149, -0.2644474182835422, 0.008001789979565896, 0.7491000520364881, -0.10848294261626644, 0.2231940660651598, 0.08168782600359926},
    {-0.025855306634772805, 0.0667795461195504, -0.38905727723715133, 0.30521004575827865, 0.3926109525667372, 0.06302671409127322, 0.18658977300205296, -0.38742687770015916, 0.10218694178809629, 0.03941053688496252, 0.49771514897024505, 0.5979082021225255, -0.05354339973082227, 0.1754383560864693, -0.27520857918941466, -0.2807098003535377, -0.35673440454682925, 0.3144160292808539, 0.10982796456786141, -0.22110631580878753, 0.34575070073839065, -0.40613974919589513, 0.4651104327110986, -0.18720542251549288, 0.4136041124849044, 0.19677342353902852, -0.3124189597433455, 0.07597880216190644, 0.04877785772879315, -0.7004319543047226, -0.49454983590966356, -0.3348552779384724, -0.30561916627275076, 0.2558748944305742, 0.5522006428121945, 0.3813104501671006, 0.12031832934734348, -0.47027912970180047, 0.23681407420122721, 0.41125279483541044, 0.09803496698783322, 0.22097476337099808, 0.03846275601296444, -0.389767832877774, 0.6461470687062536, -0.15907584162911811, -0.19448039590950406, 0.3126391449335698, -0.6222520579113149, 0.3674486431149202, -0.3763279351315613, -0.1865632960692557, -0.33533343575672186, 0.4631410110003327, 0.06099624574961692, 0.039476791732336064, -0.6250154788887897, 0.4488418909548683, -0.2213903947585112, 0.3084808928463576, -0.015354266022397253, -0.27526312749372067, -0.1526013784186265, 0.6659676010818177},
    {0.09830659851058876, -0.016213613111891192, 0.22432014773551875, 0.4376474128172716, 0.2938346043932315, 0.16192973878951397, -0.11325364932408719, 0.18565319425025067, -0.22017455820684753, -0.35820799985107465, 0.36845354539116254, 0.41317289002088314, 0.008379342885605939, 0.12227066051932764, -0.3933971380910873, -0.7692110301596411, 0.08930014993932686, 0.16516322104148937, 0.08712571614203304, -0.11811702063193852, -0.24299279529554413, -0.32206642611541764, 0.6686034488263264, 0.1821330985309266, 0.2215594492761587, 0.10663867067096568, 0.12098337993991563, 0.003724401433881194, 0.2962450365159408, 0.12568104409886754, -0.31421347563298113, -0.038556076943669366, 0.12115400464779748, 0.2821420977397729, 0.3835998057107778, 0.7069945187163241, -0.1066365512905325, -0.173853574030805, 0.11930176237198507, -0.5342380933112159, -0.27024547887706474, 0.9934223603633943, -0.30924356541670667, -0.08589921870085544, -0.04477151938796912, -0.31290806354915696, -0.04738699471939937, 0.06391468660319233, -0.3454329937761078, -0.31272159076485284, -0.13817339346776486, -0.33889009221549726, 0.3212972955069992, 0.03238843533140304, -0.21490408381950316, 0.16433803922138782, -0.5524999068630772, 0.37684596536306897, -0.30762571310938674, 0.44227860782034284, -0.35659610344809783, -0.30876030520955483, -0.19943956872226176, 0.10388324319135757},
    {-0.31472899450477604, -0.3212488454961352, 0.006229115733097479, -0.15341325688068863, -0.10965114971525664, -0.1648654757753788, -0.11023264672759023, 0.14015099856278634, -0.5739181031247896, -0.09987729785274255, 0.03298486345961269, -0.4803047344349909, -0.1774589961691099, 0.060556923114112066, 0.1776248149666844, -0.2841043060573407, -0.18593085891200478, -0.4428508636182331, -0.1199068868203068, -0.5583427168047509, -0.19333274585592322, -0.19254815416186238, 0.26094818914393086, -0.42064454766779524, -0.16892074342937954, -0.06903732974796306, -0.13027214751899902, -0.4856666737878529, -0.787645754481623, -0.1914942390291824, 0.05388846264087707, -0.4474484105090691, 0.03501542458762545, 0.06966098059934461, -0.00541594506351189, -0.1041845183628767, 0.04562115888547318, -0.6084348827000207, 0.5599405960941637, -0.3162767070726593, -0.47624421848222515, -0.3025991326502325, -0.6248804405631883, 0.01170743877837071, -0.4203691892712229, -0.606958583317066, -0.24478056246484417, -0.6368322688375866, -0.2782111378189804, -0.4560024621864321, -0.2072405323259856, -0.7844376867437947, -0.10641106172541812, -0.16205671676783345, -0.5031634304392535, -0.09094298859737168, -0.6190351932735623, -0.16043897765119944, -0.7196062319204748, -0.5628879033341162, -0.1749172619804188, -0.4133473024666289, 0.12231851983128529, 0.2761359124469078},
    {0.12684906574805574, -0.2934931942385308, -0.4450283591997039, -0.27875237344380094, 0.2750475705307979, -0.3625071414500436, 0.043343077416634686, -0.07249821060514498, -0.3650609805173053, 0.0011071117802902452, 0.013532718525790426, -0.08252837664469688, -0.5130467348135914, 0.34267442631601996, -0.26103578642410796, -0.08430343744243786, -0.1451634518466522, 0.3515062880808198, -0.019611769375012203, -0.03303520996098116, -0.006495884051295612, -0.35817079698503024, 0.17300197448070728, -0.3607020426639499, -0.3915592299780541, 0.27511181382183214, 0.012408433972634386, -0.34007920621002763, -0.8590374967380243, -0.11397743469093499, -0.3474069425737961, 0.07432992306414375, 0.4730975046872406, -0.22618351081265806, -0.15346709846497084, 0.6106607613864719, 0.14638458779933364, -0.21016651388780516, -0.04377678353955187, -0.35946700434740875, -0.28421191880967833, 0.05602928658739622, -0.3025432480535277, -0.282025897386566, -0.47897650652879725, 0.4563958912611165, -0.03808978394068184, -0.1673304984682814, -0.20977619418143809, 0.05806102279797024, 0.01491977626331915, -0.5104977150427424, -0.11594002228481953, -0.05665836590585283, -0.8385694711478794, -0.3978045082017844, -0.45017664818455405, 0.2602472818543594, -0.3945425632845324, -0.1384016809297381, 0.5716272699602223, -0.2982533804323286, -0.24086411850390646, 0.8380945336655908},
    {0.2150811767685584, 0.23140001293741633, 0.0320288011968741, 0.05456642582205917, 0.12050105061782404, -0.16551592808087773, -0.08980676578436877, -0.4731756664019881, -0.3606788158023233, 0.4078357287788405, 0.07205655616184244, 0.3064373085367391, -0.014295950743125898, -0.12452115480310158, -0.325269076892083, -0.030586409102482403, -0.40044181538749574, 0.13169869653067176, -0.22626958861084817, 0.2215785180988371, -0.011336160383896477, -0.34170070545599834, 0.2988172649007243, -0.1272800125678062, 0.007017254658860254, 0.0649127602137233, 0.0829949960223028, -0.35315286791293515, -0.39749588337459724, 0.053432149322708886, 0.43757118688576474, -0.3880279748560716, -0.3271800790104151, 0.1696691201857415, 0.19186483606941407, 0.6449400162531133, 0.1723858836331468, -0.3659522237899435, 0.1382294168569587, 0.0371018345396827, 0.41229914858413763, -0.0020551233307117395, -0.33256543004539796, 0.03641637534054227, -0.16844024621187204, 0.03576323264597431, -0.11760897870722833, -0.1534502328128619, 0.14161722155450662, 0.2440488157608403, -0.46046676092883376, -0.1455640316846936, 0.0730092641959958, -0.050462427301829024, 0.03606150687476001, 0.06500063194019458, -0.42690721571032214, 0.1104195314483237, -0.4637997504322295, 0.0977814069361775, -0.07312762578955187, -0.22234691355497044, -0.11813535080909107, 0.25222982728011006},
    {-0.3009029179736676, 0.45548073641273057, 0.04725940366271854, 0.2072235328950842, 0.252960716703458, -0.19643215398160338, 0.1041046357562717, -0.12708748047548254, -0.24062575545517523, -0.06420673877447501, 0.14874572968032745, 0.8487690893494129, 0.4215683754114871, 0.1749490605586359, -0.04374996452240369, -0.05831167907580166, 0.21156390229259042, 0.28947379760161046, -0.3842955213815898, 0.01614330201817894, 0.2393360339512512, 0.34272808111992403, 0.6596577353494028, -0.48774401349282265, 0.17735539341080325, 0.07369914138448463, 0.20198106950171393, -0.11488824156989765, -0.3114409766223227, -0.2593773218047264, 0.24391817568439308, -0.16129150462858044, 0.9378906174589328, 0.06812104118778092, 0.5022613318016655, 0.11700743569095466, 0.3674649960065191, 0.10758031987536416, 0.3092496910730198, 0.3680079954499082, -0.08418772091466724, 0.6127379935909241, -0.1917715013899726, 0.29326316350468745, 0.5476794611815298, -0.14491619474458564, 0.5158112136027967, 0.011954144015662692, 0.12972163057819994, -0.1115188052943694, 0.3266958792819001, -0.10344640484335446, -0.4734424951023587, 0.3845895808434038, 0.43028523738009794, 0.030200369886003237, -0.06718523106331274, 0.43065974277858043, 0.2197591523471965, -0.01048016172807483, 0.3198498260008509, 0.08249518060040743, 0.5748822036605779, 0.3445672451514019},
    {-0.15536376968347174, 0.612763525672689, -0.3014101947854158, 0.20491990278196218, -0.07010319790448687, 0.22198938817888766, -0.18134072146942196, -0.37123873429280296, 0.23005568864759415, -0.04749410412603602, -0.05385554942048361, 0.5991072820713444, -0.018546095546508153, 0.30049539185855995, -0.12034449479046648, 0.21141587655279273, 0.5011618038869011, -0.4740554842681134, -0.3862941311419508, 0.07561618898036404, 0.27799514636713485, -0.17691305167549246, 0.0751282533122624, -0.14642481142313182, -0.4053188923010617, 0.1579935483234426, -0.1272308629059059, 0.07810484135930208, -0.06656452565539349, -0.13806779571069677, 0.045054101197898745, 0.3503052547224103, 0.507320247241283, -0.1887984717469624, -0.23749842852723968, 0.19675528688177357, 0.35658375330771197, 0.22918288856326455, 0.3752868811220879, -0.22086739471635308, -0.022590477291812038, 0.3634385563708906, -0.2988693596977428, -0.283735147980146, -0.28648783566567326, 0.040706922615627604, -0.2725260367262807, 0.46196113024444885, -0.40270006427963967, 0.23917775462674598, -0.020529266280196492, -0.009602242211624158, 0.3426301645487394, 0.3442630113505723, -0.01943520877609703, 0.2403975718640973, -0.39399377577391176, 0.11395010331176501, 0.3437191277797868, -0.06478690055751671, -0.0604888344306718, 0.00015766757014622887, 0.3773643380701166, -0.09842505909973583},
    {-0.32837690968312233, 0.1448823394592155, -0.6612361712014632, -0.29038794597664885, 0.27960077551577106, 0.19496235970667689, -0.45867463656507046, -0.06177995519816484, -0.4507156163440754, 0.22139976161048314, 0.2723403112843143, 0.18069229632537054, -0.1748659383981928, -0.11109715081084603, 0.03768088154355744, -0.4117362826388285, 0.5245247411821545, -0.3230241593324592, -0.003832956142546425, -0.14558728083748285, -0.35334423425097505, -0.12925634978157835, 0.08258955443764532, -0.13885946161808613, -0.2644279403688982, -0.41432510665286265, -0.3110751696237164, -0.34650462687877065, -0.35654904378914126, -0.1411154319702524, -0.10902993976621844, -0.4381735773567918, 0.4178987472129277, 0.18144371083226737, -0.12091543002594392, 0.18763056272625006, 0.02003684973736179, -0.4200945317288524, -0.03530623652298549, -0.012604909812701334, -0.8302905452058519, -0.1705205158900448, 0.15829157218208142, -0.10840685607274288, -0.04869691554054245, 0.15281551694121873, -0.559845552034234, -0.8149813106105669, -0.6045517021346708, -0.20542643870079738, -0.19260275944906924, -0.2721498315123188, -0.28767261069317696, 0.2694607044616687, -0.3380544812110073, -0.029853611999971125, 0.08242267766848582, 0.37117095356346147, 0.1626087932963252, -0.7550487363390789, -0.01607297671209027, -0.16656515250639178, -0.3160327835124128, 0.45887888305719704},
    {-0.03731880675393585, -0.07874228778376555, -0.014137281524190665, 0.1369218210862209, 0.07834157900491803, -0.16568194591649077, 0.03722152301014319, 0.02837376734542717, -0.35214266432731517, -0.029443676544389206, 0.26774941253634293, 0.6219498839551331, 0.10381181436073264, 0.03538258460356234, -0.2522718924462253, 0.7350110957404892, -0.08717564954079145, -0.3111775434818688, -0.34002145464693156, -0.22355289200768091, 0.10046303247229452, 0.42813103791252766, 0.320407850541147, -0.19645730733153172, -0.07989945914150164, 0.47767598920831295, -0.04654660104231321, -0.3450000223671831, 0.10051705871397346, 0.14561483899645922, -0.15635132011637767, -0.663241578563231, 0.13754754474680583, 0.33556482867219645, 0.6687887501904809, -0.5131244385169935, -0.1199177610776975, 0.17644718078194566, 0.34382323834291434, -0.11566006668339408, -0.22428443267781803, 0.32051091895265066, -0.22455045130771292, 0.2783364892128298, -0.2335750741645591, -0.36631030427743067, 0.2404644487893685, 0.24280861667478615, -0.14447367483747228, -0.43577210366932984, 0.09603129103360339, -0.5789502588821204, -0.07785068649953342, 0.4141154840272794, -0.08505270588284033, 0.6166463290510639, -0.16276134260747063, 0.19273515408699007, -0.2780932772434208, 0.1502128800956642, 0.3241555902492585, -0.24508611860597607, 0.40930649544612663, -0.07688600402767908},
    {0.06834096303696174, 0.17584191245382283, -0.5496861566756379, -0.10832840289917652, -0.5535447074119301, -0.12033599987224522, 0.03733396170951329, 0.02867836185980698, -0.41716995387716194, 0.05468960289658088, 0.46658221469802563, 0.5162236578442224, -0.16144012120783452, 0.2917830752538386, -0.4448723592418276, 0.3495334482005197, 0.7840672658263886, 0.2118983824588964, 0.058490891565663845, -0.5226558293444095, 0.4329316473929074, 0.6541754858333285, 0.5482097607339825, -0.10372589016132631, -0.49312921336145427, 0.10020565845953458, -0.018110043477560105, 0.041155920365029804, -0.37406493638512545, 0.07355376893105273, 0.19028463205811075, 0.6144308382931377, 0.17668099418673008, 0.018920291395058284, -0.0033293565449209056, 0.15712979415459125, 0.5969577834722899, 0.1673167725666845, 0.27664598780310334, -0.20384719130095105, 0.3910089672405151, 0.12181939903276631, -0.7126706988423621, 0.2347650284033625, -0.11669925563759205, -0.14783899723632019, 0.31358536703509854, 0.08579872295009991, 0.7403976442180301, 0.4911804105036661, 0.6153317123899111, 0.2204867780121515, -0.14546033603341674, 0.10508524232210834, 0.2055967088945661, -0.05479114471371001, -0.062287286891149776, 0.3093701074605196, -0.4192718368204818, 0.2252885757689862, 0.26388464302158815, -0.2219711666463351, -0.3302865776465712, 0.3402656878299353},
    {-0.2043020577368796, -0.1472224417998546, -0.2555532607306949, -0.35390913056080636, 0.4200095006215862, -0.05804884667421202, -0.3630672556716215, -0.5900126063971023, -0.1885581659045269, -0.11829136350526176, 0.2055721316601419, 0.1400265928193961, -0.5989251026736007, -0.22951146666793215, -0.1891016907958352, 0.09296440878557803, 0.4656026725413633, -0.4684815833445764, 0.29736478757226054, 0.12097567107859443, -0.06815081496140726, -0.20857690475207008, -0.3757290910086524, -0.5503094400642426, 0.32136917045062324, -0.23085228738939198, -0.44114630876242594, -0.4525841192758467, 0.06455727529021141, -0.03578068589180893, 0.2672069536155041, 0.26965207940529284, 0.8195222613671806, 0.24384981822856247, 0.29392904665116953, 0.23659575222772686, -0.2985925532735348, -0.47365151406281303, -0.2710379235181702, 0.40750103247803676, 0.2929822382107428, 0.43770986754579455, -0.22220478465917592, -0.07213870913927183, -0.03166734378104571, 0.4074680251194396, -0.25625275695161187, -0.1622699161422365, -0.11940817699388867, -0.2974157852655214, -0.030862920709558515, 0.2941596615657877, 0.01871221066508653, 0.023520155323335415, -0.057837650084559745, -0.39455482519963125, -0.06271216260661366, 0.5620921929844283, 0.050033533134616046, 0.05825380717128576, -0.42688941035734546, -0.6502656389951773, -0.44386681924446714, 0.09075544634339962},
    {0.36572391244767755, -0.008015597679786926, 0.35052798235848404, 0.13825157374233235, 0.054997825210350584, -0.22520985663438622, -0.030239642043451566, -0.16820326708265415, -0.006406281412752754, -0.09653452819079561, 0.027254096598609046, 0.4168558208283694, -0.6713850337530736, 0.07042730227533879, 0.18415641760301382, -0.5558974310006293, -0.3205636680302767, -0.27505331431182106, -0.6089753509047781, 0.10639905555118857, 0.2789576696375235, 0.7383312642920057, 0.3158437935263935, -0.0666528259279793, -0.1383007756053197, 0.6233818086511406, 0.11375923348794617, -0.10817099187770286, 0.1979275691371946, -0.30671349209188664, -0.08541276219807395, -0.25070680518429617, -0.26851309359125813, 0.1919732272443239, 0.6760134419622253, 0.14362028343190686, -0.7764682709639447, -0.019894268229533076, -0.0635250894945298, -0.39613390330835996, 0.32701297002528984, 0.5258853165410113, 0.1947786224787359, 0.39545750090442705, 0.07455667629329576, -0.1920886688119287, 0.2478870502097938, 0.2630971677808662, -0.1050604668225915, 0.002498301441611616, 0.7718792076194892, 0.3110317534650735, 0.17451556772463928, 0.23084762857352537, 0.3419726399181438, 0.11297616536140273, -0.014547284759718983, 0.08069377463626291, -0.08566426635503915, -0.09140509543180439, 0.1989239867101334, -0.16088679492665117, -0.22098370836669393, 0.07083991977750458},
    {0.5176858573685031, 0.3206094282041218, -0.0597243602407744, -0.10486844739681979, -0.3060826374572975, -0.05756329873344698, -0.024362744177923123, -0.4663146585139565, 0.15769807480178813, -0.4730581569535112, 0.13878775481515487, 0.6352535847266029, 0.4394348956730175, 0.002277409207162858, -0.07737637392239763, -0.5514833904654203, 0.21343495475252705, 0.4863756886065143, -0.3487477947957513, 0.5013057515175445, 0.3194057773213433, 0.30951754722276725, 0.6704185404602665, -0.4331870227404822, -0.059458885662130374, -0.03329667373818883, 0.028850770040936103, 0.25675025798508005, -0.08187689065757676, -0.5616455723427032, 0.01711758351656396, 0.027508999755158706, 0.6144892665189894, 0.41323165564822206, 0.271692669021504, -0.10665409737616521, -0.55252029852436, -0.3724460221395279, 0.45393449122589064, 0.1628122793427605, -0.08528241624288571, 0.40066718750845953, -0.24990095833311124, -0.22511311463810965, -0.17045630088145372, -0.11809681502865316, -0.40051281162058056, 0.44420912070978535, 0.06995011503626535, 0.2980045667073043, 0.27280136115738945, -0.19322223748774153, -0.16208717677707063, 0.20468505895853412, -0.0490619910136423, -0.02112255978646453, -0.28161058845348735, 0.5225766425780901, -0.43819767931642817, -0.8857134058129588, -0.07688461654458965, 0.10913277245590253, -0.23819381953932736, 0.3389498879416946},
    {-0.06832134259768971, 0.12534317400765915, -0.00911105173704873, -0.08603298234953459, 0.12928743917992763, -0.023877284862234883, -0.33557056963466464, -0.1947505338682958, -0.03749681440175997, -0.3432024100488135, -0.13197975609895463, 0.3684065963103314, 0.15349208748867735, 0.3734358985814884, -0.04592060166175739, -0.1521973142555162, 0.4158658989872904, 0.1356140435102221, -0.1449292995729397, 0.40091192798209835, 0.6805401145599951, 0.6576994293810385, 0.48932485333152254, -0.1052489950251555, 0.621890918293175, 0.05870226972658626, 0.6785789660733297, -0.17584576336457644, 0.2706679818932487, 0.03503700519779524, 0.46424660213881025, -0.04268096097037505, 0.20391215228076587, 0.36564937233948885, 0.08496404967911099, -0.059390329472125795, -0.5665776418496614, 0.2375255194630854, 0.2545891144489464, 0.05474292012781494, 0.3210782859899199, 0.49241125155626314, -0.31836902631703257, 0.2824110843239642, 0.12907603458105035, -0.10083649592745822, 0.20075238082649957, 0.38521376265573903, 0.027027566934997412, 0.4897130815733957, -0.18339367254268182, 0.31711940665637184, 0.40147732633341415, 0.03194752645912958, 0.20102475809609516, -0.6730341816643223, -0.15303493434434298, 0.621309540458132, 0.2196096063977893, -0.3416059432883763, 0.13007031184461523, -0.18623250718456985, 0.5000509235889592, -0.33071238548535614},
    {-0.19797715525106507, 0.5657446158578325, -0.19879225815748708, 0.44089479930771475, -0.2197227199365005, 0.40883081756975137, 0.408046884058784, 0.12345225201658465, 0.001193370658152452, -0.4260595183755554, 0.604764136662102, 0.24766519375091353, 0.22629039494142575, 0.4409373628252101, 0.21854880447858493, 0.29767571747453275, 0.37883536205554874, 0.5934364549586927, 0.16523307058465467, 0.20071886023601151, 0.5071779393775644, 0.5063137172410435, 0.28588514910381935, -0.23623351546678809, -0.053983566186940224, 0.13100344649688295, 0.22175517199746522, 0.2558725442674772, -0.2542916036695288, -0.6358172016897111, -0.02079637281449296, 0.04228492158848221, 0.14115931788092176, 0.28046482069132256, -0.15392552161141976, 0.18258629237093094, -0.3179094530901502, 0.085176866261786, 0.22675041008062707, 0.4479826824758706, 0.23827125562901957, -0.2778103151362058, -0.02113718007857531, 0.08965362067610748, 0.33288420131928637, 0.2015332858789954, 0.6414719914599027, 0.44732793990362707, -0.29760540967114507, 0.5066347033188434, -0.39127310666410475, 0.6155073317385704, -0.23659223575088656, -0.22314812951398388, 0.037699239002767906, -0.3025760378701062, 0.25856947288681786, 0.31561145072196084, 0.18279114634637764, -0.3096660404642315, -0.0784823562217121, -0.24611930548572922, -0.3486159647849666, 0.3371821035384629},
    {-0.22256358250703132, -0.19733074304449505, -0.14022497717190863, 0.252924154178917, 0.4409847624877201, 0.037293403254655196, 0.5413887856917012, -0.04303220310208873, -0.6459968614827151, -0.2790249256021316, 0.5465811258004615, 0.35746870599389524, -0.38201021458244605, 0.06192206375271933, 0.7113431166180672, -0.5057882299590344, 0.14668375786470816, 0.42555927424381096, 0.08284288613560438, 0.4560387956947501, -0.35217462858435644, 0.6399248757790496, 0.6289734700079018, -0.4848653662460028, -0.36384425044426694, 0.1566715601903819, 0.42218226992936225, -0.23357191542406788, -0.0877370514241845, -0.4281559390179032, 0.05408098611056159, -0.17193778423786193, 0.4289767616416615, 0.265459881370957, 0.30112059258673163, 0.17017831306794368, -0.3461246362345314, 0.04869121264227043, -0.2662015123607202, 0.5961842003536654, 0.07174502847679991, 0.0695939874328757, -0.476147609527696, 0.21746172944016173, 0.10803454615971257, 0.15049781852189584, -0.7611445504647667, 0.3793626021908654, -0.3201285423690699, 0.1298358228659298, -0.041476727389030806, 0.6372449623556872, 0.20428361589164024, 0.3300779515724345, 0.07378080256215054, -0.4824648762412831, 0.1359818655679363, -0.07201664179458905, -0.019291372607955305, -0.3754044845682149, -0.13013098270247694, -0.43565414562853394, -0.0068513549135478125, -0.25831257648566636},
    {-0.1870603494928885, 0.3116623517548812, -0.2533836053895415, 0.07658124446976049, 0.12785083982242723, 0.14950805444542026, 0.2995274821124763, -0.03897463795218632, -0.4282881417177194, -0.030589444500187496, 0.2520210488551539, 0.09599535331971701, 0.09146229592235433, -0.2123396215626033, 0.3656861205979812, -0.07977486759507181, 0.32056813072331014, 0.19242952464548102, 0.4966025669253955, 0.5058364000074846, 0.060133854314617714, 0.36712759830265057, 0.0702827928270238, -0.2622574100720708, 0.21554284597498355, 0.2903755387903341, 0.36021979395788184, 0.21644933407059277, -0.16842376198262235, 0.0115259838452595, -0.003885174271719298, -0.2773401637221084, 0.4328542799700393, 0.10078817357095764, 0.7501341982359319, 0.5339361805593731, 0.47692318306603976, 0.20766613284341331, 0.48967417006630554, 0.13385077580427748, 0.08329056885751233, 0.31225982259992, -0.16451944002798569, -0.2356501703608376, 0.6509116555849548, 0.4137035265022487, 0.00012174059676433255, 0.23873222270423455, 0.01530647695631177, 0.40325828453832674, 0.2771415102805409, 0.49455803561879075, 0.23031519567231293, 0.1494519269314384, 0.5060852705793341, -0.17545867485017091, 0.03143118083829854, 0.020199317958257478, 0.457032730383249, 0.2225117377983446, 0.017025299344999127, -0.009783094009139529, 0.7227501249617049, 0.30319228125615244},
    {0.2653305850127815, 0.3649229864597019, -0.030259400063905505, 0.22330293363431003, 0.41151581376861973, 0.22302520198137288, 0.29339730662139546, -0.134786204282737, -0.23139557119718543, -0.2688740683925514, 0.5689616346745153, -0.08553709599098212, -0.04980445384766323, -0.05830545056703523, -0.23931974490165192, -0.06861815835374041, -0.11253498220493055, 0.24674210027771393, 0.007927977373431584, -0.002120330117507869, 0.2632157501972107, 0.41224952645625507, 0.2033309543720403, -0.052983142297881924, -0.3398386385449371, -0.24416102717996288, 0.33733183789466525, -0.04189715132183874, -0.7304207042989103, -0.4259589865363427, -0.3022118371827721, -0.29175797990181196, 0.16414024666423774, 0.27991907785982956, 0.33209442869860234, 0.29187022695649556, 0.5192949304070048, -0.023095761418514948, 0.3823408400909087, 0.18952876981107888, -0.2125700015140302, 0.49293207540168993, -0.09153153050457652, 0.46863461219557634, -0.06308129848179525, -0.06120520879950845, -0.2644876701819921, 0.3550045020672189, -0.5726849206440797, -0.09465029260938244, 0.06050753822839082, 0.06741734755072532, 0.1326049499718677, 0.6188208102214082, 0.3665456170006884, 0.3582197633774095, -0.19008886061602778, 0.19460193303501944, 0.25153820397909543, -0.19874361946532204, 0.4630941342235929, -0.25672391979464243, 0.6276246259160202, 0.42368990489219827},
    {0.3185320498429576, 0.3937253616604284, -0.22105614253670072, 0.061642900168457145, -0.043832174166722776, -0.5375993228759973, 0.19322452770992768, 0.00045766711182179144, 0.17273003389555525, 0.20437595124752808, 0.7885118370893588, 0.04189701504605168, -0.15269186477657565, 0.7230491465194451, -0.06820036325006197, -0.16460915820749986, -0.8626664043476099, -0.10618746323303567, 0.0740019296570969, 0.3469003814144801, -0.016218836813501423, 0.15054248232140566, -0.21360705318464557, -0.04682662685871225, -0.18384089222467329, -0.4584402635068727, 0.4638130797858452, -0.2402038851201885, -0.44488070000444846, 0.3441196018223161, 0.06316626234366116, 0.25079449370360174, 0.2384345837100618, -0.48119310210855293, 0.13435813626447218, -0.07633628775903442, 0.2470776027338563, -0.252728390640249, 0.1812872674385158, -0.4504617338681583, 0.1933439733792148, 0.312525487718345, 0.16088652454373187, 0.054261585511310155, -0.25334007700979483, 0.15208867122485026, 0.2177261114813224, -0.09260738616239474, -0.0808474055458464, -0.19824633507587505, 0.4292201511293444, 0.5511985169530547, 0.2913698630756165, -0.051236901044068146, 0.37687609112192394, 0.08499300232228743, -0.04555034796770891, -0.06403959300996491, 0.4092919255942154, 0.44588482516175115, 0.18070516966690045, -0.47851422636000135, -0.0962572348597251, 0.2885474340152431},
    {-0.055700086696887655, 0.4950744107886642, -0.3400068552136765, 0.39282146029261333, -0.2565108925802701, 0.027732586737885166, 0.33031633093754015, 0.39538358104847027, -0.2675255128672541, 0.3272439968507068, 0.0377635653274598, -0.3409816342794999, -0.26121188438871096, -0.28341421351537993, 0.01807795953090934, -0.10028628006458488, 0.025577321969404182, -0.12874722061535013, -0.01973999560318212, -0.04217005868540454, 0.07124878763144632, 0.11942156960988314, 0.5140419819491052, -0.05776624906960199, -0.24139903504455335, -0.9240843923448814, 0.5841681074270487, -0.23792563448946782, 0.029939442842226143, 0.17103574876198774, 0.1765394339868794, -0.3116129482683797, 0.22526250956561816, -0.15378498149673991, 0.3359149185769005, -0.3233682554168242, -0.2242593508023986, 0.4847427600040823, -0.26891273046505815, -0.2919676124694965, -0.5284878117692092, -0.1509542018548843, -0.09911766601266028, -0.2760314085660561, -0.1251207302203977, 0.16334373008155134, -0.09186674572117454, -0.1259255190900472, 0.17430219305139835, -0.21499027332251985, 0.4262294173193708, 0.09820035741555704, -0.11345575066898497, 0.01658329096582429, -0.15678230134688223, 0.07794197391003237, -0.14389570311113978, -0.34724419595933714, -0.34967452207450955, 0.14104713699348, -0.18345715781605096, 0.3825729673726919, 0.26437956379708893, 0.20669945845984727},
    {0.18014383835336603, 0.17445789433764317, -0.4667675908766727, -0.06745633140860041, -0.21295396007297115, -0.29251065799731735, -0.7059180648728755, 0.20883524504505604, 0.2520522247739013, -0.12648289593943446, 0.5058388701806615, 0.01199063636775869, -0.3368092654772274, 0.38709389203903627, -0.1822221683867649, -0.523203849630801, -0.5871013183227782, 0.3289774651696593, 0.6651429619175616, 0.22255484124673186, 0.19978561993773736, 0.11295098012951355, -0.04079199337475573, -0.12517895091307174, 0.09850754822391551, 0.21856468199839044, -0.1835908144692568, -0.29132534638254326, 0.06414618036760154, -0.011733441744101958, 0.12860291333012644, 0.3842835549865776, 0.1095349399516174, -0.34861441520289954, -0.2603058339942379, -0.0053022442250398386, 0.11304789552461579, -0.2429864289952414, 0.07369260975969616, -0.5201228819283634, 0.9083945201357543, -0.0818986377573688, -0.025412254054777598, 0.1368881090723139, 0.39626493409279767, 0.006539582417415697, 0.42487473845585744, 0.13269126362283903, 0.04848833082411127, -0.24156112852510314, -0.6781175008970227, 0.3969047062610604, 0.3302396399483214, 0.3947726657424415, -0.31583827785990176, 0.7144895127552063, -0.3643334189990369, 0.018943243301029124, 0.18137163171275503, -0.12151122426481317, 0.4520433134759416, -0.4178787570860086, -0.6568863535709896, -0.19077466500832008},
    {0.23206770331474233, 0.3314982233587728, 0.4733903750789736, -0.1332359367516223, 0.08892989177421666, -0.1215982704950595, -0.029088472816537137, 0.44068407499748186, -0.5014953527858964, 0.08040830948729656, 0.28653507611442286, -0.07266239656166774, -0.11766900699383984, -0.4835876406982817, -0.4950379690888723, -0.30070049229792356, -0.16670318883626176, -0.35812826788462876, -0.4704447039395647, 0.2787016874598175, -0.2789350166839367, 0.21395596524402125, 0.25473534452725627, -0.5459791761948775, -0.2515179285501693, 0.19538625044272992, 0.29835806927672154, 0.21898792044961343, -0.21640100250695063, 0.11946504658182566, -0.009823311850296107, -0.2328626880185609, 0.014785867784551725, -0.0322510914644653, 0.5108074940026065, 0.3309387599427476, -0.23545098504785975, -0.6220591543715756, 0.4913071906305493, 0.3308999163781849, -0.006791391297606025, 0.4870164761126442, -0.018248128818240717, 0.11720063941474564, 0.32108611449566504, 0.34683903957109175, -0.08999897796689768, -0.4745742302738877, -0.19583934729173408, -0.017998232381367812, 0.267305862945587, 0.2161585771756765, 0.47654460711559804, 0.19958006118062271, -0.6209471587572392, -0.39289130455587157, -0.07749708414385101, 0.5252344970013124, -0.14781041582390977, 0.06906007460325736, -0.0016627179893395723, -0.38429419012550864, 0.04695189585884637, 0.2116780430517045},
    {0.22928998538103207, -0.0887632149598826, 0.5607833946856393, -0.3402428194540901, 0.13293260696962808, -0.12352428727262023, -0.4907298209637696, -0.058645574843269745, 0.35219803114758114, -0.12246368147925175, 0.1843715064045381, -0.3681916484858309, -0.16820392862803904, 0.1394430395163288, -0.3465175738032911, -0.003871247026415189, -0.5612095873250054, -0.17922228012563496, -0.14859538309340312, 0.0046352851526043565, 0.2747685703273781, 0.3000402554530802, 0.22381227547067473, -0.40911701086262714, -0.12258974932387384, -0.29834935633526616, 0.12106249355817741, 0.2034955050546809, 0.33226658002946297, 0.21514977488313924, 0.2828699717568586, -0.031185567429619074, 0.13960018480745753, -0.011309625368447977, -0.19465216462312632, 0.1560616109837784, 0.8390568073940854, 0.16646673248807747, 0.6230534673255324, -0.21809422105279982, 0.1575461521260799, 0.2533437529230188, -0.10911067265541013, 0.27099342591334535, 0.01083198560989847, 0.10000601929504432, -0.0366759148969578, 0.30258754633338786, -0.33383636550042195, 0.02471174022906052, 0.24147228379873548, 0.03654114487844467, 0.6380710209542427, 0.5462742831290611, -0.11235423249771248, -0.27524204273734926, -0.13256296789153002, -0.39091729115929547, -0.2497189733941249, -0.0020835923542300416, -0.16816399977551766, -0.07407221930143769, 0.7174862965797001, 0.6661185400531556},
    {-0.18169376546590818, 0.5869093279290851, 0.010365212041995843, -0.047652704066596906, 0.6000230266178188, -0.08278019780921061, 0.2614553146354653, 0.3068923614149195, 0.40074162958747545, 0.4471705109231629, 0.25853318490901517, 0.4005843681659508, -0.25425586342564954, -0.4875146407123291, 0.31189995790821695, -0.4057125246583719, -0.2162450575403492, -0.23745688317965413, -0.09988499660434626, 0.22252420454152513, 0.20847140632223565, 0.2289397598587715, 0.7812194548679048, 0.3074938276927028, -0.6302584756775558, -0.29520505697277444, 0.05720370409721724, 0.09154711181437819, -0.15260600407032288, -0.3299916925967708, -0.30853377156650036, 0.150403687194173, 0.35247768126846224, -0.2882882771796451, 0.5578367560575145, 0.5150655133226613, -0.15613967230354017, 0.16932608515527597, 0.020232781838489863, -0.18737848732512624, -0.2671507805914712, 0.6108802750588269, -0.15739493599066626, 0.027208175939480155, -0.10414286792704633, 0.24153301058538368, -0.15538997046952016, 0.01715441990907408, 0.2736918898776234, -0.029138654933719796, 0.39755239617459487, 0.2647417339643407, 0.27380613406736704, 0.45986586743273183, -0.2646183010660859, 0.3569395828097247, -0.4088198598361264, 0.2826485021762754, 0.14769200632818635, 0.004481100264921886, 0.005479740021162844, -0.6262256873916416, -0.5317151654000769, 0.32626703244450794},
    {0.3831666472919119, 0.13855247683448854, 0.4721891400322698, 0.07780552778606308, -0.13586387959076954, -0.6193592842494408, -0.22458083686171054, 0.17109370757178044, -0.14115067551759722, -0.010661023760395896, -0.12464825279135094, -0.15789141984579794, -0.3736730807139937, 0.07996404904740162, -0.08112687576458662, -0.4442330376233399, -0.3792578810158523, -0.28874368880233026, 0.08473240847463194, 0.34176565658489677, -0.022183786821664192, -0.019716628512045777, -0.06488019188147238, -0.4421157203537924, -0.4666773428511964, 0.08567316698325117, 0.10712114325080965, -0.13600335689586124, -0.3823988631749329, 0.022228470585389664, 0.20889318264485987, 0.40506089600130313, 0.48398639545273586, -0.1772713761849619, 0.4323924313008685, 0.38747168787909375, -0.1634674506487604, -0.014510362670267956, 0.3624069098681337, -0.015074238439601645, -0.11467430570058629, 0.24191078649527845, 0.17725058274982897, -0.5750127011931356, 0.26656986156758417, 0.20428612572879304, -0.019804649323270546, -0.3498087736115673, -0.4299537372088097, 0.31547170941433167, 0.19986273171770547, 0.10455293539327497, 0.18220934911569478, 0.30418686325312316, -0.5774298135346836, -0.18351009680530497, -0.1906973388685519, 0.02768518071689743, -0.26824372598743096, 0.04286671788874672, -0.19585135542006027, -0.002579703298328683, 0.10261020482469445, 0.23624162448291924},
    {-0.3292030543814131, -0.025425490900480234, 0.36335404077359534, -0.03182618341680472, -0.19788908982653242, 0.06820226739979199, 0.12061916442544583, 0.34633415214498964, -0.1327686190758028, 0.15276777907959613, 0.1847246483830065, 0.2130708929123565, 0.08656789442414807, 0.10674379809524759, -0.2888643748391893, 0.028409876407296343, -0.004098055858006952, 0.2842789864932334, 0.32992890028907257, 0.27355315970372374, -0.4539439658870416, -0.1926981825927572, -0.13284684136443103, 0.0013777347609574106, 0.23413719368973504, -0.06498173192230039, 0.14578028495506576, -0.16903684425724605, -0.1496212408917388, 0.2509410124440995, 0.00956170903025851, 0.36605811012142603, -0.1820688613048574, -0.019996083812274964, -0.32682801526098715, 0.23619292321425728, 0.08839483542903981, 0.6108280670694428, -0.5282065397668214, 0.19967902462464246, 0.36493358646577445, -0.2522503592074961, 0.11347314265223499, -0.6629833418881667, -0.14642576181689312, 0.27437711766028877, -0.13611061426823373, 0.40892544466784836, 0.3050292490949413, 0.317750020027606, -0.005327458116844305, -0.055139295433683316, -0.5226863743845047, -0.15941342519395207, 0.11460968384763977, 0.01709136548147966, -0.2045933512177435, 0.21198756217351444, 0.1618496189206249, 0.16156403762298852, -0.08285620640076528, -0.07788810553792734, -0.24590930505538208, -0.269109901690189},
    {0.0017832589793382089, -0.09521254225380583, 0.09804586599592535, 0.3531862623760709, 0.19016448656460747, -0.39285069425621494, -0.3478604907670927, -0.24768484069487637, -0.1264241133440947, -0.4405583984506386, -0.21205840052667269, -0.4432061104266337, -0.31786506919939533, -0.12235252841084185, 0.012021018658511797, -0.12429676864967348, -0.18093106481665996, -0.09813488266623445, -0.002305962502733781, 0.01496878698085283, -0.05704967723096994, -0.06917410771873425, -0.35690640025423565, -0.17182155824389694, 0.012974095758517715, 0.16857046191686062, 0.3556574924891067, 0.2933996619375255, -0.12930583329012088, -0.017896622419076642, 0.22432999935243353, 0.5342528293360115, -0.10854222220624886, -0.1775668363645819, -0.40702507034875424, -0.21576450077783915, -0.5243056959377815, -0.33727238152409483, 0.25354294491123003, -0.062448792014181166, -0.3149500082752304, -0.1265798019604815, 0.18207585184292377, 0.1033822305203186, 0.24468190107518606, 0.18959019243349173, 0.026693131835451675, -0.01470666090982437, -0.0601224309557065, 0.3958230268759178, -0.5776669205572591, -0.10948812375990578, 0.5741909082204363, -0.4834891600768493, 0.11273778228811789, -0.24026169897602115, 0.47798942000730327, 0.11074686192670294, 0.01768695405871212, 0.35146998017187736, -0.027994575972992927, 0.2089881025567294, 0.3626365036777221, -0.08505172337171205},
    {-0.4362600142741737, -0.10335224034604676, 0.07323076427039821, -0.3046505018283009, 0.22050946930344015, 0.33643033353930085, -0.2623848051476389, 0.23801314942765456, -0.02345922310160254, 0.010678222615083471, 0.339142440859016, -0.03178025548273464, -0.3912904079955815, -0.35601703900007914, -0.13654659724227272, -0.28196645913876867, 0.27967707980315437, -0.20795526473208004, 0.09449816823628653, -0.061834764727018744, 0.19020242907269314, 0.048452192908788605, 0.034357062439006394, -0.18360920255398178, 0.08873294414636489, -0.21189489013968923, -0.06913925975647904, -0.05025530396593924, -0.25068490184847514, -0.021824532140368665, 0.4558773352276572, -0.17779752883135275, -0.43035488297246516, -0.18954958780129427, -0.085311302393904, -0.5902170144293258, -0.085919005836292, 0.3016243654007196, -0.0736962350297661, 0.11615054593017742, -0.4880803600431304, 0.021441962252749382, -0.05571065953103694, -0.024205301896177932, 0.16631710422898952, 0.015378998868908268, 0.1635449378483521, 0.16605013153591858, -0.0686524723571594, 0.27725611228189084, 0.3295541991660448, -0.10670355872194856, 0.15890237355903308, 0.013592872777500743, -0.006144490908517005, -0.18493282579955173, -0.08321680956400171, -0.061766571606251694, 0.1547959371957574, -0.10056801812125529, 0.10176491457016523, 0.6101759680204984, -0.037983642852730023, -0.040164532575622545},
    {-0.3557060271162913, -0.16351550340137572, -0.4332119805193155, -0.40998688252717397, -0.17288816842729077, 0.3483019953223501, 0.20298923001009822, 0.4285712439522333, -0.05501753170062025, -0.23021343039072575, -0.22086716740445222, -0.4535337217630267, -0.30514369720378354, -0.008240968597659845, -0.03100395832707496, 0.10581899673861157, 0.5127251683202345, 0.21342791213904028, 0.0259912100363106, 0.12155047713981336, 0.2966284566335047, -0.09689201922455591, 0.16598778804465078, 0.3342444833817561, -0.11919618954901269, -0.055879043758317176, -0.4208791140514035, -0.08177469492042358, -0.16306086450740562, 0.07430545461110868, 0.2994641440347789, -0.29722563402360574, -0.43183439104561155, 0.08475797649509402, -0.05812332205536035, -0.025742314041918252, -0.050267566916747046, -0.0063855728111397595, -0.013204572961156815, -0.2901289482931975, -0.3667524685274815, 0.45925373018625293, -0.508378292008186, -0.07350717495904886, -0.41004185551960737, 0.1346921452162236, 0.08449445573975439, -0.6932522321836705, -0.07500903640710861, -0.1929477877318133, 0.1335728870066014, -0.5665456039607912, -0.7462554860596236, 0.06416113742466505, -0.22787939337518062, 0.34284455852615525, 0.02417876263676204, -0.3238136715454022, -0.23331764354165502, -0.3350523084318985, -0.056126868082412955, 0.28082792369965515, -0.408597946491825, 0.16615486833208815},
    {-0.1420649069230898, -0.3612125976641377, -0.35516279628910635, -0.45908071973487025, 0.1561834100429577, 0.045986153907483604, -0.13997821159415147, 0.37239865315481896, 0.16471181191838533, 0.009141084119726332, -0.10882779257502273, 0.3120221760582046, -0.3640170368552917, 0.4036761369804952, -0.07314650387627536, 0.12712118944409906, -0.10048189413638714, 0.37253973086689834, -0.1423893484854406, -0.23885042489675024, -0.2297506369251302, 0.2584650043832806, 0.3159257488018749, -0.33164808272559465, -0.2821895715512163, -0.25953797476411516, 0.1932745000542474, -0.01282737367201999, 0.125123532336598, -0.27748921267002963, 0.007994498804586634, -0.4667033595792339, -0.2784757493966534, -0.44970378502961245, 0.28189730612361535, 0.1532336082102047, -0.09669611525520957, -0.15937092080164908, -0.04926209236829181, -0.6549459024974063, 0.19878611471143076, -0.17406124557798974, -0.11621175716247226, 0.1560212869331818, -0.14227502740486137, 0.09158803597827153, 0.18065307008435005, -0.11472917512553063, 0.057315914209227964, 0.01165270981673438, 0.17807298274435052, -0.19992997184473418, -0.5365450292995135, -0.10550089088953866, 0.22921294935291908, 0.0748287885026748, 0.18220147766829795, 0.2932011237976008, -0.6750873525753287, -0.42869629499852296, -0.011792116251289078, -0.32728357608410114, -0.03791026469572199, 0.03907889834544466},
    {0.22531919035248368, 0.31835386417514583, -0.2831924415635551, -0.13357032545861136, -0.16470373259178864, -0.38904091386346246, -0.15165353515148736, -0.32804303599716766, 0.5997654675687373, 0.4521099014598516, -0.16247824034960553, 0.45507731808111773, 0.23552581578841045, 0.021648004088313473, 0.037787507045539105, 0.055957598219662036, 0.009310111108957604, 0.012646981746010571, -0.5103820462828763, -0.32100467989703485, 0.14269389884346534, 0.678171531285675, -0.16929881733691726, 0.1404588846389275, -0.6308805141449949, -0.35857419626712067, 0.09297707029793055, 0.6621650394801306, 0.3964722274759691, 0.02463735800758006, 0.09708052413231003, -0.12631509254273562, 0.14835006159396077, -0.11594708510777266, 0.31873398082272275, 0.19541140551042688, 0.2979503939927987, -0.23228349590199018, 0.2751363134911655, -0.44732385420719095, -0.2585524924871811, 0.034020471926864415, 0.13475017146486803, 0.16267053271198276, -0.4813996178555222, -0.08744571208127436, -0.22720023481054125, 0.148922385154124, -0.0676605261357494, 0.03133545792255424, 0.21782367144196427, -0.2201126574324403, 0.26781645809563054, -0.11996625204866358, 0.10048166880125678, -0.0886791452105095, 0.28409357179019457, 0.17964212057000434, -0.18070035256043288, -0.31211874401607936, 0.16124373814318915, -0.4975498927356631, -0.17739248751716596, 0.14474173457495257},
    {0.4253140700907533, 0.08675546613449533, -0.4628734431808865, -0.04942548778045043, 0.15306777967543084, -0.06766096038717642, -0.04814038006556803, -0.028733744936585724, 0.5647014457660712, 0.15108084823174273, 0.04603385654851576, 0.3907307039607978, 0.4560013921143057, -0.11415535931989203, -0.16529768580767662, 0.23155409126429138, 0.11959017663435824, -0.052314695417051846, 0.10766529996324656, -0.425927644471043, 0.029584589934999322, 0.2665018886130066, 0.3006406704067147, -0.15344541950433768, 0.1203016636153219, 0.13321870656467524, 0.4297463997692327, 0.3697088393050933, 0.3952638397580856, -0.028972240928871178, -0.03243836078976397, -0.06438523375573851, 0.05780602750301827, -0.09134957518239965, 0.09119962453230036, -0.04864204847044355, -0.2494598269265549, -0.6784927052152567, 0.1126527131414414, -0.44674744530173893, 0.2431964872394602, 0.18568439930599584, 0.10064360264456955, 0.05025969547418655, -0.3467384459296398, -0.0017388681153068235, -0.391643224599977, -0.21740687105813475, 0.1191013759552084, -0.11735646822484914, 0.15224990755524948, -0.07944424901489539, 0.043238275398174146, 0.5461735370596541, 0.23276168887169313, 0.3615599014498982, -0.09509206856086044, 0.3849344213876842, 0.7178612583949024, 0.046786835146321204, -0.15208725948824087, -0.5644833655299493, -0.045591080368208456, -0.4964753110142964},
    {0.6302783683045408, -0.041537946317195866, -0.06813784508085512, 0.10241909012903808, -0.43343623660081193, -0.0065988089287145595, -0.06817556413327651, -0.10675744940736814, -0.34902930069150895, -0.1484841724796042, -0.14055478817938744, 0.3547771870286635, -0.2763667816537923, -0.17819200778596886, -0.49105911772204935, 0.27572643907600825, -0.3697938806317933, -0.16271176690090147, 0.20885074590898234, -0.3873339704228134, 0.41863493144914204, -0.23411700238017202, -0.03344321725496472, -0.04067683013462576, -0.39308460343440504, 0.23821704527725998, -0.21326357131036616, 0.030545738313331284, -0.5270448829120825, -0.3366826016632151, -0.48859826948657586, -0.1981848177255709, -0.32030633253840823, 0.43510532646962785, 0.48518088738800863, -0.21195324671606755, -0.04463645115079478, -0.579917150874618, -0.439137179140599, -0.0835965676082269, -0.4197331827588039, -0.23661494619277249, -0.36658371334790096, -0.1659641407116416, 0.555505601356241, -0.5472715425710056, -0.4116276925086665, -0.1847188570967904, -0.6640614986042948, -0.527865283246634, -0.19897322563657194, -0.47818356068798884, -0.37729511358325246, 0.2755176386774235, -0.4411861541948173, 0.21378307935997545, 0.07551753662792617, -0.08869060018905268, -0.4595328661681675, -0.26504881342876796, -0.7181991829783141, -0.15380821642278458, 0.5014086412029328, -0.49356153933261315},
    {-0.09762278121783227, 0.09836871326025362, 0.021478956390995334, 0.24369570199658358, -0.04493665667538436, -0.18611368796358477, -0.3237490307508874, -0.056421546530094124, -0.1621532522252128, -0.1639305586579532, -0.15487009438663787, -0.37479603594242006, 0.03327161928594207, -0.3734833748078682, 0.17752463810208885, 0.15860708798181947, -0.15857121613077044, -0.33510016480540955, 0.33001478887484004, 0.2430456392363064, 0.01218342077628855, -0.35881956349156646, 0.03529553449591232, 0.4603311439815807, 0.2205229756854258, 0.004758577520226371, -0.5445414027079084, -0.11347606467400442, 0.226505921991913, -0.5649595943586825, -0.3817072408880359, -0.17794810014740706, 0.08741818430489193, 0.1951183153674076, 0.408349534680443, -0.14942404621303249, -0.0978477498891271, 0.1067283958265206, -0.19402224635197132, -0.32251249407587795, -0.054866258912711366, -0.17497656245194793, -0.2980646698491944, -0.23687845535478907, 0.418125078551966, -0.5461780764890362, -0.4814809847966106, -0.21120370976779476, 0.051493782246962924, -0.408803492118438, -0.4114588446695704, 0.25685940547638075, -0.034008876011040606, 0.7117032181103877, -0.06495712230031538, -0.5805857856052926, 0.15165244737731937, -0.5174180123669432, -0.208151587361115, -0.2018343680379489, 0.24400003650144084, -0.23834975941778652, 0.41692800649727474, 0.2139728813008006},
    {-0.6888664108667564, -0.32037655089301287, 0.2988523647202398, 0.13763431054302255, 0.1575079450805291, -0.2325136001756054, -0.6808241382642255, -0.23457716815510765, 0.15826296404133336, -0.21908028330095172, -0.4585877892941199, -0.29471687570698996, -0.17795649882387587, 0.13327483102470528, 0.08619404442213728, -0.3910218078080225, -0.2735812827291507, -0.23131101593326006, -0.2880062987741839, 0.008737134011157534, -0.2516541522173742, -0.07721130386184945, 0.0852656898496648, 0.3159919507878174, 0.39081657617675414, -0.2919188055855716, -0.21413112587653862, -0.20863541066323824, 0.18969087204805915, -0.2337104099913045, -0.07726655134806765, 0.18865884179045095, -0.44805045014359657, -0.08352212838960825, 0.13179440613650287, -0.30247095818518727, -0.11566168861429955, 0.27421761730694566, 0.22830720500690835, 0.003578831808835167, -0.10998082613739636, 0.11179867490930123, 0.09491544924990009, 0.2569228417420662, -0.20976997791295507, -0.17760198716481723, -0.19910883258774156, 0.43708451571150114, -0.19415944570252971, 0.2730766038357396, -0.04055280347282875, 0.2860862619912584, 0.07249026798638382, 0.15383441939419235, 0.0777341589564684, -0.2222656455870644, -0.22817418886383212, -0.7133337543894348, -0.08780059193589941, 0.10883476668479984, 0.18617779532107553, 0.04107113278705938, 0.2909206638385044, 0.29099542218745034},
    {-0.6447657350096162, 0.05743949969631353, 0.018957929707303964, 0.5774114776400677, 0.0151364620539232, 0.2814876477181422, -0.0048159436469349965, 0.21388291230646314, -0.017075821664447075, -0.32392533374728694, -0.16527020177496568, 0.3236806511859717, -0.7095069295960498, -0.02413741206250716, -0.39480320482224257, 0.09264360059954735, -0.35089861085956525, -0.2823787578461003, -0.5970608487084968, -0.07043846463201443, -0.13987169870712324, -0.12303010631744464, 0.21065628168823305, -0.18254661463279714, -0.3062349029527634, -0.4182290475132849, -0.2904416547121834, -0.023366542127360508, -0.10620614839368138, 0.42012150666414916, 0.02399969171448814, -0.3630969716511867, 0.06213732340300632, 0.13983099655223108, 0.0021237217396930536, 0.06066517044351237, -0.7335012926224291, 0.5147617122691519, -0.1590848338148216, -0.47086899901989027, -0.022456333818525073, -0.16770058608576588, -0.18682545229616918, -0.11697013022244314, 0.03985799387505876, -0.1390759156063553, 0.17812193900141665, 0.12071051862995909, -0.4261984088013937, -0.06303775664546944, -0.33630447772761907, -0.1693396748357266, -0.034967650967072605, -0.24641319930572242, 0.1616171536095494, 0.3094439077428683, -0.29770098244173254, 0.17303091818463667, -0.35853050519276064, -0.1259525356321099, -0.43791755746324906, -0.04435980655147588, -0.35927937809085536, -0.06563664049464389},
    {-0.06399385600967403, 0.06124768427059222, 0.12267578231703005, -0.02142855937230939, 0.1599115057070857, -0.19095574308913227, 0.031245869798168388, -0.0848835638639044, 0.004892554832231295, 0.06597040900675252, 0.2942735937175079, -0.2732696127190993, -0.5774171508252244, -0.2117113355574839, -0.1466463539469297, 0.40023090277178597, -0.12889057056510872, 0.10341012876968847, 0.330075873883005, -0.5438053137674058, -0.09908749554751527, 0.37097927495583793, 0.4137840970257715, 0.08218819250700363, 0.2898710288107687, 0.1736271560969281, 0.16148607770499146, 0.2877525803531828, -0.12260134450815649, 0.2357011298407886, 0.18009637956480576, -0.19208302434408686, 0.04644290443531276, 0.08428765110019536, 0.24318550694590446, -0.21080869448832748, -0.10274594245845664, 0.30064765898329887, -0.014046641346975674, 0.34068287325427243, 0.28728736111710335, 0.3655017420953111, -0.2838968637025176, 0.17177335490350784, -0.017349704134130773, -0.17150182111202808, 0.2635962906556454, -0.2372997650628438, 0.045767365771656736, 0.41986475889354996, -0.06698514456037623, -0.1378890289524344, 0.28960033321135786, 0.11960817914637646, -0.26127557909919713, -0.21919991415618909, -0.2807946986211429, 0.4238924911555366, 0.020241149866636693, 0.18356306009544807, -0.1420590778105875, -0.025114111108482474, -0.7335760058481537, -0.10876859735640808},
    {-0.18062240485249131, -0.17458626897703594, -0.27057396848338344, -0.0688352034495795, -0.23759772929389059, -0.1697038906039679, 0.24921605806928607, -0.11455145838688645, -0.3403272084716874, 0.16993432633765726, -0.08961208588350683, -0.1946659988069787, 0.18770510400160648, -0.2924106826719907, 0.03911254900430816, -0.030376453180638023, 0.11860235337917602, -0.0017573496539171941, 0.14463897092927916, -0.13636291306617668, -0.07182094644181752, 0.006241666915584227, -0.11449134671294296, -0.35868422658205046, -0.2295067833197196, -0.028254578966774406, 0.18946801776395172, 0.159440197993599, -0.39253313995121347, 0.32773510328194516, -0.19163510211825407, 0.42652063488795655, 0.46334974369806287, -0.47958138726512745, -0.7766392739311069, 0.07512291010932977, 0.6099997209710096, -0.23329278103820358, 0.5113599343353955, -0.14141435271240743, -0.49532761137168135, -0.5692143553892827, 0.09796765075949485, 0.18150793323649422, -0.0935437410678422, 0.25538652661780403, 0.3331749887962513, 0.3277275440993496, 0.5054311901492989, 0.46762643614121224, -0.2635988918890357, -0.02094934429975241, 0.37575567018097134, 0.2233901542429767, -0.32066720527443987, -0.13431793181044932, 0.2007803064687088, -0.01642433046002222, 0.14855009185443604, 0.14916058772918137, 0.7701828257788095, 0.48415654230072835, -0.12740752185247978, 0.2758302463058094},
    {0.2360883572708926, 0.2029272100342357, 0.026930760477506317, -0.027677933035437387, -0.035047448097869485, 0.3323011982944702, 0.1346059106348865, 0.09114360605906321, 0.13718356180124683, -0.25671576527902346, -0.24193040514299233, 0.2255413544922633, 0.2784307537991078, 0.19625845929392463, 0.2020714868779745, 0.05421527248848655, 0.23229224211320626, -0.21571998018148078, 0.2905697518538382, 0.0760871527340972, 0.14147111085224576, -0.2426638942363401, 0.25746052177681344, -0.3683984400433265, -0.24635593082569937, 0.24412733041136628, -0.08596300292522337, 0.22766660756383508, 0.10880964647163358, 0.05768374678121151, -0.025625899628328494, 0.13540643212317227, 0.006067175787361176, -0.16472874192569395, -0.43385834773545284, 0.09902731261662664, 0.09983482101094525, -0.19803908397357065, 0.2658962567641583, 0.03144202651638936, -0.11687761887633646, 0.35668304959762404, -0.23826417606732514, 0.31636656267653, 0.19230615903242415, -0.3449410641349995, -0.17031794439594636, 0.11063563858851437, 0.007246078820628249, -0.15473036458449532, 0.027907538193520258, -0.021955892085452757, -0.25944121897581834, 0.16047003546236455, -0.12569591430963237, 0.012541987046575808, 0.1004342729692182, 0.033111847217458294, 0.3441016265363272, -0.16287695790226836, 0.6630926283597636, 0.24345163873883055, 0.20639935166645643, 0.17355298059674645},
    {0.04937630142700231, 0.08614598210284324, 0.6878270353606388, -0.07485204666652776, -0.15318783523272772, 0.47274268014541354, -0.13918500879893164, 0.10973111460178503, 0.13750239592632857, -0.0959870800081277, -0.4387585353456042, 0.534297923647712, 0.3814166224715688, 0.08779434571967025, 0.010181908291226949, -0.07551921512454506, 0.08071146580217312, 0.04143654851889924, 0.19489663739677812, 0.09680904465783638, 0.3685017614236275, 0.403900240861354, 0.17262378290944685, -0.23398272344168872, 0.3064702494075341, 0.12220387078776737, -0.3170034829077611, -0.05173317515282733, -0.39384897206514274, -0.10021793985961439, 0.12781017005821077, 0.003689279243777637, 0.06462172587500827, 0.05270000924923089, -0.04207675892085638, -0.19105938462897465, 0.26562224977944743, 0.06468506560844113, -0.3627657500212872, 0.3649172267901855, -0.2021094082444032, 0.03811436257042845, 0.44442662751228723, -0.060083430796337094, 0.04752834219316031, -0.050802861667597836, 0.7280033953978342, 0.012733801488166597, -0.13404760620153974, -0.0988346264196892, 0.17424031260071046, 0.10532831041809106, -0.1089032121701684, 0.05802816839494051, 0.23781611738183572, -0.3047484568827337, 0.3024761260052727, -0.2446927235945267, 0.44114783412907504, -0.024576191055996545, 0.09989876676398562, -0.09783063194549253, 0.6408966931795138, -0.19493736243494264},
    {-0.024386123783216994, -0.13492082053514434, 0.3589363496012731, 0.06701669587277419, -0.2644914966735663, 0.3015250357786112, -0.3407932818043095, -0.08110740072566106, 0.23391823775151077, 0.2178387599817753, -0.1384406575616888, -0.17112269111531475, 0.44407866776765614, 0.19621591750886527, -0.14711681132226878, -0.11706440057929836, 0.43120824214116565, 0.25591953641449217, -0.3975353910516969, -0.08390472656078114, 0.1865894933951499, 0.017307342162801272, -0.32770667519437274, -0.052747251738544956, 0.040435612687424446, 0.25289389825241126, 0.3939749043008364, 0.21012715086879957, -0.7325423314222484, 0.2903779425812728, -0.3432660553551457, 0.07486114538098614, -0.06490084963374544, 0.4685116724343226, -0.3582615716067933, -0.36465914985498443, 0.20121780780426698, -0.25614633391096575, 0.10277117722801946, 0.12795168077844749, 0.16355181589293452, 0.13452435732612017, 0.21379488863274013, 0.38897578986171605, -0.117744267269349, -0.2793355966132163, 0.35974567405789315, -0.12894798751387926, -0.15528894560578554, -0.022396442559459412, 0.0331954124720584, 0.5200846884175832, 0.3194634814427754, -0.2504617412712123, -0.02804304286842509, -0.09630514229331273, 0.18661489042441393, -0.2716067221716623, -0.06353207119761828, -0.060723992757957035, -0.08361113704023906, 0.0020244177359683194, 0.6363764948595597, 0.24654935909661704},
    {0.6399603145665718, -0.2529710141428428, 0.27884835321958384, 0.04334544253813571, -0.18260573719039855, -0.34570310888947, -0.27469955471323465, -0.08891139854677894, -0.3593999659042259, 0.01773651110940287, -0.1648982791141821, -0.23221877949639666, 0.12109842133913942, 0.2714133338729776, 0.06058208553445248, -0.07660164425632199, -0.30056046691542104, -0.1349936883553998, -0.6356935882986197, 0.4797663798501349, 0.03647642269799261, -0.23145385109261446, -0.39043291291531806, 0.29198836428182917, 0.07863616284963904, -0.13019639815791637, -0.393986674581825, 0.0994504163262793, -0.4155104823446689, -0.18769409138081944, 0.18483896076014006, 0.15661377001795326, 0.3241655958494885, 0.07855032026546137, 0.1103846183246912, 0.23187853472378273, 0.3469687138277787, 0.24126140030198434, -0.20303437007479092, -0.09206490036890447, 0.523169108007985, 0.11231814951820002, -0.7552801035195411, 0.5025326909929896, 0.2612603937243257, 0.06417829994055033, -0.060032986716896074, 0.0224054422327426, 0.14621508484735476, 0.13428522412211974, 0.6181306893574573, 0.011782251200251509, -0.21491972311382046, -0.4411602657946094, 0.04823922477642164, 0.0888478451789002, -0.3477838034912056, -0.42589056868996317, -0.15775100282398027, 0.8048781677731955, 0.5580721633843908, 0.21923180501089326, 0.10655590671566102, 0.08063262215886287},
    {0.1116656101022112, 0.05382096367520161, -0.26522410135416286, -0.6321532505189537, -0.011252102412352319, -0.38767956101490625, 0.1448343913511042, -0.14613793884294157, -0.21381961914520373, 0.30080502746235666, -0.12646444475582255, -0.11972045115629565, -0.25340289705899344, -0.13525308722017154, -0.15923614173826386, -0.15614820420280123, -0.0628462027928745, -0.15414769919477017, 0.45106474935211455, -0.05447272111544246, 0.15834479564107035, 0.24621936309144873, 0.01801183599330354, -0.08299054816105525, -0.48015230001863185, -0.4716278778229465, -0.3229060056730707, 0.007497107693191862, -0.5368196018205432, 0.3395852777098716, 0.2706686409489095, 0.22736539969224373, 0.4061300963686107, -0.020070522638135396, 0.7728915092896816, 0.2686603894496567, 0.1612275078083048, 0.2610124463095419, -0.4412269667456784, 0.006649588565985029, 0.14180472126195967, -0.1478891532859496, -0.3532056665118842, 0.0759497967481013, 0.03654615176704286, -0.019395110780990488, -0.3375633391232038, 0.2191347974497611, -0.06367099440231719, -0.15198351485334058, 0.13193159888944125, 0.20379140287302538, -0.024857312986792755, -0.24239239395826084, -0.048035258438885765, 0.30455755170035587, 0.09908509214360495, 0.39592473184297877, 0.06657285910929853, 0.3172182011455988, -0.19108128768452104, -0.4203861586070487, -0.46664687120316733, -0.024913251841024543},
    {-0.21213484406247476, -0.15419038234085658, -0.03083217468977434, -0.32724633292685834, 0.024005179114844358, -0.3043544783575614, 0.5253125789637831, -0.3059399998298185, 0.4724906458218486, 0.24133368194935756, 0.7507185623848883, 0.33663099043311173, -0.06373062552020554, 0.12385495595973092, -0.09808706911464603, 0.13385457511404913, -0.1246298530416314, -0.049066176129086446, 0.29092722152355605, 0.028995760023746476, 0.43435762704174935, 0.20784462847953825, 0.20325263062404245, 0.16193197578275037, 0.18976151203089864, -0.010313166932835226, 0.11616132572822857, 0.5982114721343871, -0.19448008526508173, 0.13232809037545265, -0.12699909468253984, 0.052473141324501, -0.234505570857458, 0.03729432979568697, -0.01612512706695194, 0.04166760638528425, 0.6316870618452405, 0.1908048265806593, 0.013664545293368453, -0.14797356654760832, -0.018976552862954073, 0.12815711878955446, 0.49359156432979784, 0.05012114725738035, -0.42811756176013666, 0.2143329521358864, -0.4421296417075416, 0.10936131186965617, -0.19853986136069618, 0.07084082055494692, 0.2808474502395549, 0.09345471968904141, 0.2416583381595659, -0.5598306093808455, -0.17183393343457806, 0.1719049989398201, -0.05715106457124141, 0.27645499802043894, 0.1892045777526181, 0.40404536781426725, -0.34426566318526475, 0.09261078326441814, -0.2820123005094349, 0.19465933258990764},
    {-0.08103826608073122, 0.17762034114568556, -0.35515694344144616, 3.444775489003265e-05, 0.21609176252741352, 0.3564219455309368, -0.3123367345245188, 0.14164047847732625, -0.16801356848339355, 0.012761924383362338, 0.34330463323366217, 0.15596923808392318, 0.4564678564842388, -0.0884927808519689, -0.48893200156199296, 0.13017906847525995, 0.38025378020889844, -0.18213375844352095, -0.3597719798715758, 0.4071285416159701, -0.21028384914625967, -0.13054141126275293, 0.4428703773889741, -0.17391456471444983, 0.49458155575523943, 0.024299323747504285, 0.049592106690514025, 0.031323237827103195, 0.5164568769924379, -0.23052146450611866, -0.011632454977518764, 0.07540388979864351, 0.018062005751524363, 0.04342033790723838, -0.27234783376506816, 0.489503468811899, 0.5623536820623645, 0.1039956361245796, 0.12305911034677254, -0.13016308911072955, -0.5790026555974236, -0.15465341106448063, 0.03712507516168871, -0.26801203751258734, 0.3904580911632667, 0.1581334852618282, 0.2063711792409927, 0.12786970862382868, 0.16229620803561984, 0.16829425547818191, 0.23930671259632916, -0.04676384927610783, -0.15142485763731928, 0.34434326709918645, -0.08765324832285003, -0.10541726883900286, -0.2900681910273138, 0.06720502615931212, -0.09815550023766227, -0.860507237357195, -0.046130527183990244, 0.2383093397608416, -0.0328501071706538, 0.18847882939396074},
    {-0.10652391212773266, 0.20436430375600806, 0.21797286109882555, 0.14053270694461004, -0.08970708468204847, 0.21049223096481315, -0.35713323627817695, 0.47518857932284986, 0.4561844004676802, -0.3351914118968043, -0.2124538876208773, -0.1959940458495596, 0.20218838820059512, -0.05809681577141361, -0.1359753542039077, -0.09905279586175142, -0.02726067492730148, 0.12035600479509354, -0.5573855499522793, 0.011814677270440199, -0.09411484211687604, -0.04278625248693866, 0.027108101898537157, -0.08379587654354932, 0.266423686846533, 0.35642765181779773, 0.1258776191900195, 0.423218276336067, 0.07135434816548947, -0.38994370047558463, -0.15390864195226953, 0.30740161384060904, -0.006066764700836329, -0.18965320323750853, -0.004381510138242676, 0.32658569351588995, 0.20932092141747816, 0.2616880613265885, 0.28806121023403986, -0.0029399497835380503, 0.4021332702159269, -0.051368037365349555, -0.4424534389929347, 0.004971543165696993, 0.08464877259611962, 0.00894525827219871, 0.23494940400768832, -0.051775452383589715, -0.06312918859567707, -0.09386944647945535, -0.11545753942016268, 0.10125560652933391, 0.3073914688635902, 0.26577074044289273, -0.02522592649968784, -0.22325186470157946, -0.2682665455033458, 0.10014751589266753, -0.22751958639927855, -0.19115469538426896, 0.41319671745522535, 0.3603840522649448, 0.3856500189451834, -0.2408823870313939},
    {-0.2628579210025378, 0.42087935440115526, -0.020530938342610047, 0.5027336099281818, 0.006184105683620054, -0.43225917210658216, 0.15281392716833894, 0.23162464048854237, 0.06346393267481917, 0.4983255119345003, 0.21248160002567054, 0.46817981789838875, 0.3247238110432918, -0.03426584742712476, 0.051573791959188625, 0.08613376601924755, -0.31297950157047827, -0.2912660324807115, 0.48641918606078605, 0.14819681646879476, -0.36334278564800915, 0.17335278473964613, -0.10122564900232875, 0.1553469319492838, -0.14397265319843805, 0.07430659937379172, -0.23094950810817702, -0.17648805668710457, 0.02934182094326618, -0.304065111776314, -0.09109260625269473, -0.40681392208595185, 0.4631890453498079, -0.10331923077921998, -0.023037586228552443, 0.07027858106197056, -0.3540556583332473, -0.010788593972073737, 0.2390731982024058, 0.06428001132426042, 0.24253430279929805, 0.1420422291902762, 0.06843701943547227, -0.1955097883409132, 0.20588314825143755, -0.153261302978056, 0.04726313701516966, -0.4349020009565819, 0.041857248336686276, -0.2617863318092386, -0.011649953569421253, 0.310441155248449, -0.03261569775028107, -0.03090995836992551, -0.12372413874542017, -0.18495950784878784, -0.08480506288201421, -0.3219055537571577, 0.023829101722441032, 0.0820229297605806, -0.08803419789190697, 0.12086145843911003, 0.46819520604367243, -0.32946955337126965},
    {0.36494903156438124, -0.05113886847551104, -0.523785519662948, 0.0695078456443399, 0.06152120463862745, -0.14219977463900854, -0.060014684811743615, -0.2302864265816203, -0.16599536654316827, -0.06917213768395856, 0.04682718749286211, 0.06427704744742803, 0.1086068558869683, 0.37190746228558796, 0.2986216028129131, -0.16789021371437388, -0.059567935784756006, 0.18725856084142517, -0.12093939181968322, -0.25009070349867146, 0.13005157596762656, 0.46754799824057036, 0.08026834929108231, 0.13121607738217753, 0.2589476634623619, -0.0397717611665408, -0.30205080493831105, 0.24283394130219013, 0.4139363647396485, 0.1840465859883138, 0.537830737056361, 0.14135139951490788, 0.05461816691070192, 0.036598523836979625, -0.6214640404205449, -0.3275095660701944, 0.057186313317352334, -0.0156106541515252, 0.014686701922800013, -0.029918248675497885, 0.4974954618352965, 0.04995955466301998, 0.0843157025384409, 0.4122424473682548, -0.014996145580633549, -0.2815394003670863, -0.15556297784014236, -0.5596521126950631, 0.34948408426874195, -0.014735445228948386, 0.6236172992389323, -0.0510525611481663, 0.1289587119364441, 0.23166637785180408, 0.2935894162986891, 0.2776675005239868, -0.1812073003871858, -0.03274812773055713, -0.11159481032118829, 0.30869105423163523, -0.9457096673116584, -0.06847533804863505, -0.29597487282691215, 0.04007040596691363},
    {0.11303920191983201, -0.09288101763097195, -0.3066836868380499, -0.30916416124108304, -0.430171006081711, 0.38631915442869974, 0.392644433116105, 0.04253797116225572, -0.2117258298991668, -0.3432329895459682, 0.26088237766612987, -0.09864641301134151, -0.06443406824038092, 0.532624540455337, -0.12181504710519017, 0.1364029972758175, -0.303581743166137, 0.29166235165034365, -0.14046960000391084, -0.13903519292866515, 0.10731560711451461, 0.3534468778591122, 0.38818885510680956, -0.22075349672493236, 0.2019961136566086, -0.09940380062752113, 0.09487660661750905, -0.0317811751537412, 0.21765168185187328, -0.016139901797669762, -0.5478895510804598, 0.0784359571236375, 0.2371993325122678, -0.18988994318861932, -0.3781930542488551, 0.3622889007582065, 0.34154178734778123, -0.08042292174712425, 0.32078720010394035, 0.23212964897462188, 0.578206952536229, -0.1620360159565292, -0.24828360770248714, 0.3495731864694514, -0.3180383445790004, -0.21686868355852437, 0.344628231238863, -0.21962927219144374, 0.28187600149380343, 0.3958743145450842, -0.011165476560415513, -0.06498567797574469, -0.04080081577575193, 0.2382231632563467, -0.1511498418457189, -0.1918107224614857, -0.3505279717967393, -0.5033137028648149, -0.06538603209258279, 0.01386105578692875, -0.46628570114686807, -0.17668309294050097, 0.036422561947146194, 0.1481642342602345},
    {-0.014304290226352214, 0.07068848485284515, -0.1233354708302207, -0.15504210028619525, -0.16343977624690045, 0.0048371438664495505, -0.07524959167975728, 0.30985219449349144, 0.28613748763541125, -0.3261593122335695, 0.4281039891940937, -0.45834311909978503, 0.23008601530162, -0.3183680478950379, -0.3242689391895036, -0.06641803048521296, 0.027723188979420835, 0.012072604312579255, 0.15999234599505976, -0.29916669064984847, 0.41871405599839273, -0.5001233244151432, -0.4590228896841534, 0.31979964851058024, 0.03704654038867756, -0.20749440968649474, 0.06420742788538658, -0.021972790180269024, 0.056887759409675775, -0.11829594679454636, -0.006276137491493219, -0.36293657122975675, -0.17830521252045745, 0.44788687901976565, -0.013012599283523371, -0.0026653015792510756, 0.2990760472335174, -0.046927940588648756, 0.4709884740560482, -0.3377506811306137, 0.414921167583427, -0.13433714747580947, -0.09128751246517008, -0.22694528891370414, -0.019812673631666614, 0.5019413147585646, 0.005552633110817535, 0.04497597716010508, -0.310194153126814, 0.2960859399181732, 0.07695147236509332, -0.13720795450999906, -0.41751472584823046, -0.3772185450406473, -0.4604021615555908, -0.5006667952013342, 0.3299595256991527, -0.4327381594698626, -0.017427836604715526, 0.09922436976811666, 0.042601801504950756, 0.26520557615030455, 0.08585658542779404, -0.10074681543516367},
    {0.23075663669603586, 0.31283134403188234, 0.17696779971208546, 0.4249129726437377, -0.15668738494353113, 0.09442089000170466, -0.06224924908883621, -0.22095566243966633, -0.36872465455912196, -0.0806873768618448, -0.06190245361292676, 0.2448799793427385, 0.23531780638189817, 0.189807136714622, 0.21713629032256535, -0.12184531477273025, 0.12476708035103459, 0.21533226399611088, 0.14817997344041886, -0.34247767900105847, 0.4240973572250261, -0.3846164526758146, -0.1334917329792733, 0.16794725221646298, -0.25870481626602326, -0.18920062948423927, 0.1570476943091964, -0.06901264474041524, -0.2312519530682627, 0.1525790298666797, -0.06634733287546381, -0.09820591219346955, -0.15617973540324293, -0.18132169416068944, 0.039467877068929305, -0.23282713315889386, 0.269186615498658, 0.12808258560393376, 0.15945541078770642, 0.1148320929685542, 0.22098599937382044, 0.227432514227663, 0.16252214987117555, 0.016090282929207975, -0.22136727172724124, 0.030891005341335667, 0.4186099576511653, 0.2707789165174645, -0.6886613689147328, -0.13682741432574558, -0.042683058816491835, 0.023485968877364236, 0.3052929567807527, -0.03580330768305831, 0.3752895260523492, 0.03842155138359678, -0.38458432376883683, 0.09677106390183503, -0.15487474365977788, 0.20115002772026033, -0.023222254209755516, -0.2505869149627125, -0.2258095485512128, 0.09817330620732011},
    {0.005863294788979812, -0.07230890414554293, -0.01897240943674429, -0.2195669323948789, 0.266065214367661, -0.3312635891620867, 0.1881714281185047, 0.10841690643378347, -0.5629386391447616, -0.11793997006192247, 0.1106438767155352, 0.07562265067621837, -0.0228029744628268, -0.3143442078408293, -0.16368619674344198, 0.2938544282404628, -0.2922062773503512, -0.3308832588449903, -0.5925073516459823, 0.06555046465144729, 0.008066162219303041, -0.16921694617012578, 0.26486339382697477, -0.3262330668752516, 0.07788223658223371, -0.098894282440644, 0.15790994633320274, -0.30741433383431577, -0.4667599287548612, -0.3405183936636828, 0.01037324961569839, 0.14120403858467276, 0.1514225006854771, -0.08811283705940771, -0.18301648599613587, -0.3954636112831704, -0.3299123564597254, 0.0748483819788382, -0.06990848662889569, 0.18097194802467115, -0.27717810523809094, 0.3437393299067074, -0.30354092653917786, 0.21194590718129006, 0.24242632284140272, 0.2727285840134733, -0.1534491855530254, -0.10545398743508536, -0.08540774761542544, -0.579901456299396, -0.3320048517334367, 0.07136046974387589, 0.04833439377780084, -0.006882173201748608, -0.09210323760025785, 0.47895626007646536, -0.22769641515121136, -0.14612801619983914, 0.12168011098339232, -0.2802546728274659, -0.04845618903911893, -0.25088159599277926, 0.31850957496254434, 0.12412526515739389},
    {0.08224433349017925, 0.05081516112553133, -0.34022147042759426, 0.2641247619304776, 0.05077502255768469, 0.012588017944825728, 0.6018369903392596, -0.09385463929498142, 0.265026802780122, 0.20160976002334963, -0.3807774659588306, -0.2722163757743506, -0.05578349112043257, 0.1494484231179202, 0.016118778448121214, 0.4015411890369642, -0.19052324914175692, 0.09439101139931569, -0.2521381387368945, 0.17031564528318727, 0.22345122148657612, 0.26238743683106946, -0.16822267268847965, 0.14395073472630154, 0.03375128635870717, -0.010659260001175857, -0.0002602911222527922, -0.09327595846713652, -0.2625153920902002, -0.044277513778427244, 0.172377231015059, 0.2221180754294645, 0.39363974941344887, -0.0891749104561169, -0.028467790545928802, 0.20974714382759416, 0.20490009542541276, -0.3236835909919823, 0.5764235930642803, -0.11932967984413037, -0.012927313826166034, -0.20191576198262431, 0.22523246101701458, 0.14434889055743855, 0.08443246139672596, 0.07640405983918928, 0.009091458493464391, 0.10237784257135077, 0.34099710386946097, 0.0062086466774682715, 0.21758266394713588, 0.0064535950854843595, 0.1793911426483273, 0.35553882674891235, 0.08877575908849124, -0.2651189731346672, 0.33627737398333085, -0.0813421524242994, 0.2145390448495187, -0.0893510653538398, 0.8444505330530122, -0.3504544840903919, -0.08529017753515748, -0.06008178429767427},
    {-0.2624035704891778, 0.0008656811640790582, -0.4323487355678158, -0.22216796321513219, 0.010269046799294286, -0.700306731668048, 0.2989713539320386, -0.25420225741559854, 0.07247078676288408, -0.28844911064860157, -0.5765787380894425, 0.10870723029370122, -0.22174876437481522, 0.05161705748753918, 0.38205435510441677, -0.14277789197113613, -0.03547231068976213, -0.17136829473104642, -0.19688298844595556, 0.08090060143042872, 0.11472652013087524, 0.32162601045010225, 0.2686246929331002, -0.04644483135278687, -0.26498309785540136, -0.6701141367045423, -0.1998124357919605, -0.43560155259822647, 0.16485375187461274, 0.13456146952488077, -0.18127789256115068, -0.053595375920276835, 0.2872217696328128, 0.2292951388773036, -0.0953845748740739, 0.07166366504967142, -0.5990276765857729, -0.11302324244813226, -0.47877446879865976, 0.04169130829479409, 0.07719446793043813, 0.2146729053752907, -0.08283181030440595, -0.025985668512482, -0.09706181817768282, 0.049992628127447904, 0.14216180735400938, 0.06503683486684653, 0.3800755693182815, -0.4003531094054738, -0.33789175465198495, 0.2598694657411286, 0.18108493525813904, 0.062177732145330664, 0.06464713925011431, 0.3089560454355548, -0.11004442714462744, 0.3067081450435083, -0.11603523014319325, -0.10983727325080549, -0.13086264895727495, 0.017648883898767172, -0.10681389039235946, -0.006576896026383365},
    {0.03183998621623325, -0.7588695953301885, -0.023943522208219162, -0.4563976231557041, -0.3123061204042368, -0.2020070998994969, -0.047291289227793326, -0.11942315012286925, -0.31500424826844836, -0.2511461430418605, -0.14658586804724846, -0.14497421677109104, -0.04835433013662032, 0.16621379994513252, 0.3442707293327726, 0.055533026874712184, 0.4456464913536525, -0.08814886351193264, 0.259686003222079, -0.20714743694892493, -0.4594650048828477, 0.3344516917819259, 0.36252373930335313, 0.3857231732429804, 0.2174117560234263, -0.37059081819338147, -0.36593759063604114, 0.009823368365752991, -0.06275921714606153, 0.3418352519387633, -0.045367316297284785, 0.07363622507693882, 0.1382840276479286, 0.0792136161994155, -0.07925285916740608, 0.10294406335928545, -0.23373810706814616, -0.22106592977367368, 0.25271468360794974, -0.128098560515471, -0.35550103812718814, 0.34510379980576494, -0.007663133992681784, 0.46228516422524996, -0.2823787854955092, 0.505269265824968, 0.3183782917583056, -0.07757642469461443, -0.4190425473316954, 0.04545833094897981, -0.04367145738091614, -0.5117798734179854, 0.045881880450854284, -0.03114278503093881, 0.19174765470737956, -0.004540495812320652, -0.15746506628667822, -0.37183160905881696, 0.010133168836650854, -0.03655878725863109, 0.0011067430714029405, 0.44762755864687037, -0.265783067841345, 0.044809183697390134},
    {0.1874217143070152, -0.7256248223782271, -0.6311290645610006, -0.32595688842274734, 0.5444954535978577, -0.8164827247737977, -0.08040571839262323, -0.4653149527660495, -0.526069843675634, 0.18034116270416176, 0.08941266123329357, 0.05189666753897341, 0.009310963394710796, -1.0948610885716212, -0.901259521248791, -0.6316637617044333, 0.183339184052041, -0.5260454019795993, -0.06366744973887302, -0.860363529011569, -0.1407305324883719, -0.6577156989398082, 0.5062533648386657, -0.4888527697776604, -0.14607142752213015, -0.012447206169611091, -0.8397241031336105, -0.8080130866984042, -0.6041024301648689, -0.5388798164114977, -0.6682298746517957, -0.3056575766820242, -0.3535919212657862, -0.7073527110938461, -0.055980048710289235, 0.48254832877789405, 0.36859588711642943, -0.6471168127592677, 0.09046250844888967, -0.5076970489664275, -0.28203666039846886, -0.25597758570229856, 0.5210184166750977, -0.4453600842105423, -0.33814965896610627, 0.2683427933252865, 0.06539776185888894, -0.8342195940946188, -0.4080186753222302, -0.5438425199916611, -0.4019649656750339, -0.4362521412708064, -0.4104077093242565, 0.01551056394618679, -0.24369672891994654, 0.4121973010345832, -0.6465848535199294, 0.24782549122950442, -0.8881144763801805, 0.25795845240771237, 0.35368899076893406, -0.6827363971771439, 0.05617357876878897, 0.5377742126227815},
    {0.38378733940957077, -0.5653840548880203, -0.6428212845757625, -0.6284151261236129, 0.7200840967741291, -0.6899776711778645, -0.3309433222374361, -0.5965016801174684, -0.6189875814332851, 0.4543135734055315, 0.3101273225503248, -0.1577770216820489, -0.6291555136635683, -0.7438829219679836, -0.37458834907793104, -0.6679717756041932, 0.06137564689767712, -0.11519720813950304, -0.41180934671048613, -0.4091842417256164, -0.44739139936952094, 0.018875015046299033, 0.6240346179175978, -0.6155958454228201, -0.32940084909060113, -0.30335108950185297, -0.8203236280162437, -0.6197034019924158, -0.40940043284152, -0.3299248847147224, -0.8598078025005251, -0.0941339244173997, -0.3205223555320604, -0.35171564160200336, 0.3235621863292072, 0.8225581593249275, 0.2888405736596646, -0.69277857252011, 0.24155345529034952, -0.5564785679052375, -0.33342953351081245, 0.5023900593219792, -0.29240051077056295, -0.7098886709914363, -0.22623130756148227, 0.3649576998716977, -0.2810460765204448, -0.7745950412705921, -0.1863665873819859, -0.5157869872701827, -0.14634618078732048, 0.1513246840919577, -0.11803172519496849, 0.3306960996565831, -0.6643915824787023, 0.4518956222451403, -0.6765217361447627, 0.2657232121075027, -0.8172961565284823, 0.5654618168005797, 0.17389273285521964, -0.7817116674544938, -0.08574676747892646, 0.2625544951036011},
    {0.13309562317589055, -0.4579586326626661, -0.6876645294880631, -0.2503263946495516, 0.19054580731690585, -0.33830872409856555, -0.1914024308086483, -0.46774919885838695, -0.4320302198670172, -0.08775063588129933, -0.057344398234848014, 0.27441431145608813, 0.38808064412411303, -0.23383356992793342, -0.8228460177151308, -0.4388151257347671, 0.047942071012357736, -0.02077641148875718, -0.48887847260410267, -0.3621274608625206, 0.2844320003936654, 0.4616272840652588, 0.9188847651599502, -0.4431717401410257, 0.05069648864044545, 0.41419184679931204, -0.2191560928885126, -0.7432954573587247, 0.015073877895830394, -0.15605607885952266, -0.22577923606831166, -0.6096712851571547, -0.3427948650767967, 0.2744159841035458, 0.33956757717609715, 0.3749913729486196, 0.00880363808157016, -0.558690117020735, -0.12648218892441687, -0.44900114535525326, 0.03171545300090408, 0.17937686800117428, -0.4030165828095785, -0.335501151505552, 0.15796214522486257, -0.6034937507974621, -0.18357671979775292, -0.40651716928668047, 0.07830799624642482, -0.7258378930689755, -0.2777192922664949, 0.06733513114661104, -0.28235782952131255, 0.07949131895174207, -0.6063564538858003, 0.786320448302593, -0.3129372989790162, 0.07602098470889715, -0.29733170226415456, 0.04970466700135602, 0.14233132742095828, -0.4653248966585827, 0.17939592866715962, -0.15812664363893142},
    {-0.20944918907859714, 0.11215371570025415, 0.23862284338254192, 0.14693985141768826, 0.6209722505989215, -0.5720251667435452, 0.2550622448956492, -0.06016959769620887, -0.1493899523023494, 0.26317746247149776, -0.006423574826254898, 0.27853965757675003, -0.12631633992236208, -0.13708514079409567, -0.046970920758881596, -0.47208776698985483, 0.6940832313898916, 0.3125717720228815, -0.20431530286757044, 0.2283658241773228, 0.26629305424680094, 0.4534402867100069, 0.46499874563293675, -0.5005306927741673, 0.5487047581029966, 0.6519020069384414, -0.3115240113293535, -0.5219262251688908, -0.06702369855076751, -0.35054643080990533, -0.10382323062257792, -0.14006821699775274, 0.20822451839323244, 0.14287161172631754, 0.4686269700766207, 0.21656920174864674, 0.051507999940147445, -0.260084872930193, 0.30175026703191604, 0.5896528776156476, -0.35066781371945055, 0.29671536183044606, 0.011135256745353534, 0.20826382062082793, 0.11764165978009379, 0.01629691130650336, 0.2085090695739002, -0.1316806640411132, -0.007171972360094876, 0.2239868337632928, -0.5219770633689382, -0.09359539007603206, -0.1407235653793244, -0.0016978224359399789, 0.07107377165064244, 0.36914648336581046, -0.1613394804510349, 0.6718613041277357, -0.6078194383824742, 0.1932478368485721, 0.6062633692218187, -0.19847996825379385, -0.3048179687355545, -0.059265314790640455},
    {0.726138409598635, -0.33073518405187385, -0.23939965639444516, -0.47191360203421184, 0.6409740552986479, -0.2943753068931423, 0.26354027706428634, -0.18011006684603448, 0.009438170264157074, 0.2103825903069713, 0.7747422735204857, 0.40703024271920657, -0.3085253843359803, -0.09597512402349019, -0.5463656992186843, -0.26256007669735704, 0.06899114536617887, -0.2427519150880081, 0.14382373116422795, 0.22164668914148902, 0.35935567454224404, 0.21735157982766729, 0.33315374192021674, -0.5990087515402104, 0.593448471182309, 0.2489909370495411, -0.12260808232416849, -0.3089930470303226, -0.2272852310664742, -0.15857880392611778, 0.10234454456270535, -0.07824635208526515, -0.16647815778593397, -0.29662669065084546, 0.06762605364887289, 0.0496751238244848, 0.3246797649273044, -0.37806069539291226, 0.7049734488450647, 0.12289087537568641, -0.032717676453606764, 0.46806053684221066, -0.4324506728623107, 0.020556742147891226, 0.4169429158249261, 0.07222686888116717, 0.013572270521084676, -0.32299005938476577, -0.6810672606637698, 0.017753754884946134, -0.616291792242436, -0.2994047693557613, -0.3752371293626685, -0.007597666379279047, -0.04523508469344189, 0.44514538774105283, -0.4335611063822134, 0.1798062135152298, -0.22396787615025593, 0.35921534870843613, 0.22788765846216338, -0.43067888493223305, 0.1597336108724811, -0.054207729901438385},
    {-0.12580476111721758, -0.3133388554205181, -0.49565270942448675, 0.0946133761463549, 0.37987011576532864, -0.3308626165915987, 0.011608722548857607, 0.15857390407920172, 0.3197443850565022, -0.01757594292756726, 0.16750650593044442, 0.3030416313540718, 0.037390066178144, 0.22449866349793773, -0.49470160738484464, 0.15321237167130916, 0.049458219680758746, -0.07377656418319534, -0.16471727966781632, -0.5076392034724552, 0.5285245640239767, -0.008661699596221708, 0.546743370714739, -0.11059937649717182, 0.22736570009267001, 0.24674323722838765, -0.11053903276006376, -0.45826660838006256, -0.481211020350045, -0.19355778371958282, -0.5053255423302739, -0.46177137166846577, -0.2738381585779145, 0.2834710280041829, 0.2986657812097169, 0.46155243234411497, 0.32318489181758897, -0.5427491987852331, 0.18284349362609129, 0.2859189991236751, -0.222520172679756, 0.24340448657774644, 0.32257473622765087, -0.6439084301162668, 0.3269706333660314, -0.05927418701916239, -0.13426977964262626, 0.4715288292154624, -0.22420683086353113, 0.04192922091348236, 0.2055853147791654, 0.1724162832528724, -0.013249487689685853, 0.4661972329984194, 0.07187457600082768, 0.06887436245361434, -0.6086075472578569, 0.17472224164209363, -0.28669222508414305, 0.3860117680037547, 0.09310255215449327, -0.5376927418898028, -0.08488803983548945, 0.42512349137685995},
    {0.15125301462821286, -0.030740716606859675, -0.03221559999382812, -0.16272046016719716, 0.26289076351129875, -0.023183638215483644, -0.3828500758140121, 0.1391798605111222, -0.20867844320999093, -0.27196249365714525, 0.2243397958078681, 0.43769792271630087, 0.3057899608096201, -0.2988076370936974, -0.33543197375229755, -0.42158299059619153, 0.021583195446267224, -0.2960812098786633, -0.11501626017095709, -0.052248439772091315, 0.05686277159375679, -0.22566153430660268, 0.07933993852141168, 0.13436105566830095, 0.16958497561668945, 0.07590096406151266, -0.17006002487082844, -0.060629549989545346, 0.3481694590411697, -0.021275700649059676, 0.1897420032561301, 0.0902457301308272, 0.017056398697321642, 0.15929512190868259, 0.2934411466743271, 0.33305830378416423, 0.13041647453058858, 0.08317149547571741, -0.1533663381222831, -0.5427112894013877, -0.3229236059965165, 0.5319249969147176, -0.0772240464138334, -0.5175660563931773, -0.3947402032310723, -0.42743253568161854, -0.25986026436722703, 0.14282366801771554, 0.056323051595283356, -0.25519609437722834, 0.33086123819943297, 0.1050002299027525, 0.16264149198923825, -0.19498402813795668, -0.20699467562987126, 0.2980184939419387, -0.3596996193811875, 0.5715956658508891, -0.19623116836651516, 0.30269848007686107, -0.12250292939988904, -0.217236550377527, -0.3018052770926329, -0.05885234940575669},
    {0.2968196595666286, -0.370045238551251, -0.26121195712441414, -0.2956648226284371, 0.2895199758687848, -0.2995869859995589, -0.4903346305795184, 0.29537418939058785, -0.841731449319823, 0.3092405528824593, 0.41983714488174556, -0.15223355677730468, -0.3151108072197793, -0.11819416448881453, 0.019506504575827314, -0.1562654691984834, -0.3403094094422758, -0.4396215750160462, 0.14771514915354156, -0.3009513927757013, -0.010266341279779845, 0.008300090069002041, 0.6077376776366906, 0.02058060103390086, -0.2649948691606318, -0.09297732051556157, -0.06797362291173108, -0.5796259387163127, -0.6229805070939536, -0.02992689220862853, 0.15438757726107616, -0.46733058487790785, -0.005969424583984009, -0.16712954567933666, -0.567897457449817, -0.017221374827402106, 0.3613147756550382, -0.3968463500703245, 0.02549696486644076, -0.327830723409055, -0.05287929566027603, -0.30400263455611565, -0.022517548838988113, -0.3409830092020751, -0.25488446628959094, -0.3964538633182618, -0.0812181340913979, -0.4893127158364492, 0.03230869242381199, -0.5158112161500743, -0.20923885528843103, -0.6643970833516815, -0.4585066790074743, -0.1778582633020661, -0.41439616925437145, 0.3150904181100907, -0.6164829965626728, -0.039126208722452156, -0.6062670012213439, -0.4281476959512085, 0.2599607542275107, -0.19994487122064059, -0.06604766529347612, 0.3977349820105355},
    {0.677575903612281, -0.13085041028692593, -0.3610214477371586, -0.19306630762790064, 0.24398928166876285, -0.5192090734057824, -0.4483646111260041, -0.11469677890847435, -0.7361976932802498, 0.3478092719600697, 0.13442317322154917, -0.20787711363327904, -0.002055401502725236, 0.17836572450953125, 0.1619765967626827, 0.08776319495650076, -0.08539786748931513, 0.35807722818289334, 0.15470333441425768, 0.21788249593971176, 0.20451428764359622, -0.47740525301476744, 0.503739120458154, -0.5398052826451691, -0.12249840668449263, 0.4631171900726277, -0.18583500409124254, -0.35791451242922667, -0.44141168319148044, -0.34310894626107413, -0.1539461795851547, 0.08121350602076081, 0.35746874714887006, 0.20161940858988733, -0.029216239578457353, 0.5540585843409578, -0.3385569585871297, 0.018843871721470926, -0.11762326431666097, -0.34018146536369487, -0.014138167338508784, 0.2741877939387963, 0.07416754338047056, -0.4241598108470862, -0.2810957845803123, 0.5823851046736378, 0.03678377618845238, -0.2303855401328349, -0.018593194471554768, 0.21405998598901024, 0.30199440855022913, 0.17638568457593182, -0.11634792750624684, 0.29435580661377847, -0.4655666230000026, 0.005002289442407459, -0.5972982702944875, 0.40863274927664256, -0.39686645150232963, 0.30325091287590195, 0.3666592392002536, -0.17116532816514654, 0.4690270527004953, 0.5498544197934325},
    {0.3526091956346241, 0.20646947800820437, -0.19354769478954123, 0.1180266831159859, -0.04289792294677078, -0.1288454420052681, -0.24911185773614183, -0.021445175665490535, -0.3551207131203316, 0.4967649022940335, 0.16375398204562122, 0.11963236902162527, 0.18717708130928182, 0.28573329154541244, -0.14589348701813132, -0.11901983714290484, -0.12221033951531306, 0.4260692350587177, 0.2556009364688109, 0.2344707344206618, 0.07353730647602637, 0.23276454283690676, 0.5551708212551051, -0.13907869640596668, -0.25320691610005197, 0.16482540215521876, 0.05585381229955359, -0.5146052358188025, -0.699650394652608, -0.03025195367252616, 0.7264562954100386, -0.6483430466217674, -0.2826350388708886, -0.1577519924762943, -0.004415863402101875, 0.4648226499319526, 0.06795477675983833, -0.4399290389451879, 0.38471663634656506, 0.32978897044697414, 0.06184511060229985, -0.27120555748347824, -0.3458839804172202, -0.208304327602698, -0.44182882096659437, 0.3198460455358197, -0.18772731801875622, 0.03785175982787714, 0.048845950396991224, 0.34129974943267116, -0.28689068142179674, -0.25534801368379223, 0.06370916086385643, 0.02134838578745537, -0.13862221188442783, 0.05032529709564598, -0.48566968547722555, 0.31793619384602084, -0.6381682275559568, 0.34549945969631485, 0.10489544213342258, -0.3569000506418299, -0.09708122220787092, 0.2882726210922547},
    {0.23001970344691, 0.2371185007332648, 0.3592232321062068, -0.20148807216265266, 0.4119769434303869, -0.2072029102126148, -0.1452424583441842, -0.182267728626134, -0.05710967793701521, 0.13826894976375587, 0.08116929296763056, 0.6847729285754497, 0.14654231901951795, -0.25533513242677713, -0.02839809071112446, 0.05729008088659613, 0.5704281803007685, 0.2989898540941402, -0.4023818258285014, 0.00820243680670089, 0.07710678735576176, 0.31497228787127846, 0.38490258292524454, -0.004858854631508866, 0.5461330616990243, 0.23766185930028869, -0.01717972721547452, -0.16424013340261898, -0.1502983514969862, -0.421136758185998, 0.06616827116365741, 0.02686638279298306, 0.5905244336096966, 0.1600682083613201, 0.07500958211186588, 0.40144809720685004, 0.09151612007020835, 0.32441189040763835, 0.18845377956280762, 0.3914587864450316, -0.3125274289635917, 0.6038188631308262, 0.23767371687431185, 0.13797047138551433, 0.7149585599239844, 0.11963387111534032, 0.42009045044296933, -0.23470986290292928, 0.17230587491664726, 0.021739268298917144, 0.4261036216502449, 0.09656211625814198, -0.37998974739255054, 0.3882272020844154, 0.25682213035451246, -0.29804076164985777, 0.21662219127346768, 0.3733893836189765, 0.04741840908888559, -0.2068266833504556, 0.10118385847686617, -0.07695555165730174, 0.4147420816056466, 0.21126470216462648},
    {0.1700689096160343, 0.3708720131978447, 0.039397485336685904, -0.27417285252061596, -0.0007470886722238107, -0.29410524661783666, -0.14062008297410236, -0.27081856091830514, -0.26351331937698275, -0.09929519386387803, -0.0018856390477431486, 0.8193745164051144, -0.4401833920785674, 0.17825051427710656, -0.4350439976111369, -0.25885382651305855, -0.09035591689319596, -0.2897948349057734, 0.013122728455342488, -0.23098471601686643, -0.09677006591553569, 0.044550430879413745, 0.13638350641530184, 0.007785388889102623, -0.42628431811890066, -0.21969961852723968, 0.0019779141271289093, 0.11672078817552453, -0.3308532594515359, -0.41736489981403296, 0.05481462786501066, 0.2797619816252413, 0.27564300523873536, 0.05165074853725053, 0.05894383799405251, 0.17212229395286494, 0.5016926720146878, -0.019278046906515533, 0.39416833878798013, 0.037054692565830466, -0.09295681851940436, 0.10949463307182587, 0.07687590191978479, 0.05026226126662546, -0.2765195567285741, 0.28563946472083374, 0.029444864112448992, 0.2437498623410742, -0.34878797526603605, -0.1028963611552644, -0.08674189853239594, 0.008135094051570979, 0.44165221491113144, 0.3164684757157797, -0.14616740370674042, 0.19288175623553588, -0.3500339325532114, 0.16212433325271944, -0.12900370363829497, -0.10622893178381285, 0.09260399706309584, 0.08662720840690837, 0.11034929313559934, -0.004137476711742415},
    {-0.45055660209577325, 0.4049915596587569, -0.46328909180849437, -0.07906977700009335, 0.09805196807640382, -0.2006967204353379, -0.46840274180156904, 0.02450021957995483, -0.5579336975994675, 0.10375724171070574, -0.04524272743149548, 0.7328759951973516, 0.125387459098625, -0.025662867288326955, 0.5094437153811323, -0.12613909987616748, 0.3323163846869993, 0.07257999504357546, 0.317059886525029, -0.1287656123193193, 0.06541496288264688, -0.16221190820396106, 0.0577060427098582, 0.07305958895154241, -0.34373817804368356, -0.4641938743402351, -0.2431123034646354, -0.10993274255531445, -0.0776481082183672, 0.3716340618589117, -0.05559039210583361, -0.2023332867915485, 0.45047820372415326, 0.4808318406997463, 0.16926323219433656, 0.12141574308092531, 0.11799174703594743, -0.4045604629283214, -0.17090726942921552, 0.01100387643264001, -0.5180051514797632, 0.2836982627631556, 0.16171158165436061, -0.14133802960344546, -0.26280207832706065, 0.2761475498214297, -0.6337270090851973, -0.41703223731666633, -0.46743111656188746, -0.08973997991848144, -0.3916629844670418, 0.06044799003002704, -0.4361900833590574, 0.2966101033937701, -0.34114751112337216, -0.1688420042550999, -0.6211049295702622, 0.26366775311578367, -0.043128518381523956, -0.03597974380646876, -0.49087455220567, -0.3131296642439657, -0.05016165546893112, 0.3754309006127134},
    {-0.14616711500382146, 0.07646930463900606, -0.20539975344530736, 0.23707544492479143, 0.10921728665797134, -0.501182794989056, -0.34546777669787865, -0.4411761273405548, -0.34298877337859446, 0.05313961130442662, 0.06348869677037182, 0.0666349813279887, -0.22430641062607887, 0.05284655582598521, -0.14389543924933745, 0.6302662152148196, 0.10573113822916716, 0.025121935575539153, -0.5037593895941627, 0.5569439995053433, 0.33701877815920905, 0.3538464478533531, 0.3227778754634219, -0.2374161185492411, 0.2689699872466331, 0.40424816590452883, 0.05777084117727597, -0.07034987549720172, -0.2624252964394223, -0.03601390725077345, -0.007327449789574546, -0.3540249390945869, 0.08015351720057524, 0.1659391207598465, 0.31478234619719936, -0.37232803871305087, -0.328468426468165, 0.3933515131496668, 0.003104033992493869, 0.12965774394561963, -0.2229444240960937, 0.35102531447806434, -0.11460762052370668, 0.3825992121583188, 0.06571145998986203, -0.28189926641628893, 0.33622838367397545, -0.1387567406154332, 0.1981150920721535, -0.3553376119646112, 0.1282806997947103, -0.5806111955379237, 0.07046920010385366, 0.6409179596707707, -0.39263703860479165, 0.5736156145700526, -0.09824073790042942, -0.006330189727357017, -0.28933633807551856, 0.17366465284315158, -0.0751422032792104, -0.3548732537676676, 0.537684465781947, 0.08514120961370437},
    {0.11277123672988501, -0.1549411428436288, -0.5127525625433496, -0.24224535726084154, -0.23338341894343723, -0.06847143223755255, 0.03722441770831904, 0.3903997040920822, -0.18837781031607595, 0.06223218437414779, 0.4969530816124211, 0.275753653385962, 0.13354139412661886, -0.08433736237824192, -0.5849980057268834, 0.31551844585064515, 0.4299406253351307, 0.42212359980517034, -0.16421012488862127, -0.4536651775421029, 0.26350431907525046, 0.24533745878169635, 0.02803061127553196, 0.02934430876833951, -0.14940121637492015, 0.024393573353691085, 0.2591311867139218, -0.06240746448717827, -0.4038752617440301, 0.1321982602711658, 0.17085293331406204, 0.2508541065793668, 0.2462028662163002, -0.2634425926261973, -0.31554825381251184, -0.21448766610506498, 0.4131386492998952, -0.06854808711657455, -0.04673882876289221, -0.11107229144072048, 0.04573614129772875, -0.16157528638755642, -0.6744818596310094, 0.33675281342971414, -0.234337623474117, -0.42577470597687084, 0.2917668709840691, -0.3196538633392063, 0.789648679147332, 0.298076049728299, 0.7387261342115985, 0.6783090711289375, -0.28632114483932547, -0.02511515522579387, 0.03899616131169427, -0.2027341981662914, -0.20497153363192003, 0.26892049162039927, -0.6477196058802123, 0.2128691617193578, 0.16620906131888097, 0.14454590371623072, 0.030608483335052592, -0.13078818801768943},
    {-0.06731986657777972, -0.11229863028456849, -0.46378437893200675, -0.264826185900365, 0.4718272969921311, -0.11417202901667205, -0.4270599062423238, -0.5785860693967296, 0.033724266605003266, 0.3651338061272353, 0.5355553589884707, 0.3491035964899061, -0.2878537679754253, -0.39225870448533945, 0.20888336274775096, -0.252351595274105, 0.3321344808256999, -0.3038942674398863, -0.13252452526722208, 0.07872060035774936, -0.06889054518471485, -0.19957701955297247, 0.1485732397293381, -0.05072541997948817, 0.04629958796711894, 0.13530001517468698, -0.43728850786549833, -0.23574134813241854, -0.03983748116104685, -0.09797046064654341, 0.02710011259026175, 0.2252293281046947, 0.341404430371906, 0.24008780635750626, 0.21957767722176658, 0.3771895345591085, 0.1795011116467249, -0.44800180326539624, -0.024039693756193962, 0.09746449170199897, 0.33780520809807707, 0.46498537792386285, 0.17932312399864625, -0.033827054752686395, -0.21668836583697554, 0.6742983798346318, -0.23523873345427815, -0.3034016230044459, 0.06524504466441726, -0.19868784063357914, 0.5305769982764511, 0.19853531625289222, 0.07381467138841684, 0.6169535452680984, -0.21062069382972873, 0.22568142199286542, 0.09067646429644143, 0.584772237964594, -0.4001445394064216, 0.13027132086457038, -0.1410781502508526, -0.08370783658080107, 0.270855164450323, 0.34175591368951497},
    {0.17299758235363782, -0.4948147943783368, -0.032194988537526156, 0.12406583892058053, -0.4104537197149559, -0.5831607932587501, -0.3804800709526565, -0.47530941155057593, 0.04912263899274082, 0.10174181721115373, 0.5539524021316692, 0.1786899298763575, -0.5080250815279778, 0.0422657528010826, -0.2497306124404999, -0.16581222774826945, -0.5972625922781846, -0.31654889430096284, -0.5539762880193287, -0.0244188086134192, 0.20223173335483288, 0.4456544243419339, 0.23819435469441957, 0.06809840375920163, -0.12152937773439501, 0.0988641443910588, -0.1190140168144718, -0.355293085724226, 0.21382595820956382, -0.09852310517075259, -0.47500946795252524, 0.10611289167991131, -0.2186037013867946, -0.3886782195911524, 0.5170924655158993, -0.19030413352124764, -0.3590126885403376, -0.4787492747983392, -0.2935452500931963, -0.27519036110546624, -0.38108625286643855, 0.5077647201584439, -0.15969872204027863, 0.3639345239864744, 0.1618900137546525, -0.49308747040675777, 0.13433425090566836, 0.21823967953622245, -0.18203028615478764, -0.23638953263112492, 0.45729741249562267, 0.18520259258780658, 0.42494865520491415, 0.36072000580271396, 0.3538880418442642, 0.29221569028132216, -0.3322934344862346, -0.2568405136934761, -0.4992528933338512, -0.11837972930904815, 0.4140225026521764, -0.0903518822085768, -0.7017326595417599, -0.2796236996422535},
    {0.43466657071484815, -0.0489760810157987, -0.04902381820387134, -0.06872006790537104, 0.1097764473139988, -0.16696637279604418, 0.42409979019220173, -0.2959731131547135, -0.22585417852408127, -0.3404924146462974, 0.24295143257535845, 0.19586870935712553, 0.14330407609739904, -0.03322077129754791, -0.10818663523298604, -0.3213796976317022, 0.6141321286002522, 0.6772141534371441, -0.7298212726254794, 0.8452408652625839, 0.10519996472264649, -0.156057476915185, 0.6459937026993227, -0.5018601221834745, 0.05390256241400772, -0.10874302617440515, -0.2771424726111124, -0.02067686149545329, -0.11941604142151734, -0.34143271936507186, -0.315056234903362, 0.0945589918473197, 0.39624184663849144, -0.1748170109164933, 0.22252717620500473, 0.2712529539066103, -0.6137086137268817, -0.6409995101361803, 0.38043694775535314, 0.44204298288914695, -0.2889553355783011, 0.5726498612849442, 0.009960573761251824, -0.0902712741866655, 0.15105550170307733, -0.028960266474687336, -0.2820341843806851, 0.2640270847185866, 0.3709590563688822, 0.060545735737178884, 0.1388624993960709, -0.06975656841706368, 0.13257577882518587, 0.09765649857780606, -0.23533004763243662, -0.04171473897077271, -0.4717190818949706, 0.5800487312252948, -0.6433502506406675, -0.07154881322567251, 0.22761771836043218, 0.02020905308716519, -0.2013280422311589, 0.24668230076685},
    {0.17112134898591333, -0.11376957134506692, -0.21061700156986715, -0.2888341521416918, 0.3144274382053246, 0.07810389582961909, -0.662339133433282, -0.18965933482520372, 0.17865494590026654, -0.2628204359677249, -0.05072728743400982, -0.06058982011707416, -0.0006678318422866242, 0.4246818018177584, -0.08162858450500533, 0.09771640588554778, 0.2191112664564208, -0.23582182301845994, -0.032118208657448535, 0.19397815277708935, 0.631040863994353, -0.15535430300604958, 0.3874601827096524, -0.29148630352873095, 0.0713683361785248, -0.30069653261451695, 0.12069859938382331, 0.041498180740518927, 0.23656181458922915, -0.06024106514934784, 0.5585916986135733, -0.3258277602237556, 0.38269476781948947, -0.0774004997612527, -0.10462998941589226, 0.02166090020099968, -0.03515710383316566, -0.5279184601112767, 0.28884054278765053, -0.16351305023577092, -0.35500768314056774, 0.2853663540888278, -0.25172646753055655, 0.5402619591382528, -0.03629894212775398, -0.2591749719275954, -0.33493189478643004, -0.1923094501641303, 0.20345855988066675, 0.07245660740017977, -0.23399498579553166, 0.02969298911238451, 0.4335826728786278, -0.06952362180418066, -0.14577454017730113, -0.48459119520819266, 0.040862955658136815, 0.45698875066064915, 0.07648736423583698, -0.04633945746474494, 0.2825244300363298, -0.5912700059857394, 0.6225863181588602, -0.2389569407213946},
    {0.060959078762180166, 0.5482471744181164, 0.16593010843948672, -0.009819752834125842, -0.2092748799454478, 0.3469398702084176, 0.47192841383738604, 0.3974572625812532, 0.09832110070581739, -0.2626309668415198, 0.4739692220333592, 0.25688150616816435, 0.24026453393588465, 0.5082466534749456, -0.27238795549280753, -0.025107172983577255, -0.04977564825869132, 0.8106507963655246, 0.1653702236841002, 0.05361994797782942, 0.5329567867179811, 0.5463651132266105, 0.6439590288665548, -0.3484064449321161, 0.20350196496239503, 0.01675659734723311, -0.10652855860196968, -0.3586502784964113, -0.41815271106474333, -0.8644347168791501, -0.19215819771603238, -0.08097844640196183, 0.22844580148361338, -0.07167912028239926, -0.6862981698301696, 0.014398050906353389, -0.1584782358833242, -0.14940924174754058, -0.025445758094673903, 0.39956204692359787, 0.5052912363069268, -0.22062136563886797, -0.3087371784124154, 0.18426599448199998, 0.02188915644959672, 0.33795105097456934, 0.30908370830162574, 0.6072957944462146, -0.37708150468889173, 0.5748458136907708, -0.539490453124674, 0.21289629787032396, 0.13357792110565458, -0.159465138040331, 0.24605983761179817, -0.28304902423260897, 0.17639771316323752, 0.21796809594112695, -0.1432518568040101, 0.05609280077489567, -0.11486460719741015, -0.2400699186653916, -0.40328723684924317, 0.02364774443583538},
    {-0.057487684337247755, -0.23243077444352012, -0.14685333337670467, 0.09683283759237245, 0.4164185455682227, -0.19444865004167297, 0.4434082370499118, 0.004404172678418708, -0.49087855577685197, -0.32139494936959173, -0.08213019896018825, -0.03767361928462918, -0.2537855868940412, 0.14822058071809716, 0.3387488060186419, -0.14179070815747025, 0.057720243615740005, 0.34360872427221206, -0.15226681619820348, 0.13771456434766566, 0.0368989078681889, 0.40800258274435375, 0.779698569664408, -0.3918715657847016, 0.15046972585589244, -0.25668745328003445, -0.16002750622296363, -0.0932503414299053, -0.5491701163463424, -0.4269598311129382, -0.1210087062552591, 0.2651920197727143, 0.43367610401389206, 0.14886703402946713, 0.5404608457619123, 0.19569214341599575, -0.35789547214763656, -0.28245470909759074, 0.32590416963995267, 0.24381451963513276, 0.22084753695341297, 0.16344818106620573, -0.1693060563022903, 0.1376194056407911, 0.2185581241057448, 0.2313105568976184, -0.2253644464206286, 0.30569484067474667, 0.11184042821608313, 0.3707783142812567, 0.036078420932511186, 0.3106733723906521, 0.2833490434393976, -0.136009169147199, -0.06253938785383652, -0.6243069234224562, 0.12117319017096151, -0.21404676593587277, -0.2194310808915062, -0.15979199439370348, -0.22080026975565764, 0.005118451837669337, 0.07099463309224521, 0.1133369181937246},
    {0.0880003134634372, -0.07142908376016664, -0.15336411709475714, -0.31194723451785333, 0.4467167275860655, 0.008321204849658622, 0.015784967000519505, -0.28780262211170926, -0.15147616381144893, -0.13437287006408768, 0.14484450930228246, 0.3022695392124468, 0.13334273357033632, 0.1981051914584926, 0.08609450061500525, -0.1749114127451652, 0.5842842351186288, 0.14478899689353125, 0.10146745070955734, 0.34437923300877155, 0.41182766330925197, 0.18414684108565404, 0.02593161524837406, -0.31547272650122027, 0.4894207076681534, -0.14005096611109508, 0.05262433153225648, 0.37840751874431733, -0.190968858084132, 0.03766247314298472, 0.005620386878243709, -0.47878332368694815, 0.6042689256623779, 0.13798334662441525, 0.31209379077205074, 0.27044193209079687, 0.439579548082698, -0.2785131239648577, 0.04443024276778963, -0.0823315153668531, 0.14483462982602546, 0.6480724936473046, -0.15993933675942018, -0.05084418982019403, 0.33864895084248436, 0.16094520457712647, -0.23035699903543155, 0.30612127238451126, -0.09072930463140275, 0.31214377409297284, -0.006564746781989995, 0.3607194347226182, 0.020468885655060744, 0.36788306611376975, 0.4795140147026643, -0.05715968509465377, 0.35646142579773255, -0.016681673529116793, 0.57394483066997, 0.5214648667588062, -0.2073181505673245, -0.2726060436598753, 0.43734997970899503, 0.3323113433808279},
    {0.27098956881296943, 0.261000779074809, 0.008306828711222443, -0.08256540206968555, 0.4523024943684779, 0.24440724794087912, -0.23287672331306036, -0.03523136499826443, -0.2893753995222493, -0.3004719998303293, 0.3461245898793392, -0.030813902778107246, 0.5455025280623613, 0.02769913230872694, -0.5595523953477312, -0.051330893873720966, -0.24411500102432002, -0.3612939946610314, 0.23387644740274255, -0.03298633398455682, 0.7069095359020905, 0.21051004635889636, 0.05486772585215594, 0.3229465535592954, 0.22753660844548998, 0.08762725135092787, 0.09512459654549596, -0.12665748518258663, -0.4481140199769237, -0.2914028324678901, -0.17886052240713038, -0.37672336334997064, -0.1373863382690635, -0.24367040580392832, -0.14435145189425555, -0.03569168783780484, 0.32652162848979205, 0.043479968964277554, 0.4793701704195616, 0.21727373277660286, -0.33544179101888427, 0.37093519532684516, -0.46874019394408745, 0.037389791039012535, 0.07518261613496345, -0.4473906839473569, -0.45324499516633876, -0.16492905882448422, -0.26899586713796664, -0.16303514200003427, -0.0024370785795731465, 0.28348189858484346, 0.05933034968438832, 1.0655570806730101, 0.30893061128345384, 0.31214636033950116, -0.06242368284568219, 0.11480042060130985, 0.08910472609372108, -0.06473191619814701, 0.46791393872232884, -0.1803588199744646, 0.3386390435567188, 0.18158356470246914},
    {0.03338117966604515, 0.35807304858102473, -0.43633129662855724, 0.018250922131892996, 0.12033037259708686, -0.17727332325611786, -0.11812516712971859, -0.15660318209860666, -0.06430006943591013, -0.4433596171349092, 0.6314577222979835, -0.19716553843881557, 0.4122502607741074, 0.6893369368986907, -0.13258798263272514, -0.15712523139792278, -0.21987931989721426, 0.185045456991158, 0.07126711659194876, 0.3082684519461076, 0.45752472182596704, 0.1234583793460086, -0.47662081290723946, -0.23781236209042292, 0.20310432985179555, 5.271047203952363e-05, -0.20957808303812836, -0.20541217190504513, -0.4739498754596108, 0.42372061961879937, -0.2551240506471125, 0.6047770565974381, 0.38896066979783694, -0.410462105920653, 0.044848710700699436, -0.33761577269981013, 0.2794793159646422, 0.08419900299668488, -0.016763368816203536, -0.466161540080276, 0.2503728700499835, -0.24481374171156042, 0.2174087251665241, -0.1913715003237234, -0.23070578918615373, 0.03597006780159965, -0.008015479680838123, 0.22992368508764494, -0.05394943360625965, -0.20836719528302602, 0.20713196521949795, -0.24275333229365043, 0.22616818366921107, -0.037782143383409496, 0.24243823170145237, -0.06150093257320627, -0.26690251701616546, 0.14130244887596627, 0.32470787314995336, 0.001172537305514245, 0.3060182428873957, -0.11319078964137615, -0.11334181741442531, 0.08277520774627554},
    {0.06768011119112864, 0.617381754895351, -0.34638907422130133, -0.03273041551467845, -0.05447464352631068, -0.11949277196012023, 0.2809233083546588, 0.4213770596305824, -0.3380838002740208, 0.31341187447132246, 0.1993713936658775, -0.45186318696384903, 0.03592234604733967, -0.18419452700502914, -0.6474944274301823, 0.21177289469546956, 0.08027408156698347, -0.04956180297323427, 0.05503292401397989, 0.02170145545199074, -0.10547504470267141, 0.6952377664771298, 0.3420438714575383, 0.008339887002647262, -0.12228089363672176, -1.0188152746667274, 0.31395874568496707, -0.13078514389631377, 0.3293548685088879, 0.2719995180811949, 0.03503748088288704, -0.5825839468160495, 0.184983064724784, 0.015741998963747266, 0.28295470818038626, 0.02882762892807232, -0.3864546336587448, 0.03462490168803791, -0.12256343163302326, -0.10097077970937543, -0.20542783417663288, -0.15044998987309663, -0.459583131190104, -0.056041716284281035, 0.06193087967116785, 0.16883591431195535, 0.07315268331526303, 0.18676690010147137, 0.439974200791523, -0.2340691674407718, 0.3994131784999806, -0.17425602778297658, 0.17130855451993404, -0.040111128560248954, -0.1955929994262659, 0.06461784176284312, -0.12413387736120171, -0.6329195592211347, -0.4901174083518667, 0.06592548517495857, 0.009713893187380156, 0.2505223353931275, 0.10506564788964484, 0.03492869157451915},
    {0.34504966213153027, 0.27689151877416485, -0.40663228849012395, 0.1103205333781524, -0.4474853996698742, -0.6015076472971261, -0.5432272246478684, -0.4183545178686075, -0.04940908473830663, -0.010135304080194892, 0.45527874234014426, 0.5410747141620744, -0.4282073505534548, -0.04242928018994167, -0.25471268760635746, -0.16876056754940888, -0.5450241269009474, 0.2985724068131802, 0.1830903053410056, 0.2585834368001711, 0.23629018788816578, -0.14688797341682402, 0.02115422514062242, -0.14461431294278318, 0.030266921943255247, -0.08471429423169302, -0.39686585663694246, -0.0397806781993549, 0.05316998966656761, 0.3391806181948964, 0.07240635600811085, 0.09098944702490035, -0.05058699989650163, -0.5807186603025597, -0.028740411418160583, 0.02347338999819782, 0.09819867977208613, -0.4353923764288496, 0.11083796861719167, -0.07768473979425349, 0.5689706954264886, 0.14257638978290776, 0.0654303493039093, 0.10476148417705605, 0.3154995125133617, 0.10463423201972244, -0.33869449126063433, -0.17362136561431354, 0.12677794645810578, -0.30289074465943044, -0.600899613982336, -0.124277886794961, 0.14616261852563633, 0.6060157407751459, -0.24018666352982268, 0.537978376655808, -0.2584177327292156, 0.26023575363279156, -0.3430102717392019, -0.2220316205321722, 0.7249603271860969, -0.27362571400517216, -0.2886364941838472, -0.17290350259559556},
    {-0.41315884237655676, 0.30163724331936403, 0.3685005486603329, -0.19935701106919948, -0.08990108074306044, 0.3155255251728382, -0.05870944116486806, -0.0033841614778837045, -0.22837718305856186, -0.08010099065925412, -0.040492367275037286, -0.1545182689468741, -0.10888296516719806, -0.3292957758758787, -0.375377230296752, -0.19933838243528437, -0.14028848829522134, -0.08131199238129898, -0.5095204452554684, 0.3628739230209212, -0.23355262331460142, 0.10907330488243151, 0.10656142071546869, -0.15265297421109406, -0.1906630607614478, -0.13595583140903697, -0.19644373864467404, 0.1825644877681559, -0.23598504448681012, -0.011679205854979252, -0.388506113349117, -0.2509105918375942, 0.23102520288546105, -0.2639471968926499, 0.6452154903521254, -0.06219820751293048, -0.24538991747207048, -0.6663001804221881, 0.489811576412133, 0.1534953173487731, 0.3713855126906624, 0.11576237731967437, -0.09104445156864308, 0.16805851885053397, 0.5240690340067395, 0.2837092450991358, -0.16387838275193872, -0.7580134823596352, 0.15522167176719115, -0.48706339922527775, 0.03100294903408896, 0.46897462397544076, 0.4353411649987573, 0.06002377517851525, -0.8206299313591594, -0.34282965504017276, 0.12104465848676425, 0.4483788786117209, -0.5570184908916554, -0.20280725127952373, -0.548199377863503, -0.1672480320063535, -0.0478098943394971, 0.43021609172241815},
    {0.32968505949524574, -0.38750759581157135, 0.1884805217283998, -0.637606428986111, 0.29940181784334463, -0.26684136453115165, -0.26292222745776817, -0.3591805902594577, 0.3628734684625457, -0.45184955386445885, 0.30635860876950377, -0.45810395950859367, 0.2196796137257153, 0.39172288153191615, -0.07119035419686523, -0.3595437815066992, -0.5902458818329681, 0.06493857173915214, -0.28583782813790454, 0.4111935636729535, -0.07676229856559008, 0.007180863161666895, -0.2958184899572019, -0.24091129593422603, 0.09169412269728387, -0.5172121849422288, 0.029137725304089635, -0.26243843249274496, -0.06034024886127023, -0.26417145811852294, 0.415625265060649, -0.08940814384631071, 0.2045959231266714, 0.06895181416777019, -0.3719213730667912, 0.3640829678884202, 0.63269063433632, 0.202108780715547, 0.39593111211225, -0.3160008714465775, 0.04292176892239992, 0.2905346642994842, -0.17391563012989905, 0.3393025263444582, 0.3359522413420113, 0.29274583569949403, -0.4422685204689765, 0.5460814551755442, -0.14067953776619654, -0.0735713161371255, 0.2833895266626007, 0.42468661278476744, 0.27528738691945753, 0.08791015456640586, 0.07753116323042013, -0.4163466475715895, -0.025013276713415498, -0.32268276907229887, -0.3667880859178294, -0.3071051577467356, -0.5062590722474375, -0.2945748504152008, 0.45603405215630516, 0.34101024038159194},
    {-0.1160754260855279, 0.26281183861495544, 0.09486452970765878, 0.20184657973258022, 0.4343000909834506, -0.27747785317096924, 0.2779258537889876, 0.39726424786921494, -0.006691142543033632, 0.221868352320888, -0.08555645004977802, 0.35109627964465384, 0.08707751387778483, -0.026086902349579135, -0.08712332960240816, -0.15649378896885535, 0.22998271368488515, 0.3870341418636489, -0.08702082016729595, 0.3347423574293663, 0.4103875162489313, 0.036757213515983864, 0.4719650769229707, 0.28972076644235784, -0.4749262980430943, 0.014162946665702463, -0.0444198014065621, 0.22079252363564897, -0.13384596559864256, -0.1745615733214118, -0.4187174561054603, 0.5264849201790468, 0.3615004111118776, -0.14668926504818386, 0.34112265723446983, 0.49079177657208156, -0.014439265460409398, 0.018742728322459858, -0.21237303467607388, 0.03285219984106793, 0.06588326830092242, 0.3397792154245899, 0.2278088758242982, 0.4525573644839298, -0.4864270298341962, 0.2604079111616881, 0.13143380711857314, -0.005087339239932043, 0.23911379581607384, 0.1252972899527048, 0.36649235672023234, 0.2788003027561934, -0.17648787449934836, 0.21978350819049777, -0.5062929642156672, 0.29552735281494324, -0.40090798828588664, 0.5959365561021359, -0.023802305210334336, -0.30851210348014346, 0.15081247939627834, -0.5443942124005905, -0.31115198500400815, 0.2292396306324779},
    {0.5891908492575745, 0.05487919888602682, 0.549640180470087, -0.08158808571526244, -0.1999943381596497, -0.06439540529262475, 0.08367052295071592, 0.30685217801128867, -0.655333547488221, -0.06468114128177238, -0.3462238835049218, -0.26385927866731035, -0.30036042661114454, 0.17801973253284997, -0.4160004779569583, -0.5472941135219053, -0.09126019804964529, -0.14430920685610987, 0.5609153801163181, 0.17056568046115375, -0.13124101124659165, 0.12091072355433474, 0.12573990183268965, -0.21628516397945183, -0.13240316479249417, -0.03582716280484818, -0.005009811400815141, -0.39918451515291065, -0.4095760790692593, -0.01421478661337428, 0.10247751853232666, 0.4946666721281848, 0.21019288010391834, -0.14051041219185137, 0.34027861634658446, 0.3844730346335703, -0.09143911538975524, -0.26953252017838636, 0.3508935902571026, -0.2819121830549767, -0.2827125863237022, -0.16171677340698032, 0.05959823786398494, -0.45504799741743535, 0.5782794173764633, 0.47062353277463975, 0.4580522837616096, -0.46739662790550707, 0.06974653908762345, 0.5845120759658906, 0.10139560418078436, -0.18936473935645323, 0.10602934625012482, 0.143609498355034, -0.10706840886635094, -0.09420954917476577, -0.38939339730577344, 0.22160588452331237, -0.48546166686401127, -0.14022136029124013, -0.04085444938982392, -0.1894009818295905, 0.18800440452063524, 0.5458861681700754}
};

static const float b1[64] = {0.9237106074568198, 0.9083838575463639, 0.9061041786519802, 0.9234508159839251, 0.9349415460082744, 0.9470682546210499, 1.0012967747154449, 0.9047517915763656, 0.9552478795580823, 0.8570606114571225, 0.9047041143697407, 0.9579541760984925, 0.9765797338929855, 0.9297520662307309, 0.9258687624903437, 0.7799305183632268, 0.9273345789720294, 0.9821413854112483, 1.0249447221135704, 0.8878455080797039, 0.9023194289434364, 0.9614325879390859, 0.9814581061755857, 0.8660615186082239, 0.7977411089462549, 1.0027827688888717, 0.9042495342879986, 0.8495106423288673, 0.9970369452246177, 0.9590953777578975, 0.972206237225419, 0.9103408919686982, 1.0021340725117764, 0.7870052857370698, 0.9752617574212393, 0.8994087849659488, 1.0106549531745708, 0.9998509846168493, 0.978900880448459, 0.9014547881761928, 1.0303974401134224, 1.0330634171756625, 0.8631902051458117, 0.8266983219608013, 0.8849478953803457, 0.8276411109171746, 0.8916087398534286, 0.9933367558914922, 0.951814874291512, 0.9424118687195449, 1.0192220560550622, 1.0091774498774604, 0.9903237784114964, 0.9231097406350276, 0.8421098498727374, 0.9449806170293573, 0.9284714123826593, 0.9469260113758551, 0.9897003677135431, 1.0034570376401974, 0.9341810132158351, 0.8424450942552882, 0.9813492443168529, 0.887049279332865};

static const float w2[64][32] = {
    {0.8008109837336372, 1.1641387000846353, 1.020741164994223, 0.944340422903502, 0.8617658740765601, 0.6798482849669198, 0.6074297180999422, 0.9497783418098272, 0.8987668957896889, 0.8005243941440617, 0.7995281061399739, 0.9723394052955656, 0.8492965866483184, 0.9271774670782172, 0.7313326452967123, -0.07568798310797459, 1.0052904930705804, 0.917851690880635, 0.5728153101953211, 0.7504994745652673, 0.7089288755090535, 0.23463128698033942, 0.8794209953163301, 0.9995621780794987, 0.959630976827214, 0.23262015320447607, 0.9864444008794189, 0.83944925542435, 0.7502911662643793, 1.0813522169971337, 0.7346523012850538, -0.20198601773669497},
    {1.0061598886728205, 0.8555210440511021, 0.8803731149094036, 0.8247961630467904, 0.886331049515698, 0.903034082829923, 0.5975554178841771, 0.68375986622197, 0.7996284175674592, 0.5531950806901882, 0.9899109074057282, 0.5250081458937391, 0.5627001625239216, 0.6234595548468611, 0.850902513596816, -0.3769541188849513, 0.9618862073597184, 0.8424569507685394, 0.7519497631995901, 0.43120111314694987, 0.5491504379455905, -0.04000827636120144, 1.1372919843318106, 0.7025532399713055, 0.6551707121323989, 0.010233668561104484, 0.7439584781842602, 0.5079459113884831, 0.6417409067161347, 0.7679129913504532, 0.5663677518519799, -0.3032009708830821},
    {0.7441379579795822, 1.070986016545396, 0.6237090390402552, 0.40415726407379154, 0.9759145201209155, 1.0016986579377705, 0.9229475137056948, 0.6698235368197821, 0.7865447128574029, 0.7971481904651778, 0.9646391484575187, 0.667625424148776, 0.8999511596935453, 0.863779680989353, 0.8530308543601003, -0.10636234814474059, 0.714524658626674, 0.9768611230101027, 0.7988077467479278, 0.6971814043257926, 0.706843430874641, 0.1911331180035675, 0.9357333492955777, 0.6782769423249317, 0.596873006131665, -0.08987793562755222, 0.6891764230984951, 0.7941587976672567, 0.8593376611099253, 0.7576833018494652, 0.9042907977668785, 0.30018451993182016},
    {0.6595624860803653, 0.9361408858886844, 0.6311759355187413, 0.5388489060868428, 0.8329060546168162, 0.6909446250213757, 0.21627581864793763, 0.49519145764584016, 0.8564866705160574, 0.5374445494061244, 0.42182980581515983, 0.46977204753855256, 0.3177851848969112, 0.9434101754135146, 0.7340034195935264, -0.2496591738795392, 1.1336206921416792, 0.6620450746221554, 0.7085152891293006, 0.49420796826635366, 0.9534161833766148, -0.044586637469794035, 0.8846910222646838, 0.40952636401243553, 0.7011153824107246, -0.04358496185656854, 0.8149018974515538, 0.8743604162546554, 0.8542954675116953, 0.6228199677395135, 0.904058574457999, 0.2631306949529918},
    {1.0017541924995181, 1.0014291186314652, 0.7216125094909347, 0.9000406337288308, 0.8517426771895019, 0.9311005097321464, 0.6908038735043941, 1.1061211133269233, 1.1329996533385647, 0.8764874529460361, 1.4628096477194146, 0.8875678163520672, 0.49711064321583887, 0.7658078866622329, 0.9802882290802195, -0.01399408171450793, 0.6996717492391094, 1.1397027287953683, 0.7620474955163753, 0.8586434532107241, 0.6679011827060982, -0.005567018241856039, 0.6723634932227067, 0.570940528034205, 0.7020885375490226, 0.03265785595929924, 0.7977790560691883, 0.8575820658691028, 0.7719485692117647, 0.9508404544358722, 0.7288819524777678, 0.21995774692823813},
    {0.9417325640610601, 0.7235285664665801, 0.7827382587200321, 0.325149186723116, 0.7249270163481355, 0.7422758140320029, 0.9208439387113412, 0.9391000365086798, 0.804958175300928, 0.917199780517047, 0.9679580631697376, 0.40979051267078676, 0.8837594933888809, 0.7185187355027274, 0.62945706613671, 0.008659895879066418, 0.9894569573828313, 0.42509259047813763, 0.8663594193797182, 0.5209317468817357, 0.7113682342560764, -0.05103970961454341, 0.7065295449054448, 0.5946090220909541, 0.8372707247348766, -0.13970912817904818, 0.6933576250818815, 1.0706883078402352, 0.7094449254473352, 0.9122790127564289, 0.770558944030079, 0.023993369838992678},
    {0.9363756204038163, 0.6061603631788296, 0.5730174793873215, 0.44829971572326444, 1.0141277143242096, 0.6948330076530892, 1.0796367478165205, 0.9686220356012197, 0.6819724978866597, 0.6970088707551242, 0.8994784267730559, 0.8929471195309967, 0.8032289191171809, 0.7663487085177059, 0.7201665778931168, 0.06598852428428315, 1.1428219153284624, 0.7331706075299728, 0.4860944495067671, 0.6470879321071605, 0.6748343886180952, 0.08729340218109764, 0.8241896891436302, 0.9639065856630669, 0.8306545390587006, -0.28367977839642955, 1.1984062302250333, 0.9250031671666572, 0.7875317535869731, 0.9284690692637099, 0.7352161913590014, 0.0180893578679138},
    {1.0432482929599, 0.9250135336703758, 0.6494859125325076, 0.5327826806445923, 0.8536879449453929, 0.5866423550168581, 0.6529959804111151, 0.5112561864330873, 0.8616501163130168, 1.188556374119261, 0.8647809863995363, 1.0912558966205115, 0.8105988499494478, 0.9634818755654438, 0.7056371153428193, 0.19256724389108473, 0.9952042984608233, 0.8889899851941143, 0.7079625986790785, 0.7351680758202642, 0.7990833449596252, -0.025075260204274155, 0.8301655202608005, 0.6731261027504071, 0.8814753843345414, 0.12158819846667991, 0.6856110506477463, 0.622164539658138, 0.8972861262457618, 1.073766102034365, 0.8780036406518549, -0.01682035418246549},
    {0.9582455283413669, 0.8115084321612682, 0.7797187153260887, 0.49894385668542346, 0.7651702186994621, 0.7505035468077265, 0.4820563254436314, 0.7925175033556794, 0.6986330379031314, 0.8971287827467103, 1.3019258766914619, 0.8996256427830567, 0.38368761563636744, 0.9625774892954136, 0.5746703891299998, 0.006832755150994831, 0.8374483605391682, 0.786834964483547, 0.5457705576765235, 0.6555020504325492, 0.42531689585625454, -0.019981967902148283, 1.1712437102889885, 0.7548728846379306, 0.6179575043401515, 0.1299288439988239, 0.6163331536539555, 0.9375911165888385, 0.9650111518162326, 0.9095875899223617, 0.8750827413373937, 0.03045849642767551},
    {1.2233704303912605, 0.6329840203157107, 0.7111640923507656, 0.6122173031638991, 0.9189865839431017, 0.9170659933289254, 0.5035171426129968, 0.9136277279455127, 1.0718270774945917, 0.7968171184950265, 0.9119606140921621, 0.6684749699707987, 0.7332976327576392, 0.6145403276088158, 0.7247042766505436, -0.0556555690651335, 0.7706947343074806, 1.0265840335290468, 0.5319654753581292, 0.554957653127136, 0.9506609715658926, 0.36550124196883244, 0.8175409229302985, 1.0649040527462497, 0.9704011727378982, 0.054983503599659915, 0.8258785279287495, 0.8533037796698205, 0.8226702759394354, 0.7655899214260425, 0.9370564718597338, -0.20552578468909985},
    {0.5985628285665492, 0.912994453212658, 0.9303200648056736, 0.37395821024167, 1.0188576432567977, 0.9038751280994123, 0.9146058311598495, 0.6929143406928111, 0.8021049140674751, 1.301344814726925, 1.2095646785619902, 0.7528309760560616, 0.9126386267628009, 1.1774227278750462, 0.7047015164355823, -0.04277996366611159, 0.6098530990687939, 0.6606023540844913, 0.35648929876876895, 0.18733742962688146, 0.7489061339676553, -0.1594780501908618, 0.8852205162406579, 0.733384540084835, 0.8366826008452113, 0.08124801613779815, 1.0877973345014949, 0.7718647356419315, 0.882114015459937, 0.9910183956636736, 0.9041043280172509, -0.27131331173782136},
    {0.9387047371090492, 0.8773815899435102, 0.905448404192156, 0.34029731073208735, 0.866824932152789, 0.8275427141381975, 0.6565288724194809, 0.6055410396085588, 0.809845092439737, 0.9354060526177901, 0.8637805936277374, 0.850488473362471, 0.8947036102785009, 0.7155107490479988, 0.6935533194523601, 0.048562080896706536, 0.6744427882712138, 0.9159873371194912, 0.5959395390461258, 0.5695778983531513, 0.8877255560149715, -0.4976490384168701, 0.5585484683759852, 0.9314963360177728, 0.9092584712914821, -0.08017809545117253, 0.5925762790163728, 0.9798459711134108, 0.8944469605685439, 0.5843398001722498, 0.7857609716841625, -0.08675632197524888},
    {0.5224380678026568, 1.0391612628625646, 0.7047834437607537, 0.5349396440245051, 1.02716711729063, 0.8691832050445925, 0.6302414602640046, 1.0559195541076696, 0.6696426237427475, 0.8558192338704048, 0.7352058454051099, 0.8433407752806704, 0.8241601693996703, 0.5204228264129285, 0.7755861738544748, -0.035802035380585275, 0.9320987687369667, 0.9631000495626293, 1.000261009572458, 0.6415377078218463, 0.6831488900348351, -0.12203047702396398, 0.5112968617895886, 0.9503747511947895, 0.6020863303703918, 0.1260514055647973, 0.5985796619444658, 0.8435647618503894, 1.0035508424608248, 0.938242253494731, 0.7229118539593445, -0.1118219473210381},
    {0.7896593914032377, 0.9153299010567453, 0.9933122298201968, 0.2429175869880583, 1.110267031654374, 0.6617077882319753, 0.6233268430149883, 0.9265039672068186, 0.5513235183704708, 0.7846368953885529, 0.7976929343427547, 0.8031221460285982, 0.9411939136679321, 0.9349824200607529, 0.6139611684533135, 0.012036243581172222, 0.7284256643167604, 0.5289966102525078, 0.7370619925367917, 0.4523028436873666, 0.8806551016193599, -0.10209238130321828, 0.8355057202795637, 0.8656547606680609, 0.6355559377168873, -0.22204352986681042, 0.8592440624394759, 0.9643031869004368, 0.6723369405333086, 0.7358432204596826, 0.7847980102025561, 0.039547830741465936},
    {0.7795539348946454, 1.1027566023829871, 0.9431188344321608, 0.20830594485487317, 0.7698546241035487, 1.1410088277640544, 0.9516761371801725, 0.7119423288645195, 1.044393527391842, 1.120036303750154, 1.0563107080528247, 0.9190378985020284, 0.8865794461520168, 0.806659950488796, 0.7369793598680744, 0.3068658579822101, 0.7269314841932453, 0.7211325950287039, 0.7268759982355556, 0.5792886914418224, 0.7257885120714815, -0.10870919965320477, 0.6565836201793114, 0.8344643158351952, 0.9253123800412028, -0.04911009194399068, 0.698607806064611, 0.8486050697903916, 0.9375110120433096, 0.9179886438067165, 0.6341849220929375, 0.0018616501932195335},
    {0.9173844815370066, 0.7119395883901488, 1.169493113512062, 0.36293943867356293, 1.007606595295818, 0.8452530948590149, 0.7796422454891226, 0.6305163260708181, 0.7812098307619502, 0.8618647022562195, 0.5458743260068235, 0.6975832467298376, 0.8854287483403859, 0.7878627913893954, 0.8995149256121727, 0.062290663135483725, 0.813092457740483, 0.9085513416202056, 0.6965844705686778, 0.6190489594285224, 0.8081084492597367, 0.006940605465921907, 0.9201150348135609, 0.7259019455824707, 0.8466651745696644, 0.1958959448840688, 0.8272866706268138, 0.6757280550117157, 0.44623995954568857, 0.5337231330559516, 0.9476766438640777, -0.124057368241868},
    {0.6394951119965011, 1.0908770866793251, 0.8555862725856709, 0.3810747881459688, 0.6388326494892157, 0.6892785642361183, 0.7317888589693365, 0.986873286556472, 0.8567005428967719, 0.537895693880947, 1.1010743132913972, 0.7706179249464865, 0.9694219048968138, 0.5310055194996467, 0.9963481393649594, -0.3052915618855693, 0.9109816535230045, 1.1548431401994226, 0.6947039142989364, 0.42598153897508456, 0.8061603185815717, 0.14149716368007909, 1.129466089234001, 0.811044178254497, 0.6710212593340861, -0.06020929336784912, 0.9781446738054952, 0.741408615198154, 0.794347044589807, 0.5541832760064953, 0.713636864824534, -0.17312239990433204},
    {0.6393399611576778, 0.6680441003354914, 1.161419453581165, 0.6834235727354522, 0.7920964787382097, 0.8811676601810405, 0.46031958297447856, 0.9287719236511045, 0.8154343070640571, 0.5919443632240972, 1.0142458086141368, 0.9642862480982908, 0.7601244557493563, 0.6551037561870581, 0.7979800531600324, -0.04562888868196111, 1.0566485794872782, 1.042238833421098, 0.8266756693665265, 0.5566280689720284, 0.5765122210726713, -0.2673744322725652, 0.6123641527369657, 0.8015156207284144, 0.8203619101457763, -0.14647103978612336, 0.8328956225510996, 1.0606689304913859, 1.0246458843641888, 0.8859663182925868, 0.6299648650986446, 0.18172581189053427},
    {0.575441059121186, 1.1708048015040888, 0.9591237501699096, 0.24396877887246898, 0.9766953134449892, 0.9211143289402275, 0.8918902859784533, 0.6782587913789214, 0.7228018965266142, 0.6402944641454643, 0.9614185016349521, 0.7590100120848888, 0.8447430411739764, 0.7485579295882134, 0.6101954264811089, -0.3609417607946589, 0.7898430470683427, 0.5970901414204448, 0.6567533075500257, 0.8677110228989341, 0.8058179505609, 0.08868913860011543, 0.9945974392306859, 0.8436858601419158, 0.980478907707341, -0.17879271573078911, 0.7094409018111371, 0.7823144279465936, 0.9010709840745313, 0.5465839389374547, 0.8865001524993059, -0.10029227432676924},
    {0.48538181966201427, 0.8814564574319208, 0.7864581268372515, 0.48734926116656496, 0.9134184189335621, 1.0422206055861947, 0.9911994270478174, 1.0284474626809856, 0.8133492845834513, 0.7449655888779719, 0.5304255325921696, 0.6169682329053687, 0.6242308394247114, 0.7798601871623257, 1.081381528036889, -0.18390887620373736, 1.04612299461373, 1.2019104440160013, 0.40023899328244217, 0.841618233203312, 1.043862164282576, 0.05694786013840945, 0.5535013890586572, 0.7550858824871579, 0.6521219396760729, -0.015750354665792714, 0.7649248810036654, 0.8574477547153468, 0.8679602214590209, 0.6424483133435747, 0.8424686968012418, -0.19441865226925764},
    {0.7723421661192195, 0.7402041454354873, 0.7490652106171789, 0.44053713108219444, 0.8825621241145235, 0.9737506414559522, 0.6036773109996373, 0.670133655140623, 0.7365784411513041, 0.7681866562499784, 0.7698922029048573, 0.8323034073511902, 0.9327700623367836, 0.9765060045934918, 0.8251772698925757, -0.1322950757935646, 0.8758865908443715, 0.6965816701116632, 0.6715404767367066, 0.36888122568201753, 0.8716414375354852, -0.08623794548809921, 0.48162007697049986, 0.6070622778475636, 0.7359578595377759, 0.025258316908518763, 0.9301656809213705, 0.8141329942699466, 1.0808757623363645, 1.0310119571530771, 0.5689106196872041, -0.10693034203440807},
    {0.815781369111131, 1.2511941323387692, 0.8662160966450493, 0.6062529032564843, 0.8062538379864246, 0.7272056208982283, 0.5657887507152306, 0.8207127125922252, 0.6694755619172175, 0.5924988592593547, 0.8482676576286595, 0.8932165586168364, 0.8045432262351471, 0.8995632962280795, 0.8857051635829619, 0.036456352992639676, 0.666281767582367, 0.8135841226639456, 0.6281121440789591, 0.8032498705028804, 0.4817465929510959, 0.264232806838606, 0.6772347234407499, 0.7078296471941019, 1.0502411953852728, 0.05407500296864448, 0.6678068092596917, 0.5420671525577145, 0.8929491815349293, 0.9124961844216888, 0.8380119466081832, -0.016971159930096003},
    {0.8879600694468169, 1.001213947241072, 0.6550755677468122, 0.7281756804362787, 0.6395008385241678, 0.8095598988303536, 0.7100482414474248, 0.8876989592687082, 0.572158662768145, 0.6016358094100361, 1.0454381617865536, 0.787110227618962, 0.8266816717863811, 0.8717833071030133, 1.014405988694098, -0.10602471202013626, 1.0794787837362263, 0.9197456331356965, 0.4782272123826217, 0.22952096497364924, 0.5667374991497834, -0.18681621658804637, 0.9881003322838241, 0.8084199073866148, 1.0842053746463896, -0.265724301568708, 1.2435222236161962, 1.0859656996504854, 0.7118221853413204, 0.5344150283551082, 1.0038791465640322, -0.24994668290546032},
    {0.8942847371457464, 0.7032789408604118, 0.8911785921338246, 0.4427955022996908, 0.8732888867219715, 0.8783243134836788, 0.5838118748182534, 0.6175050423701068, 0.6855153043083889, 0.7677335618621667, 0.7032297730845969, 0.8317026341567748, 0.6546266446173159, 0.9424733487697842, 0.9012509329877382, -0.1166674900611982, 0.7745710539414681, 0.7724576607518536, 0.6732639936975087, 0.5472685683161621, 1.1223690651288991, 0.22863685782783047, 0.9191963597817877, 0.6980767911599022, 0.9337354966193626, 0.09790433903717939, 1.1148678007300121, 1.1362095173624152, 0.6719614135697122, 0.9681085187088375, 1.0251338310885754, -0.338902317951112},
    {0.8738719264074559, 0.9162466215148949, 0.6027190916433638, 0.2674760851007719, 0.964422034370914, 1.067742885138171, 0.3100138872704929, 0.8644778521737183, 0.780656887250165, 0.7480241917800216, 0.7536371224772471, 0.8484327829481444, 0.45529502437880337, 0.7098770150099263, 0.4443381169863852, -0.038782360600486974, 0.9440323565373301, 1.0559267149910925, 0.6552250080976257, 0.3732142377738568, 0.9555042259586016, -0.011313422338685097, 0.5942207714023755, 0.6399216655421631, 0.7614031449809849, 0.18013464997791, 0.784903614935077, 0.5424246365554912, 0.6162330049581131, 0.6631852944176894, 0.8422455554693105, -0.1646277602555441},
    {0.935836032428636, 1.0464257488959265, 0.8329978169435452, 0.8172946312887005, 0.7383545482093312, 0.7665560283170078, 0.6629766459188161, 0.7805500420166845, 0.8673856808496702, 0.7342117036981372, 0.5737713097115777, 0.5254143164160385, 0.45853261562123343, 0.5588153067910737, 1.108542554521621, -0.10271478977326923, 0.7192704219974254, 0.81353205426193, 0.5240414039167712, 0.5359068692672027, 0.6983641743526731, 0.010730356311833968, 0.6402333674294708, 0.6721932123434078, 0.7341201820975559, -0.2616455994183102, 0.741275355332727, 0.9430502576337495, 1.1696899717288156, 0.77274698906613, 0.8424721881946087, -0.28460570909201205},
    {0.9371623635151997, 0.7393572395126153, 0.9256837667804202, 0.3254399564528461, 0.8891741281439366, 1.0413850239287756, 0.8188383186526931, 0.9383589515025684, 0.8876029327748497, 0.7404020278968806, 0.9291657033056706, 0.5600518179733968, 0.7934749276948309, 0.8830534403992443, 1.1722375794682716, 0.055261143967564895, 0.9949738110111515, 0.7325477989929138, 0.9040662697189433, 0.5572084891148772, 0.8657292648840884, -0.12970714747056858, 0.4817212099692559, 0.8602440741368149, 0.539644203063835, 0.05738629203812755, 0.9306173461640432, 1.0772057503745551, 0.573933597909411, 0.9911907109051328, 0.8038229900495587, -0.1494120328218284},
    {0.941253427675144, 1.0719167382266275, 0.8520697719984792, 0.31820203063094593, 0.9155792108033729, 0.7375744129810644, 0.9833700109423427, 0.7051019661307901, 1.0673521963222194, 0.9972120295446916, 0.4297595499119657, 1.04373090005193, 1.2075095794219937, 0.6391657186775646, 0.8337621938851483, -0.015958342785690225, 0.6694765340921943, 0.6249586112399508, 0.5337150313550622, 0.6459484114803935, 0.73966964412075, -0.25601901070562166, 1.1749350441872977, 0.8388170051556889, 0.5197049676611588, 0.07882849483597179, 0.7864872931918052, 1.1959802109518336, 0.8088863684904939, 1.0347105872280595, 0.6686766748411497, 0.023053534980873005},
    {0.8376586204510916, 0.8751763359670938, 0.768984187199621, 0.6059903774898142, 0.9220696881764948, 0.8569724335619241, 0.5250176491831774, 0.7440837300256087, 0.5579416591666161, 0.6955679186037343, 0.9659695708147538, 0.8219531943214222, 0.8282416070728377, 0.7844685172129254, 1.0992359691108515, -0.14066641886283515, 0.986480508488706, 0.8671136834013154, 0.7544514648881804, 0.5456213841056984, 0.5110894952632138, 0.09284735025933674, 0.8276487734234648, 0.5024206628166762, 0.789308780321394, -0.21836076008210087, 0.8024017058334755, 0.6630126975095599, 1.0753245474353148, 0.6551893768381021, 0.724661823984182, -0.2808244049807473},
    {0.7647231085413467, 1.0056323608652387, 0.7754614710605626, 0.33840706848124347, 0.9705707551147602, 1.043956243045857, 0.6185254743805522, 0.6532715907758382, 1.0576141203356937, 0.8783223884007852, 0.7434042997054784, 1.1446294978249385, 0.9048144241525045, 1.0558976210205924, 0.9094108080787577, 0.173240472869021, 0.890633605393513, 0.6043464957722013, 0.9495608490824495, 0.6408293532750016, 0.9580106581502831, -0.3440944636617962, 0.9027511251534927, 0.9991350075310022, 0.7495036908943892, -0.20007948246084015, 0.894817885127459, 0.9325426376032231, 0.5886686641363872, 0.6288101443929216, 0.846561844625647, -0.10451619903993384},
    {0.967265306237739, 0.9625164639755935, 1.015327545524041, 0.6304089558567477, 0.9655489897049147, 1.103555567320171, 0.5988519719913376, 0.7805373993644241, 0.5367802867378105, 0.8533787596789598, 1.0190062910006168, 0.6656067409176976, 0.8288514711558636, 0.7830725270414076, 1.0028468686724876, -0.16689272863865792, 0.839646193450231, 0.9820027983319041, 0.7366403907071091, 0.7605983138667102, 0.6968158507473228, 0.07344837258467814, 0.7018660838975815, 0.5562363187486274, 0.7759150972765518, -0.11128586193700281, 1.029680818031331, 0.6825884303037623, 1.0507496093938111, 0.37557788304309375, 0.8998802067047575, -0.0015818413058245986},
    {1.1257776201969936, 0.8227632962948981, 0.7408324784984577, 0.9341470806368423, 0.8466692569229576, 0.8380741996327112, 0.7335921692305418, 0.6082824678764204, 0.9199103018907894, 0.8808089714640148, 0.7514334936018977, 0.775506353168551, 0.3076209304505986, 0.8591261663527986, 0.9323181898447015, 0.22848344955536415, 0.8861357315329587, 0.7371451990990743, 0.5861644435284866, 0.5833470298057071, 0.7002483370297283, -0.06216565100225712, 0.4948421965851481, 0.3460586365721099, 0.8079085397583391, -0.2267044043860892, 1.130298191594634, 0.924227585209189, 0.7984126947143826, 0.9237407284564564, 0.7256643265007537, 0.0885198663188922},
    {0.8920747102622651, 1.0326993236829023, 0.6451510308195862, 0.9198717444250857, 1.1189397392947533, 0.49948951094375327, 1.0976125619638926, 0.7164055188552246, 0.7567639661594368, 0.708782022536522, 0.8544067624683301, 0.5057794602593945, 0.6936882277333509, 0.8596034244861991, 0.7481686435717358, 0.16480702214084653, 0.8994735599644237, 0.7156252377806476, 0.2852012759963276, 0.6184913419548977, 0.5941929647966165, -0.112052586785741, 0.39350556534138564, 1.2729210891580593, 1.241713979402241, -0.2564848199556371, 0.7085216233502517, 1.0077377991840208, 0.8926931619308545, 0.7531686868711419, 0.6856553773705744, -0.4088437283737108},
    {0.8402608336153217, 0.9387031443157722, 0.6871994541153555, 0.7298041440543083, 1.005429251459019, 0.6667251535642205, 0.6990971133872381, 0.8767635591803907, 0.6090899634908967, 0.7832326280438885, 0.6053532462432355, 0.72546476285794, 0.8799804498070333, 0.4686652367915066, 0.7202344186757307, -0.36555566926965416, 0.809336388992915, 0.7231591422498307, 1.010064406108844, 0.93491700164029, 0.6186160348192983, 0.21427063332179824, 0.552348086164352, 0.9125613766655943, 0.9671679490774387, -0.17261896304416674, 0.9222075253823235, 0.754265140179281, 0.5861933943277104, 0.9397974627993521, 0.7451099193237735, 0.007998114392942707},
    {0.7203028606126474, 1.039296539103478, 0.9863553770788133, 0.40966748573936645, 0.928701645215534, 0.8935640924394981, 0.8340769374059619, 0.6820361806429535, 0.9581718635770932, 0.7690518937888879, 0.9059999059515979, 1.0940265288406112, 0.7124407513608575, 0.773805441730394, 0.7803777045571118, -0.23076772551864352, 0.6001655188246331, 0.7457426142258233, 1.0302883349902174, 0.4341380698808589, 0.6500210449884825, -0.2424237583115078, 1.1138347824350086, 0.6820719462042917, 0.6767371944920992, -0.09511354487225501, 0.7995866339626266, 0.9457155428639872, 1.1485585180383442, 0.7741019967269542, 0.4741598516645319, -0.3320495458033905},
    {0.7933281713474338, 0.835609598962762, 0.5953868254314888, 0.5421892769849763, 0.8233857423484887, 0.7571904921571103, 0.8761769047580604, 0.7646538075071059, 0.7371349343536604, 0.9300273679733858, 0.9601126013150438, 0.7185768776461701, 0.8454274624401856, 0.8308695881133624, 0.8021599869037184, 0.19095936418135723, 1.0157114174731583, 0.8039219275605138, 0.6751151576812014, 0.8333911539441363, 0.7350974886912892, -0.17445920750552413, 0.6830334338357101, 0.7787737510904138, 0.9605473467293578, 0.1757443325601542, 1.3238390495889887, 1.0334481660229942, 0.8813973302931991, 0.9728166328462245, 0.8801288019173897, 0.19459083949243766},
    {0.9218658230273938, 1.1113136396485317, 0.8787817226765976, 0.5795080179722858, 0.9390236530622343, 0.7313267111172476, 0.4641285894383367, 1.0535865978603722, 0.9092727767534561, 0.6939436000394736, 1.2201558948780722, 0.6104191879081133, 0.7612568800356854, 0.9909440955955409, 1.0127528531988619, -0.1160062287320598, 1.119979465139704, 0.8334938208232039, 0.5577188708205195, 0.3808866813072785, 0.7846048830252458, -0.2080596687078142, 0.6465770538624475, 0.748824326914306, 0.7885681768638568, -0.3651760335333164, 1.0504266389111299, 0.8743644204414518, 1.2130487394782072, 1.035691891548937, 0.8648742258276408, -0.06791578181637946},
    {0.7022132308616897, 0.9382458425448986, 0.8458981254906092, 0.14698053768783445, 0.997459062443071, 0.9485249756981948, 0.40559912565728645, 0.5194804565739464, 0.6950640085987602, 0.8524109112136068, 0.7647767912182671, 0.48682718372526756, 0.9009547876307035, 0.9345468464548823, 0.5511605298080922, -0.2361401325969148, 0.9013156166512339, 1.0291267556820216, 0.7790141134558187, 0.5496524721950972, 0.6190434084006935, -0.17721947085792408, 0.7872549667110716, 1.0812821187580786, 0.8931572704667824, 0.13988702129680905, 0.9951494395028209, 1.0251417447902382, 0.9994742181996311, 1.025812295880974, 0.9088515869693428, -0.033506202106744896},
    {0.7147150883279486, 0.962896033646844, 0.9706184241202618, 0.25404051799331057, 0.8032022304337675, 0.7979863080317859, 0.8472065572895862, 0.8813419545256332, 0.7446327469988286, 0.9208233397004597, 0.6811162893842495, 0.6833163386065513, 0.7251819648004294, 0.7814440969657274, 0.6970953556931928, -0.33574841085440454, 0.8828287735772622, 0.5455486896718976, 0.8910859475372142, 0.49001798884100084, 0.5800628529616454, 0.00251752752000955, 0.7151597302240201, 0.8637618733843171, 0.758839513729192, -0.002760839996866362, 1.069189154139034, 0.8195100495449615, 0.6424753388242175, 0.6988185691274978, 1.0704687093022298, -0.013375329330105419},
    {0.7384274134318511, 0.6799265043146806, 0.7161275067116901, 0.3550032863467429, 0.8035134701593584, 0.8404975365266969, 0.7144350873441667, 0.7718997798447964, 0.6018624630428144, 0.8875324773452233, 1.0621558114639875, 0.5070687047816919, 0.5630885510050411, 1.0330968935452565, 0.7620932250511595, -0.18303195741238173, 0.7492608899848009, 0.9928125024881893, 1.1360031215478628, 0.6511861487350339, 0.8786367949989988, -0.011156568567866544, 0.7392271873111906, 0.6385941901077498, 0.7989701793606367, -0.0845005773610829, 0.49326643986164403, 0.9217704634035458, 1.048192284716235, 1.0820391362792963, 0.6318203432485615, -0.17298781451928014},
    {0.6354846968091631, 0.890146727855583, 0.828920962148655, 0.25787859287251935, 0.9378611245982085, 0.6592278801824292, 0.6270770601425809, 0.9377684260093361, 0.7853767044343165, 1.0232466160037805, 0.8694292559038741, 1.0686707428902018, 1.0918288897316861, 0.9116948108135886, 0.7818003611415812, -0.1355027411516625, 1.1214842509957652, 0.8497687981616538, 0.3803953964328669, 0.6215490604709859, 0.8672787743687175, -0.02603038034187867, 0.6245240106030242, 0.3210295340803056, 1.0452353266334997, -0.19228840794376334, 0.8039967385100133, 1.0524150061577453, 1.0085116757733041, 0.8143988541420387, 0.8213759814473994, -0.3261201179531011},
    {0.8181604904894018, 1.069787393400353, 1.0674367766584683, 0.6443875766933417, 0.6531392120209837, 0.5850192224809465, 0.7316314328349236, 0.8834145489104507, 1.0434193065776027, 0.9558868898900172, 0.665025306510853, 0.5291987796021441, 0.5841278522024663, 0.7920849944548776, 0.785010398377866, -0.2176409577648866, 0.8836010417965057, 0.8564733336226683, 0.9128427277448352, 0.44155523925832063, 0.6177560127838336, -0.20537767898314713, 0.6183898532005776, 0.7346905827455291, 0.83363083447282, -0.054956339274859024, 0.7226303469121851, 1.1076391656238633, 1.0891627651619016, 1.0443282709538353, 0.7747021321952796, -0.26061089868192777},
    {0.8072504558313042, 0.5770820101546383, 1.1484701985169847, 0.48166377275643835, 0.5875550287950659, 0.6522537987544924, 1.0408610958828586, 0.9314656141449209, 0.6677319791716612, 1.0844856298691825, 1.0342904089168983, 0.8035061367872921, 0.7371484503294564, 0.33257999373108554, 0.6682476500101046, -0.1120900223337705, 1.0396340421776675, 0.5645255901405667, 0.7358093901353833, 0.8799900837502254, 0.8197972496304369, 0.13661514614074194, 0.5844401556795564, 0.7418460564525478, 0.6134112878644742, -0.26176933152452636, 1.005883255127888, 0.7238166843724751, 0.9523048495369023, 0.9162864324659205, 0.8135281739834839, -0.17858014691566604},
    {0.8765662385072707, 0.7699438936411898, 0.6941876385771686, 0.44895686131145507, 0.5518189664128427, 0.8627266213229184, 0.8053420004187163, 0.9327087006398173, 0.8680088804027379, 0.6399827071882763, 0.7608298177671041, 0.8757739311470926, 0.7407964645996385, 0.7145045720078939, 0.9590221132199395, -0.024400442720501108, 0.744252831501058, 0.6913332984974851, 0.5190822687189339, 0.6234779454297723, 0.7680210381279279, -0.2929685159699918, 0.8490474575541718, 0.9683533771104552, 0.8057982066857263, 0.15188997889697167, 1.1024357920603312, 0.8489156872571684, 1.007772172915803, 1.1527724396616987, 0.7756459250379557, -0.012543404494566814},
    {0.8905175065814004, 0.6563141767159653, 0.6637276739346787, 0.37811617737376846, 0.8187755132607684, 0.7349401990499346, 0.5766407652852323, 1.1300776864855806, 0.6689354830394061, 0.8389106844375794, 0.8912276201565443, 0.5313943500244066, 0.9463430917385466, 0.9494381715937702, 0.7054987614053899, 0.02562939006179152, 0.8161455315110853, 0.5718325434158906, 0.708166977165592, 0.8249283971654703, 0.8667434659094823, 0.19338019890616023, 0.5886076440612863, 0.849530487101141, 0.6717347092153625, -0.05349453000192124, 0.9445368001402858, 1.0132738327489619, 0.9611931621777368, 0.6987915804970638, 0.81379678888326, 0.010531188422154522},
    {0.8321645979507266, 1.0735640970278875, 1.1005625691721685, 0.618703138524288, 0.8142247180084143, 0.7119183812695689, 0.20808169355116488, 0.7761643462202391, 0.6926246873739553, 0.7475996872230293, 0.7891787117620075, 0.8292882903202347, 0.6374927888144463, 0.4439641730982738, 0.5877127958389622, 0.09424764784504575, 0.6933783478697348, 1.0275594430453314, 0.5924546669343151, 0.7318014378721585, 1.0035131732080123, -0.40741502606688873, 1.0745788088918329, 1.1290923927074523, 0.9333976366478771, 0.05669903073618487, 0.8551540328362935, 0.6852408496107205, 0.7675990050907167, 0.8682019435396896, 0.807624692091832, -0.22499681100417082},
    {0.9576013790181281, 1.0956974477361685, 0.7980087420014633, 0.5775958462955464, 0.896181601960487, 0.8883667894174665, 0.86972084060722, 0.9059495383165912, 0.5576528281561269, 0.9059171121628875, 0.6095021477157951, 1.0277526864150401, 0.9753565485720836, 0.5664116240884977, 0.9099182245945083, -0.21044845405132417, 0.9111220748621724, 0.7162901639572598, 0.49268043544941625, 0.4909390318160726, 0.9416391027314668, 0.1768617134400237, 1.0174514203744824, 1.27922676660562, 0.853654311177843, 0.052295736104074834, 0.4014894035968594, 0.9941704649086233, 1.2194421369691537, 0.7522248425831568, 0.7108853821956225, 0.03238361945526844},
    {0.8744659169822919, 0.9036989719046117, 0.9704207190727169, 0.5600287568661884, 1.2184422593673785, 1.023294331395173, 0.9971704390180851, 1.105708287338852, 0.791860557444796, 0.8376192590960931, 1.0994605908452875, 0.672599174065607, 0.7063740088448365, 0.5933605741386458, 1.0444853425765352, -0.16529014616654308, 0.6957873459608369, 1.1219508450926134, 0.8788911253243316, 0.46668881195287226, 0.8999944928733903, -0.01588442510859117, 0.6898903555204574, 0.8351124874780642, 0.9051506168982161, -0.3290797463557389, 0.7175002594662488, 0.7824321838033171, 1.220190621275298, 0.9276916579026813, 0.6290563041563613, 0.11247670022902431},
    {0.8208665951110519, 0.8853422059644827, 0.7118643391280961, 0.2516844809751704, 1.0697169577656775, 0.4314509925359768, 0.6915071659041986, 1.1969135743728132, 0.6910923039386699, 0.5809387962668191, 0.8219612578513221, 0.7424171887134677, 0.7673456915652265, 0.987276164403406, 0.9968152851543637, -0.4334747978648083, 0.7266908717769439, 0.664799591192124, 0.6717783217592942, 0.8413630078895179, 0.32118736176910806, -0.06822459985541526, 0.8589293182271496, 0.7187541496661036, 0.9202370677090771, -0.030758174739336074, 0.7095969326022319, 0.7017497026733509, 0.7822171274897418, 0.7561785096046009, 0.9060483781605598, -0.06546659760671826},
    {0.848948609809945, 0.5770560297421169, 0.8122518539266574, 0.23045840336814882, 0.9968781000375531, 0.9407488632869759, 0.7487529682087054, 0.8586034417558174, 0.8796488598781336, 0.6551168180822226, 0.8673505494109792, 0.707747338814978, 0.670101482638799, 0.4503481035595925, 0.814976540602486, -0.29126897922135114, 0.701609471715225, 0.9137904277383733, 0.5793022233733917, 0.4446940658574992, 0.635635421502058, -0.2612936477463438, 0.5023962458819511, 0.4799963795937827, 1.000315939464553, -0.12598995138094155, 0.8851742924688619, 0.972210528141436, 0.9283906352140066, 1.1962754339284976, 0.8153992432598864, -0.15457649249216335},
    {0.7686086487689888, 0.9184890151217963, 0.9098470156142636, 0.5125189110267507, 1.0062423508198066, 0.6010944176815028, 0.724199256992178, 0.8703231326350249, 0.578980166783984, 0.5486093877387305, 0.8631922222877504, 0.8270528325911417, 0.7702546286544584, 0.9489456732532372, 0.7675787856412898, -0.23141869141855068, 1.349737797716553, 0.8072153591957668, 0.7404147065774052, 0.29597884606760344, 0.669940132905814, -0.06000042289040487, 0.7498147240115509, 0.6173149403588737, 1.0301270342289446, -0.02371039576843445, 0.9444106696399949, 0.6223421039005808, 0.7953529753042343, 0.7743119417297364, 0.8012722020050383, 0.050111208609998646},
    {0.9689205403811318, 1.1420388155957202, 0.9871432233585654, 0.5104079725738625, 0.7706014649190946, 1.0905190249747674, 0.3687090140267127, 1.0939852973854947, 0.8874505964937189, 0.49247259324638143, 0.7773463128423246, 0.6307449705277763, 0.7114928981454133, 0.692938058073658, 0.7610868046700876, -0.1972895637986262, 1.0179591006472992, 0.9177569538193687, 0.6162846435523831, 0.46339307469595353, 0.6827013856345279, -0.3781783552094198, 0.9409330281974129, 0.7832029912484878, 0.7174128932480017, -0.0462949440209282, 1.0375002146291805, 0.9520235816937077, 0.9795204276593746, 0.7844372184888756, 0.4774291594160903, 0.027836791005668292},
    {0.8454078625513777, 1.0911412632562307, 0.8773110782289072, 0.41574454694885127, 0.8119063598172584, 0.5605430345667506, 0.2931629286093349, 1.2327992136263535, 0.475739337144275, 0.5444204833685715, 0.8064694082740831, 1.081799763455319, 0.706073583930931, 0.630514587524077, 0.8601394070040083, -0.3119972218417535, 0.8994723760665264, 0.948973573170477, 0.6208907882410224, 0.5225157871685221, 0.7452862699428365, -0.0018952102604017165, 0.7833828899203936, 0.7244809924608151, 0.6641993480113468, -0.07202724337603601, 1.0011316241827013, 0.8589933576886617, 1.1325619874304913, 0.7953504308346908, 0.781177808790741, 0.138178200813136},
    {1.3591243456240143, 0.6694217028373388, 1.0620367199486807, 0.28580433634806784, 0.7373898320013705, 0.9330540945541593, 0.6461791436965901, 1.073732932643253, 0.7615369225826464, 0.6680931651713413, 0.7956573176296016, 1.134452799202973, 0.48155430539725314, 0.6404961241735927, 0.8415501188930083, -0.17708999116978416, 0.9399660948836749, 0.7699917149570633, 0.762281132484227, 0.5880411499492919, 0.8705706381223134, -0.040702822680944904, 0.8932041019756448, 1.042378438852575, 0.707710306409089, 0.03764645491136732, 0.8667272582370885, 1.1723218422785515, 1.205989837504192, 0.12286470448269808, 0.8628029705228235, 0.28267263417779115},
    {0.7570506755298542, 0.6960612028739823, 0.66715831432587, 0.4221951816025558, 1.0155336929618242, 0.9050210914404895, 0.6868489391193728, 0.8270081852984136, 0.824311304645166, 0.7350907530118176, 0.7754716803368332, 0.7236722140761543, 0.925718885703264, 0.7997264172376097, 0.6719153784376161, -0.10776647444150056, 0.6038089698614082, 0.5765759914363406, 0.7145361869444454, 0.475418504807706, 0.5647879508333672, -0.04020238275980083, 0.7432743441519517, 0.7123860635751719, 0.6412876231754289, 0.2421409471338421, 1.1870353162894394, 1.0346192928890992, 0.7536420316890821, 0.7992735066573312, 0.7234959846013427, -0.056312730156224615},
    {0.903754214836208, 0.8576142934863032, 0.8359792243449147, 0.30806261156867926, 0.733093483123636, 0.7433371318371274, 0.6970687858529654, 1.2550900869866053, 0.8852485278310936, 0.9172291900188185, 0.6645143886957491, 0.8216731648401837, 0.6869464461639484, 0.9347832931526917, 1.0317145806657828, -0.02062900107543734, 0.8666510850150358, 1.0182871994259877, 1.037131749259473, 0.3848618765350535, 0.6058294363661586, -0.12365859941505578, 0.760145579980415, 0.8578900132476028, 0.7527677827672541, -0.11958634482755898, 1.0276819694271417, 0.7899879612394678, 0.7593430339364313, 0.6045923402498826, 0.9232889440930674, 0.15297539017446388},
    {0.9819096366443476, 0.8372810047175353, 0.9785680306082638, 0.6954318263100856, 1.0504356167939186, 0.7307633414486365, 0.7915100813123898, 0.778846293865249, 0.9739855208922591, 0.750181946700631, 1.2512145840168398, 0.8991032121904772, 0.8546161570345485, 1.267570336277003, 0.8582746077571588, 0.04810533722101265, 0.9579718276632809, 0.6633856602320468, 0.6335923257009944, 0.7348962130265728, 0.5138800511360366, 0.014586357764382463, 0.958646801378621, 0.8520676467511397, 0.41527158118975055, -0.11482281195853579, 0.7239592599609427, 0.841223287479559, 1.1226758981177343, 1.1970845609557375, 0.87564729282991, -0.08323339536486399},
    {1.043230624311413, 0.9090339098763521, 0.6999056937246876, 0.5925314709954955, 0.9554995115088484, 0.9663401419386373, 0.5310378360270351, 0.8595875028824269, 1.0518172248758986, 0.902426584261409, 0.8305545362642149, 0.8783819308840399, 1.24148064805601, 0.9286490063601651, 1.112798124239458, -0.28657961423996836, 0.925339277392849, 0.7763901553909921, 0.7940084178263737, 0.3282142607184619, 0.6358031654753772, -0.24677198013017085, 0.8384081001707532, 0.794919080241751, 1.1757253475573057, -0.07828986031607038, 0.7733025913175475, 0.7750441867758302, 0.791957741770892, 0.8972777045935839, 0.7218565946846964, -0.12702776181755587},
    {1.0220492731222341, 0.9793070934794776, 0.9811952586889351, 0.4312328657722124, 0.8246861173557185, 1.0585122968013563, 0.7966770910598706, 0.9255394493533204, 0.9938865504498696, 0.7831074874834761, 1.197518739178602, 0.8919713765941288, 0.755900719879589, 1.029178741581672, 0.8892140358374141, -0.21869967805185936, 1.0481988951466903, 0.7877056181977268, 0.5068967282205459, 0.5428396001692927, 0.5009504742502007, 0.38983315037541066, 0.45267175061513243, 0.9776054185385706, 0.46769465574666946, 0.08090886498804209, 0.617352998953027, 1.0543922747555532, 0.8736810096221793, 0.5505745304926639, 0.9788457147088163, -0.08089863988559014},
    {0.704109204960565, 0.8036796706033491, 0.6813908330747346, 0.8290393382979375, 1.1955389043350064, 0.9146463288575648, 0.6217172010818811, 0.9428237886626784, 0.822971717029819, 0.7769265864172812, 1.0891551024096535, 0.8148119498346567, 0.8534276629673864, 0.48014087946700523, 0.8652194091581933, 0.03738916471405251, 0.8888470377302944, 0.7095039727230862, 0.6465078265958053, 0.7316926314840609, 0.8645076992186507, 0.10395766458423464, 0.5581797627500722, 0.6153699073520505, 0.7948459377247514, -0.01777597027856577, 0.6417761073203341, 0.6429706975235066, 0.9501742759848698, 0.6792738628623557, 0.973186855869513, 0.04156823758749321},
    {0.8080566928386569, 0.8147593608817257, 0.983954593287688, 0.7881090922205944, 0.8417524062777998, 0.6605303243041312, 0.7829336182278142, 0.6992858575150828, 0.45619112084248803, 0.9250483054856065, 0.9450573711601362, 0.6371911265225502, 0.5468960008225495, 1.0553495005946172, 0.700975797181522, 0.16243571474899154, 1.0231686193165446, 0.7246483718704948, 0.5503553676339451, 0.758453475819512, 0.7306106203475672, -0.1488316849171547, 1.0009694997160545, 0.5139215165364063, 0.5676086990120921, -0.014414890010343592, 1.0524364494487934, 0.9166885431749352, 0.9546638939221793, 0.7440224505533243, 1.0417241796421421, -0.1560773398474045},
    {0.6724454263534763, 0.9347663055791958, 0.9732091507937656, 0.6336840302947361, 0.8219041098157014, 0.6907872733338547, 0.6359266323726103, 0.755702113058575, 0.6880382343090119, 0.9019320679218198, 0.5956786530618162, 0.8258539035914321, 1.0886426541275132, 0.9889356579695735, 0.6909573724128734, -0.14145313544980623, 0.7895950914163803, 0.8245326497381157, 0.7214878628135792, 0.40170940699548535, 0.7025585333292164, 0.11760038088884378, 0.5733610520685851, 0.9224638325275988, 0.7627574349094274, -0.10074201660021351, 0.9709936502984687, 0.8962713271571088, 0.7004797396031974, 0.9233468784879808, 0.8436732779373971, -0.18484750005656173},
    {0.6318711226411646, 0.7648942401933363, 0.6161240271007303, 0.5727430395295351, 0.9543995744307626, 0.9758088750640179, 0.3872116209361324, 0.7076764079561422, 0.8198147023160195, 0.5499712911028495, 0.8680817724847012, 0.4680010908826789, 0.4227378134130267, 1.0124194990130995, 0.9634577538907559, 0.07393181685927637, 0.8557331189531016, 0.8684991816462669, 0.36599979746484496, 0.27913396548281266, 0.5899042404097431, -0.07607787525813833, 0.794766432917193, 0.7570545921904516, 0.7928714085398556, -0.1301295929087719, 0.9861673648836103, 0.8056239079865708, 0.7150397379680045, 0.3631668530712379, 0.8182946337863786, -0.25896442251750096},
    {0.7892459902345508, 0.9841941310988581, 0.5330880444312075, 0.4684740517741118, 0.9298683007334504, 0.8714132629786667, 0.5068488834142751, 0.3791867013961719, 0.6140113552699561, 0.8915464850126901, 0.6290272958144033, 0.9942924467494517, 0.7759822320095139, 0.7312136317406503, 1.0520540161013168, 0.01313612106812876, 0.9115108371741356, 0.7535135795823911, 0.6014277623571163, 0.3784248439899297, 0.7129395416025381, -0.23135840030351548, 0.6917362652222796, 0.6690893307687321, 0.7543913136604965, -0.20120385372048288, 0.8752431858604675, 0.5497282601179833, 0.9455231245221029, 0.8143345088436938, 0.5727575835388453, -0.17029633745424416}
};

static const float b2[32] = {0.8243160959872878, 0.853761755439471, 0.7849238183629826, 0.4924080550593035, 0.8349504545858881, 0.806038105640382, 0.6547116267768446, 0.7959918601869561, 0.8170804435892534, 0.828915013034138, 0.8513693074534369, 0.7900059596570016, 0.7523735434511012, 0.7355783260457907, 0.8647298196967574, -0.05629820730658841, 0.8054288982436211, 0.8092206512715269, 0.7380322689812798, 0.5906193617316685, 0.6808940827896557, -0.055815663946720294, 0.700434365045634, 0.7811321937718609, 0.8467385249431563, -0.13052191144204164, 0.7859796058938048, 0.8058696791494602, 0.8292320969724002, 0.8293078220164987, 0.8328368207409177, -0.08837129413788707};

static const float w3[32][16] = {
    {1.3639969469985873, -0.17679983657289813, -0.2900953570219797, 0.6755148001532781, 0.10956596178946737, 0.9342652238388509, 0.7510667109865204, 0.90653051540494, 0.8581467893609761, 1.2798819956025222, -0.03204772322388848, -0.06114452503141192, 0.8845073471540202, 1.1205765905744092, 0.7343747531946857, 0.3880053265220201},
    {0.9732362602437832, -0.3943576462034618, -0.08045969658404342, 0.7503664648519802, -0.003314642883137543, 1.4721711351726634, 1.162105267082378, 1.387315425517803, 0.702550842005445, 0.7897791218010873, -0.20767561437803486, -0.20961452043070486, 0.7336526594657031, 0.5230418353953414, 0.6109880411751988, 0.04898519406159878},
    {0.5911327351153961, 0.33191717614358307, -0.279606513301004, 0.88442349208598, -0.21978678047346573, 1.2477609033960235, 1.0276092366475753, 1.101414624367377, 1.1538912017300498, 0.645875690458102, 0.0903415182664327, -0.468348125145534, 0.49972834794556353, 1.074833220832989, 0.8045291607112655, -0.11620664959468761},
    {0.6427997143849183, -0.20787130903775133, 0.14391968260962812, 0.4524170358697568, -0.0045698022706452965, 0.7903643936001871, 0.7382645022346407, 0.5248006240337059, 0.7251970605423066, 0.22537188509888434, 0.09461808959625076, 0.3339984353759069, 0.5441222622133938, 0.9367037960763248, 0.995458640464182, 0.19024961446198363},
    {1.2753196330908265, -0.4260884687982751, -0.45304610681838514, 1.014232149318004, -0.4525284791871685, 1.0447683209123877, 0.5344491831484685, 0.9051612578067388, 0.8479190592381276, 0.7418013272915231, 0.007740573502473766, -0.03705400806510134, 0.6180384134319831, 0.6699412654162678, 0.5304641936845484, -0.4134947255859135},
    {0.9704578431853357, -0.27747579531625877, 0.11222964506615117, 1.1299526678762002, -0.036097116434671464, 0.8806503981314675, 0.8698763848118368, 0.6284864289122098, 0.9390389443998556, 0.46695969180657043, -0.21760722425310208, -0.018463355060401553, 0.7025260795444158, 0.9719447531416646, 1.1488253855793862, -0.06969247657838525},
    {0.5626337171390554, -0.16391662968559378, -0.16859300757151163, 1.3989796925700613, 0.29838721733224166, 0.9975558496309671, 0.8122024910458613, 0.6436437862283495, 0.6941381224422876, 0.995198896378715, 0.19597381298579095, 0.30563634553471364, 0.7518533988395598, 0.5608029499281989, 0.7700697217647147, 0.09388791306017027},
    {1.0017725431260416, 0.21805165736204293, 0.17724544698249992, 0.4449844563928534, 0.0033826264550088385, 0.7083312967446441, 1.104087387462143, 1.201774034099529, 1.0759067311979007, 0.6666358071839632, -0.15447769170243075, 0.12936795960940017, 0.27314581739499066, 0.8814868775861889, 0.4914403397797796, 0.2613865291664157},
    {0.973860499892787, -0.02996647748156544, 0.04126834776507895, 1.087145982187143, -0.6583718804106962, 0.8154402571344797, 0.8462361889252257, 0.5440572390326567, 0.9777335269880032, 1.0486704549706873, 0.17008365022227567, -0.09550275623694171, 1.3812396677576255, 0.5003829387188582, 0.812823297583453, 0.14564499225214128},
    {0.908472259541537, 0.3862417683324123, -0.0028997954230346964, 0.7821494437584104, -0.05670986730326378, 1.3671630518378002, 0.5635145104917257, 0.7249914478859469, 0.7914732591797732, 0.7832407264716584, -0.10440377445489814, 0.009912477943230672, 0.9029448827221542, 1.0199908390603913, 0.7975970428808287, -0.34081665280734036},
    {1.061917506736505, -0.12312364084737196, -0.3127462572645671, 0.8953728391207559, -0.0326397892821763, 1.1195230878813127, 1.3809748487619788, 0.6967580387553373, 1.0020896151406282, 0.6273434942476668, 0.10408240491352543, -0.07289391837741142, 0.8737484016666897, 1.1190762306154018, 0.5505954305642772, -0.41892315352691845},
    {1.1747916014078792, 0.04209924283017613, 0.32852575354493857, 0.698698903251702, -0.08350351377198499, 0.9667888403012885, 1.0139826770060691, 0.3212465720165517, 0.5289190859051092, 0.825064578248517, 0.10138691069491182, 0.42591651331745617, 1.1791245898161264, 0.9178612774060163, 0.6605392040100854, -0.29876822768068},
    {0.8127391325984211, -0.11601710864256908, -0.4771289651317064, 1.2678655689030194, -0.42082693867913623, 0.7200492408731236, 1.234885061622069, 1.1596681571094098, 1.0701346226552264, 0.24072798402083756, -0.0680570030124986, 0.18209087474223837, 0.6424149077050322, 0.9636261220303532, 1.0320947532952038, 0.5175766521034708},
    {0.9020746352699288, 0.07984547157117676, 0.06757935044118035, 1.2969353854173882, 0.08907941111838891, 1.0180084629306714, 1.2511744466088672, 0.6135982499773622, 0.9428007780378078, 0.7625994572251853, 0.19639287932133007, 0.1683985357143933, 0.8813847746421046, 1.1209469655366973, 1.018418672560971, 0.3711185649215737},
    {0.8693621464213613, -0.027346598109329164, -0.11410411893713403, 1.50457875794239, -0.11666104405229727, 1.083881654097766, 1.2692095877355523, 0.7776406558917399, 0.52807543691504, 0.6125252033301101, -0.08381152695698037, -0.23916464372065183, 0.609082963029847, 1.1505610047695278, -0.024149981676668635, -0.11238511468417733},
    {-0.5813105938695634, 0.12731990172644508, 0.001811492637346338, -0.15972554581740114, 0.24229750827010604, -0.07458119023969395, 0.5046277654183087, -0.047904722197788505, -0.45760991195515593, -0.07784619918624408, 0.46772260922215503, -0.2107306225942847, 0.3009257482485181, 0.2635697130179686, 0.14665095003322534, -0.0021993331102782565},
    {1.0510155216361399, -0.39496806288046366, -0.23337253070850822, 1.0283048124219774, -0.18568264227309914, 1.147949760033565, 0.9502927165546278, 0.564292811544569, 0.9081305526814524, 0.9050257595542939, -0.09087284214536291, -0.24615102632923233, 0.7599793265547765, 0.5109787313797326, 0.39691517071652527, -0.10640262262791192},
    {0.8431692094844512, 0.22445379019072895, 0.3284092812444892, 0.9876825258042178, -0.21877236949147055, 0.976889240634887, 0.7849924210307462, 0.9314210138789566, 1.006034731949037, 0.3599755994529585, 0.07722107638542891, -0.039999822327214385, 0.9961509300684757, 1.1539993219936027, 0.3147033361471768, -0.22359095862212983},
    {0.6303659521584144, -0.14917814531278642, 0.5283529607847225, 1.0827642567345248, -0.36423457707546797, 0.8882676396747005, 0.8420766334290495, 0.5891442646341597, 0.6853860292105973, 0.8376315158755445, 0.12804606486571826, -0.20802630375422004, 0.642471457735495, 0.9822599331622758, 0.5517785971453555, -0.364836828635395},
    {0.4775575753862023, 0.003725060129273935, -0.0744884571791189, 1.05954127828001, -0.17289563373423858, 0.6430583690670214, 0.5676707708788705, 0.9807651617237737, 1.0030488115616278, 0.8905088994000463, -0.31375445757026144, -0.4181537447944201, 0.2787768470755964, 0.3911641583995952, 0.8582240506300037, -0.31407647622197105},
    {0.5672035331727029, -0.11743593772305419, -0.3848342607529456, 0.9142375480840691, -0.053006535267339464, 1.3268823039462114, 1.1472858852392733, 0.8231267976100451, 0.984734155853693, 0.5512503703974609, 0.5057255383709013, 0.29159304711751644, 0.6698101242715284, 1.078955589150034, 0.5286410291931625, 0.008104151598596116},
    {-0.1464710636116268, -0.3917018908089353, -0.05804242155788911, 0.2452761326729588, 0.2278992199280637, 0.21452856443852794, -0.11091832808966841, -0.07336214149131207, -0.4472233382270461, 0.5077321481706915, 0.41012754817411207, 0.1291433067759555, 0.2855093860796727, 0.15489679410539875, 0.06664187843357186, -0.2943661934320598},
    {0.9751227244849137, 0.22199014746818804, 0.006141752415071761, 0.48731532268698, 0.3911868617719055, 0.6349677721860308, 0.9614152530274105, 0.8376306725606811, 1.197149337972975, 1.2521209688401058, 0.4620975599461189, -0.19754054134508983, 0.9488979555809346, 0.9328358040332294, 0.5681014221791348, -0.1592372129601597},
    {0.9481818689534597, 0.11658471153424026, -0.025368690867239328, 0.8514070258476264, 0.00529573576079906, 0.5328955477043955, 1.2652073133547277, 0.6164853011627274, 0.8019412314155574, 0.6294588536685402, -0.5680937650036872, 0.14508763797703453, 0.828048897818719, 0.749552328837595, 0.5933863141327609, -0.14222265480088028},
    {1.172929195900337, 0.24694841808495643, 0.22591944451827942, 0.8463506865392697, -0.049313309193395105, 0.7091889157558459, 1.0088929860578972, 0.5164330574603787, 1.113628648269129, 0.8740706934395561, -0.26288698881771966, -0.358783563861436, 0.7569561539246935, 0.8474389926999862, 0.8190988582987302, 0.1796965017370275},
    {-0.28768899088286265, 0.2656096837578133, -0.17060637753052943, -0.10625006968757114, 0.003428888167563098, -0.239367001059553, 0.1935782691259902, 0.21935882328514877, -0.0436028654651414, -0.22969973545746736, 0.32612364369273944, 0.19230844685154172, -0.09355093091938513, 0.41844687633070854, -0.3969455613004582, -0.053356724596768094},
    {1.1426200398590083, 0.20234574428261556, 0.04850654296771201, 0.8639048594642506, 0.15194731843512643, 1.0153660650684286, 0.8898882036009637, 1.0575393669220272, 0.5056825341000933, 0.978370837623325, -0.03344288367072153, 0.05045074072927111, 0.7474150232022605, 1.174459665673467, 0.9521962147518414, -0.4539278788202774},
    {1.2856908463232728, -0.19082744024996673, -0.06962933625484281, 0.9985160654479703, -0.03942932668037545, 0.5805598425341693, 0.8457052564874207, 0.9164273097521316, 1.274270889980012, 0.9082033898090227, 0.13374301792228185, -0.10506945320486027, 0.5716405121034086, 1.1308784838848969, 1.0430440248949662, -0.18597669424980948},
    {1.217142884568421, 0.1221233435284403, 0.3707361660000786, 1.2295013368028866, 0.08370296543945621, 0.7516526988572673, 0.760676624216293, 0.3998943326710857, 0.9202917926111076, 0.7143028393996947, -0.26229094785128093, 0.18721744685422825, 0.6413968527306952, 1.3474962003568491, 0.47682813284433834, 0.1493634282301435},
    {1.0351681262902854, 0.20384294437663056, 0.13705710047953942, 0.872310188979508, -0.4134269721578912, 0.7927356469030268, 1.0186175142610852, 1.0096920880084894, 0.8552426735039842, 0.6717828081886629, 0.1959370179519051, 0.1987620623619449, 0.9096049328367396, 0.6522557679609357, 0.34064274675378353, -0.3388777388599278},
    {1.177658683100361, -0.1180300653498287, -0.5679612686913029, 1.0978758858951856, 0.05445008447275057, 0.7835743693431299, 0.47618086654036285, 0.5117579448315683, 1.0108813620657762, 0.6384356634367951, -0.35314389693445786, -0.40892553311972096, 0.8114914803706741, 0.9825840366739718, 0.8268315750360764, -0.28243543244322655},
    {-0.36593563926805983, -0.09998280903311549, 0.006022094404441335, -0.16133715242970795, -0.020796568640712828, -0.4610104490426023, -0.40465799220527726, 0.12402220012776972, -0.1487712226560549, -0.0212411504180836, -0.518055076948168, -0.082578667665034, 0.6430904279023283, 0.12247567021481053, 0.03736990338455488, 0.42872115348092626}
};

static const float b3[16] = {0.5598379448281019, -0.03258574853875444, -0.0009854642421217596, 0.6246968094249405, -0.042537693599980886, 0.5865938844395169, 0.6503356704099033, 0.534971081455998, 0.5780654799611737, 0.5881524645686927, -0.027037463006555285, -0.025519687904862545, 0.5113814464283128, 0.5666201146548582, 0.4294204540291806, -0.017691380937049694};

static const float w4[16][12] = {
    {-1.1387104290121053, -0.6506742391281378, -0.9596826097586182, -1.286518609103973, -0.38165632454759163, -0.8403747546970457, -0.9816458805727359, -1.083767047036021, -1.290213423350878, -0.7587033660327629, -0.4199527742505628, -0.6969707968161533},
    {0.014572436080828224, 0.2808981548030023, 0.09106176052359949, 0.0567040525578412, -0.45529621699939743, 0.0029704242412007527, -0.30288036882549085, 0.15123643875575798, -0.18534716887380273, 0.2849019821591291, -0.07029939653289295, -0.16506472712704834},
    {0.2168456660495317, 0.6827727372528608, -0.17389621963472354, 0.2557975730974029, -0.03850002264541123, -0.3736431066738064, -0.26775794012647236, -0.2850339005036162, 0.02707850319309434, -0.26512563216062046, -0.45800310511123715, -0.5972972195958801},
    {-0.9683712607123538, -1.0953953776509624, -0.44266311135660785, -0.5777338681931757, -0.9131285337292299, -0.27373827591778593, -0.6968771589420619, -0.8916251039841798, -1.1583914661743466, -0.496877723724778, -0.9267791371482113, -0.7480347851849787},
    {0.8019771437196299, -0.06737696678513258, 0.19792988885177765, -0.11515554060424692, 0.4509861081958669, -0.1941751189991032, 0.3231635289980781, -0.1775062728731909, 0.15744554349858836, 0.3138483417314411, -0.29043550587703715, -0.42088697513881335},
    {-0.4434937442611821, -0.5751912119025646, -0.2963246651330518, -0.6737669361730967, -0.7491948008055589, -1.0185067863353476, -0.9534731935182966, -0.8315291702413772, -0.3990853274753937, -0.8652792846509166, -1.4867065418696697, -1.1085508531675643},
    {-1.1777378360397797, -0.8312077925545841, -0.7058425021643001, -0.5064787701638779, -0.7009549894420934, -0.8976175995640088, -1.058884497112702, -0.6485660787685332, -0.5570367153427224, -0.8213333817157494, -0.601288686627768, -0.9563497192353752},
    {-0.9234417742378369, -0.9200954165346186, -1.4467690330167842, -0.5861877202600385, -1.119559516972384, -0.7641515540565591, -0.33012139620675623, -0.4733631629021843, -0.351894150872952, -0.5807722542069762, -0.7152714156799463, -0.8559754353396943},
    {-0.3605532876531645, -0.6846987935846898, -1.6860659953649866, -0.5119404154736872, -0.5841101566007152, -0.8034140073335487, -0.9894915115681747, -0.5106881704927888, -0.7175703669520652, -0.7525410470723827, -0.697211342717187, -0.10060501704370799},
    {-0.5203224461519815, -0.5324887435843929, -0.8843493262785215, -1.4430468890737538, -0.86756817388661, -0.3906879539811242, -0.2706150360023387, -0.7142189780729531, -0.9358406987297324, -1.0730025084895238, -0.9161751353845082, -0.024582460061549117},
    {-0.5565546326824614, 0.14577435354578314, 0.24699722476179434, 0.6173000217093503, -0.4797867773522043, 0.009548701416281282, 0.047609952613872034, 0.1438269216643927, -0.19378474448833152, -0.20368758421866526, 0.045188166345130634, -0.04509402920198167},
    {0.4819190162452592, -0.032041338088484556, 0.219893670323117, 0.0563050800147809, -0.5910450258406276, 0.8255390243611603, -0.06099884697890754, -0.05350817236730194, 0.10267701466241365, -0.15892388770564234, 0.7296388356573817, -0.6212801101397292},
    {-0.7699032876959981, -0.7804112540273268, 0.10353388317350724, -1.2269270583071852, -1.0207541818374701, -0.5041476272312269, -0.8100343862624695, -1.23640567852055, -0.35458136545371155, -0.42225533137094684, -0.5534642642812588, -1.0080184765859956},
    {-0.5053846733224108, -0.5921376071971065, -0.7470630439392606, -0.13355127021033097, -0.7241467789304744, -1.1390432443596281, -0.8282598980372649, -0.735308475200542, -0.645881683516658, -0.9281692126545243, -0.6241028590763479, -0.8998605767266137},
    {-0.6552246700703881, -0.8948516366158705, -0.3288738826708831, -0.6464242214153764, -0.5462247094093697, -0.734693986094782, -0.23056469266800164, -0.2020473232417109, -1.0605164594568661, -0.7832917286422939, -0.49250817194113566, -1.0701141133468552},
    {-0.058359295972670734, 0.6721092089150076, -0.03373629544825176, 0.47168183378304857, -0.7773679620828032, 0.01652576895451035, 0.5107155629433526, -0.03419705854491635, -0.08422109708509534, -0.025991442367005044, -0.1178510694324761, 0.10496725084850242}
};

static const float b4[12] = {-0.3335246846426878, -0.29106396371954946, -0.21874446981424653, -0.21475002299102977, -0.1789747257814984, -0.1563962793972396, -0.3185391673098757, -0.17744677616409849, -0.30489470433488663, -0.2956987550565173, -0.2306296769656084, -0.2655652079972515};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
