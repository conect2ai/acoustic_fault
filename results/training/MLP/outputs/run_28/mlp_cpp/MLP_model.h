#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {2.973442296102152, -3.3379404428968056, -1.4388903585303237, -3.023817207915235, -2.8260735989671786, -3.530223636591035, -0.8837602284915795, -1.944824367345106, 0.7032889863262287, 2.2254689036580815, -3.026361128293865, -3.232791107769018, -2.615509912547187, -1.6457184669191465, 3.026933450295982, -3.28442089697046, -3.1021571298190462, -3.0884844129946987, -3.663804209035836, -2.720375479820981, -3.2030697766509553, -3.21649382434711, -2.9700938550199947, -3.594676457448273, -3.3432946935649372, -0.6396396579975614, -4.005193729509129, -3.4485506184451373, 2.7199571595108147, 1.544370097115234, -3.000127925545933, -3.5725671766871736},
    {-1.7368929907025212, 0.2938843697348874, -1.594022597140261, 0.9878043686564534, -2.0635225418446526, 0.2201998669071449, 0.010053192839538089, -2.5689033178312757, -2.30243525333316, -4.330336968793306, -1.9022080055888406, -1.8121658049094522, -1.4392715719406803, -1.03063777468495, -3.9305457977229525, -1.9764985654792788, -0.14365395050265853, 0.019601529579119495, -1.1930048091029264, -1.9419437883336337, -1.669263376005381, -1.6936456822432058, 0.4300658061649033, 1.7960472697326375, -2.6136970734261613, -2.553551962709329, -0.22740875734488167, -0.6086000606179656, -1.5692107964497952, -4.45061628537366, -2.4705468354502043, 1.644652326316471},
    {2.7069536235462452, 3.9986625870395995, 3.4999524177563597, 4.227744917290546, 3.2071076637348, 2.6579499374493314, 3.6021065095462275, 3.8670313560433316, 2.1333210551905983, 0.06987896937239302, 2.889125965093953, 2.962293569215611, 3.636392045253515, 2.8963315002127925, 1.3406418668208582, 3.6735608231022043, 3.869340218275664, 4.462527660242009, 4.393800351408438, 1.8197464535091397, 2.754519994469533, 4.200251758452165, 4.833343283044202, 3.9218188580470024, 2.6724088559321126, 4.244180156552658, 3.8581427413240847, 2.5495923410290686, -0.9974682849511628, 1.159067657182079, 4.611722481244184, 3.8218068148217412},
    {-0.46750597246774017, 1.565930685633872, 3.6608415826382714, 0.9956656953985135, 3.028353366997732, 2.525774611644778, 1.037820450037999, 4.600624721014446, 2.139053765306062, 2.5760782034421386, 3.351760776907364, 3.548354507831667, 4.72118754175407, 1.3993639295499707, 2.6422588382824297, 3.298576293752354, 2.3312991273710404, 2.0319874547727044, 3.2166097484277048, 3.5514537586651165, 3.1523156009368063, 4.313056398997544, 1.1094654458273274, 0.9784146919811605, 4.221219072333972, 4.9069212148145676, 2.8909465304656012, 2.9914030887423357, 0.4569797672711192, 2.814483524059301, 3.5896015659571643, 1.2195584215606114},
    {0.23579965523683302, 3.6297424525751207, 3.608401910044068, 3.4594789147179497, 3.8655387679187476, 4.665528916756777, 3.0818550532463136, 4.183944878237234, 3.133728120103897, 1.6332970428700049, 4.712046638393252, 5.01493242597957, 3.844620047116988, 3.139007724954383, 1.2810297462120155, 5.273939572879975, 4.059165172225843, 4.529373272602892, 5.4008804836800435, 3.8553748597385993, 4.319141392472389, 4.386328991316673, 4.469190946406233, 3.2933058204610863, 4.592487475741772, 3.710719217318887, 5.310826708842658, 3.819437927991729, -0.8856833218951972, 3.4871279343882877, 5.247647099480903, 3.5006593527958403},
    {2.3531666429614257, 5.126164598550833, 6.587984858304528, 4.236639217316581, 6.743624218975993, 5.511845053099453, 2.4734369954989885, 6.078276339010812, 5.7415737972228, 5.00141955950907, 6.320573516348119, 6.443715608060874, 5.994856193749687, 5.528194255133761, 3.967557625572264, 6.155705361393727, 5.368575663996974, 5.0102362796888, 5.828560657345176, 6.092582681574079, 6.169302576113843, 6.569641269758047, 3.9955030896439827, 4.783811545948685, 6.995396092158002, 6.167400924255203, 5.491158826300435, 5.642038488709655, 1.0311220917401138, 6.068307911343436, 6.257818334629134, 4.473234903114864},
    {1.7840542012816167, 4.503689558218328, 5.854465474329007, 4.018258409644879, 6.235479734981273, 4.725073362791874, 1.8698611150236226, 5.863688048659767, 5.364603451626016, 5.079624235139003, 5.6746431736600185, 5.333964764596002, 5.983872932655563, 4.88183261681854, 4.097670557096398, 5.7347442281604755, 5.030184021653992, 4.347825892681206, 5.850587002028764, 5.964914192969264, 5.567103923021528, 6.036448617020974, 3.6191014427007238, 4.072638843092491, 6.476944432460205, 5.998898762020872, 5.01203361193489, 5.103989824428679, 0.2952554406763423, 5.782181070952315, 5.773136374287466, 4.524226328654152},
    {-0.4134350181018592, 1.8515395232763436, 1.6343255066811306, 1.2285749910520134, 2.1063952012263574, 1.648112187535826, -0.2546056243353598, 1.613035990312861, 0.42842793333273865, -0.4272927647809173, 1.5366260091043347, 0.608257114792211, 0.6070410325812607, 0.18687964385887806, -1.2152009492338842, 1.723362155856351, 1.8496814405533368, 1.4657004548041763, 2.6647071992286375, 0.4297451864487309, 1.0919974157684829, 1.2432734050491878, 1.7422700075790867, 2.2619520263787867, 2.070195132455606, 0.6070090434628762, 1.5512584618730325, 0.3780945665433675, -0.278712216210449, -0.4061503908369095, 2.0668534380375077, 1.4282157266438955},
    {0.45338482783547746, 2.6884685363819707, 2.670090849613404, 1.8145148755691574, 2.8049190072569807, 2.7026227147057833, 1.2791008287121064, 2.3007177179503606, 1.6819506721962647, -1.1180231005036139, 1.8483875825764609, 1.1011486206892165, 2.071089515701303, 0.9367766774171896, -0.5815903966551553, 2.3636567829145223, 2.2796808122005587, 0.861470358464328, 2.7730333933746127, 1.4248944806652157, 1.979550927587184, 2.02131986118342, 2.0819888316797526, 4.2353272674510025, 1.4266333754189637, 1.7418870614981568, 2.262170395718512, 1.9511457305270012, 0.4663791820078265, -1.1794035178656979, 2.779075247903733, 2.684829027460487},
    {-2.5515799370777232, -0.9481843269155444, -1.525597152675451, -1.7588403320278356, -2.213865125021647, -0.7085640105862412, -2.6341975320631885, -2.7494820162145976, -0.3772922228763756, -3.2031088204961344, -2.5558074087394593, -2.338172714877656, -2.5736834015871843, -1.1680979076614273, -3.4558024764640503, -2.931435485090101, -2.6385945354901863, -2.7385204978836972, -2.592378705031297, -1.6718666649723528, -2.325861417495178, -2.7285699229375013, -1.98211882922807, 1.031987504981746, -2.566755834947697, -3.2887885479630814, -2.218382251218841, -1.387797629997558, 2.2404563733065412, -3.7201073146484167, -3.3575306008382673, -0.5128036926242628},
    {-2.4696509303722443, 1.2943958453768833, 1.0011834274887579, -0.360423884902928, 0.47777378373046797, 1.4619256904980724, -1.253419034057518, 0.8337433172815856, 2.60057844156928, 0.8535504426089395, 0.5699009126325665, 1.6254730966189388, 0.053079192313613945, 1.2488229266719388, -0.5782586941549489, 0.5772896549968918, -0.02334523185111483, -0.8644458994292329, 0.3475672914149919, 1.1484237620362139, 0.9951179555146493, 0.2736843766390243, -0.12697964711078136, 2.1002444438099017, 0.48150960011257005, -0.4608650761749698, 0.7406049668471807, 1.0229998875544495, 1.9854472759734798, 0.2723917269332617, 0.3374992082552059, 1.4073206306905721},
    {-0.03731517965830995, -1.272891350968891, 0.348715600528995, -1.131791553448209, -0.6788893022818878, 0.15250349237800245, -0.3535336510626609, 1.3672919452928614, -0.3897334023358749, -1.7379653150594392, -1.402479050355988, -1.3885487163595027, 1.1963725150033637, -0.7466052955339225, 0.7902699525277412, -1.2707301049687587, 0.030945986522837768, -1.6534879275152325, -1.5215995402195852, -1.1483226708380165, -1.3597195956928017, -0.04568139598378705, -1.7263661546046165, 1.073715562037582, -0.8282234901187157, 1.0800333238102497, -1.7527882617969148, 0.8465596730630491, 2.4619278778565294, -2.595141424521894, -1.3540360935609883, 0.6781611692148021},
    {2.4515287740576013, 2.2666613903439625, -0.6695212455486468, 3.025794438207984, 0.9985097651310342, 0.29907936998674917, 2.0771449742056967, -1.5439229868035729, -0.6343570872408618, -1.04058394056512, 0.4520907001514287, -0.5716282987412646, -1.4228510773175362, 2.099106211301071, -2.452108104409982, -0.1243934845481777, 2.0453677415688656, 2.3887379995279274, 0.19106431676533875, -0.5392037888797498, 0.4229997829539467, -0.5521615179177684, 3.1496843767145695, 2.6767848619801073, -1.1503435977211338, -2.2062622205550224, -0.318531650392886, -0.6994360154047025, -2.9438367286063714, -1.651251647903899, 0.458588022657406, 2.949988661305915},
    {-1.7872165416422647, -0.307644886678704, 3.928461723721647, -1.3756619742330716, 2.343343540812148, 2.265580765965402, -2.4407476598508384, 4.408334204255264, 3.75603276315239, 4.735009387310718, 2.193390260018262, 2.9197580403906516, 4.124258042569241, 1.0160756779823208, 4.318119451208136, 1.8110093619679868, 0.10389813203488174, -1.762405620778313, 1.0337690252764253, 4.399428446636087, 2.9722941587235177, 3.3398520894025605, -3.063219047425649, 0.5672653026594037, 3.8470322197685958, 4.223390467083344, -0.6615011689533286, 3.825882405272837, 3.2397627049212474, 3.6013156673305424, 1.4929020088455733, 0.880739699502646},
    {0.8922637042998537, 0.3119598319281145, 3.81622835338666, -0.4018230770313226, 4.5864119845170075, 1.0478316429139334, -0.18293594776816824, 4.2466180417000166, 3.628424639247693, 6.28766772216851, 4.216378848665433, 3.7301496376396375, 3.9794542087056555, 1.5271701213065565, 4.961969148682622, 3.5619761421048266, 1.9932650724665542, -0.06588856992314167, 2.4441887494460275, 4.465611175751998, 4.360514736239528, 3.2918131139520237, -2.6908720848665086, -0.25867916444765704, 5.1907619811672285, 4.422274501841259, -0.3307339476467083, 3.4816356989031876, 0.2541265301422658, 5.586264463399084, 4.121355517242886, 0.28762568137602995},
    {1.6539656226752892, 0.7117674781736504, 0.8188175192851641, 0.984059151844285, 2.2454760125948425, 0.7987728767239574, 0.8827463980351773, 0.9532989904503307, 1.6018039791371386, 2.9607505171614297, 2.126821354238454, 1.3246265621153532, -0.13411571077701606, 1.7844735620532712, 1.6516300357304876, 1.155279653251946, 1.4894979368825172, 0.435353043214629, 0.7109273883293954, 1.4465469488376448, 2.533664528246389, -0.33508100519264267, -1.5481171439863224, 1.3152144525796416, 1.189089075137193, -0.7439230493750666, -0.9178860521531684, 1.1155959304935639, -2.284604356960653, 1.3107883753259626, 1.6111952181977067, 1.4552517753603211},
    {-2.5110475135564556, 0.249692024378125, 4.271751937065155, -1.1708361370477283, 3.8454713788393784, 1.8507873866942175, -2.557200865323887, 4.786105904461955, 3.498091745753648, 5.52693419985746, 3.556667708709017, 3.8136623055197534, 5.238053981970493, 1.6403363473498545, 4.438183152004571, 2.8993989408891165, 1.8448709922295292, -1.1143363340114436, 1.998615263600339, 5.29831905047341, 3.994938227109899, 4.332242656390352, -3.822676632935024, 0.5897846321532133, 5.76099182111866, 5.381218297969407, 0.9468058277040684, 4.165337857221416, 2.2994159549690614, 5.2429930426682, 3.0537747356817664, 0.789882305915266},
    {-0.613591699455822, 1.229141425942765, 4.111596162008493, 0.1964063960841139, 3.05526428071212, 1.5652762768414612, -0.38299334445927075, 4.442310068721167, 3.199404004114929, 4.871885229196445, 3.2376283020183454, 3.4925624671689723, 3.777308628808518, 2.4448344597103735, 3.8291288886410966, 2.417232098779179, 1.602185233043009, -0.6178814424979526, 1.6378630679391888, 4.599547995675888, 3.580779850317803, 3.4253238835774087, -2.375071461844495, 1.2555821429777598, 4.449294578827725, 4.134915447648675, 1.350876220529641, 3.540815563697104, 1.719101465943061, 3.9637855273137794, 2.9879951891729206, 1.9124628820238712},
    {1.3295983381546896, -0.7630925487724189, 1.7331436898305037, -0.36789457862193936, 1.5202798287925205, -0.3607667785685356, 0.33585696468715265, 2.4204756933745935, -1.4520494005173106, 2.69852803317403, 0.659442448134615, 0.5931223817464534, 2.807014205019995, 0.23569906818214886, 2.2436244195420767, 0.9330225252601332, 1.4343800865371117, -0.2229494762863076, 0.746917525433266, 1.7254427427423318, 0.6145073440772151, 1.241114052519755, -0.8991962125499434, -0.8877157371055616, 2.1205845085712154, 2.2634828729045986, -0.2511854515721055, 0.2539203994343984, -1.4763137013024263, 2.1066614616248875, 1.1485586238409526, -1.2310612096952431},
    {-1.5444604344207806, -0.5951447624279944, -0.26559698531337983, -1.1136926679418366, -1.0507947549513357, -1.081115613630972, -1.8012986204105155, 0.4035013072149481, -0.40064922819642385, 2.952633531538195, -0.4441672174676802, -0.3118311008914993, 1.5657708529477357, -0.16049423799052828, 0.8153390524216015, -0.9890732024356751, -0.941557446276451, -0.6331364962310595, -1.5494328368173176, 0.7942812489845592, -0.0640494561066123, 0.021233741412731832, -1.1686579393800691, -0.9800227522220862, -0.20339865522520198, 1.0273102032117543, -0.7481745080382386, 0.6414736502863156, 1.9160586169527982, 0.3499894260045357, -1.5635041230078746, -0.43525032708341505},
    {-0.39148812218480694, -1.0083909632458516, 0.761791702997057, -1.3891178773957016, 0.6378986780942361, -1.428228875333233, -0.14218294873684661, 2.4375861264763383, -0.9961781596563073, 4.431393474463188, 0.6018646095039456, 0.920008938748522, 2.1819889648147663, -0.9500184467076671, 2.7472535126305426, 0.20088677509557637, -0.22899074547464324, -0.9039858322037785, -0.4410009327651549, 2.2225825430565993, 1.1316516112090114, 1.5069930417238162, -1.3110179117843064, -2.4471869230658543, 2.2902157514179327, 2.0135862874847743, -0.7149554267614318, 0.9023961052985703, 0.972142991492809, 2.663581174710444, 0.42568343740676945, -1.7936690871508632},
    {-3.9816925013658055, -2.3908890902638076, -0.7271790436887822, -3.2743562841557496, -0.6524103430815356, -0.6095215695747493, -3.4061232093566476, 1.4300224424269818, 0.5841882786040868, 4.420028736086227, 0.32750191336627876, 1.02184491909949, 1.3123394043424312, -1.1613401336320475, 2.3160238082051223, -0.2839823163589929, -2.5855392237454047, -3.216404939664699, -0.7716433010489047, 1.834007448954242, 0.7568528751995933, 0.6731294683534176, -3.797604365966916, -2.3939894886551523, 2.305812785015848, 1.2953562975855768, -1.3785473957139305, 1.368498446651733, 1.936770339165377, 3.042908997284734, -1.6591213993344551, -2.127624201760243},
    {-1.1682120955397068, -1.7083454255512407, -0.8476846795135108, -1.3148495929828687, -0.864943476197003, -1.989744518116007, 0.20479986250637575, 1.0919194512169896, -2.7385387297807893, 2.368763131033733, -1.6047651810852945, -0.4987177091976574, 0.7563361508197071, -1.7334225613828753, 2.1004518963208754, -1.4086727263641543, -1.0326542533226093, -0.8461391437125397, -2.0017565321309534, 0.4105149323816315, -0.9464026260768045, 0.49870588332275256, -1.3449770977581423, -3.775804323163929, 0.4680466373719847, 0.9672903498364288, -1.9591257027791382, 0.19844331712105626, -0.45076203554934313, 0.8259905973633187, -0.7313621481903568, -2.5207776647897724},
    {-4.327152464911162, -3.115886448190098, -3.5721849640026733, -2.752704624226587, -3.644942063778277, -1.995968071362897, -2.4822454450829037, -2.300420346149849, -4.080215215322729, -1.6339259170045397, -2.9226565914430025, -2.3260960852773342, -1.9742999779855823, -2.701311640337103, -1.4395582164117302, -2.580345386223053, -3.227769443022106, -2.7028700852778678, -3.1927040977465415, -2.084570687324852, -2.886429522856661, -2.1624931155214853, -2.407932196039458, -4.075533583833386, -2.2060412785286894, -2.7555691685725003, -1.9987814216376336, -1.9676750412835786, 1.1583368236808833, -2.182987044095595, -3.654856465722869, -3.43569141379979},
    {-2.0682652188828525, -1.733014098210035, 1.6253950747327022, -1.3796460682400629, -0.9770960441738085, 0.6565626938487292, -1.8930982148591264, 2.4259393938359053, 0.751390614566889, 3.628487937839322, -0.7197622085222444, 0.5689506877584546, 2.9805092757662273, -0.29273774741998, 4.065287898126261, -0.19374622343134001, -1.8332208127311265, -1.8411884686819047, -0.20861439139868382, 2.149382533328258, -0.28011924740898314, 2.0414855736516113, -1.3997423715055797, -1.1122541990293064, 2.052126269539989, 3.5050142276280067, -0.18070806012529472, 1.544077805900631, 5.113998727106596, 2.955366779284303, -1.2546162932155607, -1.3012291212265379},
    {-2.0898697098544115, -3.2101130598201206, -2.341306231803937, -2.5823235836156946, -4.152804274842984, -3.0229363509145806, -1.759528900255217, -1.403133983379106, -3.7626835554648403, -1.4868444616597005, -3.9666656739159776, -3.6514799818934986, -1.6146589396397564, -3.2145408753135363, 0.08932060280893672, -3.432235034593055, -3.4732193836994765, -2.2719189495047183, -3.8150431493189294, -2.8038668622233853, -3.87407646337354, -2.215572688263989, -1.693897703204168, -3.7911497824064413, -3.2553436034432237, -0.5232642431754676, -2.6900936659418164, -3.0337535569567766, 2.9773374491783002, -2.368948030102745, -3.566293819836921, -3.771410752628816},
    {-4.930691354884596, -5.393469476911863, -4.332235464806345, -5.191770769502544, -4.558294728392698, -4.084870707700905, -4.751191292415145, -2.985989736445378, -4.316228171069592, -0.6862205617508601, -4.000503832854986, -3.698823682974796, -2.8820958054687393, -5.008722140883208, -1.3760873713043216, -3.924531133644849, -5.096535530919854, -5.365742070440292, -4.5603961783503655, -2.8181730633339286, -4.008554861178357, -3.891928229513868, -5.500694987722236, -5.709583615525767, -3.2962496251543962, -2.737905323338825, -4.277585804157849, -3.569811674306536, 1.4122435989059685, -2.293137631202121, -5.073268546426202, -5.317065021333045},
    {0.30421678475629016, 0.011968897089133035, -1.6060329043060761, 1.3244808094681382, -1.7115913755800223, -0.12930300393657984, 1.5521698310773668, -0.624480882232825, -2.312128996034153, 0.15208382238082524, -1.38838977432709, -1.431466809022973, -0.5021860752070231, -0.11749445430064011, 0.3057373425251182, -1.1964665312308593, 0.5492314523801407, 1.4967683347773408, -0.07489338121877778, -1.112670095726728, -1.569898849800966, -0.1501466774835505, 2.5791105097908127, -0.7835584426755535, -1.1268867828661844, 0.12894448770938888, 1.1241939116885518, -1.500234876720032, -0.29106530563987604, -0.48680051732818114, 0.24041017206649096, -0.8386927053134705},
    {-4.3170121114536135, -3.096383853257313, 0.13672215718149636, -3.707552195309963, -1.5078683506302875, -0.8358619933847002, -4.229947323877394, 2.143977498687899, -1.2114461641625986, 1.6982138008919243, -1.1787541968441715, -0.3384168820602673, 1.9436813497936816, -2.3506906483924523, 1.9058135292506213, -0.9917292150483816, -3.128727555669013, -3.4252474232402066, -2.2577358232787796, 0.6425663202356422, -0.253646699066403, 0.7354664808494409, -4.468689430587118, -3.3609784072396294, 0.7701199773108861, 2.064834478566029, -1.4841890515799452, 0.14913420912194938, 3.09363861089872, 0.6712066461751044, -2.200232652560212, -2.8548358627870143},
    {-2.737850265243765, -0.7794723869942262, 0.9352936398467937, -2.236352580738969, 0.5316411695125515, 0.6563382369068972, -0.9995905589963843, 1.8053482170420052, 0.2583678242106774, 1.9298766214770762, 0.493620501666878, 1.1896600132503, 1.6916753964035796, -0.3925212760705232, 1.0241464993038965, 0.9868906148349755, 0.08225291706056936, -1.5268808956274753, 0.4680593845958591, 1.3434311518586135, 0.5917900200120623, 1.2513097848027157, -1.8050314287357982, -1.0862361878749673, 2.073453709980117, 1.599882845209257, 0.526598390457571, 1.2534481621543676, 1.4545370724580307, 1.9689017887324043, 0.6075041927718802, -1.5444985823403852},
    {0.477571157428921, -4.477404899236317, -3.3564138214408668, -5.6475576079619465, -3.5475020305638463, -6.199484794039943, -5.366429331971005, -4.5538665011113215, 0.717361818865601, 1.6774190153860367, -5.017408543298029, -4.991994161107205, -4.422126769903009, -3.9369565438168226, 1.8120357688840145, -5.2704568022987655, -5.364637782741049, -5.332072724204585, -5.1645445650886765, -4.148022440067471, -4.90289160443684, -3.9194258686271866, -5.204627169421463, -4.3678688623738715, -3.6113700562723543, -1.0955305913995503, -4.975897069085166, -5.312448890649697, 2.066803808575211, 1.441766659571089, -3.260767064753376, -6.0045011344964365},
    {0.2415655860494304, -4.255970007308866, -2.3759372145746926, -5.297967805013464, -3.0309122255732945, -5.211280322441383, -4.488976330668327, -2.7462224160409248, 1.01355115676129, 0.39297042745356225, -4.389512465413449, -4.53688529521396, -2.812301300122312, -4.3576034356420426, 2.347508818352082, -4.293860744689232, -4.889379016310169, -4.77461606948732, -4.585407784292575, -3.937645613570752, -4.23679494928807, -3.252912847862835, -4.489379072001605, -2.661488797892889, -3.778026439168277, -0.24547566085433375, -4.888879957398855, -4.468943488607434, 3.0622586421158204, -0.23406652566396038, -3.0598071101134874, -4.700935983089656},
    {2.9583731438953444, -0.3523118832544593, 0.6849949445765253, -1.230819325777445, -0.06096494577458, -3.7972514760557528, -0.9067780559156862, -1.2882366373471617, 2.0376070026637696, 1.3905090808475407, -2.977727184020758, -2.9877582539675647, -2.5804602848922067, 0.19959859188685067, 2.274791111774584, -2.2756713861256, -2.7056381991653686, -1.0682962823682307, -1.5420541485841857, -2.108950059648773, -2.7024527765265685, -1.3570366517566148, -1.3552886680241136, 0.3855672932083134, -1.411423107651907, 0.09252391843195647, -3.59726029948189, -3.63594030077534, 3.1342059552436328, 1.6480464395722505, -1.0547912520631009, -1.6838308934824404},
    {3.439560330469876, -1.4218415467562908, 0.5181957399331855, -1.8654676550337288, -1.0756630602723942, -3.9268795421511724, -1.4544503979782795, -1.9755248985280864, 1.8217887197023468, -0.31613900482258844, -2.436168773086008, -3.2992884339994193, -3.2726839215968697, -0.5174775669644258, 2.2934144586505734, -2.7516459053473556, -2.106135126895216, -1.777973405151865, -2.0903917149037246, -3.0159440497067904, -2.889865471884504, -1.2253429489851635, -1.288954335112059, 0.2844486445155234, -2.080683456358917, -0.582193069544992, -2.766319136182215, -3.7218713245381365, 1.97343686813586, 0.47972149251374047, -2.0080625113704094, -2.2421136755243785},
    {1.9375848375907292, -1.2610117915488783, -1.6122211605282324, -1.3869318769132375, -0.8968459915757042, -2.3059167745519265, -0.7198601451415727, -1.2469326625900015, 1.6220284181613327, 0.2662759692478558, -1.9299570169579003, -2.2327026053190857, -1.8908878487839402, -0.8504038564257976, 2.693746565038006, -2.2227937379930243, -0.8700226398955925, -0.6226881554708874, -1.9710445954868754, -1.7453727528995218, -2.5050929176986996, -1.766537854312052, -0.5379156341823742, 0.17004263962365282, -0.6846228440729892, -1.2285669497093745, -1.64051451557708, -3.466565331991352, 2.4475296266017703, 1.424885211044266, 0.022607989480923848, -2.1706229892269984},
    {1.4236839391653577, -0.17421878812367828, 0.834053865900352, -1.641166052500732, -1.4093251278350514, -2.7041488563053537, -2.468986974275858, -0.16385573131731437, 1.135743815451836, -0.38214003892159126, -1.2641744464695825, -1.1638464788540817, -1.081046394599128, -0.4429881704033779, 1.998666287851548, -2.090491792904824, -1.5783778077636272, -1.1721715376479949, -2.7236897385422236, -1.2935396684635512, -1.803436715452721, -1.6618601661709316, -1.4695254267596547, 0.3142299981268037, -1.0141473015686933, -0.03666538653758083, -1.8219548329573327, -1.6047891618552936, 3.226972237775953, 0.22872103091706295, -0.36065215784033866, -1.6148392486532541},
    {3.2801674521425213, -0.6084901745244425, 0.29140796021472753, -0.5635635153622166, 0.7920709868820001, -2.7769800180385817, -0.7376706371330054, -0.33470216907146205, 0.5110347161147658, -0.49241856829657704, -1.5080555839086665, -2.0864102060078706, -1.3963041879899025, -1.216936830879994, 1.6345962090551087, -1.603225886317844, -0.8110690891111738, 0.2561259993972196, -1.2644362448523603, -0.8752720435249391, -1.5273022088611365, -0.9837327709417619, -1.0004748613185879, -0.2935608816054553, -1.1323857733699239, -0.05511458592381029, -1.5663448173799963, -2.4495551140746845, 1.5879205831460361, 0.6242287759093749, 0.32328313261487696, -0.9348866039790689},
    {1.0609859703137852, -1.038495412534754, 0.6474795757657497, -1.9542780300417095, 1.0424727902840019, -1.559396306923914, -0.5919647603213064, 1.2062379464992237, 1.7970962685930192, 1.100552340685708, 0.6253298112039467, 0.35299767191604575, -0.6439455727062915, 1.2422542972927182, 1.7015507546556217, 0.1724509738109849, -0.8174873799381652, -0.5293821089839037, 0.41679930405534915, 0.15252879342823694, 0.26998514149257014, 0.8381827938426161, -0.6036060176632151, -0.19673131397992744, 1.040481849596472, 1.1181925747800798, -1.1338077906821533, -1.2087067778359015, 1.0526240418415866, 1.4574359920343123, 0.007148467929210062, -2.0037414508833815},
    {-0.7324773879353734, -1.6704679179173827, -0.6247072041297059, -2.3832031396373834, -0.6256496502276014, -1.8842056283825384, -0.9743897362168963, 0.559925692820703, 0.5302213230452971, 0.69225033840504, -1.0564059317723007, -1.2583259308587667, -0.740059456243699, -1.7370903950254224, 1.4176656739438345, -1.4553899945546038, -1.0118298775270869, -2.1355458937213734, -0.9825036641857714, -1.8477546941887601, -1.1958618698099979, -1.1088098988861554, -2.313988205629, -0.7062899388320455, 0.44164338858990604, 0.9816429987993991, -2.2030165276235, -1.050284036115755, 1.15889534655462, 0.3606047178514348, -0.19923170293735784, -2.106995874011025},
    {0.5683895050640322, -0.09045212528494387, 0.30789477678538096, -1.535409525418504, 0.2760177261301856, -1.2681164452370555, -2.586411710277976, 0.29421655400438296, -0.13182938118530366, -0.23366207302401298, -1.5321038054398965, -1.431577263426162, -1.1407598124182086, -1.8188093494278577, 0.1035680738228842, -1.0969732298464143, -1.2251024759937104, -1.365925613167919, -1.107380203030407, -0.7823923838945257, -0.9623591192092343, -1.676650790848516, -1.393693122663267, 0.8678308278678268, -0.1474112407485646, -1.034649134715681, -2.0870145262659734, -1.2776273304119092, 1.3489682569806554, -1.31492903519593, -0.7327089526452436, -1.019393039981773},
    {-0.09016204034829575, -1.4886657162503878, 0.14236182622685073, -1.3305956662260134, -0.6243299728979824, -0.16564593487409823, 0.09495063224202445, -0.11070846338166213, 0.64451479057257, -0.828223258861976, -1.2915782656702743, -1.074677164348593, -0.2034975565629982, -1.5170839950878083, 0.684034274412473, -1.138489356048751, -0.8592522817517676, -1.068406157834894, -0.8397888441033139, -0.47089132635891595, -1.0004987925572508, -1.1608554033179785, -0.9304862019653426, 0.47165434006439555, -0.6422744408461458, -1.2608736770920332, -1.706457534688819, -0.6635230550766501, 2.209550141466595, -1.5980503143441402, -1.0417451617991287, 0.5185458035758296},
    {2.2925196766232134, 1.1461885847161188, 0.38976081977249744, 0.863038472597896, 0.5955692576075801, 0.1154602989496194, 0.10920231107598834, 0.7788186565743631, 0.5906820503858353, -0.21204565684745408, -1.3022642721718862, -0.8973361582574118, -0.9120200004272394, -0.14587861000080013, 0.5390669053860182, -0.7769256522159734, -0.05394354458418505, 1.0001030895032685, -0.45921785102277424, -0.3492541753581029, -0.9015965697795821, -1.0040452809615517, 1.7992693972372553, -0.11537406108497435, -0.8020713978930015, -0.6858258538839724, -0.6794699312865201, -0.686024687484266, 0.3289812728485093, -0.5957345985171878, -0.9474424049502524, -0.4113878803588952},
    {-0.7614387183145579, 0.09641518615555583, 1.078865029559176, -0.8748486811547465, 0.5751120466135616, 0.34135823075861776, -1.531517555847756, 1.2997453106875079, 1.859110662290876, 0.44196267839408304, 0.717548764604219, 0.6864947302547111, 0.9788230460097531, -0.05602980913556509, 1.2859882928832558, 1.3016732119135532, -1.7720658778434413, -0.9120672511100678, 0.4213322012905217, 0.1577666546098411, 0.36415527513613377, 0.603085558487606, -1.263972191391873, 1.054696310523679, 1.0150249312107829, 1.4429005158997223, -1.1846946403489493, 1.150199173185623, 1.8734305985886897, -0.44677229131578255, -0.4413933766574545, -1.034716714639574},
    {1.3159395790571675, -2.0739757140503694, 0.11913681727543524, -1.8774404375946085, -0.15207490697391104, -0.33420632404971223, -1.2849749020262995, -0.508484822478731, 0.038428528999438896, 0.20717568594203364, -0.6404823469320147, -1.7469810861999115, -1.1612522643970278, -2.86494244688562, 0.858854847976088, -1.181449036420684, -0.928965611030277, -0.6942761938377632, -1.226307666109543, -1.3910851119570395, -1.2620981540500062, -1.5394422674741006, -0.4974039096543465, -0.43444931412394205, -0.4540116478869653, -1.422250974784848, -1.516758401479967, -2.0039081882965633, -1.1561561705368926, 0.3929625665411079, -0.8971117468445606, -1.633150255390016},
    {0.5557599510214772, 0.11004045482658537, 0.3560540223074458, 0.5587957026720439, 1.0169242039251318, 0.04616946330852897, 0.03151880420404034, 1.2541817895669969, 0.6105877220711969, -0.2854103111252038, -1.01168467353481, -1.1182927192101484, 0.2526582183318087, 0.8467019902367615, -0.6137509078128839, -0.06642957448203554, -0.7496068342192778, 1.6429963701994017, -0.13908171211000883, 0.10307919605611546, -0.9093954203152036, 0.6435138547958242, 1.2569075642455625, -0.5827057410872272, 0.28018815867864455, 1.0421101799170787, -0.5169169730449056, -0.0005167565033267799, 1.4118167128084547, 0.0063767476948701, -0.3554264733054103, 0.6872512258855333},
    {-2.0612110577798757, -1.3686391990446736, 0.5051603692296769, -1.8660157161412203, -0.3868584366844831, -0.20745445704516446, -1.981171200641423, 0.029533527413129968, 0.5230753476299186, -0.5983347712849401, -1.815149827633863, -1.140079788699033, 0.22597605946129232, -0.2400828950838064, 0.9792246542280357, -1.5752738117432856, -1.001968091241449, -2.372672393760135, -0.479152470758415, -0.829131666057482, -1.1891530153060599, 0.20053214986042614, -1.8262193820427106, -0.4245439668035614, -0.11460939953035743, -0.13591476477395595, -1.494214159240504, -1.0543436895089335, 1.5498050710165079, -1.3220138084507893, -1.1665325257552603, -1.9650245267293491},
    {-0.2602739773727243, -1.6084855166406868, 0.5231173023325572, -1.5422616908723281, -1.1767396640794643, 0.5362867317429748, 0.010586500622791165, 0.005420441274103904, -1.1669292819276633, -0.7612466811242113, -0.23744845934031014, -0.5366077199341742, -0.12204539533622963, -0.8275949613353041, 0.48553434749671365, -0.6479785194699749, -0.6567793971929313, 0.45559630404168827, 0.012741610941577396, -1.028513794315138, -0.07840773353412116, -0.600137651868304, -0.33921214166594404, -0.888242539532437, -0.010298617343733614, -0.8803439527874988, -1.3979456639664176, -0.10859564379864615, -0.9915988936208032, -1.0693287925371082, -0.5311274976929131, -1.3325021749015762},
    {-0.2739388470053336, 0.19158100037451387, -0.5812866024998621, -0.6043158663502437, 0.07666923779040408, -0.117558755202586, -0.9085632421475233, 0.18626213304244713, -0.8083618062124954, -0.2972925350811711, -1.2486457233327575, -1.1326024525000102, -0.3966665058543483, 0.48289372100682915, -0.9195589351954818, -1.0551268382989343, 0.17440368609719212, -0.14959406451399554, -0.10965646503884906, -0.49351805890953987, -0.9583479755288414, -1.0560721619257345, 0.588111100353048, -0.7859052790998772, 0.14434756420262862, -0.37058520259416305, -0.9347224742675881, -0.18799813039222626, 0.9766366653924444, -1.1104583340956269, -0.9706647825171912, -0.15433863423758692},
    {0.6498859662523335, 1.6790891689210332, 1.6317456461402662, 0.03475512128379692, 1.3514309876532367, 0.7352846132252274, 1.088254205620672, 0.21633924999477253, 1.2249392357230988, -0.7181310096627649, 0.17849937761296947, -0.14549521476592694, 0.22684652892418458, 0.607458207136882, -0.7360021117155425, 0.30498033845238376, -0.3981375021684214, 0.919406188633916, 0.3446919847215985, -0.41088498972504406, -0.1989680556614253, 0.15349613717533472, 1.5319462680423352, 1.719623711233215, 0.34220593333737803, -0.009961504187278498, -0.5052639460178895, -0.269652347566013, 0.38988778344716324, -1.1848192229476207, -0.9148462647966293, 0.6917780994906502},
    {0.6763469285317592, -0.34720913614521154, 0.5779253879766756, -0.5642983820553245, -0.5155238633412632, -0.029363942144746958, -0.849333478224168, 0.7876072098609416, -0.4689099135884922, -0.9903417199570603, -0.23807776726193322, 0.10811953933824044, 0.5919521399752228, -0.7922151646462612, -0.9239067497678664, -0.47651694934101596, -0.5789860438489545, -0.03498089834551861, -0.33520203035518975, -0.13934676329294535, 0.2356664857403898, 0.7164032361547474, 0.003650056438933449, 0.9073719852641879, -0.4786631279186595, 0.06889383221172742, -0.8047100399965247, 0.7310157376156923, 1.0465999370911436, -1.4382733525580267, -0.5197696795327845, 0.03985716570875449},
    {0.7271626418868101, 0.20610620840906044, 1.6735167160547026, 1.6401271023531634, 0.3379108442763433, 0.5920026127970186, 1.3724397789610971, 1.0482135134378645, 1.0431530316263218, -0.7306419584457292, -0.16622527400380924, 0.42982934770546627, 0.8099804661829529, 1.8606379786260983, 0.35538608008012273, -0.18898863993830925, 0.8680887132031199, 1.4516573126218284, 0.9171592287843652, -0.6530471917947822, 0.8402536971230744, 1.396640553188343, 1.7151071096693842, 2.1534318909215835, 0.8488345557697303, 0.5885593729505926, 0.043482146426528416, 0.6031439557363555, 1.033515508194772, -1.9071405861653248, 1.2780816458572533, 1.4717492225211362},
    {0.026789848910467793, -0.8875566711284774, 1.2069976745431825, 0.6735727643964969, 0.30070876876236124, -0.12359660629264053, 1.2469221733732911, 0.8143457342196734, 1.8223171062477312, -1.274687830860439, -0.5878842800106377, 0.2947983144246001, 1.227731497637336, 0.15961110483568142, -1.0020701032266834, 0.25535316146995957, 0.3802572518418655, -0.04589503559514712, -0.2567153030915822, -1.0287643085452944, -0.430140311312167, 0.926546918849032, 0.3863570065638471, 1.0940375107968627, 0.2270494848736024, 1.9531054986809104, -0.33428804342677815, 0.35856149896301065, 1.0338004287883382, -0.8601889690879148, 0.9868059456017089, 1.3253500358448393},
    {1.0446799903131532, 1.399053545707872, -0.03715374107934399, 0.8671130544478916, 1.169176804872452, -0.38631341956963644, -0.21608018164035558, 0.5007091841093207, 2.455958541354064, -0.2415404811681847, -0.36508149170251936, -0.5308409779687153, -0.25473501228276746, 0.19476375418223607, 1.053286234929315, 0.8864770400133001, 0.6756467683771052, 1.2875333006681258, -0.3270438004548547, 0.252866707469249, 0.05044474951396911, 0.18484120459570952, 0.5037500518784044, 0.6438727060270992, -0.3035230030863758, -0.3789249748088432, -0.28185084036707886, 0.5117478020139729, 0.7034403293381277, 0.07340624148460004, 0.7193659652414721, 1.2720282781431451},
    {-1.7943777080662284, -1.501363576575391, -0.8112600252805274, -0.7711603370388721, -0.2440992467062755, -1.2508983492539973, -1.4332760062233112, -0.22883691159867622, -0.045673909588466205, -1.265551580259873, -1.5378457252126307, -1.7865043593174075, 0.17152326510862628, -0.9443600644056868, -0.8730665553179955, -0.8665178782695726, -0.7277235663003657, -1.84491666276087, -1.3373638765544753, 0.4329240022476383, -1.6660303187919892, -0.7643410414270148, -1.1675977844450216, -0.34559741199386845, -0.8338440906381998, -0.7500590932282408, -1.4035917925770323, -1.3547304138653522, 0.8624284852805377, -0.6432558464944016, -0.9449503993741649, -1.177484431614012},
    {-2.075581970536038, -0.4062812782631057, 0.823122051007988, -0.3740673994520806, 1.08648097958827, 0.42296293673267377, 0.18998459717203076, 1.395339477282978, 1.4220116244273373, 0.009286047468082525, -0.566429248291369, -0.4770577014365587, 0.5553911693942981, 0.3940861351724778, 0.11670631531948869, 0.5156173096113698, 0.10125637828273074, -0.38942853328735166, 0.32978388394822045, 0.810293056483234, -0.16812779082643015, -1.0715671699276355, -0.9435333327691539, -0.18589311685215815, 0.3245523351354594, 1.6277080847648813, -0.7033372606644693, -0.08386529642909704, -0.2964161078482653, -1.0338726598143768, 0.153911049312947, -0.08993234446678981},
    {-1.1026131292604595, 0.3996468000950125, 0.5053888973944726, -0.8585964856474194, -0.8793907352733417, 0.34065052605829094, -1.2328869305167642, 1.0493101978692105, 0.7864012589334318, -1.0199762685830152, 0.5341028675556387, -0.4183748766445903, 0.5768733834060885, -0.7479734608972756, -0.5915931107737528, 0.14047538056795927, -0.1179837410102976, -0.10528647816930976, 0.29809385363311763, -0.030801369020911577, 0.49246443300042564, 1.3447621337810758, 0.13711058357645775, -0.22067941500655297, 0.01204125108973951, 0.31984827194977594, 1.1988117014628359, 0.015448719700110298, 0.47123597002506945, -0.6845127306900394, 0.30259503176037406, -0.790783348781577},
    {-0.8214512858231594, -0.10765305858669272, 0.12570032682849613, -2.1157502961055137, 0.06509113383098691, -0.9764735091948334, -1.8279587020498582, -0.06488466708669988, 0.17265573454806013, -0.39445532157852586, -0.9657847211064378, -0.06386190098471717, 0.16405780932226532, -1.379650646471922, -0.3122656175578176, -0.9344878498831142, -1.7046176858510023, -0.8751239427374811, -1.730818387871885, -0.49114484343982145, -0.8453247972265169, 0.5753674790327367, -1.6906440698037941, -0.43347066384623145, 0.057596437440487036, 0.46739196739218464, -1.091671325542298, -0.23346802887571003, 0.1655505386432132, -1.685541806722219, -2.2922181867268407, -1.619519083387651},
    {-1.760274882635266, 0.5244524955494488, 0.6432916749786449, 1.904981255421463, 0.1068918160705108, 1.8549511914949721, 1.1935790953274106, 0.7884770412480461, -0.3207729890840565, 0.6269303741127683, 0.6620374349179327, 0.7611072376635128, 1.6325398522616517, -0.4849520292926786, 1.4231239217395895, 0.24954167632491037, 1.846879772590357, -0.7423269469078326, 0.021120624287815408, 1.3489414410071847, 1.066416401493439, -0.02954716339144651, -0.46158669859470525, -0.2180106888557945, 0.602633065638502, 0.019821855165427907, 0.5027936798724411, 1.9313211130734944, 1.2262917569963394, -0.29560600680441956, 0.533715994273565, 0.4262966125129285},
    {-0.41808788171694616, 0.10064120817297417, 2.161961255888377, 0.6236683445180089, 1.0819417397128233, 0.17860171143079243, -0.36988802079604327, 1.1761576851256956, 1.4189740647338402, 0.6890193234620152, 0.7178460416360538, 0.3227318051897321, 1.9884123581369684, 0.6899568064583762, 0.6589533754439282, 0.6463344485612434, 0.17287779899866973, -0.5056559123595222, 1.3137705300069231, 1.4062873789448567, 0.4431112328034914, 0.8878128112680485, -1.8214828795437412, 1.457384540557286, 1.0800499783983948, 2.067052967303046, 0.038174969234099965, 1.4611200713599863, 2.308324434036967, -0.0015626987175550913, 0.6145966916327696, 0.016609879966727675},
    {-0.9245438375116213, -0.4356798233506919, 1.150463094720911, -0.656943797058228, 1.4693384515467796, 0.26507786755541524, -0.9263374348144744, 1.5555080512927244, -0.7883884628483037, 0.3635926252898962, 0.8039489355635007, 0.09208068368101509, 1.3989668611936539, -0.04014095450189271, 1.056955336965557, 0.7132063038922037, 0.3051896557544497, -0.5202512268540133, 0.6057112010594444, 1.2548087224121642, 0.29981188106205947, 0.2672747994879908, -1.3345069004618553, 0.5193341692773171, 0.748239523070293, 2.301452575267973, -0.9490764924808632, 1.3151590053163622, 1.7267659761216037, -0.08062300527163525, 0.6347198976898724, 0.19397247525358313},
    {0.36467617822034326, -0.6362851704658509, 0.6633889629839946, 0.6047653082015729, 0.24089115131169936, 0.7075454612416048, 0.9541547291605842, 0.8895575643266461, 0.20588178157616552, 0.003827914424238894, 0.7853908581417977, 1.0603084157204592, 0.5619478509642153, 0.5861044480075795, -0.029281359241632256, 1.2837342727227863, 1.4020501882566143, 0.8714344717763964, 0.360761900159397, 0.5692243843860303, 0.3774417711891246, 0.6739374039413885, -0.24979359677343174, 0.9600311425834632, 0.7097795422066003, 0.8826813096560178, 0.6216217348303132, 0.5449162468779085, 0.0814071704432853, 0.03214639788115945, 0.14955076903923767, 0.9525817415216704},
    {-0.08543001383756375, -0.5108666223610633, -1.0487379280377707, -1.0370452826051897, -0.6397324554338271, -0.6868457369139227, 0.7782290065211267, -0.7672765924131312, -1.0326682915569614, -0.4636514637536328, -0.17419912573397292, -0.8862581170239672, -1.241134504955037, -1.1968707542938173, -0.4585535569245552, -0.6887562933634435, 0.5295458565069658, 0.5769206506126956, -0.35847857026340346, -0.26345452593794627, -0.4611524022207869, -0.11932199978597294, 0.001356577153926296, -0.851030158226932, -0.7185031338881661, -0.5700139074177711, 0.26940122819147283, -1.3138663898008311, -1.4088221156566856, -0.13795126286178958, 0.2533697388436711, -0.18323418144933773},
    {0.5149926879582393, 0.5544832216036365, 0.1809898353356309, 0.6982363934010084, 0.382207698277684, -0.07296902372578475, 0.5418547307719713, -0.05794253004891022, 0.3782540191104756, 0.3421973314729027, -0.08327622644770344, -0.5496376382502524, -0.37357261153202886, 0.8383462121092092, 0.9964584263918521, -0.594676586849383, 0.7006206745626449, 0.3042434228583227, 0.667270961566875, 0.05617896656726881, -0.5768754177815134, 0.41947001350615976, -0.4891733876054984, -0.45341878339413744, -0.09445699671237294, 0.692418675096435, 0.578998750446479, 0.39155681207566334, 0.6630023055358145, 0.3424221879270536, 0.4187758660536325, 1.0036539628861643},
    {0.5876135107092916, 0.9394295300651185, -0.004339186467102412, 1.2632883910614994, -0.12788191251468553, 0.14761655530830323, -0.02491632759972415, 0.4010194925819296, -0.8635777060761268, 0.7995244277672833, 0.21755362797321817, -0.13866231168349377, 0.10145655028345459, 1.2065895713565649, 0.6841185607352318, -0.24286723711688954, 0.2930051552941922, -0.04779400807656776, 0.6260658469289844, 0.18841433253165848, 0.44706675958356756, 0.032676485609621164, 0.5668586886096036, -0.32030436874205265, 0.5179475487566075, -0.29170144523727015, 0.6264008490911067, 1.47868199029668, 0.6080606896989883, 0.98087170000019, 0.5606973517018378, 0.6604856420038279},
    {-0.7846046018045609, -1.012972734817791, 0.4600705067798539, -0.5563035825923605, 0.28403869647262026, 0.6685208354901034, -0.6630281996149111, 0.7044099602857867, -0.2627203823445414, -0.061795298696506705, 0.11715773103263116, -0.14176095032542593, 0.4231446941171161, -0.7634840397637502, -1.1210031737332757, 0.15027832518920592, -1.4542586731771088, -0.0390498971848488, 0.08899522077807571, -0.1425890507709156, 0.6737782312045831, 0.26201806904030495, 0.3132471975646289, -0.05834778039066484, 0.34899015660232924, -0.46674473817350165, -0.37028330970491025, 0.6412082971897097, -0.23162780930376162, -0.6757354878748788, -0.21623661733139846, -0.8492889742951281},
    {-0.4861838051748529, -0.3262067555191085, -0.0852444307498611, 0.2451209534321648, 0.5567017603310747, 0.9512125097227856, -0.09558872778643662, 0.6200961476043003, 0.7907281162923141, 0.4568253775325393, 1.208661741814296, 0.9938937577026, 1.7108975240251905, 0.15234937289596687, -0.766834130843037, 1.1391999670126978, -1.0451201658066755, 0.5650495325387994, 0.07911692803917654, 0.8872921384888672, 1.1282115388964011, 0.7693354349641498, 0.2600805278016633, 0.17978156662138348, 0.8056414806921396, 1.0321368714012962, 0.3767870265458061, -0.22818533333332722, 1.3020186795249102, 0.50427125081847, 0.1652066005649382, -0.0934445871245428},
    {-0.3940768421598337, 1.258673432811465, 0.4704874340304983, 0.5733874953390431, 0.3000823180284915, -0.09567896883468245, 0.20397098535951302, 0.05440438287669993, 1.918743132361786, -0.13041197331849813, 0.9773539739939111, 0.7201303144251773, 1.5657017356525977, 1.5845636397851934, 0.1574322453652296, 1.6407408304529927, -0.31219292221536993, 0.7786044937335684, 0.4614746610068304, 0.6722968525599053, 0.8013768811885107, 0.9488328353508516, 1.106618056014496, 1.0135892221319933, 0.07350646493142589, 0.36797028583351, -0.06227382180198029, -0.666088886302122, 1.1990940149606266, 0.44832117705155244, -0.3255982085098232, 0.05639858268586798},
    {-0.9397268496627658, 0.9178203707168548, -0.6709293514488929, -0.9003330997188302, -0.28277267186892674, -0.4265248733484682, -0.7484040691467634, -0.9330183102875724, -0.71777353578611, -0.5623525089245526, -0.6715339960584351, -0.1645444497093408, -1.0887440489932587, -1.1933716394538043, -0.4570708713085112, -0.8827853439224417, -0.8261364070772615, -0.5095720212566657, -0.5416574175926167, -1.2623773042523958, -1.2405388821921852, -0.8208417258293863, 0.1061038192638983, -0.4335091618506318, -0.2879869772552317, -0.994341994989882, -1.1590601860997438, -0.8939040341791801, -0.2456257581368764, -1.1485065039010662, -1.0695050471371688, -1.4710350993991173},
    {0.20928676896590873, 0.9940979391969857, -1.8129543999854942, 0.4333863629924112, -0.4163274694284883, -0.19939607351508395, -1.1749633446093348, -1.1039718439862813, 0.5091448487498121, -0.09872216246963314, -0.7888718496225532, 0.15800291794854507, -1.0636285587509147, -0.0374421037227745, -0.0889360883113474, -1.3934809350018083, -0.9934584323429161, -0.7173430926733426, -1.1656643088576248, -1.023858037228976, -0.8840533659104579, -1.1716678134152052, 0.03718666649775298, -0.6238597228504416, -0.2224177406756479, -0.6963921593346164, -1.2441734491747234, 0.21434953207220495, -0.7241808815598337, -0.4696260914531753, -0.864856415138328, -1.2069187546742148},
    {2.390502204096557, 0.24816270792612258, -0.35240184006109027, 0.9105096115708392, 0.017002721025503657, 0.03303299103147561, -0.8934906557323402, -0.04379816753908492, 0.7832860380728436, 0.5419131889595666, 0.2482713841961401, 0.05057123678858736, -0.884811909873272, 0.7974375276784286, 0.44476182356355753, -0.32407201549052, 0.06603313599033822, 0.4610227953255872, -0.22402990010142776, 0.31927341526667813, 0.11269165671183848, -0.8526865155451713, 0.3793584602989296, -0.2699032759521358, -0.17593404749244196, -0.6774456649241634, -0.18221821044902134, 0.4361301961540686, 0.17549278674201665, -0.11265250934845268, 0.7690023141622211, 0.1885863422753382},
    {0.9054768575781202, 0.2610284674317817, 0.4652743139814688, 0.037154589489364065, -0.4519129720617881, -0.022551127693588576, -0.01601992099991325, 0.044937169137677924, 0.11883234536596807, -0.12024144051405536, -0.23683681344638743, -0.2587191007888363, -0.49343640762472946, 0.5186502177301635, -0.42329982192455307, -0.6338632919060895, 1.010242202381313, 0.2362218857194652, -0.34197147479844026, -0.28461859648419574, 0.3898197000820951, -0.17209002180091343, 0.3838427408020757, -0.23388341828209844, -0.49801092954870985, 0.06842024963351041, 0.22126987909188126, 0.0004219503926326949, 0.7789200672623924, -0.35942363097798, -0.6507840038337345, -0.3666534056542818},
    {-1.5364476133211213, -0.3633004392284266, 0.04451702818549983, -0.7691309566876127, -0.4809981397149016, -0.13982311523848204, 0.22593529894619138, 0.4086449983574878, 0.14914532248756912, -0.3156788507054442, -0.39825373055548974, -0.42545000496768537, -0.15520599601712565, 0.15012375698708466, 0.3264720050004495, -0.011673115544072113, 0.5701680179305775, 0.016783954829845852, 0.19801915377516136, 0.6094034893368622, 0.21166347754489795, 1.0123850663714395, 0.38315214404467096, 0.24990986400143486, -0.8800341656769541, 0.6788745253343571, 0.8356183491930455, 0.15830571315354888, 0.3566223497640597, -0.15150493855547137, -0.09585887223382679, -0.3236243806172383},
    {-0.5615107522993442, -0.45295176567925216, 0.17552586606974024, -1.0070887049667319, -0.27032545054820395, -0.348188108233238, -0.8827572699793358, -0.2652638913932913, -0.6221399627220168, -0.12848923450526697, -0.049466249837617916, -0.4603165409737037, -0.7630129489047902, -0.5544549688503012, 0.5079445179886038, -0.7045555745195449, -0.06971906035519448, 0.21860383365869585, -0.25585236340484696, 0.0714492387607469, -0.20738150788735543, -0.014327987876887134, -0.16722702952053323, 0.060910086237396605, -0.3408751865434055, -0.18632455569856532, 0.3986116111077058, -0.44515845819021405, -1.4542642046021896, -0.05987686765900697, 0.11360163645594051, -0.6156143064831626},
    {-0.4917380923204436, -0.010714735353738448, -0.524989181623292, -1.2159965224250926, -0.20067066511492643, -0.5839791740595817, 0.6316359096542724, -0.5260618834972881, -0.994556299727051, 0.4026970314631233, -0.0882528716383155, -0.5013010787653286, -0.6016057616252767, -2.35422697793452, -0.06991449911628246, -0.23819364654804165, -0.6518750458864623, -0.29061527010821786, -0.7453486749690313, -0.9757539904489188, -0.9465695726029463, -0.7822074163881886, -0.3782665616849135, -0.11302273507417322, -0.6629937086631864, -0.09170658087337802, -0.5718166898296658, -0.5303063834615691, -1.5569134593958738, -0.2804939222194195, -0.06049067524394442, -0.28613541676923043},
    {-0.06363918502927725, 0.8325559886636563, -0.20382912657785845, 1.4551540391176885, 0.4745634435361528, 0.6655735800673015, 2.160019032691649, 0.22145751681340814, 0.12313821934001785, -0.27183936909946127, 0.2078272891172385, 0.5621345444361648, 0.885532129047581, -1.01801769014871, -0.7704446518699584, 0.9266119114226504, 0.5399441642483155, 0.4518726708212776, 0.43455149734836307, -0.30210699952588943, -0.062109538364723424, 0.3729849816669279, 1.2218222093142403, 0.5501298720254242, 0.13362072321016788, 0.9605651772821486, -0.31123296046146315, 0.4599725993991087, 0.2509945895981359, -0.7958083268132591, 0.7179309366064395, 1.12756126702319},
    {0.975443890975304, 0.27591805302059824, 0.16099761959939093, 0.8065552179375063, 0.7744303675588967, 0.012275342655043918, 0.07326088048792322, -0.041054209384980944, 1.3089624769935466, 0.2898657000566189, 0.5505913974300913, 0.32948628921914175, -0.1545074012844134, 1.4231543280376227, 0.17379675543626832, 0.6806635555172204, 0.3346032036113592, 0.30423455221515316, 0.6764668627062599, 0.23866747365876378, 0.4823133069242552, -0.4785410569090833, 1.1008025091599083, 0.5020034402055666, 0.8974555599748798, 0.14534095918207068, 0.22464811562673542, 0.7269443650518015, 0.011842188248871698, 0.42662590773389114, 0.3698717988702256, 0.9107880629211735},
    {-0.2951475791786601, 0.5931378083661054, 0.14873953225296194, 1.46825219759624, 0.4197272518313761, 0.21107036795002115, -0.14432063424433234, 0.5155573106010872, 0.14038047043030275, -0.09142976421417584, -0.14500977000271956, 0.5902708939335672, 0.5264350872429265, 2.0164732720564196, -0.4211065403591891, 0.35016712394162436, 0.11516691666557438, 0.4057332043994877, 0.25655565663080565, 0.714876325600389, 0.5105191689407657, 0.03266740760951409, 0.8391199874487076, 0.025733600075262094, 0.5529709359381253, 0.38026875585465, 1.1308333459245703, 0.4759180745112863, -0.03732617270805987, -0.06582375366475793, 0.37672087334889737, 1.2303080648455664},
    {-0.4613358602738238, -0.15153615183964655, 0.6711088920985554, 0.17115093742896267, -0.3060138712198917, 0.012666016924454708, -0.0797044261911733, -0.43160497653142305, -0.33806102525247894, -0.24900561309423597, -0.6361602689333409, -0.8710088161538884, -0.011855284474990416, -0.27996299921109713, -0.023429905628558075, -0.9432509295291298, -0.6483861429853781, -0.22886027736077813, -0.32199878095592244, -0.6906935334330683, -0.36524480128272296, -0.15408425934944858, -0.012819631154541255, -0.6967192752743748, -0.3098136797377659, -0.47328737060990295, -0.01105038851787513, -0.7535606005333771, 0.6059048465092688, 0.3237898136774873, -0.4092657075392782, 0.21198695457267822},
    {-0.40975310407420884, -0.11606310845049157, 0.27990079639119836, 0.7838093894890451, -0.27551490075240603, -0.06388335277024819, 0.42012139174074803, -0.6833885968288335, -0.059552039286791175, -0.2614902440856522, -0.4404809107281959, -0.45767984335016637, 0.40934925885856455, -0.003169786169121595, 0.6398500995687504, 0.4289233768921609, 0.09245124785058585, -0.19211402742569963, -0.27466312845540874, -0.3321044916712115, 0.17134872040115154, -0.03689668195979517, -0.2778860799311347, 0.33381440934484446, -0.4800051068216099, -0.7079477495346925, 0.46527390904462596, -0.006012021188901012, 0.014381519582116515, 0.7723364507553843, -0.579807799348449, 0.38104453236522984},
    {0.1141486662343017, -0.9551002115973091, 0.4506542793894687, -0.11087261104695183, -0.5100281270651592, -0.5420110081947339, -1.1306673964148128, -0.6716092355225494, -0.43519007140238003, -0.27872406330148664, -0.657931230217841, -0.7964531705283631, 0.850097414162006, -0.32172005605110704, 0.5019108811932175, -0.30807259678202514, -0.44874712231213987, -1.4691966201078184, -0.7650715531732919, -0.2398616475818758, -0.7724794758786773, -0.9367116083895236, -0.9658925381906429, -0.33942662289200104, -0.653292987231762, 0.5901980350779861, -0.9568312261637779, 0.3426334373039621, 0.31357360417804525, 0.2730940208797903, 0.43417548074617374, -0.661511201717145},
    {0.42422610008123324, -0.8468773930922984, -1.531618575170307, -1.1326532192745837, -1.4504553500158184, -0.39127000339913115, -0.7943501394101194, -1.0891744107645314, -0.3636667050024682, -1.2094087265049378, -1.0644389764507005, -1.034373389127632, -0.24387373117367886, -1.4803755933402194, -0.05846559429826889, -0.9651472978554869, -0.1821440255513894, -0.6632060189392881, -1.147067049721642, -1.0773947397177956, -0.9659577880296348, -1.2789431110148466, -0.43999186647025507, -0.7743363522746107, -0.6413725097540011, -0.5327518032379867, -0.494116435530252, -1.0159406155118411, -1.0649797371512393, -1.1506741839182224, 0.0226702709104788, -1.4420634651283708},
    {0.02640510930347794, -0.9383272737643601, -1.0220612680465386, -0.03890669222134752, -1.2520375844077545, 0.21368287497154947, 0.04985490274445951, -0.16420555902201245, 0.9214665788030345, -0.5860325993384629, -0.678686751850302, 0.6621485609681328, -0.3962930912230433, -0.6480371904040606, -0.15073358310479476, -0.33718092005065237, -0.3490725692672199, -0.49944934221998366, -1.4239950402934038, -0.0030457334303867684, -0.9171868168767208, -0.9507100642234648, 0.09457608740308937, 1.3593986548072634, 0.2253184942048145, 0.05866040559987685, -0.8899913472301882, 0.6106622982724235, 0.18451037840403353, -0.12453843391798877, -0.16765378117006627, -0.018418256076951536},
    {-0.5531845795472606, 0.247828523986686, 0.802413592540422, -0.1124107217402896, 0.6589012909633774, 0.1339000976045121, 0.010478300596636058, 0.48808192157090885, 0.43163641391728974, 0.23734348230881352, -0.20583320421353415, -0.29805221307867663, 0.15370559646355303, 0.2513122129785753, 0.4180252660060978, 0.021503785582266236, -0.004850986743183563, -0.2739559534042195, -0.024536748349633986, 0.25903931791282503, 0.4137615613119287, 0.19023249454013125, 0.08661136424770446, 1.1036125352134918, -0.4502171235972376, -0.5654288908710559, -0.2044328966539759, 0.9296974637308577, 0.5828194764359552, 0.20083809823496412, -0.06714340142006518, 0.4513038190839091},
    {-0.6524902395706142, 0.8884922138375431, 0.39696216347709307, -0.5399316868244353, 0.5263001586832203, -0.0448071318301948, -0.06156863603984522, 0.4324182024993279, -0.7851247540975738, -0.09573844016850795, -0.046068763078339035, -0.5519425930778472, 0.40140734594954336, -0.24293519908594652, -0.5254231157757733, 0.1660146553286142, -0.33725082001534085, -0.1550136718696877, -0.019690996026662792, 0.4754090634572277, 0.17423772320730735, 0.2911046694551251, -0.5957351347614811, -0.3099239264956674, 0.14550301409763072, -0.7099752944538203, -0.3697438240483857, 0.4884521725492863, -0.26769017077581536, 0.03863438180273769, -0.86947135815195, 0.28540580516345226},
    {-1.5713528761808513, 0.6679135857744465, 0.5433251929019902, -1.4252110844411305, -0.3811528308474314, -0.35783972326075253, -1.6444480874023097, -0.37162598571102656, 0.19468765121318993, -0.5259898232402044, -0.49232263823019906, -0.17220275687353767, -0.548931019046657, -0.1836556826362774, -0.37199277678919745, -0.5831578695395064, -1.172612917049781, -0.4348809555101068, -0.11967797937124855, -0.20248542571672928, -0.7226886217273382, -0.40274162719951306, -0.8385577191303618, -0.5465839724984167, -0.10150417495314566, -0.7081812286225281, -0.11445167406065485, -1.1910110475448, -0.692484371926979, -0.25371657404481357, -0.6596433733485535, -0.21941681843848038},
    {-0.14591922568897076, 0.6317319113438756, 0.039758729195751345, -0.7073680842220557, 0.3382063395935758, 0.024401229007427475, 0.11878413500466542, 0.40773436978365946, 0.8142566176684132, 0.3476501518913018, -0.28415701001894317, -0.2825514420249274, -0.5780966839333611, 0.24304512659289285, -0.9109399830892814, -0.402681836502084, 0.11425233754943839, 0.7058534419104617, -0.7629842841047916, -0.3926236966910106, 0.34377049067222815, -0.1591606934789707, -0.4313839966510533, -0.3946912827645691, -0.2547769810515733, 0.4395954520077701, 0.4234523049768704, -0.2743296186187444, -0.9363731727917075, 0.174204745614497, -0.13984021203935904, 0.1873652743432193},
    {0.8767037567294944, -0.4541213947133029, -0.2554422318651728, 0.5364644429757638, 0.27703066827511086, -0.5123711516923589, -0.33440189846252294, -0.24721522933506013, -0.006643031906328693, -0.11004269137327964, 0.26235447961033775, -0.5000406594313531, -0.5344558590167859, 0.6757798663364313, 0.4467920438061541, -0.2996924942152099, -0.32498629394457823, -0.15363944952910374, -0.06150523495231268, -0.4835513180584311, -0.3169336738483672, -0.37741899927312467, -0.5457967021549981, -0.2662454235632218, -0.38419773827002396, -0.17928958574169035, -0.24568394756452902, -0.9308123134297712, 0.6311986496152037, -0.2127369218388577, -0.10081694617584101, 0.3524882783778568},
    {0.3494890529922613, 1.048382739931565, 1.0443784212140625, -0.3290761165779665, -0.27374511607134894, 0.49666019010472967, -0.42237101894776713, -0.048603213417268726, 0.2772466751465654, 0.9129693182081845, 0.8302797338107466, 0.8430897194771436, 0.36472493790290483, 0.05403792898656485, 1.0509654730749538, 0.1761703225191443, 0.0164519937249869, 0.6153130512150691, 0.42137036153308605, 0.3882607479854548, 0.4503949255734375, -0.18104005173840504, 0.13433093499491425, 0.9114548395646839, -0.1886973481016581, 0.8345804333250868, 0.11824034785012275, 1.2508349396195317, -0.03346657344187274, -0.05119463105686968, 0.20941554437340332, 0.6718094110608834},
    {-0.23937644613663342, -0.351353504082166, -0.1995834889501602, 0.1481983150389312, -0.648890326437974, -0.41325503004675607, 0.4962207024180978, -1.227809948841536, -0.48818439374250744, -1.0608842230692617, -1.7155969193852383, -0.6502156327387553, 0.0683412222910784, -1.8706250950861485, -0.6616715089284263, -0.5037282965246836, -1.1229752163967335, -0.73484491239775, -1.348301602871908, -0.4787997913078494, -0.7687255550371134, -0.6180960569678751, 0.473716308543401, -0.6690962733851711, -1.0728898198903405, -1.2183419054001339, -0.9586957495220655, 0.12128434181584435, 0.3524353979404977, -1.3874486309267742, -1.1766352397551116, -1.1292319100421633},
    {0.06296882459591552, -0.10750509886489884, -0.18353222394191268, 0.49148143047851506, -0.5430382601374303, -0.7057216342042416, 0.6983022983545337, -0.21885073225137014, -1.0327199081802867, -0.06008544532741733, -1.2097516173382235, -0.13717954617910386, -0.30421057243763744, -0.7627309178087622, -0.58832606810169, -0.3067146150033926, -0.26105213738450234, -1.1203324471514378, 0.43440149086602947, -0.4081994438752048, -0.7734269117721078, 0.9836865268226365, -0.7950143296173446, -0.4810410682059174, 0.19094865924136742, -0.9092562091960533, -0.1847908208326069, -0.2715977874424161, 0.2963845427902675, -0.08834243780602258, -0.4986571268800578, -0.6016402172033604},
    {-1.0712275717703716, -4.571889604106434, -3.5299204653464615, -5.725384700724527, -3.3010046786867226, -5.048418166889122, -6.033094280916839, -3.7879544975622976, 0.49803078995346467, 0.7570685056554902, -4.671527054833645, -4.279217210991034, -3.801936603246598, -4.1865897840051955, 0.7948234411789162, -4.825476775315686, -4.8614463727255135, -5.305810498297359, -4.84358849652227, -3.693847398183499, -4.440410782240496, -3.8400475462334787, -5.422391014689988, -3.9671790024709224, -3.1919828699109583, -1.4861638841220968, -4.277107081595701, -4.589271927264478, 2.339222751522641, 0.22858851677702338, -3.3431726512027553, -5.350486272636466},
    {-3.295820426395645, -5.483537636292362, -3.7758661441426997, -6.07311088410151, -3.7375014217929663, -5.445425924004959, -6.158148671995216, -3.316515627302151, -0.745953893530797, -0.9808137664385361, -4.595485699814351, -4.579845910920145, -3.1469996984816495, -5.4173913937375175, 0.19186046088353675, -4.732579717705396, -5.428287606090676, -5.586364521033258, -5.213022247630566, -3.7002788890144402, -4.490384666427421, -4.245777558426469, -5.964671008618556, -3.636433808112605, -4.056909619868453, -2.1383215897164836, -5.085960002113273, -4.61450540638415, 2.834298523460292, -1.9992641259713213, -3.851137769189362, -5.326076725838226},
    {2.055337425629462, -1.7297257626023073, -0.8373540446884699, -1.732460753431668, -1.2834625724969677, -3.7374024345325325, -1.9024237040391787, -2.2579463478172364, 1.2057913645415808, 0.40065757180674577, -2.875758936144478, -3.038521095759308, -2.6143115636968, -0.3027835989011948, 1.281114786715401, -2.519435263885209, -3.449212803199777, -1.752560679008034, -2.1708937135854622, -2.5816370497458565, -2.7532166163181815, -1.9798006272473725, -2.088173133509928, -0.3120035030440353, -1.4981331465920111, -1.0070450635421675, -3.4270448275915437, -3.470153788168764, 2.8781791718829886, 0.9879374688384687, -2.083444279654979, -2.7172585485576435},
    {3.0142504762864406, -1.4048797125268488, 0.4221116651753624, -1.0189095313707774, -0.5227613940494661, -3.0045256140489793, -1.883931955284362, -1.2028789481879527, 1.5389297796435706, -0.0822267656905203, -1.3560065178154366, -2.0302153162480168, -2.41195007908735, -0.1966951771521539, 2.087295671387784, -1.8548008876312019, -1.2297265797241097, -1.3639079817488464, -1.4912177801343858, -2.1752056675808267, -1.780867855614384, -0.5737761016906332, -1.2652150723719502, 0.49968046424012597, -1.3237807125776453, -0.7026075989452546, -1.531437047650819, -2.577351137498341, 2.283797282457094, 0.7296034659109875, -1.3502544064620445, -2.053504803837407},
    {1.1719622992149383, -1.4022733422006686, -1.800417011580177, -1.5271684070639435, -1.0270329007979204, -1.9263102600421824, -1.5113487653849687, -1.2976399880003924, 1.5830508296039572, -0.36283982805533777, -1.3445833080547822, -2.0263699986700363, -2.026050464416415, -0.4757919266317957, 2.4283259680997866, -2.1435728344108385, -0.673647541098509, -0.9007141214777377, -2.142820257173083, -2.048594011436279, -2.1576260319342233, -2.221494021814607, -1.3483106554056408, -0.42117087945633347, -0.7732699972533948, -1.417462033151393, -1.5652921632790588, -2.9603516250489403, 2.1068734251715946, 0.47662302917329863, -0.3974400710221885, -1.8512340139866101},
    {0.5248388913995273, -0.778132594592437, 0.2805753825813853, -2.6652901543548273, -0.9428324231089718, -2.647694260244807, -2.7431571917980495, -0.3563597336555214, 0.9798901195719247, 0.09490777790251201, -1.2734090851665802, -1.321433767837607, -1.778442387995131, -0.40705095229355925, 1.4466022099325782, -2.1273925553998843, -1.813359926486994, -2.1381958436133863, -2.3188153546607184, -1.1258091389129348, -1.5544473122587252, -1.8050994302851748, -2.515531905376926, -0.18356662683241856, -0.8218658804206727, -0.6232122362480857, -2.0047963541186156, -1.4594337519376648, 2.9167422073979425, 0.7530753309722499, -0.7838230842212076, -2.5854478568119394},
    {2.252604556358785, -0.9287585705824688, 0.12689514106455432, -0.7797358497370814, 0.7999478674334224, -1.9236159311359973, -1.6752528760117593, -0.429288632961166, 0.15192411766003494, -0.18001715666404108, -1.2643709186556147, -1.7680044808842983, -0.770582602256215, -1.4344245106551345, 1.816131001909715, -1.5817556349039819, -1.2268499841889196, -0.37587315988466136, -1.0136707188684861, -0.2600399221124859, -1.3315608609126006, -0.6088186553339743, -2.0126589535514543, -0.581123472600426, -0.17061194162355672, 0.5028615125996772, -1.5546610290101803, -1.9110717704553197, 1.3210168857338511, 1.0880466009001, 0.5471751080015537, -1.2204292366357472},
    {0.03129396689365498, -1.9467276666062105, 0.3803815415023849, -2.238981006386058, 0.6459782667846952, -1.630401265486859, -2.06924317759532, 1.0277491765342583, 1.101662188036208, 0.8749732999066182, 0.8555320847440157, -0.1418687210182185, -0.7444284378000418, 1.2717051596451625, 1.5739409496664463, -0.02720935284769315, -0.9479478458936269, -1.2418742159022234, 0.045369236112772396, -0.2834526771490326, -0.03677747112915579, 0.7711126174088673, -1.8400131168375182, 0.04183150758599935, 0.6553247192941598, 0.9008312211416437, -1.5435415098178038, -1.4111181351226048, 2.2177758905396465, 1.1825878324564487, -0.5827743186982639, -2.164113885533269},
    {-1.8831060329840998, -2.003509670588956, -0.4628234494835671, -2.9131306520228217, -0.17860956240880319, -2.132345749738037, -1.9468790286814832, 0.12595036083732514, 0.17505121260267661, 0.6590915764411827, -1.4385522511930742, -1.2224109519437198, -0.3661013935769039, -1.5257797379281781, 1.1947028631293788, -1.4326163482498806, -1.4566699586970704, -2.820010288699189, -1.2581321032231323, -1.8402448545221628, -1.3611443506416887, -0.45807025784824495, -3.479812707645384, -0.8992803431727215, 0.20177618617306384, 0.7501481899516661, -2.9532133609879296, -1.0906836045908779, 1.7563282695804436, 0.026828208622084414, -0.6445809691067398, -2.2575088551048728},
    {1.1436593139086657, 0.3342443411134706, 0.6470724076635594, -0.8010531538611231, 1.1301808197230236, -0.713828579601514, -1.7152008461587565, 0.5110000039655817, 0.8846311467506474, 0.489460403568793, -0.8571153740121445, -0.7230670328564051, -0.2308641434644898, -1.547868509568893, 0.42832289174081595, -0.21073127361317837, -0.3516988013677109, -0.9914689081858167, -0.43899397182922, -0.6246764531071375, -0.37888611292741875, -0.49774395696198714, -0.9190253570321639, 1.216760558885405, 0.2765215364699261, -0.2770427795018083, -1.8506444295688436, -0.5847802664736784, 1.9355470025525265, -0.5629263776408819, 0.0365706880796857, -0.6807610922165896},
    {-1.0618472753420722, -2.045176601413036, -0.1696188723973105, -1.8539376290899905, -0.7953662193173331, -0.6444873610011002, -1.0531999596693529, -0.7390644148212295, 1.0112362113344469, -0.9852067859948891, -1.1670153132009788, -0.7694629064724051, -0.4325503975623745, -0.9764761606963224, 0.5333042919349352, -1.2722475772673958, -0.8782683234305169, -1.4666643249997364, -1.4615132441459298, -1.0713931135900199, -0.6838377331497105, -1.5305385726760166, -1.7933016490457168, 0.36402022764091624, -0.7598936792610971, -1.2377471066238575, -1.884634022510287, -1.084745826892141, 1.802622312791049, -1.3887127208513972, -1.2404882015911216, -0.4219815730042179},
    {1.8224851528129211, 0.660224324847296, 0.004226952900398136, 0.6501143409825085, 0.7554382462255369, -0.10236253889210895, 0.020405209982752946, 0.8147060501293605, 0.5664373232563881, -0.3359971663626356, -1.2976289310314253, -0.8779636765014576, -1.035380757213078, -0.2965263845894062, 0.04341995416075277, -0.4539946773077058, -0.5539905986523224, 0.7411522718135325, -0.5582223296643567, -0.27821926241584355, -0.8936981696389801, -0.6768028979452922, 0.8783446572850049, -0.33973033166531325, -0.47992918350863456, -0.6668833297916116, -0.7111439273193345, -0.873266722807318, 0.8053880755144477, -0.15940730234903747, -0.3175736655377182, -1.1064668211493487},
    {-0.21129029861865123, -0.09433253971646333, 0.7689808545531384, -1.0805327188380562, 0.87776906398055, 0.2517094202638035, -2.4513529655601864, 1.3121331251321087, 2.3267592193954014, 0.6771113158163135, 0.7341531683626469, 0.5667065127385249, 0.9511624598841527, -0.26477461549271053, 1.6178581064443165, 0.9934865603091224, -1.848403197068338, -1.9030182687404662, 0.29422706246722796, 0.40991882363848736, 0.5479234576443128, 0.6857170832712796, -1.8152272996392704, 1.2755763736749042, 0.4417748533726984, 1.1550174426842252, -1.2615600760302286, 0.7646773661656906, 2.748367201800668, -0.19731900037022126, -0.4116669226784825, -0.9848572876694449},
    {0.7187483045720622, -2.492415026480027, -0.32406351472478356, -2.021143531798309, -0.9359150228808157, -0.3718602056305939, -1.1083155362068282, -1.235550079036483, -0.5922044942150044, -0.18184412348052026, -1.8119126735991304, -1.7844663593754186, -1.7102956970455834, -2.7866722921625393, 0.43777988635184345, -1.5386645900411031, -1.0030810731319333, -0.6760295216595186, -1.6686304380701742, -1.9533561447619696, -2.061179471775547, -1.8699654805670807, -0.6821465408384219, -1.442008374629959, -0.7673137066033929, -2.2526594202852706, -1.6683374643965905, -1.6108203493208582, -0.3891109804317023, -0.19762106414931405, -2.112815206812561, -2.095472702449357},
    {-0.5018218021733457, -1.3857936190892326, -0.6405196921242988, -0.8859759372061867, 0.152261483035647, -1.3585763757319613, -1.713565658783227, 0.703856903602675, -0.26214839139095464, -0.25056788246540107, -1.4472003355471565, -1.4647540083640989, -0.5007310475112725, 0.42312952379624647, -1.663048602617176, -1.22179087476275, -1.8302807285036262, -0.5732171038941638, -1.0586790878423544, -0.5211126231461687, -1.3618268130011533, -0.6664799455606107, -1.0353850211119087, -1.397718807647838, -0.442362584994456, -0.10567750425263697, -1.6044516641277704, -0.4000906056776027, 0.5252208890872432, -0.831181529130871, -1.5516785079180107, -0.12615139146727006},
    {-2.4385635605321294, -1.5077515217544042, 0.6936780944144278, -1.7486435879203157, 0.7457061102013774, 0.6106202333272109, -2.3402460292879206, 0.5725200870912409, 1.7793750449103307, 0.07897646866003541, -1.0267214139541598, -0.11551556664300001, 0.820509162934659, -0.1492343539247138, 1.4151964053624535, -0.21700256484178376, -0.6347132955979982, -2.378063836014882, 0.15646816797397564, 0.13641795015061084, -0.49325653830063626, 0.8390781447024486, -2.3553824562278227, 0.30259180246476497, 0.39819622947686384, -0.3875660999074912, -0.7217828102170901, 0.15796623377994068, 2.229878263188805, -0.014603983850190275, -0.5226710294361334, -2.009571227905937},
    {-1.7231105146820522, -2.263136323181963, -0.552520372543685, -2.0414411622377946, -1.9514386060025584, -0.022006149691891626, -1.7847330099551328, -0.831711912096947, -0.8109377969651667, -0.9649671321866986, -0.20899378661444537, -0.8563147911742585, -1.0453610504967707, -0.6718910766009261, 0.42352856575875175, -1.2280913761387493, -1.419882222165177, -0.8550061260450771, -0.7490395825293925, -1.391782334446974, -0.22284527596676573, -1.1972120197167522, -1.1892776801332332, -0.6149488873167116, -1.1543673277374242, -1.792104199723751, -1.475377840294454, -1.0138134923537345, 0.19160358362198077, -1.7149407607794174, -1.206870228028424, -2.5569631347060144},
    {-0.4580868825470788, -1.373627834680104, -1.3100920896351642, -2.3264188086036235, -0.7774212775549432, -0.2470060047786918, -1.635322840342272, -1.2094115888496062, -1.2217804833099655, -0.7097063582423268, -2.128568073175831, -1.6330543778509423, -0.7847823251835653, -0.44378885141241503, -0.8564727605822479, -2.12819807545853, -0.7826123781446368, -1.5616851123957594, -1.3923208328060086, -0.7079614305572901, -1.690050568418279, -1.943865997539604, -1.2809185458651373, -2.2413425960214903, -0.7338318154115068, -1.5691494715938177, -1.1367152021937719, -0.24789451859813705, 1.7317730228245583, -1.273633460870095, -1.470405468319685, -1.4907995234080338},
    {0.38541259462037214, -0.04936004280102813, 0.9343284687086496, -1.3419873325375988, 0.5840499974317918, 0.08558152098843748, -0.09827414386367249, -0.12810242211319442, 1.18140272268471, -0.47775057941854876, 0.5704990451983687, 0.271330468640841, -0.2201110049129038, -0.1576326737097768, -0.008736995326513971, 0.036801705854752675, -0.7787487200606001, 0.3155805910466774, 0.11237608776195783, -0.6297420063236854, -0.048699668217109374, 0.07584582612802765, -0.2243131233868943, 0.7241205174250285, 0.44229081274803567, -0.28766127197654806, -0.6681957776040939, -0.12970531199934515, 0.44349208606751556, -0.5871416046750445, -1.103920591840859, -0.4569494839548604},
    {-1.6448836115954575, -2.13337547585165, -1.1487615203052266, -2.059251196059733, -1.8811661610845858, -1.2202015011528986, -2.0917604294316483, -0.46407431558039763, -0.995956814893943, -1.5954485349571186, -1.7503275691193065, -0.9912205445134119, -1.0161949575871752, -2.352414538970487, -1.0863685258790454, -1.2431017427220281, -2.2308371715935995, -1.8718540060663011, -1.7232171046110953, -0.8034086567511273, -0.9938499080018339, -0.8794955302013123, -1.3653568438252328, 0.11320486696178246, -1.0857645888781848, -0.5113834448211908, -1.8505732088349751, -0.8711722436835638, 1.353474680549674, -2.5813456241851744, -1.7515504106638353, -1.6481751299679315},
    {0.07825250091845104, -0.26010605917838553, 0.6185780040840175, 0.9544356881843564, -1.1258741105842243, 0.09592503406763567, 0.9757599749089902, -0.1034711985622101, 0.5791610098238232, -1.168274026122614, -1.314254297478507, -0.34406443041210877, -0.27813713923907735, 0.98820092405707, -0.1853988368569507, -1.0433379568588097, -0.6069191003626799, 0.18277748777566244, 0.19070371297308827, -1.5241151390502268, -0.5913429347217756, 0.4364161430273981, 1.124150120746875, 1.4239259481263629, -0.6192435753785087, -0.007193374156416933, -0.32762174609260003, -0.25912778953382304, 1.3912020371137803, -2.5294031460694, 0.14481417445057213, 0.16664506756545755},
    {0.10605054530129468, -1.6839993231644461, 0.34493397186694563, -0.07279455188825104, -0.07272008296397066, -0.7713911284769598, 0.08801382321389652, -0.37218111264599657, 1.2067332399133397, -1.213062186739588, -1.133845900330756, -0.0038575440352403025, 0.4388331643746899, -0.9781318760794993, -0.520430123783874, -0.2445893250821841, -1.0232516806107463, -0.9580597688355489, -0.9409246336904746, -1.59763006491574, -1.1342529790548344, -0.09979194205070153, -0.3673788196927269, 0.7341319366216973, 0.061393585276464935, 1.2492719532449885, -0.93868354650012, -0.5918646529060202, 1.8732774867418651, -0.3009886750337007, 0.10215529671346599, -0.07282361134299124},
    {0.031062585542463012, 0.8825689962812527, -1.0702062771011487, -0.6653690486228403, 0.012423933016135633, -0.505868389057269, -0.1166109832160839, 0.16061606755107888, 1.1484888549681018, -0.41187641546239706, -1.4197396572456644, -1.2140446026290246, -0.5307376932659892, -0.6254828702014882, 0.12826375189033928, 0.20133577113097598, -0.13213653795490568, 1.0268498156674264, -0.7707763079587854, -0.06706840704676888, -0.8395783837453481, -0.38954362560243083, -0.04583083463690744, -0.30982621488932105, -1.3610284236635322, -1.4644286732273581, -0.5730075450439027, -0.06686156762492713, 0.6660425929736293, -0.5724119266248704, -0.5361147601679533, -0.2719855766957356},
    {-0.539785140632283, -1.4746710105188985, -1.256041221531187, 0.3783864633166742, -0.14843173321842937, -1.3612351617042207, -0.31584381744000717, -0.27823709186866014, 0.12106441590599426, -0.8623160739197138, -1.603474324523163, -1.3178616425695058, 0.5852895719021501, -0.6159350603507402, -0.657407644763912, -0.4138886785031329, -0.1279781732385438, -1.438901145756915, -1.1012269039607188, 0.28953772021642826, -1.1903331157876664, -0.4678018125781379, -0.6638039257408076, 0.26590210648821383, -0.9770057877568815, -0.342641636178332, -0.20939705976646358, -1.4800963351629368, 1.480159818591871, -0.08978622780402797, -0.2430648447830294, -0.7098246319222957},
    {-2.1803925926390315, -1.2236157095221962, 0.07232118792377046, -0.7596383137938617, -0.2831713986816346, -0.587529690042517, -1.0680239691564042, -0.27447171899462725, 0.5983288191821492, -0.2972630798829977, -1.7031391468935881, -1.383119949067497, -0.7829206700305921, -0.8859283833529772, -0.6347881631965092, -0.9243689141719535, -1.8679826870495941, -1.0555460812315216, -0.642095178892017, -0.16137333270781543, -1.3278328308060958, -1.824081989136401, -1.6701597490457545, -0.33429196157380386, -1.088419859325351, 0.3829654150659148, -1.5657586085146382, -1.5340222036438413, 0.24755620793626723, -1.6420521957917977, -1.2721386375860324, -1.0888757401925022},
    {-0.9084529365725602, 0.8104990195803429, 0.7757711691672012, -0.6973620079324601, -0.2156859246828764, 1.1492771267918143, -1.1285248032449489, 1.0999216351506145, 0.8125446194531354, -0.31652301434701713, 0.439197492109837, -0.7838267562282617, 0.6572770556788105, -0.7318696665298631, -0.8175883688055567, 0.22390060411877072, -0.7121836194200674, -0.0665984440530259, 0.28199234190553274, 0.0571079074786532, 0.7466253689342223, 0.9453629513597367, 0.5744392805127759, -0.17969013747081958, -0.02232652358044732, 0.3729040621288199, 0.9377472426736271, 0.12030771908551995, 1.633060152832309, -0.9303748023227573, -0.3467356351516433, -0.6194081562398821},
    {-0.7149952168983883, -0.47310912490074086, -0.3989773180593388, -2.0367212795305143, -0.4130243674148148, -1.7012391836654273, -2.1390846980514255, -0.8464041655068346, 0.2778899697256138, -0.9336236166045759, -1.2955732205386328, -0.5380357026714326, -0.9158315539415832, -0.9943564100338295, -0.1342478100580234, -0.9655629207051358, -2.1153104737588664, -1.457932374370793, -1.7200628388681403, -1.4620351042110864, -1.0223889550532752, -0.480265510390268, -1.3367200064101636, -0.9919525996211485, -0.7714228850638258, -0.37146004627686385, -1.6145583431984865, -1.2740793891936204, 0.47565988406346804, -2.1037939234713448, -2.507038262463244, -1.8585411291192933},
    {-1.8799111302964042, 0.12677660163711643, -0.4863539999171882, 1.3597155617404375, -1.417406193466415, 1.2915949881590392, 0.9308921649486732, -0.49136076228532194, -1.5450828434207293, -1.050847349014662, -0.5568905610332019, -0.5395158454148588, 0.26662832282523496, -2.0554157014582675, 0.32663849487187596, -0.8403218220468797, 1.6365896102280568, -0.5164735502383212, -0.7238780269859619, 0.24501577757357243, -0.7716314923109084, -0.9035300134471054, -0.11837454959462107, -0.5978741127076987, -0.6205439158898913, -1.2872926508, -0.10364631740075189, 0.7215502206180545, 1.1168045364865848, -1.4929083559905851, -0.6051625424627417, -0.5088210157807452},
    {-1.0404701577120736, -0.7373186750646278, 1.105543678630082, 0.8202753713694269, 0.32758565001644374, -0.7480266777909431, -0.03564918956180118, 0.27680166420586466, 0.5238553579796668, 0.3414604144812553, 0.17427523526320393, -0.24217262265989956, 0.84010417308039, 0.39471867610881656, -0.30156607344210756, 0.6554871292642127, -0.1410535433112198, -0.0948178977051842, 0.25446464896966975, 0.6428508899217069, -0.1822071763655101, 0.19452000256323793, -1.5614680565732117, 0.8641104942492026, -0.06489534515128059, 0.6848498105238676, -0.7277469595573136, 0.6658779526529877, 1.1210214557210791, -0.7006971113873723, 0.06000528421956886, -0.7015294432685789},
    {-0.5880861908958201, -0.1759820766171951, -0.003380612997834965, -0.6595680174792526, 0.9905927853225593, -0.8252746774451574, -1.1403617722732982, 0.5094113847838174, -1.2690823963412745, -0.4761792961808676, 0.06118529756522059, -0.6760279706609591, -0.1591479819216978, -0.17930728424396097, 0.8637366970067946, 0.08183382189777776, -0.7667937147114228, -0.5624180697536675, -0.37579084398897217, 0.1292756283615185, -0.8815609883904401, -0.715990311447316, -1.7331281801302203, 0.7604567846241309, -0.05112879588116534, 1.0719022349351153, -1.5073982900091072, 0.08969162041267868, 0.8877200992235593, -0.7835999918671189, 0.11674157665952559, -0.31981225437357036}
};

static const float b1[32] = {8.080910501920474, 8.092305170997157, 7.988244523822297, 8.078049561631893, 7.635441404635012, 8.11310658658622, 7.806712958156941, 7.717672883111662, 7.758994830137972, 7.899194354575214, 7.796639406463507, 7.6065883850162255, 7.656294836264214, 7.901432479787562, 7.7579657113597715, 7.8975411620582365, 7.785618886361967, 7.721800949316057, 7.816901210220489, 7.484749041184417, 7.56460032794108, 7.783373119251505, 8.072144176540125, 7.942695746620109, 7.784907319020996, 7.812736852172722, 7.917667326388971, 7.987964759872627, 8.209788686841726, 7.782377104732692, 7.693028809483109, 8.078656989304827};

static const float w2[32][16] = {
    {2.379284305408063, 6.390814082937052, 4.77107350632477, 6.973120031053827, 6.467712393071958, 6.5795666480291235, 7.078414566139276, 6.342514834822583, 6.701888668278965, 6.387713136652066, 4.894929578840412, 6.675486334403832, 6.9323089619998015, 4.841201124698322, 6.9712904608096675, 6.960886925483773},
    {2.5515632122080825, 7.01774758782612, 4.599391890904033, 6.849115616897963, 6.862646050316287, 6.993652823751113, 7.059984237556537, 6.668671000969511, 7.040273445827891, 6.4851493267278455, 5.182305528490502, 6.948523216200769, 6.8773185295201165, 4.9253325759999305, 7.197112719018044, 6.76442047780191},
    {2.5965045466450913, 6.533857735563302, 5.186804141490581, 6.727977836691516, 6.374470805065065, 6.98515192491361, 6.907469797227606, 6.4760624479824695, 6.7464410619768325, 6.631244488698846, 4.751248841553485, 6.617929965704373, 6.40247666106319, 4.4489404459440225, 6.895658746651959, 6.791961398670681},
    {2.3142997380379065, 6.945379087123445, 5.020182101730931, 6.456445557724979, 6.775894794378602, 7.097641686533026, 6.9335930992848205, 6.633252857314233, 7.0758562054627285, 6.72163767652729, 5.334784099306247, 6.871773693819094, 6.999973894004356, 4.199751108021184, 6.963368166599505, 7.086801655107983},
    {2.3070807782952074, 6.3984013751369355, 5.39796434608301, 6.458082153422181, 6.7629354455878, 7.043870026938122, 6.679316789869585, 6.685928770243255, 6.778439086854745, 6.963821963570567, 4.531692765779188, 6.331323201636688, 7.154441710761992, 5.047993552961956, 6.87706733389086, 6.780794385018034},
    {2.3450396616564015, 6.742437413908277, 5.252313531041759, 7.041110227562232, 7.363378184648059, 7.088042371236994, 7.372629464886631, 6.339769526904153, 6.812433002734891, 7.018366474327786, 5.406881196241031, 7.012179083290115, 6.566607011065146, 4.806515674491688, 7.133707935126552, 6.579834619737069},
    {2.048357608934312, 7.140859201535558, 4.951834544698482, 6.834903877622027, 6.732466315617514, 7.020285734196708, 7.184980330184205, 6.81044488597759, 6.797292992963757, 6.8022166784189535, 5.0109935522749804, 7.157917552005932, 7.556649610103235, 5.44813648028097, 6.830628657868421, 6.953909382189078},
    {2.2485145670216578, 6.688024833996487, 5.01238782784557, 6.817691059825953, 7.086572510618231, 6.8621715463120125, 6.894285883246941, 6.863385284162793, 7.076232031612491, 6.919018648193872, 4.940362910604656, 6.824811244673634, 6.771026651507532, 4.7929775427566925, 6.5522173719324535, 7.044162726012901},
    {2.5766186344525073, 6.854325718559053, 4.737297667938044, 6.566689908871468, 6.632691792008367, 7.009968206334707, 6.747082399017002, 6.447227750168769, 6.62947589093215, 6.786199926877823, 5.415694683610525, 6.537029907963667, 6.6852235578762365, 4.71653953947991, 6.585007605736296, 6.908597491048297},
    {2.0210565511421685, 6.842616627875345, 5.458931239816078, 6.420815834795063, 6.792801201085527, 7.029433707906478, 6.335818306360128, 6.653739104682443, 7.033357696969361, 6.5942158776433075, 5.125070270529393, 6.746980643484973, 6.845149265547281, 4.8834547347247454, 6.973860381281549, 6.935588334703018},
    {2.0255279269904465, 6.340410006933807, 4.512794717522385, 6.142265131692331, 6.298346533432037, 6.815981480190739, 6.834682497271932, 6.146862052159994, 6.7069663179375585, 6.387946307075811, 4.896164621552629, 6.48983936415656, 6.781222828442996, 4.316979951532981, 6.667374663252236, 6.627929279131102},
    {2.4668458698943847, 6.500487935140359, 5.451766402486069, 6.880241157641831, 7.166629569092328, 7.0153895263801305, 6.7996037915383685, 6.553455933580732, 7.201502437819534, 6.52253910326139, 5.0714176627651, 6.572267619560216, 6.932963238235227, 4.896328982659484, 6.454448708435808, 6.916808331892026},
    {2.33427309922336, 6.897595960397953, 5.202171804508433, 6.804871717271813, 6.885835153888222, 6.799362171329047, 6.860928011225286, 6.936124961652897, 6.921762055571564, 6.966371366495462, 4.96687984908804, 6.867496219866933, 6.794443973937057, 5.328892789669236, 6.697957163522032, 7.234064678476288},
    {2.1172413804975383, 6.307507762427029, 5.171998961162478, 6.892433096918288, 6.888380142900383, 6.80341772996399, 7.073618046958181, 6.334256417660582, 6.715193277402126, 6.982645343536081, 5.111712294886586, 6.999175620066787, 6.860900219802076, 4.922224264854163, 7.0332253789641, 6.813363839344181},
    {2.0796059132782085, 7.05535701560623, 5.074723498870879, 6.697287184598513, 6.200829312386403, 6.817256675529638, 6.845541320374316, 6.9341027734365825, 6.668556570955763, 6.723524049512762, 4.859685907173867, 6.863457400202848, 7.019703860361765, 5.02384696019622, 6.722429128103779, 7.375370922438546},
    {2.506504655935579, 6.630399534502644, 4.757315325198164, 6.8006520622108475, 6.194886247993911, 6.412302407696275, 7.23166896870251, 6.386997353363716, 6.485026690101687, 6.803752746577726, 5.276219729721763, 6.811887889389363, 6.954509770017509, 4.612394572471437, 6.949190837859431, 6.4488258475311735},
    {2.54808979138697, 6.755098895524709, 4.711205662255589, 7.156882165008384, 7.0661971603122415, 6.706690869611876, 6.755892846577514, 6.601447929770715, 6.976050390889812, 7.062184335777236, 5.089949330680069, 6.525742402960213, 6.702970357756239, 4.728230316406703, 6.720137981874868, 6.925169576507471},
    {2.6976128775248904, 6.892191122774648, 5.278674545661553, 6.9632560060284, 6.698354824700981, 7.301871011242072, 7.134482931462269, 6.939048509837065, 7.329402259681895, 7.016175915299621, 5.23476494575435, 6.758898612755482, 6.619477833998229, 4.477045931529798, 6.340528072369113, 7.471244976206084},
    {2.205949503614616, 6.5833780326128455, 4.910377223937507, 6.53064940102168, 6.415225620373797, 6.500702753131989, 6.822971442604024, 6.382442620438041, 7.184664256475674, 6.488750973955174, 5.2168394799732996, 6.926806555195284, 7.112697960838156, 4.852332452214604, 6.454099778532556, 6.650060063238842},
    {2.1381211801175017, 7.04648962255269, 5.057246708199197, 6.865406636615253, 6.867961064263197, 6.915678715652438, 6.538490370170541, 6.790097819510792, 6.510207337458967, 6.837720276039726, 4.65262361734896, 6.612845272459333, 7.121038928044122, 4.825051420781508, 6.92531369196318, 6.920052208049416},
    {2.1138550518533012, 6.553232178068238, 5.060831658610717, 6.765734077402158, 6.5957032618348785, 6.851267242656327, 6.493626827954559, 7.117931053272827, 6.852490571360305, 6.444058940835758, 4.690606763717363, 6.653985282633917, 7.080847439664961, 5.164955297287412, 6.649253782054664, 6.771755872636537},
    {2.498168869295782, 6.78470035902788, 5.039993460929838, 6.649583769729695, 6.720614561011601, 7.007140431573278, 6.546490122715479, 6.31767982886763, 6.844949920035301, 6.502762901324781, 4.952738834115049, 6.465745712852951, 6.705702873415581, 4.587594726242059, 7.177753363210197, 7.197287909074087},
    {2.6110576957846896, 6.850882628267401, 5.098548123061345, 6.922019405834597, 7.295399660614011, 6.7397834756150345, 7.207691322646198, 6.772408974656949, 7.14216859260568, 6.945321381731361, 5.497357914301521, 7.4418902377400915, 7.435905779733628, 4.739004319811505, 7.038337072389699, 6.879453554544816},
    {2.4554794137923857, 7.193104990067107, 5.7677154443287595, 7.30234114904104, 7.46039884230364, 7.125415861279731, 7.564960457505163, 6.8318624149209475, 6.955269493160304, 7.322907992761461, 5.5081206101943545, 7.165500523162177, 7.042664809901676, 5.1035436342345575, 7.321814743070116, 7.145548276918532},
    {2.4005071595051453, 6.91117743142888, 5.016716638410736, 6.577928822826078, 6.499301895044005, 6.638526341292694, 6.8429462990972105, 6.785527137393894, 6.765739922643849, 6.631973874373749, 4.683297752210651, 6.545859062299476, 6.81100957120666, 4.628818597113747, 6.99121196750959, 6.66057801350113},
    {2.5492578482878963, 6.6037617197168625, 4.714615071150887, 6.726830111875716, 6.916267963868148, 6.75665776377309, 6.756483596809407, 6.706446206414089, 7.001760169844246, 6.871777364210889, 4.828352108039174, 6.6894979992195, 6.523194081160434, 4.760257855424437, 6.858283889143219, 6.830360425911032},
    {2.9837822967464613, 6.5550608790513865, 5.38163249434596, 6.7021876124369975, 6.750785394993835, 6.914581886072984, 7.333786100752713, 6.809950886617563, 7.0509003973821205, 7.02001382719191, 5.569021352795946, 6.9694534588320405, 6.892681495668531, 4.493958859544727, 6.906483838879535, 6.789036729060428},
    {2.6257399464172653, 6.907846051897862, 5.031222617125936, 6.784635903037434, 6.854719828384741, 7.106753128827583, 6.838127959122347, 6.586524773247614, 7.123024028537135, 6.733708825037547, 5.358772505303367, 6.543062223468176, 6.984730644710089, 4.663900636283174, 6.820803676516666, 6.812361266279044},
    {2.3616609317308574, 6.684873084030827, 4.945275846315122, 6.649766897020995, 6.520777545498089, 7.300915744506665, 7.230756189202103, 6.930599317818368, 7.031360033958683, 6.71391132664093, 5.196969910255589, 7.173186958929975, 6.719419281422164, 4.7943323122168895, 6.5965995756652696, 7.2752473709399},
    {2.517482933458625, 6.661519253817421, 4.944138404392689, 6.2880140476377235, 6.652494148909522, 6.802900830306628, 6.723498237311775, 6.514605102194484, 7.0233227380023555, 6.473905530834396, 4.995587067064692, 6.633376562486454, 6.252353916430893, 4.5823827506714565, 6.364927410063634, 6.4156807364252195},
    {2.5727285188356337, 6.1082178207100455, 4.846269378419318, 6.307549350423868, 6.637468329230297, 6.813275114878865, 6.591997283889479, 6.451918602515633, 6.62122868409673, 6.728391330258449, 4.448295305609566, 6.1088020360939685, 6.905966683518189, 4.924050704744501, 6.755397804613615, 6.64272789490698},
    {2.1195541225541565, 6.795914578287163, 4.8527012737022694, 7.190778597962032, 6.826748850772984, 6.688940494667599, 6.873215942898372, 6.559846262183537, 7.11016022240174, 6.828058840547675, 5.089869716634184, 6.975990682586279, 6.750649681376153, 4.950345829845554, 7.311719755789149, 7.132084465189363}
};

static const float b2[16] = {3.255375543341014, 6.912175486717639, 5.667436200574231, 6.834968316213106, 6.891227946399713, 6.872566712396421, 6.864474740953123, 6.753366643893349, 6.681940064642563, 6.858805591668229, 6.172098923200086, 6.772547438035773, 6.911831294090374, 5.748697353111661, 6.596109187274775, 6.877654941466135};

static const float w3[16][12] = {
    {-1.2784796211380431, -2.2754180412178333, -2.214974038595341, -1.9735788073696443, -1.3884740920079028, -1.7298993618618026, -1.8036375659924824, -2.214536443118178, -2.624711763382441, -2.5842786284964676, -0.33551977414142165, -1.4202356393976052},
    {-4.157529941126511, -3.8388137345913522, -3.3613649268978896, -5.207378846891775, -4.377201385709578, -4.247982627070142, -3.977781650328134, -4.171456362649098, -4.25395307501098, -4.585451290907792, -5.068296162229164, -4.447207860125455},
    {-2.9126145148851497, -4.500370195635407, -2.895865878272814, -2.6175175982352714, -2.4241348339177136, -3.6218971433298317, -3.5200260950286473, -4.328058216751424, -3.173694071912755, -3.2873439301780127, -3.4903604688406364, -3.052742806130624},
    {-3.7164127651475285, -4.3456384237599215, -4.912237047310825, -4.667261662572973, -4.272593645615059, -4.281883465628943, -4.8039440516174015, -3.787681329242642, -4.81539558338681, -4.780010973973143, -4.7778149172755855, -3.0933942929947196},
    {-4.069776782897077, -3.7318015985167854, -4.413854057536743, -3.556560804251605, -4.219827522769723, -4.248923559162155, -3.808998601088305, -4.433728739014519, -4.555212492233807, -3.620816571348394, -4.837960236313968, -4.369613957604944},
    {-3.92974331113968, -4.143510537778491, -4.502516025947365, -4.982748829758014, -5.046741445284355, -4.236907720077453, -4.783018404075175, -4.414859629327736, -4.147719152822824, -3.8771430272886986, -3.4975120938329676, -4.352703831188675},
    {-4.99356402249546, -3.9043275072482655, -4.388232928762749, -4.1332868131168015, -4.206807570551148, -4.185132390596408, -4.573798737070663, -3.9178714498964426, -4.816676120341798, -4.517869345559178, -3.8709578654886867, -4.6759458826413764},
    {-4.6631177440326015, -4.194451046077654, -3.8191484843019112, -3.2004468497652505, -5.023792708438191, -4.091157690807467, -3.9505036458165144, -4.804202046799254, -3.8253419436032003, -4.099310601768897, -4.053760641378841, -4.775473024215634},
    {-4.749391485113389, -4.021679186400607, -3.8503859558321576, -4.964532061311801, -3.7868554786477815, -4.5980750288103795, -4.309800787550974, -4.613998368017998, -4.358345779668737, -4.247264066440975, -4.3124801298834825, -4.375445144098896},
    {-4.47139632324935, -4.0294721209529785, -4.192403584099629, -4.531193934542625, -3.868016576424073, -3.480048192741683, -4.710977507064473, -4.48667207198683, -4.469564522684379, -3.882077521405286, -4.578546286555715, -4.901140280771694},
    {-3.596435462072794, -3.8652763386013644, -3.1914254842539984, -2.682818809030532, -3.5090764996069246, -2.9950366935804023, -3.516274154684102, -3.6617891371419504, -3.374671024383953, -3.327629134450533, -2.5109891467635994, -3.5462329932392658},
    {-4.645598788596473, -4.542953186148083, -4.671313957179277, -3.8137130919312345, -4.704529074871203, -5.2025328117694825, -4.076259797766087, -4.408375709499648, -3.6547812715258328, -3.9759101302384523, -4.01352139889405, -3.6445572929559042},
    {-4.417170514452213, -4.297399844343022, -4.406770980664286, -4.62639814739026, -3.9429519429894295, -4.771031211062371, -3.8519481560771816, -3.71263836482503, -4.715401498450353, -4.4066442332953155, -4.35344956413118, -4.774568912667069},
    {-2.949231680016972, -3.802345802409717, -3.2367895390953163, -3.605192695897741, -2.7202034564443482, -2.275390131418055, -2.8828045043759496, -2.0290712757411336, -2.718650554096771, -3.522865395024873, -3.870645456393649, -3.201793798153549},
    {-3.7900350134848857, -4.5239495865907955, -4.620164259103643, -4.0217256810109365, -5.266665203141006, -4.275503907354908, -4.454598198329517, -4.38307210130498, -4.667661841332074, -4.482311677690355, -4.527926150279658, -4.475199394832771},
    {-4.518818091882437, -4.229797643562195, -4.769680512911654, -4.573625299652276, -4.036490860829528, -4.80157356099936, -4.291662621747062, -4.270160599100376, -3.5272746263145853, -4.712146486148329, -4.331140861507551, -3.9575688974774534}
};

static const float b3[12] = {-2.139620502345761, -2.992785693891208, -2.6808541443630594, -2.1248145857249763, -2.6469026936809135, -2.5729764086767233, -3.16596531406808, -1.8602188638873227, -2.0334434404206525, -3.0977440872235547, -1.3616030168047912, -2.597178321716877};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
