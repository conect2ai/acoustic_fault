#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.1813511377660817, 1.1433128791720404, -0.5484455566296949, -1.420780783057321, 0.25506424882392076, 0.26330504964938334, -1.5113245762692142, -1.2635121694035616, -0.2186537473678817, -1.2696972159584976, -1.1730033367657864, 0.4317481779135612, -0.7075916552850491, -0.014344304703755991, -0.42009068920794795, -0.7130652422396375, -0.3623850280703504, -1.276840089078769, 0.29352514025645415, 0.7959737568125197, -0.3513896977567704, 0.28013854393178284, -0.06997333753894219, -1.7868679226970277, 0.37563768053075014, -1.2136134424803822, -0.6233289990960672, -0.05525283488308919, 1.2377641320761195, 0.9027449321877499, -0.07644643073308152, -1.325945074176251, -1.8198550008811014, 0.5953937785056288, 0.8504288921658555, 0.2028691157993855, -0.44854383131018094, 0.055060893072457165, -0.9744465938854099, 0.9210403883005992, -1.6323209424974516, 0.08703080042758282, -0.37312911236080665, -0.9401464580434183, -1.9012926791369662, -0.808360904619343, -1.7649766936299158, 1.0304320678291494, -0.44372461806336055, -1.6762791382297453, -1.266142139405908, -0.2875951574032736, -1.7597008651368087, -1.3934431383984702, -0.22956066025943622, 0.23067901151878573, -1.8190445624353462, -1.0099743977651885, -0.17151142319027923, -1.5054281843431023, 0.6864456384638938, -1.5824961671813957, 0.2672520536674274, 0.029667664385482642},
    {-0.639350500407273, -1.5040613926377062, -0.8671980129537171, 0.7548132047099186, 0.5561501527728054, -0.40460835947855445, -0.15381454426557753, 0.3523089984729168, -0.7125480203900085, 0.6105305959575347, -0.09567351410185872, -0.541410078770088, 0.4534493690483668, 0.0812856424531638, -0.19969874814696095, 1.4769469153519783, -0.8097861028500825, -1.1244364003657503, -0.3546869149137009, -1.1368207664286132, -1.3265918909064267, -0.9451630512831211, 0.07972945276351893, -1.1793067204190746, 0.0918625343545109, 0.05682481661702813, -0.12953059666900052, 1.3949319486417857, -1.8161400150777618, 0.09914842295145518, 0.8672928249606834, 1.569636222227707, 1.4391317499175271, -0.08526247088641863, -1.677964366640204, -0.0976413927127713, 1.3706202054912768, 1.2228892325427383, -0.3249715661943603, 0.3580917586610754, 0.9931649835054133, 0.6423494631769254, 0.7556638279788788, 0.7353787177341606, 0.9081285518126886, 1.902404223094049, 0.6433570029438771, -0.7691463779146342, 1.1735320882249176, 1.5211882094100513, -0.8353599798179698, 1.3376316455083817, 0.195912180685435, 0.34351442564912915, 0.017104740364526406, -0.6207151130549463, 0.9756403144918343, 1.6739512045786147, 0.19614875839091064, -0.009392308357678595, -0.7246845715691782, 0.09780035961780792, 0.5809567648766767, 0.4867622989763837},
    {-0.37675990061714304, -0.7878612837144001, -0.808192027538392, 0.5381660086081258, 0.7746126740942378, -1.0232303135116774, -0.14989125428074815, -0.8277582597035836, 1.2302623249726867, 1.279741788232783, 1.620048103547858, -1.007590102887474, 0.504957830516485, -0.2235082286311726, 0.06970364181978832, 0.27414583528512904, 0.2233886842832208, -0.08766021596931058, -0.7008662295293359, 0.7254780115089228, 1.5064641849389657, 0.14702338450160155, 0.03558174638949731, -1.2852824305919979, 0.3337223152190809, -1.3755555148995744, 0.9662033257229998, -0.6471158390392496, 0.1106832513696909, 0.5760915381388314, -0.04850575240469354, -0.26634225382455845, -0.3671380844383332, -0.3878571083320587, -0.45873544107955105, -1.0280410688238057, -0.6623617133047393, 0.9745967959708228, -0.49844584926951, 1.1564118292397432, -0.7443461102982754, 0.6221302568519396, 1.351595471485919, 1.3710420200463291, 0.2563371269831937, -0.29370168421320747, -0.3160892292608067, -0.19924534114252498, 0.34766271327034287, 0.3672037844001121, 1.379565670284814, 1.2472941401547937, 0.028987400142817518, 0.24310756832382133, 0.08891111289409911, -1.2300554574698395, -0.1503698829895452, 1.5532955053441266, -0.21314801532130348, -0.23864223488704117, 0.1324841307527904, -0.5332783292626067, 0.011539809950305275, 1.0767401477430414},
    {0.053318779749897856, 0.5987168289693925, -0.036537693782378595, 0.6287913104882654, 0.30185208836044675, -0.98248198152032, 0.6083739633126802, 0.757887421873077, 0.6314085376063869, 0.2980532051486026, 1.7382167598272833, 0.6753039297298737, 2.012247765839419, 0.8086976610100678, 0.6181919526566472, -0.4565367888167735, -0.14265601035301034, 0.9296764294634584, 0.14092146875546455, 0.9470575648368923, 2.25889884546765, 0.39385135077848327, -0.8540449152266684, -0.3050683540105783, 0.3325079965058201, -0.7764272427439907, 0.7670270880097346, -0.7559847834440133, 1.8947393541792585, 0.1691989829083906, -1.1346025767045917, -1.4343955330348332, 1.8012434457521258, 0.2545755448958979, 0.6869774767121478, 0.4176971667876467, 0.26200901538447985, -0.6070446182032095, 0.7611959560576771, 0.5585788857326598, -1.6178754548129752, -0.025946105989334976, 1.4833063455172666, -0.05704669764654512, -0.4832809538259998, -0.7308991744200714, 0.7632583398846841, -0.7129553478154596, 0.3534841553585857, 0.08732524743635348, 0.24652330458251115, 0.23924991243821575, -0.5163291728658909, 0.5672589973756827, 1.0969685996707819, -1.2429236017615741, -1.4645086855970582, 1.3518897053748427, -0.6225085185880618, 0.6731892597068363, 0.31091432323767765, 0.7747130391296537, -0.39500034798179634, 0.6473255524206045},
    {0.9891697900103281, 1.1859432242196533, 0.14566503149930052, 1.632306168944031, 1.339100380511212, 0.022662022329411134, 1.0823484044320997, -0.6172567974684512, 0.6776139058414901, 1.3842721856639206, 1.9686917982112524, 0.0778787748739183, 1.5043910888651828, 0.40231853421397906, -0.5330906656278885, 0.045562598063048985, 0.3647020294375638, 1.2481565261472558, 0.059711305137417535, 0.17498380059450216, 1.5030303194588919, 0.5501561965032081, 1.299358765119721, 1.5100017358259112, -0.7484909847951939, -1.042326754723782, 1.6748496403069297, 0.24068768857347422, 1.0583074367555332, -0.16471789276051033, 0.00509086915906838, -1.0108976489262913, 1.4558069314259259, -0.33893091950319704, -0.9643195695405548, -0.24519854078220005, -0.7728380846802468, 0.56847272819605, -1.073006220600026, 0.6461148238588337, -0.4498214496686838, 0.8642152961721294, 1.1905235084487809, 0.11620337518491289, 1.043115756331317, 0.3396682407515642, 1.3448836221675562, 0.7323636737623626, -0.47774306868641253, -0.19426852628756908, 1.44583696064497, -0.3799529557136217, -0.7032086629197913, 0.3033932864768519, 0.23335939035014286, -1.4358941951523692, -0.1461437348865702, 0.04911256358154655, -0.7965809459679196, 0.453895691044575, 1.066531282387252, -0.030109391363457753, 0.6797487557947122, -0.7053578217951729},
    {-0.3806996459710299, -0.014518690182479262, 0.30754657601026436, 1.854891109342299, 0.3371996234833155, -0.9431455607526347, 1.359583491042869, 0.7526784500113564, -0.47363693158292125, -0.23534931849881094, 2.0049211881360147, -1.4380070473877404, 0.09863531116348917, 1.1549988604854509, 0.5924077393353027, 0.9411424611913922, 0.3728653069718094, 1.3856741212515198, 1.3015464738458948, 0.5043440154752064, 0.9657473737655172, -0.5412879752609216, 1.6805269611043896, 0.03578354111629814, -0.36609749671261915, -0.9868856952011026, 0.8581605812392504, 0.28803348175227317, 0.6103707959892847, -1.247361884042616, 1.2982150477293848, -1.1901513076930121, 0.8328349611335787, -0.6732094611114923, -0.7033649687010136, 1.5357203101499284, 1.1394716930988094, -0.7025031173218061, 0.26713174740041595, 0.1639599856624833, -0.5900632864432612, -0.5712876509275088, -1.0189648231292217, 1.584734178356301, 1.847522722861023, -0.7383383845985252, 0.9955043455814886, 0.4415410480060366, 0.1821160595535079, 0.8940605361761499, 1.2322021540810115, 0.019393962601694795, 0.09153165689074304, 0.0031377381440133552, -0.6509104342824404, -0.3189040537266569, 0.021861619526550035, -0.5500935984609621, -1.124592000616604, -0.5667909704328098, 1.0986758928299265, 0.9092373076948637, 0.595465316151189, -0.4382879323538703},
    {-1.2548771164598034, 1.1622025705388113, -0.9170302194381657, 1.0368874107624564, 0.07105732440223189, 0.6656663119804468, -0.7449033980877782, 1.6424346395389369, 0.03554041942511162, 0.7802305394396816, 1.55013078093904, -0.9502797410196054, -0.4371597154857786, -0.24008624415221808, -0.7936422301364368, 0.48141705305480215, 0.29633050481141354, 0.8705641807512876, 1.199641295427376, -0.2313554015627338, 0.7780708022233499, -0.11057450608016434, 1.4119111321452158, 0.07431616812316119, -0.6446688814751997, -0.34530251371529846, 1.2904182938821533, 0.936134032291907, 0.42023871270001856, -1.1411987884856583, -0.9767076334658592, -0.7281829087677257, -0.12313122223539345, -0.76926366733694, -0.17435680011967672, 1.160286376983552, 1.099869658980647, 0.4954801739426312, 1.1942333019958278, 0.5508413407509021, -1.1894238127297105, -0.6709567690484912, 0.9897417936210873, -0.025615777154865082, 0.2839240590749386, 0.31504659004351654, 0.2243191571473026, -0.008426516763949489, 0.7955849518782138, 1.3079748938957578, 0.7085183612822089, 0.20293290565512054, 0.6304575125038333, -0.23131294147045067, -1.1569992253112662, 0.7742856255949508, -1.0425295407958612, -0.7310605206237084, -0.026404995741744576, -0.7338185689982334, 1.5624300710739991, 1.0550197603942928, -0.28387815322618637, 0.4919881709573687},
    {0.08460507291897047, 0.03540448712200225, 0.3543128599491264, -0.2477509383227529, 1.1756008240077989, -0.7560988789996005, -1.0280074197737188, -0.03960025402173291, 1.5044662169590775, 1.6734762535545074, 0.16621649888004608, 0.4936541497900944, 0.9361146419380041, 0.6277325007144654, -0.23530515450770265, 0.6500897299277963, -0.6183677695065445, -0.33207814295655497, 0.837756287709299, -0.6163695002682575, 0.4657634000100867, 1.0966112853384198, 1.1860278988213095, 1.3218601790121252, 1.081915782480917, 0.4057770500297402, 1.5112129824837142, -0.9064806096466153, -0.04839729308505272, 1.040950156489606, 0.15968049540375623, -0.14093591053391497, 0.7370892988860398, 0.7094531334005882, -1.4010775419601242, 0.03864616859385938, 0.9573583230140549, 0.6140248921116086, -0.16511953363743767, -1.0357231054764915, 0.8564283312305081, 1.0713714230316251, 0.00848022792278304, 0.6679043597205376, -0.6072351590225207, 0.6709251473109044, -0.43036729054045947, 1.1431449693533968, 1.076997550409187, 0.09956803342302104, -0.31042224975691635, 0.23704556072898003, 1.8040494424338407, 1.4344573205090048, -0.178682257553634, -0.7346676794110518, 0.6954203882311082, -0.15462193698242324, 0.8623886794279144, -0.00804231391180873, 0.020974486640279788, 1.6689147116299394, 0.2622131054469438, -0.8359161368803186},
    {-0.8860905995590953, 0.7700098752100751, 0.7215357240092622, 0.5675392644359656, 0.6370021099131711, -0.07773176016220448, -0.8789219068757207, 0.10512094083018958, 0.2574144838139575, 0.4354087710332659, 1.5235916752664755, 0.2773256008773471, -1.0925306770120078, 1.3342572456885575, -0.48482796527127164, 1.106807414068129, 0.7293466819541191, -0.054488824351941696, 0.3719318160124835, 0.6842530728237133, 1.0234170768208082, -0.6303480343421521, 1.4552392944278818, 1.5169140075227798, 1.7226355092307475, 0.9582255283558989, -0.019540781664654346, 0.03887566451507034, 0.6734806382599747, -0.6963030913759947, -0.06475616749117236, 1.2627136844958569, -0.8688393450610788, -1.1773914932805851, -0.817119080660739, -0.05436725342418264, 0.10895432443518249, 0.11051128031290149, -0.13188515497837972, -0.20383716876330304, 0.517044856395079, 1.2060516457715804, 0.06908462022098381, 0.8790406188935379, 0.30742708558418236, 1.4712834752906807, 1.5896733153358207, 1.1113799259899897, -0.03984447602695085, 1.3682487245100916, 0.9244794319655627, -0.571231202839421, 1.4655322247533844, 0.43540569285399205, 0.6143239205604429, 0.5252405266987916, 0.5158698174871085, 0.19438770402415143, 0.9796647246006364, 1.279822847213319, -0.02587274784151108, 0.8482993830718872, 0.5006036620334675, 0.9858769490799273},
    {1.1042974118092115, -0.7362189957106293, -0.9050887252095098, 1.2089577968050635, -1.3447963767585118, 0.3094611681328862, 0.9138329625244518, 1.1936243928960173, -1.1598657309892453, 1.0306432011465658, -0.043709402677419046, 1.0397565501822557, -1.4779593405899834, -0.818196188357061, 1.3906085127877013, -0.3542029060574187, -1.0606795841890977, -0.11739833061391332, 1.3078256657904135, -0.9153911549838083, -0.7689974646336046, -1.3028799609870783, 1.2182292372442662, 0.8310465612679523, 0.04954322407676388, 1.2353920953598023, 1.1518061763105572, 0.2661369595555557, 0.42047424916399323, 0.028598746595076253, 0.5508162964967466, 1.844524574589449, -0.05779918304431305, 0.03843883862321414, -1.0902982460278228, 0.9910748093757172, -0.8402623329433194, 0.09593164707266176, 0.05408716810994078, -0.2336689275906612, 1.027253849429727, 0.4277202812232698, -1.1691714770680186, 0.9965777252619158, 1.2909611090569384, -0.39897059442392313, 1.188034903579294, -1.0238407734203356, 0.6862420952646432, 0.4454111239488119, -1.154539190319704, 1.0993823423746683, 0.5091653985392918, 1.287900287367493, 0.5378000758038272, 0.8664368222467363, 0.9528368978288325, 0.8770893611337827, 1.2095247256248223, -0.32032365608422547, -0.08177829555236552, -0.502588080009935, 1.330025814388385, -0.19676904772747184},
    {-0.2653142499662027, -0.17099142010627824, -1.130577205671826, 0.6199887377471823, -1.4186159111944878, -0.8387682864179247, 0.3867531666958526, 0.9345082818029012, 0.43939580513010223, 0.09687024830994916, -0.49383164129593754, 1.2483960496796103, 0.7165271681201099, 0.13137824747941046, 0.21211296935326696, 0.03501155153635623, -1.1996055220793496, 0.6745608483972134, -1.032577647828911, 0.9120921245931569, 0.08761579289764446, -0.6819750045291229, 0.6708264625552484, 1.178974506320415, 1.2645348401011782, 0.5978318287870688, 0.17629979426012532, -0.31734504208124, -1.0426040871553413, 0.26532263958942254, 0.47436938973567006, 0.8399833214115653, 0.8846972544268653, -0.10250894373448427, -0.6096791798729431, 0.7551687335946764, -0.35427992416331194, 0.18330160970020976, 1.4975183046868759, -1.0487379616874648, 1.2751051960060455, -0.33931548162593406, -0.4496629744125592, -1.1012627373571022, 1.6364733544429997, -0.7739190050584083, -0.960443955262656, 1.0564374068771438, 1.056367428697633, 0.9538378011130239, -0.8281645826414944, 0.3041851394639474, 0.24758607072096023, -0.8099954919656849, -0.3592595785363005, -0.7424383846730342, -0.4948298616413203, 1.1485621465906983, -0.3832021431232586, -0.7836508815200596, -0.7366477099609013, -0.8268305963702414, 1.4306547067276447, -0.39327258767272394},
    {-0.7916371133626586, -0.6501962772486135, 0.2062138112863946, -1.6339236312484706, 0.587437204289249, -1.322367047481198, -0.7470457176225594, -1.1282742650775297, 0.9519419420884487, 0.9367375559377211, -1.5497077559417123, 0.21595862470939556, 0.09395832057407989, 0.1017384266129704, 0.7847877969182485, 0.10141768991185064, 0.8308277991371295, -0.45269007737505557, -1.296300981580293, -1.1992091864321663, -0.3180607606541082, 0.8434036670358404, -1.3558733774627298, -1.1689434741038598, 0.3444645919135672, -0.3697737371203748, 0.16283682685832324, -0.09754787316456424, 0.20418063554542215, 0.9354429039496855, -0.3370160721879839, -0.0623668938439386, 1.3120048476096924, 1.210693666742962, -0.18723546063824792, 0.783824182271187, -0.8031563643552715, -0.6307406962058406, -1.426073153760906, 0.9665322194598169, -0.5590533646898509, 1.2814945580729462, 0.6646362712856941, -0.8192723996151863, 1.0247340117192125, 1.2148553112799647, 0.19634374596347828, -1.1703876512998754, -0.4619057380103332, 1.109906568945948, -1.0087703283954783, -0.7708050702096405, -0.25946414890713476, -0.2629576345472423, 1.0884128413126082, -1.0252834013370664, -0.27770419929327844, 0.26439251559687943, 1.302484268552991, 1.5372144405508048, 0.5092736317806639, 0.9774307370371595, 0.5018819126327961, -1.0230456672556025},
    {-1.2093397346718977, -1.6902752974592827, 1.0414134407646076, -0.20072017765062988, -0.7179616722314569, 0.5370242429056746, 0.945672769200528, -0.4018211015077527, -0.6730343096729826, 0.7271425786420337, 0.596243039634537, 0.29344137608088183, -1.5908091323950424, 0.2661694464054833, 1.1488440485595741, -0.9012345819407424, 0.7057091786969327, -1.0359958877044735, -1.035407544951258, -0.800129229235563, -1.8236373218581772, 0.000550771457189894, 0.36293471691562096, -1.2342887638024542, -0.8291926546288275, -0.5773059713758656, -0.036126333676993326, 1.4440465841206434, -0.16592051286910275, 0.19434718079343102, 1.7581157343489973, 0.78363490860284, -0.30688452734656435, -1.2080969981206606, -0.3317526793282062, -0.9791385041863709, -0.13529915136629894, 0.6190716362807193, -0.4864575065950306, -1.7129247372537841, 1.3654046599940584, -1.7302005328224004, -0.4223051497834374, 1.284215798219104, -0.4287617782646692, 0.8870463086896035, -1.46596182498295, -0.4194842317148156, 0.7419277678054669, -0.5271820970028732, 0.19018654453065223, 0.09253902354089948, -0.06063010271513922, -1.2262193966471657, 0.8316479819281616, -0.2282276433398893, 1.3101118643963916, 0.4272919428151633, 0.10234209801178813, 0.20123302346161873, -1.3912784920698593, -0.4517677133207355, 1.0050073282986716, -1.331699498858103},
    {-0.5910728091278561, -0.9607961594585045, -1.5165538163182006, 0.983623529604838, -0.9512491293584887, -0.2677621546886523, -1.059684492936802, 0.3556283679865634, 0.8851272731421947, -0.5548034248357908, 0.7534696355393785, 0.8568188696443619, 1.0690737272563196, 0.8915358374307556, -0.016002297143112576, -0.4416061595600354, -1.1197297154469736, 0.662173556930308, 0.40602010412812595, 1.4482689504968926, 1.1481140485727528, 0.7639100655057411, -0.16077798440386254, 0.8000431148817028, -0.059527637989561136, -0.6364729298862848, -0.0545240726196105, -1.125229108828196, 0.6133569442302513, -1.1888937015079089, 0.04082602742549478, -0.21277601038679061, 1.7978100789720555, 0.9403454541008355, 0.46390645731766483, -0.3987426658012063, -0.5411631229234964, -1.2649313240053357, 1.8194068680040747, 1.0455387233877567, 0.2259221984120142, 0.21070000060288635, -0.2661717982960958, -0.6597193749012067, 1.000807756121335, -0.7783110357854961, 0.25185617011551975, 0.9006280956289787, 0.6441361555625764, -0.03526366291171599, 0.5477604245257957, 1.0484702266316333, -0.4878658582323027, 0.033041393761806245, 0.9591108342634829, -0.6196951319924148, 0.10558144805931817, -0.2544912167922631, -0.27056744086159307, 0.9177566640958108, 1.4766076875074874, -0.10801113831011741, -0.12004294958175044, -0.7511721680617175},
    {-1.0357270760864825, 1.043058133724131, -0.007429835363850943, -0.019354807707381877, -0.8120476847238295, -0.8706673298466004, -0.20981055467709764, -0.5733567799317347, 0.2505455120511123, 0.1199074655558081, 0.5475553268072877, -0.9509231058716637, -0.44070834584397184, 0.20888349163038752, -0.5258288549695274, -0.44782911506853557, 0.3635051268145767, 1.4301662113539584, 0.4470326278064206, 0.6502823845627059, 1.6571725148521768, -0.41590889839485135, 0.07164080882038404, 0.45592869017087495, -1.069772746126648, 0.38765066677925636, -0.2566911145691008, -0.023651073995602536, 1.0523300814379422, -0.529126163143776, -0.6556410983034878, -1.4351303303300305, 0.5049261984608145, -1.0894225310206254, -0.08486900690503534, 0.6700245955013153, 0.5088501200519463, -1.4424957385770998, 0.30059813757369247, -0.7558896805974231, 0.0348150025982778, -0.754436247964962, -1.1458831762300166, -0.3895300507739224, 0.08785763841394688, -1.4973747218241424, -0.47063906525200166, 1.4827129793724532, -0.9581195133058886, -1.0229934380699668, 1.227676867311571, -0.3408071571968128, -1.4151775583637822, -0.48695472522175426, -1.6403200400776823, 1.4099808167763836, 0.4326010022008924, -1.88157690704572, -1.1367044533420985, 0.4609402529088654, -0.4042275909500688, -0.17874967833893143, -0.28587910609203016, -1.2591442593628672},
    {-0.5964476023767121, -0.7108294023963525, -0.8109650592682018, 0.25359257044136174, -0.2706874330562627, 0.31678433452468774, 0.773820183183514, 1.5040748442690923, -1.3268112671354264, -1.062655265463314, 0.7818438840640635, -1.3688297475934752, -0.6630531269880874, 1.0207808668779974, -0.14920198647131727, 1.114491503130592, 0.20894429744087356, 0.35322927460599474, -0.8835403545108067, 1.3560292725671497, -0.2810042521267377, 1.2572463145979667, -0.3790583529548892, -1.155625119995472, -0.9758869508154592, -0.9885873428516601, -1.0044021884110401, 1.0742840628248955, -0.8413485232648287, -1.1269641164508826, 0.6959153841115593, -0.2474887614651776, -0.8264389270824419, 0.6110627320848077, -1.1771852940043055, 0.3749244882551146, -0.7905212456681703, -0.8231011836853175, 0.7745715509419859, -0.41491349165524766, 0.9726204819933001, -0.1814059426150405, -1.5824218429443448, 0.37666812406396666, -0.31102372655753896, 0.34125996946865983, -1.2810734109871773, 0.516600305813452, -0.8515300694479622, -0.6125818777710608, -0.6673620911599699, 0.1985651830646487, -0.8790257124215276, 0.852751746324887, 0.07454561797178323, 1.6163045278352803, -0.5257561133526709, -1.4700868165042216, -0.17275514299831246, 1.1011461560851066, -1.1773297159303246, -1.3725250920125602, -1.0946128892201565, 0.44078254681021767},
    {-0.05864758046761441, -0.434743335171665, -1.4892401960065218, 1.0135234495902323, 0.5273054663691246, -1.2468533708892804, 0.14552311738438253, 1.7289091971797594, -0.43509158539471465, -0.8788943861658385, 1.0048662297123558, 0.3917178897920576, 0.8982387912414509, 0.3252716029097844, -0.47709888005408924, -0.618228318596475, -0.04975241064465271, 1.254763717081037, -0.03470527133058798, -0.3374097888404753, 1.8628070922270525, 0.36996038321911656, -0.18304489937070734, -0.019946348802337664, -0.5822780738247326, -0.07995084523260722, -0.37482329878924286, 0.6321313446696595, 1.2483125365213876, 0.14363618113040197, 0.9463901261001149, -0.41822207436250514, -0.15282957737779865, 1.0509601726724855, 0.3973248042115321, 1.2964338578893615, -0.26822943757708495, -0.7229189494996575, 1.8897845473566302, 0.5371610611505373, -1.1941639506686472, 0.2237793647630446, -0.6950527652610125, -0.7284790415151942, 1.6321297714785559, 0.10210784776687624, -1.2595378629883536, 0.5903845383885622, 1.3917831606586009, 1.560141196917639, 0.10252992436518611, 0.06608826972244433, -0.4970264452683662, -0.20000406311893332, 0.46569212898331225, 1.2035733133569038, -0.5328482637281364, -0.4672202833921892, -1.1866175843368987, 0.04487774726288461, 1.6111079495187257, 0.13819675817923086, 0.1734205081343405, 0.6146127624578417},
    {-1.0230468518419202, 0.8375212894308443, -1.4420290356693655, 0.054382980959365924, -1.4928457558303208, -0.35262272726059635, 1.1732143617212967, 1.4475769109777652, -0.3502147339722342, -1.2456441011378914, -0.27209575633325606, -0.0789863834853561, -0.20076045810635823, -0.3270917851079572, 0.589950982945559, 0.7974545466763191, -1.153971721636831, 1.6854700010226205, -0.32057763557140073, -0.0842248445715897, 1.3000918373466412, -0.2637309136459175, 0.15979812553202447, 1.1944686150078259, 0.4228540077208872, 0.6763764287627446, -0.2676005373708289, -1.124813169308102, 0.020440956388175325, -1.0448611709124498, -0.7382408960124913, -1.0983322982709818, 0.2726326908262023, 1.2584625983667084, -0.39945712601904676, -0.06714627024145452, -1.076979588343673, 0.6954317330410059, 0.492985022118462, -0.5516324831998112, 0.6846550359038562, 0.08599985336622112, 0.9768252996097464, 0.6387985498356068, 0.3962291580354261, -0.4896546042872547, -1.3333716439615366, 0.2961041510789364, 0.023460696348402622, 1.3769931586414432, 1.2973604063324748, 1.1019504692657212, -0.272404338508592, 0.5008394716676052, 0.013159875275681533, 0.43996639623683786, -0.36355050893601315, -0.20249005521138305, -0.7033413041667363, 0.5828779830138773, 0.1697846061896933, 1.1664757917961759, 1.1198423401978308, -1.1717970331423861},
    {-0.6158829120610028, 0.2649199184170162, 0.42764529083982616, 0.8029430703365623, -0.23936414938942865, -0.5489214098408266, 0.414937762392641, -0.8705793179259473, 1.0003572555799367, 0.9156889195183868, -1.0727153897198574, -0.7214234328382869, -0.8035044207213735, -0.9327243642058659, -0.7368197493474385, 1.3728584497190781, -0.7834980061060586, -0.15382528249359348, -0.31273367764384674, 0.4326644155348713, 1.5414261906373303, 1.3247959370337492, 0.5909965322318581, -0.9085210119256152, -1.1239972886884713, 1.1524099184781558, -0.4248403465468296, -0.9269297729735197, -0.6490209654860994, 1.3551795189366478, 0.021292376036924427, 0.27103807364527877, -0.9301706117436251, 1.3029545236277595, 0.17484599107869003, -0.593861611300399, 1.5691151205225764, -0.4567791523757866, -0.603891069019723, -0.29132777783127567, -1.0386828844311122, 1.4956595794027898, 0.029439065199001406, 0.8577212926876656, -0.7401360959968599, 0.8241018730463738, 0.04426649651259525, 0.6474631904473457, -0.10850956491380234, -0.5479903176468327, 1.220557647101271, 0.6400359368280822, -0.635409695555338, 0.6011976982769968, -0.6066264934187081, 0.4783746125085965, 0.183196134425779, -0.2915715616291331, -1.258394812218886, 0.7556507282016804, -0.9999488846249167, 0.27063716223039275, -1.4707000926361133, 0.06237084573359569},
    {0.1191833521064875, 0.9633670175009899, -0.18609344030397088, -0.7738633314944234, -1.1982501187188812, -0.5012092861937428, -0.8487425744953878, -0.2742546329944871, -0.22022749718238252, 0.7295442300907441, 0.864997255676288, -0.33913887655988273, 1.5427794872072982, 1.0309817417935394, 0.415766046713759, 0.7356731681885635, -0.7510280030135004, 1.7212355772075232, -1.4894315726842011, 0.39654743091270145, 0.5903650631664391, 0.6011683755698414, -0.5330662512042108, 0.2827130429722302, -0.07895082641032407, -0.8981417677320649, -0.6812350244426261, -0.6118400328785023, 0.22918265519286618, 0.057965402831059644, 0.23843876634021366, 0.4324940147008185, -0.39635918322007757, 0.9999356714942439, 1.1799820519381132, -0.5380542817562677, 0.4975456756748523, -1.1687916756884782, 0.9348500068249948, 0.569573372840551, 0.3789249264175795, -0.03784353698939468, 0.8524447956552766, -0.7442059014095417, 0.4730820682253069, -1.4299953782776307, 0.3636379628483036, 0.05334198952230448, -1.1736084918577263, -0.16190743129578322, -0.05386822801790072, 0.14215057113197085, 0.7117410175206772, -0.25005922118533314, -1.3251512058804662, -0.9756652082352008, -0.7857825904334598, -0.4931932657682358, 0.9226322347113698, -0.7194833230121462, -0.9483291632701698, 1.6556664004082797, -1.2786473629903201, 0.26798148619622847},
    {-0.3270330692625271, 1.264317075171599, -1.2720253537364552, 1.19502126755522, -0.34335104994817317, 0.6180081770944874, -0.7511672356605825, -1.1608263069167033, 0.26728263162915755, -1.4539362966768705, -0.6271785472479806, -0.13980399247926203, 0.1732735492665354, 0.9872564875625903, -0.29663776745526155, -0.5477867999404996, 0.9670701270811611, 1.3644406700255074, 0.08321759056526949, 0.48745979666269257, 1.31576441082633, 0.15687989368202077, -0.084221832375831, 0.8536792809980023, 0.524548739547804, -0.10448007011846454, -0.5238978056959813, -1.5603804562878723, 0.6932799699041963, 0.2853046088207553, -0.18699434787436994, -1.3004308833596199, -0.18548395229148737, 0.23774641406094432, 0.8070074027699742, -1.03805437209994, 1.3965227216119485, -0.14157172959899325, 1.6161186416175009, 0.40515209072520236, -0.3836671044419747, 0.7345866982339343, -0.4302708388963763, -1.6160910446970094, 0.31083060592511197, -1.3082051894716062, -1.0257942100107829, 1.4408511475280956, -0.43738888365344514, -0.05970543927004913, 1.4005782798339539, -1.4736584989677493, 0.007534109698905901, 0.4450606233524566, 1.038341037744639, -0.49843193257478496, -0.531763865687862, -0.3236031789074164, -0.7302162014976323, 0.8048425491030804, 0.7639786427016986, 0.6869031498855694, -1.4256127556671647, -0.7576886023642139},
    {-0.7617091312787522, -0.0850119954062886, -0.5996513290253974, 0.7127349332420617, 0.5444244945816309, -0.8224786229691577, -0.6086428116464783, 1.0760683085948626, -1.2390670501407886, -0.989770451255547, 0.8967538743251453, -0.20868702100234193, 1.6473881280280747, 1.4224312734182853, 0.06135012442834316, 0.08286855213580044, 0.5851785550312729, 0.7340843043699424, 0.28490218994663946, -0.3358989599712405, 1.1057206379271756, 1.4516039503784688, -1.3346029132737987, -0.4071013726750442, -0.4151863323487298, -0.38487372400763914, -1.6860914113344938, -0.38142638071471124, 0.2996759769207311, -1.562384887069193, -1.5830977204602301, 0.41612798485875746, 0.4310310892122071, 1.0843569609357586, -0.4996561858786588, -0.37734581331074757, -1.0125778728445936, -0.05891001899174442, 1.247919450331005, 0.6487655937088161, -1.237139599721817, -0.010543851104120672, 0.5649743906173317, -0.14216002704290584, -0.05106184379851245, -1.023002504155775, -0.7299224317756567, 1.35964565624986, -0.9261269493333506, 0.15308381871732388, 0.4127957943620379, -0.28200590228570765, -0.7578198328025256, -0.3073079320692585, -0.4023982584180865, 0.8604563901535204, -1.4905900041024367, -1.3788803361493587, -0.3016424814913451, 0.7562296187537642, 0.20964935282269148, 0.8388124827788445, -1.1918121858787034, 0.7614311492902303},
    {0.2850401603499224, -0.2372701989205046, 0.12114029013392946, -0.6262649400127663, -0.8221687416508361, -0.6048324637152569, -0.2777645907691586, -0.4571147342265079, 0.7260979283650096, -1.3165347123817328, 0.05524562109958329, 0.1472645767909746, 1.5853908290988583, -0.973356214774494, -0.7285071416087232, -0.8493260988865995, -0.05841614744025734, 1.3450806029185391, -0.8313053350459417, -0.4251115161680288, 1.5088723756439437, 1.5758252115386333, -0.19753429890962498, -0.5688257696675035, -0.5676425361326779, 0.9041626359056094, -0.5654937702883926, -0.5726559863478164, 1.4655071752175444, 0.6095796931439798, -1.1527182288473001, -1.1943670390098586, -0.02455593943357321, 1.274406160093065, 1.0571747037875774, -0.7916675065402697, -0.14917287304367538, -0.9538175865335372, -0.17369227337865858, -0.17958636408284762, -1.3841289743020462, 0.6440305695252989, 0.6547204738284406, -1.5533058941373374, -1.0163644225280992, 0.68648555825988, -0.005007215414918848, 0.8162051210623091, -1.3841833964745727, -0.7287417576812497, 1.0224438348702025, 0.5699492860103054, 0.010696962628852637, 1.3117287319125321, 0.14816542053997062, 0.7935414263352655, 0.06036946667008392, 0.6793878044944706, 0.37890241108722456, 1.1807371265984477, -1.3070966154768153, 0.37728145289902354, -1.4517322063411646, 1.3176301752788322},
    {0.40618737066789135, 1.4300189482459191, -1.1822972044490192, -1.5062666083643803, 0.5675805986475574, -0.17689936040652324, -0.11308945787733979, -0.8825382105031612, 0.44269947160048145, 0.6322474668008728, -0.3672297851470796, 0.6385493597524781, 1.945417275201124, 0.5618694581631131, -0.5938854918696072, 0.43903550813001485, 1.0477758537526876, -0.5041889206053751, -0.5871164996338124, 0.14559580306691725, 0.48994873259026045, 0.7317713916840533, -1.2370033319306735, -0.378597430222352, -0.010113143357029172, -0.18728819950090492, -1.0615364008629684, -1.4060640470638266, -0.8218731737129888, -0.2699431244070496, -0.9834239682495592, -0.12282327339616174, -0.4222082181350101, 1.0903309311909135, 1.4385642736826336, -0.18101180454045807, 0.3903418002174192, 0.2732104469278059, 0.8396158791256211, 1.0901803522955564, -0.9214528109149845, 0.7545931546977686, 0.22423877553890512, -0.5751823851081084, -0.9859987250574539, 1.0342789098942646, -0.08205113420128154, -0.44787181889282573, -0.2082164878174699, -0.270281441873498, -0.6097618238680903, -0.5434984393991148, -0.3795743035011936, -0.1478363321133298, 1.3645996193686694, 0.38897280974715953, -0.277624626875172, 0.5367788158644831, -1.306207828814143, -0.07441976714867038, -0.7453436058886267, 1.6415202713710917, 0.1132283233055855, 0.36236339133008516},
    {0.9672212352769731, 0.3267177548973223, -1.3028817600607434, -0.47600524065560457, -0.804972028467904, 0.40815496977396826, 1.112975001994141, -0.0385287292978746, -0.6237376580876814, -0.19204279542923064, 0.4154973995317248, 1.0737085534663378, 1.9275379922599674, 0.17342354652589823, 1.064634010466899, -0.8406492831986196, -0.16559828081105646, 1.796950575291323, 0.4700334189375593, -0.34034342136200907, 0.020389667795212216, -0.886299208891846, -0.09627021893710443, -0.8488391061617861, 0.5022938901314532, 0.4998805211087475, -0.03653866014551162, -0.7996686280489437, 1.3799336261349961, -0.9872819336398516, -1.1829724579369025, -1.479538840487439, 1.128181135163622, 1.72317646477491, 1.332181743167731, -0.1950518565982388, 0.6242899467122915, -0.04488537340661065, -0.3731077850035002, 0.5098149084980139, -0.5277822351329771, 0.19545174145447683, 0.4036081836136848, -0.9541383761914466, 0.45540478681387025, 0.1388722533410508, 0.9822830171885681, 0.8369605127602469, -0.26579076944603097, -0.40869937655558963, 0.7244496189395324, -0.09757629947099124, 0.15841560907856006, 1.304784314948227, -0.3974783592495759, -0.2236589986442475, -1.6158218220788827, 0.3851915395539935, 0.45899469245573493, 1.1484490575605455, 1.021825856639198, 0.8294857495867602, -1.106851792453431, 1.2992397399899802},
    {1.335852283116164, 1.2460807386186665, -0.34154401046898936, -0.02476080345901452, -0.5467217527777214, 0.06464040891212368, 0.960467827495399, -1.3917371333195356, 0.17156064848321026, -0.29692930548999824, -1.184857607587536, -0.08382120355088725, 1.1121372140262542, -0.5255930416937754, 0.08345545201196114, 0.19067819980653045, 0.09565646109849518, 0.8059288630532774, -0.8147155489037323, -0.5930400527153785, -0.0015474331975828743, 0.1630044569620607, -0.6530245894438373, 0.4843411188487835, 0.6700298317049992, 0.4846068943282049, -1.323363013010288, -1.1651148837839147, 1.0400401060140674, 0.09366577141192212, -1.169630557598482, -1.3517560708658043, 1.440246288003037, 1.4555519676329225, 2.033786987141772, -1.200245350041631, 1.3163853615821723, 0.42942313800219745, 0.14756033041262773, 1.1859229175634207, -0.28283771819928766, 1.187673466758725, 0.8387754062725639, -1.2228849368869605, -1.458713274632351, -1.0677635625494843, 0.12808785132950626, -0.782395915127045, -0.3596043696164808, 0.491645658486775, 0.46792656334468774, -0.6793191425569839, -1.5788307712178653, -0.45474902815727536, 1.32473198345041, 0.9522631339196488, -0.1760557961389447, 0.030049568238839627, -0.247385447870735, -0.00956617243111335, -0.33027453569433124, 1.0869339585051185, -0.36426056524913064, 0.7953494658809352},
    {-0.19773701485128342, 0.4699007294727792, -0.6338597966426449, -0.8421860568887528, -0.9054803856134606, 1.0312347292905393, 0.3080027097393186, -1.0603508159335693, -1.06635624448078, 0.21045739556089466, -1.1548701744457497, 1.5652544676760458, 1.1761526717219073, 0.32250913177119217, 0.46394559835513877, -0.39164488748495824, -1.2128690448612574, 1.7180855729892992, -1.4001544509861577, -1.03562313188894, 0.0696704612011933, 0.9801141045020025, -1.2354963012691131, 0.8511024914090444, -0.41716692850656834, 1.0470301795449704, -0.8387039780288653, -0.6124228563629723, 1.2794992926059798, -1.3077234821311696, -0.8557953522411329, 0.07425496028203593, 0.7986988065744156, -0.074358527211237, 1.4046971783927626, 0.8213403417472166, -0.7062511879602051, 0.0267425237161003, -0.6539002900864114, 1.0998059718205975, -1.9546005296304196, 1.4448376708033677, 1.4833237884933024, -1.091238941697324, -0.7040251878589747, -0.9223478486804774, -1.245550253380024, -0.8628712238506623, -0.8389355819297265, -0.4923916437637001, 0.9507248121867455, -0.7414925252374421, -0.7779192723430243, 0.4578330699148667, 0.055798859935671546, 0.33910126220805625, -0.01719367704071492, 0.6050545844718852, -0.29454760918618705, -0.5511153810669858, -1.3340401978788061, 0.2535801610985458, -1.648496741624797, -0.7396065422472733},
    {0.37070511429925657, 0.1029807164523976, -0.3829025616848462, -1.345318530589737, 0.7982453626998677, -1.2173764934844382, 1.1999506950960863, -1.082725669911792, 0.7161815379282038, 0.34943768551831783, -1.042433778798329, -0.3019146133526467, 1.4823542245316188, -0.9249672049373044, -0.43350240060276274, 1.0295019744158926, 0.15782894890779292, 0.5273397609249147, -1.1031605746713689, -0.07801077324463002, 0.14856747944798307, -0.11854399459309448, -1.3820864553634602, -0.21286268160005586, -0.3035795614072202, 0.6186219362197176, 0.43378965261269875, -1.637447362517541, -0.2985376907308468, 0.6006116502471837, -0.5890347119901459, -1.4396811185039489, 0.43726225449130196, 0.37197071037933016, 1.7673193528918456, -0.8461641240261032, 0.6567934293798806, -0.1693565094025279, -1.1542117306761268, 0.0671197444154353, -1.5633103416253211, 1.1925871531855168, -0.36944637891894866, 0.7106188300801842, -1.0885643693271803, -1.2884168487377514, 0.8189586870183281, -0.748261495142287, -0.6524132811618111, -0.8911194408358408, 0.19358570007774173, -1.005991357250738, -0.3545588742538851, -0.3462094777926828, -0.5306689298269867, -0.7809589921115311, -1.5972047685373638, -0.031677332658113524, -0.6214845219845873, 0.596282493879517, -0.5764615093345741, 1.292569949467888, -0.24210189594243126, 0.4134624490661913},
    {1.3422223779573406, 1.340018153285797, -0.7647800788370681, -1.0789830819056674, -1.203736731097601, 0.22860970152758808, 1.2942580204105105, -0.2264601152957854, 0.6358398966964296, 0.8441934731565799, 0.05796650658902475, 1.427861950827726, 0.5620154548900429, -0.5094237845229158, 0.3498845920010234, -1.1496694957764448, -0.9541243831813798, 1.8362791216236027, 0.45332643379991405, 0.04031139867108369, 1.6236381950664434, 0.833275177141565, -0.6660074095707842, 0.823077855658126, -0.5858699425784089, -0.25973294120879403, 0.8757131238754982, -1.9181011601973776, 0.4992851328327773, -1.0308649001494778, -1.5469114972062683, -0.33368126841885415, 1.7491927098365034, 1.6206315286572621, 1.422455216389285, 0.45266248938309417, 0.38922053938739676, -0.35398326960316384, 0.026924793521636226, 1.3419766175094854, -1.9275790555641101, 0.237021935521566, -0.3373071530491428, -0.6190959217214729, 0.3323932381436754, -0.1506067335637999, -0.6437048203645206, 1.2045825077036683, 0.6588579081411392, -0.8592338008485242, 1.380037432462536, 0.7489155770801527, -0.3935933308351709, 0.9239807018549885, 0.10316751580599685, 0.699973541061415, -1.5973352099047018, -0.07317753086517352, -0.608061549404982, -0.3994281952985621, -0.12642137403129494, 1.5636696652401916, -1.28002251031829, -1.1020893475652398},
    {0.30881546111191416, -0.8843979696712185, -1.462414380254103, -1.1340520911708134, -0.6849296321497815, 0.22645576348015745, 0.88932854495472, -0.7371971868446828, 0.16491863614303076, -1.0566262786660183, 0.7537120543355269, 0.7110812392259866, 1.3983035671735013, 0.28728244310056605, -0.4618580157805712, 0.37733782263329096, -0.8757940879533953, 0.8589977476639271, -0.18476761475005207, -0.027104142787947094, -0.21018486734077252, -0.30566547270549077, 0.6462300784267524, -0.3971601881671818, -0.3279535788584774, 0.004016875033782001, -1.0059746630021216, -0.8017696597601927, 0.7485292374914027, -1.1294338945907743, -0.7320073610690709, -0.09918039631610331, 0.1760372850267486, -0.2386102273546536, 1.8054370877447041, 0.624616299539911, -1.040256305333689, -1.0293954244689003, 0.7499700131942677, -0.9763253801738919, -0.25584900881068134, 1.6020858620647702, 0.23866544983948032, -0.6620063248387837, 0.9271214307006279, 0.6912992301697813, 0.29921711245420557, -0.6693337176567967, 0.8953236896973742, -0.1635941437335998, 1.4578959600480084, -1.0564123656062177, 0.5188847085432943, -0.31466498011037564, 0.40523322058599237, 0.6618315904312845, -0.9363134073263393, 0.6862402907364845, -1.162513078781923, 0.7951031009296756, -0.06489468164103043, 0.9890003043870292, 0.3937190832563711, 0.13673551873908377},
    {0.8894738490030585, 0.4451539047292919, -1.9425636146154013, 0.08903422819648131, -0.6367342358564113, 0.37242735885482686, 0.6674504492926936, -0.22177635547290397, -1.1861119272706646, -1.5223857133461307, -1.800670713882436, -0.12924031928790852, -0.7697838553282917, 0.10622437585971416, -0.00916549055215303, -1.279006105731572, -0.0605023783209675, -1.2663101063759683, -1.4705884126310247, 1.087439796960908, 0.7965613421921525, -1.1188154924112712, -1.563158156477851, -1.4641456153357444, -0.32056687755201346, -0.09467547277598413, 0.6478185937535891, -0.03319037105640137, -0.46837463633822124, -1.421670928413361, -0.6774102684738349, -1.7265350254699339, -1.8861986019342927, 1.3939947567084026, 0.7952192206649761, -0.18024306702522444, -1.4759513183921462, -0.8687509134142872, 0.19992255773968934, -0.32479283435580547, -1.514491823037704, 0.8884920071461041, -1.065431845087993, -0.7496907894934384, -0.7967103701592575, -0.8332162880376733, -0.725042897868895, 0.20704263789019495, -1.633067581579686, -1.5564136127983932, -0.14925485999974158, -1.614578870468569, -2.051943285691869, -0.5004848903304001, -0.8700101546077598, -0.9421994768361216, -1.8103053930920603, -1.8142957195652802, -1.2132883080489263, -1.9932176137640327, -0.41981737547775877, 0.36082252631236167, -0.2428331727257704, -1.1924384044657517},
    {0.041934592984244165, 0.5956965576692912, -0.4083116765745015, -1.0694903411723937, -0.04288107628142409, -0.9673536498099685, 0.4969647466428128, -1.2466429761749398, -0.9735787363268681, 0.3586540594558876, 0.1242279190195496, 1.5039332158047964, 1.220520357788438, -1.3383389317935492, -0.7459761355765773, -1.4596998013700628, 0.9438991012874867, -0.3825727020706299, -1.4513058356206228, 1.1749720341797887, 1.1108679513568085, -1.2207093304310175, -1.25612200939825, -0.7360906812183446, -1.0944728267683015, -1.2619126420919669, 0.1635509264334987, -1.26491330964415, 0.8866848440544124, -0.05692073977299438, 0.3548170132833745, -0.6922999733319962, 0.37414586928399785, 1.7635138667543464, 1.6368676763468293, -0.17215715216266744, -0.8775335359700712, 0.016047437601857402, 1.2694423507188046, -0.40478726082949973, -0.008244272809709933, 1.4230059180383148, 0.5283871885999522, -0.04302228547557777, -0.9683637733111217, -0.3127786497059382, -1.721437383982887, -0.33518510021007514, -1.7435335655488629, -1.4822304851636523, 0.4003765011448988, -0.8404534810197475, -0.7875365971201546, -1.5929701739207376, -0.22659495164814175, -0.5024952407316046, -0.4673466578414041, -0.916584032648733, -1.538758846879837, -0.3275716874941405, 1.013470695321242, 0.7282698290600889, -0.3978874680679903, -1.0747050739038908},
    {-0.5430276392105516, -0.6002882048372187, -0.5818638784997825, -1.4758518105842287, -0.9934409345821313, -1.6549068646254013, -0.4279061548544325, 0.30380542026369767, -1.2244631981669862, -0.5851656121960599, -1.6099555678088278, 0.9458129253679338, -0.7839127981195345, -1.542179550807012, 1.0794462051366949, 0.4347843544395839, 0.23685103215624712, -0.08879945385304336, -0.1776323601035399, -0.1197279939254006, 0.9934405212795719, 0.12640724716053037, -1.490253794570836, -0.6114098157952151, -1.4620375921028734, -0.8693532706170187, -0.12774547873664457, 0.5846119040098893, 1.1338550893781947, 0.42378451067045986, -1.26105151358476, -1.3109590250543024, -1.3893681393414792, 0.673555999986894, -0.8437185147999489, -0.6149824872549443, 0.3143837229813715, -0.74662967741039, -0.8149801664697778, 1.30245692268327, 0.3453296310369345, 1.148654152151308, -1.6133655668678948, 0.5395735335540293, -0.6369818065104493, -0.8652142456831732, 0.4260066214398063, 1.281384025945312, -1.617718397944336, 0.12483721384822617, -0.38788039794253293, -1.5254557789579613, -1.1754672732037268, -0.8112489408906247, -0.16072200296780695, 0.4748611796461474, -1.556969342815524, 0.9391055589592456, 0.43341227467055443, -1.0083866861447466, 0.08892764934542499, -1.0387386914092651, 0.23853642246099704, -0.27925262204152634},
    {1.2224821651599953, 0.34854422280882325, 0.5679225124471953, -1.1136833100762504, 0.00987613568550134, -0.25138588542428897, 0.7970830521024661, -1.3169849352826488, -1.8558575487541, -0.5480669053140445, -0.4329316992408368, 0.7272102914465075, -0.29185827686213345, -0.893042255554417, 0.32430887997598523, 0.6140973058904348, -0.33017299185023724, -0.8826931441654398, -0.23497087334490369, 0.22718239361152207, 0.13265959913872377, -1.2305393981877917, -0.5561854543836933, -1.3449996957325734, 0.3508213464804836, -0.7710151304286524, -0.6871941669815409, 1.1684912753979475, -0.8574474534466113, -0.5036843478966245, 0.8281470436633854, -0.16431035725961388, -0.9849504444756839, -0.4696387927019448, 0.04745368161104634, 0.7472020957913541, -0.2077844847050111, -0.033110993501603216, 0.9684066142414619, 0.6858611781176984, -0.7915066252481909, 0.6550951849230006, 0.3037323668336486, -0.7792364394850118, -0.30667259174035927, -0.7308564783384667, -0.9264958722518437, -0.7164026620852044, -1.537885379871011, -0.011658993673249938, -1.0780263853505079, -1.3735332952660921, -0.49046973702614166, -0.4509750773077278, -1.0362001858670606, -1.127606453870334, -0.6536972514398529, 0.9279011126676527, -0.7333279029110242, -0.01397624976632235, -0.06453406973113143, -0.15745133836459232, -0.4015002796873106, -0.152110172321912},
    {-0.964898931670224, 1.4260282738817347, -0.12721333734602358, -0.3024807985830004, 0.463788877119644, -0.4843960684839692, -1.0549669894229667, 0.2659148531405703, 0.9658236949345377, -0.006596298846263738, -0.11195260697689764, 1.3777311391559115, 1.0232454837777059, 0.03712790302752484, -0.6600983538824808, 0.644064003066833, -0.18508982608837507, 0.23105743960747135, 0.21796121256297574, -0.743079337722658, 0.45185486755651405, 0.2582082349674501, -0.2594759389603224, 0.6359052400417435, 0.6005091811957288, 0.2898519125801442, 0.6240731164859218, 1.327756011103004, -0.14349284139111923, -0.8230071510667701, -0.7196392980309613, -0.07643350324736856, 0.8528073810586085, 0.38437129615294, 0.7836424043508782, 0.45719116731626175, 0.05895480413197964, -0.5258798568538874, 0.729972963068243, -0.11191364397385786, -1.6156676602961635, 0.5471177477120178, 0.10982397651951072, 0.9803725812300447, -1.0092859295547754, 0.3598541743589916, -0.6023629359511763, 0.40687431880809216, -1.1127978949922859, 0.8906504892174748, -0.9817426716490258, -0.7084982987177186, -0.751187620112641, -1.2198204241722868, -0.7552952151878751, -0.8665673832256247, -1.2333963703992987, 1.0282472542839194, -0.7235822229309359, 0.41125782437529024, -0.46524484735622185, 1.2676854721259265, -0.4276899993168464, -0.8789055977238258},
    {-0.47100293896353107, -1.18722879466979, -1.3689085931497436, -0.7280476230714847, -0.8962713809801058, 0.5383319247750236, 0.15075593283190658, 0.946476915094577, 0.16355744223461555, 1.0548192046005165, -1.0560392737350457, -0.3915217765332238, 0.25475046114273503, -1.4479446373212121, 0.04297240545289705, 0.0752965953628969, -0.9308727754978872, -1.2992516524185156, -0.6240455782719261, 1.373631951377414, 0.14566228480292, -0.8700379692968606, -0.4054192208456175, 0.27961002496263887, -0.3645282006565149, 0.5613820755955916, 0.313016056314114, -0.8677677570207365, 0.033236339461300834, -1.3655580381156287, 1.3530016713792674, -0.45507405534568923, -1.2560986046702032, 1.426779592904298, 1.5023130861940992, -0.8260144720243608, 1.1466776981978395, -1.3504383466869243, -0.5317212762413079, 0.7792752705777514, 0.09868146132957753, 0.6040414440404603, -0.7477313099673384, 0.40893985310849396, 0.7612896902889589, -1.447866372613737, -0.04784102245489759, 0.9091779008768025, 0.1096722201576712, -1.254797402928665, 1.0879380934549951, -0.004278809655099913, -0.8110843391311071, -0.8866816999030853, 1.1323422795894813, 0.12605341690521765, -0.6599393958557962, 1.5967662117155115, -1.1290135941810953, -0.8579438159689595, -1.127716566251191, -0.4445184053600531, 1.2214622626836804, 0.19659554821984077},
    {0.6217960697166809, -1.078748669649592, -0.3890291428745114, -0.6279036324473286, -1.1734756499240238, -0.205285801292473, 0.5410818849342004, -1.1456484244992746, -0.8143985216083227, 1.083692110498316, -1.3134165148814976, 1.1347478452856254, 0.42913707837047516, 0.6382881640869282, -0.19800016788670793, 0.6516228882761643, 1.1794105881138488, -0.6420145377030312, -0.8958918801860728, -0.570184031944249, 1.1788330605635653, 0.07506265810007123, -1.4915550645806648, -0.030676810287921595, -0.9484194389154411, -0.48658984060577565, 0.6382132430263642, 0.35579130982922047, -0.07241038826740581, 1.3824163796005595, 0.3481563318493194, -0.3200821704902159, -0.42485039045632544, 0.9744714774393198, 1.2326507151831116, -0.5527548237622423, 0.8386498068531596, -0.5142854647457399, -1.2153794866161713, -0.049934018326900406, -0.8131389963064686, -0.3287626515974946, 0.0019218434470092338, -1.1771208435266307, -0.8401143962473928, -1.1528114116996384, -0.8736211319035333, 0.09542873866593765, -1.2236467010769145, -1.2097819162053562, -0.7652815782162612, -0.5104548893855926, 0.4267809419735028, -1.4022984874306517, 0.804907416685669, 1.0677911212355156, 1.2829351231007158, 0.7677131769079255, -0.06025604811645873, 0.5591863718357983, -1.2710460361677358, 0.6352585749292342, -1.0845215859050688, 1.2171037722263474},
    {1.4076399414627085, -1.3729078660251515, -0.9841902389303331, -0.7278019085805092, -1.1108653826029868, -0.003925260874390184, -1.337553504111601, 0.9999850149536254, 0.3773208704364281, -0.3670925386456712, 0.4583567756057099, -1.0950442950839818, -0.21990509494845986, 0.9938042215545471, 0.8616899629332837, 0.542586195400386, -1.0872196048087712, 0.3502371062926451, 1.104562805341005, -1.1640705305711272, 0.23614755582488917, 1.265247999378432, -0.026599919033585474, 0.8817201829118237, -1.4112886743344348, -0.4845407802040271, 0.34367269909991816, -0.16045740561655758, 1.3711008855786149, 0.6296907134145714, 0.7537700152736616, -0.9606731700839869, -1.4913033652591585, -0.7165160494798994, 1.1638504817271127, 1.204753398558615, -0.12771815763007635, -0.879243610413499, -0.6571578350265179, 1.2196072773357531, -1.1053075291070507, -1.280775444657931, 0.9451040114245329, -1.6440250230357711, -0.34334220629193307, -1.5682205468188706, 1.0713527793711675, -0.5725514841364607, -0.43374010710568583, -1.302070981109691, 0.4112284239407184, -0.9643413047369574, 0.6874662966393404, -0.8189302811468422, 0.5455098401927172, 1.1721147843723363, -0.4753899698312385, 0.8472554295382334, -1.0539213861410353, 0.9588975908693169, 0.10601580054373548, -1.0953449117471548, -1.4345950100548508, 0.32886174216415215},
    {0.07553405931115711, -0.7695164533114265, -1.0445756151841998, -1.3750224197164402, -0.05896456433391844, 0.8182553232381475, 0.8868359477621538, 1.5459524430733698, 1.075703412223658, 0.9860744595563606, -0.8717338681881326, -0.08426177946449237, 1.3691544933673845, -0.7032447227655823, -1.5788894202304586, -0.4866853659367994, -0.036086771294550284, 0.3915532179717549, -0.26070983437045964, 0.3194319087634308, 0.9934475708872909, -0.03180476066793987, -1.3835161375057228, -1.4115131179381568, -0.03921305181435221, -0.7049755471781299, -0.8324339127194585, 0.006218047190178527, -0.2864749793730789, -0.7393868152693007, -0.6612057453051555, -0.4991143490116451, -0.842015466865339, 0.8018155202845882, -0.48245227981291444, 1.3041677416230304, 0.14169815248228929, -1.3322713944570252, 0.6159442251392013, 1.2597481556375205, -1.2208819322153854, 1.0442059054255184, -0.5818849240024037, -1.512360228811771, 0.1545561143403865, 0.30114159444359184, -0.15818329783355445, -0.1278786611192091, -1.4918128423530093, 1.082699666723072, -1.353189418701801, -0.6608132299335836, -0.7921860815691374, -0.5573474395283742, -0.3362352197470974, 0.753289902531758, -1.295862297653496, -1.1483595890996257, -0.014618862310527806, 0.2207771794717642, -0.7836214599470147, 0.3397995415443096, -0.2639378983225868, -0.05008026032416403},
    {-1.4123146419214674, 0.4459503900003804, -0.7021162840224621, -1.5442265079662, -1.4892610089502265, -0.028562220167508798, -0.020584110961741096, 0.29436065194122085, 0.9381236532823953, -0.06009633701962891, 0.45638178584195926, 1.0088274516411138, -0.028050113061003426, -1.1118527846433857, -0.7079723470048171, -0.9586418725528332, 0.572324401559456, -0.2808999608441034, -0.6268855464504816, 0.6428311551681897, -0.39326971142124645, 0.4997829135316621, -0.5593978639941141, 0.1951471792036282, -0.18028319485448766, 1.0734097246289218, -0.7630620233380226, 0.8757312234967064, -0.14525580791583734, 0.31705572842917806, 0.40751262212185574, -0.052793554747496994, -0.7664813383906961, 0.7761774096102526, -0.20298291429807794, 0.09629927097613772, -1.033292258740939, -0.08904758721085074, -0.16056341867565757, -1.1553097743419667, 0.5916805975712244, 0.9332861994277329, -1.1291781014551714, -0.9007721980865487, 0.6606838480297796, -0.23125264655867878, -0.40109963923774256, 0.8953040752880593, 0.36250232750026073, -0.6111189368268172, -0.195604916808307, -0.8980641728853699, -0.8243497167666741, 0.38963036599090195, 0.3566403036481533, 0.9937696745519622, 0.16644396175736523, -0.03858154204475404, 0.5164396625713671, 0.564954777250729, -1.5329821335968634, 0.3734804264615581, -0.014134166571516516, -0.5187586903463943},
    {-1.2801277707886811, 0.8711894543045832, -1.1136229182377997, -0.6411121831576722, 0.6837058362619823, -0.7967899305963013, -1.0918881245984873, -0.012072942016029396, -0.07666530498946891, 0.9821269283215809, -0.35513061919459166, 0.15566111263466864, 0.20595388766296158, 0.9434295742721708, -0.9472667019334351, 1.603349741729392, -0.42408123945632215, -1.032165239642739, 0.6255756097278081, -0.9934497874322514, -1.0399935198974575, -0.7590713458358179, 0.18235638330792847, -1.433309061696107, -0.5102132592888234, 1.0705376499757306, 0.9950698671144539, -1.2907447642601224, -1.1023679167204827, 1.3056539434634349, 1.2104403305777198, 1.1429766611788714, 0.8607931327105268, -1.0506562260598873, 0.14546051141742375, 0.42846821046289435, -0.7731286164915696, 0.8428312825378156, 0.32069536859323194, 1.3279356786917296, -0.07026569598094859, 0.7331510756421209, 0.011599121915410715, 0.27792513194706514, -0.4938384656973326, 0.9347749348539295, 0.9134382876564696, -0.8903236899162018, -0.768092530034835, 0.9823569152034364, 0.5283907312927881, -0.8699367940537106, 0.9605651725433682, -0.9734368327506308, -0.4113578010190844, 0.44634813121955386, 0.432368849964622, -0.9074278205445288, 1.5332081821992347, 0.06340605809405193, -1.5404360391239367, 1.4074887728385561, -0.47331761237450143, 0.9071639340815802},
    {-0.5616820235576252, -1.196544859061219, 0.13770428914256297, -0.69784017709585, -0.7133872982618482, 1.293864530948426, 0.9753238432122171, 0.8639082501761235, -0.5019366380698528, -0.48297264522453237, 1.1386001588093468, -1.2646880598679253, 1.1117803531246673, -0.3879665752073949, -0.38964563526088575, -0.41692084409288493, 1.463855356001924, 0.581059172080872, -0.9912272487460559, 0.2971654866599057, 0.5328694588394901, 1.204394884317149, -1.165246496486753, -1.3896470055631547, -0.5980084285006934, -0.5871041167055543, -1.2863391877904213, -1.3749645038605538, -0.035181359907447175, 1.1506501451563498, 0.788736501192671, 1.1004866982143346, -0.17217043242306282, -0.9063793727084715, 1.222906469035708, -1.322308048790473, 0.22045263705783433, -0.30870175433622393, -0.3929735404932054, -0.4912105342541441, -0.6141944573636151, -1.3116277711890525, 1.5053981317197758, -0.29113071926355294, -0.4869043034360529, 0.9986248742990929, -1.0349481798357916, -0.861617145035399, -1.2117777366793476, 1.0721670289723562, -0.012290919439162225, 0.5587614082185709, -0.4318026535466337, -0.029489705153340436, 0.8836223953198029, 0.37895867098249797, 0.874660398102849, -0.23478742887848503, 0.9420793783682817, 0.22040918970482926, -0.8713216634743874, 0.7324639149838716, -0.6591348562208227, -0.028993267369257343},
    {-0.2246729314109118, -0.30744147169017694, -1.2651260237072801, -1.026725874470331, -1.2773015782143682, 0.5789731828102984, -1.2326798825070926, 1.2481496487340789, -0.46764106102903635, 0.33512034664179374, -0.6572372512354995, 1.0256351524019616, 0.6649333306421611, -0.966389637715938, -0.5859545359739533, -1.407645295623361, -0.42332929547914233, 0.06539210154972167, -1.293673224296586, 0.8254252198863877, -0.4555514906634169, 0.656286968902127, -0.06235971467087475, 1.3709358126305367, -0.7451701698023694, 1.721458437061508, -0.5894086603464841, -0.5582114339639141, -0.5259013464837657, -0.15565642429594626, 0.4201657250906984, -0.7415842874848476, 1.2200257237001617, 1.5654652577286974, -1.038201083008777, 0.7608491134462945, 0.5779271689078836, 0.19781214386442958, 1.148664563028864, 0.13427077014456076, 0.44122266070784544, 1.2297594768880238, -0.3038024364625329, -1.1695188500457883, 0.9626631772184783, -0.5123293350336995, 1.2867453024429605, -0.44938711812376286, 0.03555653936737088, 0.07514231955551184, 0.7465350885514185, 0.8266465731659315, -1.0974426821241567, -0.4083556287661137, 0.7532805207874401, -0.9977435098515125, -1.1118751261444864, 0.8333813917644448, 0.22888089532606953, 1.048580758659601, 0.770616469447937, 0.7726246560325446, -0.7076988458062263, 0.4417975067346706},
    {-0.3033307001696666, -0.985528198754942, -0.8104413805193952, 0.3365603928047672, -0.178541498203539, 0.9146042826357748, -0.8292304278020711, 0.6952489644265749, -0.8012184546550604, 0.4061064062973929, 1.0455773907905241, -0.24040365749313794, -0.5629337681702233, 0.014728091619051968, -0.4852315707447331, -0.2763180797453996, -0.23916880644848446, -0.6018695187349742, 0.15152968239335105, 0.7801210786899984, 0.33089210107783995, 0.7901881731400844, -0.7400599307717785, -1.0195704383595354, -0.47513224210064314, -1.3089995852047653, 0.9559298668753905, 0.2554344551137059, -0.30274475946604146, 0.3056728219182649, 0.07058167189702659, 0.5504008897741675, -0.596588584500903, -0.6342317145510621, 1.096863864111075, 0.5559594833875312, 0.5884772113191651, -0.41671244414316144, 0.18317389015708388, -1.1012232495143555, 0.4008821751212796, -0.20685297795154717, 0.47989838787896405, 0.014943764064516623, -1.3714625864911738, 1.1578739195745664, -0.6501825605921383, -1.181527196056187, -1.3516186824442917, -1.015090458921847, 1.111612141168643, 0.538692710355742, -0.9726017572034252, -1.4327194013152729, 1.0090680675740207, -0.7590332418711311, 0.8065946866045817, 0.4378307513400884, -1.0451240698514181, -0.0129738588503887, 1.0755258792634526, 0.005652470708580834, -0.06279898858157683, -0.7027787633584904},
    {0.5910113016648547, 0.786368509798963, 0.18974473249327176, -0.3059629675170865, -0.16379346784960297, 0.6762083940136352, 1.336969815000998, 0.8032812298684567, 0.6725601322508067, 0.5207456254123816, -0.966279492647588, 0.307820627793655, 0.35909779856334545, -0.01119594293856573, -0.7056661610159196, 0.037656099850341324, 1.396098003944789, -0.6110361273489683, -0.7807599501961694, 0.8663009591526039, -1.1710015148058186, 0.4001756398620137, 0.8833787074123377, 0.7351667443624654, 0.6867445919374457, -0.17674738338357454, -1.1618702196039368, 0.048913329166090334, 1.2357061532173517, -0.3150440961264976, 0.752497614053064, -0.5414874382586832, 0.8227553428340583, -0.332062524055407, -1.0146869904483833, -0.8473581653246302, 0.9132182296518608, -0.596692401159191, -0.2944573491463912, -0.27150581750029495, 0.7828998532142817, 1.3320502511249301, -1.4522494286833076, -1.2427218877345694, 0.3686969068931599, 0.4995413428135864, 1.3162046965439211, -1.4393305046559701, -1.3330841303016379, 0.8314572091975806, 0.23844587352922073, 0.859506931926337, 0.847639720683284, 1.0288380044639114, 1.3353465697308082, -1.2377125232486343, -0.7404948244896101, 0.6174958278847784, 0.4999990836131219, -0.1743583748836956, -1.010102061128187, -1.038560173789051, -0.6326994930307273, -0.49691993919173577},
    {0.9014006271769656, 0.769580417226731, 0.347845925758364, -0.5096031097901826, 1.1213406360964175, -0.6485893003314467, 1.253684230726855, -0.9541528746340459, 0.6479297893129566, 0.4504870068604923, 0.13501376602797124, 1.372096762284219, 0.7061070048058355, 0.883620631443589, 0.7598255765346569, -0.1861624026021696, 0.18959858829056944, 0.28507507327750753, 1.0088900585026495, -0.815541482137024, 0.2610615301518796, -1.4503034507476367, 0.7295355302680219, -0.03176945499201259, -0.4467848082319315, 0.23209572651331853, -1.1515220059781883, -0.2550258286832756, 0.20108644446622556, -0.6241871484600723, -1.3178496819561396, -0.7634562741970334, -0.21774417160968826, -0.7264295861320931, -0.8559451171921231, -1.2223645320728191, 1.4783758596497911, 0.3344061794501121, -0.4562968535572899, -0.9959467432274551, -0.867466995284549, 1.6677298718275189, -0.15167114964774955, -1.4101306220903942, 0.9998440113642029, -0.7888867350035197, 0.8796196386272932, -1.3422717552667165, 0.04537289491451515, -0.968410610804089, 0.9810150359607667, -0.5819667752840453, 0.23260354255414173, -0.9565263184220258, 0.5256073783827216, 0.2993785436742422, -0.37518521124408977, 1.0373982525631047, 0.9140670022679086, 0.03988874808454795, -0.864114256081839, 0.40154069103585666, -0.641741235952686, -1.5941018282534825},
    {0.21403584682944754, 0.6482436702590433, -0.8231331776489839, -0.31307516397054647, 1.2582294308132225, -1.1477636992113334, -0.3726312984959597, -0.85040866455641, -0.3504082829307439, -1.1898565188528396, -0.7762847715867109, 0.033500287111987, -0.5925237248806404, 0.994829297663281, -0.4055568930061791, -1.3209845715550255, 1.2107761026506447, -0.6044176862116207, 0.5897083947319012, 0.8234742100369176, -1.0229030810156634, 1.0890488242707062, 0.005194695136365233, -1.3457719729682007, -0.8534743888721437, -1.2806389762760444, -0.7854648176758349, 0.3342470877673453, -0.9942111288727201, -0.9943374388126819, 1.104037749818781, -0.8989031038011989, 0.655769843508265, 1.012018820233116, -0.6028807333600098, -0.07526330398275782, 1.2424646953385412, -0.6986087763794163, -0.221100164547555, -1.2549961533294687, -0.34175614410039046, -0.6530225543150728, -0.37731233375463963, -0.5487724905865906, -0.7897317765543915, -0.8339576048954856, -0.40353616332989123, 0.3207097090711547, 0.03266292702494816, -0.8815072691131365, -0.4287511937536791, 1.4103618746228364, 0.7889870318750904, -1.1364486215495964, 0.2937028544705772, -0.37821895856885174, -0.2457451063959042, 0.21607583032634464, 0.006202621867272273, -0.6969550502887863, -0.2900202380892982, 0.3935786847128364, 0.927044396026822, -0.6002786933204958},
    {-0.5695631854488807, -0.9148723483564268, -1.10828565809363, -0.16067350879953438, 0.940074479594505, -1.2911596359172983, 0.2691785857360515, -0.8229871111793402, -0.8491382949381233, 1.1014068453755277, -0.775368080715583, -0.8989200119147099, -0.5840890025709912, -1.14971994099809, -1.2803192898534779, 0.8873922865035924, 1.3749559384123589, -0.9046892020701429, -1.142459257311377, 0.42482316984198815, -1.083491900143711, -0.9547365331646801, -1.011243907306482, -0.75471673407965, 0.24871154518803398, -0.2963771973649914, -0.004259896511486739, -0.8141638616442007, 0.7980179689704492, 1.4330227456425417, -0.26877093543736497, 0.8460592640349159, 0.949986749974262, 0.10171472130426794, 1.267349149064538, -0.1973910035740912, 1.3314587946412764, -0.5298975155042676, -0.9105701157065953, -0.07254004528383022, -0.17194234162202626, 1.0571102496808142, 0.13947381265413775, -1.1955367413908844, -0.33648851600503116, 1.003085644797727, 0.23171624333616914, -0.19649558048266577, -0.45651805094393794, -0.7635309427755217, -0.7318448080567787, -1.0087737025018932, -0.4012014500842015, 0.9445755175435421, 0.9984638997435226, -0.1352317916592132, 0.07264967735342885, 0.4163363804028925, 0.34746090724689743, 0.4241079463565858, -0.5893168193864852, 0.3363645269894092, -1.3127215791005205, 1.590734719583515},
    {0.08890259654172696, -0.32632736142572266, 0.03147444822314425, -0.25328838760719885, -0.38925905974675046, -0.12503787455729828, 1.2221363617754792, -1.059798390984468, -1.2230541361240324, -0.5725382590164386, -0.25224194832130803, -0.475504520157263, -1.4525279523285979, -0.10386733188903037, 1.0179844693375302, 1.0202780556999942, -0.8401178340143987, 0.30931741581455136, 1.193642205762369, 1.3572925520478025, 0.583971433627264, 0.5289032287943448, 0.46635497050442326, -0.18807872946776283, 1.20715306833484, -1.118240815271537, 0.1737194316222214, -0.6424373993302058, 0.6014018316515779, 1.4458263718752118, -0.12329259438364448, 0.3858533174055235, 0.3590098302415034, 0.43564605628477465, -0.8989596779881259, -0.34871641463351777, -0.6293187027080672, 0.3854303821856473, 0.41649778858374303, 1.172035623326185, 1.2994625273301859, 1.061871457843267, -1.0170439830242939, 1.0530627038175804, 1.1123351962834145, -1.0210522701529905, 0.5679212770126277, -0.2632885990783424, -1.0063058677391163, -0.07316324787619151, -0.24163435670085406, 0.23364713125965295, -0.8987321764623811, 1.1204559513318995, 0.7715321338403215, -1.3868848269781686, 0.9520207781437466, 1.3635272284716626, 1.2357321182748597, -0.2993200192733181, -0.7825934388286849, -0.694389612920294, 0.2928808510947702, 0.08398004520755743},
    {-0.937973381787674, 0.23576786377966166, 1.0738058468906817, -0.3581457367420183, 0.7234602233621295, -0.877912224593685, -0.5515018421011061, -0.7026257825161979, -0.3563015567469808, 1.7527538255372699, -0.9654462929623114, 0.26795091882611877, -0.8426902886716617, -0.007192221145887957, -0.12786085989197693, -1.2122632824192816, 0.1308545575714759, 0.36187769938949865, -0.5249103744405144, -0.7912333191706987, -0.5812457040168506, -0.9145927582711089, -0.14761642741764394, -1.4518935023412383, -0.033142596640072165, 0.894995133064061, 0.015813984034053655, -0.2925790950915341, -0.4346467566694339, 0.49536455767071286, -0.5514520315342123, -0.6735073472717643, 0.828743525251561, -0.5430063503642621, -0.41790347023273045, -1.5535374779063225, -0.04757027931289227, 0.105356999653977, -1.338831440646007, -0.7534145642022549, 1.14804629054283, 0.7575684229342218, -0.9083535389763729, 0.7831450159890117, -0.796248704671578, -0.03616878561544355, -1.1200516122136701, 0.5908143651204748, -0.4841240408709736, -0.7685475338537098, 1.2672948754457871, 0.06262826122966797, -0.49663418603084286, -1.5002964631997593, 0.8053377113043312, -0.9906392143095422, -0.2457015039967638, 0.9326752512024589, 1.4920507434753312, 1.5745179355192214, 0.9211840473966648, 0.0189509134207223, -1.0498557422576067, 0.4739102127603002},
    {-0.015021154329215657, -0.832009942352047, -1.214343971773947, -0.4187536533038253, -0.9539016325781288, -1.244857315312993, 1.0847858384369984, 0.9842389689307313, -1.377980067912382, -0.3489053287480503, 0.6604290368617228, 1.153280501850271, 0.10169967583824799, -1.106608225213907, -0.26494754714404495, -0.7300185706485586, 1.3084555378327212, -0.24941866265213625, -1.458152061825188, -0.716745875299117, -0.7069168557466704, -0.8023946738433199, 0.4265095601954477, -1.5669358748732458, -0.5287534765228263, -0.10187530473955043, -0.06671310122958067, 0.853156518517553, 0.5951738902759355, 0.9906222769555989, 0.35445399498072355, 0.921473566539877, -0.619195896618096, -0.6784080252970307, -1.3251101355690103, -1.2379951555226378, 0.13918518251198003, -0.698891341024072, -1.1236923293066852, -0.16310376052733777, 0.34402409638998954, -0.7653240305648017, -0.1587666763859688, 0.9284536369047354, -1.0957273586461178, 1.2325194387335914, 0.6924205148227377, 0.2964095206387493, -0.28392175160683764, -0.6686156199856083, 0.7353754362360392, -1.2952999753554981, -1.4445087357940163, 0.7709120122955326, 1.108212591036652, -0.31524699036583637, 0.7792196530171019, 0.4786800261278224, 1.1857213541029192, -0.5728297999231161, 0.44392718476132925, 1.0517787362361612, 0.01854236589586964, -0.6840689016164638},
    {1.272702122357779, -0.921809190790355, 0.17811279852565834, -0.7885488880158164, -0.6605870612493889, -1.4174999388162048, -0.336511185153905, -0.7358431733017717, -0.8496753056540547, -0.03897506876929249, 0.06614419775931672, 0.549997043962477, 1.1411229486620993, 0.41906216318230394, 1.5732684604139977, 1.1162255157934176, -0.02008162781411762, -0.27941030347960844, -0.461161155728016, -1.3311027900338135, 0.7790695570910755, -1.4340791258862644, -0.03044049316597409, -0.7177761812053852, -1.1899919708209248, 1.5553900418249538, -1.241825789345799, -1.5092970081156452, -1.2746518916960337, 0.9477153945795067, 0.6540741755191773, 0.08190059725064902, 0.5147558777169604, 0.0998079212171859, 0.841786550590298, -0.48700204394091656, 1.0467110547225225, 0.5006363529509767, -0.4523279399344191, 1.0416125796997264, -0.22380821829546507, -0.9791944450566438, -0.9500327563764692, -0.10466875218933987, 1.2240554940052113, 1.1326058911034298, 1.027502070897237, 0.6851713050340364, -0.3565387059044803, -0.4783819989502559, -0.5905664864094763, 0.920564118952159, 0.9886681141361371, 1.3056018823164872, -0.5464604319208066, -0.4796312390713373, 0.1569863290417387, 1.314560556449703, -0.7962209358010873, 1.2961359211823256, 1.1480763968120657, -1.0576621779032604, -0.2311685373452429, -0.7872909286538158},
    {1.0118929859099612, -1.2067578822850822, 0.1721031708498339, 0.67517266548821, -0.4874628376106474, -0.8589030971838086, -0.7579898454345463, 1.097333661753526, -0.5455680192238352, 0.1332012848111436, 0.35702346891720393, -0.738189380654375, 0.5433874941821784, -0.23134020518083456, -0.4343666216849402, -0.908259888561704, 1.12266309726821, 1.3459270427790204, -1.0168601704833942, 0.8675367504764131, -0.17070449193498105, -1.1023603988898325, 0.7531055320519604, 1.287718811872528, 0.10463231465347339, 0.06666232813189754, -0.7694611693749319, 1.0744849830013918, 0.12535765101350965, 1.133065877510841, -0.02445310984920613, 0.6226426288351957, -1.0274963091536573, 1.156186790130838, -0.621810539175984, 1.0752473640349256, -1.293317107082966, 1.539037564834086, 1.0020924205828945, 0.8511644524578421, -1.0896947514729953, 0.8990036323931602, 0.2771283995728752, -0.414258674708582, 1.025817494117115, -0.6539175312060092, -0.15480335590666974, 1.4644436463342438, -0.15283716601401276, -0.7840200296674809, 0.4394918004086384, 0.1752583649985175, -1.2864881816539455, -0.5076356865322369, -0.4814993672208365, -0.6649983046171024, 0.37282581947346566, -0.37255708751087635, 0.7740099802155804, 0.8494169308756732, -1.133450917548804, 0.7532461008423452, 0.6758180955813387, 0.0233628673746944},
    {-0.6468181232139102, 0.06326287766285707, -1.3927677305592516, -1.4511503337587295, 1.0046422582722017, -1.5633501309789124, -0.7581316745469981, -1.168715328477729, -0.3923648950990411, 0.44537102508472093, -1.0908067557480359, 0.42812828279735377, -1.1049961956865724, -0.37100387567095944, 0.3789223409526713, 0.3190875140172908, 0.31406604961257084, 0.7207668355468753, 0.05461514947056226, 0.6282848527773951, -0.8725644413022947, -0.8515199816500186, 0.2975725772911096, -1.3199514181218994, 1.4438746555637882, 1.2063219019386036, -1.2919704265393703, -0.9662048374999939, 0.6182933131532702, -1.227333257489146, 0.2608209322533345, -0.35832944342875206, -0.4033611791945277, -0.039397577566224924, 0.7748381517267408, 0.7497557739693244, -0.86587221293813, 0.33059316621765916, -0.8518166186764861, 1.0009160060596602, -0.20333721950198158, -0.23492262314942214, 0.8827450934589817, 0.9753344665361144, -0.0010650288187487105, -0.21951066312344655, -0.4985214717239594, -0.04891613196347932, -1.198764435853933, -1.0042671751949594, 0.01643548564188922, -0.4239884552323168, 0.43257437921313857, 0.9242788852460458, -1.2958272614594246, -1.1216479176020782, -0.439383308457912, 0.83515094544538, 0.6063846009222089, 1.4016360117991882, -0.23294819681697126, 1.150714473958204, 0.610528727728001, 0.30061288087741167},
    {-0.8174497414026352, -1.1620169503599154, -0.2832818395727614, -0.33828960067042446, 0.8327352406427151, -0.5226093414875875, -0.03881138142335268, -0.521267762274378, 0.011006780538770662, -0.2188196302154564, -0.005904089813745501, -0.026815765639034903, -0.7045403625155744, -0.12792428556073854, -1.4055899780707064, 0.8456315016978674, -0.02952326118883205, 1.213969580910913, -1.364337246849737, 1.3623520021080817, 1.3086729117169338, 0.8642894291352072, -0.8253357400534382, -0.5606536507755505, -0.4540177354803306, 1.1369941112642559, -1.4016565623587527, 0.4110735232868057, 1.3927654603576516, 0.800837777305092, -1.2671366951827587, 0.21420808334916966, -0.08315891135036221, 1.0281020212974536, 0.3989549517363411, 0.78391153161963, -0.6013176284394468, 0.4311612450854814, -0.7978531294602877, 0.7320138555806583, 0.43287434125280017, -0.7936845574696916, 0.8422019074016761, -0.8630919013573953, -0.18046554244922408, 0.5124788025786107, -1.0890205980582148, 0.004269080870355319, -0.8731715272753263, 1.2317410210087663, -1.3195256921570067, -0.9436343745570179, -1.1621522585976878, 0.4488706513798534, -1.2626587416231312, -0.09550086732375386, -0.888913249516561, -1.1363427041624257, -0.685418681815995, 0.817077027870074, -0.6721495267224111, 0.8877880548518627, 0.13394600787536814, 0.0877758956803128},
    {0.9964399083472105, 0.22362080859647893, 1.040974759765514, -0.5308527353449518, -0.099986564514027, -0.22948848204136307, -0.34471567163900263, 1.062779701566753, -0.956759985945451, 1.1211817404765319, -0.6590623645598562, -0.11182196805797635, -0.30995297015669176, -0.3244199211180068, 0.23865458135726683, 0.25534234991411436, -0.8723214826137381, 0.8922840833229528, -1.486655151057843, -0.1299743918951114, 1.0371769256029766, 0.08168044221867476, 0.4859702352745716, -0.8410187780607938, 0.10685049937908692, -0.3625854376871844, -1.0364890604303438, -0.6616011614019388, -1.058678802062574, -0.8359183153321915, -0.5668386440383884, -0.4182531698199702, -0.5935601182232966, 1.3459586482520882, -1.0512854753813248, -0.9884400207149281, -0.519759523636387, 0.4439575844697381, -1.3294107006507296, -0.795218425327888, 0.16632131674777303, -0.35327142072481266, 1.3964333605559314, -0.8984813418133125, 0.47960643801011693, 0.6607621902913835, 0.20076097626756056, -0.8299588344305788, 0.1780635556057517, -0.6987918181588779, 0.2553544048590982, 0.26372680170115903, 0.6109151350443637, -1.3861502302866704, 0.11786335332076103, -0.05114414313970496, 1.0132797222790026, -0.7520218009105778, -1.1801772279369624, 0.33134381791272033, -1.4043321556232244, 1.029025819532558, 1.2859458824787213, -0.958735284378317},
    {-1.0943707569484609, 0.6216234757843297, -0.5427376133097753, 0.3305831694250595, 0.3641370574148278, -0.1831579317846031, 0.7192822039767032, 0.25045269326502534, -1.4186073877478216, 0.3145043292808472, -0.26033640485871534, -0.04898249105375017, -0.19466561639973928, -0.8964414088354282, 0.06352361894566558, 1.3816009356937142, 0.24711506109725034, -0.574158789400029, -1.4225740638939255, 0.47792314660861757, 0.7475737462307402, -0.47661196905949577, 0.7505049915546973, -0.07409229910035016, -1.106184182402481, 0.5266859138814993, -0.5341396802751033, 1.0175668654180334, -0.19626753652669546, 1.283531064856384, 0.3022109812092772, 0.6959889490433578, 0.4623078374511852, 1.1679411535838857, -0.3110497845002562, 0.7134154250949916, 0.012012419192919956, 0.43632798729380634, -0.982196556546925, -0.21614199451179766, 0.8457405178317188, -0.7413297625823468, -0.34924569973180397, 1.0115312159097125, 0.9468254786571486, 0.6611675878026498, 1.213577100232004, 0.36036904790415425, 0.5021636890046816, 0.8762757704873734, 0.6657675571099146, 0.4428130226346001, 0.4896829197956226, 0.18896012377744348, -0.010459947820680772, 1.459191577876779, 0.369124326300201, 1.3302635862150767, -0.7053714152010979, 1.4082804886995348, 0.5335132215646806, 1.027158893890184, -0.8933515978084274, 0.6880838616718511},
    {-0.9724048558635254, -1.131255958842587, 0.3640849488518304, -0.6500587894714432, 0.12939536084534708, 0.6699866254908241, -0.0056261704234061944, -1.0972479478307904, 0.2619137280249417, -0.7763943899199134, -0.974800424371228, -0.46687810179352063, -0.3493825935959584, -1.1516397204861706, 1.1790388161847354, -0.0038602659586928286, -0.15526052543740845, 1.7276028311042964, 1.1597278604700243, -0.1660321228514454, 1.2976329026792213, -1.1412569260963374, -1.170083787469002, -0.18915130120565454, 0.34922959576939583, -0.016062976716260523, -0.35589010547172734, -1.279979973865104, -0.7182056787989113, -0.3746541891625574, 0.1393840603935274, -0.06677208158764486, -0.41383794893639614, -1.0550896976355697, -0.7910198757429938, -0.9744558930445367, 1.218372613073153, -1.3034139514480538, -0.22907020334107406, -0.851386551600694, -1.450443277813785, 0.7242325793317541, 1.467031046809946, -0.9005525542280366, -0.3099898619487777, -0.5911428557596741, 0.7175253755278046, 1.3086148574451928, 1.2463641232945528, -0.07874366329481342, 0.2697461148565722, -1.1487845830346692, 0.33222968239480233, -1.3830839005326478, -0.06303441320317897, 0.34988077808087464, -0.2372152427121502, -0.14327603163435504, -0.3964176440395788, 1.0158877129799442, 0.6933574919264318, 1.427620855177375, 1.085851011516968, -0.12533492315635383},
    {0.8393151934969949, -0.5062550773182348, -0.5716026530841568, 0.6666065722316986, 1.163446650715222, 1.1616666753094935, 1.1723296964984677, -1.2245821461066715, 1.2797659268050017, 0.5610579614571819, -0.8665509446395846, 0.20656070403175095, 0.8384601877125456, 0.6278228544098403, -0.5118032412130104, -0.5347459618460857, -0.5171630697334586, 0.2900729455097571, -1.0134583725677473, 0.9173233916912684, -0.38139729928735494, 0.8890088468903824, -0.3826030503345858, -1.0877502321320176, 1.2479265381720945, -1.1194184620667544, -1.1226948096497509, -0.37949408662024836, 0.8596386989844468, -0.18015800977345423, -1.208918982484202, 0.8777133040364657, 0.7708259541613264, -0.19784799850092363, 0.5025574750624839, -0.8408241116388149, 1.2195124237685362, -0.472175624405115, -0.014318957542400201, 0.1346655411145061, -0.6876734735810428, 0.11498664125824314, 0.7209734852679139, 0.15887218402058523, 0.16374430527930087, 0.7692970556740801, 0.036827127000547376, 0.3724858908697348, -0.3137923569298002, 0.6464708436745887, 1.1362690362256873, 1.087834687447442, -0.6493874623307488, -1.1190167007111966, -0.06725017277908153, -0.705013594831101, -1.5432153420937444, 0.41118677406249704, 0.8585069168052053, 1.193441323099901, 1.075255220460305, -1.0756685679093123, 0.34497897196583466, 0.4515833919927591},
    {0.2537669845003905, 0.8776422174427339, -0.8136881314832729, 0.5219218149913676, -1.1676636277158057, -0.6192706618033647, -0.5129123234803952, -1.2445408380498404, 0.3632168403782233, -0.05015987058201231, 1.0939008057713338, 0.6467491072934305, -0.4898478985350429, -0.08481771097398128, -0.5164429008314516, -0.3242797520888757, -0.08424470768590692, -0.394986656778185, 0.6167044268975419, 0.7431013388647544, 0.31510014706601236, 0.09751991139325072, -0.13261866891560617, 0.9695859686734924, 0.6653175571100073, -1.3281142780089896, 0.47318680918967343, -0.5525220288341568, 1.4746435617192415, -0.7538602174974759, 0.41595286995225805, -0.6550778552755021, -0.16812014932069808, 1.0681888374637256, -0.055061287737458664, -0.009045326547576364, 0.6321327666146246, -1.4398706954894893, 0.023190494234898724, 0.6207194233125906, -0.4539769242527251, -0.6375441552339699, 0.5772275385771919, -0.5278351538809538, -0.27213502125745453, 0.09450425222593033, 0.32949815057257476, -0.40269500136160336, -0.6334537208955089, 0.697080896702746, 0.49273786525773794, -0.4958179883242868, -1.1213945567490256, -0.7528524132568968, 0.9561841581722386, -1.0723981338798418, 0.6809855448760221, -1.00317988874578, 1.2260135717984717, 1.1760729582783434, -0.6718164748435597, 1.4228225104994663, 0.39943821370016613, -0.38722050252643825},
    {-0.5424146361906701, -0.8409761139268215, 1.0154171603189586, 1.2819340628515719, 1.2374963477393104, -1.0899607662630038, 0.11824856010922749, -1.256432363526181, 0.31094828096453947, 0.2137628676584218, 0.5537249425088335, -1.0278607629723715, 1.4814112682500247, -0.3574350555340309, -0.3300288680421231, 0.33427804543224793, 0.5020661316375223, 0.21068502740605002, 0.7248623211215369, -1.2771080702018085, -0.9144242461486606, 0.8479961600205376, 0.9861626364735884, 0.5685648441498723, 1.1838970543238398, -0.6287071720365108, -1.2375890312078361, -1.3492255490840133, -0.8961920849980155, -0.6305103222307119, -0.20420296222995107, 0.6877460416982796, -0.7393829562072459, 0.14268596187468066, 0.9852162125035964, -0.7005526086193353, 0.020643156804981348, 0.36808226998324955, 0.4511911874502016, -0.5952072811967998, -0.7095957508060027, -0.6367884393686971, -0.5441121790498359, -0.9862578495027741, 1.2506198345423054, 0.4448810971427346, -0.1595484545868714, -0.08302755203546826, 1.0363783879668695, -0.817535790216185, 0.004623956774325833, 0.16727793285270315, 1.336547162595507, 1.5016405916243423, -0.8763612603942575, 0.767133155513934, -0.9663976610062828, 1.1110060968553317, -0.3013575489986285, 0.600595302448297, 0.9145546824050168, -1.1221026083279155, 1.3239210481485473, -0.5701255782568598},
    {-0.9149052412541935, -1.0381814248157484, 1.1568822354558799, 0.9986025559011513, -1.4516860094103692, -0.5616336393740519, -0.8121217132566932, 1.1572657146692187, -0.17953092272615198, -0.276972450521559, -0.9343747359125291, -1.079828708335343, 0.7452594966614688, 1.1638536963872184, -0.6806110570269464, 0.1343089466078471, -0.1839186462427644, 0.12951684709778813, -0.12106316492241861, 1.5426049258914296, -0.5298518868827939, -0.7469757786715566, -1.3551009378197394, 0.2752771118124801, -0.6368808533189378, -0.214611196902674, 0.07024849167862264, -0.5796204902717186, 0.8585421394021627, 0.3641342173984954, -1.2744367402327736, -0.2818661417164492, -1.0178200470547305, -0.053525796909817375, -0.6803632242573996, -0.9413552292455681, -0.034903947591560625, -0.7302311241771973, 0.850279691536461, 1.3903855165735624, 0.37674721496235736, -0.06627380225331017, -0.9117300816346552, 0.6480996976140837, 1.2270757679597126, -0.09381753957813381, -0.07086658012073674, 0.699936351498156, -0.19847130400376908, -0.15840283402509384, -0.5117550519486449, -1.377920650931483, -1.3671648373822454, -1.1013431141467371, -0.15300647257538008, -0.35112425620939763, 1.124821355395397, -1.1517487448421049, 0.29916014687429293, 0.3460739372560775, 1.0297205439198058, -1.0759172939592583, 0.3480574159437526, -1.0777298115386487},
    {0.81798383116553, -0.5190977076958339, 0.4882571347784786, 1.4321496410054146, -0.8397574558376311, 0.20513610157177867, -0.46221395325058234, 0.6985806926188697, 0.12983693858124162, 1.1520857377584455, -1.1670793513612878, 1.19450353214791, -0.7190110081759733, 0.9142033995337739, 0.5183841341635101, -0.4090365261408943, 0.4146636438254163, -0.3022045918602544, -1.4870404526571033, -0.26036226613735286, 0.5189260902437047, 0.07894646378579195, -0.7719110481938264, -1.1293983067734514, 0.9145167504676909, -1.1753147921658005, -1.0541157611969318, -0.11239074412418582, 0.3972604623367016, -0.2823232807803196, -0.6919984492175602, -0.932264718982894, -0.44874961603615093, 0.4583254552641229, -0.4144806764647525, -1.2147697313731087, -1.4583178303987734, 0.5964898360240534, 0.349161141178882, -0.6339337748027302, 0.8904191243781417, -0.20732431048797378, 1.559906755147275, -0.9168865277143552, -1.0377644304837494, 0.256740329469603, 0.6514916665583185, -0.6798858636904859, -0.7319480816208144, 1.26583319954178, 0.9266841237111342, 0.447259006444389, 1.1645801418255854, -0.1665119413663049, 1.2897330362744284, -1.2877867810999877, -0.3860981577483385, -0.093630984480313, -0.9341555602754441, 0.37120024482541414, -0.6792007566873561, -0.7418161105193277, 0.5870224999404761, -0.5618170238746462},
    {-0.7820554577893135, 0.601184260975762, 1.3011887627012066, 0.0417749482748993, -0.6501659316663442, -0.44693716266495387, -0.7804675919509034, -0.2604343981419192, 0.7527546104710882, 1.0658175974399746, -0.1583156399750483, -0.7487640574278658, 1.18298102945125, -1.0601196828850155, -0.11390328349490182, -0.008460930432294353, 1.3485483132552105, 0.895684150421222, -1.1486130587793433, 0.009035253303841917, -0.9448182181471357, -0.905800551350997, -1.1483791548470952, -0.8929184790038276, -0.17254254795936647, 0.7855452720675379, 0.24054553749661445, 1.134566722553142, 0.07891374107228182, 1.1308012466490076, 0.5735407815723234, 0.22375410075456684, 0.8029515636771257, 1.450668383722124, -1.1221161137071178, -0.4457633653458872, -0.47399534347149513, -1.146019518356758, 0.0826628603681253, -0.8195690958445525, 0.11977357205514343, 1.2611348708514065, 0.11193398031275775, -0.8299646170496865, -1.0574859305058584, 0.12050649402157838, -1.0386091538416466, -0.2834382753277658, -0.00430595353928863, 0.879884618986883, 1.2449155581049156, 0.832323484370714, 1.3802574594892447, 0.1789185490642499, -0.25871701778754697, 0.9139708684358282, 0.11704691326300795, -0.8382833755094399, -1.3552373210707365, 1.19812801331754, -0.6260216928999056, 0.3886421269967305, 1.208298433416632, -0.4959170756530559},
    {-0.029915910677717775, 0.4945866856482728, 0.56787564194333, -1.0958551679996875, 0.42004782793362705, -0.8903268550495799, 0.9716808860246253, -0.8893227799796506, 0.2938369573306195, 0.410781258268028, 1.1836803771082658, 0.1736667323669811, -0.33777206459927556, -0.9347765934847226, -0.9932732476832625, 0.5721831194808586, 1.5734048360778512, 0.05811383166792932, 0.4050093413498062, -1.021661773722829, -0.6727761981629354, -1.4459717167721022, 1.166751017212098, 0.7349474773513754, 0.46466198968099204, 1.0072073197285945, -0.4337435164836357, -1.2110490832655327, 0.03564998971675398, 1.1627157686681404, -0.7819844144058045, -0.7351617862122073, -0.8937346816754888, -0.3813226080332332, 0.5412590541695042, 0.8564190099218785, -0.5819421462516368, 0.32620246851390095, 0.23767700380504095, -1.0722006574353216, -0.7263128754107231, 0.9995196267851287, -0.7380220435041351, -0.36805665593706727, -0.1420564173892209, -0.29721387471876365, -1.058042443830833, -0.8175299465859479, -0.4731612720403035, 0.1286962418024476, 0.4642519403533933, -0.33461894167601747, -0.540894703651767, 1.0679991923486423, -1.4189100140255244, 0.7088484085655423, -0.6003922870308416, -0.6836790669508961, -0.6177601968520531, 0.15211164764849844, -0.7649467314147309, -0.6427678732848091, -0.6619465226256461, -0.6492033258839067},
    {0.07771456269594824, 0.5108047062444544, -0.9922372594732872, -0.9036814938409071, 1.270219359998843, 0.3872105547239027, -0.683359598486405, 0.9041775707898978, -0.9255165912137591, 0.5134473219010477, -0.3508482758110504, -0.6613987226281142, 0.31235567600855396, 0.10410053713643373, -1.3664593879832765, -0.44015334304943, 1.500976894801474, -0.9509430880370939, -0.20688830474380498, -0.6542322314290447, -0.004412593700556226, 0.8127248431887918, 1.2178399524789532, 0.8872515574489087, 0.2734333164382997, 1.1051624602729233, -1.0862277926323458, -0.47449191381935446, 0.056571322360160006, 0.8668918530502803, -0.55939331852927, -0.876380070194613, 0.3423559608608655, -0.1501293035674617, 0.7362501438254075, 1.2067977721910912, 0.33600864276192255, -1.0943463755501823, 0.8338569068163668, 1.1228402823325445, -0.9459952082058095, -0.6270474859157171, 0.18308258113239229, -0.560111242656972, -0.6557868428360218, 0.05430884639812828, 0.4419333800527303, -0.5044167769807978, -0.6900768167142253, 1.0900344945509752, -0.5370755757975783, 0.3073443212299913, -1.1364892517417204, 0.09938800796416249, -0.8571862331273633, -1.0086041074671996, -0.32345177467946934, -1.0982932358954423, 0.6895508613534896, -0.45423533075871936, 0.9177509555923054, -0.9194208255519967, -0.3565630242379684, 1.0632348736025348},
    {1.1550694399204933, -0.8265666059502825, 0.13628587702178507, -0.7967199893223358, -0.2885001392106382, -1.081164383676687, 0.20100326916171132, 0.21685605974875005, -0.5842112799886968, -0.4239992348540267, -0.5762295507026012, 0.8975523841481987, -0.32441917776558193, 1.0296229056287707, 0.054466274791330656, -1.0570502651401656, 0.49513579245632305, -1.26340345566869, 0.10303284262758142, -0.6057442977978227, -0.8963149977481636, 1.085595406054484, 0.7029011885060746, 0.25718788832666456, 0.6153093901378879, -0.4053259997189543, 0.2822540560501903, 0.6467707110188753, -0.04706942484882499, -0.24225066477199336, -0.5089463010085227, 0.5449206019703672, 1.4356957332830733, -1.0552337364448856, 0.6012749818662423, 1.2463544133118984, 1.549089152379822, 1.0278073857710752, 1.0844820530270156, 1.4064883491109816, 0.03343414003089225, -0.021548880561810934, -1.186598714223779, -0.742805802829441, 0.9782969548296027, -1.37826870935155, -0.5969503371330634, 1.1532065561167664, -0.28945537062638127, 0.1246441859778322, 0.518407481548839, 0.10952295553978762, 0.20964986057256565, 0.6573383909795159, -1.2260729225197213, 0.1629946265947646, -0.823691458445727, 0.6269716983327217, 1.3858691119116, 0.5014636530303993, 0.1705817732398408, 0.2604914363821282, 0.13532527021945506, 0.9592621627410963},
    {0.16463047200921474, 0.6333704057956507, 0.17684694094753303, -0.8613262560158111, -1.5500356425008044, 0.35981864665314, -1.2593954696882437, -1.4361465869523273, 1.3851386441690625, -1.0928898236039735, -0.6117961970460215, -0.5327400993665925, -0.40689043313789097, -0.12391890187622394, 1.0193154445137635, 0.722117237578011, -0.7601323567196542, -0.3871286300800148, -0.7358156590494765, -0.6006648204147012, 0.5767818709817447, 0.6108326302619985, 1.042710908530941, 1.1243188175988355, 1.0917272150304693, 1.2694518355092834, -0.014336547036721579, 1.3196006948257106, 1.3118931498011075, 0.6397103509893126, 0.7117856909877687, 0.14620101919986944, -0.5204883656084176, -1.3204359803535464, 0.6454365795132531, -1.0331120348274616, -0.529740497506201, 1.0355095303049469, -1.164133346227083, 0.12341026668447969, -0.15543789851774636, 0.771647584212837, 0.5930077962904583, -0.7513613176332664, -0.9916075296832394, -1.0187054905433275, -1.3925704587211656, 0.45745761108290395, -0.4396555746859778, -0.3207404591358773, 0.13181139163714217, 0.08611197550422184, 0.3311521683068455, 0.6615075750143717, -0.9311770811178255, -0.5795668403370726, -0.6632715484869571, -0.7184720660624877, 0.23027991656436972, -0.9932255940917388, 0.3974467028122471, 1.0259632071421871, -0.017852963539624848, 0.14898331832260484},
    {1.322655277913775, 0.9031229199586577, 1.1506025451024369, 0.201061828899464, -0.12547958884377713, 0.23312754960247908, -1.1540442865345653, -1.0567183405938787, -0.4849955722801716, -0.3698286039815553, 0.04129152144792731, -0.08886400498465762, -1.039909286018527, -0.41498419067165593, 1.348782955121252, 0.5305300592789196, 0.6005979721015154, -0.7505571998214854, -1.1961601702854294, -1.2533961186714264, -0.6452236865433594, 1.1816843982339513, -0.9285560950883882, -0.022861713446503108, -0.7421252250413981, 0.929323153005172, 0.6502051053599267, -0.7070996148035041, -0.6944405682942927, -0.39990599557035694, -0.9555299766996028, -0.028891635241303427, -1.095364882219585, -0.854098468725015, 0.8575615791532236, 0.6231883303748889, 0.8898926969220743, 0.8469496116259773, 0.2992738136566704, -1.2638648911691008, -0.6394071422443068, 0.8664732533416954, 1.111064250483705, -0.3438792788692667, 0.09660403948219186, -0.328598420066166, 0.2988388877108647, -0.8143358026527399, 0.8245382899370465, 1.2347133811872508, 1.3756884834239513, 1.320841362675586, 0.21226742765904827, -0.7597182911286259, -0.014799210618797272, 0.09827006017461465, 0.09021189497705943, -1.2274391314173476, -0.0773785728232594, -0.45581913355523596, -0.9201805906284134, 1.517890818622213, -0.6559135748919499, 1.0524330416173557},
    {-0.938786979906522, 0.5307109414760472, 1.3856652140934695, -0.7571058616045266, -0.08793450349210463, -0.7897965079695909, 0.0673875526640625, 0.24303673801476047, -1.2400793601704296, 0.5906288076206315, -0.6431758800463613, 0.9437097325105241, -0.03900590458946268, -0.10490136970289096, -0.21947843920875193, -0.37954003108072115, -1.370705227826429, 0.34308044913793534, -1.3805158538225133, -1.0647766461330557, -0.8310821088449588, 0.10101047457566006, -0.7759965380975956, -0.05260697535319933, -1.3335456996531512, 0.490261548498989, -0.5073323448055675, 1.2797317073359515, 0.16830592885688564, 0.9613936195091711, 0.1281508913352258, 0.11940327771198561, -0.7480632808316635, -0.08287013570961695, 0.045928038782094865, -1.2916602604861225, -0.845428669154632, 0.6140726243452469, -0.2410350936108792, -1.4204361883741552, 1.197611262048583, 0.2725061273534337, 1.0780471166392156, -0.40187586930685937, 0.9957185099978091, -0.3573580796128568, 1.3944473307077194, -0.7914448584422502, -0.6030209218519362, -0.6408311268271276, -0.8560195699345432, -0.14395281417584588, 0.8319745258218436, -1.4742251782250573, 0.22138852982430895, 0.48461001076096505, 1.2294245983015086, 0.8972548448545863, -0.03455768376209927, 0.15204040190430987, -0.7022699280829834, 0.9377795684552691, -1.296046430203358, 0.6902091741218138},
    {0.8945162881825927, -0.686467046365038, -0.5437884593801713, -1.4098551934637642, 0.7888812275545706, 0.46978714841439095, 0.017728978851339706, 0.0002872234821247281, -1.380443185562244, 0.5989267015434442, 0.870675939076667, 1.4132104841466167, -0.03136085837066948, -0.2828036724568046, 0.7279244717161661, -1.3168105581305396, -1.6131291901698688, -0.7833161260200454, 0.9847107605997609, -1.00055145980171, 0.22563912226683694, 0.5677229647307372, 0.3184005940577517, -0.48642300948949485, 0.9518580667759988, 0.7232882454373646, -0.9427636886108541, 1.3055153523780498, 0.13929791886524523, -0.09173011839111211, 1.3717905044386818, -1.2091156303367454, -0.08370671725730652, -1.1543928398981402, 0.7831766410298189, -0.13338125268342363, -0.9283901374239729, -1.0777130978994856, 0.05785516603584665, -1.0771102859244779, 0.4843008599939287, -0.37169039009474963, -0.47573767735189754, -0.3533692777736256, 0.10208920598226429, -1.4718067537791395, 1.0928389963056575, -0.9710358664701011, -0.3612832829052905, -0.9186450521668734, 0.2842376732159973, 0.907626925816237, -0.39954437997382575, 0.14556455573964122, -0.22556263628729337, 0.22448125358047888, -0.31821169254181036, 0.5659927527809316, 0.532838342824844, 0.8609679236525257, 0.9988940632545299, 1.0966080103176066, -0.06065840353411186, 0.7079680756490918},
    {0.28436559302593906, -0.7913846148827883, -1.138503022895494, 0.5645855563779109, -0.2943940750727241, -0.7949602934098112, -0.9495404431743566, 0.2615391735447047, 1.0966843668401374, -0.7461926212187554, -0.11225922795309601, 1.115512205684888, 0.868444642691484, -1.3309165504445057, 0.400457595698924, 0.3695900541463773, -0.8663168314964861, 0.19872160141473144, 1.3733283062780113, 0.07467438345227731, 0.6176524860004363, -0.5336452134016406, -0.9238070529220459, -1.250832342101188, 0.9110619006636929, -0.5398516816640379, -0.04748959630562568, 0.23312425608399875, -1.2437622905828776, 1.270761745478742, 1.101187792009046, -0.6753975050968603, -0.4546097603849696, 0.7118411477285328, -1.4054452650614195, 0.5684763395394448, 0.967213191983849, -0.5349728194729945, -1.2053636912824361, 0.2898375379105875, -0.21425327930671242, 0.9264509767010218, 0.9312389805181777, 1.3182663452214862, -0.6284249500109427, -0.8406671348698747, 0.127483118934884, 0.3950595312222244, 0.12345399006434539, -0.12660007872068962, -0.20411825602646844, -0.9664833280939493, 0.19147417741184655, 0.8007303627122451, 0.8979736579194831, 0.660060679948685, 0.09841275727993054, -0.691493018998048, 0.05957433734693345, 0.14173594148286633, 1.2227560817822007, -0.01907449005119587, 1.1485232935379273, -0.906927756499749},
    {1.2678635356524488, 1.281232636856255, 0.37578027581393175, -0.7435385351568252, -1.2430131311265769, -0.42697850454546243, 0.17924283288458642, 0.6621589283557107, -0.7173380218738954, 0.3338534617178687, -0.88714444633622, -1.246808848400965, -1.0496914928636094, -0.5071792370479306, 0.38268175742514315, 0.1822757411700451, -1.2149332776545052, 0.4026910265582733, 0.8223147521388728, -0.048200722413734645, 1.158390441740285, 0.9859989196673682, 1.2268923297711205, -0.7620475530891264, -0.4784763216317884, -0.08008767760718644, 0.11923215095635624, 1.0842858922653402, -0.8814826665500906, -0.15311736110344945, -0.9556673303971059, -0.6123731909649248, 0.22265927357791063, -0.2808246183240971, -1.346456803593885, -0.9459406440678008, 1.6443875524045357, -0.09089960341860391, -1.0338723633894016, 0.2629927779135421, -1.0436091877273956, -0.35279492904137, 1.2056655765588506, 1.1578665582397956, -0.07420292123440259, -1.0996918739499626, 1.1395774402422845, 1.0331198927170528, -0.15714534438586744, -1.2887187346593547, 0.2676803229317222, -1.094374150587988, -0.6452914392866238, -1.2682047456725751, -0.2277736013935849, 0.1848325644851499, 1.2385030922831297, 0.010027232241825397, 0.4189355063063371, -0.3382489687256942, -0.43534546476684427, 0.6608180552617214, -1.1604571645731505, -0.1532707232662716},
    {0.759790729329567, 0.7232313567015982, 0.06072081844877159, -0.8688051443043139, 0.6937858639599989, 1.0841013570987283, -0.3787363336333211, 0.22340894032616743, 1.2260596311418075, 0.28055058397880883, 0.551122853390203, -0.35308377192477197, 0.24151102755689421, 1.2122220399475627, 0.2685429548196493, -0.23287024950194463, -1.0409401829943934, 1.2921517218970227, -0.7304698240829225, -1.1024188901092762, 0.9472041167256499, 1.0038827195867677, 1.1193907611218643, -0.1544729610035709, 0.71101236828597, 0.27563723293549053, -0.9011746916304986, 0.4460634769049745, -0.03454665981636649, -0.2849301547420418, -0.9307346867018661, -0.8600910513705072, -0.21550267898453307, -0.9680025932624707, -0.1433344885386802, -0.3041871972980245, -0.9543385623484337, -0.738901486869068, 0.8006508693981449, 0.8193368026110448, -0.253385027265673, 0.6033634235126356, -1.0081852574837753, -0.47001643787895286, 1.0108461280515983, 0.4704432574379976, -0.12007490498873835, -0.5940481125580469, 0.6510789035305593, -1.1045359812710165, -1.2072415904947869, 0.42544066472374453, -0.7305392406645455, -0.344159070939334, -0.2199769712686794, 0.3290870948119921, 0.12872904440229113, -0.7651500364907826, -0.10029294046546457, -0.6349207764326793, -1.302466709152231, 0.32677175855792095, -0.990487450946439, -0.007965268873147193},
    {-0.0997642956152771, 0.13776850110862743, -0.067878106336219, -0.5053688424276176, 0.42510774906390786, 0.6471313303885504, 0.49231800475854, 0.6139809834801543, 1.1078566588778536, -1.2762171003925782, 0.45030234847611045, 0.8908007578613124, 0.1099359350417131, 0.7822956915640713, -0.6452073688826085, 1.239899876615637, 0.26404172847559787, 1.0778366486273812, -0.19819582686994888, -1.3876015993007533, 0.08220941538253604, 1.435544062966328, -0.6599435294893701, -0.35858822311802757, 1.3597589577044062, -0.4879477637183444, 0.2635561100564091, -1.090439951813969, 0.6250647516757525, -0.6888052255872392, -0.6002738307902346, 1.2171145895866833, -0.34250597771779395, 0.3287668809798962, 0.6569967359759292, -0.467580339606358, -1.2216478863927078, -0.06550735890485165, 0.2449424939648336, -0.8354938148926252, -0.39597203545819276, -0.3056244029977021, -0.6136687548326853, 1.4988745485095925, -0.17642015032083438, 1.546586211090405, -0.39218300405771706, 0.15091063362338586, -0.43041077511371945, 1.3203141824985907, 0.27322170995795003, 0.852728654634645, -0.8771991205342865, -0.7396581410884104, 0.3971005111447344, 0.12640151333754582, 1.245177667944626, 1.0043225170151528, 0.24207040053987958, -0.05480653305405879, -0.7080055319764625, -1.289585109498242, -0.9439172461353857, 0.2514866726639885},
    {-0.5971250126051411, -1.3460929905960757, -0.8844339644651512, -0.7088929031866316, 0.35995600210329093, -0.11036040095636751, -0.7394911439671166, 1.2734525294506758, -1.1085866250180376, -0.2990024037621657, 1.1573211123454512, -0.8130469711421071, 0.8962052779731797, -1.001509548517753, -1.1171087023192596, 1.2236488490358846, -0.004060516114471703, -0.6260272096141544, 0.5123688121113875, 1.241462802059864, -1.346362729328984, 0.09609320409493062, 0.05249550126336897, -0.8681828815742083, -0.7601541965171172, 1.076636537898712, 1.1274189317269232, -0.49427723217073666, -0.8047274643251625, -0.5400233087026903, -1.0895839107805176, 0.6956276364393943, 0.23439550168977608, 0.04023606127824111, 0.7781253419288586, 0.699382727398697, -0.14763734041162555, -0.3120230015245771, -1.071728470106959, 0.7356022321929251, -0.20990901134410514, -0.9656422191916975, -1.0903479490402723, 1.1109415454984608, -1.0208640725458236, 0.11525012282376261, 1.101424975832723, -0.6543971448080335, -0.3842687275661027, 0.938065332304552, -1.0469253105594578, -0.4651875020535874, -0.1290050731929003, -1.0605449554623998, -0.20900876925226308, 0.06243323213525018, 0.1754782951379259, 0.5995827910754369, 0.3146572361563561, -0.33949184477983313, -0.8700180602290385, -0.9224905880206684, 0.11803795764605751, 0.7435167365630353},
    {0.12199628313461953, 1.3911668815533265, 0.36684168103980525, -1.1882894654909415, 0.19341148433267688, 0.7559200096411328, 0.9058156430198199, -0.023639610212545167, -0.29822852526783794, -0.5648298619589281, -0.3159769692454422, 0.2795967876364682, 0.6783701991311764, 0.17720741996618378, 1.0018003838875655, 1.156114357601826, -1.2749962676875002, 1.4301006407930839, 0.8813028572212374, 0.8148315062250159, -1.1827359576089718, 0.6309409421424911, 1.2720581508152995, 0.38526413281834676, -0.28539933434677306, -0.4630661769564455, -0.5708151014913977, -1.2836218404884714, 0.4663873630894987, 0.5003992763883487, -0.46641017346426505, -0.40256565281452256, -0.34911155554606504, 0.8099272800470073, -1.0573566665269931, -0.4622471032957022, -0.6747361844950955, -0.0076902968393365795, 1.1108291112711566, 0.5338691941645187, -0.2654710191394301, 0.39444874060568924, 1.1126226552048673, 0.08691981573619452, 0.2534737830576186, -0.7931276075879592, 0.5005468255760193, 0.5955616538454359, -0.8289662853549672, -0.7354550074528653, 0.8366148603856903, -0.9903304828624356, -0.43472468388433255, -0.20480005757186026, -0.6270563995475552, -0.8610707457695436, 0.45323500919189186, 0.014833244765312592, 0.08802686062450656, -1.1344283538066062, 0.1754801101147868, 0.6651659462838504, 0.20925298367837775, 0.8503846986111024},
    {1.0490855641521792, -0.5957080642190782, 0.5011192390696122, 0.5910261433690654, 0.6488366860013093, 0.30769320557062807, -0.43823394802425825, 0.013611409396309806, 0.8953912118199915, 0.7889496244907633, -0.26395178291102145, 0.35100584103826615, -0.643811837647212, 0.040908892882210765, 1.1931110479617666, -0.18088913132021028, -0.4069438876818489, 0.7135294324412885, 0.39182966678218323, 0.6561090166871216, -0.9322278166209488, -1.202777603251465, 1.229763348354416, -0.6099005643735254, -1.2913071902725906, 0.7286732233558262, -1.1228071536512447, -1.4918242605413123, 1.1073430056686655, 0.8569058047363932, 0.19708858394751133, -0.5092617380312143, -0.3348912026758787, 0.6571110698772348, 0.16539469387755681, -0.3335092052382979, -0.17093109622184846, -1.2231113444390116, -0.7646355740677012, 1.3680340083226479, 0.19097982609700925, -0.5998389423681413, -0.43024583141092143, -0.8456461808442742, 0.12056351322601785, -0.5674426406442239, -0.3846381514149605, -0.09395959572557086, -0.544055077750393, 0.48301696815810624, -1.0636471014624531, -0.8003090166560652, 0.5208915459740054, 0.40576677819875756, 1.2028143148786072, -0.9914951875442235, 1.3238592372889701, 0.261671770372814, -0.40090579941038806, -0.5059673574090616, 0.6206413831843086, 0.6648579731714878, -0.1887992549269351, -0.18072817546164513},
    {0.34401437737650703, -0.314488973296908, 0.12166533464218371, 0.7121090631018474, 0.7780372437757653, -0.9820303424614893, -0.3931782678661613, 0.36422051389906585, -0.10427134183157927, -0.3954935085934991, 0.6656786348099694, -0.6616671303454591, 0.22094537607058104, -0.5396218914968337, 0.7049612599973505, 0.6064191401103856, -0.1908897874664417, 0.11290107934114754, -0.07519595468192353, -0.42229408841668076, 1.3622797734141074, -0.9414629108148975, -0.1759757761469756, 0.006100683775933708, -0.0020864653007280974, -0.844328707630758, 1.2533794974041126, -0.4318209539032611, -0.3818596662534346, 0.9943408706429058, 1.0939064872142439, -0.29695233579176583, -0.07281191460031144, -1.0756227983423996, 0.6396427856749688, -0.3573540263558887, -0.8165186347714488, 0.6138792473253114, 0.1662557334291138, -0.2333776087829981, -0.3347660242595458, -1.081124102868844, -0.0926568282236034, -0.20863125208208846, -0.6249670493346196, 0.8395252777178092, -0.9285615941749564, -0.4006268005423889, -0.8735587160103344, 0.2229039372684023, 0.07612995264811193, 0.9557067347916478, -0.6886286030548844, -0.565267804054612, 0.4883179159434705, 1.0322443955497955, -0.8209583323253727, 0.9499838224104602, -1.1702827008784547, -0.6835714542926368, 0.5290228190640208, 1.1123445803803358, -1.3083138389666709, -0.19575797071478546},
    {0.6428902533708352, 1.3258614290625432, -1.127982762994751, 0.9708358069306244, -0.739861639764559, 0.6489033979754169, -0.9301720718835402, 0.4149391398092682, -0.7162174699225031, -0.34902053978252057, 0.8734157784456759, 0.7435785903573874, -1.1189977582690929, -0.9216299843761715, -0.26408863344694533, 1.0702549017079108, 0.6783710237013488, -0.5412343156990904, 0.7473272006099329, 1.0146703480884516, -0.43216387687801994, -1.4832892186347726, 0.2428647553149032, 1.0324556297015246, -0.37194761165834006, 1.1270559769545978, -1.420203125963889, -1.2873938097668218, 0.3064475250010753, -1.3958284008474722, -0.018005950268656076, 0.03617136689928178, -0.6860565630265496, 0.4164035820451432, -0.4002148416577347, 1.266510603000687, 1.1871438423064542, -0.553002290377385, -0.302434701880684, 0.9350387985803631, 0.2530918057540798, 1.2351292088890455, 0.8037860763638691, -1.2563821108765696, 0.194591588822602, 1.2856964087438583, -0.18611872933864906, 0.01735388355153489, 0.08278764484564222, -1.0742866558581097, 0.003587773272861392, 0.507160828144485, -0.4097747805416598, 0.7653348101820632, 0.2523034631139793, -0.19233019236374713, 0.271967958062561, -1.2022101807761172, 0.7682903363505333, -0.32973310658371713, -0.43250479505340145, -0.11101007670683657, -0.7417829465194303, 0.008103264034812839},
    {0.8515339036106873, -1.377214711189443, -0.8487968580750526, -0.6451179108031027, -1.070551314285166, -1.046559062109275, 0.1583821823853941, -1.2678523064924592, -0.29110850891980405, -0.11658479192713062, -0.4919599900660516, 1.1365671873810548, 0.11845630876850147, -0.5218516501908149, 0.25362534474810555, -1.3534669669137411, 0.9016839670148632, 0.8378497155692358, 0.7245747536593264, 0.6846215657735025, -0.6005105240815714, -1.2118628084456622, -1.4153602500529017, 0.6831914727329232, -0.4048407051719951, 0.8707818710806695, 0.2370581892186087, 0.3174291428650572, -0.723360737627076, -0.9200602030303311, -0.8997984593413971, -0.869230688448332, -1.0964369677993784, -0.7172640755831071, -0.5341786860196923, 1.3484462415854321, -0.899451898230702, -0.055468308154786886, -0.05937859601673184, 0.5707130373162529, -0.7490661617606751, 0.6524835898396885, -0.7659922920204913, 0.051068878458943055, -0.0372081865637142, 0.6309027315422602, 0.22834127203532203, 0.12914205668733816, -0.5482500355923055, 0.6750383822094081, 0.3546846906904104, -0.9594080599744977, -0.5187862044223676, 0.4812555262888318, -1.334105274422762, -0.41207438527559986, 0.009254165191969034, -0.15612279205395768, 0.09831977820828715, -0.27612894507032315, 1.1976790260625563, 0.13660834629080862, 0.6075288444343062, -0.24124979518091713},
    {0.9022294470191135, -1.4837438697371252, -0.8881586297379511, 0.32772426515103437, -0.3936309151085973, -0.09540344494283653, 0.26105593304597324, 0.8833290663940281, 0.11807993781415045, 0.1791319910116371, -0.9772212272894474, -0.10427210953697319, -0.1422471224933634, 0.7110179022589204, -0.6451819390360211, 0.1289240803324832, 1.4673633535895545, -1.1739672752935446, 0.23534497683396466, 0.18754067684944087, -0.0238397078837321, 0.5530600763513139, 1.1924002300403418, -0.5336799767624618, -0.6867590266482352, -1.5606669540113614, 1.0393316463928077, -0.2831246464170406, -0.02970929400931365, -1.059607309467848, 0.5750504947245181, 0.6032972279106565, -1.1747510374301848, 0.7169694587269098, -1.1193278614826836, 0.08009473839215767, -0.2973440349430293, 1.141606129349313, 0.7487998656570224, -1.0753576151067934, 1.1657872116391303, -1.0447294423058195, 0.36029091197764185, 0.147163040372114, -1.331713878788947, -1.290158574492812, 0.29182449718192965, 0.663629065045616, 1.1914495079175946, 0.22056721257092443, -0.18775164581078285, 0.9984119062689658, 0.650524476087196, 1.1028018099180865, -1.0983488682814981, 0.7254850022643797, 0.3230994417592827, 1.0612053490761308, -1.495695590941127, 0.1883394449940473, 0.735346601139621, -1.0450612096660914, 1.144557041821197, 0.7932581749762208},
    {-1.0098821989059048, -0.36166440729681165, -1.0364690481501155, -1.0527489682280127, -0.9071029260871136, -1.1481656631960746, 1.3245106557825035, 1.3449575182389122, -0.8067736503764897, -0.9169750093885328, 0.4434595813071561, 0.7973576385801069, -0.13523332325201076, 0.7398306312267033, 1.298180923116026, -1.114808104082341, 0.6573626459073018, 0.7764804978575323, -0.48864353122212034, 0.33338236206495425, 0.9889043417840001, -0.31432526692611434, 0.44214158401762693, -0.4305121527774347, -0.9423238826361248, 0.12610898015352348, -1.3712383764092646, 0.8756623049352338, -1.065756662003304, -0.3793844220790422, 0.8805286523163119, -0.38755276434066716, -0.8076900869708158, -0.4702910473180991, 0.11258576573211247, -1.1178249456071934, -1.153132976670228, -0.2026240458693568, -0.6524729969111158, -0.8749009360946014, 0.8400404816985575, 1.1579461326065879, 0.02758106843701398, 0.19754400523512633, 0.1564892922266193, -0.777858451896932, -0.319385617585768, -0.56291249914218, 0.20803089982233514, -0.37571473256287685, 0.816519465450968, 0.8981165848345958, 0.03723523996958973, 0.3658468165378959, -1.0896535963766807, -1.1356166092068827, -0.014396947131395674, -0.6376211247444497, 0.19802518324713347, 0.7675835396089671, 0.16237176698713043, -1.1313383284552265, -0.6952236405798004, -1.330259423202724},
    {0.45009644446331093, 0.2810031893512453, -1.1034859141044149, -0.4807999187052343, -0.5579747032854627, -1.4722512025753813, -0.642274870546572, 0.6769107412801376, -1.175590457920781, 0.08038202712686515, 0.6952288062970244, 0.9702117561957871, 1.0834061946838691, -1.4482210729175395, 0.8883708919756094, -1.2956640601238116, 0.04171590641041332, 0.9594853080908488, -1.275270386157784, 1.0364087139444191, -0.5623192834384121, 0.09230668896097169, -0.20998137506291248, -0.84447764835369, 1.3491562784898092, -1.3495850227033053, -0.478916654790905, 0.690173706342648, -1.6644339673056563, 1.271707065722505, -0.06304344809283913, 0.35151622380852754, -0.45192999683181767, -0.025902780289657073, -0.9072763003736949, -1.2428700250701146, 1.057178848994904, 0.05727720179506945, -1.0482410827184252, -0.5529748917833789, -0.30855210661271515, 0.8773612666097645, 1.3549863813451166, -1.445652719253493, 0.21907078401125074, -1.1923824013821955, 0.5320432987234313, -0.9385757551408536, -1.2222414534150425, -0.7538003303441627, 0.9699208847456768, -0.18333795188920857, 0.9993321622211956, -0.5362585814041113, -0.9187848528603832, 0.8609536232462229, 0.559704889957228, 0.9157379942394017, -0.09531689542842561, 0.10852148310731115, 1.1372230526914862, 0.19821923464803595, 0.6327399968381231, -1.3954840281450447},
    {-0.6724430494801227, 0.015424064649208787, 0.11653300915378813, 0.42959486289907345, 0.47483955925935667, 0.48101074944610017, 0.23036992232108136, 0.16103204217878567, 0.4815604353616005, -0.3161416918083189, -1.103004061227407, 1.1396409866000075, 1.1542045189403112, -0.20612225233464976, -0.9233795001174308, -1.0028082619140375, -0.12610632982759276, -0.3703941740154587, -0.35318814647744173, -1.1121384962814724, 0.8777585538462196, -0.9744319582417794, 1.0454916445128348, -1.2495112761492813, 0.47214024975549546, 0.7771605294803633, -1.0620922535993422, 0.08634868220732611, -1.1150965359367664, 0.025103962783087852, -0.4850199914385632, 0.7914053988187871, -1.0174466435837068, -1.0179742708427717, -1.3971534017142917, -0.42445542848159956, 0.03179637622856221, -0.8041530013816187, 0.4161588204174291, 0.4747265782111514, -1.0628866371404275, -0.4005553943196735, 0.6243205650071172, -1.3253395719382057, -1.0393386755428877, -0.787698799925988, 0.8230701783140077, -1.0574028919446594, 0.5064711517974122, -0.6527650004302875, -0.4290896804275321, 0.46094927540104574, 1.0163312958263602, 0.21182756877586806, -0.8537133484683405, 1.2684909812434582, 0.5438263360001591, 1.087336972941568, 0.8996069276942859, 0.891639686095543, -0.5067937383445295, 1.1533225235966407, -1.19011354915941, 0.3812567648720608},
    {1.100843824433751, 1.2286928429404904, 0.20868912719684676, -0.0831860502843086, -0.5969630070011794, -1.095123706804482, -1.0929354018420876, 1.242119223122684, 0.8638565643469259, -0.22588816416578136, -0.336449259489398, -0.8013139024200483, 0.9334671305525699, -0.7682090074192194, 1.180701592062569, -1.3937709086017025, -0.6978038285317062, 0.9131157029598909, -0.9383172914540098, -0.8405184844573069, -0.5437539240535127, 1.0294933965283974, -1.0986525930302455, -0.7695565113157679, 0.09480689156759048, 1.1259784859692092, -0.8402984559424574, 1.047386822989266, -0.42595504691945124, -0.09640815186079152, 0.4481525088758977, -0.7716789706142305, -1.1041309591201043, -0.6674631039420063, -0.6331184325530285, 0.22281814936846173, -0.5786455454975455, 0.31994346538296226, 0.04587146329120381, 0.036253693571065226, 0.6955547489922941, -1.0701948481134171, 1.0856212638494758, 0.79012426327751, 0.8773200472761113, 1.3430369848921297, 1.3064125157040893, 0.340844702981638, -1.0444975278746258, 0.5276862833724513, 0.3445061226584276, -1.0762834044901224, 0.46576167090220366, -0.07694264938397506, 0.390523800251896, 0.3620298341051421, -0.3458082223010072, 0.2923819968830621, 0.18814950538039474, 1.3256814786365982, 0.545875513946076, 0.18571868476084558, 0.28317289702763837, 0.7729060957426667},
    {-0.9276515778894852, 0.3342322841686635, 1.0424054892056633, 0.5001983953327437, 0.09861110370535231, -0.9675843853297484, -0.790932105824536, -0.883843865908541, -1.1067184464313182, -0.7197575501658219, -0.10019793967293508, -0.02194554899401326, 0.8133710527964103, 1.0948193509376465, -0.9302085120019866, -0.19198812382639652, -0.7507634028353681, -1.0524636971079622, -0.4599534764843653, -0.7154740133947887, -0.45914730515458607, 0.3294244833001298, 0.15785464789792755, -0.35096378439417963, 0.5794471175966616, 0.9895025610790615, 1.0738108336949812, 0.23462489589830743, 1.4442623023563057, 1.0834525889357656, -0.3053434147096938, -0.5276071238542653, -0.5673578117924081, 0.4039320896508258, 0.08609671988344234, -0.666881210997786, 0.06105203609395891, 0.451169807543579, 0.5476027619888407, 1.2782576082980228, 0.41427462879614757, -0.04410040283959133, 0.7674514756565909, -0.6968817751122066, 0.47325932962038825, 0.7754972818390526, 0.7156299944330454, 0.9804704032139528, -0.29368814556740885, 0.7679337932767543, 0.27969177503667964, -0.6841267438444875, -0.5576917385910345, 0.510108297812181, 0.5630578404896881, -0.7506102119400717, -1.3565666032521413, -0.1307598755555514, -0.5177567370538735, -0.648788290632721, -0.37387583974175276, 0.9878597252006045, -1.0236342642555218, 0.09953549581901532},
    {-0.3217746448812653, 0.4624171669984536, 0.7536095404166456, 0.6345514035324012, -0.9584913111061227, 0.8191355182868602, -1.4230419360534927, 0.2086486200444755, -0.5262249745832033, -0.21914658765735598, 0.9892262551068725, 1.0322966399104148, 1.1671495048491805, 0.447142568068907, 0.06582290575448052, -0.7941961112540268, -1.3116042045967733, 0.7578625519382278, -0.47483794154103176, 0.4993773371995439, 0.9541004483075547, -0.18974777908187584, -0.5423493790359427, -0.5718047050346249, -0.21901596786862668, 1.2219300811465605, 0.6919308999650772, -0.3489826812073225, 1.3803120459134366, -0.38594260841693845, -0.05836369769090471, 0.7407038064759155, 0.8962652877115317, 0.060630648478353824, -0.9580210912321704, 1.3781231672462435, 0.6153866708631588, -0.08628702285728186, -0.5884939234995477, -0.13982872960488857, 1.414876437376507, -0.44465901909241407, 0.3957049999520034, 0.7159318218819648, 0.4864731666527299, -0.13850274727796466, 0.8977193245112046, 0.2120256386737332, 0.7741215805973454, 1.122903389137759, -0.01962515724525534, -0.11995479379436359, -1.2538822494293067, 0.2027240760475646, -0.5398812186703961, -0.6216073881276002, 1.3145428152746546, -0.05568923034933515, -0.2751140984265183, -0.965940828240134, -0.11823164657404411, 0.1136636030792969, -1.2267930227400712, -1.341041919450316},
    {0.6852329543043221, 0.9458441310436463, -0.03827225903643928, -0.8358559170438891, 0.7443616157242401, -1.072233271427639, -0.0983664234626872, 0.25287706544065336, 0.7737061776963912, 0.6744389949823606, -0.35773600555328017, -0.7032993472467247, -1.1911115601989923, -0.23247304373180075, 1.0996527494661472, 0.33494058731665993, 0.3926763562699899, 1.0241397750627201, -1.3219219022579705, -0.0738574329099415, -0.6596882616474722, 0.6741091017138006, -0.7264456597558098, -0.9701908462651698, -0.5403860654621326, -0.9360012865462166, 1.2695936337457938, 0.9641280161888234, 0.44677503035395244, 0.7612733695399018, 0.1299088779149896, 0.11949345852609784, 0.4582354565318639, -0.9823554625903276, -0.7673449515687336, 0.37280844720499084, -1.0110614816582089, -0.7606829187476085, 1.022930243506565, 1.0797577626742365, 0.3140637162124706, 0.8668409267073144, 0.7397906326807567, -1.364283548795448, -0.3357681196169317, -1.2524537905545239, -1.032016236546748, 0.12822522869044697, 0.24731445834051952, 0.08775600303235745, -0.4647280146937958, 0.32008508741292513, -0.6065745471948781, 0.790075852656073, 0.513945734977755, 0.04517890925744954, 0.0900847687530047, -0.1594059145459128, 0.6201619529499541, 0.9083793825992625, 0.7663018294893761, -0.19847249960194827, -1.2640892360171403, -1.4717868321342482},
    {1.343901037085341, 1.2561150423201384, -1.3347453817638433, 0.9720409756660964, -0.468736884405983, 1.1690574117295376, -0.7460097283608937, -0.34025572533531373, 1.345080956655116, 0.7013777008103336, 1.052376243633203, -0.12393266539855236, -0.5645548644856082, 0.008248118299845663, 0.9574949955876942, 1.1688934007571872, 0.7810030443261528, -0.08908743433649811, -0.053914629178325624, -1.1243826573420441, -0.8699887119714663, -0.5816769576875542, -1.265060566790153, 1.0823061042876345, -0.0371979342976664, -0.37675710694256, -0.46911091617563583, -1.5669210732445837, 0.5322852514985433, 0.34900643256552677, 0.2661698125606539, -1.1647526780517579, -1.72625135497983, 0.5255346643075414, -0.6516995394529037, 1.001211745640398, 0.8876485918365163, -0.4815904580665772, 0.24886387625706713, 0.5748888988777434, -0.6122051978343248, 0.2903081821343707, 0.45867630848583973, -0.594135796898785, 0.5062085492258198, 1.1117639064292253, -1.1928923342412023, -0.3979694208093777, -0.4504226011368651, -0.14861499268658626, 0.653117378417351, -0.7963442651761005, 1.1932970124322124, 0.24702019431470001, -0.2531770856006039, -0.3014920128277764, -1.0118976352236595, 0.9550809871069408, -0.17845353442501696, -0.34615172903806485, 0.7062101135216012, -0.4676673034936629, 0.611134791252618, 1.2561026130229593},
    {0.59763997230507, 0.7955123399324847, -0.9989302613186289, -0.2854762847364279, -1.0364846640811385, -0.16750272706796393, -1.069754893773438, 0.2778757901119432, -0.62599099423876, -0.7916349691878243, -1.5052329149399362, -0.026419738529216363, -0.12923004287514275, -1.202565583810555, 0.5517656326462183, -0.5790947950504618, 1.1673594109455494, 1.0693528730838, 0.5576194089445035, 1.2379750619463952, 0.7147522537860298, -1.7632878773257759, 0.06611464601764341, -1.0496793640919793, -0.6544664019670433, 0.6160146073521408, 0.8828926611428344, -1.2083215064487103, 1.1086208904377464, 0.29851571291142626, -1.2297426953249762, 0.3482467471119799, -0.9276617860772074, 0.8271567203105733, 0.6046365587340157, 0.980585151983112, -0.16510281567958404, -1.7822081407330475, 0.9427219505875297, 1.4319868993350082, 0.08621729680030714, 0.5217334414381966, -0.4646446033199259, -0.3837561631817566, 0.12060816546943685, -0.9839833778720728, -1.7875463492608508, 0.9841813124670568, -0.4059858341121573, -0.3072984894870136, -0.8736412627492129, -1.6864384090580262, -0.9523952183827831, -1.1584150263216004, -0.09377573243667171, -0.6618964349689076, -0.7200208955044466, -1.13588080689308, -1.5200127667061427, -1.0106821189704365, -0.34219190128623683, -0.6744078327191526, -1.1498496622609369, -1.6769597178923072},
    {-1.0053308663367329, 0.06359999637770988, -1.7508637557960436, -1.162596476506655, -0.420199556868472, -1.606558685556517, 0.8826018676221651, 0.20252534548346865, -0.8768344053483182, 1.3612747557185076, 0.5892366119037123, 0.4374192789904149, 1.8033996800047836, -0.3449597869020617, -0.6008086943027321, -1.4457339217734342, 1.2285710425131926, 1.1377095447533632, -0.43861903186363793, -0.277779337950203, 1.4518814828124182, -1.3900142793544477, -0.6302843977700154, -1.5822993563826844, 0.5126808197497523, 0.3198578063242472, 0.7744229483635494, 0.07862179545593125, 1.1889982916649193, -0.8416368488906246, -1.1944620338296517, -0.9091510244235328, -0.9282636581917483, 0.5862893938557606, 1.5854939029632422, -0.9870520044308908, -0.02038478944672777, -1.1901890339074201, 1.6027246316907506, 1.35657894434676, -1.6810723616171834, 1.5891394367220293, 1.173979972712827, -1.0081944189921495, -1.2957913360456177, -0.9727668770137473, -2.0026028793074215, 0.6769091350578775, 0.34790113688917673, 0.18255147802392593, -0.6100049444611677, -0.2953611015631232, -0.06426770478811832, -0.21298203327697374, -0.0913401177579977, -0.3566790413268509, -0.8361484856334349, -1.1370944009525823, -1.5497458153726602, -0.4061528510188741, 1.0637417744751867, -0.021236628063608095, -0.3582056085446666, 0.3090033082759118},
    {-1.036203329204591, -1.165852846210458, -0.7140857983885335, -0.4085840023978489, 0.5704619115291738, -1.6048567627859323, 0.9541682729355153, 0.04971633607865499, -0.6034614756341312, 0.3495001583606823, -1.5844715275078882, 1.213334868643087, 0.9884174952194225, -0.03228481878532189, -0.5519449243277564, -0.7285173875429125, -0.5463492444092024, 0.5930299071017929, -1.4715562754854914, 1.147870463172911, 0.04706287096981846, 0.7913375681302864, 0.0527630474360594, 0.19571859843557807, -0.5498418154655601, -0.6856044959228612, -0.7014338637662275, 1.0739357268697114, 1.0705254087215064, -0.6228614804857368, -1.5156820509326865, 0.5681865924122013, -0.9822709355851637, -0.8316922219056909, 0.28951351813644494, 0.804145429804364, -0.6186470531092859, -1.3689312319414524, -1.0141186879798592, 0.7533632429245948, -1.0853886626858726, -0.14794348430408116, -1.0743908873154437, 0.4131926884556098, -1.0719055690361288, 0.5848915622090601, -0.5748144761371438, 1.0970794893220057, -1.5570049016397198, -1.2360729128259278, 0.3899856794960804, -0.3704880529409847, -0.83553144931558, -1.3300957537261953, -1.1417049222859432, -0.9261945786077512, -0.6080885989911387, 0.9009126842450312, -0.6695584026578619, -0.36904606465743417, -0.11257274984756391, -0.7744765043511871, 0.6030742502618192, 0.795717552230136},
    {-0.37303805197587053, -0.259601284890627, -0.696567336434829, -1.4281956471303636, -0.22910283766959844, -0.599361844422538, -0.5356481976263129, 0.4087016458450104, -1.5978123553019394, -1.1472595625224289, -1.0405478266721975, 0.26503231117517145, 1.273259145109859, -0.35019433576994996, 0.2756003865608891, -0.08992153091603645, 0.08816713494259733, -1.29401771580888, -1.0293487103348702, -0.8442588343951465, -0.18083010647685166, -0.6248423922569807, -1.150367565418152, -0.1566816203883016, -0.3183929967612774, -0.3880852530784147, 0.011844213135878112, 0.7779799489245648, 0.3904034594137953, 0.6422416507744859, -1.1004966292152094, -0.8471592226241851, -1.2897470539449472, 0.46505222935552776, -0.014739698311184391, -0.4884305615148294, 0.6989155141488381, -0.683345153209461, 0.4635746988283332, -0.03919149427618839, -1.3469174757799405, 0.17406999534519188, 0.30868941888735857, 0.46477252543128994, 0.41963996317517893, 0.6369464967687329, 0.6496634425534298, -0.701191131882647, -0.8812368464530472, -1.069181327709384, -1.320495973911525, -1.1194740601179052, -0.0003791743713177811, 0.3936457925627948, 0.9526025383291866, 0.8647251232862246, -0.23594220099185031, 0.9533046125516007, -0.5260852031155523, -1.3854126295556346, -0.02792123380681091, 1.2763568966087286, 0.6313705660163826, 1.196536272659462},
    {-0.2212688138947636, 0.864929446617062, -0.5711160430298685, -0.3366648640081268, -0.5640551142416068, 0.48774136527008444, 0.6322991631062187, 0.6687675651304144, 0.29454001383742245, 1.3563402580260218, -0.8718792894777172, 1.354247672444353, 0.32058116977368073, 0.31059826646650335, -0.6014082901748183, -0.4970606704900818, -0.5691948459338334, 0.36121466215136117, -1.4909762307017314, 0.11538521257377612, 0.3341410317611452, -0.9675528949509119, 0.5794748040958949, -0.6201771045213588, -0.9325864628986633, -1.0535880982162595, -0.29641291749459053, 1.0346261782162847, -0.3950206389284156, -1.306586450214337, 1.0336521597095156, 0.73110163552128, 0.006326411504472561, 0.6165025900786886, 0.6397361736377318, 1.0304200839342945, 0.22835240377062815, 0.11104382345658437, -0.7835359374380587, -0.08453520708895398, -0.13829903633412724, 0.3785515321762223, -0.14131104259609745, 0.45835484001095345, 0.13035189205359438, 0.6511365675487037, -1.069162208513783, 0.761188478618559, -0.9627151143416769, -0.7291069984911788, 0.5517384024688426, -1.3168619972875124, -1.5361213975231618, 0.6830588539201804, 1.1711341456243431, -0.9146712531151534, -0.5480887536645611, 1.4847023083666668, -1.199083822342986, -0.8925421619425845, -0.2505675373763632, 0.19712653188004525, 0.5558759354394999, -0.8985245189192426},
    {-1.1530649992357898, -0.951823614881453, -0.7343833845417158, -1.2591063816125352, -0.9532879470338752, -0.23620558116646173, 0.8803511684596126, 0.5276883745203103, 0.09850460538670917, -0.669757144750927, 0.440272108733579, -0.7093687149873381, 0.049622228035101454, -0.8122114062131096, 0.9599376364789332, 0.9748327190251496, 0.5935641467477323, -0.10925513002091099, 0.9039944115885895, 1.0400618761973037, 0.4767684219422167, 0.6876246394534438, -0.6427736287321966, 0.6402343907121033, 0.05439847097974879, 0.45957636820757114, 0.39269716253747183, 0.1532479352534308, -1.1142115214250843, -1.5425183509640978, 1.2784072658324073, 0.41574026476495257, -0.26528269832428714, 1.2392430527839164, 0.4048662158566526, 0.07642190196050533, -0.7136724514702983, -0.8558042139174142, 0.09589539526604396, 1.28387321349822, -0.49241722532183435, 0.9218925626898002, -0.4301494273810541, 0.09936420538363816, -0.17641372775421535, -0.8101089616766216, 0.8886417590709524, 0.881510852503805, -0.438540492630082, -0.7825866724163498, 0.9488432938031034, -0.7573808053184504, -1.2003622537344334, -1.461306832136211, 0.6743763563178041, -0.7569421490269554, -1.480023229733756, 0.020202878726221733, -1.2528655575508236, 1.0007513012829943, 0.18553993970096783, 0.654546437798213, 0.6803410950688832, -0.8552716821795681},
    {0.8467914730010255, -1.3179265120811199, 0.4799275195272809, 0.29709623470773966, 0.06672847318594821, -0.2183424591024246, 0.8588280071851949, 0.4705600887585917, -0.7495468235106425, 1.236144820301999, -0.8979357019372254, -0.27903271557688497, -0.6338522123492539, -0.7569117361196745, -1.2429353521336524, 1.1873997379536554, 1.6012071010218718, -0.07327869900654488, 0.7698054125065992, 0.2893087504383951, -0.26171703709910504, 0.8511993477255274, -1.3262087980710275, 0.5045759172401012, -1.5051582787897062, -1.0154180244681001, 0.5290183173779763, -1.093874841428459, 0.9526248287929161, 0.9417715188041255, -0.8992587463089092, -0.5528182006134332, -0.23966428645732832, 0.07253900949132586, 0.2913866418953662, -0.38621164069766895, -0.02774151659955335, -0.37795812111095145, -0.9951017283156184, 0.20902595088159928, -0.09057579186790445, 0.7999440597625872, 0.7283395179433417, 0.5172439656766652, 1.0299108302324678, -1.1049388799064386, -0.050869894154687616, 0.7084083695392261, -1.5898760479588332, -1.453295872421738, 0.3615710883241613, -0.18044537898561575, 0.2887705302664092, -0.24221569343681978, 0.1321841348685454, 1.501487312162917, 1.0703440743696506, -0.40208064513481956, -0.18246240397728133, 0.3755055759998202, 0.6333905879715126, 0.6503455235441704, 0.6910909325279093, -0.32056534958261473},
    {0.07259093932801883, -1.5521283457306205, -1.2323395474556238, -1.3772318351327577, 0.11981270281301519, -0.08372046811184657, -0.8690218677743293, 0.8986000677826406, 0.10668418920115977, -0.14453182811390808, 0.8601340367407156, -0.31033186995682593, -0.3029714492282986, 0.42635034996233556, 0.5656529016984606, 1.1359623480844165, 0.28827508239627486, 0.3996080286222543, 0.9104559182224126, 0.9828849218702819, 1.173497572625573, 1.0376309519742533, -0.9097311855794841, 0.6621047184154883, -1.2471572913656408, 0.6241416780206893, 0.4245557714858847, -0.22356389437367813, 0.5734501682706867, -0.8377516086694566, -0.8247792852697421, -0.15996474810724964, -0.3857727043941841, -0.7033709648490712, 0.29389449250711686, -0.3759660360627743, 1.2779520522421206, 0.051544571798277684, -0.24122671054812184, 0.05945652013883183, 0.17179422833609304, -0.9808802027242396, 0.8211060666917113, -0.9727925759436639, 0.8928769764069402, 0.6186474083348867, -0.08822069500603923, -0.904347630789515, -0.9473406816088402, -0.7871175711213036, -0.8885869850738167, -1.1097988706679778, 0.004431675027908009, -0.041509106726035326, 0.29060984867172196, 0.6807417029610012, 0.5582216265410201, -0.24945001042305284, -1.3919777218444567, -0.1198802840308895, 0.3596901662118878, 0.9472811877737942, 0.7654967217957946, -1.3445379722794053},
    {1.0928766830055385, -1.2237607879352055, -1.8562665414029014, -0.16609930874880915, -0.5580687196540228, -1.4785998023768787, 0.5817399469656132, 0.7794867954984529, 0.27288637486988493, 0.6147237713038112, -1.270138133578358, -0.6809455844430666, 0.938800567312862, -0.02304658033295062, -0.9808270220178378, 0.9628043452923357, 0.27540592294510297, 0.4590621677122731, -1.04025819363213, 1.1491461514595636, 0.3250226968988056, -0.4418292825077896, -1.426806972847354, -1.197271167007983, 0.6059495080977111, -1.122401706759947, -0.9114956585511085, -0.7267757223806611, -0.18342890709104467, -0.49678475859426785, -0.1886108949114774, -1.0434783692304894, -1.5619293013701374, 0.5282188043278391, -0.8618158256281196, 1.4004377764600828, 0.5596126937186462, -1.4934197723580582, 0.6313209019690735, 0.8340043909906183, 0.2669426728317789, 1.1936715082815135, 0.5322906207835103, -0.2065359825437836, -1.2260044173264908, -0.10465433808305834, 0.23168537716577817, -0.8899828550790151, -0.4061249844990574, 0.9027248700961233, -0.8097765959064444, -1.5200099617254446, -0.9214394208136699, 0.6510007341543451, 1.3195054885545867, 0.448165676573458, 0.20650325249897808, -0.7115126336209292, -1.1737485815040853, -0.21804508605432973, -1.30413109002236, 1.5256976001585183, 0.6091541978954945, 0.6837319887823838},
    {-1.161922147521182, -0.24180166552923035, 0.1693801370052533, -1.1407101538872262, -1.4532499861546229, -1.2259727396872233, -1.2747619113975985, 0.9775494380067223, -0.6645678729372523, -0.263711621803738, -1.1924591063846612, -0.7589648509274629, 0.040278371153501635, 0.11209724626266067, 1.1554576852546183, 0.08555183445095113, 1.0149803941899878, 0.41296401899814544, 0.21803389754002528, 1.087638754851078, 0.18790713757393282, -0.3624660250616477, 0.3037853036470991, 1.1495753576493037, 0.9890440254256965, 1.1137298459599232, -1.29855106013307, 1.485306618521487, 0.6626503455122517, 1.2293875509677932, -0.674047499847119, -0.9765754345676613, -1.4818526858214685, 0.3470734360503037, 0.8643160679839478, 0.3766865725106671, 0.9174126033289538, -0.0498509083104181, 0.6536475425054685, 0.37745299485254213, 0.45166920424615176, -0.21157282889394619, 0.7445732360253304, -0.7408512240621983, -0.9058092955956957, 0.9556336930768007, -0.7949525000392982, 1.0785437049911855, 0.7633188339202678, 0.8225559865340355, -0.2526269517867755, -0.3027129325347124, 0.5722026568726685, -1.1692358451890426, -1.1482015313114597, -0.6138874563623771, -0.4222767112873623, 0.6923672066897216, -0.5524557222764441, -0.02374757584738253, -1.1063310254338352, 0.608655369984312, 0.43847699919613903, -0.2674348110908971},
    {-0.3455924507076458, 1.2847187611898978, 0.6862976453950814, -0.8131382339086324, -0.9586862550188406, 0.47723829028647835, -0.9822569188112077, 0.5486125522057771, -0.6942057685682246, -0.8380310641749099, -1.1183500550139063, 1.3141848333076296, 0.7989801601989532, 0.031296992655228596, 0.03975597079246431, 1.340947654477281, -0.46384045561106896, 0.9963101882349544, -1.3989910030310895, -0.04147993638134747, -1.1637403976487404, 0.8397097847031751, 0.2090057275044234, -1.1810834520336664, -1.46875478467377, 0.605061571752375, -0.19633859133596634, -0.44064303151620443, -0.4120667662809839, 0.24043864598044407, -0.9638682282434405, 1.1805854081274592, 0.8771589101583698, -0.8429557820304687, -0.6093650497112253, -1.2338025874164569, 0.723350146490097, -0.44645008670245445, -0.8610031086766513, 0.6817881693295159, 0.1559098490919883, -0.7386863005962436, 0.7464569032546899, 0.7478589715760832, -0.44303237181264243, 0.27101089713181264, 0.5701054029978831, -0.7898727784849108, -1.2562933179005515, 1.1873999940078905, -0.03344697981655977, 0.13077217679281797, 0.30370798227796697, -1.2646545109678566, -1.0721179127302616, 1.2487798663891292, -0.3935710113647153, 0.8947267102410343, 0.5027805816524357, -0.6101211122627521, -0.9986543086449665, 1.0605830469908868, -1.055768640875883, -1.167262990774663},
    {1.0311276118241184, 0.052623174953902195, -0.30346140740527044, 0.935494458248251, -0.35494137399869324, 0.9534302194636267, 0.8016819415684532, 0.36681727381828266, 0.8633904059975411, -0.3984390480524097, 1.0377190065671262, -0.03632504185733552, 1.0374051075494954, -0.06408704807611883, 0.38479034907386106, -0.9426287564315211, 0.07954854920395316, 1.0918373603169444, -1.4922861402833145, -0.9261023225507415, 0.9862705180545012, 0.46611121464855515, -0.8352627787316929, -0.6748851601893662, 0.7568938264069645, -0.3326529557122112, -1.2687746252021652, -0.278707550048651, 0.9502621078738733, 1.2395605537495826, 1.0803257681253624, -0.4836317178819917, -0.11237116348373898, -0.8270595613920253, -0.4797401149366984, -1.255373214794994, -0.44652508585650663, 1.1368355876678837, -0.6208524840812016, 0.9294883500188434, -0.3490637996015565, -1.3676525388178977, 1.302665643332599, 0.3772889450437299, -0.9675018110397081, -0.7015332637067444, -0.3537215373741414, 1.167001626402253, 0.3003621658333587, 0.7992818357780294, 0.388302946301088, -0.3970085347370956, -0.5871583320826514, 0.1216955184940026, -0.5399152408393258, 0.09902683461247622, 0.40587151045359265, -0.7715021120593573, -0.3159603217557829, -0.7637275484550762, -1.1062487085093164, -0.5768334525991394, -1.4759721492442173, -1.005490757587923},
    {-0.5502604054337733, 0.22384763258814644, -1.2106491402342552, -1.4391116703299887, -0.46048923937153274, 0.5815190852001176, -1.1166478749299473, 0.5839449400835248, 0.60717609752931, 0.4029507840720506, 0.20745626245518625, 1.1084770609813077, 0.70231424486987, 0.43453488299195225, -1.228747790177588, -0.9689933453454855, -0.12128126854675718, 0.951531279726983, -1.2507408157447624, -0.9720637579005985, -0.1666947874137855, 0.998600228544275, -0.7332557393920033, -0.4218064935580732, -0.20838008393235863, 1.4673037811323575, 0.13894942724759762, 0.6609781534077506, -0.6495114923642351, -0.1073614828109402, 0.5971333094232535, -0.9024511093950706, -0.04838147780474203, 0.9168593957575313, -1.0044653879930467, 1.3688369380985852, 1.205753178971819, -0.6682778195707695, 1.1474979625201696, 1.2623029347861974, -0.5117467697596312, -0.11786343299827975, -0.729002446155308, -0.4868958808969634, 0.9359230378197416, -0.3671865150964293, -1.0210289956169663, -0.4601813141950304, -0.18848609697999943, 0.5794536422672172, -0.7487580634923017, -0.5117218949097151, 0.4273658089938336, 0.14754201209661644, 0.4275806897827872, -1.2457030358432852, -0.6298516440012174, 0.40977190023393106, -0.9149616298235349, 0.9304715538278211, -0.2904356063407648, 1.2084133410809612, -1.1613970698343608, -0.9212255665040336},
    {-1.1802841371991837, 1.0794726128618781, -0.5443307060289221, -0.07604144505875376, -1.2768445905566517, 0.9087313853470615, 0.620153607460932, 1.2763630537384014, 0.8858225812313223, 0.40873132485043207, 0.1306977151044921, -1.0659611435501466, -0.14762152663656591, -0.04246350578555045, 0.43831259143702866, -0.7768217818501496, -0.7785147792658594, 0.9360242354233993, 0.19818116456444307, 0.6356660780926959, 1.0553594761561111, 0.09633741535970594, -0.06124127574098851, -1.4608526637937471, 0.9603539088444775, -0.02142958962993539, -0.4074341354544925, 0.10173307323583657, 0.15826058894220624, 0.3197501941584917, 0.7837089659743197, -1.3857202817914622, -0.9233305659030743, 0.3441486559167676, -0.20077915970267546, 1.1012924920494829, -0.7225771670053173, -1.2463789417812485, -0.4785840554283505, 0.780017172716995, -1.0090609043157475, -0.526985423978467, 1.3907102274575924, -0.7604348101610012, -0.6572683992574975, 0.35000728376067547, 0.04925751776597381, -0.06350430897097097, -1.0619505846157165, -0.9824449958606399, -0.7083236234931576, -0.6244387123968754, -0.444183981355111, -1.5624152763753514, -0.6963832550780154, 0.9069200100009362, -0.3284325919456319, 0.5781460234073155, 0.4556776673467057, -0.31226318194967045, 0.805921318216074, -0.23520068259014293, 0.7771224719045384, -0.6516309204670973},
    {-0.8561657642858964, 0.19173006284087685, 1.1764040181661626, 0.24492733435535713, -0.8414643855731782, -0.3580925642655407, 0.4956660517394197, 0.2308588014434754, -0.1252554555150094, 0.265600368955939, 0.34685223112356783, -0.24319007122416936, -0.7747748197735813, 0.02883421978885186, -1.3934026755603361, 0.2674866838586107, 0.014834805943132627, 0.5616317670518663, 0.5123624721972121, -0.801608049738507, -0.03711180219793033, 0.5316207375540526, -0.7336707782515247, -0.02072101407242561, 1.4693014251386016, -0.5902911447734585, -0.10934176363830624, 0.09123451035955944, -0.17554809729036397, 0.6973815645359613, 0.7706281681537516, 0.011567443945031786, -0.8776362212594193, 1.0674578120555789, 0.29398597972394674, 0.32775930655409546, 1.1940116611974705, 0.175157477483546, -1.3215581212557992, 1.326467009600406, -0.8479621970068407, -0.739901145939934, -0.9659085784490569, 0.43529599477628833, 1.3673699671106343, 0.09387489169394926, -0.576942338197308, -1.2298212765720629, -0.9761946728148667, -1.0923244008456423, 0.5006975567664872, 0.5792849800553599, 0.2100614955380443, 0.8488224856477256, 1.0660630176869432, -1.4372074729945798, -0.6905452904752447, 0.7627393647503516, 0.17272259495498474, 0.2976795674649137, -1.043732422001735, -0.664172642283917, 0.480619606648941, -0.17105021150938093},
    {0.9456731037052059, 0.563127607024686, -0.6987167327883276, -0.4691759278828864, 1.0870852955608343, -0.5802007444506772, -0.35465511873461175, 0.08805960278830434, -1.1519803740831964, 0.5892394013962565, 1.1407599989786605, 0.9809241282553932, -0.5660657937874274, -0.1637438641699204, 0.12473382591821455, 0.44088218870747087, -0.1417418204144228, -0.4356204655323529, 0.22932365112975545, 0.8694602960819211, 0.7370373851146637, -1.3264204857980275, 0.018954602184095257, -0.5078130127391682, -1.2694210945039954, -1.0126147474999192, -0.4777603971694611, -0.8136785147221627, -0.4765994233119575, -1.278334372195705, -0.3248906539011012, -1.6321060641720644, 0.8237720880601617, -0.29338071583582986, -1.110029686372725, -1.3549314970503499, 1.3269813993262192, -0.22743914709988564, 0.5767096301165028, -1.220910663148695, -0.03993629164800361, 1.365515769791521, -0.882553330326967, 0.25120307452256085, -0.6970858279787815, -0.3936789025407477, -1.3110086389814588, -0.7224813281649134, 0.9926516115856837, 0.2975034110461522, 0.46040700885883046, -0.38675357001752375, -1.0894201167447795, 0.5899145506482226, 0.8383712061825384, -0.9325024364220984, -1.5837886627212099, 0.4376802650119763, -0.44272695171203563, -0.4122303840070912, 0.2873686904307465, -0.31555361989638414, 0.3217115795858343, -1.7375694617467672},
    {1.2085940091462586, 0.028402880784630193, 0.9294918962736318, -0.20960531109814684, -0.1556546324977485, 0.28849534162795415, -1.315916938172718, -1.3830142435158486, -0.4356367199812589, -0.8055096509860452, 0.3427024627516938, -1.2575764654464419, -0.5148335542111737, 1.0570966448459733, 0.3537011240400308, -0.5655165114905587, 0.6077899695603044, 0.22646842285363608, -0.2405742996815104, -0.3017105753851964, 0.3939751131632624, 1.172930008430015, 0.6974517892572838, -0.46600424003553725, 1.1803984610717804, -0.9605291656189652, -1.0604793298977526, 0.4341558724990294, -1.1511742452631055, -1.0823012368005442, 0.4269033790267124, -0.5647023008554483, 0.7838546048500857, 0.7723424792642044, -0.9680097990463284, -1.192329393421628, -0.6052319069251373, 0.9506346420246153, 1.2213639324159995, 0.008901697025760246, -0.8260789298201666, 0.3079788219938703, -1.2553954467729176, -1.029193820502709, -0.10364998520364335, -0.7220180982067712, 1.010078539065467, -0.0018630746035546084, 0.06141563200975106, 0.5604356680468182, -0.01798195843864838, 0.5347225988973016, -0.05870115243671557, -1.307785523536952, 0.3694001240750721, 0.9946527125692327, -1.0524548697943037, -0.5407464631769477, 1.2280646138043991, -1.416990512906031, -0.3289756575387831, -0.3493048398671953, -0.0034443525238335355, -0.4332802569440708},
    {-0.11304489573824006, -0.7367278320898768, -0.5535238388085472, -1.290660054087322, 1.044055543576767, 0.5366392340120719, -1.014650580193008, -1.1325691139370173, 0.03065529272064988, 0.2831222099215532, -0.2126162430030822, 1.1592849243945311, 0.7733483635243851, 0.3585045474315236, -0.18136549633310686, -0.4328740049239896, 0.5001595857173919, -0.06155396744602549, -0.2237964734086665, 1.1042274361599083, 0.4249220076125558, -0.4301451354741006, -0.0712287335516895, 0.5559252782524801, 0.8131118002956534, 0.1158659765343467, -0.06419848023333978, 0.8057098894930529, 0.7351666233225383, -0.8223742571635336, 0.9197002366889573, -0.6535107102043788, -0.0012985582010366758, -0.41848636752584667, 1.1840071670449077, 0.2698639857515274, 0.1606801974889151, -0.9425835841197973, 0.05171612945093614, 0.5839080154364678, 0.2753344369375637, -0.8009423264824447, 0.6002024538887591, -1.4061644501566428, -1.0023438720622286, -0.6117251557121078, -0.5173371087168206, -0.3716854662301605, 0.4560762334208496, -1.341030951344182, -0.4965633051227954, 0.5854586490825668, -0.36080221783846184, -0.25472431581196087, 0.37209785852735067, 0.9006642601148032, -0.7292218955552512, 1.0021617829582143, 1.5186835214385501, -0.8072444000411387, -0.2723266043916221, 0.02664375954677535, -0.6942024938189374, 1.2213630249559406},
    {1.3079008595879154, 0.33381187924389943, 0.2306016843848436, 0.8234297005261373, 1.1348503059122224, 0.11648867648635879, -0.3996093978247474, -0.9956586904148548, 0.5554972542530804, 0.701063978015433, -1.4835506875807345, 0.47977331321557476, -1.2157711450699142, 0.980103956659107, 0.5436154314793632, 1.4333165250322608, -0.5200636804130294, -0.839909172347259, -0.9689695073066854, 1.3379815696889215, -0.837378750505751, -0.1306691390854675, 0.47915997243904485, -0.07919841441947732, 0.616925814864199, 0.5398336616195895, -0.25859111151812475, 0.24565656206117842, -0.30665846670125163, 0.6661887514292365, 1.2333553772522623, 0.10404003772915729, 0.9383747477162556, 0.005987761613293981, -0.38161429409899794, -1.1882941485722318, 0.179174909210262, -0.43369757647094775, 1.1226068230436266, 0.1428496463838605, 1.2128779310056703, 0.23296473974354218, -1.3086230794204547, 0.7549806113091143, -0.37309936664779664, -1.2005209799394216, -0.2710158739032692, -0.08284032136795913, -1.26131190401011, 0.8845983265780973, 0.31723046600450383, -0.1412146734440584, 1.0434560501171204, 0.8270486163431888, -0.9931020791669373, -0.16810807374015832, 0.23424269330717176, 1.5949259276211607, 0.8706273689494033, -0.5933168372224836, -1.0276678323122588, -0.9622145481566102, -0.7525951793480936, -0.7703808688125828},
    {0.49166425384207624, 0.80865359138549, -0.967495268971708, 0.7491297729585931, 0.38429891189613596, -0.5578766044427425, 0.10612879666013898, -1.0450515058681333, 0.09016858815149932, 1.2995200163488252, 0.6046011708762554, -0.34924740982492564, -1.1849516858624185, 0.8740563659081281, 1.0464468725027631, -1.2861340002413608, -0.3580755612253871, 0.33419113947380846, 0.10527802265569619, -0.7042985269709526, -1.3141574397638156, 0.7321008423740311, -1.04948582473606, -0.6132811094174623, -0.1009406761626104, 0.7631152886994412, 0.7045075187700571, 0.7312247918643827, 1.001521146505467, 0.4283602363827374, 0.6191991785482549, -0.35860072361788453, 1.2361344557680822, -0.5733599309786933, 1.0046490826107979, -1.0501204856284987, -0.72188594014494, 0.6874992053920413, -0.9864378685433467, -1.2343591171523312, 0.0639534744770148, 1.3126130069519621, 0.9802111157628525, 0.12573786127118577, -1.4086373627100226, -1.2760807709298005, 0.18679153588362704, -0.3490100384659118, 0.23405809438259711, -1.1958850326186115, 0.578084488974339, -0.8423816854998408, 0.8738987928562946, -1.040328250197995, 0.6020334956173833, -0.8760015564483169, -1.4509118313303146, 1.4889016289940071, -0.12651314370465394, 1.4463022066638989, -0.6218770497176704, 0.4606951436757116, 0.2110947436581729, -0.12459657158055387},
    {1.0554591761660679, -0.03295921384331723, -1.5052110366101967, -0.9697729520815846, -1.2109029603494406, -1.017457836409473, 0.451710967572551, 0.2869567413154969, 0.12783018055165413, -0.8668216540829011, -0.0912424896026134, 0.5597760441064893, 0.8185838050493723, 0.12795715656741605, -0.4562343308310606, 0.48707037888367105, 1.5286830750489266, -0.7553659056991542, -0.3303649137743566, -1.3515486633019045, -1.4812768176911728, -1.3995823185775906, 0.5241249500381441, -0.8176970945919138, 0.9468610272861128, -0.9410109800282347, -0.832647954660745, 0.069023598608371, -0.07265009276773174, 0.729595307195712, 0.17113678192221857, 0.49405480774659405, 1.1650136575341792, -0.7162329420280262, -0.054595067576185555, 0.23356764343128542, 0.20900808321061706, -0.23039553931240245, 0.43287976106086107, -0.7453103453059157, -0.3467455646594194, -0.9152457572652213, 1.084872350228453, 0.3571412673547007, -0.8982309846611144, -0.14985107601064804, 0.9367418101400588, 0.07675041964419117, 1.0979685388133698, -0.17796342883837396, -0.5622722173444712, -1.0110606731695302, -0.08262650286613137, 0.3066685021067541, 0.8899542782894037, -0.0874002538311587, 0.8645483487551706, -0.2227390247355804, 0.08772706514706058, -0.4621356352914724, -0.5705878093690123, -1.1210674095448672, -0.5633753827456807, 0.7074755135256952},
    {1.0395321443794938, 0.8614454577795533, 0.23691359484375232, -0.5186332374403433, 0.6727725486264906, -0.12392923397492848, 0.6886689693201841, 0.793385206169876, 0.8824310232169985, 0.5924770101476597, 1.1182138835688678, 0.09383799232258255, 1.0813270956823264, -1.022113825288913, 1.2085183821122543, 1.4006165650190152, -0.9141023303664594, 0.7706534691441094, -0.9709165156856158, -0.3917577801136275, -0.7817248690352927, -1.1424620708282707, -0.5330719432148225, 0.20549014897030377, -1.0983240488169141, 0.419611025127131, -0.538407152573873, -0.673364891818643, -1.173815796692143, 0.7025062438795115, 1.1475047854292728, -0.33021050024340926, -0.41308387548111286, 0.6499747254894556, 0.4488270879331844, -1.241605214699322, 1.4520577741766854, -1.1933224458727685, -0.2940407397297992, 0.9852251796106319, 0.5399458808919774, -1.1568851322660791, 1.292280080411613, -0.715042147190212, 1.132133230708226, 0.37428988761941023, 1.0327117799571477, -0.49571214401565455, -0.7422736992519566, -0.2544466670276559, 1.2069030609809543, 0.7934547641120866, -0.1490944627594726, 0.47712732305581496, 1.4390286395649632, -0.3571401108906024, -0.38282547730012284, 0.1937246949858828, -0.530012526261928, 1.5681901592619993, -0.5418842918436363, -1.0822686584908898, -1.0531524776237233, 0.821673799231083},
    {1.5515811801774133, -1.3320089193877558, -0.5969195790037333, -0.38424068493410046, -0.3920883777576541, -0.12312998725351726, 0.7784724931125521, 0.4213742335355678, -0.7829820638569199, -0.7066020795466911, -0.1888575582988698, -1.3509119929501654, -0.07732096493887153, -0.8848286920740501, -0.00015852425454152767, -0.07404609490906662, -0.1399786028642238, 1.3371368750903858, 0.48339444058040026, 0.3242729951211985, -0.7787222550107595, -0.38835199699716527, 0.43531394512846355, 0.009389218311055363, 0.08847264409606603, 0.3288624969161096, -0.8959253790254142, 0.0576247164235151, 1.2062201215879624, -0.8863690277824324, -1.0281661545252934, 0.275753604250408, -0.3752823702018445, 0.32774214570124327, -1.3961041203459614, 0.8119366474054689, -1.367088946046762, 1.5110771333504784, -0.011412775523477, -0.09043086225675728, 0.6032076992829895, -0.2772348116246415, -1.241052072798581, -1.0464570528857249, -0.022582879173268948, 0.10026987851733414, 1.1310750665616345, 0.9954090012894834, -1.4112245950335442, -1.0004564990578932, -0.6100460337234384, 0.5002811690419445, -0.8622357996055007, -0.5454709580507417, 0.1124202962964121, -1.2557618708436178, -1.0651539778600565, -0.9765996228489917, 0.03349001212397793, 0.7436637280651851, 0.027083695631904797, -0.7525633856912575, -0.32396309638598403, -0.24242677948648067},
    {-1.3879857813979988, -0.8383319802602276, -1.5040137241182612, -1.1394986773861437, -0.3309370471232135, -1.58416606378714, -0.593451766407206, -1.0228255837480527, 0.01682761389598603, 0.44026474497802826, -1.0337628097705696, 0.47803005915541813, -1.445859546381633, 1.1192695796759813, -0.6237730579030815, 0.45731505409470297, 0.21890476471342699, 1.1676217647648488, -1.2321582209573667, 0.33699611080107883, -0.9261541865508293, -1.1983187538737057, -0.8362253364300687, -1.3162313946512432, 1.470589094242094, 0.5476745030387229, -0.0698218208440636, 0.05880036830424114, 1.2073325857102035, 0.4884436169270145, 1.14066124955052, -0.8891878957681937, -0.5729264423414407, -0.32891487626730725, 0.32530011944003867, 1.0802241605819711, 0.7800846847038051, 1.1092145537486278, -0.5249950423270261, 1.1628770047116321, 0.07529415199043837, 0.9661551748160038, 1.4826295908878426, -1.4212895665181124, 0.23847898521789582, 0.0841528615090035, -0.084381128535532, 1.2505484087336, -0.7119677758501665, -1.150514085953296, 1.1655439363934719, 0.1958767822151124, -0.10457621260180905, 1.4314489851635472, -0.7085280926656894, -1.3111898278208765, -0.9831924201809453, 1.2782945238617487, -0.48370461787284524, 0.9600540671991789, -1.0153649851712263, -0.8397307713944018, 0.6868459331509352, -0.17314325266070912},
    {-1.050440550429715, 0.39859687022395507, -1.3649204320170323, 0.250937334454852, -1.219150302391267, 0.6914764285495244, 1.1419741324368147, -0.5122131806250415, -0.881700260565185, 0.22695919929991432, -0.6185629419169973, -0.40962400524241827, 0.8578374428543326, -1.0117273346018896, -0.06990736023390087, 0.018820823907300995, -0.009813964966084176, 0.1808152052726103, -0.5526073367854294, 1.3562997244206503, 0.5568371516391807, 1.108140124284589, -0.08154620667581701, 0.4925299974784667, -0.7358783653709875, 0.6886784195574296, -1.539911536004582, -1.3845008612914458, 0.09504624732338601, -1.035959406610477, -1.0376730645319827, -0.8175269875091915, 0.7954274306785184, -0.5883999682371126, 0.3251652836193906, -0.16709494994239843, 1.0724846840561735, 0.01189378862607788, -0.18103564975688982, -0.9099265294462179, -0.8825620836990898, -0.3751623603056861, 0.7715356502033507, -0.6213011858798907, 0.1208604588571668, 0.2742723612580108, 0.3303696711065595, 1.1402462963711324, -0.9227582910405392, 0.4847626322825246, 0.1522181653492942, -0.919466907351754, -1.3159987206035015, -1.1256530451069882, -1.405145177500745, 0.13066068664142452, 0.3619279614704947, -0.6696307613516853, -0.007216717268281777, 0.22181300756919, 0.8229995218311242, 0.3848145031409363, 0.8734206422189835, -0.8478038105666363},
    {-0.6891910501973587, -1.155866886739843, 0.025046884092931595, -1.3726201805743241, 1.3244954081920657, -0.6187807622247864, 0.3647774609822824, -1.241114940287851, 0.2711029065525246, -1.0554035444184455, 0.9402806213154088, 0.18324606836470955, 0.8851282739950957, 1.0396873249904672, 1.1975330981666286, 0.4691660868005742, -0.5022672935399614, -0.988506608718674, -0.8556092344724916, -0.48811033285756605, -0.2392232795902755, -0.4891319921542717, -0.9857713390595878, -0.3645399330155572, -0.2236999921581922, -0.8254541088088996, 0.28467079103423637, 1.0075092452645278, -0.14510708767764655, -1.638238913234147, 0.00819738215104199, 0.8633060769560663, 0.5601582159222736, 1.145883404952226, 0.23883264593186945, -0.08389254194266524, -0.5831588753501323, 0.15186431930572306, -0.6826948795726179, -0.6124984245233184, 1.070696256303193, 0.30058902205675103, 1.1766435966045568, 0.023129748693132834, 0.68317903804211, 0.404344299665726, 0.7715199436836986, 0.6081812237196481, 0.40724088996029534, 0.6990366557303901, 0.9142090195061627, -0.6400633057552342, -0.7637186030150873, -0.22754210042487272, 0.12300343764167304, -0.668305744130173, -1.0666969278778873, 0.759033051255705, 0.7821705895316239, 1.0924879177083913, -1.427895082981347, 0.8933477863869735, 1.2215141082838403, -0.5233691653498945},
    {0.5408065972477433, 0.09520353413959534, -0.3846310062384567, 0.661639459040289, -1.3397412303946041, 0.2755487295900696, -0.45651241893668204, 0.9307353300237861, -1.126688141338741, -0.13190258952855227, -0.09605354744677641, -0.6002265265525771, -0.109538135225338, -0.900561649368874, -0.980775324313181, 0.9135671162802277, 0.9178068202101072, -0.09619331832363326, -0.8871735300194338, 0.44210305926741983, 0.8371399579380792, -0.30566983143663373, 1.0660408552346543, -0.00737524717791932, 0.809155992969125, -0.7364691897277235, 0.3857589895737366, 0.5600480647753678, -0.8819493734504886, 0.27234841629955947, 0.6924137928401469, -0.3679784079648923, -1.134032863351592, 0.9847493330363042, 0.4715773754368128, -0.2818601960860314, 0.694882933278911, 0.22472613957401788, -1.2049601738483515, 0.6331736265695153, 0.6217287619440242, 0.9151528111623854, -1.4172590030378551, -0.16340903697292028, -0.5772262734615975, 1.2697557641731745, -0.43389511057563973, -1.0240877824924581, -0.257909736478944, -0.7541722494246302, -0.7028805147017791, -0.7570489262400214, 1.1577339054168612, 0.7062896479300762, -0.15056219529344606, 0.6014970675698259, -0.0488948748720033, 0.7097216892009032, -0.9527660469669721, -0.3753726896893149, 0.5733782651898267, -0.7991374831960362, -0.652349625848383, -0.8995657018531237},
    {-0.031178346336701974, -0.20687458264001768, -0.025625388438291593, -0.001228331674442334, 0.2941407082891641, 0.6858045785413048, 0.8083357415432696, -1.0229879185827342, 0.9373025996714004, -0.4201874159612903, -0.14107680324233127, -0.8525353219834868, 0.31359105263953835, -0.054523797663957874, 0.3815287797736728, 0.17518110410822146, -0.7367895448323403, 0.9810200842006693, 0.7241029604486992, -0.37261696114952375, -0.0778927911858015, -0.2304518400182133, 0.8327980898449164, 0.9586037259932942, 0.478930160150379, -1.1998670115012144, 0.22625928983779398, -0.30364178169554945, 0.961089348321236, 0.39761923503086855, 0.029871881359605168, -0.08109697456070056, 0.7416163858028675, -0.6198310434958101, 0.3310754279995296, 0.7935224088619852, 1.2740002838264488, -1.378356499412069, -1.3016988611234854, -1.000526766322573, -1.4471194567385568, -1.1664259129401986, 0.6356714298254782, 0.25979396802615673, -0.43047651930080244, 0.5145294309774489, 0.8887576840804386, 0.7279687142706786, 1.1145044238988622, -0.4908064055567531, 1.3602359121891676, -0.7947574994236275, 0.7114082431139559, -0.01809983165116757, -1.1105052630058023, -1.1592766639641316, 0.700277758378919, 0.49264700084503604, 1.0919592955527568, 0.6938903248843178, 0.5192291902357337, 0.8974449124916153, 1.0829105493348727, -1.1818682239723584},
    {0.20146949758654284, 0.9499766673879628, 0.6972425606491338, -0.7777816140608987, -0.0016430219197993779, 0.4238072776832118, 0.695652144472749, 0.05826509294550183, -0.03960275456175808, 0.009218767927466415, -1.0512017256802908, 1.093922914209236, 0.6405348556628109, -0.8119545736931402, 0.4543387963229107, -0.8530233136199716, -0.1504277632694622, 0.008215290743461666, -0.419989883299615, -0.3485155227282132, 1.1128637743600007, 0.010306963603056348, 0.3897538227767858, -0.43552186387769537, -0.21880211181723885, -1.4230824392643158, -0.4357174796227741, -1.331689759619472, 1.4177108933805287, 0.8056938088511462, -1.0270715518976221, -0.026719722899386917, 1.4981637558908483, -0.3691178339598494, 1.2100674650745065, 0.6255116256215488, 0.07149241479593176, -0.20476203777716376, -0.920608547462006, -0.981958817174047, -0.476324554993626, -0.7709645094848481, 1.3663097217245743, -1.012216159447433, 0.14012252346026502, 0.2720209775707241, -1.2173812854950323, 0.7423272339161208, -1.234203688737894, 1.2378882954236816, 0.6718474539813811, -0.01924071793992327, -1.1694954843870904, -1.4876604892945418, -0.011100932904443849, -1.2637499080410177, -1.08933071380196, 0.28483423541927017, 0.7065219955914082, -0.07165096230549096, 1.3597339607321421, -0.6031927118625195, -0.39134298931044814, -0.7263642540578333},
    {0.47614378416113984, -0.3779403943846946, 0.6774515767895906, -0.4467293843420389, -1.0896515556185995, -0.44493675468349475, -1.1105337172224632, -0.5936974251112562, 0.31127101273074503, 0.719319156544281, 1.1312509207615715, -1.0788031033679004, -0.22147543907970052, -0.1327437264572315, -1.284166347298901, 0.2017858247934132, 0.09080650711359964, -0.9501406135915534, -1.0772597464957623, 0.6397753578846977, -1.0145998107897545, -0.5026154321099583, -1.0940897782618617, -0.5280969382936714, -1.2715810407605712, -1.1845274293186598, 0.9354900406784727, 0.9242968259333186, 0.8754234516281082, -0.6747034161523755, 0.9869209724263188, 0.4579424071803985, -1.240954654771796, 1.319562773057081, 0.7156752934102011, 1.1028018970914153, 0.7977879358417971, -1.4973069869749118, 0.7222432772812231, -0.5631317491706221, 0.26294314354222753, 0.7939619343048271, 1.1753810632607111, 1.1287381416260833, 1.0896816746491556, -1.1193290379528227, 0.5239439286768117, -0.5722513238326796, -0.19816237136431405, -0.1906546453110649, -0.3390252567308673, -0.4259027763984892, 0.0379419008216058, 0.22370348189013245, 1.1362111160031119, -1.4120607374536236, 1.4021599492868457, 0.7612141749559884, 0.5739716331953271, 1.0357634645628901, -1.1768103021783565, -0.743596265891867, 0.7076173025634849, 0.2626831264946039}
};

static const float b1[64] = {1.5730821212578563, 1.5210948434424427, 1.6043046124965705, 1.5241016569104604, 1.4590803535486059, 1.1646688605681605, 1.2860431295836905, 1.7558575180515654, 1.578588494358729, 1.4578970312938517, 1.633499397753512, 1.4582327588655997, 1.749132157621631, 0.8613912919240377, 1.3355526443107402, 1.6308897767802304, 1.568550922317133, 1.5604146312781877, 1.5578018035373604, 1.1642782215226783, 1.6282783550358195, 1.5807316167284473, 0.99139189630039, 1.3318185723131448, 1.4085749198858557, 1.5787851056086275, 1.1920253745736957, 1.6816466123760343, 1.597676035274157, 1.3152672774815204, 1.3863834992320854, 1.0666819123059978, 1.7732849598310663, 1.3777810143739273, 1.6705986761496665, 1.3288489660433949, 1.6940876882273979, 1.080789436685333, 1.342013162413031, 1.4260002110113326, 1.6368396864090198, 1.577808136869956, 1.7892627967751829, 1.444735566621969, 1.3286824324564341, 1.6504926297182592, 1.5735214383835556, 1.3410254888612243, 1.5731180973371897, 1.224678067110539, 1.0600771986125797, 0.9554063767773833, 1.494307966821913, 1.6479447593136132, 1.1946477007850844, 1.5500718341356285, 1.498424213861441, 1.6693949732455415, 1.6384450042223602, 1.3869760778030542, 1.3686328027867174, 1.5812685435431473, 1.3934437432704727, 1.3492435081213254};

static const float w2[64][32] = {
    {1.3701767873811852, 1.6190759237671482, 0.7609880006699851, -1.0198494158199851, 1.3240220491398262, 0.7393392067939237, 1.0651284632677682, 0.38747796356262015, -0.5216637170818191, 1.2376621987666387, -0.7097459809135385, 0.724841078183445, 0.28455409761779077, 0.6460802179337038, 0.8524785602601315, 1.7860244879994966, -0.8595577103425903, 0.1608229681420885, 2.0153300878769125, 1.4025920891332353, 1.6993450947091222, -0.3213539202878346, 1.0664907037061848, 1.4930742059472155, 1.375295108599993, 1.8889055984812668, 1.4713821690702782, 0.4064641479871626, 0.6367885525379233, 1.8744725452691662, -0.38414747886181666, 0.4285472933954845},
    {1.184574368622675, 0.7855376400627171, 1.3595182636524243, 0.291932749130578, 0.12915674455789974, 0.27926734118645646, 2.160233277893014, 2.0922387388844443, 0.7525760600910036, 1.2984516698286763, -0.29735225855751257, 2.2714366088175364, 0.35589872046239585, 0.4062842565695717, 0.7375766556425997, 2.4544035896583796, -0.45059855883443867, 1.619423866893661, 2.223639513601421, 1.719992495455593, 0.37986578732534687, 0.3891307239130202, -0.08448500223688239, 0.87714474450682, 1.3036760167663628, 0.4911229302549134, 0.743638004524372, -0.4984811862899854, 1.1726499286000223, 2.043530458098604, 0.2507279647265783, 0.8841766377591405},
    {0.46639998390451065, 0.6451009918386746, 1.9040339815484175, -1.0211736118742585, 1.4221818042191288, -0.6254597838403366, 0.8122277802758499, 1.5144059136825778, -0.9762270945896729, 0.8578706150869763, -0.4778339884927793, 0.8977308919342699, -0.350486316958808, 1.6462449633658864, 1.8650127101565985, 2.463841444342761, -0.2870459925620336, 1.1470703234037922, 0.9093932148368217, 0.8720388369116484, 0.36186274284079284, -0.7054823551528144, 1.3409643995469045, 0.20572034768599035, 1.5604041128109116, 0.410900502948832, 1.3326991097968015, -0.9470769019372829, 0.16183820402052324, 2.0740816770399686, -0.05486848081819691, 2.1360023937167285},
    {1.7674257957754151, 1.6337481177216147, 0.3043825583155643, 0.5993540325909935, 1.0258979162784454, -0.5343154576590632, 1.6849476206075429, 1.2641874778107853, 0.26561960021858666, 1.5694164282266714, -0.19821649482230794, 1.476230526888692, -0.4685300440328272, 1.3534819284904762, 1.5444363642715813, 2.096183440113872, -0.33853412896380125, 1.3605497998670728, 0.9488520688218998, 0.05198722620967376, 2.111987276364169, -0.11959327850791855, 1.6613550850152732, 1.2471205028443235, 1.782536144276112, 0.8076538448488988, 0.19634338192899328, -0.8829330750797453, 1.5808391181067345, 1.340645924246465, -0.3259777004920451, 2.0205612451450277},
    {0.6804541892685803, 1.5692596579379954, 1.0334409756805423, -0.0026643356057717924, 1.4923528659231313, -0.08122851112882275, 0.7918672711791397, 0.4733356121697767, -0.24462411567935397, 0.16807531209905402, -0.17528531436418937, 2.2961080070631246, -0.307577417471443, 0.9631264291126186, 0.0010365116900698463, 1.3977210982648711, -0.002312031994140515, 0.4117438182510444, 0.8110550266064303, -0.16006682318389642, 0.9682904234775241, -0.364000322700608, 1.3016300149151918, 1.157746611627356, 0.29650018551421176, 1.2197350668707096, 0.7551612714639094, -0.2067768585709342, 0.8880828599686391, 1.5867549999298334, 0.37747004825076896, 1.6785720865795222},
    {1.6443017667670705, 1.2180148422910455, 0.6141596843307848, -0.61496149502121, 1.550249044224093, -0.8219277652002701, 0.7587392137394525, 0.6231303798971004, 0.47186833447609994, 0.8978383779040313, -0.5798615335046899, 1.4542458988112543, -0.31274389187640866, 1.457687673823118, 0.26539168919375417, 1.2189650443584208, -0.49526524044077574, 1.6719827884790526, 1.0290655971023202, 0.1589712569170256, 1.2366255030747542, -0.21579687937344388, 1.2528287247543828, 1.4349769240380998, 0.6014198440512896, 0.9791162572710068, 0.8730582135182422, 0.5096300043677092, 1.0203443632829925, 0.7419306161494547, -0.8729659089895059, 1.4188249035987266},
    {0.0662923804613924, 1.96864451886848, -0.05378358231178814, -1.0350334751099621, 0.10059990990970667, 0.05089788226569871, 1.6314216863898214, 0.8378416831439603, -0.9963246971510574, 1.5650284187007777, 0.04452779587965615, 1.3407295884215922, 0.0776600329614637, 0.9521075798900612, 0.3210332224003425, 1.780743187436734, -0.9060148893421419, 0.5316363304451829, 0.4027289946311893, 1.1996090969413948, 0.86784110574326, -0.368489876911436, 0.8953262215520302, 0.3951636897877562, 0.8610710484945455, 0.9297894071167646, 0.12184335123519671, -0.9127327649789362, 0.37018996100806484, 0.5143463924575833, -1.069778604015045, 1.388291949158001},
    {1.0797298838937837, 0.9258184046763931, 0.8208830570371751, 0.7099553200206004, 0.5900960037127178, 0.3098502308072101, 1.36996228406783, 0.6414673553196143, -0.730201877218879, 0.4227945590537433, -0.7360259517817286, 1.82849748974475, -0.7142300830933597, 1.485783147944651, 1.2671477326751672, 2.424896793464996, 0.7192409841228764, 0.8725399503675124, 0.7625844349659099, 1.6383195184035064, 1.927435508271084, -0.5878976146629172, 0.6093131983040483, 1.5732267780514306, 1.0339349697895008, 1.3836273895892948, 0.8711353786883783, -0.7481322855467075, 1.8019052968278624, 2.0081289337737043, -0.32630801543334725, 2.2143001440610734},
    {1.6368113434034106, 1.8768429636856572, 0.6640847728680678, -1.069252925823913, 0.7942910745176134, 0.6976545630209747, 1.395668274689251, 0.6425054594371066, -0.9955726806750644, 0.10426970786793212, -0.554154348030335, 1.7923913850656121, 0.22408474444355492, 1.218041284808425, 1.6542702723272342, 2.153724165816756, -0.700297854797543, 0.37030909560949754, 0.8604547287952604, 0.6921071570383867, 0.7404048318842786, -0.3336815005066558, 0.6158994669750462, 0.6523461230387829, 0.44237052791400294, 1.2448397809071423, 0.4043836520747758, -1.0409543433372754, 1.7569117848361389, 0.5827522975808578, -0.5341989968809291, 0.8219450857089161},
    {1.5599428253166876, 0.5181705870478023, 1.4946169464369132, -0.6993761456793407, 0.831283358355166, -0.40023924395249416, 1.8525770734841012, 1.5423056736322762, -0.8170239355722361, 0.08390429185410885, -0.8478850351718156, 2.2047987780793754, -0.6353716130257262, 1.3129526781261014, 1.4522169726193979, 1.509490010782734, -0.2658986181850772, 1.1033513047576828, 0.4545529947049463, 0.044386170206569285, 1.4550286102269616, 0.5024952639250899, 1.056200532202555, 2.1068960878107963, 0.6115967114593395, 1.479839549812359, 0.5095747637451351, -0.18145921715669475, 1.428890361805794, 0.45152687364023975, 0.36296725776276667, 0.9095701124607458},
    {1.7604196021141778, 1.2875367898007866, 0.11002990492603486, -0.47481124523297386, 1.2305345965251182, -0.3563262217899033, 1.948398625164962, 1.6735713413884004, -0.9604470024183746, -0.020214293224627165, 0.27137247327144276, 1.685132586087816, -0.6598075347065523, 1.5454884552424046, 0.45056887101892235, 2.2876110277653807, 0.36622776023098885, 0.7073610990669162, 1.7805476978768502, 1.1288554690234105, 1.905696346936008, 0.38200592948721435, -0.1013175451470808, 0.33190512632412456, 1.4477477464970596, 0.8734115952201003, 1.629769724785661, -0.19499281890819387, 1.4143077020588462, 0.30530552187178334, -0.19749839363148583, 0.652903719252394},
    {0.37781158779861745, 1.1475254497389213, 0.05908870489005502, -0.3409000521012672, 0.10404988678536307, -0.5764969990893054, 0.7289873409955131, 0.8827206447475352, 0.28172584231967734, 0.6250970794840145, -0.2943992735693138, 1.1711694396120838, -0.3786777311048998, 1.6673830363677453, 1.6981116643893552, 2.480785109511894, 0.2601581570718843, 0.9106801459324687, 0.7435863193550579, 1.1252258765904224, 1.5147849892925738, 0.24225722073316233, 1.3577510295820046, 1.261056073046732, 1.555372622985655, 0.8999251560679853, 1.9017817141732967, 0.15722099390127417, 1.8306024422521996, 2.245377276649899, -0.9633651412322815, 1.1698560319975368},
    {-0.007809885270488406, 1.4399218549136634, 1.681608419561967, -0.17651323953204473, 0.17760120644669497, -0.8400831398897558, 0.6468070444628204, 0.7732555603335887, -0.22194527493579777, 1.4790547754650412, 0.2965380274923567, 0.7299359964939379, -0.15648507034017706, 2.209286984582065, 0.24226818024818925, 1.9201638619917758, -0.3680609068599767, 1.313831143671529, 1.46154035365224, -0.008295025376352941, 1.6785251627948334, -0.9733303946013038, 1.7240675515467394, 1.8817777683520724, 1.2585999790525528, 1.3645967304786668, 0.2570374184185653, -0.18020074983750903, 0.22128671408896808, 1.6403922997326992, 0.032819268440080804, 2.225394832430836},
    {0.6317939118580845, 1.8167026147357839, 0.1922072553594597, 0.5659598512009945, 0.8091462182589635, -0.1309757276665047, 0.3604779321611834, 0.541958266676727, 0.5134886008099675, 1.403490155713193, 0.34812507580969765, 1.1875996099556057, 0.18350125430992603, 0.292895290670493, 0.3340241463300013, 1.1739974257363552, -0.7900116338517451, 1.9386976887780252, 0.5076518557144404, 1.4513614181972923, 1.7362826662318085, -0.25631462034130836, -0.13979760409453784, 2.0421214607332256, 0.8658079430314589, 1.7752770178814516, 1.6166761668618679, 0.39829524571559305, 0.23302599431191293, 1.8265770897055098, -0.7938252150081265, 0.7512948403916591},
    {1.1759831316883145, 0.44832916266019784, 1.2103892403474454, -0.8539648960473347, 0.9016893669753885, -0.16603997098777637, 0.7838993127068818, 1.4590334188377432, -0.32181691758605474, 0.8981791229719297, 0.4924642490831638, 2.2191335705551802, 0.32770120461786845, 0.39207351160438025, 1.3704681802588934, 0.7552779048438124, -0.5194949084980768, 1.3506186592770448, 2.2711721333179855, 1.6101035648493984, 1.6272003604911698, -0.2658321002934134, 1.5375549232897705, 1.2825012076453703, 0.30689705549897217, 1.3335589394516063, 0.5920193092449278, -0.42879091691537574, 0.39266916451200723, 1.257728472102806, 0.1400471241700024, 2.21343977943818},
    {0.1443462337062776, 1.3807920922445511, 1.5967598106536485, -0.6692013055944923, 0.6761705157194762, -0.3679035472594545, 0.639836664571792, 0.4468274274611652, 0.42870188283535604, 1.2237496684936706, -0.9727453211968806, 1.468749801002918, 0.13546271379509658, 1.5389509362274485, 1.835200570057252, 2.3168630032520237, -0.3145073674650389, 0.7911430057786317, 1.6689362140575332, 1.1669204586969384, 1.306774058151814, -1.175021878558922, 0.26752172523178724, 0.8669913807671885, 0.7063386652432235, 0.749819680810702, 1.9370001507605115, -0.49309761280510034, 0.28515597554362604, 0.48209410219354304, 0.02423690579865875, 1.874241799727335},
    {0.7412514748432371, 0.6215535435055883, 1.855447560800009, 0.376133295787943, 0.5086320909693723, -1.078533957886368, 2.110944595259855, 1.7873229421898922, -0.665148711634493, 1.1661018003448018, 0.055766774244021454, 1.229461451778078, -0.7323486200196633, 0.4326504010293731, 1.1736793426799483, 1.291327406260013, 0.2547849447472721, 0.8282198391135756, 1.5536541337687062, 1.2690198531543342, 1.9767197026117396, -0.4904783912620453, 0.2798193147995766, 0.3623235797324924, 0.26864021611823247, 1.3952348121250397, 1.1521876052643387, -0.41460965558434, 1.580451083525947, 1.0166322584933576, 0.3557276844710103, 2.0239905628821355},
    {0.7451747658884822, 0.9695349520723504, 0.7428750296772918, 0.20253024496492533, 0.5892786800303284, 0.12656828295779246, 0.42236241246589773, 0.9901559056965743, 0.333794229169181, 1.2038444373236048, -0.5504346263793098, 0.7328800908421333, -0.47892303345309784, 0.808885448088632, 1.0401535203320547, 1.5651705792802648, -0.7629551442268799, 1.2665011052330086, 1.567911579362639, 0.09285129722801225, 1.0046681733794103, -0.9313394948875009, 0.09581387710119231, 0.885354737470401, 1.447997730497555, 2.042371205380029, 0.6244377619796532, 0.17061917717827824, 1.234470435715705, 1.5440413411609717, 0.2796016714050088, 1.7685915793615903},
    {-0.05169411747503899, 0.8947548152158029, 1.568108165889013, -0.5860912342275955, 1.0305644701521357, -0.18592121317997135, 1.690414933007894, 2.1128667609656078, -0.3072901610482082, 1.28972524336546, 0.46501275578302903, 0.981874726718472, -0.7051971036173041, 1.3631623573454734, 0.6079327269080016, 1.5736803660850895, -0.3567990956340737, 1.9675323707240373, 1.7024094700017485, 1.865832185209352, 2.069276728947397, -0.5181762300732825, 1.6237829009939213, 2.0140183681815396, 0.39820499388597486, 1.7197362190016725, 0.5961378073599207, 0.5431373272920963, 0.29676989471216836, 1.6517967172252415, -0.5041990023544953, 1.3152677167257216},
    {0.9775215901070802, 1.18981479975002, 1.3583574251925294, -0.5425856327963903, 1.257573140796979, -0.7407545091498225, 1.3774144287672452, 1.4179328070506227, -0.16800599728132415, 1.490059029711797, -0.716731132657525, 0.8142281748183369, 0.3399148844960032, 1.8051947912011357, 0.5332042649480856, 1.0019087428381714, -0.7647058523455168, 0.2253574111921439, 1.5794733964555872, 1.336455535102873, 2.103783409362453, -0.7253569347826662, 0.14125484506697175, 1.2666176774223925, 0.5608863449126408, 1.2154971925830764, 0.7396202816009421, -0.4803430680110827, 1.3585965632788493, 0.4314927270732256, -0.2894729018398497, 0.49596068183351716},
    {0.28457748661363685, 0.5556657351578728, 1.8221838116825801, -0.414526784345349, 0.2901353651549211, 0.08807443963538478, 1.3926299536938989, 1.6890337461433975, 0.4905484121637888, 0.1924813057853372, 0.4938524465839023, 2.1977540484126203, -0.36423918041842007, 1.9542175536323052, 1.1205997775867893, 1.4660779300982325, 0.22600220244121716, 1.4384938908827274, 1.6535028922626143, 1.1689333940863988, 0.4532126671225196, -0.13912400355275625, 0.8767701477972348, 1.6086790536851294, 0.9691592803513972, 1.7317786198600569, 1.1235826971094827, -0.47171369783392275, 2.143688405071536, 0.4245463638511748, -0.8938201085097262, 1.684434837051064},
    {0.827287736111188, 1.5796409109894483, 0.795820195380175, -0.1156209189307968, 0.04910988581316454, -1.1543050656260525, 0.6244072444088163, 0.8369894555914803, 0.4222327918988528, 0.9022469972710774, 0.28168745395789835, 1.5933643810351543, -0.9978598936524817, 1.2421733685846013, 1.4849380106206842, 2.198120041789293, 0.45801776160772806, 1.0807203260744285, 1.6616489930354856, 1.672845468831751, 0.9711696728983656, 0.7230459872933894, 0.39669479620936277, 0.2410143889689549, 1.475617261994594, 1.4964750644237577, 0.995508460243315, -0.25499030078661783, 0.28357722352184117, 0.7221777635546819, -0.023380360113094006, 0.976392834154067},
    {0.3945456096269618, 1.6777956737535722, 0.930000327844527, -0.2096593312569807, 0.46897097746119615, -0.3519105339254159, 1.3991136368792811, 0.670887209220298, 0.07585638496485518, 0.9626507605365191, 0.35344269373566817, 1.2099239660138568, -0.6227539099623315, 0.6923440071884472, 1.5588433282984726, 0.83093094180203, -0.15065647276360564, 0.8355265194505833, 1.6105569483925186, 0.5398282515660435, 1.3095753322687422, 0.723877038737601, -0.13532087691574787, 1.1719746652414764, 1.3037149377105244, 1.1084509376206908, 0.3066854757456849, 0.24732297388340577, 1.0211082822726025, 1.516217013070809, 0.056547056170587515, 0.5181466891681257},
    {1.1208500523345923, 1.8180572131469557, 0.6381365705066689, 0.24844274056651544, 0.33018770153120114, 0.11285472517968449, 1.9771392214728005, 0.7066019691365749, -0.10721939930028487, 0.5520934938607901, -0.139833672367539, 2.263359180160148, 0.18841078468008704, 1.0311067205879023, 1.52204387941948, 0.8860310781077092, -0.915468996254421, 1.7076946180724972, 2.1677007547559533, 0.14154638792401383, 0.9758091268254024, -0.8573040101589725, 0.4401148242972456, 1.0980050315580208, 0.8403560825956047, 1.676515549121514, 0.7859542217435939, -1.1020135452309925, 1.3577627303364732, 0.4720629443475205, 0.5609409464146404, 0.3921164947404676},
    {0.7556012774286899, 0.7842057969665169, 1.3234018560007828, 0.11513748261307162, 0.17010043812637418, -0.7628217559610736, 1.0169467377802905, 0.2484373258631933, 0.20789773460447825, 0.09421404907704625, -0.44915082645965965, 1.0580160462145738, 0.3723613523302835, 1.293688491620466, 0.5389864540332605, 1.3761858535484557, -0.25750256997084714, 0.2757769473164404, 0.8681445083839504, 0.26453525720602067, 1.6376153210422673, -0.6848631624804097, 1.7367096265625452, 1.9397238535340757, 1.9713285840363106, 1.3005715505455688, 1.6153063367867309, -0.10851083502551669, 0.6277862710768141, 1.2961640820750953, 0.2692635035144613, 2.312944758367032},
    {0.7730368427232113, 0.6698410268500694, 1.5340992516645362, 0.5172664321734822, 1.0602474354083005, -0.16838584541232646, 1.3973263748296485, 1.4415914763294677, 0.5457246133083892, 0.04655808538666911, 0.2849121238835415, 2.0720193502877104, -0.20180262953785827, 0.44775156484728135, 1.1633215799061576, 2.0717951678668234, -0.7142583358318678, 1.444925610613776, 1.058600632605081, 0.4104243917278837, 1.0665108954166669, 0.3321622010809874, 0.3648756686050634, 0.5604252806834598, 1.8282560659932015, 0.9111969557444036, 0.12083524526596534, -1.0697086763115642, 0.9059905334791354, 1.6945272583589426, -0.057784309519740056, 1.454042071701017},
    {1.5230314682560184, 0.5979956345117801, 1.3317955429672113, -0.785256395216375, -0.25475332215459473, -0.5414928173003857, 1.7180231975894873, 2.2182487012858227, 0.13567541176677364, 1.4296663953998325, 0.6176741536434642, 0.6869739868245883, 0.35142384907928653, 0.7593725912324504, 0.9463595974597385, 2.429845363411081, 0.5869295245337411, 0.8654980305641335, 0.7150199225509858, 0.686260543383075, 0.8641866840696111, 0.6514328611418985, 1.0045825215616033, 1.720403789540013, 1.7815215357216652, 0.4904573388725047, 1.1405129020122147, -0.4554218159387942, 0.2090099125470132, 1.3536291689497224, -0.7346519055210882, 0.6986090851196748},
    {0.35323789511142006, 0.40216584699995134, 1.5106316271730864, -0.137671432476159, 0.06188434262581996, -0.4341574912570981, 0.9953717301298791, 1.1056688154803, -0.24467905073561586, 0.9850919237898966, 0.12609479672843055, 0.7752693413209611, 0.3984738901974484, 0.280475058510856, 1.9703524029179402, 2.4211428718253676, -0.6040203637117579, 0.12650211776678838, 1.9287921315661718, 0.2954120003213423, 0.6521400241574055, -0.9444316317716486, 1.0477028282445597, 0.8177699011609428, 0.3547961675238988, 1.7864233898585087, 0.7217551779694459, -0.5824504710882477, 2.119219684651291, 1.4875145505705436, -0.35644472456485976, 2.2030962869351582},
    {1.648732713073679, 1.9566648753661013, 1.6841208198731592, -0.24525877024522166, -0.06006390172541938, -0.5009320155619941, 1.8554173511908187, 1.3227066087841175, -0.020423816862691967, 1.7308765447045362, 0.15579344207233053, 1.780886849668255, 0.0300017915749075, 1.4215815639545857, 0.24046705000716578, 1.8812179254087054, -0.1662648482681893, 1.4184215170181935, 1.820148452169291, 1.7865199285162086, 0.595885939237192, -0.2861661381660016, 0.8765840367040889, 1.011279125490564, 1.8984881606948278, 1.533365190672395, 1.9013894819346153, -0.47500732227033865, 1.503905217787893, 1.0537404320046286, 0.27330768659018784, 1.7573327655996496},
    {0.335709796960183, 2.0509574845765406, 0.7796527689072494, -0.9072684875016458, 0.7161024702261499, -0.39235300704102577, 2.106395773781485, 1.460980409398447, 0.5175299494511812, 0.32999311656345925, -0.17874107437792336, 1.8589598042035977, 0.35263737587542016, 0.6346430185921378, 1.577565583280642, 0.9124870397806208, 0.42022868925193596, 1.681175676147883, 2.2076130588274774, 0.33945246598311096, 0.518376326191522, -0.2550035742801463, 1.160940574141861, 1.1740407342934382, 1.482845647470482, 1.2156272436367133, 0.31012936764006516, 0.49691012075114244, 1.5798636320278392, 0.6983947637334218, -0.8350685392050675, 1.150691960269607},
    {1.6114581559031083, 0.6415395818885562, 1.7246292324965748, -0.6281605421862766, 1.2137369621457645, -0.6801183589989217, 2.02964637447292, 2.190653907960664, 0.459002292243695, 1.0860635581161222, 0.32845320026362135, 1.3290992107175366, -0.019975480783576773, 1.5738953195568466, 0.3427007164097505, 1.594085327774113, -1.0351471209872907, 1.4429969497358646, 1.7018951241570357, 0.4447813234399063, 1.2587927965866685, -0.3819543907186615, 1.1640373576508238, 1.1992018734503938, 0.4173775667411819, 1.6373485609769831, 0.50486836235558, -0.5531309670595693, 1.6017730973424757, 2.1936455520514175, 0.5298888377264488, 0.7650513910947327},
    {0.7077777165696626, 1.7310798130111171, 0.9889791796693143, -0.7071150629747459, 0.7897369833410159, 0.5026718359632181, 0.8848232996046739, 0.23576723082696746, -0.0839356838452621, 0.185410226556326, -0.5130849792649095, 0.44949491594339896, 0.19831391430536907, 0.5651591965392826, 0.11173329889544661, 0.7599858854882015, -0.8426927067904897, 0.6462852140271329, 1.4665550780034937, 0.3430088230630796, 2.174365020601873, -0.0021748123514711572, 1.0104875529383464, 1.531069780777721, 0.2053742503836067, 1.7078897250891267, 1.7328884193136227, -1.012972751283106, 1.6482171355085105, 1.9630702465197414, -0.1825471894790634, 0.6748099458573728},
    {1.5022857712831104, 1.4812216771734752, 0.0007087477411777891, -0.6802473095558428, -0.08216416164147965, 0.14574360793615548, 1.7341191960814832, 1.2066762324044933, -0.8855474463117878, 1.5768172625557602, -0.1759487699378232, 2.2546788341158583, 0.22936602191034763, 0.8028297614399774, 1.7115512678358018, 1.6746058069283922, -0.25964988747311746, 0.6936060478131405, 1.9856043547707283, 1.6832370008510378, 1.515646199373426, 0.06322560854652354, -0.0024086282774026953, 0.8461318962120064, 0.6131160265566203, 2.311721680546046, 0.23474432488827834, -1.0575687215695946, 0.4799868277619894, 0.5617063804920712, -1.0748308539057352, 0.8386844550168605},
    {1.252024811347581, 2.074624816554124, 0.339378828229623, -0.9875494569843676, 1.639618792857679, -0.7405391652292517, 0.8432814304866336, 1.6881226069796293, -1.0560644740227692, 1.022136465175153, -0.9720225820535088, 0.9333913045218836, -0.11963063404267155, 1.129546531012908, 0.3137686193088838, 0.8254980265409757, -0.3543295964330172, 1.694942130948248, 1.1168402898023448, 0.9773420327328531, 1.6185633244105444, -1.1413861595224617, 1.8381758965853932, 1.1136527800219895, 1.7609237551434893, 2.192186931406719, 0.9855100004457571, -0.9680259150047271, 1.2255202345954395, 2.1623152021423326, 0.25391276044824895, 2.245233573985186},
    {0.3969418186678813, 1.5546223706322244, 0.3933248555263755, 0.5279049151056531, 1.2246558860453565, -1.0658454089576443, 1.4992295714607706, 0.46648156543895064, -1.0761497714880022, 0.6473992233829301, -1.1381098159563008, 0.8232422769794571, 0.17561093324161772, 1.4849438580361107, 1.4488659025320691, 1.8942816225984085, -0.2133805302694668, 0.5636743463357234, 1.7746280276246866, 0.6612922690518473, 0.60971524334648, 0.6915913355655473, 0.6328631173417286, 2.1240860372435044, 1.8308308615225328, 2.1105632066436795, 1.7508831064663686, -0.225296334911648, 2.003539981762609, 1.7800596124097459, -0.12767997155455474, 1.9748472359945575},
    {0.16723193393716534, 1.5805150685628444, 1.659377045158476, 0.7277938276994945, -0.20595467663345882, 0.17136334703516698, 0.8362338943967347, 1.4222394511568779, -0.13851486851949138, 0.275831547275016, 0.2775247871037737, 1.8911178167644975, 0.32581252407391315, 1.8111306239131217, 1.9405149395972998, 0.8127605113206088, -0.6700729071966038, 1.6932902939091126, 2.144722333383133, 1.7361263489368663, 1.3080898622582349, 0.7929139522698092, 1.328769029555415, 1.1990433067802755, 0.2803416097551888, 2.300154346587342, 0.5492646767584562, 0.16324885445666001, 0.1833940150933035, 1.33883412457904, -0.5280023865016249, 0.6228191781485896},
    {0.9287072050573317, 0.9538671321052109, 0.6845894768843327, 0.027112329892470182, 1.0908075852172276, -0.11637923163117149, 1.8509133818896042, 0.3626675092626376, -1.1036113241803016, 0.11610407489096673, -1.2026381672910098, 1.2437660459848934, -1.0053764303759443, 1.7568122027561024, 1.4909901102109584, 1.2546385345886146, -0.05799337872134395, 0.3320718986028076, 1.868308930383392, 0.4528945305523683, 1.2554357530207243, 0.15705514935965043, 0.2023716304892129, 1.3000040614228399, 0.8074341413573435, 0.6166329433378629, 1.5878322810018883, 0.007549757330026388, 1.4367086604047936, 1.7876030917757304, -0.4656892104783426, 1.6565215150468229},
    {0.06852075472471604, 0.57364761762032, 1.6094758547574197, -0.22897443988821953, 1.3696655274636167, 0.36005296689432387, 0.5203122064342023, 0.5161221501950386, 0.49408461070451615, 1.6293558209599521, 0.3136497585386432, 1.541846449037392, 0.2151188271331213, 0.5530722506562125, 1.5677271793315843, 1.9108863867935286, -0.04395345361914684, 1.6090714298451259, 1.9585279504521007, 0.9550203364475599, 1.5329030454194754, 0.023566061148249426, 0.42331886268088165, 1.4704524265932752, 0.6712852473688661, 0.6130624930381743, 0.05160879043871682, 0.7068442533572353, 0.9580635833773669, 0.41937288760518027, 0.5879744257579703, 0.63777217233745},
    {0.8624414016424875, 1.0840713772834882, 1.7353128112972827, -0.14227486533789255, 1.624891482447174, -0.612145669608772, 1.5941618723356556, 1.6685588134712215, -0.9271428295776724, 0.5455398293624761, 0.6345535567539605, 0.486549575428334, -1.1342196628674, 1.344390199690816, 1.5444039968978969, 1.1170267699134138, 0.42215392464312174, 0.9805698312560519, 1.3848748273456681, 1.0772456561285109, 1.5806812762029998, 0.16633552777241317, 1.703153969338947, 1.980626072979093, 1.7322642705242166, 0.9333481044441786, 1.2983068565669125, -0.2665013824879319, 1.9916091914502063, 1.565986741938958, -0.4137369200479658, 2.120775322475795},
    {1.4213446268214573, 1.8365536709108756, 0.38126072066970446, 0.6711008349185389, 0.978775192781474, -0.7137960860582974, 0.8786504404171314, 2.028751731437603, 0.3776612974348181, 0.7556291993866482, -0.28570855931584715, 0.7504667227857905, -0.28567482329530236, 0.7752593724549427, 0.3178884922191722, 2.5771304302644107, -0.28342187007516495, 0.8671435048972329, 1.8092210183676978, 1.757538063894891, 0.8967523789674907, -0.12395154069841484, 1.2979095512504826, 0.6414822119119671, 1.609683432555353, 1.2464024693949263, 1.1737638559428953, 0.026732695278401507, 0.3336115036102467, 0.4893417550484764, 0.0712997777657259, 0.9148919476003777},
    {1.2738463565036504, 0.2180092136944736, 0.49841348283545206, 0.3223074377082624, 0.3904104058602832, -0.7219563662929741, 1.3030411595467648, 1.1600877694004876, -0.7857508058469124, 0.8253883479826862, -1.0421406385805305, 1.6371382816988518, -0.8968178918686234, 0.7429724264856237, 1.1846987472548982, 1.5846901446876713, 0.7413046342180595, 0.33491452997686555, 1.6168535632591556, -0.02242899212686519, 0.37767213128188515, -0.833091522636751, 0.4059898457819707, 0.7553790773289152, 1.8676579551008166, 2.2265016465586807, 0.6887710393491733, 0.24287996888324306, 0.31279255489103847, 0.3614979752434593, -0.20533136653552403, 1.369802862030478},
    {0.52725321917507, 0.8663300667592729, -0.045456275945752314, -0.06385879331352269, 0.6038217644379923, -0.5737128023713873, 1.1410874596197993, 0.7919031673126504, 0.3433987024091654, 0.518325719392362, 0.33685367023111595, 0.5537901305447801, -0.6089258787022375, 1.0321527824992418, 0.02125681546578099, 1.4714198387611408, -0.6670694073957371, 2.0224861737587774, 1.3818915125581157, 1.4599756468774612, 2.079555141745297, -0.24796219362509966, 1.454599431064243, 1.6797733504649144, 1.0441889711442207, 1.9871141607736051, 0.2782796091626004, 0.5907328091290664, 0.8199869522580544, 0.9524647950419064, 0.3200412533943452, 2.286878923771604},
    {1.461301683805955, 1.3248570172625713, 0.882855016741718, -0.9558747089220658, 0.5193574771371264, -0.0625920564279834, 2.134089708286839, 1.1088577595730327, -1.1030305761203671, 1.0650079352053525, -0.34789902647987714, 1.750866516712094, -0.8770778370172873, 1.5282595096371865, 0.8297770738327638, 2.390432195248771, 0.468653524608468, 0.9697874636312043, 0.709279038838211, 1.060378199131186, 0.9790461748823908, -0.4984469687657992, 0.6112192460980336, 0.3533920545622914, 1.942103027103183, 1.7595592500899195, 0.20629254089917792, -0.5660172281609988, 0.9564406911484231, 0.5002454635565573, -0.3915128833269156, 1.6338621976132226},
    {0.3883211750658387, 1.9071164128096447, 1.6810468628843402, 0.3905898065433183, -0.11351716725717818, 0.5260715652243692, 2.0776321450082893, 0.7573282981963257, -0.743773463754876, 1.7736484059478785, -0.9902907264143432, 1.549235002448568, -0.5673951280396955, 1.2517572373163597, 1.3004195991084202, 1.2399406943999773, -0.42621676451500584, 1.5275849962309098, 2.1100967079611865, 0.9731447163506419, 1.4719387004218694, -0.5951514619778028, 0.8311222954334677, 1.560843466073872, 1.5170161079417153, 1.694499202128754, 1.5556007684735391, -0.8170241855345717, 1.967429998596545, 1.7804907463157023, 0.5527810889559406, 0.42406787300775883},
    {1.5483236988839892, 1.1332000752972857, 0.9709839696659759, -0.46315799395691626, 0.5499375216928251, -0.04790316168219242, 1.2883577319038626, 1.1005999292149693, 0.24147791470184818, 1.7487710273525883, -0.8978278817426648, 0.9522253060120448, 0.6534047871208378, 0.909843775185194, 0.9104167964518771, 0.6641762680351282, 0.35932208478307104, 1.8519919546904533, 2.22224267497065, 1.1246339495552353, 2.1054526797939177, -1.0093890132830896, 0.9964002717453948, 0.5891251705994135, 0.6614800540986974, 1.9643694899986175, 1.0722971364389657, -0.5518993245129062, 1.0916022884550198, 1.6505799650169846, -0.4929184557043603, 1.8039020326737119},
    {1.2217701995587253, 1.3692462555468874, 0.38984010682985126, -0.86413947968437, 0.6749725479769298, 0.23838242743784674, 1.9074358066973514, 0.349859895121392, -1.0561240689224172, 1.4600840882420218, 0.6324302289291819, 0.3746602245380728, -0.6053343717303191, 0.9750566380091262, 0.7657952848167656, 1.7081750275333698, -1.0051522599229044, 0.48755113466223027, 1.5963867127807057, 0.1122650310778292, 0.8567428396444217, -0.7148930522875673, 1.7393240902869722, 1.2950438686961074, 0.40828833484110555, 1.9377176893867611, 1.5589291878729241, 0.5052117681515185, 1.6013049610316652, 1.8034464281550753, -0.10845976673838888, 1.8007646806210604},
    {1.6620302539188627, 1.2288947885555712, 0.8378278223913749, -0.0473051985000702, 0.18080365400837609, 0.5541304598570014, 2.13097281284025, 1.808070416047932, -0.2901590302786843, 0.5679644537228119, 0.24609857141072103, 0.6785494741228874, 0.17466046385171302, 1.3579692192590422, 1.7136502890682648, 2.525706129976935, -1.0168765950377487, 0.5139612818053836, 2.1318355754771168, 1.7281492344342761, 0.4314108374725884, -0.8756834262865248, -0.09473666977890564, 0.32083414066079863, 0.6595276213353002, 0.7264859285166082, 1.2109819955547034, 0.36872179612025624, 1.6519883192124611, 0.42285022121466, -0.7624694077884195, 1.4845196817702946},
    {0.3206028396001947, 1.559960718911793, 1.4066506569165331, -1.0382550662951868, 0.5789680406332464, 0.40341132554849024, 0.8901390766251145, 1.8685553107962218, -0.865546961974856, 1.3396577923093609, -0.22193260797741288, 1.0380658581163866, -0.38994211943846857, 1.5210508341909268, 1.9694790874456538, 0.7759775621628212, 0.3890094639579781, 1.0849084120557537, 1.9319539758013298, 0.3719628744705249, 1.5349098555125826, -0.9714784651196742, 1.660860252404371, 0.15585003133473618, 0.6467227576140541, 2.2349713414497145, 1.1770052483564089, -0.038685819401330604, 0.6026539338692036, 0.6331718804304841, -0.528460064732551, 0.5666444653376714},
    {0.9501311917860505, 0.9677756851418521, 1.679408455503988, 0.6372751085214611, 1.2388294616126934, 0.08490400944455329, 0.8315989905379836, 1.2694861696291972, -0.0072362251000859705, 0.15273260064876973, -1.1350128617311894, 1.2153590405673305, -0.4709157134363338, 0.31924027384506876, 1.0900915169317882, 2.485637221454182, 0.31476609293928437, 0.7491589149903951, 0.46995945151469765, 1.4822063704619939, 1.9911778992824836, -0.17277294533212229, 0.7558523550476112, 1.0553563145831653, 0.6975815001550333, 2.309982860720134, 0.45960568330916673, 0.5075041086472213, 1.1198404334472494, 1.4455875837322467, -0.11823164951939584, 1.5074349156039053},
    {0.28166438590919635, 1.0948005087100545, 0.30593264510039275, -0.6608391564843697, 0.9033394588111227, -0.42531306346401165, 0.7031047979764966, 0.4881865405174724, 0.31486886227369065, 1.551033830723378, -1.0360069161871117, 2.2363376496981493, 0.26052760519023704, 1.224938690191638, 0.7772576605446747, 1.22319077478227, 0.6406616635583207, 1.6257469458907343, 0.7349012402016538, 0.6702210632490033, 1.404984174179047, 0.624553028074015, 0.3193154807387086, 1.299844984501571, 0.3414051641152274, 2.067300488404775, 0.255899716275176, 0.5766378427214766, 1.9590953045330897, 0.6190394370429207, 0.5355745837477818, 1.2719023004600005},
    {1.4513199352774009, 1.5408204752529773, 0.24192054706078933, -0.4048365101090842, 0.4875373647974366, -0.05206722435342713, 0.9003263666828987, 1.5500351337759046, -0.47854580767344596, 1.554695157322063, -0.5121848825021372, 1.3857092260278103, -0.028289307640300913, 0.429131920397513, 0.36265004054144023, 1.2822892745378605, 0.5662602332470411, 1.3705963862212245, 0.6383833472080179, 0.2340059235438147, 0.8663601093463059, -0.9836571002290431, 1.6698716236806903, 1.6389144777740452, 1.517666414578357, 0.5787041734173163, 0.45421248733763625, 0.7785798429900135, 0.8535853553747178, 1.4652759226401353, 0.7435091130716693, 2.260593971702054},
    {0.5492488146796818, 1.3709923235019805, 0.8108530364381614, 0.27769426622878063, 0.6779701913050843, 0.35355333823286467, 0.36840386641382067, 1.7183446233705892, 0.6589607641626644, 0.01604334260448906, 0.10960101215253774, 1.1568443073255827, -0.13193097929688066, 1.3367340993000312, 1.088170267211932, 1.141784879584802, -0.3470965959118515, 1.6255236943125067, 1.1217262207087104, 0.6865049443401048, 0.996504169992292, 0.10110343223398544, 1.3862194690266594, 0.21477013441640094, 2.1617842643767045, 0.7508621829095543, 1.1270697316740803, 0.11782732517844748, 0.8353661855028899, 1.9130051263722736, -0.2097190424489621, 0.8945689911352533},
    {1.101874521031451, 0.5275760284725628, 1.568585834664197, -0.4309146333655903, 0.2513976745468123, -0.5750619404309418, 0.5309586890523006, 1.8758694418011639, -0.9226542493744737, -0.08512408413290654, 0.24583747929278707, 1.7899654869415187, 0.2582663811951118, 1.9431502844078516, 1.7266367489176901, 1.9167978728340682, 0.44024791714734496, 0.709768790852103, 2.1772928078657836, 1.7114950695155986, 0.4867364334040788, -0.6930430043728011, 1.5135329551695544, 0.9582613221035202, 2.2519055748897028, 1.056469062404771, 1.521146616789005, 0.024460922748469123, 0.43849189075473655, 0.7560694161860791, -0.7848065622943957, 0.8172684874941658},
    {1.5022422793215318, 0.4759730212551854, 0.9274135181011084, -0.2027280961136773, -0.09939898877373875, -1.1087135296489088, 1.401384120563435, 1.9589485872091197, 0.29983188761445667, 1.2198150365762888, 0.38116936435192655, 0.45278849730700443, -0.3565096251827403, 2.062959003263587, 0.4405012046799469, 2.5177208146704326, -0.30559934643948117, 1.4291422593812153, 0.7082481201052608, 1.3181174771904993, 1.7252537443410352, 0.29787375504913477, 0.031011483117490538, 1.4791329714410246, 1.0008855393197296, 1.597090216533575, 1.4948493936733491, -0.40510163067868027, 1.9303876029522662, 0.6376350215058998, -0.5206369774366393, 1.7647992344983618},
    {0.4763177240862642, 0.6585879692150692, 0.6023259269062662, 0.38418245197217077, 0.4298227029424403, 0.3798845223045654, 0.2816165094535543, 0.23308040710083336, 0.49387248807537837, 1.2774020782795108, -0.6925698773717062, 0.7576749799706795, 0.566973755207587, 0.7052410812230226, 1.1370264400861527, 0.6978467592271647, -0.5675394022372224, 0.2889905273798388, 2.032919866901313, 1.3292944419243917, 1.422847542801169, 0.1976406340632139, 0.8511087224749392, 1.582452889907603, 1.2750626805121497, 2.3066066501500258, 0.0649358758079994, -0.16824812425231211, 1.8414749093273788, 2.1919765024305593, 0.18771090175132318, 1.499303404937305},
    {0.6590761004910101, 0.21041614579238077, 0.8555344476316513, -0.2172110988937504, -0.14619200603399757, 0.16097960295969063, 1.557420033284875, 0.8423430594714111, -0.5469036012822974, 1.7479483397004965, 0.4738091529965386, 0.8440015178604373, 0.48745641877986673, 1.5043928842878502, 1.8573379260661793, 1.7926150051466911, -1.0606791615126379, 1.5111661406274866, 1.9578977912700226, 0.2396042940821714, 1.352816853075613, -0.16926212935706222, 0.8928998899033304, 1.3727145320144003, 1.8699572063528511, 0.9998286021869058, 1.9424625256806471, -0.4835269493415851, 1.807474672666359, 1.55193330423376, 0.5040405270085776, 2.0038294527375915},
    {0.18783542005580364, 1.6111169870836208, 0.14538326214659478, 0.5924271365331816, 0.9207449265236608, -0.2451629312401882, 1.9705331383703566, 1.6790003165914784, 0.3484529427659954, 0.1858815483891391, -0.3149829293119324, 1.0705519000799255, -0.36432804258984913, 0.9033202909998723, 1.3110921978581784, 2.1187682131623577, -0.7401900012897834, 1.2687541409579568, 1.4596249174621072, 0.17878220912049209, 1.911859453129161, 0.6543716924531029, 0.04401775206418886, 1.8568203522668572, 0.46587696564214237, 1.685785049245165, 0.3974820705639919, 0.7850025736681302, 1.6002631593757104, 0.42571978182815895, 0.1695633917859885, 0.5094698185970081},
    {1.4898712423836225, 0.3695818043512363, 0.6870047850237916, 0.535080583816801, 0.43998392904142847, -0.8930161544509174, 1.9590942087111083, 1.1821854924605277, 0.451771604859001, 0.7325753363766399, 0.6293518494115419, 1.194461132406484, -0.1328301483064061, 2.157541008494811, 0.4937076714067486, 2.4987383619312915, 0.6654176415566753, 0.2913640363447051, 1.6529928080765428, 0.5165024782892857, 0.3510659090744259, -0.09064911480857188, 0.7615375239190025, 1.0159461593639278, 1.8900719392708438, 0.8531432620270892, 0.03330561124270293, -0.6719606966148489, 0.7381658678968762, 0.9856184678682127, -0.8972978446084094, 1.989104678069574},
    {1.2342117161923427, 0.7215487813548813, 0.32584178705224587, 0.05178761622449702, 0.51594177556082, -0.6828571880422035, 1.5838839760042474, 1.3870252208965157, -0.8617467483880697, 0.2463321421024877, 0.11149043135863637, 1.602991668747023, 0.2620788719203927, 0.5581715055538887, 0.7804574336729218, 1.5734106031273651, 0.05759191793809606, 0.08321995196801756, 1.281879304541044, -0.0958817091579313, 0.6910261155186729, -0.7952988609861188, 1.298964838585652, 0.34532193198154826, 1.522247613201651, 1.5308455113777555, 1.651609462864464, -0.7034029902056091, 1.3684422849731899, 2.1100282218912616, -0.10523491083293299, 2.230078263714809},
    {0.24160499735340094, 1.4470274907013216, 0.1325706035359506, -0.8419147485401305, -0.02292188139328521, 0.04195788889873713, 1.490046001717228, 0.9122473264477278, -0.3732890597319561, 0.7822589561091456, 0.1403030040331565, 0.9582861654539709, 0.42180391329456873, 2.0572285414569236, 1.275158436394008, 1.5389729498260394, -0.826164423895533, 0.6880689113751423, 0.8080138709765454, 1.431835971480244, 1.4042400520663705, -0.2955245782284503, -0.10767120347161342, 0.29189920232107947, 1.3998618375503749, 0.5547514250481853, 1.189055369938275, 0.18500393017669287, 1.0916541743286212, 0.4701362470422391, -0.4668986050770029, 1.8287564539688808},
    {0.04734226339457266, 0.38001010974552296, 0.7237998028437928, -0.0505084586384058, 0.7800880877975729, 0.11600437335618027, 1.043274939360993, 1.2284042395126538, -0.0023446820543468823, 0.6264633918853297, 0.12070213836686094, 0.7721772111872566, -0.28159312060462255, 1.2089406777054348, 1.1369699784864473, 1.280475640942274, -0.41602161357644146, 1.1417702529348956, 1.5883323354237062, 1.6204637888042723, 1.7012086617481765, -1.0074825041035673, 1.4854726869453927, 1.1860747199869606, 0.9460057547684698, 1.0714408456883333, 0.4526767604661681, 0.6464839093368984, 0.6163145794569357, 2.0446294337458277, 0.7021538890401251, 2.241836145454994},
    {1.4762658130069977, 1.7533789494757004, 1.7594887973541953, -0.43270152469236967, 0.021546838341631316, 0.441946388845135, 0.9200317827885871, 0.585802217486004, -0.8075788654995171, 1.813630938127315, 0.37451234424643154, 1.6375126982468222, -1.1204197571979588, 1.2665058677707401, 0.7072069267873136, 2.488604965498881, -0.6028895303990564, 0.9876822652257353, 0.41183448194128436, 0.7432185332418472, 1.4174569380143431, 0.02670674515037314, 1.5780528661861226, 1.5733814360559435, 1.8114960801074738, 1.6298924608143677, 1.8165381576485522, 0.21002099839072252, 1.9998414310984531, 1.8128097713006006, -0.5081460822965898, 0.889847108157299},
    {1.7123771777026326, 0.21383384490399193, 0.5778530447906134, -0.3484430354295791, 0.26584842560138616, -0.9889800493313998, 2.156958925553464, 0.5602247177007383, 0.5225774900810872, 0.5160433430550968, -0.29935770370126963, 2.1775465179666567, -0.5482474976597247, 1.923716017455888, 1.330225019501521, 0.9266389941227242, 0.782747062495069, 0.1655141500601776, 2.0069866982080025, 1.0355297164026274, 1.4936775704763336, 0.6362036029777394, 0.10867509816758984, 1.0706882566227724, 1.5733293105561152, 1.3032090501446394, 1.0119530961712504, -0.03580612646416691, 1.2530209609812295, 1.0139446156726966, 0.4886202714594365, 0.6301038731371311},
    {1.5015027841143067, 1.257107381233078, 1.0700206047862482, -0.6957011361593307, 0.3676457525174961, -0.19108168059974492, 1.1059778386953603, 1.563324857836018, 0.3516012291284641, 1.1955672965476687, -0.47620491307904894, 1.9518874915394426, -0.7963780564225548, 1.3942826435425555, 1.0670975361327437, 1.2223654949407263, -0.09108084571970541, 1.4692405506530788, 1.321897834607541, 0.1270460567656698, 0.5387086262534528, -0.380971512071861, 0.6482892231415167, 1.4417015440423206, 1.3793135800930976, 1.500756553578352, 1.0345617587050258, 0.07856631784509012, 2.029070424108372, 1.4741418112618452, 0.676703623134311, 1.283359211093846}
};

static const float b2[32] = {0.8911913043003604, 1.1578675327946573, 0.9573064729381983, -0.41561071573312947, 0.6843288529037383, -0.2916549334329215, 1.3606388986941629, 1.3153168103299524, -0.35813156006748964, 0.8996961049347386, -0.2624737049961535, 1.4198502699075235, -0.4193499812485922, 1.3354255802345842, 0.9830686461869923, 1.7400287305305848, -0.3485089570706277, 1.0184820890973931, 1.4425068031611714, 0.8438019298155466, 1.4170525032221883, -0.23670765416364573, 0.852582134389239, 1.1758184515521797, 1.3201863494152173, 1.4619221855787137, 1.095125978067307, -0.315488025549653, 1.1486787309278026, 1.3236308827646799, -0.37488673535918643, 1.5099124148039538};

static const float w3[32][16] = {
    {0.6969838524344278, -0.3505246198480537, 0.25569112706804464, 0.9679802663915307, -0.8916470894250603, -0.8636620642978434, 0.5438044153247342, 0.4946232693834993, 0.030805523334273232, -0.12418058719945906, -0.872007499705073, 0.5149780883363126, -1.0058123403228145, -0.7194671671655907, 0.37219046988622423, 1.6394878878349939},
    {-0.2571186680080198, -0.13275896502420023, 0.5900571030573754, -0.05011015023052543, -0.5792622555801169, -0.5234975088709002, -0.00834877168712505, -0.17310133041056022, -0.8939274603537569, 0.05530546681903898, 0.6282241487701746, 1.304617156430852, 0.711918247144439, -0.857144200108536, 0.4403903733584453, 2.158277461154694},
    {-0.8062896747000676, 0.5466487751971434, 0.1963052133456268, -0.5808975913112171, -0.5981350946330335, 0.6594361850372588, -0.6726902628653751, -0.06313099447721991, -0.20096904620395062, -0.5117917656541784, 0.6369716616088753, 0.5261904879052578, 0.009019594765012504, 0.7443185577854106, -0.20684578429637349, 1.877683869769285},
    {-0.5225249397205359, 0.716104685147708, -0.37447193296243647, -0.2625690307028901, 0.17614768837098796, 0.18417367000404156, -0.12630024079618044, -0.5463538329995326, -0.6124140166176716, -0.4982180564574731, 0.005777387887560494, -0.5495444682163013, -0.6066841672686958, -0.9691337182079781, -0.2431260514532724, -0.7554271903934798},
    {0.8274426212038165, 0.138822899878627, 0.2180390286760971, 0.07521042684356417, 0.8833742471029773, -0.8945024704013496, 0.06074249030266524, -0.3726000921688315, -0.7333647781427418, -0.7528789998610781, 0.7309239254439278, 1.5576969373433984, -0.6566776535708452, -0.5172450254208233, 0.7580355164335906, 0.8099884953922056},
    {-0.6622060418754387, 0.1492671725096605, 0.6437192375623095, -0.9769506109839569, 0.6709317188077263, 0.43949712181474443, 0.02185341329364931, 0.8995668113877359, -0.7683932062947189, 0.16680976703672978, 0.8420218384583211, -0.38691016459984195, -0.2935454352673134, -0.1854381372815569, 0.20076678560782446, -0.7811332291679748},
    {-0.0144365002328721, 0.21651051860910794, -0.7479905254298616, 0.1643230590407316, -0.568084456601604, -0.07870191270954206, -0.45062264759860327, -0.48526028847501584, -0.9061524729323469, 0.1944378757652357, -0.6998903306932645, 1.0720253856759117, -0.7888502512973949, -1.0208214679533076, -0.9898583479203905, 1.522106699078754},
    {0.3738192998326013, -0.5053435410937401, 0.2578649290450552, -0.6986236102672397, 0.14531436906571812, -0.11804692342559361, 0.3284055712318269, -0.9717409001539632, -0.43244864310074277, 0.25466023027394874, -0.6751888475478544, 2.028346484131576, 0.6797547486192702, 0.17001264045986078, 0.17686305662414253, 1.9598842385085486},
    {-0.8684116870756531, 0.5491671571753509, 0.504363612230906, -0.585787324240089, 0.7542966538599478, 0.38169251247231356, -0.7964057070333067, 0.29395263811533856, -0.4736366620734363, -0.5017882604366598, -0.886576988789588, -0.10195061226225302, -0.028240740029400798, -0.11215661461938493, 0.786570755233338, -0.549720254705491},
    {0.21059706476976323, -0.21270770692826274, 0.31728061494481186, -0.006126623267092921, 0.5340775763324129, 0.027480829945691312, 0.25914456004060205, -0.1681866613858758, -0.754584660986511, -1.04123520408312, -0.4880054352531091, 2.1397997066011603, -0.4825913971542028, -0.524069124793853, 0.5364395718471717, 0.9857483357009583},
    {0.5539264415112687, -1.022087986053919, -0.30684897780281717, 0.5836172320588909, -0.47140758775302505, -0.930594160360322, 0.4783115595086831, -0.8124682600278822, 0.2643937311213393, -0.07173739693728197, 0.7823685552676191, -0.3008300852276083, -0.31800099485148275, 0.05527573431135527, -0.24468771990968197, 0.10011779223278337},
    {-0.3438313822291384, -0.23470366811642737, -0.3975352435245815, 0.824546936711733, 0.7648595646061871, -0.7012330225970774, 0.5304171805069579, 0.6312873667413503, -0.510236598835456, 0.751617440060306, -0.5400808980522258, 2.2664727095945327, 0.42057520423548256, -0.7361103468999269, -0.9714422722154944, 1.7251227103868016},
    {0.15917453134523005, -0.5830761503654007, 0.40568289198367685, -0.12739817833037856, 0.5291782457121381, 0.41474015832819294, 0.1491731722875691, 0.04506954753083129, -0.10244028206103342, 0.1848792205666568, -0.27126748347631197, -0.1065585821784715, -0.14022151144153985, 0.26977208158007177, -1.0629495916347809, -0.6989279500156047},
    {0.5112787463433406, 0.46378577277211, 0.0132066541280009, -0.6140899827211954, 0.3438699055686311, 0.7905967668671565, -0.42175916802083974, 0.3124890137378188, 0.8913557446639931, -0.4893657018791098, 0.5430456352463026, 2.503696804220294, -0.16567163797641624, 0.09572803761603745, 0.025502831145089073, 1.9560559197517078},
    {-0.13729807536959146, -0.7014029590141045, -0.23250035551194895, -0.8205695565595535, 0.17026817903928915, 0.20998160646182282, 0.6747781556549133, -1.0042477774233043, 0.16950501407412175, -0.6895201616016244, 0.61775954789803, 1.405854405737313, -0.015438431556473432, 0.30075999903894246, -0.10460782763835103, 1.2112442183175005},
    {-0.4825849707416597, -0.5968772601081513, -0.6722081380171374, -0.9591148293143668, -0.385416483682701, -0.5182993651562383, -1.0560283366671532, -0.9542826313258771, -0.3076163053314796, -0.7396042750762615, -0.7019770844456733, 1.8419787333864754, -1.1742327787917244, -0.916542989212293, 0.35111355268233696, 1.8851381207936602},
    {0.5106278024537694, -0.36478431710864717, 0.6573531841490051, 0.18419515489678553, 0.5796005144358564, 0.10718401765763638, 0.7405457655341908, -0.6837366754618719, 0.6781674715402778, -0.42425418206956106, -0.8176823030936355, 0.33000679984588904, -0.0700533516950345, 0.6738765600330416, 0.22509734486831734, -0.527076822322209},
    {0.3295671717954978, -0.7396652903324126, 0.5453549275515593, -0.9940747596703241, 0.07568547520396375, 0.6431479490942501, -0.4462179708772938, -0.7584540688985416, -0.1750013233517604, 0.7098693547346907, -0.6895227112718252, 0.7493656267518691, 0.42823533256802165, 0.7437574680073143, -0.6129284655951283, 2.257068284234255},
    {-0.6298227559833695, -0.11292799301433645, -0.5569031682655543, 0.27955523987674147, -0.8795261116417136, 0.01860678971566694, 0.2380688609092037, 0.6832389653865256, -0.9966794471560924, 0.10670542299394369, 0.005782564486281139, 1.9642028881767795, 0.30665032081437144, 0.13680329991060658, 0.16673328315923494, 2.253481256351187},
    {0.7633893426209041, -0.07168958460247839, 0.18369981097685048, 0.0809509657225005, -0.4152511525468308, 0.7181172525215015, -0.560038730022665, -0.44257996576915004, -0.08317368880041576, -0.9484583036692615, 0.33574123482541174, 2.2728787368913825, 0.49563593890912677, 0.4077541648378804, 0.27520506342621653, 1.008791378121553},
    {0.2733900930983022, -0.9181186340127401, -0.957974776175695, -0.4019911298558246, 0.37506377133152724, -0.33590506831051975, -0.7136590296700197, 0.6445666541593926, 0.43221953078624215, 0.40417561765722265, 0.6051660368315414, 1.5352602337063803, -1.1413698582211147, -1.0335942995238456, -0.15186020586529067, 1.6766073214203583},
    {0.7657922588543101, -0.8621108167740397, 0.36053327362104104, 0.9914417398142195, 0.25704862999015754, 0.13387599595392444, -0.5303128683489465, 0.9117852923811847, 0.029186736173505465, 0.26634642672561026, 0.21254792556977722, -0.3901469645989896, -0.6074405671779542, 0.31959177924441495, -0.2837296336604304, -0.6636211931773368},
    {-0.5162289953619629, 0.401798993601327, 0.7461940786102399, 0.7414094493437501, 0.5384411591206933, 0.11340317799641435, 0.5495178598190179, -0.384213914051338, -0.7398096225809361, 0.7281205862776062, 0.7272496518198434, 1.9906200521304143, 0.6373260507552679, -0.19184426808025523, 0.9032773731763049, 1.0022203289488107},
    {-0.8814996423465598, -0.026691255081568426, 0.12549881162264306, -0.02558982782413026, 0.05077914201346598, -0.10390117024181891, 0.7527325326528406, 0.7198654869415921, 0.6730082534129845, 0.4534046365855268, -0.5310254212378008, 0.7803816867956326, 0.017339915734357676, 0.5075475874966499, -1.0564975543167252, 2.051100111538799},
    {-0.9182883312119006, 0.3839437142775573, 0.2120080683977879, -0.6603223606725743, -0.2928388299789786, -0.5188575831186261, 0.2886210115305617, 0.43871634926124825, -0.886778786416918, 0.027598245185388205, -0.3200878559062696, 0.8707487738584865, 0.06648476023685439, -0.8085509708657413, -0.031971650242816424, 2.1566836515789127},
    {-0.9098386171198706, 0.2667918011786455, 0.11302308698350462, -0.8568022068181703, -1.1332880859462602, -0.29228772226959376, -0.5685334296196833, -0.6516991815912476, -0.6645004227915833, -0.6911663364529936, -0.7579479528802824, 0.8735501892132796, -0.00041169391419389596, -0.16628095352685932, -0.44477247636347467, 1.9453697916542056},
    {0.11528406656625514, -0.703839412275612, -0.9238246060580216, -0.2765008377883515, 0.8728975032838457, -0.9783381297109289, -0.6609690001307319, -0.9308233637741121, 0.61112257318568, -0.04411058422813234, -1.0560287180988146, 1.691432471091577, 0.06861092770545302, -0.42239757824869445, -0.4640247047082284, 1.1014139281225626},
    {-0.7802389112213657, -0.5068531007653025, -0.27912844764157874, 0.6385194168647935, 0.21770173110350846, 0.40222161307490223, -0.05236064926320662, -0.15007615248672077, -0.23996370176590795, -0.0729904655942356, -0.06631741105559834, 0.08231582831626683, 0.5554413445924237, -0.21823358435783557, 0.5543856810167328, -0.3745538309880568},
    {0.37875722208826085, -0.1965013654088823, 0.7797559469715298, 0.4223891377930814, 0.430057369509764, -0.11561982179662506, 0.8212805605564053, 0.7512774346263785, -0.4434793613577992, -0.4574253066589895, 0.1894206607286217, 1.8374800401349076, 0.14154642073790866, 0.5958156844539927, 0.3745800854661754, 1.6542608386552076},
    {0.8217399281341272, -0.29217788052677035, -0.18782047382450823, 0.42653929366832755, -0.14040875561378852, 0.004569986269177025, 0.7080565199950549, -0.5953643847807223, -0.28248625545765477, 0.13770620341194234, 0.3752594718245632, 1.6837473096690674, -1.002804924925842, 0.8079402568135717, -0.8499921637857577, 1.749755400119452},
    {0.30617841761527254, 0.42901393414927436, 0.6333253186099925, 0.9566285168367399, -0.591794386541023, 0.19237584296268923, -1.0052105842648855, -0.06151613257778275, 0.1770761998411016, -0.01705589359612394, -0.04424591804673596, 0.5200043546741581, -0.46772334281331257, 0.46848109783616326, -0.5195504807514751, -0.39113429922424675},
    {-0.4639832097449008, 0.0301483353960824, -1.0169045620249924, -0.38353076077324155, -0.5983264234055831, 0.4624898426094756, -0.2081811031873948, -0.002787201428391028, -0.7923935164925737, -0.42909059373395103, -0.5812025740484196, 1.5915371098789397, 0.7005357354410752, 0.3509222937910577, -1.0040040865912714, 2.1698337119473092}
};

static const float b3[16] = {-0.2145136448789701, -0.2547921251681585, -0.18181021781209872, -0.01746521209133819, -0.15274741063975442, -0.20637530774670995, -0.17722504306075448, -0.24344229338124093, -0.039502948469517386, -0.1745249429447067, -0.20013071148432074, 1.3233823905992197, -0.17730987353940247, -0.10927564463782537, -0.21674486180191985, 1.203724768555696};

static const float w4[16][12] = {
    {0.6254106090026089, -0.1621026217597257, -0.21553852398963708, 0.5279572605897243, 0.17680082880138098, -1.0253867205695908, -0.9232666503216446, -0.47140710792176277, -0.031519464454920404, 0.0841830865571905, -0.7703390895547444, -0.39400045782531495},
    {0.019523155801917273, 0.7267056828037819, 0.10689967204905491, 0.7695792326886315, -0.8543912226750716, -0.31250106800658495, 0.15345515477602084, -0.008460875537372905, 0.6852744257377236, -0.06910119907349337, 0.7169333890291493, -0.9467356570248694},
    {-0.1268246596980541, 0.640696732150488, 0.7738520290627413, 0.8235940176492081, 0.3105080963903312, 0.4180855737064028, -0.41284755910935667, -0.5456693254641369, -0.8004226021604023, -0.7053866227112536, 0.1631352136093899, -0.7380609943357919},
    {-0.020087264724846423, -0.013719506556283224, -1.0274239011916808, -0.1644509838607408, -0.4572291121425144, 0.7489693263631173, 0.8808568982549241, 0.37533042559710705, -0.3708008866412969, -0.6908649442679177, -0.8348484454485129, -1.0251470371151539},
    {-0.9133602837491165, -0.7599821807701426, -0.22001909528379776, -0.917377620786895, 0.7954742861378594, 0.5043097191068606, -0.32974575861003586, 0.5283569764094268, 0.8341944315175575, 0.49826731355894827, -0.8298607381072909, -0.22596617203263758},
    {-0.4495450264688733, -0.9232105373490151, -0.16905569738578352, -0.6479666059249004, -0.1020053695710613, -0.663853761204454, 0.19612156664723437, 0.5149553636938426, -0.0598524098023379, -0.3258892510178026, -0.2879004058885194, 0.6755858303712374},
    {0.3689369250866857, -0.6613126155879719, -0.7703459711689273, 0.5768471607665239, -0.5747760141396704, -0.3186660427064061, -0.7523008897811655, -0.03800020144478515, -0.34221226479647365, -0.4991643759229899, -0.49612550314584036, 0.6525250908170068},
    {-0.19512485648289085, -1.051585898794144, -0.5908688718898225, -0.24456690498644698, -0.06799928118650996, -0.47007917970127233, 0.10751573428191796, -0.9558611629606882, -0.14380533933158743, 0.5022961451183222, 0.4306884119304467, 0.00788166709643719},
    {0.20212717227335655, 0.33284519592834383, 0.593192261534887, -0.23382058851390108, 0.4987383495457532, 0.24820538674902776, 0.2935433957743216, 0.7930218690307607, 0.12119593797187776, -0.049253863898064396, 0.41280111928773977, 0.2573245147756484},
    {-1.0084702283334392, 0.8146472558255342, -0.58599311919432, 0.3762128742022232, -0.47564782876182105, 0.14427743547354482, -0.9111013073882572, 0.07884033332060252, -0.3545370977269811, 0.49945730515370296, 0.7288247966541084, 0.46488466107826015},
    {0.45332485825556695, -0.22881562696377733, -0.9952368035103125, -0.306782791732356, -0.3044573296044569, -0.9381675327598088, 0.6993575748169975, 0.7225762491976178, 0.6899705695196149, -0.24747326053094834, -1.0258510444308233, 0.8877680718261795},
    {-1.8196091187764722, -0.7205864122414932, -1.333962452572519, -1.5945711468849675, -1.5005187809242204, -1.5642107695933012, -1.7063362376010769, -0.8842761100219676, -2.102894286319484, -0.9397936496237189, -1.586561884725332, -1.7152772853943106},
    {-0.48704386761210383, 0.6769864882316843, 0.795998641297552, 0.5743004668844525, -0.07057700687558593, 0.4474377423762123, 0.6708002140468352, 0.03152610838096561, 0.46408448247413014, 0.40680589183788124, -0.6770441971254729, 0.1907353442593249},
    {-0.34700804263402324, -0.15012030987133235, -0.7210316884733946, -0.7307424824428472, 0.24918833268149343, 0.5495463786540896, -0.2258050440113519, 0.04172644381408852, 0.526937125916548, 0.512837983680348, -1.0062407299027059, 0.5043617884954503},
    {-0.4354358885606735, 0.6496692802303157, -0.17316660328924754, 0.6914532120884185, 0.7001238636284722, 0.2992134580208624, -0.22059011338072518, 0.7064030567970766, 0.04504647728190327, -0.16306472696573912, 0.6253900946722163, 0.0260401754971031},
    {-1.3455513247230257, -2.315045814259377, -1.7472014631655495, -1.5421513076373874, -1.5789586534177038, -1.5719116960890374, -1.4350155044857118, -2.1634769862911174, -1.0667942536599186, -2.097390558958628, -1.5356890158774552, -1.4213404971130346}
};

static const float b4[12] = {-2.3528116432981534, -2.4029432475488983, -2.386310052770644, -2.3376837198836586, -2.4230759396530805, -2.4029060129081543, -2.33962300221763, -2.4387917642094004, -2.403270939762476, -2.489373117121134, -2.4227115696960735, -2.3049958137713285};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
