#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-1.5510394350458176, -0.9713304117363677, -0.4011996169396953, 0.18961282878928035, -2.2863989065647585, -1.5524248213408518, -1.1665223742058342, -1.0116599952822363, -1.3521901138361663, -1.0548765513429472, 0.36016436885207237, -1.9746286476449293, -0.8717288475911457, 2.108625474401356, 0.5449349598749752, 0.6382688108896633, 0.5553053712902217, 1.205643301087379, -0.26782751637815283, 0.743116446911511, -0.5163370184125617, 0.5847193605267602, -0.5638635341892645, -0.5412960741843577, 1.3883542926753392, 2.275069989773187, -0.5351293365942538, 1.7231621941124937, 1.1882480640399087, -0.4483632906145777, 1.5364604180550756, 1.661514783290685, -0.029692292527423295, 0.7127423054625022, 1.0006101366090354, -1.036588790003306, -0.012769507491838226, -1.0297198993167076, 1.0734991747887408, -0.2327249658947864, -0.08899284337363259, -0.47604892586635505, -1.6212387528000243, 0.015060629649171386, -1.0642869582538321, 0.753348321379511, -1.3346022837495122, -0.6010535124527495, 0.608424363045036, -0.27022588906290856, 0.11259788965167761, -1.1540655586560162, 1.3265847805758297, 0.5750580015886356, 0.7430197288760501, 1.501021492858861, 0.8372362084133124, -0.9409767916756403, 2.566835881083478, 0.27750899102688104, 0.07368825712306834, -1.0082496545322974, -0.11317431721742688, -1.020537048825103},
    {2.1144443532900086, 0.3452566766438546, -0.023951974936089634, 1.3846555388494586, -1.6546534500150998, 0.3707719345799062, -0.45144230390567913, 0.42070540745655094, -1.4915640893129039, -1.42775673896509, -0.7570342867329305, -0.7072386342353292, 1.3832726377804543, -1.6420743478251365, 3.659207192300216, -0.6748048276385367, -1.1231657745441588, -2.1548583281574363, 1.2424854619042252, 0.6678077086202423, -0.490373995040268, -2.077467793977977, 0.5431616611983461, -0.9916384350908505, -1.2035629514546329, -1.0645083907408135, 0.7879855690375943, 0.8105286952244826, -0.8874755081939548, -0.8899851767627711, -0.6426808528619284, -1.48814214946624, -0.6478527900857118, 0.1482851476476746, 0.45272503906794465, -0.37423845219728463, 1.5476482602002195, 0.5173801952364718, 1.5792841582723993, 0.21208886156152862, -1.068878045937979, -0.3173746055087689, -1.0715645212256169, 0.1628739698272325, 0.15948912326743447, 0.7516198308455057, -0.2964758763416821, -2.3971179267813074, 0.429934861508827, -1.5404245424564729, 1.4573077133161525, -0.7349637832573045, -0.9707869663353361, 0.30554754444129556, 0.07726924420217553, -2.2928488459041496, 2.2855548545856643, -1.9971149817614289, -0.8060337309163249, 0.7942315739259199, 0.27242901048840695, 1.7142300866887852, -0.3734065554732293, -0.49852826707696957},
    {-0.6492086712293041, 2.604052736173516, 0.3872509834330858, -0.8311325260437484, 0.6003198093972992, -0.8596587892706236, 1.1978104886182812, 1.1774973370410282, -0.4853030241244784, 0.5102385786855119, 0.5831990830835011, -0.11816219910956942, 0.6733999613024686, -0.8831021854814995, 0.391445279407, -1.419972006718601, -1.7299363459651702, -0.8466066210644025, 0.34158454649480596, -0.28222330662638895, 0.2267665973790774, -1.863303334226746, -0.045990933634892886, 0.3907357093516413, -0.3014643410386161, -0.07886301026483077, 1.3892599877944398, 0.0051253753371340634, -1.4248301548155307, -2.8664287256672645, 0.20078220962947002, -0.3615344200440626, 1.6100270295628751, 0.9686568594050136, -0.04468102166405933, -0.07545397568070412, 0.9930069389129321, 0.36365983624342446, -0.71943492858193, 0.2686440745081119, 0.19198420611564226, -0.027868413737666423, 1.5321237607589473, -2.92030833439029, 1.1755964508264118, 0.9945193570347068, -0.7293520640906637, -0.25922320012006167, -1.7348043329707767, 1.7249071748369098, 0.2949037804447614, 0.3759945915085187, -0.5020443170701561, 0.3399129036607016, 0.35518529035894875, -1.8128489404313628, 1.8984086129032163, -0.22040392278381382, -1.597578088128498, -1.0184673540579028, -2.0057269026359594, -2.1471906039233946, 0.8737426899824601, -0.38038095646455605},
    {-0.5685367497216736, 0.114534241428381, -0.14523296025057286, 0.9415428461414481, 0.8900984014235049, 0.7256230534019221, 0.09535174506194607, 0.024758388041977334, -0.8434362440113425, -1.3903568236125425, 1.8083053367114148, 0.11298122315364836, 1.271955797680484, 0.4594264799104939, -1.9058654768173766, 0.4854043916331903, 0.7844659529235134, 0.6285101891538495, 0.500933366172523, 1.5012910820523173, -0.9552768026707525, -0.07282365860412189, -0.40379062868902116, -1.9985132205598846, 0.8949043007793418, 0.9456498386294858, 0.771164955388376, 0.23568541231605122, 1.06653633943349, -1.3578237771587525, 0.5952765996486874, -0.6009913747699759, -0.7674130137910816, 0.576117498388792, -0.8281296990225673, 0.4634844325417143, -1.358167381000499, -0.8572488132637605, 0.07157977749617836, -0.24804339891626692, 1.0441902955615907, 1.5290003612992513, 1.185128553611727, 1.3565193991639142, -0.6682832885752399, -1.182060686145493, 0.175419516690461, 0.4209667116850258, 0.07875380001086037, -0.45406816332778904, -1.0379775929245798, 0.10045233516247788, 1.046480388046167, -1.5536766910208244, -1.66529496320357, 0.9150061225506994, -0.4423405514345291, 0.2833442901599961, 0.2613456292018133, -0.7929505090461666, 1.3951771462140488, 0.5981834323093109, 0.6660259149642215, -0.17788400236756968},
    {1.2140524707742446, 0.09496194718007035, 0.652921171191011, -1.2262553412677057, -0.6115383465979946, 0.3941999663016548, 0.9745425897334444, 0.22759276422542962, -0.4602171907345547, -1.0146541218800444, 1.8712500901481846, 0.20137354637375188, -1.5551689058763047, -0.9138226618984286, 1.1814937738721079, 0.2859547355341958, -0.3319528929628859, -0.5959273459482495, 0.6744421516669303, 2.866804858763511, -0.6144919468700695, 1.091929719415623, 0.10243938469647403, -1.6901504048335019, -0.9823836840779548, 0.47401587923232974, 0.3978067743519481, 0.32695984951930335, 0.8898134368943348, -3.4616235366508836, 0.2198074250923642, 1.2175531043993457, -0.552623413092529, -1.5482762103071632, -1.190923019798763, 0.06056331104394486, 0.5863657269216129, 1.2697935420092903, -0.23219729781829596, 2.5627172992413674, 1.3916333555884064, -0.6328155286221961, 0.80311953660518, 1.7616608481654756, 1.9245558433000742, 0.8772516893126221, 0.6931787425954214, 0.9374997817685082, 0.31209072282631256, 0.17874271801125804, -1.4753896887472386, 1.8918223612694054, 0.41439207279299367, -0.7187671406221988, -1.0692196625999602, 0.17153990604051841, 0.6956359322757876, -0.304033399186751, -2.722634407167174, 0.230520127752922, -1.7415974777959717, -2.0795187884000184, 0.1559843973787053, -1.623556828569223},
    {0.41326940003314155, -0.4284788439890561, 1.3280357193540686, 0.6712561353119405, 1.3860554483463943, -0.8770090840027792, -0.05934189429038782, -0.22970286239231003, -0.2417435743895809, -0.8245101732543065, -0.47849633077896486, -0.6591744102845756, -0.44426557026474944, 0.08524613824558426, 0.6519160315662611, -0.3265626966624366, 1.1216700386502014, -0.49385917183690103, -1.2569325216132488, 0.7064453776147235, -0.21961498933007928, -1.9683453468814374, 1.5501988132828461, -0.15132773884423262, -1.4984343427500952, 0.18829899721746143, 1.3908547883679903, -0.48804840205818717, 1.7310258049251706, -0.7048537267701881, -1.0098658495942652, 0.6049043485085114, -0.7895520676692634, -1.9297745838403417, 1.7100662681530217, 0.23602314719382766, 0.7483788224634822, -1.1733665587176032, -1.5361487652375243, 0.8168555457996542, 1.5183632266182365, -0.8658762432071008, 0.06869523864164906, -2.050729389042821, 1.758031889766774, 1.157409391310222, 0.24343698438361328, 0.11440412940346191, 0.06418595910062377, 1.9481075086551143, -0.7922253831100003, 0.3340933982025069, -1.217897294847165, -2.1346757362231186, -0.42427204386091233, 2.644722026364333, -0.014629454426112798, -0.440458388543954, 0.6058699807437953, 0.23019099824553238, 0.3538254422978551, 0.28218385723013184, -0.3200648290625738, 0.2815128716851829},
    {-0.4381298688122579, -0.11296919803666731, 1.0871918873908244, 0.5258876478354488, 0.9593692508065099, 0.7165944840604294, -0.1220691847315129, 1.044312489357434, 0.7021529662477881, 0.3114006252696794, -0.529890000938271, -0.22122490491348756, 1.324499149074606, 0.04321463499570916, 1.520509049611883, -0.5037783533794156, -0.37104369246525903, -0.7094684312476257, 0.7997980350987999, 0.3149665357884286, -0.9075078224439765, -0.07521574779098601, 2.580578903502331, 0.9595362000526385, -0.4724517498564979, -0.7904765688071979, 1.118384826058138, -0.12921111949478703, -0.19914179598436152, -1.5163952439566004, 0.9045145651679606, -1.38763993078187, -2.030020549550532, 0.44391444156779913, -1.6246940295681613, -0.15378046766909947, 0.07052145250262767, 0.960215067286562, 0.7008314573700667, -0.7510048327416173, 0.44125500434835885, 1.0903246460732072, 2.241457015544314, -3.8978561515670425, -0.16355092591212372, -1.8514274228453358, 1.2712681443807292, 0.5568904634288787, 0.42530422027541287, -0.12583754860846486, -1.8941601198664932, -1.6093074862178587, 0.1191907360633961, -1.4473426006973447, 2.251842867298048, 0.34147133274105024, 0.5840062432253234, -2.5181051784851496, -1.2015708463747412, -1.2583765274213714, 1.5268042550275844, -1.3156026535353582, -0.05937629624891608, -0.6649668690596615},
    {-0.8725856668858835, 0.15593938375867492, 0.5127602650516158, -2.193089427030921, 1.7631107112751616, 0.4584832407479748, -0.4425868827511501, -0.8711594477993527, -0.936175450813086, -0.7786126027513763, -0.3667000065107661, -1.686968404064476, -0.7576723472592461, 0.4775069451136354, 1.7143306871451465, 0.37863553815748396, -2.5673968977557675, -0.08106883031364187, -1.407044658253222, -0.6439556975356463, -1.9438512175909521, 1.068399996239917, 1.761051648590055, 1.0306084832736737, 0.3246222770006815, -1.3311942697388062, 1.501904281852112, 2.009779110444198, -0.8052521006567259, 2.21881826634586, 0.3908411366848355, -1.7223356860015175, -0.9338451341852564, -1.1722678607589003, 1.4306136010478279, -1.8500267831748642, -0.24863335001256828, -0.06879944268438606, -0.45368027831382113, 1.4994902129912757, 3.074484139611579, -0.1898762516342002, 0.7659056940526442, 0.5398062256238959, 0.5861813366104419, -0.016194335945898128, -0.39823608266467975, 0.6654303916599251, -0.5589869536914055, -0.850942230619204, 1.4761299131660781, 0.8455592821800443, 0.40933862080235245, 0.0627395183337394, 1.8679546360732338, 2.4777342718003483, 1.6504032818392411, 0.9071694932731842, -0.35431676991018074, 0.058535428068068204, 0.7862427696149534, -0.9980134090202227, 2.688206191598634, -1.9228896928983576},
    {-0.38652042854494356, 0.4531240718554889, -0.23461456631411703, -0.6824855871589236, 0.6766743633149407, -0.2073937344539392, 0.35251542413392256, -1.0942418485423901, -0.9839480054364433, 0.9432270516205652, -0.39464989727196786, -0.5486239481503719, 0.07077966051430745, 1.595500390714814, 0.026017582581720017, 0.89041857242908, 0.2033083930311451, -2.509144811505645, -1.1266703893912076, -0.4610121601734593, -1.6233247421701635, -0.5695980286971288, -0.0799944147737799, 0.589938229294423, 1.2572799918498916, 1.7250516658461275, 0.39182041422315383, 0.9057724380572996, -0.8736162587661728, -1.0174628441537248, -3.678413089421654, -0.14621258546055904, 0.4573996148919667, 0.3102447778833772, 1.6201585588003067, 3.0840101989961473, -0.12738974118132831, 1.4917603437579985, -0.4547277071646093, -0.31115400118307446, -1.4555278979394333, -0.33283195149105177, 0.8786649739335368, -0.12917171375772057, 0.628033747171519, 0.4955131272222026, 2.190706522333521, -0.29160609960152306, 0.7632407093033156, -0.5528227762745939, 0.5993325202612534, -0.46037270029260113, -0.8486924533345417, 1.0509422525536898, 0.42500632571866753, 1.1755548662144195, 0.8063493681497762, -0.6967534864959035, 0.17229096510626118, 2.762438067431397, -0.6527626907885128, 1.645978706147858, -0.27957675659179054, -0.6916678194451664},
    {-0.5891862006417896, 0.6662915778136015, -1.0356945732391356, -2.2951306146640778, 0.928777733383319, 1.127556720525346, -0.6443655311872712, 0.24805317424371454, -0.41817862314098614, 1.1670038868379304, -1.8421456687503033, -1.9074630884277493, 0.6027284572723921, -0.4009782597440639, 1.0107909936456718, 0.9922927383183548, -2.068525493198462, 0.3161920836219929, -0.3113602587631469, -1.3371577149758036, -1.2141228267373385, -2.481654308123754, 2.2841059626604006, -0.3303415474047086, 0.25574320775016757, 0.06633539828554925, -0.6563726856261869, 0.16044200763268243, -1.521177115025795, 1.1902412557187914, -0.5079009203183174, -0.3025464675275098, -1.0615809622307726, -0.012961363814891057, 0.6724516782240605, -1.0273340368960278, -0.12616553054938637, 0.5040537488393094, 0.8992179924817041, 2.439182965817461, 1.552177350717998, -1.3475418086510784, -1.3638532006469124, -1.677796073993067, -0.20230397887935594, -0.3331466250303, 0.7305523139459603, 3.756824942635632, 0.19277918488405962, -1.175057770287817, -0.4004023561005626, 0.829616006516937, -2.8621004678529642, -0.6601879064967151, 0.9214066548107303, 0.18596767739929543, -1.7786108185128073, -1.0222462454960843, -0.15046023862320648, 0.6402093226485104, 0.39187596037335476, 0.22664734880953608, -0.312669068499723, 0.8117152107806461},
    {-1.2806431669820546, -0.769890035119287, -1.1735557562969454, -0.6693297013011809, 0.11498487912707696, 1.6415949582041796, 1.6117581996719768, 0.3197804935438159, -0.19446991766524052, 0.9686981322219526, 0.23032328618045408, 0.393347088402337, 2.0279419317943974, 0.9323812610620406, 2.05012850270046, -2.916786987712555, -0.6125275915813627, 1.4135367004433703, 0.9587632236807475, -0.3267855324176565, -0.6160090822218587, 0.32464528797441505, 0.45378636983146986, 0.12373398548978642, -0.026507979705540217, 0.8327569519060114, -0.8383759733247196, -0.16331018765358696, -0.8488832004656292, 0.9048064899522631, -0.6613768592976714, 2.4896636346214045, 2.3665536014201876, 1.2168161102464639, -1.2211085783860558, 0.5365810403962313, -0.5180667175397876, -1.3052229786104446, -0.49662008477002223, -2.431423899253877, -1.2548170989090761, -0.0040591172277075396, -0.3612977536725521, -0.1829051751992897, -0.616886847484381, -0.6903788482599473, -0.2239819003616981, 0.40487677523551535, -0.35370541514077214, 0.4966271459727676, 1.5351497591698076, 0.19393861134236212, 0.9586955803182098, -2.5316011105032263, 0.6934200648218942, 0.05478849497973922, -0.7150831385468996, 0.9082082792578584, -0.9098366228248375, -0.8663256692457285, -0.45831660846166145, -0.5599027930136813, -0.6518663193780149, -0.40743038398015896},
    {-1.1326931054787328, -0.803808625926465, -0.6476347996582118, 1.1938336992576906, -0.541051295742445, 1.1287083895122376, -0.440224701893929, -1.1678057673659246, 1.0262402129645645, -0.3848225753640103, 0.2812461763553457, -1.2791819326879486, -1.1795770644037982, 0.8147152764809295, -0.9262320638046001, -2.1604994039334353, -0.17527762879240824, 3.4081521272967352, -0.5226487038799866, 1.6739398899577493, 0.9677600249554955, -1.5815605379333004, 1.4664623149963452, 2.630024095735049, 1.0140013206879617, -0.5928959893339201, 1.258400369368468, -1.3938006281324866, 1.3430369167436884, 0.3497298394559137, 1.378625973139714, 0.36004899152458364, -0.4764266033009447, -0.0854830957188308, -1.0797877937571583, -0.5944758339206649, -0.22533192179964856, -0.8201006152219839, 1.9399419045721136, -1.6026053821373294, 0.6647083020391004, 0.017653969947902113, -0.41672574310035815, -0.05604572067062733, 1.0492065670757351, 0.4189928912853837, 0.5390969985503686, 0.3025447757942048, 0.8017832263985366, 0.5229572099313233, -0.6201370122785509, 1.6775022379996471, 0.2505373233953637, 1.1785127663393764, 1.0427401490184283, -1.1554651135451892, 0.03283497020794455, -0.7029853113621738, -0.1343312856392412, -0.424580410039635, -1.131453570155085, 0.30069973419093593, 2.340102752636297, 0.6169160422246368},
    {1.2536840050477196, 0.9883945941572786, 0.1061915432125615, -0.06322515442764041, 1.0266387877704841, 0.3321797570675782, 2.235391065744357, 0.7890587981219547, -3.247915928197411, -0.9182238409998342, -1.387879070646532, -1.1040677525333056, -0.30872209196384637, 0.7825589517864906, 3.23538871125917, 0.19555865165353467, 0.48155643710473406, -1.2466958631371923, -2.1001031914780586, 0.17707426204024768, -0.26082088346826515, -0.7146972466759076, -1.5178260858777082, 0.26742273164081376, -0.0034560895645394767, -1.469109712190419, 0.7784376334549127, 0.3501281992367918, 0.45988743269118143, 0.308051920554983, -0.008001527096900276, -0.589052019126792, -0.9627570064807315, 1.8526190745105646, -0.9964694538861637, 0.36441092996471275, 1.1865189212136609, -0.7999060515684063, 0.7577696136454718, -1.2224548324225744, -1.62158144118561, 0.5662957731152466, 0.7774698975797628, 0.690033668860467, -0.602998446027802, 0.7534771194271499, 1.9999807082810324, -1.1523806567526402, -0.37085773529894034, 0.5398708610403119, -2.520997641302932, -1.1358697172643606, -0.9122718709582603, 0.37889106479254475, -2.690373085527336, -2.2747024474467565, -0.877096291229175, -0.9785232570380673, 0.3765686051271075, -1.9665591536264726, 0.061626971846338044, 1.5570302655487893, -0.81394682963177, 0.9007011189326164},
    {-0.4135044489843736, 0.7245897798959325, -0.2999774319838829, -0.7888681817382983, -0.47788695588353863, 0.07566612403242613, 0.3547744037743402, 0.07331043519729888, -0.0946130361213312, -0.8268669064022335, -0.42868677467792904, -1.1319296798327663, -0.07241576170676728, 1.64579503943272, -0.7797534999276, 1.0016543811274183, -0.858298963748149, -1.5665036766782956, 0.12257240354245451, 0.8305912225383002, -1.8989638293247242, 0.7066077837206806, 1.129848392357811, 0.44294970325843985, 0.7449141170227649, -0.2967251597073557, -0.046015990043442305, 2.839280324509352, 1.5409994101276774, 0.23867544495738996, 0.1442569136880701, 0.7612746317586433, 0.48492152412564743, 0.9972397141795837, -0.29735146088893505, -0.7090904500560584, -1.6498191125813033, -2.78832733473397, -0.3278950760283484, 0.9006468883291462, -1.5330693675959814, -0.10281424772514768, 0.37812845218177704, -1.6171007096575072, 1.0569746600308902, -1.278845518909323, 1.2808201095297054, -0.04170440472614042, -2.1372645812022815, 1.6015076301671132, -0.038492188887251436, 0.623773291397235, 0.5138302572190231, 0.11889123088740325, -1.2734429994873864, -0.10716383187859063, -0.016627523662445826, -0.49700435015388794, 1.6938857510326633, -1.4036697365351012, -0.9057277424621165, -0.46631850835939365, 0.31201470187203645, -0.29481766140043686},
    {-1.201759938658301, 0.45581811353628693, -1.4903909059753755, 1.0739792750334507, -1.7861716419789386, -0.9857701376272308, 0.02366757124787076, 1.5011532097095739, -0.08798999242891888, -0.22003574789826796, 0.5512298613352016, -0.3750475859231328, 0.430377562211669, 0.7309696480629624, -3.743418501905076, -1.30788077453046, 2.416314575167312, -0.08109186575884873, 1.129893441932465, 1.551306495953782, 1.348443039803508, -0.03214466061232003, 0.7801609051900836, -0.490269631317608, 1.9685513385493072, 2.189514488853461, -0.7347808288618846, 0.03980294844057001, 0.04246352583994038, -1.3290545711886002, -1.3886206614726015, -1.5766501326132256, 1.3377334111507617, -0.7398323088037003, -3.4746747743269997, 1.1072938702077764, -0.4883950057830676, -1.2284687331224196, -1.4704028506403088, -2.78732552519733, -1.6995412185329706, -0.06950657390277452, 0.24997603600367266, -0.8011943378639768, -1.108470634110827, -0.20250904383636179, 1.54920350415727, -0.12886602679227255, 0.6378568784934305, 1.0669936594633846, 0.29285266202415317, 0.5580316620917726, -0.3242336757147239, 1.0920095387085822, -0.07449342019811041, 1.3555449224456138, 0.5301740835486811, -0.6785992291804552, 0.34003667973804397, 1.609691483794768, -0.030105755373599292, 0.6338072794524827, -2.4855793981600325, 0.5024837621740506},
    {-1.5618758820453684, 0.07439688477023657, 1.0227966277141165, 0.4514629721603568, -1.8751054357812758, -1.8604881917727676, -0.12405262034361861, 0.46497214248380236, -1.6532969349375435, 0.2965494065349395, -2.3858537300028875, 0.2707577137945934, 2.1726791364609053, -1.5224265201081564, -0.06490763455485286, -1.6833300358520649, -0.4765812493719517, 3.1018026968483654, -0.7618751421361795, 1.2492968409460612, -0.31780476891506576, 0.2810463077198064, 1.1308934675243318, 3.2135976973571267, 1.0259383531924675, -0.6240251860476038, -0.4852495908909655, -0.009346799411602448, -0.6242176173759004, -0.5144091489466994, 0.5028550855340862, 0.5121856997335057, 2.482760411645, 0.9505411963068027, -1.192540829289663, 0.6097020312284454, -0.8197776790018558, -0.9010942003333712, -1.8050651477914608, 1.2964363099161875, -2.006902911854507, 1.6753840430410656, 0.6644766039403007, -0.8649832037281674, -0.05368673128424287, -0.8268532544739131, -0.713765021759341, 0.44112382522207105, -0.4555296567816961, -2.404000747965067, 0.1584767804245725, 0.3863410893126558, 0.9804600829214692, 0.8000408482072503, -0.4993285385274195, 0.3477759401003635, 0.7729426887643871, -0.3871875907688694, 1.7620170245249014, -1.1430153721950882, -0.21541992583403108, 1.5314221884785986, -1.2994484466529408, -0.3181763893205284},
    {-0.8351455805889376, 0.6471389026700407, -0.07541414553735502, 1.2617142631512244, -0.3474140738679481, 3.1908019747066856, -1.6154379191701962, -0.7635298205116753, 2.0058053505446485, -0.8546111492608398, 0.9942520353594896, -1.1059327914736985, 1.0056733356236487, 0.313991318685058, -0.7476719502666196, -3.02336724362846, 0.8442087966256316, -0.47590325470078015, -0.1457311870994869, 0.8388696683768403, 0.7776045481827063, 1.6096798254275275, 1.1259989473042504, -0.8152496951283298, -0.8839122185429313, 0.5458349867633236, 1.5983741646723835, 0.1350852158176079, 1.1469826452889205, 0.7038588914216388, -0.11377655628650783, 0.9839681611999725, 0.45011399319305145, -0.48549203606317143, -0.2736065114222024, 0.2814035635068178, 1.4745617289244402, 0.9817558404351405, 2.0728683925698177, 0.3704208972065774, -0.8354850194767723, 1.3951106970022638, 0.6601708664469566, -0.5848046056508274, -0.503876961576475, -0.8547005526928814, 0.39228250506661155, 1.3359749251006592, 0.5707372640183328, -0.6578050951322638, -1.888529396182128, 0.06647469822834279, 0.7224684633003101, 0.9485463176600619, 0.2489849246250968, 0.9410683531155692, 0.5562957099613456, 1.1491852089555925, 1.0163216591563415, 0.3354757288776657, -1.2557990465378521, 0.10984871636883071, -0.3555548364540715, -1.0607324420188848},
    {-0.031428013042654204, -1.5792966273637181, -1.1435204338966134, 1.4361028408889593, 0.3813434785839941, 0.020164148593858632, -0.08686879903004047, -0.6960530137410917, -0.7573643999630639, -1.3651804096922362, -1.9970729054935727, -1.063069460396068, 2.3575031401428848, 1.4371827091139324, -2.140489002701244, -0.9696018347482469, 0.6368968709954789, 0.4386953993034361, -0.30602809924422153, 1.5241248107265888, 1.921001716808982, -0.42177077071390046, 1.6262874851892144, -1.406236101439623, 0.4343265914525859, -1.128693519865627, 0.802013835795311, 0.09316003622747435, 0.6186707978697932, 0.20785754236378232, -0.15252852917353982, 1.0277577978108374, -1.0295017222650613, 0.49028509578988, -0.8533974218174146, 1.4257081040165456, 1.3492843710042726, 3.092473508002588, 0.9251376822352402, -0.3748401643909359, -0.5226818814806171, -0.43279286566517533, -1.3898333625896058, 0.6803447279011283, 1.1409474108444029, -0.07479469955691825, -0.0677544095640628, 2.6846134147089913, -0.8239481510424934, -1.1749801024227375, 0.8552412942435771, 1.7271846301206268, -0.6516059417097979, 0.7429751530397901, 1.5263768041962353, 0.5743826382555064, -0.7350410959963691, 0.6779622943372456, 0.29238548642513595, 1.8066866870724916, -0.05296532879817396, 0.564445436373639, 1.333737813130063, -0.5147840365729546},
    {0.3307204486787653, -1.0584853061192157, -0.30121341141019287, -0.8159877802752763, 0.24696940879514284, 2.1744436737961683, 0.5377255848365177, 0.7359183043808826, 1.7947205295950508, 1.6803245663885995, -0.9499604000552075, -1.0588594215913514, -0.17944073018945278, 0.9869467952106055, -0.944435386863549, -0.12170749192470699, 1.10485663829072, -0.7410017897360712, -0.29431763596474897, -0.31612009687809794, -0.535505485481653, 0.6358637290845822, -0.5303260904571087, 0.782431673613117, 0.4084130336456643, -0.20517522411550934, 1.2592039956180399, 0.8182610396397447, -1.7286584596460675, -1.0565103834103686, 0.35056425600445856, -1.6385581087840355, 1.764430506707847, -0.9350039020470576, 1.2011162977628524, -0.7007222770024617, 1.4655462136187025, 1.2654867964253265, 1.2239690166699793, -0.012268671439197527, 1.0125372429951087, 1.0803246780312616, 0.09492866108641684, -1.0926785082571333, 1.8096203032245763, -0.966170580810661, -0.06663306605300995, -0.22634280118726746, -1.331747224407721, 2.0942158843258905, 0.7331093988389943, -0.2692201457361785, 0.010355344399038333, 1.0322448401243907, -1.457756500651744, 0.995635482928285, -2.40027101548543, 0.8423837891890417, -1.8828614365650664, -1.6591865878094245, -0.4419849560000202, 0.19217527494652897, 0.5684734928756551, 0.10173914019118126},
    {0.4891220669281993, 2.0555991512559384, -0.5203018908543021, -1.4369812945012799, 0.039656007492617364, 0.5879546290218571, 0.39371061841487015, 1.2816479192741725, 1.2969823846993571, -2.0924970233576903, 0.3868765202022833, 1.2880965670191757, 1.531066943814848, 0.38806935110043306, 0.7326209031559744, -0.23262001008982722, 0.07217386385280372, -1.2912388718631151, 1.3494194786371707, 0.6617806322565225, -0.25721425656369273, -0.6291526275347059, 0.4218188723373071, 1.1521379478015232, -1.067451603828118, 0.9504706102516884, 2.6484607078266453, -1.9336994765913333, 1.4082460309664862, 0.08596637651726924, 0.11830308855740099, 0.31057268018990764, -0.5082752835205837, 1.7774353994141454, -1.0785631112243899, -0.5595969519459387, 1.2064715803173638, 0.031198949824815112, 0.4400981407235474, -0.8350345156177684, 0.47559873956755744, -1.6795001628754835, 1.063323069291263, 0.4216982915730661, -0.5755194763893797, -0.40309410540884366, 0.6706386167798483, 1.6279295865541696, 0.09090772017535027, 0.9865798946248315, -1.3891092801474239, 0.42450655325666636, -0.8505024715391849, -0.051517762976415256, -0.8573968842461296, -0.40521926657352764, 0.43940947358259247, 0.9379147536041905, 1.310962498769165, -1.02919768403871, -1.2130421719696396, -0.7241208005842156, 1.4521326647265111, -0.23033788343133138},
    {-1.1876399581575532, 0.23757608157510396, 1.3914606032369037, 1.7118940262722684, -0.46823039935162925, 0.5135221056633922, 1.161546484744927, -1.7814640334196308, 2.46399332979377, -0.26076672196541517, -1.5795480498262173, -0.42588137402884363, 1.471997661703813, -2.0921119645821817, -0.16913804670904486, 1.5145279632671147, 0.16379182600462183, -1.920134081792831, -0.6604578288227022, 0.6446922240998648, 0.6578792851893489, 0.36307038217336596, -0.1562250712369966, 0.25584314497403265, -1.280818198980907, -0.8325689065837971, 2.7776066110467346, 0.20898133171615177, 1.451258184882851, -1.2447372952025337, -0.3277505495646322, 0.9783182795737877, -1.3049609379661722, -1.1434019953124328, -0.21975188292415815, 0.11561484054291879, 2.074115614700541, -1.4064565518968317, 0.021443147477217647, -0.5306472625381266, -1.5966807004593453, 0.8287595202603133, 1.6787700283300617, -0.06020632007664216, -2.2287305633058105, -0.1844787041263701, 0.4953380821331118, 1.9771149446788316, -2.1508840614382656, 1.222469630005533, -1.6384763089674488, 0.6597225977765667, -1.3508440945821114, 0.893224787135538, -0.22013272635963632, 0.6465234010049893, -1.186201444643962, -0.4122688528269925, -0.8120779135970083, -0.6531052987344809, -0.5253272854364848, 1.7542867433129434, 1.5411530088608218, 0.1291689168013695},
    {-1.4133385243277112, -0.11847198344684745, -0.7281913134437674, 0.15202108551181706, -0.058656315829551206, 1.6197546540623715, 0.5973351762273438, -0.7114159046311962, 1.3178425206242057, -0.5026461351630395, -0.37821202984436325, -1.6424498658384235, -0.24855571611720773, 1.3371985178175638, 0.6115472511421319, 1.6243685310364941, 3.4044429536004994, 0.8550639384238286, -0.3450135133381388, -1.4044622994969853, -0.8451558308501887, 0.2895205435598685, 0.17606917256699756, 0.734923191278761, -0.2816511759532311, -0.8942070530322207, 1.8089305232962831, 0.926657472604236, 0.6874793334870765, 0.0836104801828379, 0.15208468542599451, 0.8078488030789128, 1.2544833852401516, 0.5901189981169165, -1.2340724392828555, -2.470094853630173, 0.1548466724979593, 1.1673715233759603, 0.2938246987864202, 0.13801413874607288, 1.8889775447574235, -1.1923736819646802, -0.9968398359123866, 0.7205924401568108, 1.3665126821436113, 0.13226330258088748, 0.6094289653584004, 0.7650907258827419, -2.4632808318860113, -0.9177394677153661, 0.0639031478940115, -0.323654061386909, -0.7830307408953426, 0.5618796837032716, 0.4642861443475956, 1.4421574400754362, -1.4324068571889794, -1.4059330657173261, 0.9775902925049056, 0.2575943836532835, 1.7703048282110547, -0.007764323973633685, 0.23840737904042952, 0.3715966711615553},
    {0.5444898863704903, 0.0192079389004953, -1.756418709805587, 1.0433156238302435, -0.15951870156362244, 0.46311647331128714, 0.04958340855513603, 0.07575671492192464, 2.1067036566178765, -0.023999649864756993, -1.3315686914423597, -1.9939547546667562, 0.2380548921585229, 1.45634047760572, -0.9679414072071721, 0.5719441809800713, -0.27351304810272664, 1.2748420010917336, -0.4128054250112938, 2.933440985643746, -0.2901111291630958, -1.9311953120499235, 2.339979069502814, 1.0135938063495158, 0.34739101622613033, 1.2505198912243543, 1.2756204249418241, -1.012179668558979, 0.6805410756868958, -0.7901376708038045, 0.2358122866264501, 1.2260193938107495, 1.3469166628695173, -1.8056598475353318, -1.8128648033872772, -0.14846116602806825, -0.3173783174287488, -1.827736080998397, 2.4752333197234417, -0.9559476783683074, -0.4482545974809789, 1.0099329136031363, 1.6311613158221503, -0.2219472679655414, 0.17657123008427428, 1.5669257440346183, 1.660797463529788, -0.16648976681786554, 0.7175674211401912, -1.9147007115116734, -0.18764180044868847, -0.46239053633188154, -0.9275401042027032, -0.6179877966054673, -1.3092301033905391, 1.2496601220657837, -2.2223796800940114, 2.6189930154731518, -0.10828015514671441, 0.37320468159546677, -0.3929733891665839, 0.8514463704334413, 2.577898838567435, -1.5132521416877165},
    {1.239582305379307, -0.1992949450431147, -0.12291846412103324, 0.30297804827675595, 1.500074502267392, -0.9900927113537265, -0.6274267798040897, 0.2552313064558576, 0.20873731629928174, 0.617149388403071, 0.2637127468269987, 1.5307044764500053, 0.3971743469708563, 0.16132435939585546, 1.108174363637865, 0.3559904086627349, 0.9742636657235957, 1.3281910566937318, 0.6191525680015861, 1.820061962812888, -0.5628832456157647, 0.18248718457193636, 0.9152608129858879, -1.3707318439953453, -0.15909582380489481, -0.016489301602718495, -0.9320727034478707, 0.9551237799197363, -0.3071838411441008, 0.453272897971959, 0.438651924326296, -0.17478712599921478, -1.169199938621022, -2.064371365342651, -0.17694722336116436, -0.057681738457439534, -0.5473677756716424, 0.052033787285072776, -0.9348431063916819, 0.21219725288993, 0.8429181546787675, -0.09197981737814481, 2.37227210231811, -0.3382195015473759, -0.5380729138351722, 0.38893921781509766, 0.34499163572573016, -0.04289319097588075, -0.936227255961107, -0.19447552497147222, 0.004044168989496069, -0.24058661830798936, -0.7525346360078794, -0.3569385244121238, 1.3557552470252836, 0.24553200498846467, -1.1832158138282387, 0.4270225590592182, -0.7604613470405744, 0.7671197053411382, 0.6944562604113071, -1.4846291908026845, 0.2667996385067357, -0.1513316032211494},
    {-1.482025735738341, 1.3188489506538412, 2.043391728993188, 3.1492498278915626, 0.13686009950498404, -0.9873956025318873, 2.4829866361726385, 0.3213452961201971, 1.4434706642796444, -0.2194202498618414, 0.5416692598232262, 3.439094219512732, 1.7485909902705261, -0.13061451444566963, -1.0382562935243698, 0.507372401577184, -0.8751162417877356, -0.8772956833182637, 1.2043687471331388, -0.2681249984304182, 1.005040805911324, -0.14361433117853287, -1.3050750141945997, 0.9525001482690438, 0.22574175307744873, -1.5993442722598386, 1.9512456028503584, -0.2151420286616767, 0.40437432142251173, -1.1189213587708962, 0.26221548536154377, 1.0629437536280884, -0.6050511909586138, 0.7339687708306859, -0.3521351046615514, 1.344041178701351, -0.9907474886041853, 1.450515122477038, 0.7583659670042581, 1.2810011184100254, -1.451861211670118, -0.4119038840749055, 0.5001055065626763, 1.5785609697773189, -0.13564909375554185, 0.024051654105374607, 0.8875681911318501, -0.950703646817078, -2.5730238856619754, 0.6655947872407993, 0.32534623639915927, 2.4469670611264767, 3.0058657169608938, -1.8388480376711962, -0.39878115106883055, 1.1442483421036063, -0.4079887374929455, 3.3389476003385523, -0.8449728560721401, -0.5881686571660252, -1.0132388608530434, -0.33562481524660287, 0.3721102888366126, 0.569381338745406},
    {-0.2502148664993831, -0.4459949968708608, 1.2922588137841748, -1.3466590208458948, -0.3373748029407659, -0.29565692813361, -0.044474815805007166, -0.33913715798343447, 0.22523356471825257, -0.9341350252910208, 0.9553258234109828, 0.7233029894461648, -0.08633912561179787, 0.18708542772280326, 0.9658623798719544, 0.7800546136816057, -0.9587028904296006, -0.9350062155889223, 2.0647396066935713, -1.2188353213126124, 1.4226546119432746, -0.4126713543702569, -2.6073377836806975, -0.5946158041576322, 0.29936041432184396, 0.3412747548276789, -0.49576879595686574, -1.240991184111647, 1.7494885619697376, 1.797536158859158, 0.415556054586414, 0.5055180525007741, 1.5499580277541578, 2.3133584809398346, 0.3889370883848097, 0.5961724673891393, -1.6349181976860208, 0.40589239102008123, 0.7834887008316617, 1.0242503434105479, 2.03410213051955, -0.04177142240027059, -0.31704578691242236, 0.7100773833105547, -0.6843877651575143, -0.16106994166657976, 0.05600813043392285, 0.4105930438791069, 0.9075087884680747, 1.1939704169126137, 0.45700487129196743, 0.7251484794753645, -1.075788547506475, -1.1603258753361925, 1.0989451538890866, 0.10464616526289076, -0.1215133133820158, 1.0656264495914225, -1.1429600888364018, -1.8082301589325933, 0.20236469893396217, 2.2917796946072606, 0.6337006577848199, -0.08572490836533872},
    {-0.7404223576478649, -0.9093536733610368, -2.1460006129970925, -0.35550861984700854, -0.22142658389372322, 0.0001880412820349138, 0.9900543563507107, -0.34811968038057456, -0.5129748210510257, -0.5235407772164327, 2.060615657883415, -0.723020384065675, 0.4184650342036572, -0.4447346149680764, -1.3498881594636212, -0.7170610877322189, 1.458930807877452, 1.935554618101405, -1.9957406359022336, -0.5454805822905144, -0.068406899178498, 1.4007669011813006, -1.3311974813486187, -0.09542882286579939, 0.7390455154419965, 1.6329328934168064, 0.3569273940853319, -0.3235780324341082, 1.5543252591505898, 0.6716754354712416, -0.2981882935685687, 1.3551198150015586, -1.0350190474443615, -0.7048600688979333, -1.5295365129245406, -0.144345819051992, 1.4601936428929951, 0.31255233464356175, -0.4136100799525419, 0.22119913260558835, 1.4046095012039828, -1.325748830841621, 0.5668111199493931, -1.0079110577656456, 1.2485487158665993, -0.6270674201215727, -1.2095268135024841, 0.9982841900691208, 0.03826854537719538, 1.4066695222865067, -1.9141247943678132, 1.0753743691788524, 0.6625703308845726, 0.7416558729997533, 0.5775460008116511, -0.5458456414042813, -0.6984961342528947, -0.12225398519196413, 1.053793394246909, -1.6400791683658957, 0.07367037752694489, 0.3930769295879661, -0.017714228794106692, -0.46385837576515726},
    {1.9805608903891982, -0.509242612146808, -0.4416779218026237, -1.1397075384948123, -0.23726398609819477, -0.6003076989744442, -0.2582527803217771, -0.749468594509164, 1.1989437790594935, -0.006583762408459694, 0.9871580636264207, -0.9313210942818811, 0.5542976251587229, -0.273492004911667, 0.42805534397038636, 0.06336440357643876, -0.07280334826234684, 0.86142150924644, 1.1369944372960759, -1.1387300850288073, -0.5183191005897108, 0.1998451340922635, -0.019615566148925602, 0.9534679391692018, 1.463657689621663, -1.3578626644057195, 0.4668094705443589, -0.5423987874720274, -0.4838756251615735, -1.8493493233056963, 0.9863673264922944, -0.21751259916309992, -1.4454063473591452, -0.9473610340898494, 2.0770932474994246, -1.7555913253874504, -2.3790193144522616, 1.2865559216417728, -1.1783596343574736, 1.5544068830785291, 0.42469851050570767, 0.23500148913456032, 0.156156330323933, -1.595215247562318, -0.9475404795281729, -0.6157017220718352, -1.6797668037554465, 0.3250598257418956, 1.1891865728420417, 1.1263791337744544, -2.9211931383976126, -1.1125290434717607, 1.684100881990149, 0.2312167396401772, 0.8262596580835242, -0.33122462145359505, -1.5946559048426934, -2.6064097852810777, -2.6916130081161316, 0.8801905498760052, -0.438958955097456, 0.24988312572451138, 1.7600490089968919, 0.987232475869046},
    {-1.3921399039850966, -1.106720812650854, -0.7219584466892107, -2.0397956641638255, 1.2204342065448122, 1.9101576595615406, -2.4037394785716213, 0.5741279441741721, 0.35326968379439905, 0.7028955431006856, -0.31345847982640546, 1.3915203368450901, 1.2134981755630827, -1.9953728285353418, -2.1861229159114113, 0.13403381699960537, 0.892442331500148, -0.18390560576455225, -0.09277218692914933, 2.5460604840850274, -0.504622664890586, 1.0060841526988058, 0.14398322565817184, -1.1904263530220547, -0.676137413376003, 1.8180216142344818, 3.2192462739900223, 0.5154577689986425, 0.5157193723132951, -0.8053101349931434, -0.3253419664459266, -0.5585977322888254, -1.1932161354116435, -0.9059473532146681, -0.9768250793245014, -1.0546661838475522, -1.382112878529199, 0.416411378726085, -0.20245817228355073, 0.38087171221390914, 0.29843528182933643, 1.60701841332538, 1.1676184823903646, -1.1421522231391383, -0.5739717310294987, -0.6490184332073134, 1.5112067431501088, 0.2863944767785745, -0.5110185319651704, 1.2595149243867934, 1.837525398378194, -0.05949012184629923, 0.6797281723380192, -0.4177982142470724, 1.8359174165604824, 1.1504649516714223, 1.0022441841220167, 0.10792799479211461, 0.7632401508954699, -0.4121701607019245, -1.432824406773807, 0.3981233099444223, -0.015486212466239586, -1.5099667955086378},
    {0.4273703644778743, -1.312464006673796, -0.6744335014510908, 1.166839545834899, 0.47877415104691795, -0.7857532487451363, 0.4847589977921791, 0.6434131694540233, 2.4538862288772476, 0.7285621146171185, 1.9288108792118799, -0.48492940846569615, 2.649000019033222, 1.5995773638988993, 0.504319424163471, -0.1736929203282508, -0.3445140544827704, 0.7851065468789821, 0.5483729909801496, -0.27357004941351526, -0.8806467222637803, 1.5014021362793137, -0.37245603866988714, -1.2869982813096235, -0.5955680091844208, 1.0905357795057735, -0.13134288233508823, -2.312532154822317, -0.06448616799993236, -0.6549006251082252, -1.6442725255199644, -1.1815581026948787, -1.2358963568231816, -1.0771683048485619, 0.2678410162585784, 1.8062374906232581, -1.9496884111049062, -1.275009225893876, 0.9666655719808633, 0.618183537174707, -0.42527856205591563, -2.550679964087099, 1.0345699746416925, -0.2377951732082545, -1.95919792448711, 1.1148258122034524, -0.44151960054967554, 0.5946363947844502, 0.7193686585453967, -0.34118366419130275, -0.2661275326815189, -0.10858192885130799, 3.0251912755845978, -0.42085254445812675, 1.2654306390152374, -0.5626046115358333, 0.0942623225297128, 1.3378786858707017, -0.8421328850091742, 2.4448997491765443, -0.8721955035370115, -1.009889870121103, 1.063642469137473, 0.30786660030954704},
    {-1.2528153929423742, -0.7178454204854812, 0.5040113540860055, -0.8487728664153629, -1.3546804491201831, 0.11638876072882808, 0.4681839959144589, 0.3200169283535864, -0.847102994249789, 0.05118841078707869, 1.6099828507826015, -2.0222770378651984, -1.1888534794203378, 0.10093860462385601, -0.8738087101711293, 1.8041225856168361, -0.325728468893331, -0.3027580913297323, 0.17616119729059346, -0.6511874673671701, 1.7310499322076969, 1.3963963546414049, -0.9736666768676417, -1.1254620796933914, -0.05371309670419738, -0.5485947208584041, 1.4806835660065358, 0.0947755409229548, 0.5319309831385441, 0.33449438431510436, -0.045254854571181655, -0.43538740815992505, -1.5794985935521466, 0.8153013316888957, 2.61234080236196, -0.004422853156856794, -1.7540431048185732, -2.8048833785210254, 1.003392602827933, 0.38511820796534413, -1.8562899703561275, -1.1102533347404284, 0.13744311684436616, 1.5128534756088903, 0.03452752650084073, -1.3863794541622936, -0.7593149552910884, -0.3098250528188805, -1.4626384512786967, -1.2202355077774585, 0.20236725724208338, 0.6753338396998013, 1.3120994952294416, -1.2310480461980804, 0.17701707668709624, -0.9027347029315267, -1.676954501986321, -0.2702319152580318, 0.07346037291099893, -0.9558289358882265, -1.6827343431883663, -1.684868562383228, -0.3759107465898808, 0.5578783597996704},
    {-1.6152567448416866, 0.09171920875724947, -0.35012202717262636, -0.7898071060556007, 0.15857351991432098, -0.18304488162943558, 0.5299438186038472, 0.7294617989977322, -1.8202362947832214, 1.0583403287779598, 0.5079958470326508, -1.095077114088754, 0.8895951508834441, -0.358518459405848, -0.04075647758730889, 0.15767551607936023, -1.9178053553816332, 0.5955048792209174, 2.1323329849410566, -1.978746668868899, 0.2560920126741645, -3.2019322533561816, -2.6196841474329498, -0.7725253582086415, 1.6556343019945807, 0.20066959761170847, 0.11070220264966708, 0.5611412376562912, -0.16679415147854812, -0.006424974438178824, 0.023947564088586313, 0.37993418326763323, 0.19349710435408773, 0.09998613364422741, -0.7881213594800901, -0.7584647560431458, -1.9838995621033406, 0.09483834677081107, -1.3566289409711076, 1.0848614425137464, -0.9907867217005907, 0.8493836693441047, -0.6856666328097752, -0.6224500226929945, -1.2934675543198026, 0.22537405806308944, -0.07094738279817872, -0.1325859062985553, -1.2436489265175832, 1.0955649807630006, -0.6350211309626715, -0.017648941874355832, 0.7127591505039022, -0.02783380088110655, 0.14163228266713565, 0.06171217690803414, 0.17784531381149804, 0.5402048576203616, -1.6087121827351205, 0.6880242475604874, 0.418843191640813, 0.30550301878805736, 1.1662329442544777, -1.022963302339887},
    {-1.2582948167622656, 0.3031094343804658, -0.6717285785212043, -1.3883745084884758, -1.175739106891076, 1.5794353132017613, -2.303975829699823, -0.6387935631636891, -1.9266107042564795, -0.4380846285076609, -1.566567234605081, -0.6443835926447888, -1.1494803449645508, 0.1280437605762489, -0.8881253358278953, 1.7642294128876461, 1.718564282429812, -1.7054208049985031, -0.922757951150555, -0.013483601802015948, -1.0291993915515552, -0.44657202124798806, 0.00701600242948807, -1.4201628529651842, 0.8220543393576666, -2.4196933151397, 0.7523881359987781, 2.42684609535043, 0.33398243920108617, -0.943032902845935, -0.6324263962284411, 0.6223985610558795, -0.3042036405080175, 0.8815116527098683, -3.2108174457936305, -2.0217792904861804, -0.2064962205260978, -0.0627733413845173, -0.30891061662313873, -1.7620447489644318, -1.4617568291992942, -0.7050007405794371, -1.381734512875181, 0.671116432833428, -2.181508811943127, -0.3662849028123462, -0.21431588140148888, 1.2770322485191858, -0.8410980306257582, -1.2497441130102056, 1.5095994550158716, 1.0511796536065656, 1.5557710019572815, -3.612888303727582, 0.21579530147174403, 0.9755503965954242, -0.4569670206755346, 0.33544157710732514, -0.27167144767516377, 0.7258653532152334, 1.3693200266704353, -0.3707537581041915, 0.9242051741523065, 0.2805521921186768},
    {-1.65673874403855, 0.38356448048844155, -2.466779444783879, -0.2106190733350812, 0.24496380768649628, 0.2648425171553455, -2.3132051034640537, 1.1877855861471984, -1.2156355761381918, 0.2293887238208673, -1.2584456421204053, 0.011907372361369954, 1.5155140186250646, -0.133234801582479, -1.6228598285010916, -0.15514001152122922, -2.624365165212315, 0.0015210754514792223, 2.575624230824164, -0.8116097910729287, 0.7257217723397567, -1.1313271354514989, 1.6757078581904892, -2.4091277672263733, 0.2646922537146817, 3.1072416739924544, 0.3592010527981929, -0.16585504496515027, 0.6797366910213244, 0.07481395750008396, 0.2993836188330161, 1.7581258575569951, 0.07105151742434343, -0.9127869447660031, -0.30408703339792725, -1.9230653771366353, 0.03158836410659156, -0.5253227116223349, -1.4057285041065857, -0.5801901442958617, 1.6778143574093922, -0.6242579702293314, -1.2687702913511796, -0.700409522935059, -0.19902190599258712, 0.25286114106718954, -0.7130497520239825, -0.7129725269314786, -1.1002124251476626, -0.12425678398092625, -2.367817695468498, 0.46317593420418784, 1.6040545565367543, -0.490959766852349, -0.24013280598733625, -1.9176487090862946, -1.9938466876211212, 1.7622445143481718, 1.2816030803565737, -2.1621977131311905, -2.5205359588973217, -0.3734173360216024, -1.2405575314898547, 0.7783454382300723},
    {0.5431851899836926, -2.167601095793663, 1.0883894871364752, 0.29233261449884657, -1.167380774411883, 0.013684423478688446, 1.1553021589437376, -2.4196892965589356, 0.2907753455885204, 1.8345070391950766, 1.6578297882057826, -0.9963793711890655, -1.0524379235497052, 0.12070358955634362, 2.3633814564226845, -0.15535314868175956, -2.1397751746809353, 0.21668765032284137, 0.7130468928979264, -0.984932249310988, -2.0639839190645666, -1.4322622628943695, -1.1583969321957783, -0.5371500384766482, -0.54081154850317, 0.7881780483498783, -0.05025951385669373, -0.5161291471911962, 0.7680336633651953, 0.23178375473539586, 0.18954060409840695, 0.33819645424933875, -1.3487483467820152, 0.35843271194873644, -0.05842592555660178, -3.1673437069521415, 0.7150687809004189, 0.3686218768614029, 1.7762816633583944, 1.5026317544167378, -0.680855173306877, -1.3727140536967868, -0.3694007516319595, 0.08214736832595179, 0.9444688707302077, 0.5205543572048941, -0.48442247900591695, 0.07009611352677339, 0.6888245608351886, 0.24023726088643252, -0.6332711528995076, -1.6154505030182227, -0.42776941565413307, 0.04619847446981897, -0.05965655048884859, 1.510586810314955, -1.2855526068531098, -1.1551092210879206, 1.2679878101877597, 0.4463340160276501, 0.650666382480812, 0.5170425620945017, -1.4535661537964049, -1.8094780750751158},
    {0.19885580249549795, 1.5589310471639588, -2.4113927024707267, 0.9769593413021187, 0.05516590937081015, 0.22856100360332313, 0.45394040392132035, 1.050114473264256, -1.5715256165166227, -1.1492364428656394, -0.025816469376326406, 1.2417981888242178, -1.6552125652519398, -0.1872876672035004, -0.14444015595820728, -1.0967789196412725, -0.14309793102087012, -0.39690668277379815, -0.19669333745825518, -0.6850782049085617, -1.9083040026762326, -1.1422354401965666, -0.14365269020902793, -0.43153159884959336, -0.5212569952093481, -0.3511767137876054, -1.129651574940622, -0.7561175813626704, -0.4269494386888468, -0.5944972878640786, -1.2756888753644295, 1.6783091963224779, -0.3812416466398017, -1.2444185907111078, -0.8816129959863152, 1.6135679569009753, 1.417094128137808, 0.8571030351820396, 0.5314760742970873, -0.2777880444543533, -0.2701539187897886, -1.0879473246816713, 0.7782889156467099, -0.2775047259019321, -1.8068955714556527, -0.18811509652937064, 0.19984069760942105, -0.5027682874621219, -2.570073645424114, -1.6866531529033308, -1.0808309807344665, -0.22651984497181923, -0.1819561087023874, -1.0250862266872114, -1.7045569962203946, -0.3436299670575496, -1.4707125343725909, 1.2124132119450421, 1.002057802221852, 0.0796493828704229, 0.8374887576818321, -0.9987325725221153, -3.882650873713482, -0.892497416798378},
    {-0.7122512833471226, 1.8992382748995666, 0.5066198924156102, 1.8174188869710652, -0.9049330647793996, -1.1567632815868765, -1.0215163254715824, 1.8577780064757248, -1.6810237361490197, 0.26756412193751705, 2.1593474403813038, -0.7443771852729856, -1.1328701191194794, -1.5352105420254305, -0.8447674822263762, -2.16792662402609, -0.8253243349552755, -1.1187750543362285, 0.5425864497325525, 1.8613078742998697, 1.2602254863318327, -1.7509807118341993, -2.31770385496317, -0.12115588887783117, 2.729482223730503, 0.9959786559870228, -1.618604211737099, -1.5003144037215639, -0.16558191450531515, -2.2018273948719345, -2.3692255019699813, 0.5459123667075827, 0.5133680975309595, -0.49299815202099234, 0.43034118356935525, -0.0073939121044738895, -1.0238559309052706, 0.6965946955486884, 0.20478982518655517, 0.31992293223027307, -0.8606869402671486, -0.7931937146581225, -1.3456334365007632, -0.35804387249082487, 1.4556965673957327, 1.6595268028595962, -1.0874611207550242, -2.3641686228814507, 1.0729172801802418, 0.18152995879800587, -0.836600885291783, -2.0389258671507133, -1.0720785903009675, 0.3585752934821841, 0.1239742238450592, -0.26630284407830684, 0.6971677919063136, -1.2624008068857442, 1.2892351947206653, -1.7883778539997548, -0.3110199016919881, -0.6451365005141451, -3.3816559165140583, -1.2059687642082615},
    {-2.659460201152364, 0.4595407525688261, -2.8899578357475995, -0.5715306657359998, -0.5776174223907942, -1.5508688648349411, -0.44738971585438025, 1.2060824950678237, -0.37667247237130846, -1.184622263569555, 0.4172394611826424, 0.06772299286549156, 1.097275694189353, -0.4942922426282289, -0.4412123091316917, 0.13429562959862226, -2.4388596582313924, 1.228956535301343, -0.19323189806066401, -1.3267484370410363, 1.4013575674596803, 2.433964499687499, 0.04213755866436409, -1.5186155190957682, 0.8305212193623845, 0.7185869187660855, 1.5086655417196106, 0.1671692330493152, -0.029796329609427918, -0.5337356471291479, 1.9269615430566056, -1.2103305562835702, 0.9578851933299741, 1.8755299864927615, 2.1213585254084673, 0.5306753430279212, 0.16576057567759245, -0.6365292011583047, -0.3003897385371991, 0.1443029764065864, 0.7538883880861896, -0.3223815985710563, 1.3415247949495968, 2.173440841349167, -2.375196219681497, 0.3852442975821755, -1.207547020295235, -0.1574384341576046, -1.6169985473921495, 2.130945704940344, -1.2455233377614612, -0.07077350371452244, -0.3206417212641918, 0.6269621423004074, -0.14949210078877515, -1.9597105100879801, -0.33356827054022703, 0.8607789383329582, -1.5241173628994285, 1.6741820643063197, -1.6801539133303773, -2.008069453838572, -0.043914363716332123, 0.31569488180913763},
    {-1.4109873011860077, -0.33492276845055735, 1.9954384922151092, -0.5209559391215512, 0.49222572676076465, 1.9233061099833573, 1.597082808955946, -0.9074554699051284, -1.1822344060799084, -1.5073195292322463, 0.8367505251463684, -1.8699964689818813, -0.4827856310753726, 0.8859897096853302, 2.44189680359717, 0.5081556136597831, 0.4606305613114336, -1.2257048609545274, -0.11040705010247934, -0.4252151501307018, 0.6021285475720065, 0.13526349738756804, 0.60766317273575, 1.097613045633313, -0.43061510680044657, 0.11100933175760846, -1.737483199884439, -0.2898192979927012, 1.2931893000900097, 1.0765484556263263, -0.3512756237751471, 1.0066499494165813, 1.128165969023783, -0.47651751730313097, -2.1104813875009962, -1.2859923531555975, -0.5148194764212545, -0.8478303290772147, -1.2430804665022301, -0.7382477249484538, 0.05456191348948998, 0.5235560246460923, -0.70680395019598, -0.001400352551117251, -0.7444889975545431, 1.458596036025415, 0.11663185617157168, -0.17253963015589668, -2.6842067584530596, -0.9579021391696045, 0.6029037647845079, 0.7528227212495819, -0.15318035195233928, -0.43915747985270226, -1.9659933741979607, 1.2002162181449023, 2.294949843200651, 1.2176859342672266, 1.0203090917291517, -2.2539637480611106, 0.6801696306587662, -1.6661714624039345, -0.1000970932232185, 0.006466757607957851},
    {1.1337046717904886, -0.826332794701436, 1.8883931858832457, 0.25577778126148104, 1.524763188156679, 0.7754408002042783, -0.604252785441436, -0.4016319193887708, -0.6730784633819245, 0.00651383871111749, 0.4754903606467155, 0.5793720330151482, -1.3700751874842494, 1.5557819529518326, -0.9815467053149703, 1.2533393155090853, 1.0319599565497481, 1.6030874968385673, -1.6264431753871633, 0.5956190932807183, 0.6810293843788237, -1.7719925632213165, -0.15584537367979023, 1.139339280487767, 0.8943614357737707, -0.9894006620792061, 1.4453332890422843, -0.13373689540484388, 0.35992352973820413, -1.0985128373242588, 0.387771928037457, -1.0275171877511742, -1.3621886614114425, -0.7396251589214528, -0.08660998068304225, -0.551387278266354, 0.05517648252339803, -0.4702342812670984, -0.7549226711236596, 0.46798453430678144, -0.3680737848833862, 0.6703123112231409, 0.6864202033257527, 0.8069347424679796, -2.314133557642046, 2.066877976897852, 1.7799588386525635, -0.324230718648351, -2.1205538992445074, 1.3098064974506995, -0.8952645393064427, 0.8953535558918249, 0.569035375159196, -0.8487522257950048, 0.8960621882834272, 0.5774540016244186, 1.1747638458167493, 0.45248483574363446, -0.45762995672912943, 0.05741843528479881, -1.2208362920994282, -0.05013961911973228, 1.3106966916316996, 1.3564635538841032},
    {-2.47304139841065, -1.1642041833048857, 0.9679624299056532, 0.9014888862441293, -1.2310679490870464, 1.630972598728647, -1.6455449737217425, 1.1588530649279363, 2.058362778261269, -1.2988901735699383, 2.687523087659293, -1.0377986582426084, 1.3046132397543044, -2.316392224174692, -1.6265549023381578, -1.3621842430026807, -0.006693146941193051, -1.1176561693292795, 1.9527088709492788, -1.1741097333907073, -1.4651902700984716, 1.5236120881139046, -0.7504346770886091, -0.1027337673977887, 1.9841729700403035, -1.816393401389519, 0.4474243238363532, 0.15746896823008386, 0.0892047501150842, 0.5784654668727143, -0.45251099923915267, 0.33008061154271023, -0.12323467976544264, -1.6989355366217498, -1.7469632703215743, -0.19286355433176133, 0.5246708341638714, -0.6908265580255617, -0.7321816885497575, 1.8513002840831811, -0.04277251992767305, 1.5128863343001766, 0.6993970413075388, 0.8309574496839218, -0.7719083212661451, -1.2002520103182424, 0.5938444788099141, -0.1228300532459962, 1.239744554055448, 3.331810790357765, -0.4813492788470209, -0.9648701859790481, 1.0736605797450367, 0.5375294952697952, -0.5918249460316362, -1.6736346954449262, 1.548363606782576, 1.7976973251529798, 0.5086282865760718, -0.19386649125948516, -0.7428282484995682, 0.282546892266811, -1.1578151092886328, -0.9886873514079216},
    {0.35574580137052647, 0.44767953771155206, 0.9622717972574945, 0.06081274662087318, 0.2314499899258374, 1.0356387799169091, 0.8441642018289576, 2.003879032036571, 0.37680045808048174, -0.9244510833592104, 0.7678126593698288, 0.9216702929932428, -1.23486859493867, 0.9063091867973686, 0.7960716877434433, -0.8474403240801113, -0.44936329080434306, -0.031217770265917762, -1.3511040545845103, 1.423834772620786, -0.3914176406039458, 0.03447629164188966, 0.5066027750353249, -0.5770983114660222, -1.4192385421712415, 1.3746455426628794, 0.2864611411899845, 1.241675149254694, -0.2911762263404406, 0.6478783093263761, 2.9392471301510414, -0.7934632211509114, 1.9217845184177627, 0.43013215321403686, -0.9209780890039597, -0.506477664946446, 0.8151368591640222, 0.022922115655788815, -0.2953687556790096, 1.1441789539301552, 0.6533726755947583, -0.731462620156742, 0.9130248625384708, -1.1587774954877885, -1.3625907093806533, 0.6400610024120026, -0.9227688807749004, 2.1832068616470908, -0.2322700894609583, 0.11485473863329203, 0.6341323955606119, -0.2351966735205531, -1.427125624359211, -0.39918799913654973, 0.2305636613027461, -2.0174376942129366, 0.4323441972969352, 0.40652057554182713, -0.49281603803325574, 0.14877645380251278, 0.6529651094958718, 0.29327012921717543, -1.8454827397597175, -0.508162971991498},
    {-1.7579268734441214, -0.3151950309298558, -1.5884931018095405, 0.2436526580505229, 0.033622773120484596, -0.9672747641735957, -0.5665832669350724, 0.595189183820319, 3.023330317086771, 1.7324452860052972, 0.850818978186087, -0.9758145611860811, 1.267371237708943, 0.5793991739609228, -2.5777295439598986, 1.5806758070088962, -0.14349800482548575, 1.5766633188620323, -0.5650639303595092, -0.28718481433722054, -1.5504712341348645, 0.06140761980571882, 0.8098566234293834, 0.6025962333198223, -0.7802734704857209, -0.4722404022951302, 1.4641530082334542, 1.5560644843475742, -0.09984755360800572, 1.1458386225717436, -1.5629664806944898, 1.6601416854800601, 0.22281562318280979, -3.6533183045238076, -0.5703255545121448, 0.33889660358305346, 0.12591307422091227, 1.3828351454270127, 2.184321017192412, -1.7073604314150466, 1.5377635009250408, -1.420653775746084, -1.3578429823450926, 2.3262651686868585, 0.024813504928428667, -1.7704923961183112, -0.6261839341860156, 0.8991176762662165, -0.2082015281947498, -0.45443455045593567, 0.4733249276397339, -0.19023339957387475, 2.0103940734157946, -0.4035086064067244, 0.7784952035049767, 0.7099022515469289, -0.6022148583309274, 0.4863957622217084, 2.1146767890748066, 0.9028490667760584, 0.7812708672225922, 0.9837058510864201, 0.4758749014234647, 0.6795172185626603},
    {-0.22477918288906434, 0.5472041694903885, -0.5364898047150137, 0.23912710114671498, 1.0709612455445638, 1.0190171421267578, 0.48862404800403153, -0.16343559674223174, 1.462173210154037, 1.319525291441302, -1.621856623009794, 1.3436513445550717, -0.20143367845028565, 2.6305288914607785, 1.54478341618628, -0.10026983970102148, -0.1869614021748171, -0.4467223774897337, -0.6128193201773002, 0.342384907377058, -0.3621945106504914, -1.1337296590444732, 0.1697458771618359, -1.8321128883488826, 0.3050446712993569, -0.10415157589590772, 0.18049839887238506, -1.935792473207471, -0.5857963747069437, -0.7382791597791561, 0.4701896976190142, 0.9339834009220378, -0.3796474759552181, 1.9218460445833339, 0.5815950675332056, 2.598700938222351, 0.41664453216531855, -0.11354212456260358, -0.026577044871290034, 2.9156884702643078, 0.9871862999864789, 0.29004771601550594, 0.8879886615505042, -0.6755013764149315, -1.6904270523258735, 0.43258330071534395, 3.6637421359759257, -0.45644204045470005, -1.3518872662060195, -1.6293140612952668, -1.33160147742935, -1.2647978675225744, -0.2792835965904443, -0.7562145856428142, 0.6561497950548676, 0.13837657056832747, 0.32139662048669326, 0.017064302781205735, -0.07751692939292491, 0.05872867040941318, 0.7088366591340657, 0.5560113981040263, -0.646071445424513, 1.564803134456887},
    {-0.7124515744035164, 0.7643645640581258, -0.5536336852706992, -0.6683566760571683, -0.015396207277654622, 0.23616110145256808, 0.5419310991529305, 0.24322543694700355, 0.6296585229238368, 0.9990685670322882, 0.9434465055136754, 0.5788804986445353, 0.8356236617061011, -0.2240912906179818, 1.3867279604961984, 0.9163722498761111, -1.5362728652629751, -1.5694192925082529, -0.37339350510935926, 0.06663126454523366, 2.1113302262073343, 2.109031513980106, 0.14397262037170877, -0.5955972916584336, 0.5738777998939216, 2.460693082629274, -0.3245138069225249, -0.5783101251829293, 0.1242673652066631, 0.8841941570182414, 0.416641359513782, 0.1799913965276722, -0.9140916945961698, 0.23027852306496668, 0.08705397006760689, -1.5197010244876543, -2.5267756479830576, 0.06706799324392593, 0.255233629659109, 0.6407194511157368, 0.058996005595246724, -0.006930970483162667, -1.0123641126361715, -0.3514656020470259, -2.4555533363402438, -0.27330118165165634, -1.0719673534452185, -0.30633478827485405, -1.7526401640670815, 0.5232571580449973, -1.4411824986958701, -0.4326778523941601, -0.43139705133865547, 1.496068505287104, 0.3592940236983033, 1.8789058088588897, 0.29220856237574205, 1.0836101487190801, 0.6245443514518533, 1.5335041275797168, 0.16494277710736038, 1.221957264176769, 1.4536455537754573, 0.7572597290608823},
    {-2.031493685717116, -1.137834364098228, 0.04221481432070453, -0.3909178524879824, -1.4358520375600559, -0.4020303097539461, 0.8771225978159249, 0.10606293842912752, 0.6959914312815182, -0.8487679617443371, -0.6121502872624071, 1.8375895078210995, 0.7996558890852533, 0.5032529726506318, 1.0879637019948412, 2.336992001203147, -1.1009328004428354, 0.09949857719571323, 0.06271909987779349, 0.2796469097879053, -1.275674677058757, -0.33264050385113064, 0.3762577971690492, 2.0676267400549535, -1.0957357177649891, -0.29231040389066887, 0.5373915329163055, -0.17700912657317822, -1.2218224220345295, -1.2221216291165309, -2.1107841978574067, -0.9475065630737073, 0.7719366427618282, -1.481640284723157, 0.615360560019449, -2.0685356295152606, -0.18986303367323382, -2.8070541288754, 0.017262234358564974, 2.436285782369018, 3.014287042023269, 0.01130796897339942, -1.190798488012594, -0.30274950714345505, 0.013179244401317234, 2.116196076786501, 1.4134779328580545, -0.7585767125667475, -1.095328974659188, -3.379399481556184, -0.9042393918692696, 0.7371562533218027, -0.7405176222895139, -0.6976056986791475, 0.653888758958263, 0.9303423416274403, 4.073937556939125, -0.7192033045202244, 2.398675972500888, 1.0082311801841661, -0.5234284000134072, 1.8226522012887947, -0.38105288939791443, 0.12366027527728557},
    {1.0481362955430398, 0.08277282399250496, 0.19664867042747333, 0.36478616105796696, 0.9903117747355511, 0.2550620817992722, -0.2603549274916899, -0.9256186208134244, 0.788116371748529, -0.820882542997981, 0.09840102092552928, -0.5785431535520221, -0.9825316180417235, -0.7163641081676242, -0.813757054291135, 1.8633516216192427, 0.7064320151228708, 1.7025632635666696, -0.8371449502798917, 1.4082221770222665, -0.4158809328855079, 0.11328774892800637, -1.0839805957233728, 0.7184856543845365, -0.129972467787936, -0.18166939140286606, 1.1217667251466217, 1.511358946895329, -0.847604640431992, -0.028137204920070685, -1.416483636151316, -0.19503298539185396, 0.8420989116551866, 1.7157567752532126, 0.8423107116761256, -0.36876659515242355, 0.6499811021874566, -0.13603432486406974, -0.41958990725810225, -0.24209804532057205, 0.5579400177055406, 0.9000102528934101, 1.9298131307624957, 1.5311377590038897, 0.9487313898785762, -1.5282775278197096, -1.2871349971472508, -0.09149548426457087, -0.23412868578026638, -2.017333421393057, -0.46405224821215235, -2.0245010249554842, 1.8316693729238505, 1.0236809625214118, -0.19186446455003422, 1.8817677581977272, -0.7068711329895264, -0.5313428977567972, 1.2067517696680894, -0.7311399848403222, -0.677142828119589, 0.43063170404662104, 2.1207887729384147, 1.1163800964793227},
    {0.3249611733192871, -2.8686481278901232, -2.6659531597522714, -0.6439451199312755, 1.3746506338916835, -0.11714522445537782, 0.8732664792239965, 0.3905950972349929, -1.4252758277086421, -1.4170914297988921, 0.9321934473737254, 1.4352914387078555, 0.034523822345714036, -0.8851922802704285, -0.09678794435931036, -2.9577351587255962, 0.1759336195561519, -1.1056567649206606, -1.5779482857670046, 0.7649397327064208, 0.08531769623262327, -1.0358424120526089, -1.3713704486052156, 0.9176342118252949, 0.022026024066147034, 0.9322345142150801, -1.3298819305650293, 0.46784024010969083, -0.31003799817611283, 0.10416487287020121, 0.5529641717732535, -0.13765115186302845, -0.29078415860096063, -1.4267408497000662, -1.0047226368976494, 0.45672619017341154, 1.1079811908001849, 1.481622766025349, -0.29152676601642924, -0.7130023724783326, -0.09097802090044325, -1.6698891818471806, 1.538517299504722, 0.7805074694104238, 2.5762152564969893, -0.6468196999531317, -1.7884847186136403, 1.9345081248816627, 1.3214520020868872, 1.4109307118497183, 0.7204104156054081, 1.1986593099243255, -3.0510648732134515, -0.1255017673352897, -0.3779778492684374, -0.6803043762288291, -2.5718778250110255, 1.1042922515304827, -0.35487268349683065, 0.6593009039349014, -0.7152285042069321, 0.7188755696648594, -2.082417831318841, -0.603181031441041},
    {-0.10150390071087456, -0.20440935511465397, -1.0124890872455643, 0.8084117743490573, 2.134938130831086, -1.859020430099327, -0.4039431493970223, -0.5770081546921094, 1.4109457961635008, -0.7629148354702888, -1.0682732005364926, 0.518566043242072, 0.20562027840075914, -1.3705229565683619, 0.1530221264759271, 0.234528240505313, -1.07170291271742, -0.013248280274348784, 1.131715117898981, -1.734607405563903, 0.8732771180182326, 0.9126925634346842, -1.0220699531289417, 0.03915312375758423, -1.5433254602167517, 0.5929065238088727, -2.105221580552245, -1.0842732921127707, -1.741362806679822, -1.0592999731209496, 0.16963423071326147, -1.4668574619279786, -1.775715973810408, 0.08419270289316362, -1.6756328092886217, -0.30525004999377026, -0.12522245197507087, -1.1004290283338687, 1.2354629977626987, 1.5262148569457668, 2.082699333799963, -1.1224393770285477, 0.14030886338366286, -0.49046751782737363, 0.20298414133985457, -0.697065009979806, -0.12284700462941897, -0.6248345945411472, -1.308644352458479, -0.8177416743620516, 0.8733287660631279, 0.9134566431090321, -1.874078842141657, -2.0526870384381195, -1.2325768934050594, 1.3723613645698303, 0.8709754006805601, -0.1420858051696008, 0.8219211063651658, -0.4086639676011239, 1.0519212444837471, 0.26044139943273303, 0.9633855751633064, 0.5885004929845806},
    {-0.6204516719229265, 0.10461762847827386, 0.663322976537418, 2.65478368927588, 1.4082241542507543, -1.420652158179394, -0.6347100124148571, 1.053020414397122, 0.6458565655333529, 0.4553039649163397, -0.2229399229884255, -2.733373746950399, 1.7171665721234473, 0.0605065867995736, 0.07102071579927799, 0.1890394847457452, -0.5022434446955575, -0.1735770350107511, 0.554608485667899, 1.8613667525593325, 1.1553470123026068, -0.7519924670585044, -0.8886384718253763, -0.9485261642152633, -0.9011600876286908, -0.22535460916474315, 0.31120993453300755, -1.46180075251319, 0.7657147086280733, -0.724576270149737, 1.174660684867204, -0.1430209987604231, 1.8779809271361276, 0.13074699463875922, -2.7772520851497364, -0.5236149508640511, 0.02110800372830022, -1.8033051378915348, -0.32172447317176517, 2.2956602322312416, -0.4407318846096213, 0.20072823432424253, 0.9164965877867839, 0.79661897481781, 1.3920769605426242, 0.3888933744792009, -1.2966140067673075, -0.18137113726338738, -0.28540226194908214, 0.6800097970075961, -2.3007175048567237, 1.1056790314007017, -1.9051919261112669, 0.45681590051437737, -1.0673672492611752, -0.2626467426332301, 0.16617773306063136, 0.2633755150051418, 1.3285524310563313, 0.20206042149484169, -1.0015154706457798, 1.3612924946879108, -1.4689458640744528, -0.04873211624505093},
    {1.3702126177991487, 0.5047191783133237, 0.14791130365271324, -1.3988665362129908, -0.5543772099532951, 0.4964533800129811, 0.3612648510127962, -0.5639988219831188, -0.3760273191663612, 1.4117754692218054, -1.103675297152053, -0.4700528162141364, -0.7229640243213045, -0.11550729188400859, -0.36531523991365245, -1.2379740482440706, -0.4283726781373342, -0.04529739700086715, -0.8506003447993521, -0.6808565347351193, 0.7765576207449599, 0.11842567867866674, 0.5677476827385379, 0.27072647485373436, -0.7382818681927258, 0.909671289181635, 0.644825669809159, 0.10212861726393556, -0.4114859520887101, -2.1138375677087735, -0.1539863835733599, 0.5796636463006616, -0.15838505471071837, 0.17133121041808724, 1.0274068689574423, -0.977450479480442, 1.623499719797019, 1.367478802878861, 0.3451814519116895, -0.8779124298602153, 0.8637985587544502, -2.6885335402193684, -0.14004180233552765, -1.8820605344387986, -0.38234868182857723, 0.1655054364608591, 0.1806234360512601, 0.7631603128983531, 1.0281991116352702, 1.4829564367552113, -0.8169344172383829, 1.3855659633501507, -2.0571788948398595, -1.4014814588765325, 0.33389470357599416, -0.4965306108766924, 1.0553421329700747, 0.34486834565181973, -1.445640698301361, -0.17991763299509775, 1.3165843876823065, 1.2672881759279961, 0.6277216875882531, 0.9718417221296597},
    {-0.3690347481826813, 1.1476974219948202, 0.10713042829848479, -0.19789378475027838, -1.6804682821804218, 0.20743961431695795, 0.12454750530849742, 1.5516937635050767, -0.3590622176576961, -1.5579269096698647, -0.08160923685041675, 0.5552500200594873, 0.49794316716292736, -0.5150435817681199, 0.9697387866110395, -1.1117193024031535, 0.7326637979750835, -1.0167156207458712, -0.6460429849140731, 0.4996443933489476, -0.11287542894016635, -0.7765840484108281, -0.8362598437203147, -1.0238701694823304, 0.6949203800992338, -0.8308458981101686, -0.3918634911208933, -1.5018790050993631, -0.5997140251849734, -0.9637414691146695, 2.715015277191821, 0.6616753204356236, 0.5106686541866549, 1.1426496034568294, 0.4823945551350384, -0.10297082499033547, -0.6976677077936748, -0.31674825862833594, 1.6939170170372282, 1.0537751132750657, 2.2353031594928625, 0.7101501538361238, 0.6386274345345819, 0.38258036611405266, -0.054409752465476975, 1.3658536166345732, -0.4807615513294449, -0.8234573359997527, -1.852692282045295, 0.005568524272668457, 1.34927494468095, -1.03831493439121, -0.5840766762962163, -0.441660761058581, 1.9401079719137286, 0.23099212908720426, -0.1597908356056635, 0.2254617010791089, -0.4466150154880368, 0.7370676924885227, -0.8304039521576355, -0.5277849155594091, 1.8377103411021898, -0.43780843121944485},
    {1.199966405143766, -0.3918830306972195, 0.7946041239598812, -2.12877537156514, -1.9318596690187806, 1.930198471933697, -0.25919788932462795, 1.546167050661476, 1.1957587601790427, 0.31871092654469885, -1.0011786717349644, 0.4103835509557317, 0.40436303010668195, -2.40129714176279, 1.134209029280024, -0.1546277944430151, -0.9992683420011845, 0.09032596003431913, 1.2307688712003766, -0.544359821099018, -0.13075454528198194, 1.4034555718306867, -0.04652694978961598, 0.3320246686964859, 0.30179596531552644, 1.2054932475107154, -0.071235805921357, -1.4101652939193507, -1.030166040980003, 0.7532637426817839, 0.28776642520167073, -0.6741568157595081, -0.4968927929646671, 0.13925004572404498, -0.7059154962124847, 0.17229844883589793, -2.6599440258032137, -2.0653845060504987, 0.8044140182712483, -1.542019413377374, -0.8275938863793528, 0.6388676421358782, -0.9916119459848283, 1.1843594318100399, 0.37888272969422326, -1.2919265196902703, 2.1517633506067506, -3.3663055096214287, -0.5139526970185763, 1.178131438941761, 0.6884919474700635, -1.0946202142650239, 1.734578892518003, -1.0981588653778227, 0.37251420862166135, 0.36233148064534654, -0.008516277580439399, 0.047336193332735234, 0.11259006325920243, -0.43097454685833764, -0.6588240832562143, 0.9273866857626992, -0.48221951383022527, 0.4145591198383804},
    {-1.551721682526523, -1.1796580950516735, -0.9264569420961729, -1.066405749807209, 1.1264757404080012, 0.580416385078003, -3.4827347411912055, -1.3801318679064447, -1.3159261502358235, 1.5390862589848897, -0.05130303566460946, 0.8219808030316764, 1.1487715551831263, 1.4944466399310559, 0.49860176854652477, 0.1602509374235375, 0.6808216073595256, -1.5537745045277451, -0.12322149183687534, -0.7479327406090175, 1.7351010982938802, 1.0988659302433617, -0.6693872546473839, -1.1873836979489905, -1.6279386189976681, 1.2808500648379222, -0.9556749018021558, 1.1154214418739476, -1.8198038571642339, 0.2921164460221385, -0.5028551887874753, -2.322233898396017, -0.6492574551766734, 0.06500748449788575, -0.3667221541458067, -1.1682975030064457, 2.643021438539034, -0.08230021896980769, -0.736066310886001, 1.7636445211659986, -0.41033838609434686, 1.348230365679536, -0.5607966456818932, -0.6055981220352054, -0.08181547264936564, -0.7530956469473817, 0.8270577718631922, -1.1999111054136773, 0.19683856362455815, -1.1266172522356859, -1.708816934603922, 2.3112801814600554, 0.10531796072830674, -0.30357514622852017, 1.0936016674099593, -0.6884958232226475, -0.42993168820680794, -1.9911075052940281, -0.8764805164319392, -0.9331904789200066, 0.23762676900328253, 0.22872319774939684, 0.6842064181409376, 1.7839771251053065},
    {-0.9401717961458022, 1.1416633646834118, 1.569881224032518, -0.9358656912271271, 1.8240308092225075, -0.31243509584792556, -2.844988375279154, -0.0005842666250738328, -1.685087689623839, 1.3998875581522496, 1.031777993584287, 1.7065737778809171, -0.06149425361233466, 1.4106174440423778, -1.4624172601658239, 0.49755688562030115, 0.6682955990914046, 1.0245513942869262, -0.5877803909970617, -0.4496871271347801, 1.168551708664562, 0.40573921028287685, 0.6259263442373415, -0.013527665140320772, 1.5080436308861513, 0.5066030203617949, -2.4307535595902547, 0.7542848009416546, 0.7714996415336594, 1.2243745340665653, 0.9689974211375153, 1.2540930338530505, -0.16181601306280924, -1.1337561515600163, -0.160702820028065, -1.0540242556963992, 0.6083757351979212, 3.5125424313768683, -1.0195571900107998, 1.504870014846758, 0.48660012571834554, -1.9641496526825768, 0.31205479039494727, -0.1425031196060586, -0.5976216572858025, 3.0073283271640463, -0.1745052089621469, -0.7837685564474763, 1.4770076168003292, 0.7196768043174774, -1.3214782876466675, 1.5804160472520932, 0.1759097705628473, 1.1008584968843715, 0.3933247597133591, 2.146110833504788, 0.19436792257979293, -1.5487218181005908, 2.1509067015775747, 0.8738711301877402, 1.0099064215753701, 0.13346950754091774, 0.20203961306167217, -0.511175701589423},
    {-1.0327874772767773, 2.9709137020234757, -0.5561177881217358, 0.8855896829356906, 1.2490562223024735, 2.2603625118814734, -1.2374253202206442, 1.5119909605173323, -1.5442549455632846, 2.3856006355132666, -0.0754362127113277, -1.1140323396053964, 0.17297450919484597, 0.7420349558996627, 0.5821268227612799, 0.019983605837608574, 1.5299523582796968, -1.5808673436917038, -2.0168390763981625, 0.35902909950330125, -2.0895172464805962, -0.8825896403335796, -0.12073695654576017, -0.1881139260978253, -1.782465676720042, -0.06974580244559535, -0.03271818685745641, 1.8254823159586933, 1.7337750171827138, 0.6325521274394633, 0.26555902594427505, 0.5665888715740043, 0.5816577393384242, 0.41951621009196377, 0.012576557862680072, -1.5955453234132952, 1.2375454878846892, 0.6348478426954974, -1.159720790453099, 0.6622782906621657, -1.1627730168491541, 1.1855514738317567, 0.18404881372574586, -0.6982605990338485, 0.2132861256473091, -0.4038700016099723, -0.204282615917706, -0.26260102118664413, -1.1016715035110367, 1.7505750030441465, -0.2065043379600862, 0.202755990368214, 0.5835482183679989, 1.320906510638906, 2.155807954927094, -0.7807684793908564, 0.4281673933975655, 1.4935932513033026, 1.2994140132971783, 0.689261529820481, 0.5184939008636732, -1.5853601455189497, -0.24732396903091092, 0.13201571581932495},
    {-0.05990013606530657, 0.16222799046255637, -0.8896905222377965, 4.802080169562075, -0.7365492610114334, 0.09367472294341676, 0.2449470287722678, -0.14983791228457702, 0.05233608778278454, 0.6179799028615156, -0.6126985810231299, -0.4037713732998622, 0.9085069292191665, 1.464619067491016, -0.08085186800123446, -1.941140113718712, -0.42490687180327763, -0.6583404208281742, 0.2970070678426106, -1.0197175209564946, -0.2974303328672642, 2.3390799764251162, -0.009962594887524242, -0.3793446599125331, 2.644309898222106, 0.851747018258908, 2.032465322982764, -1.3148035849507427, 0.789585160957147, 0.4703845673330917, -0.4514589447100626, -0.4726714307597548, -1.093159250325343, 1.8093984347515262, 0.4060640121571465, 0.7052996843600149, -0.4071638524734881, -1.718772220224734, -0.9836032941846268, -1.0616246938516318, -0.7399814735578755, -1.4202308895240057, -1.5734193314171523, -2.027815564553593, 0.38967178052637474, 0.38316403572328317, -0.7355621205872297, 0.8247299462536393, 0.11892842773098528, 1.0572617591272424, 1.7395772429096799, -0.43071952638568106, 1.1520535304647184, 2.454706546965369, -0.6410963313513451, -0.7528245361588939, -0.20590300418615387, 1.190132077848144, -0.24219487458916683, -1.1321772123271807, -0.8255157307982303, -0.25031827327126327, 1.3459977333735513, 1.8166364021198045},
    {0.40889871245812237, 0.9411110116157276, 0.05750321174935735, -0.013809607660327553, -0.2605957696622085, 0.8879832578188382, 1.3454905535084658, -1.6202504528408554, -0.24414614819120917, 1.2567680482995838, 1.5168044305037018, -0.48708020827393933, 0.9701440673421012, 1.141118107542906, 0.045938980725215434, 1.1276122874309265, 0.3612927337546256, -0.1997933083342074, -0.7423678473630582, 1.7349599656928105, -1.2907436842720532, -1.5492875861118445, 1.1250521970810112, -1.1265559682847908, -1.0597461175175642, 1.1451855379305944, -0.24022697586269842, -0.21411697983406405, 1.7617955421175682, -0.2649823168614932, 1.5603504138114321, -1.1668262724614533, -0.333919715094947, -1.4555093268454529, 0.43781712698033093, 1.34545929684849, 2.263914174899489, 0.8055075856859554, -1.0783965284661308, 0.037405225848749876, 0.1803963776022383, 1.452776308405386, -1.2914396923238793, -1.931438843583221, -0.6656318625404732, 0.8833266953338128, 0.6729512621186043, 1.0777901770217395, 0.07397827929014097, -1.3117365372242753, 1.0197830721738732, -1.6224140297912377, 0.35722014328547896, 2.045777844040278, -0.00577227268291842, 0.22651087496687217, 0.08077434692099116, 0.4672013754863728, -0.11448779804568757, -0.48853106385910156, 0.004695189330531711, 0.7466404485806364, 0.9925675297696748, -1.1077475880702263},
    {-2.139902785158112, -1.7397646430849676, -0.09329825553361626, -0.17366272115375506, -1.8483551296012144, -0.826781487456216, -0.675003014265759, 0.16739386669218562, 2.1499163391285836, 0.15330796426514484, 1.1178680742729723, 1.1978291181395782, 1.4453193194631127, 0.3216790480137907, 0.7886012232494171, -0.24576285917185442, -0.4038484918511711, 0.3586397254492938, -1.2147029585641314, -1.7127641620675988, -0.014952870651330564, -0.9963122619701367, -0.7715055399863514, 0.44253689784843203, 0.7052053997738872, 0.9802072454948821, -0.11066174071546352, 2.2997942989814146, 1.8995684116737714, 0.08323623073425929, 0.10193805041486503, 2.1968619709554393, 0.3528187010378826, 3.480797227654197, -0.16108896306344533, -0.27442619563994197, 0.8068999866873272, 1.2941787282918824, 1.2857915831103623, 0.2814627065089537, 0.01049770393210978, 1.019299841916647, -1.518993517044378, 1.0104535924556863, -1.5144631442204544, 0.2816551593149464, 0.22216515086890418, 1.3845361157428757, -1.7062927121791107, 0.25720664760449913, -0.5245426331761847, 1.012630111503447, -1.5898642733495976, 1.1872961013893422, 0.00810518832042494, -0.1704344254669657, -0.12343251613083353, 2.5230773087233898, 0.9624440824516919, 0.9413253747752653, 0.5525728491368083, 0.3470773219169261, -1.2535786120424042, 0.731718184411547},
    {0.604268958126244, 0.09860736495361182, 1.0258851260163768, -0.14702532600297655, -1.2965038204943535, 0.3808556233443962, -0.8859672064773658, 0.5302958672492242, -0.26150685725212885, -0.28108265078811395, -0.41911594233264204, 0.8174543199651021, -0.9686139071264592, 2.0358670698797354, 0.25085014612197387, -0.615776223730833, 0.398082027551311, 0.23528753545770176, -1.0366743559100227, -0.2666324190191816, -1.5934230525947903, -1.196236211920375, 1.932971542821194, -0.22097844318296564, 1.4453650790587722, -0.4808030120704352, 1.3809874881539737, 0.32979037035536307, -0.33130488540900127, -2.157249859396686, -2.119806962539775, -2.1855835721701147, 0.1896586819668875, 0.8043787434598887, -1.5091230856774032, 0.19600976775055654, 1.2913497363472717, 0.9625965168749824, 0.5011097245310223, 2.6377448754234876, -1.4606681119037335, 0.5724065461280259, -0.3361058887389252, 1.7552942869116956, 1.2373581009488053, -2.9128722035645707, 1.2724082400347014, -0.05893006451288869, 0.49928122525671575, 0.3471531890688773, -2.245639931872049, 0.8804468615606177, 0.2613122085500337, -0.22873126414135567, -0.5397157085588885, -1.3614881692475127, 1.2016483687277344, 1.4366047490734863, 0.3847896651277823, 0.3402209637288103, 0.36699642289802253, 0.24010818283419758, 1.619366354623331, 0.7408264282948087},
    {2.49646041224294, -1.3652760923603475, -1.5546946550653638, -2.403369794801209, 1.9262772374185058, -0.4474670062721214, -0.602217954990649, -0.6325223377847313, -1.339965465741069, 1.8457517768759608, 0.07845451054416618, 0.3921726972016147, 2.5552287226168913, -0.5148628399616539, 0.9809838827625481, -1.1040827031817357, 0.49790883117325546, 2.1728805623496217, 0.8311507927008277, 1.9697948996886878, -0.3935147903120754, -0.2462637858070858, 0.89795800595505, 0.18582025285851023, -0.6089101353608833, 0.45946604831457116, -0.2519312641074201, -0.7569364090591169, 0.07537251157950675, -1.7956712914719464, -0.13597073483378708, 1.270643103125879, -0.2686359465696542, -0.4643961232732669, -0.08183635713388386, -0.9463459842873623, 0.6923980811553742, -2.4702101209464113, -0.7426530983534375, -0.10463123974815729, -0.8042513109996935, 1.9431071797900523, 0.3319521381590013, -0.8849945383751595, -0.47668336370401104, -1.1534449573524155, 0.049874099020623903, -0.2400717169403321, -1.8739669316226348, 0.42015790127657004, -0.32942492554558706, 1.3750463930400036, -0.51629460959366, 1.5720790464501935, 0.10788635170974178, -1.9758701033045316, 1.6982416123940547, 0.4961952860721073, -0.09635598798963504, 0.6060356715646733, -0.5844060205115583, -0.04752151001955713, -0.6958014913586253, 0.7735177810639384},
    {-0.8447539096740351, 0.31778588814621506, -1.7867724463424883, 1.2162927545507047, -0.37365044439561057, 0.5816693806356623, -0.15098232595975714, 1.0890485125133549, 0.17587479673419495, 0.9122564336254005, 0.3624728446111371, -1.0525003400243684, -2.672547013939233, 0.7309730290347944, 0.5965353848583869, 0.21309630270625154, 0.09371694890663057, 0.47261200872712117, -1.0577036743402939, -0.14562358940863313, 1.5358718961058844, 0.0221221569538574, -0.6779799281792771, 0.6828940670357234, -1.5956744889107075, 0.43185555086066374, -0.3485142061502222, -0.896083286285055, -0.14791869937393068, 1.5026272624577997, -0.10306980649628537, 1.3043296959444184, -0.49268172783858954, 0.7754303880142865, -0.09153424469647667, 0.9050906683037895, -1.364250315430422, -0.30176944680182943, 1.1225581629018975, -0.9987440800704096, -0.5615255941463644, -3.2197697096991633, -2.4231062539943946, 0.3694005923646302, 0.04168271379940466, 0.8221129222260125, -0.4729984822936685, 0.1543375343248694, -0.12657982920887892, -1.0167684415295075, -1.1926063311152797, -1.67653432143237, 0.15154563755768002, 1.0210976795632778, -0.5902184640570781, 0.36544439139985946, 0.5479226945740547, 0.43874186360871875, -1.829451944628689, -0.3668877242732879, -2.2882968305460114, -0.1180750517487593, -2.2977715884219854, -0.0065220573752725755},
    {-1.038968653424729, 0.08438248581556308, 0.685086527395257, 1.3801844938779588, -1.0606068212366009, 0.3264747078351514, 0.1457062713073822, -0.5527172207923059, -0.7940380793583592, -0.06694705217858155, -0.6100379205147994, 0.1716223540611112, 0.9122729669248236, 1.1575349669703212, -2.2347790411737996, 1.7593533554690477, 0.34577210047429, -0.19864567170615052, -1.2604727112100844, 0.2052498047964009, 1.244450044444779, -0.45375791360041684, -0.49611808018820003, 1.903697657519162, 0.2746654418798038, -0.9254642007815599, -1.0456991781602756, 1.702334952074363, 0.14859131217029015, -1.512470648051785, 0.3930385569165367, 0.3285939246901857, -2.325451066113559, 0.121075443832261, -0.31146818138788857, -0.06241773787129118, 1.853041473892616, -0.126276312632246, 1.5186561022798952, -0.9308883707742688, 1.489639179216579, -0.715346410765486, -1.1216508460497998, 0.22579509042243232, -1.5153038612418013, -0.11199671773395507, -1.364908242259625, -0.10979554314632206, 1.6847454507425077, 2.8071654319890196, 0.17000134632278613, 0.8644826979596569, 0.8585464200077264, -1.3649095252760206, -0.9115462705119448, 1.619173344188076, 0.48164421167040855, -0.15957539719991115, 1.7148219087448946, 1.2075685016098792, 0.46185262185000964, 1.5937091706287887, -0.25859176963119096, -0.700430505349408},
    {0.47440779822050727, 0.6317762685439278, -1.0710287688220925, 1.316931631696808, -0.7391673532133437, -2.0365720474506204, 0.30242510484031004, -0.08973101426417397, -0.46661794960693354, -1.0861057911871752, -0.8968308954581818, -0.07711216767933932, -0.11354538140838898, 1.5074512242064417, -1.098507942426495, -0.49986828100433606, 0.1955339375655345, -2.0915477459044967, -0.37302807956830975, -1.6828292111371188, -0.8392336971707197, -0.032070358987671126, 0.6748992395842539, -0.3380274660159015, -1.5896537779050706, -2.0375196520119245, -0.051652646732927944, -1.1012011983146044, -0.5350500146393888, -0.8021029676132293, 0.05013782552767005, 1.4476631095126316, 0.7297869079784608, 1.59826104532057, 1.843870490393376, -0.2746922926083255, -2.201094704465777, -1.177612347061346, 1.680554620352191, 0.7632268683733341, 1.3149663998899084, -0.14374002066250274, -2.2433659924972726, 0.9709860825189229, 0.7302709440227452, 0.8155021282412257, 1.0716117093271744, -0.30224948245676436, -1.0466224980754897, 0.32070664938198573, -0.8664816989012005, 1.182564627792073, -0.424450950540393, 0.37892084927016256, 1.318523180112095, -0.5711548661521686, 0.995643623504414, -0.31104310624011655, -0.7052346742134927, 0.028319705353671346, -0.6989801409872938, -0.266645980375685, -1.0222214668351735, 0.066035807324839},
    {0.5870820496964183, 0.7336531373352424, 1.040053714171819, -1.236510280675994, -1.7246205947896518, 0.20303278758342855, 0.974465126785622, 0.41702782130516847, -0.2881670743694866, -0.6221383709938331, 1.609094779371076, -1.1116997228300558, 1.6253408468335697, -0.21761953664712383, 1.096274783754247, -0.7708110539246452, 0.2647081913474618, -1.702071212666528, 1.0577328564965869, 0.9835111764074782, -0.8420619750434792, 0.4113190762859126, -2.1575540917196108, -0.6997324631143746, 1.6771042940139147, 0.28243609964680666, -0.3621412366869167, 1.736064027601193, 1.257482961950184, 0.991628929811079, -0.9032643804835441, -1.0511254893926416, 0.4481703472144203, -0.4001705286297718, 0.35052889066343906, -1.8554833054483026, -1.1800937832072842, 0.278104005147411, -1.3730033787062539, 0.13328666439413211, -0.6260315953345015, 0.43773847670988736, -0.3970771045758224, 1.3514339276378713, 3.1133069369078106, 0.3413564759133945, -0.3952589733521862, -0.6185049277851317, -0.2316635104259549, 0.00795424668706516, -0.3841158122453864, 0.4439408208254679, 0.2141090843217848, -0.028804584366257463, -1.2422334378753566, -1.4699082698406591, 1.0551969956736333, -0.6738238288069008, -1.841274636586775, 0.0983141338689128, -0.9493932375366245, 2.210260523037319, 1.1238974152824763, 0.7877216648685905},
    {-0.054625839785887094, -0.7043718423206293, 1.598408592571371, -1.7358990425854697, -0.8864779244753179, 0.8069686691686435, -0.3459397251467836, 0.9669381880441039, -1.6363810614297292, -0.8455883557208955, -0.17719606756182363, 0.3077978251295036, 0.3103906638472903, 0.8400855621964156, -0.7540586232764057, 0.01543425054210003, 0.08280926071805739, -0.11604489613064138, 0.6492256451750894, 0.18127530367010186, 0.04387416229880476, 2.402422163725133, -0.6892975915540898, -1.4010528993839912, -0.3030540486115024, 1.3781622884259865, -0.3163753807867972, 0.18601215594402626, 1.3149577402323258, -1.6394456107142334, -0.27034206396559063, -1.153738201883082, -0.6412753895332414, 0.6519922588307087, -0.27190646488483655, -0.7522835521022476, 0.6230207872605091, -1.4926304176074212, -2.076562391498784, -1.3308898940466762, -0.057834559709600934, 0.886700944579554, 0.3806136638169864, 0.8000326002808901, -0.6331068448902653, 1.2665301344949347, -1.347218711418459, -0.27597916716537113, -2.661523818042808, -1.169679404548189, -0.8521874208719578, -0.34344961798525386, -0.281157191506899, 0.17692508683075253, -0.23860609082010206, 0.44704832196536337, -0.8736188578116155, -0.526159878207698, 1.353563944687336, -1.0147656319736198, -0.07419887389202094, 0.23966518487525731, -3.135564746210771, -1.5787359384928672},
    {0.3236126350277151, 1.1073663315674362, -0.436090818005419, 0.04313729830257208, -0.2296346151412722, 0.6946361654940987, 0.35023775695575793, -0.9380698167651814, 1.919034985654672, -0.6634888091026693, -2.148110562388409, -1.3965886047822396, -1.447865483222874, 0.9055396167235464, -0.4273437110530961, -1.13387538326268, 1.5317837789435327, -1.4094276692511876, 0.44457405037689757, 0.3330427148242558, 1.001350711033122, 0.2883898453871019, -0.5356137166832589, 0.11751105080182049, 1.6625555226030087, -1.6296266715862544, 1.2852031343270647, 1.010807340003817, -0.8557487937385965, -0.7873337579116898, 0.33431912824608173, 2.0329152155669465, 1.0052823469618115, 0.10616283099536737, -1.1737276854844407, 1.2578279233468768, 0.2535274859306641, -1.7472855559353173, -1.2406802048427583, -2.7492098742699524, 0.7398960659829533, 2.7520344294810046, 2.1873444741790786, 1.2707207509361498, -0.7387805832215891, 1.0979773952912495, 0.47039765891684343, -0.7162804603983833, 0.19111521073100962, -0.8638367766277832, 0.8932642356881642, 0.2077389576099956, 0.1073369894059749, -1.2063041335913247, -1.3223098117202399, 0.18403422839336034, -1.6203141744627065, -1.3310131273931918, 0.638669584588508, 0.9389014441821547, -1.9507353318486744, -1.2959335701273116, 0.9814132481399118, 0.6570615572946987},
    {0.9294861335661445, 2.224268987604895, -0.0017875441525300646, -0.20728048578706537, 0.8795424338502507, 0.19385252011716203, -0.033110589316630745, 0.4010348697464543, 0.5979722238736064, -0.7442379248495232, 0.8111288337149708, -0.11465446132733999, 0.7802578205673385, -0.25728563805384463, -0.45315092660834655, 0.30256318673121024, -0.7011477040469275, -1.0103185150854328, 0.3490973772158122, 0.6134727436246387, 0.617742096128017, 0.011118275111957178, -0.8535583186578377, 0.6389412435528986, 0.6623926285881363, -0.21745232600236464, -0.04322452108299159, 1.512555762849231, -0.17864636467223838, -0.21315259052086363, -3.8664248758169415, -0.43119539553822706, -0.4848926221443819, 0.6759722239258691, 0.7324382137095965, 1.2011553011418143, 0.18108283313349183, -1.0147843810401973, -0.21143867791964024, 1.9654774028701623, 0.34968767767131703, 0.0798143760870797, -0.5919688192305745, -0.7235438854791387, 2.3192686036779375, 1.5102414209104993, -1.5381000862087315, -0.06847346654325503, 0.2822780464337552, -1.0476973087120485, 1.285492463194389, 0.13512228887958663, 0.8484670379222132, -1.1556748341795189, -2.6301471415626514, 0.09518988624045639, -0.3083009414084291, -0.8921798117940725, -0.9532239114494333, -0.22158532277148202, -1.4619877407331903, -1.083732843954994, 0.4680813047028588, 0.26567350716700644},
    {-1.8968740613194834, 0.12173412204990215, -0.5902679905306855, -0.19263217268612823, 1.7421490822037904, -0.9548500936358906, -0.633975480980495, 1.190289416724433, 1.6377432738748223, -0.2966444583476616, -0.7933857421374435, -0.3128099201925084, 1.0679502367818936, -0.8532539884013756, 1.011280125057915, 0.47099368429005456, -1.6878916176099357, -0.1692602140311377, -0.9429179723108052, -0.5874038478142872, -0.26314903778328, -0.7425720562892926, -0.25185136811517567, 0.49238151598819613, 0.7443340367768291, 0.38212773766317104, 1.516791544140189, 0.00231369447176959, -0.5638207676840138, 0.8793668370472139, 0.1257567167934712, -0.2864190145982033, -1.0406766828593805, -0.18693459998467638, -0.8046239276419962, 0.7223706094796628, -1.1721116754722114, 0.4849052823173192, -1.9819989441870922, 1.993221148315652, 0.4956002342907552, -0.5294688139816653, 1.4449391101495022, 1.4509462366685986, 1.0686776827186166, 0.457408086941379, 0.9222756177477589, 0.278693257778353, -1.088267585254796, -2.1228124146628735, 1.190701455543591, -0.31125015425728497, 0.39198726772307324, -0.9008383257117929, -1.663197349054837, -1.3076489819236556, -0.22610756938332358, 0.012294778805006143, 1.427797930022826, -0.8408159864621084, -0.8143852022151228, -1.3649929460929724, 0.9563566140834107, 0.4740863344682289},
    {-1.1169660064021207, 1.6727328753884647, -0.3099669579947956, -0.9299559934697504, 0.3056600579541759, -1.366732453289209, -0.4136470201627487, 0.7180183486559704, -0.4521213951686775, -0.5597948467193808, 0.24867455140200742, 0.7437552645985991, 0.26196249050172243, 2.398158940798233, 0.19688178871926287, 0.8833042874562358, 0.15558628909237895, -0.6630659778227334, 0.1501628116726182, 0.5830248890639831, -0.6564540982007859, -1.5201134308837092, -0.271932764096013, -0.12343543479933014, 1.5070115139019644, -1.065853685912894, -0.626674419285172, -1.654750818257623, 0.48532531708511095, 0.210811556836369, -0.03516821868400949, 0.5776579953090668, -0.16561779943529378, -0.7020429960065832, -0.9692895319842983, 1.8857138893989023, -0.6616766800197823, 1.0283628015355784, -0.7492267316355466, -0.04732784550262583, -2.08401133534063, -1.400647744876891, 1.4637446210384466, -0.36543870611868606, -1.5633978694310735, 2.2309325209832673, -1.513664280578189, -1.0025857458058856, 1.4025186431072167, 0.1215789224006846, -0.8986936498462011, -0.9437538334756195, 2.213881536364481, 0.40723692906038605, -0.24782189401622826, -2.6193823669221197, -0.5898777262615053, -0.00046373615908861307, -0.48314330058451826, -0.21480215392813687, 0.9364294160642623, 0.17765537757306404, 1.2263729870653715, 0.17863463384712755},
    {0.24362148442607415, -1.4184283767514918, 0.9707704769784097, 1.575646774117251, 1.176410484056184, 0.15026246454228445, -0.28072089969071573, -1.3280686571477274, 1.820467832135927, -0.4748199152183777, 1.6604165392660517, 0.1939553806264827, 1.2088738829502037, -2.119535767417501, 0.9465108584979564, -0.464661957983743, 1.3603143369913007, 2.0643688382742784, -1.0190144647035557, 0.25918751617801955, 1.1060639442204694, -0.12152298237796379, 0.6214007999422427, -3.3613473727107586, -0.575429225968331, -1.8547229152136284, 0.6725862144087109, -0.3965600455511486, -0.7674637504394926, 1.0729539146875215, 0.8103392148890519, -0.28706455690520166, -0.018593879900330453, 0.9494375113123406, -0.14490793587878462, -0.8368075239733583, -1.109003318822948, -1.2599829815269075, -1.0671957692587892, -0.3186116117125326, 2.914599297391063, 0.4877639741595091, 0.4250082585653562, -1.5766699626985974, 0.3767618093548188, -1.9078228503252372, 1.203980859096957, 1.0591642478612875, 1.3911587469633495, -0.8986537962722961, -0.22942933420761397, 1.132696322398543, 0.8877211887609902, -0.26356260754430394, 1.7618132366546901, -0.612126395996509, -0.1316440314626089, 0.8025359478788625, 1.4009654873015909, -1.6727636813303988, -0.6323082185797955, 0.5659943170381906, 0.2902067216062455, -0.06648832724065062},
    {-0.7785905481709212, 1.6141150644454567, 0.17667658358906296, -1.1241036307128518, 0.06721951484953194, 1.4521010744770617, 0.17320647014599422, -1.4976108041168896, -0.4581499135959893, -0.35278666375586226, 0.671340677414271, 0.8964853820338119, 1.03517290610923, -2.7480614579429616, 0.7821456929501021, -0.19256459269210138, 0.4616086176371228, -1.4115292750035595, -1.8638498283566243, 0.03430249266474764, -1.436610949529329, 0.7465976930882706, 0.7058070665281911, -0.9317453708477937, -0.5747584353830729, 0.784551171706562, -0.322320125577912, -0.11283213247656673, -0.1656117847281669, -3.2557718261004744, -1.1182649241053302, -0.64234632403764, 0.2077918574823687, 0.8916967349132583, -0.5753398417672982, -1.4672230647936895, -0.6708908909534654, -0.20989467884924098, 1.507584608834779, -1.100925411873899, 2.827858408207981, 0.47150838061627853, 1.047465802766242, 0.3407901184407212, -0.8338387227649028, -0.8883181504501055, 0.22620936883182985, 0.8083407317578832, -0.023765401152090443, 1.0549975567848022, -1.398296956751301, -0.3190299027617336, -0.28451052813776506, -0.14275752485252452, 0.4340604226878826, -0.8642407972072335, 0.3640780980824005, 1.20978325980989, -0.11030621337161249, 0.3797683535269542, -0.44451797751679156, -0.48633756835188013, -0.6184557653001259, -0.6960276147342533},
    {-0.22626625535203168, -0.7095120707412806, -0.9248076412170437, 0.3148594978539753, 1.0008008573971072, 0.49912298814713524, 0.6355278011711456, 0.5304365213418865, -0.5368159430203729, -0.8683228207441621, -0.461395931647662, -0.005014734567491127, -1.392057515368753, -0.7008279519257176, 1.1849903486305395, 0.3118476101528726, 0.10809147836231152, -0.7807186760310105, -0.9871861545165139, -0.5016008345405766, 1.4359943164241276, -1.1550886372658102, 0.3188446404057121, -0.02128973418671487, 0.1971923784504115, 0.14696348990212874, 0.7181779788999109, 0.9562253259485645, 1.5694625113060912, -0.7283028350760192, 1.7280926897448177, 0.5210696359974332, -0.9583815975104643, 1.4724617350598341, 1.6757905383390352, 0.543017656532584, -0.34216747369516415, 1.254804043477777, -0.09729430473772344, -0.059137231435299864, -0.5167001589028404, 0.8615277449550235, 0.5425603722285098, -0.997004398422949, 0.48307018086884634, 1.909448086290381, -0.5458014944954428, 0.03552538243694341, -0.8269783758830981, 0.2756561811942286, -1.3652839755422652, -0.8751618870046849, 0.8414848564052259, -0.7320088465489949, -0.24428751573309232, -1.8917109360002575, 0.7945720592003287, -0.9638045245910455, 0.4069852406027079, 1.5034990894532805, 0.24393252591573059, 0.030153136982520444, -0.23920606966523647, -0.18807651975155287},
    {0.3683221817885551, -0.6225981337001114, -1.2184789869545953, 2.153731036209411, -0.560069176909116, -0.40668956805237655, -1.1475281248598188, -1.6202475804640606, 1.6653112451482994, -0.8920483574217568, 0.5845181547785185, 0.9608983625865215, -0.23474240374205896, -0.1022036105194767, 0.37658401982129736, -0.6603797404480332, -0.21640063447888785, -0.5208957203220279, -1.5236981874129765, 2.2625898275090686, -0.47288517531984037, 1.066165326280147, 0.4473053412966755, -1.7487471044883685, -0.20639803679945326, 1.2220296053909003, 1.3956568461300414, 0.9866755194523137, -1.4126967620714561, 1.289184755580047, 0.762675569847374, 1.3365039912663934, -1.5968272750130872, -0.5479563628951883, 1.84819931286877, -0.27138114680493997, -0.3052169336214867, -0.6440692010018281, 0.5969161380516234, 0.9219855692619127, -0.25659329668793746, -1.1731358170713002, -2.5334143726438207, 2.8414085374726112, -1.7293137542050685, 0.9127672255839842, 0.8306545571121696, -2.271701864161545, 1.871290856068278, -0.5485283654576087, 2.036925723383013, -0.21964366263229218, 0.6689320688851843, 1.04821976999847, 1.178016570913052, 0.8165474168146684, 2.3083918895725053, -0.42754870747499246, -0.057525367532913395, -0.3161635175516671, 0.76666084503129, 0.8428987715423909, 1.6650167998680685, 0.4504918672496914},
    {-1.3623746035527489, -0.036297862163291575, 0.582591731177798, -0.33652862271480194, 0.361256628594445, -0.3270418838914656, 2.8233306788776296, 0.6297019884714298, 0.25044196633864085, -1.2066226693803632, -1.4120458200906407, 0.19077140488953856, -0.12728908656459936, 0.8046998531421339, -0.5014850902982857, 1.302890528324735, -0.07047526364630982, -1.1303778019681625, -1.89979738868044, 3.3315698559589073, -1.1043998650526703, 0.07352017116822197, 1.722627465231331, -0.36200493222645563, -0.5719160576940336, 1.1919244471997967, 1.3305982091144788, -0.42018199988335364, -0.7190165714741032, 0.95485447789971, 2.603924285747297, -0.23358056652394285, 0.8061385749175367, -0.9498186063254682, 2.041163065189867, -1.2388026931611968, 0.20202678842222344, -0.6939085776682613, -0.9400800966458684, 0.2170292812060085, -1.8735828677716015, -0.43078501927008334, -0.819380393420911, -1.385564797724394, -0.14482291831617988, 0.5898774050330028, -0.18053740785543215, 1.8797780355129785, -0.15576837531795973, 0.1553129371724827, -0.2258649027020694, 0.40429977838892955, 0.395037823409802, 0.364275797249755, -0.48588913164176534, -0.10440325102832067, 1.55536177100006, 1.2452406116266566, 0.4604118534694922, 1.5665692286408894, 0.10372000239019288, 0.8065362755272297, -0.15610497619308472, 1.1325906200582372},
    {1.3552154721418033, -0.17958202244660076, -0.6865833698004105, 1.7233115162641972, -1.1158505461312485, 0.004679984290507551, 2.3842200806640164, -0.6598012961433029, 0.7284698299765252, 0.5019302305915719, 0.019126451744077726, 0.5292110577057223, 0.9965266727168945, 1.5106801127579268, -1.4341311461121002, 0.18908615038962048, 0.8787015152293925, 1.3856866294637942, -0.22784271130751524, -0.5090232305943019, -0.06417523480051068, -0.47680843444311366, -0.9411879879465356, 0.1597676755116534, 0.7626115308408322, -0.07361760266991453, 0.6541298689973238, 0.009041765549202373, -0.9438114994431593, 1.2298880040335083, -1.3286403143831242, -0.9888888248270891, 2.0547535328664592, -0.3609436277596451, -1.1549206005571642, -0.6429859152720176, -0.027719465591062146, -0.43183705167902336, 1.5784535663093586, 0.22092940652745321, 1.4809551521929296, 1.0385895106383667, 1.3037513299945676, -2.084293793323392, -0.7036619161947281, 0.8897016500909157, 1.9995633067067613, 2.1218523962487903, -0.6387173928209096, -0.8336703802050749, -2.0548989664438797, -1.4914939551795345, -0.3483214164059111, 2.4121215991644283, 1.7373185681905479, 1.1826725529572104, -1.261675928205856, 1.311176088794177, 0.7414518217282935, -0.6955522114999575, 1.3523587949704723, 1.7302640906620805, -1.1229783263348547, 0.49723135479888436},
    {0.09015513937253394, 0.5946270111553379, 1.2308245562998577, 0.14159498562653167, 0.6948314323350733, -1.2574289590141816, 1.1440878350865844, 1.150220533910791, -0.39372688491947955, -0.18287900766495155, 2.1175398513760983, 0.568190377009264, 1.107666154123056, 0.3781086807966074, 0.17796813802723158, -1.4195550107340709, -0.0004312635088003138, -1.563086203304943, -1.9813218913982138, 1.0034945447990098, 0.04454432837300502, 2.466394674508576, -0.11038956632819669, -0.7813269116400878, -0.3594403005689834, -1.046263249545548, 0.6288444428374026, -0.016308987467629057, 1.6289405723564283, -0.9954474795613438, 2.181312897128004, 2.2507267203136916, -0.21248304859401068, 0.29407753242994333, -1.198016885255917, 0.4958367545926613, 0.32476027618490544, -0.036593991361338854, 1.4073682703314625, 0.3059509566651331, -0.009466481565442397, 1.4497255282112793, 0.3712116131242999, 0.10042452012791953, 0.684167113692358, 1.7877557830503101, 0.31448948655752007, -0.27198341982584884, -0.06729431670846082, 0.3469086174572659, -1.2922573910674744, -0.18391618130880788, -1.33302556525713, 1.6735820091666564, -1.0345794854647212, 0.962363500261261, -0.5562409143150717, 0.5688849180517304, 0.8714166123491898, -1.1493620070904635, 1.2778798449226567, -0.38131843587114433, 1.1444462343256685, -0.4624103769972542},
    {-2.2130349230608357, -0.3352690843827705, -0.08890410761309171, 1.08362519482134, 1.2268883065084188, 0.6040212999738429, -1.100250109467429, -0.6915299345894375, 1.003253493281911, -0.1426282479045506, 0.41863799982802813, 0.6718009234549723, 1.3651047985254756, 2.271008393266346, -0.003479478941725283, -0.9693656723271471, 0.8541165777046548, 0.08198566167546441, -0.305248179376881, -0.6531340885803704, -0.9406401853315679, 1.4432856612558083, 0.40942289403235266, -0.7567837831278899, 1.8369978783851193, 1.750514790638744, 0.6563325042485734, 0.8121573537221908, -0.2839431275502517, 0.3371871543390199, -0.43336435629033676, 2.1463571467440294, -2.2617673207381688, -1.6164877966148863, -0.8411943430451561, -0.700974014045309, -2.627597477746011, -0.20533391386079405, 1.4726213660348477, 0.5478071811787955, 1.1173020325480176, 0.0886295931453421, -0.9140224599365501, 0.5257871830384836, 0.8274092977237526, 0.5936167281489241, -0.44831939827283807, -0.31936281599452054, 1.2022165085730685, -0.7431102051527521, -0.12540998360923786, 1.2552959084964852, 2.6796582414824575, 1.8027459088015865, -0.6893450910820476, -0.4022724102138589, -0.2787026372480908, 0.16221929876853777, 0.7602157512029107, -0.6547313112565402, 1.1284310829605275, 0.3784580208055265, -0.35907077537578624, 1.032053355737884},
    {-0.7460073375197059, -0.7466191709610833, 1.4798521313140476, 0.434655740048997, 1.491287988301587, 2.276198658500536, -0.17316389732408355, 0.08754634428490154, -2.396601028132486, -2.1374870529452172, 1.01737985057859, 1.2701898100592652, -0.055920438700676936, -0.6190189866189191, 0.24550180061590055, 0.48852142510224794, 1.4517029015844212, -0.5728774329402813, -0.048753888547945504, -0.45478663527773605, -1.113856906258776, 1.3779874068334061, 0.45815138665200117, -0.26447440385675297, -2.2445268923280692, 0.2178119347052184, 1.4238119469189416, -1.8710722904785158, 1.803410647295867, 0.5174277498154553, 0.5365386486482021, 0.5415305260515115, 2.392006124004248, 1.3224922762159088, -0.2618902499355378, -1.3946870208262265, 0.352266066156724, -0.21043799188818765, -1.8098202111688988, -0.23823035640444679, -0.14815901286437114, 2.260525249702041, -0.009435109692917477, 0.5150256873115863, -0.6437154834433672, 0.5579143266287255, -0.5147233242685604, 1.1392055303588329, -1.1067894513820096, -0.294916328459445, -3.041632505732802, 0.2438995971704477, 0.3996510575199648, -0.286318009502096, 1.819770533361947, 1.5249830998741896, 0.15245352817140434, -0.30896415900336466, -1.2363995184133956, -0.7415182725647378, 0.8887732533213001, 1.6362781497495305, 0.6466465834342733, 0.42311433951434596},
    {-0.4473216364456029, -2.545442110621794, -1.0268925742755406, -1.0057170087804288, -1.166894275220114, 2.295159288226995, 1.0877078689543458, -1.1040016184278791, -0.6595759769170552, 1.0226984378331367, -0.48550063044134384, -2.4188388232541387, -0.835902494879986, 0.03879837087123057, 0.6768282756764437, -1.1998208351296604, -0.3665649133295462, 0.2066861184357752, -1.8194729360016244, 1.4648645514397118, -0.9475625143127332, 2.4527339192338813, -1.1589210596570005, -0.9962359827179218, 0.17614637449357656, -1.3657760344996603, 0.988609196576331, -0.7008909178442366, -0.2660299015279471, -0.4058925174148926, 1.244782039239727, -0.8475790013397816, 0.8300586525349949, 0.4559923241786347, -0.7857218947979459, 0.055470999029698896, 2.644478326322135, -0.16035932781535764, -0.6586961690945203, 0.26976385921709234, -2.5949394595822417, -0.6578694811707112, -0.9336888213450394, -1.5471713589652454, 1.0902768566727903, 1.514509725512207, 2.0283346570183456, -0.8869784575338703, -0.022418297867676712, 1.7066362416791632, 0.5853947041194995, -0.4890392432684007, -0.36853629442294084, -0.08275702791475324, -0.2605181171608349, 1.7940858543878075, 0.11466722739565721, -0.06698498062679434, 1.1528002815885279, -0.34462937386560766, -0.30611762711789475, -0.11609568466854134, 0.8477454277196712, -2.0918816232988777},
    {-0.5787282347215994, 1.7091623477702498, 1.0864319351207503, -0.970680790887456, -1.297150397465344, 0.7336673217178481, -1.5785919460734017, 0.2485771391115102, -0.88814554679612, 1.4027287391108325, -2.426790091895309, 1.1521618628257824, 1.1610667507094552, 0.7690559810334647, 1.714055270474548, -0.7847039809859088, 0.69211446292955, 1.1374580142760615, -0.3280677900881634, -0.12535300053520115, -0.49931000159236927, 0.46070637003143267, -0.7989730930028278, 0.11248955763100099, -0.14589173234899, 2.298838411423097, -1.199087753193295, -0.6812780123448527, -1.1278095068887135, -0.573993821896779, -0.013037642519809566, 0.0812212312547983, -1.3549646995008406, -1.545432244271907, 0.14100783113292137, -0.49450413316874875, -0.9587196363411332, 0.586285004371892, -1.1026160168044445, 0.021928819355070024, -1.0730245304333825, -0.0927578176860028, 1.5384489600097258, 1.2256617031070234, 0.29158930024642604, -2.0903982556580547, 1.6414857956532969, -0.3235743855984898, -2.331356688236957, 0.014483922962488936, -1.1833424565645407, 0.3034280257600455, -0.5885912902460415, 0.16830661875509964, -0.2552744602030613, 2.481296141854439, 0.5417159119242229, -2.3064291166377293, -0.5199609191552069, -1.035387353246738, 0.3553069479607268, -0.9355959341768493, -0.04253132118683112, 0.07762141701750365},
    {2.499817552400339, 0.6153620969688647, -1.2764202692629194, 0.166480106415603, -2.772911966805247, 0.1722778325149884, 0.10982536694434686, -0.29446321683439114, -0.6342673038940319, 3.0037995302871456, -1.2282005508798985, 0.44268192695985425, -0.7216178513972036, 1.6392998594917803, -1.1567394127249793, -0.6772835756527419, -1.0864417408361242, -0.1683251506252455, 1.3804299902142076, 0.5861842466863987, 1.1631306930660679, 0.47381331169397645, -0.17143584749510973, 2.150625333263424, 0.9146655340312877, -0.8345005187576455, -1.2376505869533758, 1.114434672981269, 0.8412641559974678, -1.061026021910239, -0.47743212942933994, -0.22624252224924507, 1.0773334217241137, -2.0352252279317717, 1.6427410855432718, 1.3652001849180122, -0.07460380909619135, -0.48680142458116105, -1.2138473281968407, -1.097881320692589, -1.0087464693963033, -0.11760180310098524, 1.44896827830407, -0.4021814059979996, 0.3039078908088699, -1.6622429251743012, -1.5732749511631618, 2.157365916896752, -0.17628412072623512, -1.0738924579666436, -0.5077143566060791, 0.6743736713637095, -0.5752241768463912, -1.7867148297611162, -2.221267462980548, -0.11630317043757553, 1.0553836675568458, -1.5882515071049152, 0.6749526426473449, 0.1514169670199585, 0.4405176215524947, 0.011464287824078915, 1.4890752313993458, -0.5849875170673279},
    {-0.8234677514593682, -0.30642849929573884, 0.5246816260557816, 0.4472292575649225, -1.4597200642414574, 0.4198089632207154, 1.2675065966176107, -1.4539622131141166, 0.8390333814554778, -0.14455448200118973, -1.4006459816656345, -0.22753201081908056, -0.008069914659390772, 0.6289592283935959, 0.22713660712868528, -0.3190478438109257, 2.0258370687447353, -0.16115293452048912, -0.38612115596987406, 0.3220932956957899, -0.38936446698911087, -2.0711264672953935, -2.4836941024903303, -1.6780304012803324, -1.7866087976813227, 0.4214774904684315, 1.4269114442124688, 0.7061747873001422, -0.7053002696080011, 0.28436920729334997, -2.2206760697106636, -1.016816608774398, 0.9206299749118618, 0.5296039946831089, -0.05328051567465051, -0.5324976538326532, -1.7792664045451758, -0.7105586915544729, -1.6068723069731892, -0.38649727307676174, 0.09325546487237142, -2.448219288754483, -0.04307019610211408, -0.6494609312605599, -0.8382423241506544, -0.788346301736815, 0.4462181045204476, 0.10552141446076194, 0.5278052572031972, 1.5509435129756253, 2.4004483498956337, -0.4389436807361017, -0.5429456497373387, 0.626821916427408, -0.3381930328510491, 0.7268931771448492, -0.4405067162073214, 1.1213830494562917, 0.03977475686888959, -0.5317213622470809, -2.854290569228358, 1.7332931182979763, 1.0463261897614564, -0.1284328768643546},
    {1.32398026144297, -2.1046850131345964, -1.2747875482898716, -1.3359062430023345, 0.38619486731776237, 2.3623688328973906, -1.3957894245667604, -0.21799630126403227, 0.17976709159929996, 0.542338371917494, -1.388740405199669, -0.9991501140771332, 0.7931924695653421, 0.7208722408588711, -1.1392732447203755, 0.8624842293125708, 0.16024029972193712, -1.9404871311317984, 1.562883885592269, 2.1968433238769864, 1.3212173820377198, -0.06118340290899525, -1.3406936512343453, 0.006796439956741833, -2.833267702573348, 0.3077231248719253, -0.6039118181288169, 0.3831916633869109, -0.29859111027606416, -1.1057640252526708, 1.2426114564666446, 0.25271859309626216, -1.150566288394753, -0.9206484322654199, 3.0155818180064884, -0.7216391726696235, -1.0144145521990287, 0.522232524666628, 0.4358171382525063, -0.0593506670839042, -0.9644484433166608, 0.5210618657388112, -0.4058233213359004, -1.1398694673797987, 1.026806067710589, -0.8595247138394526, 1.921572130020099, -0.306326425042755, 0.41457447843915124, -1.2733287526982904, -1.691110870284559, -1.0125107328204097, -1.193990729965077, -0.023376581380300264, 0.5065152934658623, 0.5582452712509441, -0.5261113752716855, 0.2153386475278511, 0.9352312877242148, 0.11855274921409222, -0.5575292412661266, -0.7902240735123679, -1.0634130896986291, -0.08805562219790103},
    {-0.011681636367333983, 0.42266484401657267, 0.06968433249067199, 0.42642272888824884, 0.41930133282876997, 1.3557194624286721, 1.0376377327829442, -0.4992835840208986, -0.06652577738624872, 0.3775181908808305, -1.8690544027847351, -1.3041386618588737, -0.9180606336273046, 0.4085896721567287, -0.832925608246357, 0.2927926560814051, -0.8750881768167089, -0.30376633670422154, -0.26710641357555076, -0.3535927531022284, 0.8296699675575262, -0.9972886167631732, 2.0620464521827055, 0.6677869724351411, -0.29205581710864914, 1.504559830329136, 2.600635453741035, 1.1634215512001143, 0.9366812789607456, -0.15944055952935532, 0.8128504629730675, 0.49677571666444453, 0.46371355251140756, -1.4930098287652371, -1.2462397380887225, 1.5202772705977736, -1.3786851334026256, 1.0857257052294818, 0.39925254956318545, 0.9248191681802292, 0.24238684502098956, 0.2626806814380514, 0.4693004786495547, 0.43057826474682326, 0.7686363535966779, 0.5262645834782579, -0.7363718890016492, -1.3101762613709318, 0.2778328151399472, 1.4159442229473118, -0.010128702000294294, -1.189335565028094, -0.1685962616662852, 3.032406847655347, 1.4554433225958423, -0.4698020454369965, 0.7762524372103886, 0.029767190058392835, 0.7314234422516701, -0.21389821810417284, 0.9698898386829822, -0.06915830246130411, 1.551475035366805, -1.2511557585325928},
    {-1.2964712217566647, 0.3007052386049365, -0.6310355728736465, 0.4707669147567604, -0.5815130894621747, -0.008737710707331477, -0.6425223418826871, -0.7099322722401178, 0.210553062199619, 1.1592373721986657, 0.5187132144019521, -0.8745894859940592, 1.039997184713634, -0.20355725668355246, -2.1060555814726363, 1.0291926789057488, -1.425803835300215, -1.582851014166999, -0.022975535652111048, 0.7938347216925287, -1.6268232418769197, -0.5473972445653185, -1.8338663886795492, -0.5231326438507685, -1.6732307257451269, 1.1363414563940313, -2.0036572783080144, -0.4247547873555211, 0.747846717614318, 0.41898007118599473, -0.8938816396044257, 0.24703424724094758, 1.0737883853474837, -0.24715423701004705, 1.1551067197364944, 1.8601300318496392, -0.5390792184001552, 0.9861084177053636, -0.12366045963495938, -0.659233477874215, -0.11940408318330371, 1.6716385504088391, 0.4218369584563553, -0.43732261969852065, -1.0810184817813713, -1.0840774042626493, 2.284157630932322, 0.3076223610975073, 0.7867412843635132, -2.354040580826447, -2.06773224912224, 0.8852586202370861, -1.306801468654857, 0.6334877230744642, 1.3670007139751004, 0.49753726799496495, -1.0825027085001122, -1.015260707796449, -0.7302584329962513, -1.234305187002678, 0.31353925109809866, 1.2899596907562543, 0.087045414366524, -1.3877914318392868},
    {-2.4060946138168724, 1.2204990971882355, -0.1738740829681545, -0.6182636992552623, -0.6232602705280875, 1.351934417272293, 0.67802746075073, -1.0597872550278826, -0.2668788458579919, 0.2971301405723254, 1.561783247976003, -0.3342840785567247, 0.42848242678743576, -0.0956837686399396, 0.6641127273346558, -0.01644124574715617, -0.7846832454653083, -0.027594053262442853, 0.5740615583162674, 1.4437415973469112, -1.5210305241531032, 0.6088047046775812, 0.15077970961839957, -0.9285646808281122, 1.3931672690201506, 0.3149411129898839, -0.8027703468202847, -0.7280986421673739, -0.742703870114274, -0.6226193660735022, -0.8247454626637182, 0.6030097412438169, -0.5812920903053282, 0.1727491134625551, -0.5675779269752266, 0.9147208282362961, 0.1830611451982228, -2.0199020694819674, -0.9634548023443021, -1.2331001534894908, 0.5508934501466454, 1.4920385134462548, 2.086322212802122, 1.213652864646641, 1.2660331032937588, -1.6855551494983818, -1.7619324001029217, -1.2044392248039753, 0.941788061331181, 0.4024855343913168, -0.7482556867929706, 0.5120968728719367, -1.1000724907920796, -1.8188212820520897, 1.76637379897203, -0.8747345232684413, 0.7070145324473808, 0.4544560229839206, 0.08351824545946109, -2.338142847406722, -0.48834242370065695, -0.709909216236419, -0.21671528204207552, 0.6109431365281569},
    {0.9513979845989268, -0.5274086888359137, 0.42980939227451254, 0.3561462614445128, -1.332962387393974, -0.665679993202163, -0.28966811533006787, -0.8171891817803463, 0.5437316409927734, -1.6575575999219516, 1.1092097163125647, -0.3187767037449027, 1.4452297225092325, -1.1684206378901656, 1.415731733103379, 2.1501750906288475, -0.35923303235103926, 1.3807269342657493, 0.8809225223853173, 0.3718866307790396, -1.7733781106557287, -0.37996893967809936, 1.2664250349041948, 0.39060502611034786, 0.9029813244996261, -2.6546204582156085, 0.738451407479568, -0.5970348368415509, -1.2286169851372966, 0.3406358953737, 0.39447731960073695, -0.5082069414152561, 1.6024624476726945, 0.33754984106214, -1.1647661210890081, 0.8154308815969065, 0.9265496793176189, 0.8063924547660951, -2.6201027239047074, 0.47948514788992797, -1.2340474497851, 1.3138795399709442, 1.5286215041208269, -1.4274752962032475, 0.3549997016234421, 1.3107137785992256, 0.3889554600131061, 1.073265262574727, 2.2101279755386374, 0.8279690856068371, 0.9252373897682437, 0.9673376095768669, 1.453549746958027, 2.022191991710842, -0.1728967902992491, -3.230134149154173, 0.854887639268796, 1.4882532063172444, -0.3919322685378427, 3.2830958880686625, -2.031746090937638, 1.2363192263319005, -1.229579832457222, -0.7274086509861751},
    {-0.4386107102808033, -0.5767039931132492, -1.9461071136263113, 0.08602814802537537, -0.39615744242387635, 0.7767154863040318, -1.6556693505175826, -0.793000128034293, -0.3479944835029223, 0.33406582428500303, -0.4014632217151101, 0.5746003465462204, 1.1432116947614603, 0.0319513943033167, 2.0971743629704127, -0.8771030036656369, -0.043401952236062656, -0.5737917137881992, -0.8986623580192398, -0.2923607601123731, -0.6394642199061499, 1.5922687978634726, 2.152339188842918, -1.599584360224492, -0.9687198531430333, -0.6138692095411046, 0.2705709894759899, 0.16328226733173684, -0.5660279957040322, 0.10992206576522318, 0.2272713651400312, 0.937966832769371, -0.7406700502883231, 0.31838275912165787, 0.02123819867063374, -0.23445796347573192, 0.8935221550845108, -1.051104400988825, 0.04384044511507613, 0.603384725283686, -0.23565884639720713, -1.6888117453135327, -0.11381920279125617, -1.014808465217572, 0.2572479374130723, 0.5940651191773152, -3.516810170460629, 2.936719938929099, 1.1570231908101911, -0.18008442951342382, 0.7766808310905604, 2.0357075783874077, -0.3656215230309535, -0.3998204611472478, 0.40676655131896566, -0.797949282373822, 0.30926067151646297, -0.29483559486429334, -0.8101512477904309, -0.015429033483457111, -1.1551437382241918, 1.0709237897510313, -0.3811370326599961, 0.18527719777582988},
    {-1.7543564557108202, -1.1419786752221586, -1.4506381054421387, 0.43787259498636694, -0.7612800800753573, 1.0906379163178181, -0.559434333811968, -0.9246528587488014, 1.5490208346810497, -1.6645230765359298, -1.5917391665587572, -0.9516588169350653, -0.29678052044179487, -2.8769244928028295, -0.8536716404078148, 1.2524023830968547, -0.4149689761365338, 1.3212204971875106, 0.05648942862942734, -0.004426367443764699, 0.5406716925542018, 1.1066198518104857, 0.6125727171636925, -0.005415664331487432, 2.1800271620979257, -0.01439494023676774, 2.828866563342452, -0.19801873238613335, 0.335075441141156, 0.4417900976366918, -0.8375722934015021, -0.2977974251094508, 0.421005282196186, 1.1786406087807921, 1.6987047805210997, 0.5264630777881246, -0.14895073569964903, -0.9944234198679208, -2.2216560241664265, 1.5713451410271342, -0.6142971202794689, -0.7529182187158889, -0.8312584853515701, -0.653162394081906, 0.08204410629993139, 1.712546647123883, -0.5095994727765769, 1.7116043508311194, -1.805929001700884, 0.7697214227628735, -0.09735072388310692, -0.9394353581278737, -0.33736505449641024, -0.4439149423245141, 0.6231689373959653, 0.7167371901859068, 0.2695600185389385, -1.6362375963293239, 0.2145478099063527, 1.1170437213005522, 0.2242717419988917, -0.39593155375070505, -0.4083724481966864, 0.8969799037313152},
    {-1.7417846610837173, -3.003044616083296, -0.7749117395325357, -0.4592872495990541, -1.335937911604025, 1.8040619778950986, -2.4012212573833938, 1.4632231474490234, -1.3779862885535106, -0.9018430752991786, -0.4178211079714552, -2.3389956220846666, 0.2712375699988112, 0.42769765825681516, -1.4179087583143106, -0.07539766702836789, -0.11563194593633723, 1.8376238745666797, 0.5003669299914763, 0.4977348989976003, -1.0290661482473664, -0.07991538020103041, 0.5501216794682676, 0.462729177103091, 0.057201428901744185, 0.646738221892692, -0.37761073220114033, -0.39457187920206055, -0.1398548448366971, 1.004414151154936, 0.4014313514594786, 0.8433832380371468, -2.862063474117488, -0.3822372784298485, -0.9139484033541873, 1.047479091781584, -1.5574813677325414, -0.25573991886176606, -0.046399493344889894, 0.4915952441003328, -2.337437448593307, -2.446348342052248, -0.37697902067948913, -0.4230549392386512, -0.7170960803598094, 1.0384904741251548, 1.240118922281851, 2.817436899137029, -0.7679791075025895, -0.34572976412449874, 0.2392076636646631, 0.28003849649037327, 0.7171356594723889, -1.425970024856826, 0.7274537339266456, 0.29041803328567, -0.602400496697738, 0.2148371259880934, 0.9355097493315617, 0.8090573715326301, -1.6555516554867244, 0.7906280462307739, -1.1121678179564012, -0.1792682780808236},
    {-1.5855496136220109, -0.981393175814024, -0.8651126657306102, 1.6864719399128134, 0.28213048890868325, -0.1799565978216513, -0.111094449935815, 0.7686326272230751, -1.1037453621296767, 2.246854792180256, -1.91204802962616, -1.3407431357187571, 2.153102421744892, -0.6308414706474198, 1.3703619256707087, 0.22958128405957856, 0.6462219667309033, -1.5360369378744685, 1.768820804297501, -0.04041014543262625, -1.4548071613317477, -0.8977420643028289, -1.5790842033982901, 0.03655690253370943, -1.336242388244734, -0.9906383619101155, -1.8118834738343559, -1.131339503615073, -1.1647695625600385, 1.2223075121653504, -1.1271748705117455, 0.0653254220232297, -0.7493986291117534, 0.04852262354183587, -1.2322901293905584, -0.15835378440437486, -1.371367373954686, -0.8721847695179186, -1.4544150008621377, 2.291690563294812, 1.8738408213635933, -2.0700848137289833, -0.6406695153027229, -1.5817823847238746, 2.0106240375803828, -1.7658357166217662, -0.07713837022789453, 2.226745707650284, -0.9158828978013077, -0.3962153724820831, 0.091037363513173, 1.5093014173898776, -0.16217982947114315, -0.543265381126099, -0.5813157328344618, 1.5472809139054717, 0.23050189876401536, -0.5047395359719643, 1.2212267295176833, -0.67924345728246, -0.6550668853743491, 0.3930309330264893, -0.2400313821991405, -0.8718841838325593},
    {-2.656866060455986, -2.053238452523975, -0.2480596271922472, -0.669285835845384, -0.021503730736678845, 1.9334783492694796, -0.5860266735557113, -1.527258600866296, 0.4348052199355329, 0.34520626794048775, -0.7276081413762009, 0.23080350007714906, -2.4653466290208756, -1.359805967568778, 1.3229020141364844, -0.7985029375981606, 1.6780833227575838, -2.332915086500572, -0.19529270471371218, 0.30275241763468225, -0.5847458827455699, -0.6864845967579088, 0.6538777680922795, -1.6010845466481782, 0.29427110982091564, -0.4807884821646076, -1.6458227424785739, 0.20427822176172653, 0.04707129383973572, -0.2386234596111724, -0.6777953670365521, -0.598648789101446, -1.3817563442986658, -1.373843501579991, -0.5385605352298439, -0.30059231979765344, -0.2794532420085411, -1.9723925220257625, -0.6144264928916952, 0.5320862073189138, 1.0381563399672171, 0.33016021266470785, 0.16246007942205576, 1.2100627881764314, -2.055445732297304, 1.9441226279440382, -1.32954067881687, -0.5135601007412157, -0.6118430498467246, -1.8176692806762096, 0.9232925213401664, -1.3394701533977766, -0.5374820952196738, -2.0777701200035943, -0.4875146658765185, 2.6749566748431315, 1.759932267914231, -1.1198765815891343, 2.1749781893032387, -0.9489074529188304, 1.4987699257809293, 0.8821289977608893, 0.9366614597787459, -1.8971458743996632},
    {2.3930848908054108, -1.062389932025573, -0.9981732193642159, -0.7201296177118847, 1.2205226442988752, 0.07001274790858926, 0.41299403022802955, -0.1790281703234422, -0.32703252934180216, 1.3524087921169565, 0.17951621076493762, 0.8327920239514064, -1.8157519009594105, 0.32751550206000024, -0.46698900289227785, 0.20153900242727343, -1.4645151592488728, -1.9249659246570066, 3.2843451102064902, -1.098150673539426, 1.0202068202158652, -0.11050858919398172, -1.6554966847796493, -0.7393295666813248, -0.8019088055675206, 1.5293460358335182, -1.7288082504622855, -0.42716830651491045, 0.19262815807320569, -1.4128772352509456, -0.07655648237449231, 0.5802738653641245, 0.2585629281072565, -0.36303714377312646, 0.619255422913066, 0.9454352506522807, -0.5646315108213869, -0.7636231879697608, 1.2100247416240666, -0.7155693166881479, 2.484088752810423, -0.8935542824490263, -0.3362935604696202, -0.03554037498122605, -0.41003159793431965, -0.21099478112600062, 1.3068858467008655, 0.9039544717692994, -1.8615329905603182, -0.6761250294222243, 0.3568096135171363, 1.0873681615300628, -0.4572252053562368, 0.3437219228269106, 0.3258998978341488, -0.4470008271822592, 0.32881064536901844, -0.929645372844402, 2.3903783737659876, -1.8211935259529048, -0.08188639435406946, -0.38969541054185447, 0.10432128375267552, 0.23662360151113196},
    {-0.5016560388012906, -0.5822601233620077, -1.1585544989863539, -0.04730245506292006, -1.4830785564321245, 0.5945154964198794, 0.15440209170557315, -1.3495991139502868, -1.5246737848783531, 0.6608205633700669, 1.1267338723034737, -1.190315161959904, 0.9954276915631664, 1.2164269000500472, -0.28701328640181273, -0.019059301995177795, 0.8831353022105741, 1.6324464664844511, 0.0712950555134747, -0.3935191542764077, 1.9080751618919496, -0.4209671083489033, -0.5307567844297626, -0.40485130640613176, -1.64451854739102, -0.48689441863853467, -2.3534989287461343, 0.4252379684438464, -0.43215394499207754, -2.1103130683874034, -0.5485910244505844, -1.4063126384781308, -1.3771524383867608, 1.2169463507226213, 0.040384791249893304, -0.4278195698183532, 1.7028626274085374, 0.24148987030225932, 1.504301020136559, -0.1305856885844869, 1.2910823949385235, 1.1737055731426602, 0.4763192257976213, -1.281521474553371, -0.3516473280230792, 1.234196973162306, 0.48755802392470265, -0.6269848281726024, -1.2925420891037533, 1.1891558408163452, -0.9430226741965162, -0.9991544520166802, -0.5129529464413551, -0.3117732282739669, -0.15553501400955125, 1.4360855793396117, -1.5421923625943337, -0.7234510987887697, 0.2373017541380324, -1.3703897804175653, -1.8398164598726716, -0.5763760219945854, -0.08648503106685769, 0.001006919275459135},
    {-1.6609013051698438, -1.370677413664062, -1.3705198565420815, 0.6338877801691299, -0.7050339556338955, -1.9607675271589469, 0.17430242220248024, -0.4019727873247061, 0.3613572415846045, 0.40333254679758224, 0.8897150415697894, 0.6784165836177279, 1.3119248567606427, -1.1080215606073365, 0.8697014331095994, -0.2733473275349148, -1.1437048825781906, 0.15425299745112125, 0.46376272285259734, -1.1934192376121004, -0.36934569607786116, 1.3470904795710834, -1.0789649500672989, -1.2792629604004164, -0.2280035172783883, 0.3504380508300839, 1.1883290582748627, 0.06552853270849023, -0.404658590177472, -0.4873417309631743, -3.0329670514447336, 1.4718577515487645, -0.8879584927044322, -1.0915016097272703, 1.1562480093461702, -0.9290048954876515, -2.6182186783908667, -1.0311773956767396, 0.0057035297193869195, -0.634378300017391, 0.6213252926609701, 1.5594396754803481, -0.15767252013349134, 1.698711212812003, -0.7529285013578179, 0.43520737640262586, 0.9579568519560213, 0.11115835393285836, -1.190531945803441, -0.35806460224751757, 0.5947966962400832, 2.1050074869195825, -0.19758434508447148, -2.5673416084701373, 1.0557831969640896, 0.12984630357585503, -0.14103159475763408, 0.2837070638358438, 0.7791887424381432, -0.3911250772619842, 1.4313740039283935, 1.3055901674278425, -3.0625393960713136, 0.3282414956312077},
    {0.16785559227378932, -0.629417179282496, 0.18708332058601274, -0.11925116603188692, 0.07339474821183847, 0.6429142666227824, -0.8237159762307477, 0.814338661356467, 0.41196218146743047, 1.6936659586220117, 0.04844341868545456, -1.1282733018447373, 0.05568658850501099, -0.909058089756007, -0.5756752770906701, 0.674828548661712, -0.7424744950168273, -0.06710846921920735, -1.497121219514201, -0.1600861353402379, -0.06615588095042764, -0.8764215274980399, -0.2147360302387924, -0.033326640197441845, 2.6427246641404403, 0.8332095294760693, -0.323981145594767, -0.0126390403615466, 1.4947037175662534, -0.9185692193338644, 1.0688380915466813, -1.8035801276201804, 0.7023671441962839, -1.5542426216568552, -0.002802640622131603, 0.35258771926561255, 1.187602264227215, 0.4074810284012097, -1.7365509333210416, -0.8921210650456572, -1.0489744946879862, 0.7440829166219971, 0.5296800431501504, -0.6190271088612339, 1.815344293545078, -0.47432851865977405, -0.0829664282361524, -2.1857551036547793, -0.16305907237884326, 0.593375478006342, 0.43807463310022055, 2.2754528223159896, -0.8966450602044549, -0.7993154521747903, -0.5879721485038236, 1.026730225907559, -1.4673647377111305, 1.082002308250669, 2.068299955249869, -2.3476296278672577, -1.3796762256273585, 1.6188647673894103, -0.4594742356255429, 1.3007562050114783},
    {-2.462309455998165, -1.868103821459085, -1.5949043877190805, -0.06853470257958179, 0.6834309887866064, -0.11911656311194117, 1.9282188885744047, 1.237544110878801, 0.43362208811209085, -1.8509546655003601, -0.5426671352018142, 0.8311219855552736, 0.1750379441112649, -0.6393409025460777, -2.39510379375995, 0.14501780532251252, 0.35920507222578724, -1.5493171958169516, 0.6885807176974719, 0.7158318674480721, 2.748983891535445, 1.2005782064304231, -1.2136385947491533, -1.3023877618135042, 0.7732643324692846, -0.6291915490514228, 0.4087126297394736, 1.532277840323888, 1.2174735117809043, 0.24720078346622518, 1.1925059239059055, -1.1608240693890286, 1.1557482045011822, 2.281988121214117, 2.063343928276521, 0.912214083207585, -0.8146595027038274, -0.6619137897018393, 1.3526550597140847, 0.42317016524780426, -0.11356794649219987, -0.6975341383245324, 0.06462386724437967, 0.6059758489537055, -0.05746882758618848, 1.1680781151631134, 2.3352725625027464, 1.9654961125083352, 0.5680043981031743, 1.587982024041182, -0.608857271688649, 0.0385343722945807, 0.4411392929174529, 0.336074140624248, -0.9174902377118952, -0.9618090247308336, -1.0448711004229199, -0.45721366815493986, -2.4274418490270167, 0.6456065814034814, -0.9765237726783044, -0.11691233232021986, -1.2773781142019855, 1.3292753186613897},
    {-1.723137101901435, 1.4520542696113206, -1.512648852397546, 0.9872353494411896, -0.8431053125770472, -0.39834877463966223, 0.15832614800139858, -0.9530811242228894, -1.0483961981492802, 0.060559148356602595, -1.4816005214644017, -2.1276843567801187, -2.1790299624230958, -0.6718746200839067, 1.698604395517344, 0.9951109025465495, -0.18211564935078056, -1.529329575673907, 1.4430647721883307, 0.7912751633853596, 1.144879885201342, 0.49141731961836543, 0.026129087418970395, -1.0845615786118201, 0.042851248305147985, -1.5533515664576647, -1.909393315127958, -0.6309354870215238, -0.8417711022938941, -0.03360640015595027, -0.36495083269495543, 1.526275230349468, 1.0124481027011456, -0.4815868569634371, -2.9351025318422446, -0.43424261595555985, 0.6130868279524008, 0.6300382738524708, -1.9193337353712339, 0.4176519506683011, 0.5996040259642641, 0.2844087934706347, 0.15746625559475816, -0.9698763920568849, -0.42209769980034484, -1.1614451924532059, 0.7554876387501472, -0.26997319059078495, 0.417878187429409, 2.3519475759437616, -0.5284833738187522, 0.4720827008272101, -0.8697509069439175, 2.6121234190853753, -0.856294741885199, -1.4621061111135774, -0.09223595386289718, 0.0939923177115298, -1.7082224733138576, 0.762552063237065, -0.8303336751993365, -0.34142949009438933, 1.2453457852119718, -1.0669704466010952},
    {-1.5293439405025795, 0.5784966408484304, 0.8486156864639745, -1.394229658198207, 0.4641285416502059, -1.026667053172083, -0.6189134693011377, -1.893277380722537, 0.35869836659574683, -0.891417695982921, 2.193175179602956, -0.7999270611271048, -2.7061448775169947, 0.3692009739821446, -0.8762658229218065, 1.4838210604096982, -1.2575155883524225, -0.3252466986003016, 0.2547791607050599, -1.9749038395305196, 0.5773890959279094, -0.6565948663192019, -0.8140687496132187, 0.7345056279932075, -0.13513052993741068, -0.6294167574181474, 1.40123147032014, -0.7812935561134254, -0.14399027096951927, 0.6457381553555054, -1.3280299971832195, -0.7937376282744559, -0.6057743554720221, 1.1598599599601667, -0.2747555102493343, -1.4176357191912268, 1.8883678629451894, -1.760330725524557, 0.6943915411469415, -0.5566734511103922, 0.018287618951635488, -1.5005458856811877, -1.1551373801152827, -0.3364698079861612, -0.4712448359218889, 0.6821207337656577, 0.24016495967515072, -1.3535647148584427, -0.7279796086071324, -0.263294951055163, -0.8714715717151756, 0.11904278857234987, -1.2635028315799932, 1.6039376508160763, 1.1909411837200705, -0.976412972963092, -0.08775835212238918, 0.24935243719909703, -0.03546292932296874, 0.6711874048698158, -1.941146866561363, 1.2384632333865326, 2.106364492725377, -0.4317611454254699},
    {-0.5844612729189103, -0.8070562031635412, -0.6977901672382928, 1.1593080745497502, 0.32049883047679906, 1.154042481245511, -0.1019946959517994, 1.2132070654107487, 0.2482110437995561, -0.48841909700430275, -1.7053673671086738, 1.4560713248030377, -1.141528075408865, 0.37421193038097633, 1.4723453640038169, 0.4580054733282639, 0.4371987778115883, -0.031229209980429214, 1.2653795358368718, -0.4147569623800622, -0.5759648479902655, -0.43300620255712957, 0.6369966121917521, -0.3748764405315618, 0.6934057966128467, -0.2537786699922562, 1.7192755741254233, 0.7510105522697633, 0.7020587798815338, 0.9099936165956102, -0.3835668609326015, 0.6528829226604836, 0.1794736108939465, -0.3883735776479016, -0.8512460908852371, -1.0148173809513066, -0.9414869840407583, 0.5578811770141539, 0.9706127258613079, -2.2695034373403784, -1.2509761800042858, -1.2707936022540904, -0.06705062032881365, 2.272663768184155, -0.081958022858874, -0.9771960451960193, -2.4265620188562047, 0.9843481098751349, 1.4229779122075232, 0.9682119271497206, -1.6439625537230487, -1.369424176578686, -1.140896168887799, 2.4519495153187196, 0.42025974633461227, 2.299049609602188, 2.325083869119295, -0.0010882175002163209, 0.18679607363839823, 1.5956783698677903, 0.06915775997159039, 1.6630251330104966, -0.6000293033670424, -1.235141540194715},
    {0.4385138046941196, 0.16255946550141662, -0.6711554802621553, 2.957580868987212, -0.6093546333207114, -0.04575037239860455, 0.1386490145196441, 1.2909161843566432, 0.36065533175210784, -0.04905593086027112, -0.3476654348616883, 1.0403919882943442, -0.27767695284469657, 0.6220438818079388, 0.8285475880925898, 0.6964356783060137, 0.3610431922445592, -2.606501815375177, -0.5489524987117479, 2.450680662105238, -1.417288972650707, 0.14181556734747544, 0.19054793062143385, 1.0482152706629244, 0.8060170329350922, -1.4600798209643362, -0.40484659195952766, 0.7282865574650423, -0.5228855327051535, -0.4033668445785713, -1.6483739906097572, -2.4741373249308327, -1.8262691542423979, -1.330937820381717, -0.7959805251959753, 0.32770083629563584, 1.3785266123770494, -2.096452628542878, -0.41809720518887755, 0.8204071877732372, -1.0806219232436398, -1.7408823910880855, 1.1939174078478114, -0.16159330608915018, 0.9650883242252398, 0.8977548610037663, 0.8096344487680963, 1.395758685362885, 0.20330850939481088, -0.21355034977659962, 0.405831328795904, -1.8413700775284072, 0.20868460434177458, -1.2638513445196657, -0.7511502616570707, -1.2506648350467002, 1.6549954629676882, 0.5160068377614703, -0.8592908650968283, -1.3289221731698526, 0.5010496655907467, -0.5426550581829895, 0.05386404155630784, -0.8438226726364263},
    {-2.6256383068750075, 0.3830340037536658, -0.10402286966089294, 0.23910068954222438, -0.2249181292963689, 0.12015549630783505, -0.4342984483956929, 0.8164970384887463, 1.0804396574685382, -1.7804640708709152, -0.0029318966566954045, 0.9466650459811126, 0.6598902202475103, 0.08189646224058157, -0.4147476460311938, 1.2047206713729066, 0.4533492019495555, 0.5336524642983619, -0.6889163612707434, -1.6590831798233876, 0.45999904547237497, 1.0172287960342834, 0.09814345660682225, -0.25705686856951687, -0.8825916213721444, 0.8841280070124707, -0.9385298025232216, -0.5789405722246468, -1.6911273002972829, -0.6454130763664039, -1.5271069931182029, 2.057127951663902, 1.4923594794450568, -0.5784557092896698, 0.7944303055270411, 1.5298718405566645, -0.3306214980431187, 0.6034847243921313, 1.2887192320722263, 0.9776200378618496, 0.46730269711495415, 0.5526497905983595, 0.9931101946037979, 0.7146681434866404, 0.9230771802264289, -0.16296964846420137, 0.6312864077516585, -0.25724104122395214, -0.30075193776126435, 0.035463378665470495, -0.8103306125452027, 0.35503772990138344, 0.8299221759704432, 2.5184386969866623, 0.7387056779053175, 0.5281118518261505, -0.18553498762160334, 0.9289287833673583, -2.712481930843146, 1.7489337904339701, 0.3905535828282944, 0.24714353161888106, -1.1050790029214825, 0.8368774494475789},
    {-1.0375656626026384, 0.4235391028111707, 1.542454298188225, -0.10770266700518862, -1.3813885886944994, -0.10255905392196271, -0.7443494860652565, -0.1242350375255399, 1.3154211547897863, 0.8530153513711161, -0.7274099209473935, 0.8850689555955785, -1.4496973518800402, 0.10190507505515348, -0.4575283171681311, 1.0976953989820972, 0.3790500652980659, 1.6226797050226167, 0.8313511350737756, 0.278147533465204, 0.39566015205150595, 0.07925635024365593, 0.9012198243802135, -0.694728696870872, -0.9638231939817404, -0.8569609582181549, 0.09255384593697433, -1.043196401286517, 0.2573549228702881, -1.3792544866739602, -1.3295840971078061, 0.1455564637061369, 0.13516964521370434, 0.7484041705624417, -0.21980274175133524, 0.6235868553163147, -1.13351746156402, 1.0603171348045959, 0.8047466681168224, -1.50630950401795, -0.804709392108286, 1.4426566139041865, -1.0339473831170027, 1.5554770496943986, -0.004129597594565881, -0.403776077115613, 1.1669677952182411, 0.9124395815644126, -0.920975992429878, -0.6226039261765846, -1.430679854861626, 0.5657401761746644, -0.3664198011129438, -0.10366560834447532, 0.10682620342642689, 0.42681962922622163, 0.9941052773512165, -0.7425463889121171, 0.6779731971955342, -0.44789672914338285, -1.5017422956351985, -0.8994781611808655, -1.2827252090050763, 0.2012998780764964},
    {0.47544308682551945, -0.09714635250025688, -1.67532632722627, 0.008870441152461012, -1.5146287467449224, -1.2490094330422346, 0.09277643028496599, 0.4806250790456035, 0.6811520515637531, -0.2014990412338599, -0.1948689015497817, 0.9408936517424096, 1.5546606332005681, 0.7788992255068447, -1.678835933560417, 0.2502298869175844, -0.27028938225145327, -0.7813733240923911, 2.1343551316470797, -0.09855325794576714, -0.8984200510655559, -1.6094603446375002, -1.5888677670641094, 1.1952435182653494, 1.2538123360985376, 2.406210480815773, 0.07023585271966551, -1.1213833984546893, 1.1610380121417423, 1.2397922799429972, 0.6222550846310793, 0.5016296523391113, 0.6393437100940491, -0.4061049580318977, -0.3820494740169815, -1.4430669922254706, 0.9932011903034698, 1.817925452091762, -0.12565238963661424, 1.108311179979018, 0.2531099883983041, -0.7602460854388804, 0.7391336146846479, -0.5601202385472847, 0.5639310124925497, -0.51745218131368, -0.30610909981602524, 0.3310132946229523, -1.3033660870714199, -0.9064983870380239, 0.35912454664188903, 0.37538966922618633, -0.9448302790830391, 1.563262144466949, 1.3863522115756426, 0.7668446284097633, -2.8097028942751985, 0.4831741961293477, -0.41306176510364423, -1.476252673089564, 0.10980107689010525, 0.00948984323397519, -0.3763036807911094, 2.195540441357707},
    {-0.9493631453509164, -0.15646157858989584, -1.0768298920774046, 0.36090423613532363, 0.24799260816647273, -0.952622895911245, 1.7893686456340616, 0.6768570506036834, -0.24267806318035365, 1.9119977613079677, 0.9053107502106381, 1.3655938963953116, 1.6900507066934556, -0.04065739574820522, 0.8806928086340682, 0.9726306264744408, -1.4293581104453854, 0.18788354601661883, 0.5147343103541012, 1.0737013823602704, -0.8248174328477194, 1.2446517283893763, -1.617272771575333, -1.2852355690369741, 0.32573067744038847, 1.6510131778026, -1.1883788420844734, 0.613978861182264, -0.670575027384176, 1.8229096596976537, -1.5129625882178446, -1.883447167519495, -1.4300367020514073, 1.1230402800142905, 0.7941425627363919, 1.730661691090489, 0.17187541258633807, 0.3237525061266715, 0.013780792251705976, -0.00038855393362968873, -2.0434796238403363, -1.9545133485559676, 0.1748526051841574, 1.4084909877471319, 0.6446670769015921, -1.302529862986485, -0.2519167544064029, -0.6073590127097243, -0.568901540686631, -0.3267034672752027, -1.0210753625145905, -1.0185560989872935, -0.27381238830498245, -0.7713988033035102, -0.8333207408192725, -0.3786452719622404, -0.14366719737472172, 0.46230348502436375, 0.6772021620634994, -0.6260729315404177, 0.7985435391882799, 0.16363149986639006, -0.5727085242989327, -1.4843566335592406},
    {-0.7784759946738561, 0.41946270670542396, -0.5831225865421172, -0.20411219331479444, -1.4248872527106302, -1.2299370869101163, -0.44388939948303807, 0.2605047740251206, -0.3109421409205322, -1.3090467702083834, 0.19432039076419844, 1.1284868155065537, -0.3664963238205923, 0.3284562911000749, -1.057586892731301, 2.7838522752667805, 0.9381163293115506, 0.3131733284267452, -0.8109996287991176, 0.7533201500222516, 1.8521256827048864, 0.47379764869002305, -2.225940226056513, -0.4805362889825657, -1.1352468568458973, 1.2277457841111155, 0.2715825302054253, -1.1438031294318958, 0.5283526268946668, 0.2858770271728008, -0.672037821829972, -0.7219045787900537, 0.5025774142418252, -0.31989015709946095, 1.8216416168813332, 0.9599924164946233, 1.6865764685146494, -1.8659571530521861, 1.2090678189401585, -0.30201697110955894, -0.7356898153107573, 0.2254487911486917, -0.7706970938654998, 1.940952801863859, -0.09609528414155542, -1.8807793612297468, 0.174467356947132, -1.7686321251025994, 0.25090680848539204, -0.17559500105107195, 0.8902092956781857, 0.9737601373025739, 1.3846691470346963, -0.3738385047738246, -0.5513261329506395, 1.3662836330039294, 0.8938275369072296, -0.4612122151099255, 0.7092442323767472, -0.31070692810735173, 0.473281034494311, -1.041151595468328, 0.9694892443252081, 1.766954710255142},
    {-0.011832880911607006, -0.8247270919461507, -2.008289245633323, 0.37995716841898153, -0.7065509716673308, -0.25014096042184963, -0.5631546741560565, 0.534566006937553, 0.974706434876626, 0.9098865760296083, -0.6431361095429297, -0.3530515504165035, 0.7755450551737396, 1.1013650202646468, 0.756573552921203, -0.8941936402221582, 0.5176916907347674, 0.5896719273777217, -0.786026155981011, -0.30620879575996934, -0.28519026742556625, 0.28900075768392897, -1.3948692350791574, -0.08325700425145949, 1.2064969174418156, -0.35883152812106606, -0.8511546966585991, -0.38421495290569635, 0.18144089307120598, 0.58449815858924, 2.2242846861542147, 0.6867590694591511, 0.47448316699141535, 1.2771754648630986, -1.1323238538333287, 0.4558386066946579, -0.28591349880830014, -1.1116707071176848, -1.1948963868730254, -0.3306088241742662, -1.4467136684284652, -0.92324580064145, -0.4989107325833061, -0.9508464469952881, 0.6336963284428844, -0.634269123165386, 0.27619045322429264, 1.734827557941674, 0.2987129412302865, 0.03958559815626878, -0.8234107628753033, 0.16000655859664492, -0.1683214938846406, -1.3987495314467466, 0.184388607182808, -1.498528888696863, -0.9625014961692258, 0.8455186454126552, 0.8176578876240944, 0.8969569118404487, -0.1963955849630137, -1.9948292827729173, 0.9523625474128433, -0.670596103887659},
    {0.0959440023998026, 1.761876333689318, -1.2041624692163564, 0.4629901505252403, -1.670962224877284, -0.9491129001274544, 2.2344883911590894, -1.478301405481323, 0.5378626490320946, 0.5691366737469266, 0.7957674692965623, 1.1958339849731088, -0.74392408950974, 0.6084023325129739, -1.3548682816968511, 0.10249300732316553, -2.7896953094944, -2.5928639244167, -0.2670834759399894, 2.344491765577297, 0.7327410722948722, 0.30509590404500214, -0.7659648014703656, 0.9648770283649908, -1.5201461159168264, -2.0913769204650263, -0.3738371431042127, -1.8952377642449085, 0.9233445353929809, -1.4618636655497548, 2.3956510386392433, 0.632505791124062, -0.453965257779805, 0.8897479268716847, -0.23216202329583357, -1.5177949729059295, -1.267722009977377, 0.6339861440631155, 0.5423465968518342, 0.03322210927185778, -1.3765698987894208, -0.5205264195658166, 1.595828102617272, 0.1614286734629287, 0.23405332360240338, -0.4207626355771869, -0.31736282479781913, 0.5240495636198165, 1.3952438506473295, 1.6668578157474683, 0.9112738301383002, 1.8959978276343865, 0.06911538181250787, -0.10465883093200033, 1.1765567975264588, 0.4651924357235292, 1.6704835649570078, -0.3497769626540439, -0.6250708990690812, 0.24845171162578678, 0.10390962877341163, -3.9254451422226384, -2.2836175185181613, 1.0418539679804042},
    {-0.8384184840917558, -1.3143346116645513, -0.4805961938087643, -0.32176032434900115, 0.7685363082175637, -0.6928523398651766, 0.7619424929969537, -0.024992576312770902, 0.12206244842298658, -1.3531106603537109, -1.4144573032015202, -1.3075880483942588, 0.3036631389629298, -0.6895391193752964, 0.26669017635628106, 1.3510862872250218, -1.4077298962110065, -0.5457795885002473, -0.05694094162975365, 0.4231712524992641, 1.2237224841019771, -1.2189102091291544, 0.6070373636858523, 0.30002381742586504, -2.216934164531843, 0.3752092781251359, 0.2242214991034674, 1.4539655301966035, -1.6297893767621487, 0.19977502868047398, 0.5737934085334204, -0.23803914746417187, -0.7800501994292597, -0.9631944573348471, -0.4815428050459164, -3.2007781357755105, -1.132403718625377, 0.29626109215671426, -0.5648133700364648, -1.7735734963027798, 0.6976207945937754, -1.5224737811791749, -0.3463583835928641, 0.3666963344187518, -0.29831666770533005, 1.4464389667927309, -0.30745709258514703, -0.7994754032259755, 0.31409262950509576, -0.1291235859323131, -1.2577720598442117, 1.5560910194842885, 0.32973660575388386, -0.9276226016099269, -1.0447895810977852, -1.0272406743130236, 0.33274030328584703, 0.8838768901515082, -2.248936432728862, 0.8425594404138865, -1.035490869108353, -1.8701239072371856, 1.8238127726936428, -0.9170685903662333},
    {0.0491554779147196, 2.4118216595457325, -0.1279921119692413, -1.0573989979384115, -0.12456752224027724, 0.3731520888322424, 0.8617378128011378, 0.09775791411838615, 0.266737694888556, 0.1594453974256366, -0.0024468880404627307, 0.6813600095804063, -1.7762898685596273, 0.38253015343229957, 0.7380919115817275, -2.846757464189002, -0.7363555643428306, 1.4590492345091755, -0.2451485677416713, 0.7687909930611178, -1.8539407286737999, -0.8080287400199747, 0.9457460340034645, 1.6810291448436228, 1.0314844945928137, 0.01344677219661741, 0.18352044813451926, -1.3864071931126791, 0.9479138441655712, 0.24379815506743027, 0.0780542883075038, 1.7352108817964018, -1.1606498099542222, 0.009569101532791367, -0.7508340407110813, -0.5025843023394713, -3.352404217201828, 1.9340237036946404, 0.21075525333908593, 1.564151790568504, -1.6976228591495692, -0.6585247446771113, 1.2964579130953413, -1.155766217982233, 0.16559729300021755, -0.44604237473194513, 0.461329421653642, 0.9149031460604865, 0.8664674516826714, 0.4310186440385295, 1.4473542171653766, -1.06691178808224, -0.9964512126802819, 0.40342496022854024, -0.30214238470641996, -0.4022256641246481, 0.6000957076754937, 0.4932707016440144, -0.25448191526424585, 0.13738031228866704, -1.3872617516987797, 0.49909387801119787, 0.23019288584237707, -0.40772070136983607},
    {-0.001837519239176871, -1.4247794339812831, -0.4866972316747088, 0.42010047832099523, 0.8363895448279536, -0.2566395823786336, 0.635571501137955, -1.5438752142453414, -0.6822139393393345, -1.5333864251043605, -0.5628761102014628, 0.2592929617941717, -2.1342484685541105, 0.31015509255838913, 0.36909062158843847, -0.5020980147616115, 0.17174002628171528, -1.2149351378692534, -0.6886864408061046, -0.3619351598188101, -0.992911425192945, 0.3924509585983361, 0.030997278696167745, -1.3323508661554777, 0.8938427638256963, 0.16178568332140567, 0.7775280292591817, -1.8553487196214693, -1.412720694031176, -0.41458816462025677, -0.13285930436431756, -0.8170230895384522, -0.9669546011249177, 0.31700537843213666, 1.4778916619127787, -1.5751618706822874, 0.9796374761652556, 1.288224322746606, 2.4867548074035004, -0.7149852474331356, 0.10563948604457346, -0.2526726735154654, -0.162180708762722, -1.344807919458565, 0.6795876460704113, 0.052660212858692323, 0.5421312734890348, 0.060702218638737586, 0.9811937464853651, -0.5466193902807555, -0.4438700777489727, -0.6951938979829496, 0.789352520535066, 0.6964725384945957, -1.684462833508219, -0.8572357700266772, 0.0736228549277062, -0.5425335129079052, -0.8192950183496152, 1.0452389816881649, -0.7504931455668018, -0.5112067260418911, -1.1983972127221478, 0.9320284947828318},
    {0.7695754794786952, -1.0434804997907596, 0.8739195880677958, 0.7314314686159774, -0.6478927079075093, 0.11982175861687241, 1.1242660331316183, 0.8365964268411893, -2.4163072062156377, 1.4002038888122093, 1.3899467638613365, -0.5479317467839017, 0.3488266219657979, -1.0911538345470129, 0.4590887629534438, -0.1957875406811058, -1.5419591281823932, 0.24433963183657917, 0.5911320776222798, -0.8548642073145274, -1.4677158187564368, 0.47202257685442395, -0.8918326256177883, 0.5856322085292146, 0.36495181632699714, 0.02035897297145591, 1.2682003375629691, -1.566099786515172, -0.7944196874450091, 0.32003225945510805, 1.2595658552088855, -0.31918642358429566, -0.03434169631619118, -1.0012933837025595, -1.0316551685881294, -0.5404128906558848, -1.4362899029433547, 0.5881217664068579, -2.718900935689016, -0.20693541932998596, -1.0415043505509665, 0.7418002681259384, -2.4546686839671668, 1.0570214925981665, -1.4582324456390707, 1.615453134498039, 0.11859871229973873, -2.003781831519437, 1.9755909757201493, -1.0435551509195367, 1.9032202348193987, 0.17992737325252742, 1.1749802781878176, -0.2732696782352968, -0.12141266769160386, 0.6264821978614917, -1.3197784611667467, 0.4164026300751071, -0.02988550823548256, 1.5973548608564156, 0.5289705551429684, 0.3480458441673874, -1.099746302652657, 0.40607203233576783},
    {0.44485790810810283, 0.5199554685053163, -1.3122226400544779, -0.5269840430189633, 0.12055343725954872, 0.27842176885754316, -0.1815521858821333, -1.350173368810623, 0.2405549769479585, 0.32809217523652073, -0.5240915541405117, 0.4260573236553038, -0.3587139828005662, -0.9006992917287592, -1.4070623116699528, -2.347130400583221, -0.2841267619633099, 0.2945799478074516, -0.8733883583623703, -0.6841690801062574, -0.4851126290132677, -1.2715842713070813, -0.0030238007178922956, 0.006437877631618415, 1.3813857388453612, 0.7958143053138587, -0.3683119961635356, -1.1630079693659343, 0.4040463632784225, -0.0629194970907263, -0.9011190181121124, 1.907181336071848, 0.5966091132439538, -0.6458417543060248, 0.5711938965126403, 0.3450906501832376, -0.25188682539717705, -1.2236557594510693, -2.949224122307527, 1.9689948944361748, -0.5856876942274136, 0.2962658226170755, -1.935077854366531, -0.19359740154888172, -0.0031415883506735703, -0.14547476473983734, -1.4365431990959212, -0.818862749092941, 0.2096105396535156, -2.131299675853096, 1.3603714759210455, -0.9628081067959413, 1.0014399173843478, -0.6403009161608106, 0.7060568885019399, 0.7028070618423635, 1.098148440942103, -0.16911401525322534, -0.8953698648687697, 2.398804715159146, -0.15577754827748172, 0.49430690749994044, 0.9432401295744411, -1.1911820656465621},
    {-1.2136031818147957, -1.985217561045806, -0.5959290113796017, -0.3480580818034319, 0.9198329534133308, -1.0878277610611158, -2.260037661712197, 0.3314802655041816, 0.11334764659566982, 1.3034141172077391, 1.4867125665057648, -0.8369166013520101, 2.146759652282111, 1.0983869912754518, 0.510574838596023, -2.2810705964061486, 0.9389469354488519, 1.6611607135913768, 0.19191218031132914, -0.9428452095871247, 0.223269404952569, 0.8287264267547917, 0.4871274471093004, 0.41154606512104447, -0.9369035747568811, -1.4983890582236714, -2.9744288521233577, 1.9117753673802091, 2.096070402941358, -0.3373802448363345, -1.8645519885936381, 0.0710342989922437, 0.3625480530090286, -1.244111633391052, 2.346012111249212, -0.8474262259337962, 0.35466341694202647, -0.8855322933656417, -0.6638736960113194, -0.34084754770246223, 0.21823366281814885, -0.5667519219800942, -0.5869307851334249, 1.8068103484493288, 0.08907179232943858, -0.9157657504864047, 0.3670052318586747, -0.23463760506018877, -0.7821754555438275, -0.7881335161358343, 0.09632381748042879, 1.352048722876574, 0.7088097964373185, -0.5207198749437831, -0.5206492037344058, 1.6737511198298072, -0.11258286181711086, -0.612586825504869, 3.2395635544031283, -0.326837779801954, -0.9017555938568236, 0.7894148854750181, -0.2449062728546556, -2.1123588864457656},
    {-2.2356485807043853, -1.4475733079400308, -1.4202932099160903, -0.2609814106814995, 0.18153557571140902, -0.275473352594356, 0.19889335647794237, -0.8817996898604228, -1.3522242261287951, -0.14936407415838415, -0.403259090321452, -1.994179115412342, -1.437078322905087, 1.0745238134170187, -0.4046110294395792, -0.746012999591537, -0.6108190696270259, 0.16620177984092707, 0.46239574919934257, 1.1332257149521294, 0.7185572756041673, -0.5829183131559534, 1.162363524045265, 0.10242604967681611, -0.4147675633155694, 1.8437785249243577, 2.081818075533032, 0.22717433382340327, 0.16434973393257443, -0.05811195135442173, -0.08225925520462359, 0.8976568958887555, 0.6705690335373251, -0.0816527367058564, -0.30563825046001764, -0.48144869207009183, 0.5251838579260826, -0.32942050701659714, -1.9908955904758585, -0.17865762879499955, 0.28058747987819854, -1.7115095041068262, -1.3025725952836513, -0.9440709473034318, -0.7651544475273725, -1.8631654554208432, 1.1776089978086746, -0.5764448936907813, -1.7489307351392551, 0.7345332784964309, 2.6803768256389215, -0.3262981804695765, 2.283020667677971, -1.2226922005342873, 0.19442803836552613, 0.1506429341823188, -0.6150924434029874, 1.7053723498448794, -0.19804739972300955, -1.3972920926353045, 0.04613520849968402, -2.3328167307167873, 0.14457365235593803, -1.001696555574314},
    {-0.08321897741517491, -0.6706101040981862, -1.0914265570488868, 0.6312286989010338, 1.345428430789794, -0.23598866509624536, -0.5253752196861428, -0.12578977879929196, 1.4715143911011617, -1.1781381617885573, -1.3943161833371183, 0.253187339209911, 0.9875496220537048, -0.7126408137878834, -0.5210638496685415, -0.7016445700120658, 0.30884907432142, 1.6715068094602865, 0.7764166459849947, 0.3289913689855507, 0.021679290352542183, 0.4640904921473021, 1.557306442731674, -0.5713280324547885, 2.3345251554259314, 1.7962824744575825, 0.3457893034322496, -0.33165478353217714, -1.0147637761284065, -0.6008728307817229, -2.0384811810843924, -0.16746869650149698, -0.09846156190488804, -0.3996335693098463, 1.020277740772852, 0.3872272094976422, -0.3037647065613908, -0.32610305396033207, 0.42660876266825937, 1.464490910857394, 0.07675473431333216, -1.136055898004826, -1.4669500590027365, -0.4172870201659882, 0.6580502831200887, -0.9772511869012976, -1.3682166673315594, -0.2870454889640121, -0.5584294005101136, -0.6884242776537493, -0.4011394662752743, -0.19256653622204462, -0.8476620474989505, 2.6682250201892996, -0.8624146704272468, 0.786550979029962, 1.2466512598876254, 0.1222712684469782, 1.5344342892613625, -0.23484250909846005, -1.2547119180939634, -1.2285475802271224, 0.17928722566137237, -1.9279217268597464},
    {-0.6208810707314194, 0.7799295785674993, -0.9541199531946329, 2.494992433698346, -0.686628604593921, -0.2766479957681744, 0.16681833316406447, -1.415440350191751, -0.9266736385830772, 0.2335584964138722, 0.32173260018964284, 0.755518891324736, 0.3054414273153105, -1.9843420260289433, -0.29022464277857724, 0.1691714464434576, -1.8505142980429177, 1.9147841257304195, -1.3854283487083514, -0.2508577191014722, -1.5987946392872807, -1.1469125926989379, 0.7194204181180748, -1.87405550308451, 0.035783387125998815, 0.5852940021992041, -0.35409745903987755, -0.6425150713231264, -0.0659166566227075, 0.3254204116514962, -0.18144136250797788, -0.7144317329974056, 1.2726216967920365, -1.5794700810428062, -0.2584973915193826, 0.7889063102107658, -0.296967822761177, 0.236576848124602, -2.65868235540045, 0.7141551570849861, 0.5026357186814471, 1.4804320801642077, 0.017033465795237537, -0.462926163576242, 1.5048481959157565, 1.5144365331076153, -0.02966568088626522, 0.20699094083010527, -1.7244403297060729, -1.8274991692113975, 0.2044556737279416, -0.2073427240424041, 0.8826847456364312, -0.8465342191519653, 0.19965024344334037, -0.37612451938658165, 2.2455680241400517, 0.887966263725905, -2.409150113451491, 0.03181588801482823, 0.7786909583636399, 0.8909199690246894, -0.013916738678915444, 0.735531946325295},
    {-0.33279709316451817, -1.5113496901252683, 2.124966403276394, 0.241995674587075, -0.015114014218291857, 0.31966817346440296, 1.3545961735339116, -0.959064409470258, -0.21484662677451644, 1.5241031451499618, 0.08382678466438859, 0.5181882714036311, 0.3665817769623543, -0.19180988415684658, -1.2231657934328908, 1.0529074391361954, 0.13735827355296237, 0.3523836488418315, -1.4749748324539576, 0.7789430523948608, 0.2638580823247286, 0.6124289006858014, -1.2820045948402983, -0.2287070515615199, 0.6042431350901116, 1.2724021395668001, 0.1819866996714634, 1.5351638038101565, -1.160850175356349, 1.7439839081822943, -0.27607266187277, -0.1097769264006311, 1.0157858138729068, 0.27418550487204957, -0.5868572627986867, -0.9501787031581815, -1.6712634506309398, 0.08325302521405967, 1.8185106330121592, -2.093201374033946, -0.14488073754667907, 0.45002695996312064, -1.2874485555291848, 0.09621242398958113, 1.2812544205251568, 0.4104636580208765, 1.5744737789962715, 0.836172980700995, 0.784988271782123, -1.4014012426581095, 0.9241355376395599, -1.6291264668244834, -0.4886641186430702, 0.27674375338271934, 0.21767419622800724, -0.14057933146368834, -0.8473541190373189, 2.2324469074898965, 0.17582653166065232, 0.8489486299930437, -0.9781212163173801, -1.5860077250229474, 0.0730238759074359, 0.23368212551682063},
    {-0.8999579449178022, 1.3352745906428707, -0.35498617458878234, 0.8942266833236729, -0.9477747070967875, 1.478176142932305, -0.07049435174388816, 0.967842472176531, 0.2572750826946136, -0.359412500992645, -0.4536273870682545, -0.3304724056339708, -1.3554204290944654, -0.16237347633497415, 0.5493626548771448, 0.8266524696981945, 1.236642361145919, 1.1284337444170771, 1.4487360728253464, -0.9634988626779122, -1.1762001238314257, 1.3290291638594949, 0.7056710910018426, -0.5051340183188195, -0.9327723062294264, -0.6548476706734544, 1.8444252749577095, -0.3422606087437965, -0.6727394624664247, -1.6954812751671253, -0.7055098463425151, -0.9492087519479507, 1.1456901454429946, -1.412300581064753, 0.6671346780027383, 0.0212199803339748, -0.30957279072617977, 0.5334049902481324, 0.14711231600767943, -0.7225606503415155, 0.1270863441964308, 0.08121717487713534, -2.4016790054204726, -0.02565362829919036, -0.3803106706168752, 1.3949060345112523, -0.2022065977818118, 0.29686063581437117, 0.9604773368786413, 1.187946921359543, -0.7211403393468433, -0.15013155671212325, -0.8903933159189582, 1.9462068749000438, -0.9976420583228606, -0.6183223975701027, 1.8839754301136187, -0.23478343593908668, -1.2291718804447023, -0.5238152257304451, 1.709168796776578, 0.6869334953700262, -1.3916594109351514, 1.4210101687992076}
};

static const float b1[64] = {2.088242036925596, 1.1679141387589578, 1.9642652701276584, 1.5415513030704049, 1.4856278188458325, 1.7769698651950472, 1.092933066863062, 0.08173955496849689, 2.0693326874827527, 1.5230327754622117, 1.498852762788637, 2.0440392773114673, 2.026918394181552, 0.9943224234509442, 1.8643297322903936, 1.9356531138609365, 1.8413125070242677, 2.010011130581341, 1.6460771256896833, 1.500909733508016, 2.085188292782693, 2.0844154260508834, 2.1943878040596614, 1.5074112900337837, 1.9572214936814694, 1.8381202988620615, 1.7011379284578738, 1.1011062841534387, 1.6201960046679496, 1.7488004450658416, 1.940944902399474, 1.9109989778461256, 2.0017402680208227, 1.8551772019230541, 1.9419116905360776, 1.6347328066696758, 2.0303460293099023, 1.919095232975108, 2.042037998831891, 1.9985677863155629, 1.7615771757108873, 2.1303916693976706, 2.000081815330135, 1.4712607939742912, 1.8543732900981138, 2.026444909656116, 1.7799270066476194, 1.3504128051033375, 2.194341594017995, 1.9779203708244706, 1.9309777106403496, 1.2590333090269312, 1.9709390068859296, 1.976664383956824, 1.140081706286468, 1.9452177505991228, 1.1946582637048782, 1.1066814130612381, 1.685219497311335, 2.1037310359093686, 1.0383775527076644, 1.8995369359009848, 2.195007390596449, 1.698235807591805};

static const float w2[64][32] = {
    {1.6056960878439082, 1.5974525168370228, 1.5313021769499837, -0.10170384020269861, 1.3631228987837103, -0.6814294436691886, 0.5071713813998602, -0.23795041567735445, -0.740144006027551, -0.023211123694451004, 1.4711341249158107, 0.6308443510592401, 1.3999803517155478, 2.964154956919296, 0.5743105185718652, 1.9629402766564124, 1.3961617623111515, 2.5302952876204565, 2.4228110418518676, -0.00532586531815881, 2.470498145206556, 1.1365088405392576, 1.2549066744059505, 2.0547598811293497, 0.7029846470921509, 1.2392366838090398, 0.8066294941764975, 2.333214382202267, 0.5691516320161208, 1.4229170087817093, 2.4117487729219116, 1.5174882449401401},
    {0.6170705965258663, 0.45282690381866797, 0.7924500688972379, -0.755311172134944, 2.9581507217368377, 0.691210329727912, -0.5943303823052087, 0.5231599488954638, -1.3241251270717886, 1.7535171251445028, 2.5913605738816656, -1.3531615486061759, -0.17351953330577796, 1.7275508556211212, 1.3540698813062637, 0.08019482669148265, 1.6446957819833132, -0.5816946692945995, 1.4303898389634917, -0.17410652000655444, 2.5523179074980686, 0.6131022635467875, 0.3987912456310765, 1.1379375099223077, 0.36637569362875444, 0.18670532445194385, 1.4557369259429673, 1.2922076107152578, 0.23143590856388063, 2.2730258728199093, 0.7012426193693314, 1.5556332255225325},
    {1.687554221509398, 1.9939982954951159, 0.4641461201214469, -0.5020485121026291, 2.327558249290758, 1.6901179429369668, 1.0792909746426544, 0.352971364814764, -3.494525453227531, -0.6206984931027969, 0.96206319898361, 1.1310782628208187, 2.0371369356288658, -1.1974905331411128, 0.9176642516621791, 1.4791747681137273, 1.3897173600233788, 2.3479966029105226, 1.5652530256888384, 0.7163427846429097, 2.0293516866096986, 2.117625787578161, 2.221110651804724, 1.5460089747372998, 1.3773921730634422, 1.3487446619599444, 1.6554878548928655, 1.4770321944242133, -0.925355951033061, 0.27951330892141624, 0.2832607379591031, 2.891387399197461},
    {1.4227643859485812, 0.004471109298496428, 0.7460761470293844, -0.31415720681890935, 1.0608493510989376, 0.9353526699862508, 1.5315022937069154, -0.30552514847750745, -0.14961049148105338, -0.8440013525971967, 1.5812759577918454, 1.6016573138142687, -0.3400470558469301, 2.1795373701154896, 1.7049629902221712, 0.7716837139655035, 1.0884077069263345, 0.34240767709640835, 2.574982900436084, -0.9407905722736171, 0.031762277308724204, 1.621192189900415, 0.9409825405531833, 0.8045115230936879, 1.8839970839448132, 1.5777473735692988, 0.752386271198854, -0.21419831293873642, -2.095252056426254, 0.06679869870289248, 0.3855361734923719, 1.1106836905925168},
    {0.4851626736409473, 2.2420522113652166, 0.7120919437900614, 0.8159955827555657, 2.9243160285245735, 1.0643231826939707, -0.15345109952195585, -0.07282669549492203, -2.0050235812686554, -0.8068371348460982, 1.1878421125876033, 0.9248121142131221, 0.2560639881270802, 0.3461781658605894, 0.5842245684544913, 2.741436374374526, -0.6037981061259532, 1.902447837170305, 0.7333499483011703, -0.7657783080364545, 0.37620942464312823, 0.9674481552293398, 1.4771692060444357, 1.9397027721478017, -0.42840010291920483, 0.6885317930761328, 1.6962883268672897, 1.2188226962649387, -1.1337565136871486, 0.062094395926087974, 0.6360076828099094, 2.295566548491331},
    {2.083715520679414, 1.9460639975452116, 0.7601822754253053, -0.39278657659677746, 1.4522065383737555, -1.8617529327099138, 1.683304835035035, -0.7489551512929638, -0.18328091480112269, 0.9544122290613725, 1.2459342010163916, -0.44085308675727164, 2.2644482113341318, 1.5067722785141795, 0.8608578475362354, 1.6133624151186594, 0.8969856784856162, 1.1737472944387692, 1.6707687981798034, 0.2659358165739199, 1.7303256259087687, 0.02529621723917562, 1.5797855236692269, -0.7266111526911522, -0.24706153485413412, 2.8779053954884226, -0.1535459397857185, 0.1480330532414461, -0.10174435668216099, -0.6899086467838841, 2.2609870574559894, 1.2103505178956548},
    {1.9476095285578434, 1.0307636451610487, 1.1099436861856338, -0.7348102144866815, 1.4052099471478243, -0.8530415331422428, 1.2727273132600412, 1.428777549740101, -0.947759783327592, 0.6763905783856705, 2.4913273468014627, 0.9320871831398627, 0.4523004967679272, -0.01555557898629754, -0.8869025449043799, 2.2217312432416056, 1.273979083501426, -0.11705313781656694, 1.1928256259365269, -1.2455767493174053, 0.7174187947391258, -0.7418450386064082, 0.9342870091721411, 1.3468444503156827, -0.40550219124497167, 1.0997551248354442, 0.4066059521977739, -0.7356888015834392, 0.3575227819066492, -0.3368238523204333, 1.3811122351208758, 2.7329791541766943},
    {1.4206357922528434, -0.607726933510557, 1.6353534441989768, -0.7697088486029644, 1.5809948747852163, -0.4897525859082594, -0.2208082817566289, 1.0727160745900042, -0.012278726408474048, 0.9319333632466281, 1.4438843251066342, 0.21744347158829824, -0.6330334266531878, -0.6234256226118926, -0.08071629999023908, 1.0966688395120774, 0.2584667552671243, -0.4337017919914303, 0.7380820781104609, 0.8038569336903102, 0.5913574026788576, 1.466661820186586, 0.7872596168356427, 0.5698218104963862, -0.8411499494927874, -0.6964355112989562, 0.030381507817624852, 1.579223459270705, -1.4052212430365234, 0.7000978765862834, 0.13197568551897523, 0.11371818698126626},
    {2.30463111798552, 2.6069433946346643, -0.6494365091859994, 0.11229233560400277, 1.4616943279327852, 0.7586397543705905, -0.07579225485183268, 1.421392520365126, 0.0580911630716942, 0.9545713350565871, 1.8352670122277186, -1.9183509218188537, 2.573093556850011, 0.8630424710738807, 0.6523015636350504, 1.817490850965123, 0.7118678774727097, 1.7624391162953752, 1.4456556455907787, 0.19868192335986912, 1.052603568684265, 2.91948554399579, 1.901863446331125, 1.6153256992460738, 0.15365381402594838, 2.29591843006396, 0.03869017309584676, 0.2779616682633176, -0.04576499921702522, 1.4385186287433283, -1.1132492446934859, 1.947362647175822},
    {-0.1567741273648707, 0.1020279036844586, -0.30017694959205987, -0.1429299747602017, -1.2825461876969626, 1.626038514844778, 1.7724308616672342, 1.5034284989045947, 1.0231748834880765, 1.253569964220332, 1.0785549985150633, 0.44834929951700253, 1.937641335308131, 0.07710584244320913, -0.4493536353351857, 0.23845056405038076, 0.9355574356346265, 2.8898486968348616, 2.8069279617895697, 0.5531215032868436, 1.4340317726960234, 4.191197580901611, 2.051503511578741, 0.9193145790553989, 0.9727523334946196, 1.4305548143968474, -0.26884147268420056, 0.7703977928241589, -2.0602696360978365, 0.12778891009791665, -0.4709636411817059, -0.6047400855560034},
    {1.197260671963168, 1.2274333245080096, 1.5282179488723697, -1.633975967187176, 2.488620948833027, 0.8127263208558269, 2.391791434440799, -0.42657803552111623, 0.1697909621481484, 1.8251640127715296, 0.612241403857718, -0.7136130021586985, 0.13352816903822254, 1.8582023889644954, -0.48912333372575595, 2.485989576707554, 1.281714683840268, 1.6487404987631606, 1.1200196696890428, 0.5041485624243253, 0.6965260333529573, -0.2996613789301262, 2.6289578037659025, -0.40662281628187946, 1.1889881251662817, 0.6797429039697019, 0.22295796887355854, 0.9043499773751154, 1.2849029548141708, 0.673365272883939, 1.8549122307669632, 2.025897859068101},
    {3.3516576550178443, 0.5252626019337604, 2.0566881933397454, -0.5155773357633205, 1.970905162574135, 0.8377193305227061, 0.5474611333875803, 0.38108503619079703, -1.7139889645327224, 0.8970457571940731, 1.0876828405608097, -1.493020339134882, -0.08854653227339399, -0.11474899459481924, 1.9454052350644728, 0.5472462533076248, 0.451289747911805, 1.4573109361319068, 2.2062751221687233, 0.4256271762350314, 0.848801588207016, 1.5880538188278202, 0.9523605679956778, 1.4102412197764744, -0.638699208430207, 1.1366780700739307, -0.12192683255301065, 0.5178661367727238, 0.02949025480038856, 0.40028135068487136, 0.955343426974999, 1.339893123426071},
    {2.312260056118877, 0.9560272037309158, 3.0404484028089085, -0.7985261241678495, 0.5747680997886974, 1.6558917759258045, 1.6424255981897058, 2.0221734942627494, -1.345437452874981, 0.841785123544203, 3.5803974987285745, 1.985736059586409, -0.8686526548608646, 1.5060894809963188, 0.8927382784630428, 1.1774543735391845, 1.394421849343987, 1.5170967660799177, 4.819502136814544, -0.7268455173997592, 0.6960123013808918, 1.6239100267188504, -0.12688112818138542, 0.886292073851481, 0.7187752199852223, 0.3211815239556848, 0.6019446580540564, 0.4868804071473354, -1.2225702367238713, 0.9754334654967648, 2.290605625085669, 0.05619675300262748},
    {1.138081463146099, 0.31516070419029985, 2.589256978752, 0.6541479502662315, -0.028640849625603728, 0.9591974074634286, -0.618415355373357, 1.9582669683312224, -0.3156808298680406, 1.0428918976604067, 1.2671964544603083, -0.7580486712595484, 0.030962237305936523, 1.6886811289289614, 1.3386320447332436, 1.6877552309733843, 0.35903845967537806, 1.3946350337280577, 0.44258437524332056, -0.757231742749688, 0.6191258627153597, 2.35813517614373, -0.7939395746772722, -0.03465973318276432, 0.6734131617054538, 3.216803681473754, 0.29298638409468364, 0.8708928069623777, -0.9919627208522575, -0.15934134804259553, 0.41166503785528735, 0.7485453759934965},
    {-0.4532980484425038, 0.13614245539498546, 1.4536973449585395, 0.5222005089150119, 1.1469952058123218, 2.4280315956660616, 0.5116248654540524, 0.009458094071889103, -1.2126591683161005, 1.204204766147541, -0.2355165075342626, -0.4851686783997281, 1.4241627419075296, 2.436079827522632, 1.8666723472978146, 1.0092159141311412, 2.282969131264955, 1.0659238263023234, 2.650229466327151, -0.8363455351615156, 2.6276930350806285, 1.8311770513978118, 2.223670391499901, 1.43449577535293, 1.4104550450510804, 1.2222043566032796, 0.03190393414387626, 3.074484589612659, 1.1439530038945265, 0.5204507527701048, -0.03048229076092359, 2.4666939036127253},
    {1.6406184893146833, 0.4152968934864523, 1.6511384948626135, -0.004087345824665849, 1.6033698709796427, 1.6578123104336384, 0.37742847723440426, 2.7541249393129323, -0.6945272565768636, -0.30843958973585345, 2.436484508032336, -0.204536356609354, 0.06084808930227534, 2.0122810051159936, 0.5001967833709627, 1.291384858629915, -0.4075513114614327, 0.3960806331026311, 2.4495755807241633, 0.8329603412151244, 1.7857462059649942, 1.609056677589114, 1.9454069055027063, 0.5893773587003003, 0.5265339302944669, 1.257647323383332, -0.8555240000683842, 3.5419824015581627, -0.3482759248847311, 1.990415739998844, 1.2655780031896218, 4.288395650569867},
    {1.2156849084294972, 4.745593605591857, 0.3762564940199175, 0.9113416574311718, 0.6157150987211875, 2.9789013613122552, 1.5292880868049388, 1.7581585745175798, 1.4525959590115003, 1.2621628245419478, 2.043748614452895, -0.7502641733174057, 0.1348120986104207, 1.3830097716567569, 0.5951413226787078, 2.209832149116525, 0.9359323232979913, 1.8794453943466038, 1.5704822388515798, -0.08818922747285743, 3.323860191518353, 2.1753393554875173, 1.9643366229979144, -1.1964533704181188, -0.5808908185212063, 0.625994785756077, 0.9076797309377553, 2.521139515273611, 0.8304194496956125, 1.0559288662085138, 1.7847129427447657, 1.6304503956612781},
    {1.987690678899656, 3.7661289815174905, 0.24578260026160748, 0.3025103373495795, 0.30777494249721016, 2.0763431551234306, 0.12724362593084784, 1.0231154959848392, 1.177828790250231, 0.6849349994293368, 2.2419118736977777, 0.6012203948698954, 0.38684705566151345, 2.075826883044077, 3.1477787602518346, 2.5410730608256444, 0.5205346350167642, -0.1505184385819322, 1.2426495768491619, 0.9178450764284377, 1.9079729299141415, 2.690189289698289, 1.2996054525025418, 0.5748328405472667, -0.4373132915466052, 1.1997458339461413, -0.18172494860554667, 2.0686132606449776, 1.303416962069541, -0.5683425245527717, 1.1876492226227084, 1.8429352405861585},
    {0.967965558521639, 3.264493583923916, 1.8610675511309114, 1.8396810184675756, 0.4005948585934666, 3.8651457022802616, -0.403803209669641, 1.128348772127985, -0.0798813710991635, 0.22603082818441492, 0.14159309309200785, -3.0683699767701302, 1.3326076878887056, 1.9073291804322208, 2.633161616439334, 0.03734278365655375, -0.02255129637326406, 2.0712074025515004, 1.590467206401302, -0.1354360590875775, -0.24681405542288465, 1.535909661731893, 2.3657423793183416, 1.096186252500436, -1.000811525673844, 0.08747176234137415, -1.2815393372763426, 0.8484267221505256, -0.46649069697911644, -0.6234546905812722, 2.1811897593695657, 0.32230300032733417},
    {0.8778636051790939, 2.161511386593927, 0.8191440157603214, -0.8349043902319602, -0.26128772970327246, 2.2278708447522164, 0.5469426017509595, 0.13940069722178253, -0.6924856122640467, 1.791050961279214, 0.07380177625073003, -0.06465422371595501, 1.7749229229744712, 4.695377263719016, 2.646185264088239, -0.6198050071003041, 1.4471259918861143, 0.6598719191162021, 3.4939490492488936, -1.5735519521979087, 1.5851191816705892, 1.428641391619282, -0.3108789964003637, 1.2849201446157121, 0.11537386238421733, -0.8013968988334429, 0.9410094151580394, 1.980229389652688, 1.343947137474952, 0.9027780048141906, 2.413681430775998, 1.485197860528936},
    {2.3389583021684883, -0.3777803740780067, 2.4051495671429164, -0.26978935806688165, 1.8094662190145943, 0.11974885805864298, 0.16313901889529783, 0.708800865263886, -0.6435774922234869, 0.12528304841146187, -0.19762691242481248, 0.8694697107542511, 2.311035032862117, 0.6507333801696001, 2.5997075376221574, 1.2616048660927406, 0.08265181796965156, -0.263682194268379, 2.5256672461690948, 0.35497401200471596, 1.3993980949424025, 2.671069275581292, 2.5737143050045015, 0.76573537129761, 2.5009545114165763, 3.2175367819443697, -0.8151538781330493, 1.4820868350681435, -0.7388646781920034, 1.014587371632923, 1.0801731771466045, 1.8254266147414238},
    {4.571732462808393, 0.05673501118755701, 0.5448653124108415, 1.5439665447293556, 1.8744729968516733, 0.9368866209187291, 0.3398403606619954, 0.2180065793457538, -0.8091662061596018, 0.35432467651001404, 0.559943122201383, -1.1611686980681342, -1.2179216286718029, 1.034532057812205, 1.7143971785764138, 1.3371933493202688, 1.5736974715750767, 2.3656396923364413, 2.532286182129212, -1.1526262278813415, 0.6503218084291567, 0.8245679169013452, 1.3781080797763252, 2.8803454577772944, -0.04482016202637926, 1.9548939361601623, -2.3401934457191773, 1.575732535417046, 1.8996729390388871, 1.508441305388252, 0.9918556945428559, 1.2902654363330457},
    {1.3135150104460027, -0.2961909041841845, 1.0921136431184975, -1.3765792484037802, 0.7896900917088238, -0.5994126470999516, -0.7460930999890879, -0.11955235256482002, 0.7033848213315773, -1.8946662449064964, 1.4645535970970491, -1.199512179196034, 1.7967724011724946, 1.881470785232369, -1.093135289762986, 1.6814466485052881, 1.7165833837171822, 1.6259832091630924, 2.387624260992958, -0.45538547386989947, 1.3563776970211838, 2.2867228771855372, 1.6217350272857631, 0.739922712770591, -1.058281741162509, 0.6513988621950599, -0.8554295295623605, 1.858621448251072, -0.98258932858678, -0.014517763660622436, 0.8847834426684251, 2.4674678157284227},
    {2.168776373948991, 1.4895622545039273, -1.0663438236604257, -1.3044416903289453, 2.047736077643834, -0.5274423909763942, 0.6669738411162034, 2.7395497721462982, -0.6340103417989134, 2.4795987591498, 0.41144369452361523, -0.07489039889411493, 0.0791713476912834, 1.627706522290506, -2.7399172893465082, 0.6529978247996772, 1.3707487997034395, 0.47027102106349217, 1.4002636950049367, 0.5780686814352208, -0.22848250923828298, 1.221648356049463, 1.5874436176199245, 0.926410440465251, -0.16492374164224186, 0.9035900375023025, -1.3847090867998841, 1.7849882452406123, 0.2635922943721739, 0.7571110454890096, 1.7659806589780687, 2.38203968110892},
    {0.719021962947765, 1.325584293847716, 0.5883962221852136, 2.6248568263178202, 0.5955804545009508, 1.5834404137303837, 2.1178741628310944, 0.15024889091490556, -1.3977964960231917, 1.1124765685285098, 0.9936198025009491, 1.1667858943616136, -0.14879054892164129, 3.3543390812195253, 0.9867454387123634, 1.7835277653290158, 0.9548837445008219, 2.705594655470976, 2.689951810606562, -0.06267548178872923, 3.1719425426657435, 1.6827809375353222, 1.7557911744863928, -0.5292109620495401, 2.057543697662877, 2.2776744404746085, -1.1031890136121045, 2.287675202029352, -1.3064000849906239, 2.650087181957454, 2.5324816399549444, 2.539110466066647},
    {2.074065082274797, 3.5406335340473594, -0.5807036911435777, -1.1192276577206095, 1.381325508779409, 0.7039540595377748, -0.2147796009869884, 1.4845032875997073, -0.5272654277966677, 0.2200856199070834, 0.721989083567236, 0.4669485815968319, 1.1923229422123731, 1.4297794798143109, 0.3810249520541965, 1.5738200047862425, 2.6364167307020776, 1.0764744926764795, 2.3864864981499787, -1.7182966362751233, 3.3647536811053667, 1.6072270855987338, 1.1555321308758733, 1.323583768530881, 1.3304523791331258, 0.6761499547068323, 1.8217751123233337, 1.4695171642301414, -0.10597421647916888, -0.04764318523617589, 1.3674512424862297, 1.5768975197619692},
    {2.9627202558494496, 1.7024446528096884, 0.5342661878801742, 0.38561693811338565, 1.5949207667779464, 0.4224570564202035, -0.9777480098522948, 0.24823075675078166, -0.6666465304756809, 0.16428931580057296, 1.3580650890284378, 0.49043093910943614, 1.9201197897254356, 0.7224647692473611, 0.5880093519211204, 1.5414898646769155, 1.7092996486842413, 1.6114334110350248, -0.5462385510110519, 0.38288025457995895, 1.4814686485782946, 1.4426746661673446, 2.7146825055379584, 1.4582961842805007, 1.3745494769358046, 2.407634185911697, -0.39085723572105646, 2.7178967166842094, 1.0363856960449296, 0.3935505508861899, 0.03571739772112909, -0.6273171956912552},
    {0.8788841550975095, 0.656860725516667, 0.676828043129728, -4.121715356631048, 0.8603004888916053, 0.6960412243635821, 0.6453173148673005, 1.605604731000993, 1.3142347349713988, 3.4352084165404313, 2.872143583938056, -1.0469263288310575, 0.9630382805409722, 0.7109371614937496, 1.0930029505085306, 1.7400383024083046, 3.322015676638045, 1.0259524004954583, -0.2421941483108366, -0.707174210693991, -0.2347015752464126, 2.151079576492033, -0.048096521565389634, 2.4809065744343775, 1.8352589880516226, 0.05307467719753579, 1.7224267699142217, 2.069128871321681, -0.7059155762331606, 0.4311062182830816, 0.9505145679248307, 0.9502944799784104},
    {2.0039848007738263, 0.49176722997544253, -0.1468169004154304, 0.7169681914574829, -0.273270237081873, 1.9950189548076283, 0.43543098725010154, 1.9616521008679413, -0.7676795006580764, -1.717883407669482, 2.7575801710199275, -0.5363521079425883, 1.9734773450426657, 0.9759867505324662, 0.8584733463173814, 1.0147876202109554, 1.041379128872315, 1.7772281281640587, 1.9278635751397102, -0.2712775728909748, 2.3069264850767897, -0.22576312068486282, 2.3530531525357676, 1.5665901255292327, 0.9454751816460092, 1.8377876280780725, -2.047581626331327, 1.2169012689771321, 0.956173321464553, -0.6472871092187292, -0.3200743066576158, -0.3419618707908631},
    {1.427084213357929, 1.6520136229027278, 0.8835660102658663, 0.55989671431552, 1.4706232790014333, 1.8811840401684676, 0.23590617558652288, -0.1905652277983347, 0.08144258254559614, 1.0485901810503573, 1.324936642726285, -2.3521956197335583, 0.7623974619476479, 0.3814584379139958, -0.03955675103555171, 0.9982315673496909, 2.068470734287545, 0.8064262462832792, 1.7887678276917651, -0.09739926887439448, 1.5821201547372692, -0.30652747489221366, 1.2421400742997553, -0.12611811609258985, -0.08526432014548427, 2.367410854072334, -0.9260743913216163, 1.486813236621057, -0.4350164905650945, 0.05645895211235191, 2.5250103580911523, -0.4510537009611572},
    {1.9527345850253142, 0.9117274468432482, 0.45831724451884404, -1.794932730179267, 2.1048865816067606, -0.20720270642920516, -0.2807834527649949, 0.8016153209421891, -0.8706747875006497, 1.5717231791838506, 0.5241374802549248, -1.3110508878772205, 1.677688213371924, 1.7471422975123234, -0.41933874696466816, 1.190387128404861, 0.5039899561617639, 1.490818399652518, 3.3923896664804762, 0.2437736809182652, 0.14002839068855893, 2.2055132629736267, -0.09560736969206142, 1.4880165429967291, -0.0020864717579935597, 2.128891306287894, -0.21151256093826654, 0.065695808291141, 1.3080777437542024, 1.3253435570567451, 1.9750033282028623, 3.3239651881509036},
    {1.8308121600414853, -0.01658058170536429, 0.6553693061054735, -0.45991617455796013, 0.21996851192778724, 0.6422692551466481, 0.09260320929507021, 0.5459252754234017, -0.5634002341897606, -0.3414920489662241, -1.5383350768685045, -1.8704110410009596, 0.37265515190193826, 0.4097530077506045, 0.43728644177291764, 1.6280393564028066, 0.6252777204789891, 2.449131485762968, 3.8708886731999828, 0.152598844489347, 0.3348880376635557, 1.4200432503471552, 2.5002699414213234, 2.136156053411372, -0.4246792924662337, 0.9192647783134142, 1.9824106579580114, 1.949723615196481, -0.9361281825802537, 0.5160744704153437, 1.2100495102473496, 1.9047062272609625},
    {2.0670188250546095, 0.5949170203406913, -0.49599082630174307, 0.4072756259880738, 1.5529264001066394, 0.05065780016071745, 0.3711714094588878, 0.05642159596396855, -1.024118393304997, -1.3558519045939437, 1.283743531827354, 1.444975866176357, -0.797128307020378, 1.9607912083569528, -0.4579529326849639, 2.6362927757384402, 0.410151288077178, 1.1953259404977807, 3.924756606072976, 1.9260579411663463, 0.8787801699403145, 3.1510959848094746, 0.7623278224677434, 2.5928033245678037, 2.0236329050668576, 0.08593927957833353, -1.1935321058308903, 0.7049053025692648, -0.34729362569280364, -0.9148538513137126, 1.7384786208996716, 0.5355895069420691},
    {1.0582983176935716, 1.6635864084664196, -0.6768016949079825, -0.7072708851324274, 1.9487156931800482, 1.5362443073594563, 0.25356442678804714, 1.2483330782991564, 0.1516936513032429, 0.4708480901897366, 1.4761217117037817, -1.1634157139152403, -0.666475367561853, 1.8067886692347348, 3.3217394957806605, 1.3035229429703166, 2.580117220992802, 0.9884447838601447, 1.2868392324664581, 0.9496212412625634, 2.33126970128982, 1.2682171564884577, 1.7095899013511082, 2.6335129818507603, 1.2936528540007204, 2.7248165890780767, -1.7990636488259186, 0.7384176849783818, -0.08678411345585367, 2.3692560609116864, 0.26980207207745627, 2.4270165091310982},
    {2.097279309875813, 1.8115656351589036, 0.8418730675277076, 0.02605895970282149, 2.1718503595404166, 2.291090471630422, 1.1073395069516305, 1.0267008766071908, 0.11824078652129484, 0.02330206850852314, 1.0014971443583631, 0.8364389298632148, 0.3498514827202921, 1.2142373888372258, 1.1042678357106481, 1.73642013339117, 1.1826984174284667, 0.3894183375264249, 2.1723402078913736, -0.15176405926744194, 0.8001476323047756, 0.7697608752336552, 1.040355479825712, 0.9520284659108869, 0.9785504982058827, 2.1427173074062047, 0.8228962217237096, 2.7129858572482233, -1.1770844638663212, 3.1391429566262303, 1.5532562914405175, 0.9623780722459994},
    {-0.6172926868302632, 0.9182719851956972, 1.4064390416005947, -1.097110340597158, 0.6904422156687685, 0.4490669729461869, 1.0515552485518882, 0.7062391842726192, -1.0518216632594042, -0.7365617037535357, 0.7329673773730645, 0.6433405655997855, 0.5240958862646856, 4.3943842780735345, 0.33765345002948177, 1.1060853509617512, 2.061441202203505, 0.9715637339278014, 0.5340131812682937, -1.3488892431562802, 2.1538394763505337, 1.5811485998009545, 2.5431039187380144, 0.5042497336885805, 0.5858846387738522, 2.8274735671250917, 0.16453822236498647, 1.627235993373188, -0.8830968500482029, 0.810770746679276, 2.18044128667594, 1.8062703337992396},
    {0.6171347165220279, 3.540756910577205, 1.1804380067720956, 0.6924587278321597, 2.4964467994349357, 0.563142049580624, 2.2092188441742513, 1.538965222276477, 1.1511623485687805, 2.2601158349006236, 1.2531054822985566, -0.6959705450666954, 1.7494130223372695, 0.9034863769475684, -0.2831294309908025, 1.012080300559111, 2.7670511469180794, 1.4585015864199662, 3.1901922740785955, -0.5734379743777356, 0.20711465093836026, 2.5502088893426405, 3.3552926552716813, 3.760426137464802, 1.3243070484416883, 2.165783811923767, 0.3089581025529894, 2.818844416510995, -0.398553875487137, 0.9560845213297869, 3.277112672657855, 1.5561065256541406},
    {2.660849750569725, 1.7812983173081043, 2.309065672785275, -1.4023926454014672, 1.1718588934280354, 2.2239455805431687, -0.1528346489547876, 2.2225973513141137, -1.0108341090011292, -0.7305814703087393, 0.4919545672203111, 0.4360590841478957, 1.113581402909858, 1.646808914504544, -0.0942394779711663, 2.4379907713399582, 1.38597925023265, 1.5215188204365024, 3.045164283877291, -2.5273595777941633, 0.3346293733705805, 0.8365459938335524, -0.3955598972921566, 1.8388741938089765, 1.242447187967321, 2.4942191382354926, 0.2883047260811319, 1.1565761960685805, 0.1382641283671953, 0.32284391265935575, 1.4898117516773832, 1.248701396218941},
    {1.1898828537448567, 1.9231421107935611, 0.8849301391284037, 1.8887176026541443, 2.189789658464728, 1.5310218526235095, -1.18038251444654, 0.16630923860709432, 0.15835067107247386, 1.2540747058852661, 1.3246735957321918, 0.1182876281448929, 1.446216129428271, -0.9534873969670943, 0.7465889740305094, 1.160536613119111, -0.21662826379763228, 2.5876001975694507, 2.340067783683629, -0.7327511479404354, 0.31034034148773393, 2.4009437233912228, 1.214473694940416, 1.4604275701173968, 0.6612518798171934, 1.1633803387791901, -0.4630817846453731, -0.2397996386439155, -0.906014766220019, 2.3005698401650574, 1.1540947582792327, 0.7966527448882834},
    {0.6821466611012384, -0.1316359438981716, -0.39800037280644923, 0.3666599957863804, 1.174144025169413, 1.8883637026691629, 0.7655088356053462, 0.14238683152300619, -0.7711826227232321, -0.1673412797607289, 2.1962758804556937, -1.676201497127343, 1.674433318728238, 1.052366846111102, 1.1277551975017082, 1.6646030079715544, 0.2957811604234398, 2.7221597440418432, 1.5220908987590234, -2.1938108154304787, 1.6204050286548253, 2.9807466689049837, 0.8945743762561773, 0.0676868795657459, -0.13269182643236394, 2.1381712003651048, -1.379517864087327, 0.9455472983603994, -0.014138704988700412, -0.15906724079768994, 2.445269965998173, 1.3252791903553718},
    {2.0593221533793176, -0.7825790492145964, 2.276989786024744, -0.2192955772483365, 1.2402958546688116, 1.129621150107726, 0.7371148223675985, 0.9087532447243027, 1.4940909583277504, 0.09805209075452832, 0.5277179950171553, -1.182412367321171, 1.521098286049902, 1.3567489699006783, 0.08690157572196444, 2.251618409923794, 1.2370173356899152, -0.4933332396230956, 1.7733134839967504, -0.23608779688719447, 1.0775287722004094, 0.5101911566737211, 2.6016722163160044, 1.7250137672657946, 0.2915437544035346, 2.444274789094863, -0.5794201164635817, 2.1513437497610712, -0.38592698795799335, -0.31065902470764367, 1.1098684956610454, -1.0042292698096993},
    {1.0998429089406758, 0.2963034474544532, 1.7833775987816816, 0.48616872124782745, 1.582883309770117, 3.553399676496168, 1.6380959543483995, 0.8607913738741753, 0.06500417702903578, 1.3025130462024244, 3.1708244087146915, -1.7200150157252891, 0.7613354747170769, 1.4014637513144428, 0.3705234679606343, 0.9501116018767763, 0.35796864376612575, 2.028529405255951, 2.2737359205992482, -1.0387618708435684, 0.785255954927335, 0.5487407080850344, 2.0809908607944343, 0.7911028951764262, 1.8110248552524149, 1.7084424044091924, -0.5355531664792241, 1.574295170377698, -0.4829609417140112, 0.575156333736711, 1.5976135684626394, 1.6553096791876714},
    {2.2349854415422197, 0.6144452313821639, -0.45241299124866613, 0.17028200448360137, 2.9113601689356554, -1.1764116822715498, 1.0422980013882785, 0.5525776309018178, 1.08580064796042, 0.5759124267077664, 0.2781272581738775, -0.20017581501735332, 1.8882895193626303, 1.2788697544241154, 2.4228021544521408, -0.5797130121486983, 0.7979420686209923, 2.1569049529066047, 3.287738569283739, -0.1637997635095728, 0.0955381464053162, 0.6757585192650225, 0.6879446119343429, 0.25603517155137595, -0.12874154245528774, 0.11894577891811567, 0.6363244633562614, 2.2775328177898446, -1.1711807236782001, 0.8369087800843016, 1.3819557323065528, 2.0155625690063714},
    {0.6952547237884987, 1.051120553286748, 1.2713518042785394, -1.6482082719229467, 0.956297481196797, 1.5662935695260767, -0.434326312654912, 0.34729971510258867, 0.3246386846580362, -1.7608669722333326, 2.7511297520233713, 0.34903453299301607, 2.566246454128642, 1.3729580005791626, 1.4605947563534134, 1.8333220455140167, 2.388069971993824, 0.8669716472114131, 2.0639269946990693, -0.08547484674170708, 2.716769099493868, -0.11132929685157039, 1.7149529422824392, -0.09160654071197417, 0.01036312289946421, 0.575838388265693, 2.272091252595439, 2.454483655665713, -0.20608590479086436, 0.3267880141159922, 1.9623789374588467, -0.404433293382794},
    {1.530544284174038, -0.3744810118291665, 0.5239827365916999, -0.9120673971634764, 2.069418741576811, 0.1766042479919923, 0.5672867645662462, 0.4856147776936563, 0.6193365654311042, 0.07547124920831219, 1.7617216031352507, -2.6175461956216606, 1.4210491804727232, 1.8924300856685554, -0.49328543031624583, 2.1079259812261553, -0.8911863340171734, -0.6050701034732532, 2.0713148860772117, -1.3525519123162564, 2.2468013114106786, 2.2937488287588446, 2.2842815340754696, 1.6338571392596792, 0.1477918591890314, 0.5863141586728899, 0.6651648840954594, -0.6964617624608047, -0.9974045301941461, 1.7525113381474877, -0.07962249055876697, 1.8227273089681502},
    {2.2343706990956558, -0.014654232832272698, 0.8248968319047032, -0.411750316470016, 1.7361722563254596, 0.7395813230458963, -0.1270147077784646, 0.5950597065176739, -1.9389218224033906, -0.8537515103780158, 0.6588350658378761, 0.035310218779758325, 2.490626505321213, 1.266955863839786, 2.2854270489693698, 2.2380656438536484, 0.08483196601720434, 1.757418152383087, 1.864443461180955, 0.7121182303502317, 1.9508524535174192, 2.0016953339328794, 1.6320908247543655, 1.0400097901425438, 1.1413549031784236, 1.2221078452633392, 0.822669340589727, 1.6411963014108542, -2.1559846034236445, -1.2901296629531194, 1.6138116605098853, 2.609025345315869},
    {1.4867864887333389, 1.7244000761986273, 1.7599874167344385, -0.9203295724536457, 1.3004466705040003, -0.3726892065929068, 1.2315299225530436, 0.6754973467986035, 0.18777775628532015, 0.05497126679546707, 2.0530933253899173, 1.0503915468938947, 2.9281056603003406, 0.9338946473907181, -0.42536112269174325, -0.3448131496680813, 1.720673310255969, 1.2443728252296242, 1.1413002583553122, 0.6087953052989988, 2.871082765641123, 1.5091809398794338, 0.7595857987019318, 1.36332932712359, 0.331545717341752, 1.553623521741395, -0.9707533242477621, 1.2193704759137933, -1.8858742642577497, 0.04353246729391646, 1.4848739444768577, -0.08679583398265552},
    {0.4366425835029995, -0.08063766565473268, -0.015166268859757429, -1.031733713462337, 0.6008653535411287, 0.1302863598535724, 0.19189490995696093, -0.8549347122764305, -2.0233747153049144, 2.2969118366320522, 1.6182545711224925, -0.8496092191391205, 0.6945342209866573, 1.2852278007665068, 0.8354864250641237, 0.06050261488501794, 0.6350025153556607, 2.9940322418373926, 0.7893577824743172, 2.0464529822853836, 1.1628721523977397, 2.523371796248479, 0.2268928189861807, 2.4916425914005282, 0.518627205018714, 2.223438758854586, -0.3305735774426335, 0.24712706234638393, -0.3647574204014946, 0.9821542893065801, 1.3485143977084861, 0.8231019801833607},
    {3.80567572007143, 1.3071136658684877, -0.01650976344636083, 0.8566955691507288, 0.96872690506776, -0.8049128708348544, -0.19685221260502667, 0.36705178597503774, -0.37366564500024363, 0.41925277447718967, 1.6786546358809522, -1.2635713243103461, 0.9968484511586505, 3.767143886538825, 0.7707266854984759, 0.4808343622949079, -0.4246158517087941, 1.5198132563107563, 2.272622508458331, 0.013910518700483526, 1.538219586968759, 1.85436787578104, 0.7800386864304775, 2.0764125466595944, 1.1821690610508286, 0.5799056951749642, -2.699231601760076, 2.0616856814592537, -0.4444036961510796, 1.9448789455645994, 0.9552921492746413, 2.4706370219687974},
    {2.1007168360416903, 2.6838176198804247, 2.5950595689028373, 0.3524434099135362, 1.8812585042242866, -0.5048412094483855, 1.6550359709156697, 0.99506755328844, 0.18976593471507866, -1.9748781901123855, 1.2901036441820335, -0.8726128874136938, 0.06248440280339352, 1.4258550389085078, 0.18130797861228715, 1.9700445417120656, 1.8635074302524641, 1.403789537737625, 2.010160022631275, -1.4696335106552736, -0.1797352190823337, 4.421581159371353, 2.249831564086346, 3.6915382534334023, -0.6229414460483083, -0.12925545343814765, -0.09004501318550708, 2.2038463913933195, -2.3992156593342115, 0.6022145777879018, 0.4351353982916565, 0.8018791115873052},
    {1.9029222010317242, 2.0672411303936027, 1.4171317141255644, 0.35200657057439366, 0.23565733374151773, -0.14852258446089797, 1.613322888992858, 1.3270106749746584, 0.5800979184514587, 0.839122641836584, 1.6161264937651627, 0.29938797815175966, 1.806831094613595, 1.170582331732537, 2.092920707295092, 3.678387383427649, 3.205664710066297, 1.9825644970118754, 1.5718400439002644, -0.20282130563906103, 1.730202783088852, 1.7724407149253325, 0.7852534462378968, 0.39429205934303874, 0.19057122828336617, 2.757169844453626, 1.542275493649362, 3.3939472004160125, -0.2960877310197978, -0.07653724232645939, 2.290496773171157, 1.0747143821893808},
    {1.339468934472473, 1.154268928075556, 0.7931964174672174, -2.957834837448385, 0.8798987043868242, 0.9941081381507857, 1.0991561208186873, 0.46271668502788027, 1.100173540977862, -0.8317512596717679, 0.4400107287887238, 0.2568358041606856, -0.06860194668911677, 2.9058790948124775, -0.8018367950384283, -0.030722705276846552, 1.5316332402927675, 1.0910092603906276, 2.0265362645764435, -1.8100310581759869, 0.7069456231711514, 2.2401851812814733, 1.7933207574473213, 1.327964321435901, -0.43499176564116904, -1.1290991607053835, 0.05297753245604144, -0.188097134152899, -0.34469225001117215, -0.6948356020275428, -2.2491684105572265, 0.9181704418465892},
    {0.6618749515982647, 0.7061170309251149, 1.9591627578481576, -0.3756219137812426, 2.2637092089679873, -0.185151411015061, -0.8028803091617346, -0.08099408905248964, -0.18760870286221612, -0.7879543754212364, 0.019193995357094828, -0.9944396080761521, 2.573825814373545, 0.9472318300139237, 0.7773081206877659, -0.5403611496264006, 1.6415986946520225, 2.362808848584052, 2.0210698274940393, 0.6803560673374811, 1.6734054064251267, 1.037054609196253, 2.5011840624347053, 2.781585568480222, 0.4895104960485445, 3.6975816502109, -0.38175838743004153, 2.8222700759741213, 0.470178732490384, 0.3085419849037136, 0.807509016436055, 2.0882791016314117},
    {1.875225622416265, 2.0000979773809813, 0.7542537444244685, -0.6035458254706372, 1.4026717444301102, 1.6412225404297442, 2.18369218351244, 1.6677661474903265, -0.5446202365985818, -0.9797272847759917, 1.5832625207468911, 1.2507334890397603, 0.6142335667651851, 0.6806884366425419, 1.0981370806032265, 0.9395094175566592, 1.4853850900852283, 1.2770638131189402, 1.196230541267736, -0.366062588106259, 0.5941761300521451, 1.548561114346608, 1.6534314885551755, 2.272498971682657, -1.2220744299783883, 2.2490184917723735, -1.0524007910033595, 1.2946735965386702, -0.9213154094276852, 1.116785400218099, 0.8163578010415208, 0.8136313662873202},
    {-0.028822495202086088, 1.177210299471624, -0.7796599356579115, 1.0893015315707724, 0.7852797773361027, 1.9676957959087182, -0.4853511284838749, 1.8942803371748105, -0.6809506431643656, -0.5009500899397505, 1.6337278331387053, 1.8472326794341951, 2.578140458468602, 0.8754180507876347, 0.7418295595510648, 0.12484785864550853, 1.1839534747143805, 2.388713147190324, 1.3409302058676895, 0.5450318130313431, 1.857654324022597, 0.09097026109134165, 2.039617590028894, 1.9304562396817828, -0.5209702628148809, 1.5723858105973918, 0.6581018669832257, 0.3165104758856089, -1.1176238426322547, 0.6389344359502754, 1.6402383923706199, 0.8425262503259596},
    {0.7025275521810636, 2.1891942510019473, 0.18573059294636307, -2.020541499755027, 1.9166953557824358, 0.8063697229689799, 2.1084204460230684, 0.13771941964143533, 0.10788127944268337, 0.7031978910136018, 2.284230624037545, 0.9654275148808931, 2.745935147201601, 1.7897353741725492, 0.22077913994544135, 1.2910620541189586, 0.5677047243755735, 1.8932228138630558, 1.9211717511312947, -0.7426199394846663, 2.084704765720822, 1.3703434394203529, 1.3794611085843813, 0.33492947887108815, -0.3988321621440061, 1.7978804369805157, -0.6211849477881586, 0.9805480202801785, 1.2013014695901856, 2.0067255861423954, 1.45854754919097, 0.04777549910925177},
    {0.011924355500243943, 1.5052466400537863, -1.2964901813911196, -1.0524658720618079, 2.35206450925502, -0.2320987523935947, 1.5210795734841416, 0.10773434252045792, -1.2601359788773177, 0.5574707222710287, -0.13685118877806493, -0.570789929260626, 2.0599715694316223, -0.9176402360785166, -1.0899259691432495, 0.9700141324819194, 0.017209459107979476, 0.9577663521041236, 1.832991341008145, -0.5222736981372131, -0.25375004877759105, 0.39353607064829915, 2.077433942838388, 2.2853518389269554, 0.03147895138973089, 0.370246897514572, -0.35970828291747264, 0.6792923044053034, 0.3317975650940181, -0.7121110381872616, 1.3507015036860142, 1.336651881398194},
    {1.0453697270728888, 2.854008819427299, 0.05640800821827156, 1.0068882654973923, 0.9004628483383303, 1.6565859828662814, 1.6704889271311256, 1.435979377268701, -1.2781302733333533, 1.675524706698448, 0.8111063139267959, 0.3391631747256217, 0.6436863483466436, 0.26250453909525423, 2.572913237483385, 0.4337505060164881, 1.38486406733659, 1.4487950659497368, 0.612746186768793, -0.5472029991665691, 1.5705489256013667, 0.15793182741760345, 2.022262216844063, 0.6171677746844717, 3.009908321186438, 2.720091348046082, 1.6138509840137227, 1.8153893020988892, 0.8985833349786153, 0.26158107230454497, 0.7049850122623095, -0.6764134834518601},
    {0.45484051858333985, 1.336805558941387, 1.125641833563702, 0.9572584493266468, 1.3868170934472466, 1.6320276287058708, -1.1313447226301834, 0.06190550278144682, -0.02608624995414061, 0.9595253002986718, 1.8378467728170664, 0.061965942123083574, 1.1219250401320084, 2.261596746872244, -0.8803431820570278, 2.4078634333632913, 0.16433770099910927, 2.852837352278698, 2.430253790807528, -1.838752262487078, -0.45029914513720803, 1.6171581147086735, 0.11144368492120683, 2.019730360096202, -0.5387079632671758, 1.7094624044346283, -0.20550048595997655, 0.9108501794417351, 0.5482970924319928, 1.026247780010139, 2.3570135733672535, 4.158930302525454},
    {2.236350898287901, 1.3486180796338763, 2.1078492806117115, 1.7633359547869278, 0.642422164675651, 0.8581506616445056, 1.0767355123038573, 0.9990799076065751, -0.03152094428628463, 1.0448744144481248, 1.9809000778233803, 0.12785106747708186, 1.8045694375772352, 1.5945631592969043, 0.08491988848540905, 2.364435244799959, 2.560283424561782, 0.9625904431560464, 3.5447253843470405, 0.5363097254707395, 2.4756633824068017, 1.5502939856360793, 2.0229307089206015, 1.4163885021175393, 2.096195422476991, 3.6902635007311453, -0.09995802123974754, 0.8318439249669779, 0.04461839903915628, -0.02866367805273941, 2.397133077372595, 0.09144040135398568},
    {0.2797925243899073, 0.8292058561806892, -1.083734347804637, -0.47573496789023395, 2.029787491708497, 1.5460607493996443, 0.34870814783674975, 0.7907541608359338, 1.2157206323047163, 0.6277115581802891, 3.751597088665629, -1.732731496274021, 0.3324039660167698, 0.7880712383509487, -1.880178546390579, 0.578781569389318, 0.7325650600455493, 1.282440289622466, 0.18471274221098408, 0.04000478417764044, -0.29423098766257716, 2.002138259581097, 1.6418263263859256, -0.7617182212721456, 0.07208569134177492, 1.733061132617741, -0.7375153588416288, 0.9345255355694966, 0.08062395782723857, 1.0405390498972198, 0.01806256589469438, 0.41852829396069946},
    {2.2768403880934365, 2.117374391318911, 0.30709022735204644, -0.007805220633729443, -0.07656805632451315, 0.21104067632443707, 1.7380524473391457, 0.27434977196876825, -1.4663043017346182, 1.0770018930657828, 0.2357256957993224, -0.28280768472510137, 1.5377795336692803, 2.838004428513457, 0.4571767572997356, 0.7468748201820818, 0.19811910447081474, 0.6838760139247461, 0.0716519230111385, -0.4505961461123565, 2.1588591085354465, 1.0575608831580896, 3.2975886035275974, 1.6732711619203635, 0.5644918985161053, 3.139371302146587, 1.0470006112471173, 2.5403881410482505, -1.1226886349131995, 1.0615594425198538, 1.9618984863445423, 1.7579096428831171},
    {2.78722508528225, 3.2453634012185524, 1.8082346116822108, -0.9306525948454576, 0.13819594918162975, 0.7665791364845713, 0.5523074408117432, -0.8545380166042936, -1.816877106314757, 0.8311461601607765, 0.4388533021884051, -1.120256940521268, 1.2109369368246654, 0.7778859736224435, 0.929544044873895, 2.313836109053316, 1.3441618459884384, 2.9019034219103967, 2.4983762491527366, -0.9463546251688411, 1.4642702579278202, 0.8883691360771122, 2.32924040158074, 1.616509597692159, 1.717721632395509, 1.4870222582253436, 0.9867579450801527, 2.385841224656207, -0.6387073306873993, -0.18010112494950287, 0.6725216489701793, 2.210505680049422},
    {0.7558163089126883, 2.331631475623792, 2.006595487273768, 0.19577983953289024, 1.9296503054815288, 1.5632713523873276, 1.5734601294636845, 1.015592554066741, -0.27942535145577235, 1.7631035235896324, -0.28964847836285923, -0.5451239911461009, 1.4474074101332925, 1.4891026274900068, 0.25171755774914223, 1.850152460338394, 2.2279143994178336, 0.5418390693514642, 1.242160541589963, -0.9622470373150024, 1.0523785274099338, 1.889810739146744, -0.5664274121132813, 2.634597289267321, 0.025560454733133793, 2.188469769086915, 0.14260710484270897, 1.878847976412545, -1.7207286711629641, 0.37330958422347027, 2.433421844082487, 1.0281429356908973}
};

static const float b2[32] = {2.4413289759604524, 2.149172165650518, 1.3694197278798634, -0.16297914377749453, 2.2781877773145993, 1.4967540887850352, 1.2498370321737873, 0.89046509409859, -0.2566776819528826, 0.7181559949080468, 1.955555605154981, -0.18355107936101994, 1.868537782042438, 2.140478713701031, 1.3527547551511536, 1.7487919439646764, 1.7469984585812175, 2.007115892233784, 2.5803128909760997, -0.5685043141941918, 1.8436600758916062, 2.2475435069449703, 2.186554609379691, 2.1364537472257488, 0.9610832049779102, 2.097393875946773, -0.22511204801766338, 2.1613657617358175, -0.4353562037281663, 1.15222530897749, 1.9672237987396288, 1.9768421062288997};

static const float w3[32][16] = {
    {0.5887642796070931, 1.409185057447602, 3.169877785030529, -1.0704864571259214, -1.141806360216934, 3.015055990187039, 0.3818815282276822, -0.4322657447760412, 1.656867845795427, 3.1792120191206594, 0.11018909721383104, 4.342604600443382, 0.5099076797572294, 0.6844058822489691, 0.9839349158660577, -1.4908024112321234},
    {0.6043994931453839, 0.7649711506999445, 2.565072920518608, 0.2659849322581612, -0.09514707846308128, 1.57393150231244, -0.19814915384035364, -1.4996502329784502, 1.390455585691859, 1.6436058635271755, -0.8071050338651751, 2.1967503340404266, 1.0536232108712225, 1.5425021123187281, 1.212374255548392, 0.014186579229832165},
    {2.0187766214893754, -0.6788068156207605, 1.0031123292119815, 3.078191551367804, -1.782193475411564, 1.2393684947703547, -0.08260516746682899, 0.130106354747473, 2.6475586533024122, 1.3636602270670501, 0.49597443489574833, 3.3268010243425024, 2.4095344473905205, 1.568166205454993, 1.3338221172765863, -1.6383453594902377},
    {-1.7971795833136257, 0.2323966763129578, -0.2635484710820329, -1.5070206396222932, -0.4538604025758129, 0.6979169017615082, 0.2753477013068626, -1.0535812487406455, 1.1723139628309163, -1.4463722653905864, -1.2346425835807868, 0.05826833151875155, 1.7755035255467477, -0.17544341359192034, 0.08827542652623238, -0.3752908792886273},
    {-0.2482384340071027, 0.9100803884188017, 4.656455182734364, 0.9331423549134139, 1.1260039012066114, 1.9243979564660554, 0.4935770937199351, 0.9951320200528774, 1.8931864909981946, 1.2891229410427318, 0.09854351132634195, 2.917965617844756, 2.947062240449902, 0.10078184049297455, 0.8262399771713548, 0.6734254457586695},
    {0.2462641503843963, 1.127932169469207, 2.556818838041274, -0.4274207533690084, -0.9538050859335372, 1.4342319895791502, 0.8771485527492209, -0.6842810872823499, -0.9365608635190924, 0.7711202730711452, 0.452931388944969, 2.336566129643397, 0.9774580683300428, 1.556033940280708, 1.3668394694415358, 0.2607907155230089},
    {-1.1851635943075662, 1.0534383590520238, 0.25427932717996954, 2.328816424213197, 1.4535596368353911, 0.7168643870877079, -0.7167502117527705, 1.4091608558230304, 0.8381781313124986, 2.028273957400307, 0.8436246727330199, 1.9084236854164867, 0.8408598554082476, 0.6670278115383724, 2.0238656158881128, -0.07657951483187057},
    {-0.4755646137984565, 0.17353849778478722, 0.47418404691582916, 0.136755826744511, 1.0070957365228546, 3.330320971869217, 0.6935444430571842, -0.5391484397663807, 3.7362939724713637, 0.6363991270486501, 0.6915785924824681, 1.6500465817305159, 0.6591550675351524, 1.742690103699467, -1.178360113052724, -0.007934344218833645},
    {0.45712799203166926, -0.19931561714348978, -0.7657488139903198, -0.08120095734574642, -1.6135898427607582, 0.02007701508671816, -0.46775473504280923, 0.6728652198017937, 0.6969242063552343, 0.6639110516356969, 0.8996056074269454, -1.5399786118923677, 0.529610566995515, -0.9425691941292205, -1.2963234137288038, -0.9652320690703404},
    {1.439181736702938, 0.8843773955532204, -0.16858123117323656, -0.7480825146829235, 0.7722273186534968, 1.0361563750623675, -0.4709917848692097, 0.6948110084816447, 1.323390456654353, 1.498184268677806, -0.24937419467229585, 2.70228109305292, 0.7728675278506109, -0.39853622301972796, 0.136227098730384, 0.9588130156899892},
    {-1.1203952290761081, 1.8186650274336997, 1.8717048812634813, 0.7083728610664507, -0.6286744777522456, 0.7811084141959252, -0.3246338841387975, -0.4138654203832986, -0.07541472534283818, 2.088038345943042, 0.4215713437408303, 2.73030249169831, 1.0441062535640706, 1.1664431185565214, 1.4228306563246476, -1.6199651166691849},
    {-0.033918963558929836, 0.5543747649835712, 0.5519136268576981, 1.5228008500521721, -0.05496102703253709, 0.7636553283264852, -0.21594611542799821, -1.8099198332952078, 0.0009796346076497095, -1.6701034877243341, -1.0650460502125951, -0.5937114309313182, 0.9239274278612724, -0.6836675633078532, 0.341097360073382, -0.955635623624783},
    {0.9824287152956493, -0.20730960522098565, 2.8596583609478494, -0.05023513646941575, 0.8469485082709947, 2.665957287679508, 0.72488770696369, 1.3137983101742248, 0.9951319141118703, 0.9771650678933316, -1.2180863876535306, 2.3308872645065275, 1.309233382774229, 2.330151797630439, 2.1445822761398525, -0.005308653696894769},
    {-0.9069870808527668, 0.15260579965615917, 2.4080900502606983, 1.3844443629419998, -0.00033462287774419864, 2.200347570134863, -0.593202941830249, -0.4634360903716008, 1.339549036624652, 2.266616956958719, -0.3366342055117124, 1.5575839519256918, 2.798402561256693, 1.7271079667250144, 1.6847616635931082, 0.27598499568166834},
    {0.40549240715856416, -0.026079291821390977, 3.457162961358529, -0.10613433302918027, -1.4860393531101774, 0.5266410745956613, 0.22681192677710568, 0.46854817585005853, 2.316479698170943, 1.0113716012924314, -0.6364274116135453, 1.0492828098914655, 0.3522007472630885, -0.3108634760920851, 1.1314281427484474, 0.3575309460880535},
    {1.7542506618429907, 1.1331554340294538, 2.445740139400303, 0.3232963078034934, 0.7499161553448551, 2.5407608306781833, 0.1396247152352517, 0.14683402219959146, 0.4017260062209702, 0.408718388376284, 1.5270749526646479, 2.6065168175252724, 1.59337733575624, 0.7550600703873753, 1.777265353837454, -0.5607409967663173},
    {0.27539464482572934, 1.0783300038441086, 2.308064929605893, 0.23996443297320721, 0.2827541893841629, 1.4142158787204482, 0.4586080118332562, -0.6373789970475789, 1.3520478468233095, 1.0122937314606344, 0.5531148266322653, 2.5221430977088155, 1.5119058310023057, 1.9187740588408821, 2.462517606922544, 2.3675420032181096},
    {0.15031507501621952, 1.445609446161374, 1.9462545558900897, 1.7068993208822136, 0.030438971319909844, 1.4893011619238323, -0.24928092855073267, -0.15256528049473952, 2.8321112564699216, 1.444006903536252, -0.6487321864034369, 3.029408223939806, 3.312870902141759, 1.6902006264705092, 0.5345170861862162, 0.8487432742364753},
    {-0.4151963582179494, 0.21277087924899493, 3.3936942974956534, 2.088799037781453, 0.6026463526294605, 2.977285896128841, 0.16383035465692347, -1.6464588659785377, 0.955369240232999, 2.1506585043738986, -0.657929305384613, 2.906767042847755, 1.8967887001088772, 0.9771901885278887, 1.950059511993308, -1.013886765641698},
    {1.4355005682611104, -0.4286515235761369, -1.5774579771052621, -2.489009327637006, 0.41477109929202194, -0.36359486841201055, 0.5487489605380498, -0.6765724956131985, 0.3760669197866151, 0.3789726572787103, -0.24833241550924395, 1.5868190858516484, -0.2330657467595147, 1.1180073161919308, -0.5178553382004811, 1.0854315974909796},
    {0.5607297618019236, 1.7767703734111169, 2.7293770702491518, -0.4342313558578741, 1.4393075672931415, 2.16861922600456, 1.1232583546073098, -0.6577039721942621, 0.11343568172562962, 0.7195190675113781, 0.20968927160595904, 2.0603497502277937, 3.1139307558309595, -0.5045309392728504, 0.15006313506133376, 2.1202795645019012},
    {-1.9186868307520695, 0.40322339792556444, 3.9043548578437233, 1.5059634085416411, -1.5523760998195857, 1.913816520517358, -1.5992970850539832, -1.1437353786792837, 0.4476964373908479, 1.8459236150971117, -0.45327851131511165, 2.1554472148865456, 3.672055925055588, 1.4616263418190598, 1.5848007105091535, 1.3404180633571774},
    {-2.82785480185291, 1.1460890616739028, 2.8526500035836255, 1.176598533451747, -1.9342746855889188, 4.351233019313564, 0.24072936445572637, 0.9751706473121807, 1.9868966183926595, 2.1917419774265188, 0.43663699670413886, 2.0679426352953714, 0.2108701373525729, 1.9048180540345712, 1.3136106266639194, -0.5519140333084418},
    {-0.8015630016149997, -0.8039063773472339, 2.8790600897313845, 1.486220997136027, -1.046401632039892, 2.1138395738664704, -0.19530154349104614, -1.2091308450644274, 1.7390364068987798, 2.6738733956552236, 0.12672438494693058, 2.2722359862329995, 0.9585143606120646, 2.809821082035876, 0.9206165547779983, 0.6838006943705859},
    {0.7342316650907943, 1.191232147326095, 2.9278124630874807, 2.0289879278681555, 0.3361317501951806, 1.5208432354058372, -0.7963585982054523, 0.037709595689618416, -0.7077407473811104, 1.6177260695088913, 0.09072217221892036, -0.3670589469332239, 0.9919735787948768, 1.4919891302132748, 0.6614855162022564, -0.5728769532351679},
    {-0.32108181711115513, 0.2640396924784663, 1.1015352615192089, 1.915233088259453, -0.5938063769618678, 3.329310528146285, -2.450105321420175, 0.5161805399540623, 0.36265636996718975, 2.1097575168321647, -1.113943926505898, 3.9265032816830834, 0.5563865855531177, 2.7183013315184232, 1.2351048871902293, -1.6595719156848998},
    {0.6131497376818065, 0.7419768460425658, 1.3566475433759406, 0.15298730678552844, -0.6616116538794238, 0.06252672492838866, -0.4708822704671015, -0.10124454077345703, 0.6639688308301251, 0.3885950351612394, 0.4899339801444534, -1.2924671113148465, -0.7865806200398492, 1.236193806855792, 0.6109597591571043, -2.2859425987394664},
    {0.13917698346019347, 1.392722260761205, 2.3027751438817483, 0.27103743627936866, -1.9883679042587024, 0.8248343050906544, -0.02861236330398731, -0.062471063666973047, 1.9610302561927577, 3.1100622082697815, -0.56704389415078, 2.882704278164857, 0.8658392051482964, 1.1242315902933835, -0.009201169218829788, 0.1324074448130467},
    {-2.0936241206545714, 1.2415087623691883, -1.1495972325631638, 1.4870605430879043, 0.16406686166887077, 0.06007523742562529, -0.008881408496569486, -0.22370524277053822, -0.00998802029930789, -0.5859773833425307, -0.06852383136617612, -1.0068735405013847, -0.2705207426098276, -0.22525374425074227, -1.4967089939811, 0.7729409253876854},
    {0.8939830360627745, -0.7009454849102338, 2.3294294769946564, 1.708601648135868, -0.2941684241146969, 0.3796241348323717, 1.3113267839076772, -1.2302514595230258, -0.06578926888916871, 1.933046923561549, -0.08022314373485971, 0.9291394977309799, 0.7600398032643447, 0.41368230555528085, 1.4047458740513612, 2.284417650552416},
    {-0.3512540503347927, 0.6299068348587357, 3.1935732207074237, 0.031039644188730304, -1.1786682132037112, 2.310389058373322, 0.8783557048978488, -0.3568007607712931, -0.4919140390942268, 0.8312870555433485, -1.1253037618297315, 1.9827785735055499, 2.6946046553219603, 1.9182692179247307, -0.02345899525613919, -0.4714018082338175},
    {0.033039269263404246, -0.019338116381030706, 2.028418501773542, 2.127675401361992, -0.126549036402735, 3.1541276540242604, -1.2094201501036808, 0.1061119635486592, 0.6461238540910548, 0.7828833165927584, -0.5426047379724489, 3.6218552405656275, 2.2343930258569262, 0.8418713620135093, 1.4909511555149304, -0.1858059083363657}
};

static const float b3[16] = {-0.13081634503863557, 0.7325731782970802, 1.7641013881284366, 0.7063500566853606, -0.13335568731530434, 1.32506409146416, -0.16040276670368617, -0.04868532026061612, 0.8940454209098775, 1.3436352496039947, 0.006626326042785884, 1.9745653653587407, 1.4275548718169586, 0.642606869905071, 0.6319526664841267, -0.03096190251869938};

static const float w4[16][12] = {
    {-0.7052652585430872, 0.971664865519608, -1.5372920617717487, 0.13799703559678647, -2.22419872844426, 1.4800168449952944, 0.18119904457488764, -0.29720609154849387, 0.036317454155662635, -0.9114202832698606, 1.3443988125469049, -0.7526074488387361},
    {-1.1706008393797978, -1.5747416649280952, 0.08740653408534571, -2.255850032041472, -0.07274022591645876, -2.03982978046492, -2.426901552508225, 0.5809939672632276, -1.543850885419771, -0.437712040032592, -0.5279230313661248, -0.9047459190283728},
    {-2.049496835099269, -1.7190053785741723, -3.85385255826546, 0.014628867632065468, -1.669410790261467, -1.0236691775580737, -1.6128269381799063, -2.946231487517117, -2.1988199651667157, -2.3498071747028044, -2.2767823594789793, -0.4160522888268796},
    {-1.633918141606939, -1.3509285157608577, -0.30927139389916697, -0.27860475790464084, 2.187138673519987, 0.12447588226075551, -0.3839667651361818, -1.223357056341685, -0.6749041439368655, -1.4243874306096507, -1.3587821127163733, -3.0106828658944367},
    {-2.1023251502092535, -0.11027479551865124, 1.8128015356619072, 0.14156436249555548, -1.3590826122386142, -1.2143904330774435, -0.5238800373318253, 0.2420309614162619, 2.329926673085558, -0.4884083736826074, 0.29459092565854905, -0.4255127822033922},
    {-1.7178517229959833, -1.8502067736592105, 0.0560854479567125, -2.539043249709167, -1.4123451316263267, -1.8540110945191066, -2.53922114025471, -0.6560043186879612, -0.848553508436988, -2.0241522492936252, 0.0475087778367959, -1.6679390842814987},
    {0.4242364965747804, 1.809530497224788, 0.4827016855639572, 0.23965729205288278, 0.6798100925353694, 0.02536002531951481, -0.42448789735995773, 0.7882330236411237, 1.3341231351986578, 0.3551984734215318, 2.0385727151427164, -0.9745146052749346},
    {-1.3566559616108875, 1.514757138058898, -0.5822763431593782, -1.0722743217336288, -0.41442211478051877, -0.297748832336056, 0.0788995749563944, 0.38338644772702324, -0.2680267344072561, 0.6684861563875483, 0.02593737996346544, 0.936450101870546},
    {-2.883010440999205, -1.656680959220067, -0.7373494298443091, -1.8675794059241329, -2.5717609596388966, -3.0962490597352987, 1.1326289888758352, -1.2803441787428393, -1.6165406769907613, -1.9399548817568026, -0.11375056001529012, -1.0588760871561418},
    {0.4655690903547983, -1.3210388424101853, -1.0768039025358598, -0.9347300098171768, -1.4383982556606034, -2.1046694314604517, -2.8379951754029658, -1.7396022355144074, -0.9659814275417652, 1.0276691560368096, -2.539626515305611, -1.4789093112699558},
    {0.7034626365519863, -0.28007800502545904, 2.0448915601035775, -0.528980631662713, -0.68173700434259, -0.5446374026601145, 1.2605171438531326, -0.03061009221573855, -1.3309605699857021, -0.687968695202353, -1.3572709102352503, 0.9993319987030423},
    {-1.9254734700394296, -0.9834344143874768, -1.2155491601051884, -3.0092032891587253, -2.193330271626071, -1.611047871391203, 0.019786936470534266, -0.9274436780285236, -1.174279292228247, -1.494053742031218, -1.7915436238956681, -2.387146829456896},
    {-0.010778949431032438, -1.6010905556735064, -0.26335840010047695, -1.223949393398215, -1.3805486470767638, -0.9958297281192623, -1.3039769425380452, -1.267134317258844, -1.2888405913730754, -1.5534661123205569, -1.0781837004063335, -0.9964616756304439},
    {-0.5267884935147902, -0.3590623465841448, -1.2400220051295925, -0.6857413055867352, 0.133199191664507, 0.21801660633900433, -1.7552458531794215, -2.574156208389062, -1.6453406291961101, -0.71936145735708, -1.317222126705473, -0.48854480739775097},
    {-1.4675747716118108, -0.5239715389538276, -2.713278944793832, 0.22516866882241351, -2.32451641272667, -0.7703007213834087, -1.2737686627803608, 1.0212614073106623, -0.9692091664069384, -1.12391063891298, -0.8812308139138788, -0.719658835796092},
    {-0.7686974546121963, -0.11842860172806971, 0.2480907269003779, -2.3975962547906637, -0.9885781885096037, 1.972960812795612, 0.654240948868101, -0.9299150345199654, -0.6247487985453305, 0.8534690762219606, -1.0548980110210762, -1.1409271090021627}
};

static const float b4[12] = {-0.639531522425277, -0.5514561533155238, -0.7931126566193347, -0.620557817102444, -0.5831164366436032, -0.9234736095734292, -0.9898912240428348, -0.8797870535290163, -0.7676382536092952, -0.9760183146945087, -0.9840128465589494, -1.0920956312828458};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
