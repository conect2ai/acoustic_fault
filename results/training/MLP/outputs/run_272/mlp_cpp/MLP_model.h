#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.2304294498942722, 0.4487329578005446, -0.10358514117685506, -0.3876205894444123, -0.0024419549653183505, 0.5952998723735529, 0.5238778089833728, -0.34420677681238565, -0.35753057752706924, 0.5602238881289103, -0.28041501789121875, 0.5232896488530993, -0.204501201672147, -0.33841649031512483, -0.7199611934720054, 0.4012118015928914, -0.36704221457086117, 0.4551816420406575, -0.07348140046420415, 0.4935140955465142, -0.03376356744680595, -0.12593075341299972, -0.32805578172051464, -0.5121074807974885, 0.10244270512018752, 0.5680942823381633, -0.29156042621709616, 0.8086054493508945, -0.4569411291245484, 0.527309763818671, 0.146089749986497, 0.4468256707373254, 0.7436892886429449, 0.6661550952304328, -0.2419718984332813, 0.5281275967808946, -0.16680419889852782, -0.4288557656265006, -0.40252618872913715, -0.5182814068329747, 0.5446101612559611, -0.15837154990814958, -0.6447565379671295, -0.42266175524430116, -0.0688667540431938, -0.0490786040762071, -0.5909494941637194, -0.6129763140543043, 0.666206147905399, -0.26891809258733035, -0.4321666730013089, -0.392896575131684, -0.08778160915330191, 0.25914316018826455, -0.534347077165396, 0.5498728448479395, -0.04203669103827444, -0.4482837914580667, 0.6717136834431233, -0.6836070329196191, -0.0760383955536513, -0.3462906022635254, -0.4398361657277916, 0.16769215352733133},
    {0.3531649409720584, 0.22611781174014928, -0.21995740150759854, -0.2833243666295133, -0.2759284090029681, 0.4906702613263553, 0.5230129071803241, -0.46360227679021404, -0.8332894980565652, 0.42539545763524544, -0.6821741093773022, 0.6330960269538082, -0.03412970838772227, -0.5549757652853361, -0.41341103570159354, 0.2730878692028359, -0.5405432030780726, 0.5318057575848942, -0.41564015351846045, 0.6647402836839107, -0.47722319517667944, -0.25425293185561576, -0.5905210259871619, -0.5359207734001961, 0.09911558356728493, 0.5502351492265021, -0.21190901369734405, 0.5486497421602387, -0.1401418433282079, 0.5525833412485235, 0.3048822691225418, 0.42569010387310363, 0.5123714631831435, 0.35043132846132125, -0.38705738096640624, 0.5036275568544136, -0.3545814191009776, -0.5065571275018365, -0.18512016065609238, -0.2669840966068264, 0.927359661788519, -0.4587807796083692, -0.7189366649856922, -0.6723636671467785, 0.11839116725679351, 0.356370789117711, -0.68369814382405, -0.6514100527848581, 0.5081350238281115, -0.44228057736281073, -0.5115647663561327, -0.4394222445411595, -0.4051831752693522, -0.28397420839359444, -0.19497551437407523, 0.20537902085853, -0.2660548354184648, -0.1535806142718371, 0.6547532267999723, -0.6984444880522733, -0.5936863034225924, -0.34409232275603674, -0.5587741162484141, 0.12018576217217905},
    {-0.25928922289294365, 0.5815000454209963, -0.5084929335575816, -0.7057302318011074, -0.2635300524471851, 0.7430587053778019, 0.7067163539659888, -0.31372934181802636, -0.44902937174588514, 0.5001212908303814, -0.5967604311826127, 0.5230866184345683, -0.6643474848073669, -0.3912843561985642, -0.6638757302472537, 0.12790400098618032, -0.4186154622449852, 0.6633485302396104, 0.1847323772239632, 0.5990211287432836, 0.23637594725216352, -0.05416868727037772, -0.6197953532306871, -0.6791524206349501, -0.17364290744146227, 0.6902969385699896, -0.35568301498148414, 0.6330730521765798, -0.4304523902194917, 0.5810871685931518, 0.13448780784738362, 0.747470895414972, 0.778495532832282, 0.3146512163804694, -0.6901976322484803, 0.9376805839825316, -0.3793505025835146, -0.13854560350103012, -0.3034643831470703, -0.4683600826817114, 0.9366781695905594, -0.4786810723260511, -0.6272144397918277, -0.5251729060662609, -0.40550699145755165, 0.3941364884302908, -0.5429751606249041, -0.8667493223224955, 0.548682178842943, -0.21898734299185285, -0.4688487439822634, -0.5596163981074033, -0.222039707489937, 0.12355963324824713, -0.06968762951595481, 0.06580012529769477, -0.47288868745271745, -0.4717100629756254, 0.5605803111667135, -0.5190555493255182, -0.5320162160091358, -0.20536397453752978, -0.25252156172372436, 0.07397344879010653},
    {-0.7891163879888157, 0.08820613929352056, -0.3817401503825941, -0.6937464986091135, -0.48478295277500966, 0.6255357471644298, 0.5922833508387484, -0.7222014085797215, -0.6462339490395572, 0.8597844821308407, -0.7356675141925437, 0.6677007974406185, -0.9057093968042864, -0.47579293769962616, -0.9365534039973784, 0.11329996227959904, -0.5876950352825775, 0.5358923614405419, -0.40285195136790447, 0.6586151274557296, -0.43629010325235823, -0.15014392405701066, -0.7359396583985159, -0.4833466242312976, -0.6027665508019641, 0.5573074350120575, -0.6129763732530544, 0.6414988014495432, -0.6083563524553911, 0.5266142912285259, 0.13507683700899792, 0.379054733352584, 0.45523595501099734, 0.34168274090540557, -0.6507548459344656, 0.7067114856568496, -0.7582885844090019, -0.6609157521698058, -0.2642842884160677, -0.6309898068001786, 0.38640859023025026, -0.5118266891315053, -0.6779607256640431, -0.6754958326310325, -0.4504512754934281, 0.13013071888095468, -0.5338972388369975, -0.7787956362475212, 0.5880822909244424, -0.17883876353590272, -0.6428230721628563, -0.6383297131434189, -0.5064903096372445, 0.20186330306981712, -0.3761386107436447, 0.1316007920888637, -0.6180429128538816, -0.5134560982544153, 0.7179375114260711, -0.757704921972258, -0.6449266220922536, -0.7909765687192429, -0.5387536410529994, -0.2572031252932256},
    {-0.4597406510418918, -0.21985386101276044, -0.4790918879754088, -0.8120003974525194, -0.6428497940097342, 0.5298656029983373, 0.3480531737252829, -0.7928619527081918, -0.7621622843353781, 0.23291210359532125, -0.7277273076977095, 0.642213601202355, -0.65859795773773, -0.6737040523629291, -0.67513474018705, -0.4278457596940645, -0.5849134071395413, 0.33101995217054264, -0.6323582274863345, 0.6528407637999877, 0.12217183607178649, -0.4293490753803561, -0.7841928520317849, -0.7161336855612609, -0.6049283825950821, 0.3556226833284152, -0.5671046214969423, 0.34395942041298494, -0.5182770514943055, 0.45851091446145814, 0.09070195114537224, 0.6109188625855153, 0.6952507609659269, 0.24145333083881462, -0.7002710416402653, 0.38788820719400674, -0.8150188747380966, -0.5893687829035958, -0.31520514687876766, -0.5983865640529199, 0.5273023916976742, -0.6202947043505661, -0.7151184365867899, -0.7285395971071735, -0.5062027785350586, 0.003961076405645648, -0.6847940567349582, -0.8432231501323779, 0.2202876284704461, -0.4207512578205645, -0.4891696517771772, -0.7376555739960924, -0.6293426913004789, -0.15243421098710042, -0.6189067270242512, -0.12844198125379672, -0.3219960067063349, -0.3251434450533993, -0.023571890949845423, -0.7204551298131313, -0.5294772349980155, -0.5667478418996786, -0.42470782273582597, -0.6183890999783156},
    {-0.48666556534236705, 0.058012869116972, -0.605626916551173, -0.8153323032539801, -0.6372280622535178, 0.7597961013265137, -0.42797786920059544, -0.8090074848096377, -0.791688712186028, -0.1620048707704171, -0.6439813423707722, 0.4136676446458545, -0.7585976171173138, -0.5669989643714142, -0.3800080793071333, -0.48319313556448956, -0.7043618103178123, 0.09418488673892367, -0.4771044900357647, 0.3698372200203192, 0.03281620705262327, -0.5626824487413363, -0.7788602792528212, -0.846118307618679, -0.4520774624291773, 0.35757883508271376, -0.6697543670792776, 0.27353101700216953, -0.7079021275307883, 0.06653400499379443, -0.3703819133877861, 0.5404014810584303, 0.41387625275697426, -0.3131924112368688, -0.6462175171755065, 0.06878129956682834, -0.6865019220540801, -0.5311600147352378, -0.5082200166499494, -0.6739775904369173, 0.24102767181816706, -0.7578671405331676, -0.6198226476444983, -0.6810787081430717, -0.4889750265013161, 0.05804252071459365, -0.6311447461862671, -0.6703131883243085, -0.0460748478094065, -0.8139953942291775, -0.5661633989660685, -0.7506542428521715, -0.8681241623215693, -0.32016863085609887, -0.39940688326529866, -0.4290700776122832, -0.4063982205481886, -0.8310035951130089, -0.07631188197513329, -0.9384814695063765, -0.48288322581323573, -0.8853291847226364, -0.6219718981397149, -0.619682009226511},
    {-0.5308855487522577, -0.013640593163461324, -0.523119634692594, -0.5246914834172488, -0.7489495092391051, 0.683818792344764, -0.23602397782123238, -0.6862892687307346, -0.584621475978208, -0.25742376836235553, -0.43035131727865644, 0.3172769720001367, -0.6419727598343401, -0.5301586514987806, -0.6796457958411621, -0.6959671233230493, -0.6794929392816861, -0.03446678421225431, -0.5799486031942678, 0.4170625503324691, 0.040008720482133414, -0.37663164578011854, -0.699990208807436, -0.6846333507324672, -0.47531464410313856, 0.5026340056693523, -0.3070898385978901, 0.12756507694591007, -0.7274486696136752, 0.07663464912272519, -0.24487508344375059, 0.487888779052212, 0.3112446720483802, -0.05538066708448307, -0.5245236256434981, 0.042147662893790155, -0.8642069876112165, -0.8406240227932199, -0.34745676858331226, -0.5644127084887975, 0.10638671813119527, -0.8025270170009073, -0.5256170593108866, -0.6720320873185521, -0.5059551960317933, -0.004645359640744568, -0.4893076196192824, -0.7325609477002651, -0.22139101818266457, -0.5639809904278308, -0.7786241260350965, -0.7985340739780332, -0.7080321343231947, -0.38923935114693037, -0.7225827645507258, -0.2614410248778776, -0.4719471022728732, -0.5790162761686886, 0.032875915365285974, -0.6848564610279791, -0.5924545941530475, -0.8188204233680558, -0.5873743214348399, -0.2830910435752151},
    {-0.6896959377720252, -0.06522710999589891, -0.5716050304726784, -0.5333402244276108, -0.5053976143101585, 0.7599662180683465, -0.03140097924341113, -0.7061804000742614, -0.7175766846806904, 0.038377028244893197, -0.47221698704278364, 0.2914706327427905, -0.6366979458727928, -0.5529563089417391, -0.7541201428752298, -0.4345234194227344, -0.3593978208109959, 0.013615856382270228, -0.3212444411081981, 0.36914294002277015, -0.019237376649371564, -0.4581300464875577, -0.816151157111091, -0.6727596763959796, -0.45036020573684005, 0.5445026234985504, -0.5109538802124391, 0.20156615444854564, -0.6743470429716628, 0.3238422683235347, -0.5740366362951129, 0.5117581307927179, 0.27555490490447, -0.1655132944413484, -0.6696873445609527, 0.172072047106321, -0.7826063191046012, -0.7631978597861789, -0.41752409133212665, -0.5480872474865416, 0.21550682235318244, -0.5786576462033404, -0.544627102369838, -0.6312626453867958, -0.7494829435527471, 0.025752174113995094, -0.7012087783586224, -0.9242179200855951, -0.0009192294262020661, -0.4901096372793598, -0.31716568346904417, -0.5491511218829752, -0.5826822316101997, -0.24005756798371802, -0.46158488989513885, -0.04678405798628335, -0.6218835791686719, -0.9630144270132518, -0.022159945921592938, -0.7384264581692527, -0.6402207563811243, -0.7355145776316593, -0.7287191389033237, -0.5468498581207912},
    {-0.6168185495402106, 0.2080035967312846, -0.48760050928524407, -0.7323513411054432, -0.8254770223119519, 0.5463221780745653, 0.15209778044932545, -0.6858897143477745, -0.6637541579036642, 0.4420094458820619, -0.7268575730488098, 0.51734467452927, -0.7882492868587567, -0.5881489158705739, -0.63732343653177, -0.5259678310962671, -0.487726813772873, -0.1296871341393485, -0.709562183604772, 0.6577654648275071, 0.06466104053288371, -0.43681472094059826, -0.5184777693516728, -0.6709954193775879, -0.364946213236799, 0.5343627786355939, -0.6306432337627138, 0.5742849416992106, -0.49531697399479485, 0.4912485040410574, -0.34873934664898176, 0.1757150992495888, 0.6148708093151012, -0.24979095044977753, -0.6346440463126741, -0.11377928054744964, -0.7930157818236918, -0.6554774519800379, -0.5543649280584143, -0.4777680667932669, 0.3092579520675775, -0.5870071303784685, -0.3645107052175177, -0.9168916522655688, -0.6402472906189904, -0.2393695102062049, -0.6982798491240821, -0.7513004221818806, 0.05870695666075583, -0.2701051116133883, -0.615887501797862, -0.852779497078701, -0.7866208609738767, -0.0876497427923988, -0.5221401957532301, -0.14248966038653674, -0.9071476692416396, -0.8278861234629545, 0.49205588604618533, -0.7168611045216734, -0.6159980630939488, -0.787156166959766, -0.3993141625831427, -0.39873234665949153},
    {-0.580339603315911, 0.11206542384046327, -0.4724924301884449, -0.6483553125570565, -0.7006291639618596, 0.7102293004659816, 0.19669856140190933, -0.7256576212097638, -0.6434108446588982, 0.4641888026368732, -0.4222914682622133, 0.67815308119873, -0.5048020954775209, -0.47216149332137014, -0.6678547260662038, -0.26746485882059834, -0.5181354007045129, 0.13559655344879148, -0.5842152987376936, 0.44369075215470943, 0.10543814456619338, -0.24511206393407106, -0.3767843224477497, -0.8947675427952981, -0.6282290299912229, 0.4464226373827482, -0.45993021110838267, 0.4133063840330113, -0.4187193515231184, 0.3951914288602004, -0.031025988707470923, 0.4093432759421074, 0.753870419889502, 0.1765307332409345, -0.6974706566400296, 0.4827573715685067, -0.9481324837456705, -0.8062383557516656, -0.5475221086586194, -0.3392870000941098, 0.5018240670210085, -0.6838565131344422, -0.7791868771019522, -0.8630985241095294, -0.42170028466178283, 0.09536996882838936, -0.7071735071407111, -0.6412635854620128, 0.40476121768583256, -0.3878541106648859, -0.8029929171130044, -0.8337825171668599, -0.4138723405244013, -0.04436893817705821, -0.6549578652545681, -0.30678806564056393, -0.6119173013851528, -0.5419724459584871, 0.6008934706513498, -0.571337594064919, -0.8355639400906056, -0.6036478603454158, -0.6841392767674479, -0.34926257397250493},
    {-0.5205609884791939, -0.15601153545564309, -0.6916875211362432, -0.7207442457470135, -0.40943003019780844, 0.4494901611233583, 0.12363251436772371, -0.6646248331272815, -0.5895052172148669, 0.5758146835986747, -0.3088747095533547, 0.5171711741006405, -0.5128508582535766, -0.5502375026150845, -0.5420243552627074, -0.2586153364280833, -0.5132529007807116, 0.1987508016800865, -0.5079862042898239, 0.5630262512751044, -0.20343528938469507, -0.4506070544667305, -0.5911430238576744, -0.8925914474424949, -0.35811650728317096, 0.4229451650915158, -0.4403215533220571, 0.5489547223079567, -0.7644802247083017, 0.06739528705175356, 0.026596016616077776, 0.37354873824233514, 0.5117990425488422, 0.16974044617740452, -0.7165116162073789, 0.20866162753084835, -0.6112531184509703, -0.43961854953631785, -0.3792978362876296, -0.47174027406576147, 0.3134147262414769, -0.7001503169396369, -0.5308968187218291, -0.772369582506637, -0.29290463255612287, -0.030206062116848703, -0.7239891892512793, -0.6476505454598287, -0.015801308418712936, -0.20327976370961973, -0.8876572586752659, -0.5394054861268264, -0.44855094341014173, 0.12593130057001853, -0.26052115677895504, -0.11214816907699376, -0.3767660931435891, -0.4349188562721523, 0.19947242144604588, -0.5474713747042006, -0.6935328069909485, -0.6781038948985, -0.4954122444369118, -0.22496090610941508},
    {-0.4012866042296144, -0.16960883621296302, -0.36712557024147274, -0.7617413019552935, -0.47508272167291365, 0.3291206893856093, 0.1127378302310448, -0.7037748333644551, -0.944783119464803, 0.6161424898570582, -0.6675088279580224, 0.46833435446839666, -0.549322704145224, -0.6482638448801402, -0.5829302167909821, -0.12726711214135158, -0.3129599291874401, 0.08198538221473711, -0.10832099475065035, 0.465004263349973, 0.06564726029815089, -0.47182934188606673, -0.5666376139509028, -0.7885994464499291, -0.24879665844486124, 0.27752920509915663, -0.09871465650770751, 0.255577909256934, -0.6869932662293856, 0.4154504910358393, -0.34159224201055266, 0.35249705158834244, 0.4725932719720047, -0.22081584097930615, -0.5995134217139202, 0.500934960786606, -0.5114902498501362, -0.7430410274680533, -0.32408680510601157, -0.4799790610685131, 0.21440554328772063, -0.6194951593208183, -0.7030969387447659, -0.6445030673851291, -0.3016008924544186, 0.026895254201442755, -0.5601992351896657, -0.8101760843251169, -0.0356839910746562, -0.3041232913160693, -0.4310258260669764, -0.7528911863104774, -0.37932829121027895, 0.005271508959727785, -0.2970087704650845, -0.161979124996705, -0.8800210900159648, -0.7883590032767683, 0.3459045176975605, -0.6928321498407843, -0.7006629447200372, -0.6185962031886734, -0.4713832407151384, -0.31405566783005434},
    {-0.4111789167516246, 0.33833605881142864, -0.3402525955098295, -0.7225294698536905, -0.31361121268147346, 0.35423737146540824, -0.12355233086597579, -0.5544731146576264, -0.7494352484503528, 0.5385689325551561, -0.23843209848732522, 0.5086762150668064, -0.47109902322782, -0.5079384352697006, -0.6674612766873872, -0.29830924948994064, -0.4610258900869262, 0.37999776633187066, -0.4881936647416164, 0.5946619742306862, 0.2595451974664779, -0.37050095068299377, -0.916978003514545, -0.7768499012862545, -0.283068069018881, 0.445074052080867, -0.6321774925252198, 0.3494251315843026, -0.5297975092499627, 0.755015752634216, -0.36715408564469865, 0.3369161164570161, 0.6360626171375853, 0.02302114844525504, -0.6567529010944883, 0.5466631143670322, -0.4988756715260023, -0.7770992738165772, -0.298231089434557, -0.4744926272552805, 0.4143514357416276, -0.5170020156336507, -0.6679250516757014, -0.8766466744649908, -0.21450818705973954, 0.17632917460366265, -0.5953208135014616, -0.6599300436014182, 0.12861243778261994, -0.4635077319280262, -0.27901199917034153, -0.7894612744729697, -0.5656435770517327, -0.3557949610073131, -0.36366327553042216, -0.03068717500182497, -0.6584732786543291, -0.5089088767123072, 0.2785504931859325, -0.544421178591035, -0.7495588501852983, -0.7557251725855713, -0.5703023615220507, -0.3062580206618979},
    {-0.6072813737514546, -0.1978169861491206, -0.521668167416755, -0.8301349287354908, -0.5484395031129411, 0.35710644645696116, -0.01102501965130188, -0.7282187858066518, -0.65266211357267, 0.38039429979026024, -0.5545817026903872, 0.5099081619014328, -0.3109559976314285, -0.5915230822321255, -0.49755066468639086, -0.4610860351496336, -0.6423740435867533, 0.31456450345513004, -0.5684369202056269, 0.667736095132861, 0.0751484469711295, -0.26391518372503336, -0.6380064696895549, -0.7008238689662849, -0.6153804052220454, 0.655544952154103, -0.5590424791272853, 0.425058602243519, -0.30245528997212706, 0.2839800411452103, -0.36761444576855434, 0.2509151125999409, 0.5531183372933143, 0.0951507333118219, -0.8103128693463915, 0.30418489587681824, -0.5532590609167368, -0.7239173576608873, -0.492479190601203, -0.5746186012534309, 0.4005922247855138, -0.6932318620736321, -0.4894302716158258, -0.42522706142206335, -0.23995810637277562, -0.03735527904913106, -0.6401991179306714, -0.7283690154487885, 0.20339767485352572, -0.31586338070058223, -0.5211941398865952, -0.7137604689181034, -0.30122097249710983, -0.2583231447218535, -0.5392440822869159, -0.05842775810671855, -0.7091472372073748, -0.6964153075439588, 0.22258516833822062, -0.7298596313297602, -0.5767500872662866, -0.6957210255054158, -0.7312801335786516, -0.1248551626316781},
    {-0.33002759711590285, 0.24371390866749357, -0.21188612782478392, -0.8089499809667446, -0.45885849794976424, 0.5077145396492595, 0.1632268170631973, -0.7203953865530566, -0.659906051127818, 0.6551041511250081, -0.7434600827434726, 0.5064473736119582, -0.7136594935301338, -0.7021748522003388, -0.4828314980875128, -0.2990734996770954, -0.5026029475795402, 0.04885409241245805, -0.36284653101095937, 0.5715964741015335, -0.047409599754531045, -0.16649520079670996, -0.7489763496187113, -0.6959430944239581, -0.3182660011911985, 0.4247931595660327, -0.5103065881079716, 0.6037103287661932, -0.46644608095767004, 0.3688182058107115, -0.001307550838822058, 0.260312174384596, 0.2523285956898672, 0.045375963371144794, -0.8426723423308102, 0.8142074187858593, -0.49234379622357327, -0.404416459843593, -0.271534565220989, -0.545020206599289, 0.4130379100004179, -0.4945426087718881, -0.49897873399907927, -0.7999222805391208, -0.3238544455687784, -0.15226154921424412, -0.717067988237511, -0.8209576888776204, 0.09906657608533573, 0.12412678467282869, -0.615108428163273, -0.7430672271138411, -0.4198570783990677, -0.056637353559453325, -0.43458978459460346, 0.16625282533901845, -0.6354926167617144, -0.7351055229681335, 0.4885329200739822, -0.8328132694702562, -0.6062708322384144, -0.6353078439074769, -0.45557422691630395, -0.3498566912857295},
    {-0.36909451859031633, 0.12293025423022083, -0.36746946313929796, -0.5052382061561578, -0.5015339860282657, 0.5637318109555929, 0.2010811261908935, -0.7829007134944784, -0.3340981825840647, 0.5680703080256704, -0.3710998202467381, 0.5303493067118566, -0.7058453278998253, -0.8610106079747263, -0.5506909230445308, -0.33419179513712644, -0.36832141641066035, 0.5305082940456668, -0.6180566511832386, 0.46614023061855414, -0.14428396816018363, -0.15467350317633372, -0.6533588397160319, -0.7718328878027336, -0.36596685645447663, 0.5845765800034539, -0.5087463842843957, 0.8487767407902023, -0.4854460603839353, 0.5169868239341227, -0.3647267079218797, 0.3824100719361778, 0.4054841812017558, 0.24692699334398197, -0.6387028015330852, 0.3749843662631042, -0.6227466787602344, -0.5065461006601234, -0.3727755112455015, -0.8359722279839644, 0.6407388822983049, -0.4836391358042117, -0.5347158757356736, -0.7752687544027244, -0.20112821953145496, -0.046862386620403075, -0.5621127507339893, -0.9439875780595574, 0.2185909281910184, -0.41967360197332493, -0.5363624130301547, -0.6457972657073446, -0.5493000255005077, 0.2079138370976176, -0.31685318060891265, -0.15699971175369273, -0.3809805029501713, -0.7951902881718392, 0.5378727064029852, -0.7881652063616251, -0.5135324119778313, -0.426475520091069, -0.8905524122967036, -0.199967666199458},
    {-0.5053699065778686, 0.13911060184088067, -0.5825923431607795, -0.9306379150318539, -0.5588530236192568, 0.6712182168705515, 0.4079314898773248, -0.7276924827360737, -0.6011285231709993, 0.4415494215295549, -0.7918380824316184, 0.5393523226381919, -0.49036414750236235, -0.6607458387498322, -0.5688110663461113, -0.5035851586451147, -0.6263608831180476, 0.4978662650038191, -0.485834360182197, 0.5187842604609251, 0.05100487129549229, -0.4373224140707676, -0.9416718893518082, -0.6272367278456406, -0.5254928654281364, 0.5187986782451051, -0.5852494536579923, 0.7700565189486828, -0.6057510652471981, 0.6618221326593016, -0.3012755600945896, 0.6249073123809324, 0.5700156463008034, 0.08884595574480375, -0.5820746858228661, 0.7487908276086129, -0.5185424257853495, -0.6924602309747595, -0.3320479184699003, -0.603095666574585, 0.8039981177573765, -0.42915570364386907, -0.5722078379532713, -0.801625855215066, -0.36696662897336807, 0.20011707753596952, -0.6988213589362773, -0.7642224332960397, 0.46864350921194087, -0.44646396845196695, -0.8408700951423146, -0.6497028551208197, -0.38913223673210484, 0.10040742942898612, -0.5233532256384377, -0.12305521902603005, -0.5121073029890665, -0.5452030243483136, 0.5366534414485424, -0.8591499491237374, -0.4488094271044797, -0.7032491272461618, -0.6854622361572628, -0.2321869949275446},
    {-0.2703021238507603, 0.34376095173036714, -0.30801796051205205, -0.7354589968384434, -0.4743700847087472, 0.4390717652586026, 0.29798429635777396, -0.6593450367353011, -0.6004719634522506, 0.7178751286707776, -0.521762718804996, 0.6687136232633784, -0.3421746787188279, -0.28034311043789095, -0.9645947221416113, 0.16008036681209847, -0.5212242348416973, 0.46711828230163366, -0.07375421849757169, 0.5622391468814995, 0.5362337589851108, -0.013954319940867578, -0.63379995351921, -0.4613171614643982, -0.33307148652244123, 0.6928776960453094, -0.5202458092200802, 0.49832097864067154, -0.6638354046566922, 0.7026517706925715, -0.1327503417911598, 0.6862962518273413, 0.6990744336243502, 0.3440000675314742, -0.40001533902661274, 0.6823592866743095, -0.6629173548229838, -0.6271577745610257, 0.004187635966709303, -0.8029820780143445, 0.6493248465421253, -0.8104415613706629, -0.584098082894168, -0.4243324657682814, -0.2061502772754546, 0.2912720458358357, -0.4317533235351695, -0.6199008850196361, 0.6768531751091614, -0.3639503211618013, -0.6091913220561844, -0.6500915809524129, -0.4289396662535213, 0.32140083699754585, -0.11028309277256411, 0.4504545219475953, -0.6084208117098273, -0.6628933484494637, 0.49956232115123217, -0.5137590252402456, -0.5141038057153382, -0.47659213626953295, -0.5714218826523155, 0.08858428840502845},
    {-0.3678930446506419, 0.5731465769829154, -0.2490911402641364, -0.5530656147614248, -0.5297737722892701, 0.9026347542145644, 0.050514319915211346, -0.787986810961482, -0.696770700647197, 0.5291384452509932, -0.4011277976878103, 0.3500390466709407, -0.5244508090050182, -0.47220853651753575, -0.8842112974316882, 0.0591111517452211, -0.49757768298031885, 0.305036536014432, -0.286116748711169, 0.44359362037450834, 0.3455415421799855, -0.4592728757224549, -0.2227664267136901, -0.7185251174039999, -0.4882035625698678, 0.5259653167442331, -0.5846843153517309, 0.5363157762784382, -0.5086520118906043, 1.0002738230922215, -0.0033405602186195073, 0.4541427269885505, 0.5189621228996126, 0.3548605624948653, -0.6411081237917554, 0.6361718590551685, -0.6745393274235275, -0.5002185294516838, -0.03589174721313518, -0.7778189919795288, 0.7438977204144566, -0.7073656131564956, -0.48586895557379334, -0.764094911106297, -0.20066575172589637, 0.474030601195084, -0.4562723533873241, -0.48355228152402574, 0.478376284040744, -0.43757240085845645, -0.7137822531862812, -0.7569200450271182, -0.42900786333503155, 0.23967915796867276, -0.3704228997967002, 0.18388912504479438, -0.5640600667243011, -0.5929464169304326, 0.6671065984694905, -0.6808614392203944, -0.4666790179681551, -0.7456412444448611, -0.794260562129393, -0.22784128963335207},
    {-0.28851323105103954, 0.5076772821927291, -0.517265058278993, -0.6604134402655585, -0.663967376511491, 0.597415533496994, 0.4801728399531744, -0.9177148571891873, -0.5853829379416937, 0.7122814896632891, -0.6067456890070563, 0.4517491356171735, -0.3876918442137582, -0.3779336961847528, -0.6537474344047833, -0.2596326575330592, -0.4052831793267751, 0.5412909696194772, -0.30778190117071474, 0.5682305417649858, 0.38354752599201464, -0.16897914292960156, -0.5616925220347114, -0.6309813603276219, -0.42957803643268266, 0.5668095650407919, -0.4279059673926535, 0.6168589355049766, -0.6656051426820371, 0.9370618339518701, -0.07172624839758775, 0.857066899603348, 0.538446699537483, 0.23970962585707686, -0.35472356088507534, 0.6765672166846165, -0.6540993089630531, -0.4514908553363774, -0.25371628245413524, -0.3446733275572888, 0.5755307357982418, -0.5662003944913646, -0.5197504222440031, -0.553733006863817, -0.334081569060621, 0.3991062892656524, -0.33764883051587935, -0.7634884242663063, 0.23263414898143697, -0.3241700948013081, -0.507918864603346, -1.0254644012319227, -0.6478820894672209, -0.009411703633424768, -0.25028288110063907, 0.31584345821088383, -0.7705528376702687, -0.678306585456249, 0.7367020404353672, -0.8397892994826086, -0.6916677443378689, -0.5094248853357056, -0.5979351697468371, -0.169971225859033},
    {-0.19448652640466385, 0.5360043554791704, -0.39379724484588735, -0.802007472593314, -0.43091730030079184, 0.6135007220490355, 0.4245356873451943, -0.846250365282511, -0.9729258311411012, 0.7469468884021069, -0.6400299531918348, 0.5949922286516506, -0.3004732960169638, -0.6032810474837076, -0.8524569271312427, -0.02784397877074866, -0.5939445598098827, 0.6395303629455704, -0.3953014212525687, 0.5947772012424924, 0.04709746429593994, -0.16695913794917674, -0.5119215862181845, -0.6842526936777753, -0.4851286444812713, 0.5738295930748726, -0.47229839415364067, 0.6124564141082578, -0.6558501871777017, 0.6792046461974943, -0.17014293741097453, 0.44468978092533007, 0.6774210992653775, 0.18539076550112538, -0.6130975852440653, 0.6148250962917979, -0.5765574704734905, -0.6631574739348056, -0.31727272877209006, -0.4248081030040588, 0.5457854229996053, -0.5246337271399847, -0.47267005967276216, -0.7550257785595882, -0.26413224200654156, 0.3854593925469703, -0.5694570274432448, -0.8205737564627916, 0.45368440131536303, -0.5085759537266276, -0.46341039913868004, -0.8756405227583253, -0.5759873999957927, 0.1863585016940224, -0.3952339039213728, 0.1489057564924871, -0.7793798507879344, -0.5633161961598253, 0.3557260584710073, -0.7260872465874294, -0.634203470225798, -0.605689394020345, -0.5926873431769172, 0.04002298222661763},
    {-0.21447335484830268, 0.6247731441283193, -0.5658281102027323, -0.5056643062378381, -0.3269673717741959, 0.8004568863833353, 0.6787589201104274, -0.44109145591358107, -0.7208451833441271, 0.8164816774342375, -0.530074759969621, 0.7735101672876743, -0.2985139003249381, -0.4629821914310976, -0.5099176931807341, 0.07165136992845332, -0.5406015553038583, 0.46259737783487725, -0.22879764469078423, 0.5910365424006655, 0.09597684261664637, -0.1500859644860837, -0.5947111552133482, -0.8115297812983406, -0.10300140566702554, 0.45744033369227144, -0.16546592317564016, 0.4784570733933295, -0.5845618919045141, 0.7739014161856923, 0.19770525336301914, 0.5327305211657882, 0.7003979558236374, 0.505790215022664, -0.49902302994103664, 0.6082818683708844, -0.320917815898539, -0.55747294787925, -0.07402942653773792, -0.7374897950530921, 0.7796900659308573, -0.41594250334288985, -0.42153995842855063, -0.47970032980591604, -0.343644355793615, 0.3039504182187289, -0.4444258598369721, -0.9438027879741642, 0.6496238681521941, -0.28801005899275095, -0.49248826564983417, -0.7695965020136497, -0.2684357687075204, 0.4120433773738497, -0.26713211290293704, 0.3926561624148537, -0.703054386915802, -0.6606535676523041, 0.5671431890980297, -0.41551101087542447, -0.5900241135847207, -0.4887462634616952, -0.526026947210338, -0.20810482864045396},
    {-0.14721640374431752, 0.4013879318777345, -0.15484840434203287, -0.6790374506607764, -0.3518100463344146, 0.5746194917737921, 0.7195537873655697, -0.566749336674751, -0.29914646320911803, 0.5612354794697191, -0.45879754947050594, 0.44694377953635067, -0.13056200673141602, -0.5590732697456007, -0.7945611048354213, 0.13694622395520345, -0.6261012707024425, 0.6980550466236681, -0.09118095156304169, 0.8095612671897097, 0.2458522475958418, -0.004105563224937708, -0.2700295071955789, -0.7151691446881905, -0.06170313708566348, 0.49025291581812647, -0.3478103050600199, 0.7659983778788177, -0.3824949455332711, 0.7102420387601373, 0.2857408527559152, 0.7866077296920768, 1.0243391866648563, 0.4870178505887199, -0.62292910856185, 0.7200679565158757, -0.5464836595757971, -0.5076653767960665, 0.06743193273732988, -0.4442824907970812, 0.9129575058407681, -0.5884665087288269, -0.490679033475417, -0.20457151867560444, 0.09970018305203622, 0.3645084060995298, -0.5775909931419997, -0.6012600888734112, 0.4574329204049422, -0.233835618733588, -0.5040640412551308, -0.5759588721117065, -0.3473679424203149, 0.36763150267515265, -0.20358336471173394, 0.4680479000148512, -0.3848678306008309, -0.5502164647254157, 0.4909883189496116, -0.6111116739432696, -0.34656091700319186, -0.43648333757408, -0.403558911776409, 0.08579399966161601},
    {-0.10764240736276393, 0.1906342584981416, -0.16362817544648006, -0.8412636081843887, -0.2665897949742008, 0.6234769212856768, 0.5746296516262162, -0.5762668709612613, -0.5552582804556927, 0.6632018673819832, -0.3844535605358113, 0.8211398092012127, -0.4919351778709066, -0.4577717173740431, -0.3809629953307428, 0.11366332645515785, -0.3484602745208639, 0.6884981807892598, -0.015669286506889906, 0.7428376474583847, 0.04679034716319713, -0.20293069777683118, -0.40343646595620275, -0.535258245387271, -0.3130312247259646, 0.4860664384028607, -0.5222018368948781, 0.6065470994088871, -0.4123701702634458, 0.6745694695075019, 0.24919760430150928, 0.4204536200888062, 0.4016510155251139, 0.4300886372009288, -0.4339444257647583, 0.6828594020880864, -0.36963967030190714, -0.4530257789069213, 0.09096148420047748, -0.4928213550026993, 0.7840502036142228, -0.8089091968173021, -0.5071586477521288, -0.7452707683907294, -0.2161409092204418, 0.6265451539522929, -0.48009924992761593, -0.6155169971333044, 0.5350101423759396, -0.17219288607644936, -0.5882229509195372, -0.6244618806781088, -0.1891434413287024, 0.24749979727399693, -0.2150324919177095, 0.28236594859616815, -0.6711867353241734, -0.44851513095550777, 0.5014085440168853, -0.627654937629671, -0.6259022638385257, -0.6485944317918199, -0.4434905984680557, 0.05763356285745948},
    {-0.22540206305207353, 0.5184157538993568, -0.4552689503681987, -0.7291125115810092, -0.3359230171275547, 0.6109513180965152, 0.35127169614854065, -0.8833786985974984, -0.4241113179201228, 0.7302452256205108, -0.6010091267059184, 0.8718197102972289, -0.31276229707967607, -0.2864529644929489, -0.38012414282405227, 0.1930971093913908, -0.4740272562152134, 0.6395267966953043, -0.3574501870768523, 0.7158638860916553, 0.06404795989908779, -0.20928604221303468, -0.6949276933811436, -0.5876542995324782, -0.1539244178844559, 0.5509709834508707, -0.39244606312497704, 0.8664972126269331, -0.3546648437609467, 0.8067317583020545, 0.21326840344393916, 0.4523545150636195, 0.8769896266935988, 0.5092338242692357, -0.5261526025707066, 0.7170587193906579, -0.5149769786431222, -0.4688921653317756, 0.009915275499749665, -0.5860232886449191, 0.7839438142479884, -0.6944387757564225, -1.0219731992633645, -0.6025701010316041, -0.278253994193384, 0.16684351588704976, -0.6444918666695542, -0.7019835048381882, 0.5971242469241852, -0.236250857504995, -0.388433995390071, -0.7268272710684874, -0.4522559969379481, 0.11722819127006268, 0.09853686253264379, 0.2866916382918458, -0.7972497078624501, -0.70430729217775, 0.5516303532489658, -0.7376893043285958, -0.7437125952495485, -0.3574158822151366, -0.44175589432763906, 0.01639316099208513},
    {-0.4966024124824371, 0.3542551597503434, -0.5084507928338946, -0.5021902521880641, -0.36602999958303956, 0.6097708445971719, 0.586323162311851, -0.4508709889364701, -0.3379640153035881, 0.434222310584049, -0.6314542124419059, 0.5468285138410234, -0.48735610852383654, -0.5758780835040666, -0.40948886912145127, 0.17719366048613164, -0.1774788629731258, 0.5915710133560432, -0.16828992076158536, 0.7215829508451738, 0.014492795609378164, -0.12584677770438968, -0.6061057159026939, -0.5715587676499453, -0.3876852923117496, 0.6243684159136959, -0.3471661287272525, 0.6217253417398709, -0.5604721941575013, 1.0243691984294592, -0.27530117436374163, 0.5424883914520123, 0.6936007656259433, 0.14906915006244836, -0.3889256203661956, 0.5944467108495856, -0.45772657022676677, -0.7242733345698387, -0.028234315419102797, -0.7758754511302348, 0.6482690142903991, -0.6575536142789813, -0.4305584487172182, -0.23735689579529973, -0.09163463055449818, 0.3577556867000919, -0.5391703665321351, -0.5673729538627426, 0.5372741661712791, -0.44428275177924437, -0.4002216372834763, -0.6305158586041117, -0.3254372152552611, 0.14380417921654956, -0.2559171341338797, 0.5723663696500317, -0.5558950983979135, -0.524854955580813, 0.7064690693322193, -0.6589224875982352, -0.8296622471512762, -0.5212806926681357, -0.5626592288991155, -0.026053114955958932},
    {-0.13044151162303785, 0.607783031283118, -0.12389297849457559, -0.7935548348436164, -0.42896827093379664, 0.7374540846523236, 0.5756150269226311, -0.6602703236012444, -0.7203508091329699, 0.6478575255914286, -0.7527702865202069, 0.83781975933142, -0.4990454406760704, -0.49624493610900783, -0.47358606544368875, -0.044608011689413925, -0.6905461295728872, 0.6715406586597802, -0.3060257443815645, 0.5072785357482753, 0.1069694541724333, -0.1454694311490847, -0.40278309292705405, -0.5678697470002089, -0.27066582556447877, 0.5444240280092574, -0.656398642041481, 0.6152430193916603, -0.7068896148290182, 0.8457212225419888, 0.04948769342206986, 0.47906113045431653, 0.8541887922892192, 0.4589840209937583, -0.5424183288549959, 0.8253006717422849, -0.6320886075375384, -0.260041843431252, 0.07551198972839294, -0.6248752354121363, 0.5896255478656648, -0.6258543980082533, -0.46220293855687744, -0.6265440868435971, -0.2883819859893705, 0.1566615314165098, -0.5413480956460299, -0.8307039605842655, 0.49269546546469684, -0.3526616567913597, -0.6120459670360102, -0.6447811758942515, -0.5968242613033172, 0.16709686455778466, -0.05614238959386728, 0.25297707080881193, -0.6056159809877393, -0.6992175987001266, 0.4980041835364936, -0.5963613510892659, -0.6530867609375375, -0.3499108199404367, -0.47444796151266055, 0.040310507702569214},
    {-0.32504517737772326, 0.6047663601262817, -0.33045797902286217, -0.8872335554871066, -0.4237051207211459, 0.44012327645023114, 0.6433828860384263, -0.7555673881672538, -0.27037862189190137, 1.134579694124793, -0.43272492257842315, 0.5487975632266169, -0.49849113037557724, -0.5798540093602554, -0.4333980197208895, 0.01174940974189624, -0.5807395378759409, 0.47746891656433277, 0.08820755749534073, 0.7412103314947862, -0.05104720625424178, -0.24845979795318504, -0.5631542094549363, -0.39794489257171767, -0.24491773770929376, 0.4227169414214542, -0.5096774131535756, 0.6048835467054068, -0.713666209316071, 0.7737121109913376, 0.12129525532352364, 0.5451755147727692, 1.0384949879357537, 0.4948325298686049, -0.36663062300826976, 0.49585594856463, -0.4606550826940225, -0.5245387335470132, 0.008903956518888687, -0.826908560538225, 0.7302283899607551, -0.4529061296457681, -0.4377968091745423, -0.677885209977827, -0.5077026442522479, 0.3287056482127484, -0.7088755099769543, -0.861622712483783, 0.44606220521831635, -0.3591316655791664, -0.71244839932007, -0.5438338434341639, -0.33713001450339697, 0.014847986325048449, -0.5052236121783734, 0.19283420849843258, -0.3502080836486, -0.5014713771785676, 0.776302408354449, -0.8252128182011508, -0.6206902396731242, -0.7490577669912964, -0.5407674164465421, -0.19191601016247026},
    {-0.11529419255649129, 0.6698029098343948, -0.32534625195190264, -0.8183705230345092, -0.5793716983074692, 0.46051519747256386, 0.42484617890016885, -0.6353817535464084, -0.6716489424843963, 0.7450123098994936, -0.4057304299319426, 0.6451587239070068, -0.4239956339392497, -0.5392571635771339, -0.27801299312074174, -0.14474465992652036, -0.6885613570577005, 0.5818207018760784, -0.14879823260728806, 0.6064955129387506, -0.14265989082962202, -0.3230320290312654, -0.6573394843350361, -0.6310524090148497, -0.1337094274391139, 0.4972629821258522, -0.5322642723100978, 0.40545383519587846, -0.4643087903737388, 0.3484564658678669, -0.02914763569534735, 0.5152775656160475, 0.8895930974839156, 0.7009238473687607, -0.5054795923913374, 0.7810496751909967, -0.6094839961139702, -0.41494753603929707, -0.40955140551164526, -0.47007960766408935, 0.5139111235175059, -0.6562397737330646, -0.45053116200895016, -0.444859948174693, 0.01994906328715372, 0.3128449207243002, -0.814956167333874, -0.6473699377594779, 0.7532723186294349, -0.26236426307238825, -0.5932728349956506, -0.5277451130510795, -0.4056818099178451, 0.2020072321964025, -0.18154332232183823, 0.3730318302458836, -0.40550630324497805, -0.5377000500455231, 0.5775510031774733, -0.9363016933978159, -0.8193942188966359, -0.6737277930998186, -0.6985491119778381, -0.3254868931523361},
    {-0.30538111079278607, 0.5596475781122683, -0.17393030344099253, -0.8442034396711539, -0.26513589651231784, 0.5012158335235466, 0.5762799480839609, -0.5389300423544887, -0.596488947267545, 0.5827823701997108, -0.46736506290992874, 0.9734189942127359, -0.48458347099758514, -0.5986869537260023, -0.5405265604950606, 0.25934983566986197, -0.6364339315546399, 0.338691417747561, -0.04263496939963102, 0.7013625225620038, -0.10436331731970144, -0.0840247734250906, -0.5023383598858538, -0.6364369620941179, -0.198977709680924, 0.3865462917374789, -0.6203955975982504, 0.6828209541521398, -0.36342048540915556, 0.7305176568931561, 0.23580634803542588, 0.4637795395385681, 0.6667546872275969, 0.3141815609035628, -0.5425227246845414, 0.7666715785413942, -0.5348592803133075, -0.7438159729947447, -0.0801137273106541, -0.6576882298012384, 0.7879642481530903, -0.49427590136893107, -0.685640952650038, -0.4883334207874161, -0.010963479280974454, 0.33927202251696803, -0.5918260348613443, -0.4510697623901054, 0.6792189085086512, -0.26384335467478737, -0.5946288043767091, -0.7183067862155343, -0.26528032682754005, 0.4646433080984413, -0.007836297766845348, 0.46111452243945644, -0.5150469560695702, -0.5574486327048375, 0.7627864577327097, -0.7741142110304201, -0.7505023772544629, -0.3773230508483356, -0.5423444400756062, -0.10991406921039495},
    {0.23359630509947782, 0.6425959727758668, 0.13047911434635304, 0.5457555269208249, 0.37737207311275817, 0.01555618091382128, -0.22607222870426597, 0.31427547779676246, 0.6773512610656941, -0.3438741110354938, 0.03430941439230918, -0.25391407496217805, 0.6191276970422527, 0.15915515360423152, 0.5372694653487592, 0.06898029148639713, 0.3815234762247771, 0.452889248091407, 0.5905412682848709, -0.046617798723862125, 0.32688346602881835, 0.31233285520814263, 0.602626567810485, 0.6118920301682548, 0.38048061986643383, -0.027521825175333137, 0.11613206813693872, -0.0799828650539256, 0.2304517138160849, -0.39000914300029466, -0.24017328543994393, 0.27453678454241487, -0.5270139124854452, -0.14914124979404222, 0.2237518535240035, 0.10452032807591409, 0.18680074156553098, 0.5278422809297771, 0.21283004571944622, 0.3455042000252471, -0.42004607974216307, 0.42369304469101665, 0.7715180531997735, 0.19331323254655453, 0.478700750330756, 0.2163885678155376, 0.3206510579622414, 0.6128211174570484, -0.4317005648213467, 0.12574305403329408, 0.43045366359784004, 0.2443650419612247, -0.29006535175894665, 0.2804990107118933, 0.37501767128805547, 0.10052980552775133, 0.46160638780731683, 0.2223346869610452, 0.31827459545865744, 0.5289486012593361, 0.31320015358428244, 0.573414537328113, 0.4776657975429017, 0.14983503847999366},
    {-0.08152701317892733, 0.12439374875156599, -0.19829217603855473, -0.31955374066817377, -0.44318421649286216, 0.1255323894878591, 0.18659655205116282, -0.6621233738959619, -0.4628803737331072, 0.2464551655384523, -0.2294774236999614, 0.3528782186789902, -0.2852780878482007, -0.5497615151193562, -0.4347342114696724, 0.19348045533285987, -0.23536147123465428, 0.03201717935583388, -0.3069596480478793, 0.42031913026406204, -0.0017335658745127182, -0.3067294324526425, -0.3450995742859104, -0.18716473667661043, 0.05018209650053994, 0.23100075264693096, -0.16258185431267216, 0.19835114049272934, -0.16304052656868478, 0.23590653079417395, -0.18807415180623976, -0.0032875608473616298, 0.04448635382777836, -0.02886592632104705, -0.7509964697805788, 0.597047635997381, -0.17122030389007806, -0.37289201893200186, -0.2939957586404811, -0.3962493589836816, 0.253087087590382, -0.2913927999094942, -0.6529123206003308, -0.4579980303532381, -0.05145502264742628, -0.22185323427670603, -0.48776015795445626, -0.7508949115617372, -0.11004460734441272, -0.2212835161174028, -0.16480711591819988, -0.41185492636822063, -0.40396500710943717, -0.1204148970951089, -0.4009939281310082, 0.26572371923879623, -0.30522112651499467, -0.3034033490590182, -0.10713158968127616, -0.30548154252326937, -0.17529576204623004, -0.24132085947088228, -0.08264283193795531, -0.37912435886632256},
    {-0.482615874377065, 0.09478752464832012, -0.4314235293785213, -0.02540594899765514, -0.15300967562339368, -0.004196052384172513, -0.4963814045544643, -0.251121686699417, 0.35912599385002175, -0.48855716579848724, -0.5364705603108406, 0.03356023154046977, -0.4104865667081173, -0.11391572016799788, -0.21371757198130756, -0.49036526462312985, 0.18925554229512956, 0.04472870529506766, -0.31813283755481886, -0.25117001465890454, 0.5612050274244414, -0.4278481139191977, -0.15116921197625272, -0.3279928091488903, -0.5779443377037777, 0.3166979442272079, -0.19780366329874655, -0.30491058896535383, -0.04002138522228968, -0.5073163432998896, -0.4259726795944492, 0.12874674323998297, -0.2717843511111428, -0.6081579955061385, -0.30827683708103043, 0.29888116251602553, -0.3106621238485152, -0.06986582474232854, -0.43687226147570113, -0.02039635066596415, -0.47679531257520574, -0.32025775826076874, 0.4476045904566884, -0.3798868122350807, -0.6656359475504935, -0.2992387477094258, -0.13546620185174454, 0.08143621532780299, -0.4084461692554569, -0.4098057261749716, -0.43135973134378136, -0.6296215953528853, -0.5122999736855509, -0.2333697214823804, -0.08924567733946584, -0.007559440691890851, -0.3544424241056046, -0.27793611094917525, -0.6848097273353254, -0.3590118490551988, -0.26693222738963684, -0.2829818769169361, -0.000449849287303657, -0.3694031557688395},
    {-0.4005997679756801, -0.1737999031190975, -0.3885291455318977, -0.365840941722472, -0.4350041586695975, -0.3182171860309705, -0.5411364069114409, -0.1690220180090467, -0.1347471310393192, 0.08320144087564998, -0.25243620583776355, 0.03731640257552397, -0.6264079310793199, -0.08095629845406885, -0.253673079136438, -0.32514986011541885, -0.18630067503676206, -0.25463079268308275, -0.36793394524535156, -0.34403065383870673, 0.07830345758900367, -0.6832637142831958, -0.24236749421487472, -0.22620758062146673, -0.5890143198807655, -0.3132947413380947, -0.3267609669682537, -0.17072457194817492, -0.13783062648101144, -0.3614525259323282, -0.674463434226488, -0.42075653734157004, -0.2218792300416732, -0.5090426840013622, -0.4358733450796939, -0.14297311778233976, -0.7168255591149738, -0.5209367955008107, -0.586232143474265, -0.40751923405359386, -0.36690746806622965, -0.3395125617429312, -0.12112708857073053, -0.559218439334374, -0.49835178505830985, -0.40436858697245115, -0.3865426415288016, -0.08733381407375108, -0.5515376096800515, -0.4183620857301291, -0.5892547880689025, -0.28629843167806407, -0.4391094355187417, -0.10660228078796859, -0.3562123619963577, -0.26301188322676405, -0.2929642967235481, -0.10355018258593597, -0.6596461248606132, -0.4360148843282927, -0.3751951348590287, -0.49432293646385633, -0.35939733388656037, -0.551382059625695},
    {-0.39918875237631896, 0.1484121862001199, -0.7095564879072617, -0.5274950355823494, -0.6836220770633518, -0.050876909617816685, -0.24424676321952596, -0.41404609201682835, -0.30471539993590835, -0.018387883813090877, -0.3980847656878021, -0.0006013437616097335, -0.32483750897793745, -0.790044081452173, -0.215377940670069, -0.32926713666004326, -0.3094714563116735, -0.10253655159520504, -0.46252377362490354, -0.07216690973051533, 0.25411962876807337, -0.5085464998236571, -0.5486212885078747, -0.3321174408844764, -0.661316730519669, -0.02887431763326948, -0.7647545742432872, -0.12892695136534382, -0.11490159310505489, -0.38622949465711903, -0.5379663120815704, 0.00776367597183303, -0.14559906068936102, -0.5219779709495639, -0.42140112647161193, -0.1310275963030166, -0.6298679142365881, -0.6183036426519861, -0.37201698878449363, -0.32514739871649684, -0.2851455546670108, -0.3562488248827392, 0.01912064914822883, -0.8749340131425071, -0.6012817524120417, -0.45162331222720886, -0.5256779891696786, -0.20149806057326272, -0.26124267536893786, -0.670127016584813, -0.2388989104531712, -0.2985234110530927, -0.6504482730266257, -0.5233792761245917, -0.589754079054401, -0.27022258905930474, -0.466513293000157, -0.4204803239627894, -0.3482341600807511, -0.3619756614492447, -0.4364296396743486, -0.7912498335555801, -0.6270970845752392, -0.23862355237323943},
    {-0.6640430754249059, 0.00357531577538933, -0.44909529189348335, -0.4225664386071058, -0.468345470757534, 0.2312470377991858, -0.03730227256871659, -0.42712219278526853, -0.38282593081582666, -0.2819440339130126, -0.45885753987265876, -0.13576506871860908, -0.7573762829786658, -0.5671607263747606, -0.6650497009397996, -0.3737098903372675, -0.40810592907319837, -0.24698298529692328, -0.8401606644997713, 0.0598293386119584, 0.4769878730114802, -0.5754127172386199, -0.7314913317251314, -0.7144741821833722, -0.6107479096091311, 0.2273416473085689, -0.5717469001593706, -0.16245797281066754, -0.3999392395226169, -0.3599483716680696, -0.3363984475172461, 0.2855673334299372, -0.23199388522989833, -0.49994772450896185, -0.5352804989177213, -0.23151349350684372, -0.8384812680597205, -0.4955280079891137, -0.49443233615092375, -0.293082625763765, -0.464547889046211, -0.3886660791438154, -0.2523332613680726, -0.40988197825398737, -0.6939618034606693, -0.3893491062293298, -0.34135562389214447, -0.5472293715162184, -0.3158347464563377, -0.4056784456838228, -0.2815758717954355, -0.6274393401145739, -0.6312035699207993, -0.6957691261086132, -0.2871368101979985, -0.0982718653893843, -0.4528551820450952, -0.4457981036788118, -0.589294153954693, -0.4001716441238451, -0.6433381629532797, -0.4795912164338379, -0.46084466673799285, -0.31738219321449723},
    {-0.19131719993010038, 0.1026798524169989, -0.6950466167951973, -0.5003678625690547, -0.3223763049612639, 0.04022571171202595, -0.5139703265949452, -0.44877547792773825, -0.045468832192320466, -0.31458154713329306, -0.6030492482320626, -0.1385410784645068, -0.5468223277350145, -0.3184051790397165, -0.5662310442468246, -0.18412458739569584, -0.36096629955118403, -0.1841627798320488, -0.6517294015570555, 0.14339217187324885, 0.29893736829210266, -0.4047575249847199, -0.4850232337650161, -0.5954819672212377, -0.4146005567586521, 0.19567816122300175, -0.5143923182489676, 0.012545406615648427, -0.3076364438703349, -0.47100101806660255, -0.44287620584555965, 0.18757927810008887, -0.13120722795284123, -0.42144598005486933, -0.5462587723562412, -0.21277433763025974, -0.3255449694768282, -0.5212370575220313, -0.5254109911041156, -0.40502689420679366, -0.4344724684896063, -0.42642931079689184, -0.44651684302523426, -0.5159590779244384, -0.489712300262919, -0.266441719786581, -0.31171894921330345, -0.6012392573049334, -0.6329030697811737, -0.4881292826507188, -0.2805144963636106, -0.5799987020057216, -0.6212423012390785, -0.33769550818247746, -0.37274275113835237, -0.09870265760159619, -0.6932602562452971, -0.39043094278487894, -0.8078885886429341, -0.603140874676195, -0.31084717384144656, -0.3459021064485883, -0.18564088560706793, -0.36831311387344556},
    {-0.29312807093692567, 0.12163714186540933, -0.5704123435632616, -0.3761422547399777, -0.23098190813378208, 0.04661298956876546, -0.23924333366145492, -0.4905328575799818, -0.45983958868395663, -0.2314891941469593, -0.2857598653667514, 0.0036202300211946015, -0.515859773918382, -0.36135040399583573, -0.43272850030945853, -0.25412362680373607, -0.5675640523500978, -0.23056408172349918, -0.6568937495568791, -0.08234429159578739, 0.2051567262917206, -0.7002397752054521, -0.47719944535548475, -0.6689502796402794, -0.6787269028305171, -0.1665243245301717, -0.37219153499760277, -0.21361079244472642, -0.5067111517040953, -0.11124808996377845, -0.809432607944461, -0.0077986675336362676, -0.25616663201472833, -0.4079678617875047, -0.6249185545738511, -0.3469226419412918, -0.36362452137320683, -0.3562881331385779, -0.21607376913125614, -0.2592378711608974, -0.07349355889387062, -0.27819896379785236, -0.20201163067481157, -0.7639077290184886, -0.6651372295775604, -0.4348909476694811, -0.47813055695055845, -0.39158326192814247, -0.5618078243753145, -0.342846124903459, -0.4298428036587814, -0.6226898196256133, -0.7365828716457472, -0.5997041894629253, -0.3117003166800345, -0.01935102035547955, -0.6267598756589424, -0.5202982259147104, -0.36533422690474393, -0.16899066009485866, -0.6078882345529932, -0.7171257058993066, -0.3030081312423762, -0.3462511826926787},
    {-0.3435368034560697, 0.18101311414640298, -0.3836063105098456, -0.369138027382737, -0.4999918238958376, -0.23121234373231123, -0.37019866028381826, -0.3111631463509231, -0.2195191484767576, -0.2284471241095975, -0.4595199894605317, 0.2734189030258271, -0.5188086808260167, -0.5835472773108933, -0.5280676093990724, -0.07900218808177542, -0.3840333738387899, -0.41883563219694414, -0.6618359207626644, 0.12373764767315795, 0.41612756959997943, -0.549399755237016, -0.7496130392949627, -0.47852882607002156, -0.35141708509997166, 0.18797671136693458, -0.4035318994732495, -0.19933457447981925, -0.3241319180478495, -0.3891033532071314, -0.37619936079556865, 0.06960484150426574, -0.26850993914975785, -0.31291538663062135, -0.4867171600360476, -0.07506267082568749, -0.6023853194709832, -0.5147863340157974, -0.6510821363795775, -0.2831376375921137, 0.04890248397861144, -0.4994778898771155, -0.15907898090492287, -0.6748939093141874, -0.7218378206460131, -0.4774324849804461, -0.3904946696346576, -0.44730334859843585, -0.5464051349380694, -0.6066069702115473, -0.4683361018216985, -0.6412301494418723, -0.5718235352299261, -0.5720264649110658, -0.5178319980803131, 0.050178806187674736, -0.5971981439008162, -0.37459348048014574, -0.4590563197165375, -0.3292855628854799, -0.059659517024326494, -0.23006791781920205, -0.27023095163361627, -0.642826782400374},
    {-0.5850963653429501, 0.35134495876045835, -0.389228499229011, -0.4305788742623616, -0.5742974681777543, 0.23572312877136037, -0.3853706455498252, -0.22364553794184874, -0.6130029577039406, -0.3722195439750348, -0.6025178411900272, 0.06553873249153079, -0.8106615450973285, -0.3943282106621324, -0.6148016345728955, -0.22510947395265085, -0.26326899867587084, -0.037725870806613306, -0.7418798978566176, -0.12820933428134068, 0.30403301063911853, -0.6914178159355072, -0.6695816739872564, -0.6364160470901528, -0.48071540767191867, 0.3323644140598035, -0.46614125454087757, 0.1126821493724385, -0.5464957858574482, -0.12549771530413362, -0.3444966369190048, 0.020936593921039665, -0.07863056982010902, -0.7688178598226532, -0.40706543672087986, -0.11668121602435515, -0.4502823463200559, -0.2687354818162586, -0.5740963771590905, -0.5261236015339907, -0.08937453923217158, -0.4480557207245618, -0.547531591938076, -0.41514241686409037, -0.7153647118257289, 0.1399892415155735, -0.4748687999598055, -0.4590406199366489, -0.5931538029058785, -0.4613485436950178, -0.5932087877204062, -0.5576860066392615, -0.5250936708340056, -0.28950120866917284, -0.3744079183882428, 0.2956235231828974, -0.18613492113919292, -0.6461638165396038, -0.4904117380386543, -0.35769544867915576, -0.5770781935149604, -0.5434722254408095, -0.38549017906314614, -0.3768001825519348},
    {0.04696953388282649, -0.25941907060942015, -0.20202511162889747, -0.5570734805278006, -0.254542382626705, 0.08384485753932974, -0.31313493389524805, 0.04735742432816594, -0.21206291896214383, -0.175654356092557, -0.4888523097598209, -0.3222951964494268, -0.4284646469482406, -0.08037310321591114, -0.3552184831495047, -0.36066343855568744, -0.22784993086508695, -0.016241698402843455, -0.7059130022509165, -0.23486273542972635, 0.13122258580642931, -0.21969662374576382, -0.4948826076879506, -0.2600651138308333, -0.5310906542179611, 0.17492922000760716, -0.4206280698242143, -0.03478592656837956, -0.4989295587708135, -0.22529743068899907, -0.5337038973933242, -0.003277903985295499, -0.09959818085439183, -0.38929408574019464, -0.4307693187842861, -0.4327971470567993, -0.5198234072261121, -0.18343429613688092, -0.4062772887455985, -0.06637295658734271, -0.25220598497098834, -0.32152474139559717, -0.5547393335858647, -0.25190576647431934, -0.5420353555796982, -0.17537097248363967, -0.627940109471365, -0.3048062354990107, -0.5493084849825899, -0.4011542803615093, -0.3743912095555958, -0.2077852978694396, -0.5587819747831243, -0.3683246814244673, -0.28557407005386415, 0.12149948008810094, -0.5047436001406908, -0.43457667335656347, -0.3818935801593682, -0.24340139910274972, -0.392500138164634, -0.4887109183532488, -0.25737133425998865, -0.2744864350963083},
    {-0.22007761422134045, -0.18116396744081992, -0.5420615638888262, -0.5470183367804526, -0.45392840183494565, 0.20905542461446971, -0.4595355999626617, -0.5183725391567684, -0.3537568627384309, -0.4069517413533308, -0.5986896073598826, -0.25391985853931276, -0.4888790649871856, -0.2693923010157674, -0.29514390375908783, -0.49904080172733, -0.2522815688622736, -0.23592612876496089, -0.6050910436185761, 0.0597691832759331, 0.20862782444063796, -0.4142683556482844, -0.6936059039553422, -0.331660595826562, -0.5286993787275255, 0.35257889470287995, -0.553787876960262, -0.09030175753068426, -0.5882490493052626, -0.45861659829110063, -0.4096282227270725, 0.29185263573697684, -0.36293389604024406, -0.34051401820499655, -0.449705929733989, -0.37337987804058825, -0.46753414927853665, -0.31439638249547475, -0.43590299218528683, -0.2303555653762024, -0.44642883663229005, -0.09759313400321278, -0.3544304325347393, -0.5908435416970227, -0.7867980582758877, -0.35057930889071415, -0.3860014479109228, -0.3578871247737935, -0.4011268646266614, -0.4478973748770951, -0.2735325820607131, -0.4703979920211041, -0.5170758089917165, -0.5747177284514576, -0.5283485350507462, -0.16648214384441798, -0.5342942726227017, -0.631887231631873, -0.5721496370089059, -0.2021770203640676, -0.23600774069097843, -0.4347592836688389, -0.3328741582357375, -0.4741244780495124},
    {-0.5611509008300287, 0.1836151407492675, -0.5814499718724453, -0.3420373412325041, -0.5780727386685194, -0.11399860240945903, -0.3589974511878611, -0.5630421749760719, -0.32482715708603815, -0.44249006605814056, -0.46456460460411414, 0.3834608861497461, -0.5133308701821337, -0.6158307385132085, -0.6150496482990878, -0.7671591038990538, -0.12752076535723922, 0.07803826914510445, -0.300761996862955, 0.22784487327535755, -0.06876297736577276, -0.5757222302393047, -0.45234010343978753, -0.36712721779594354, -0.4180593895595478, -0.10846471688220609, -0.3378941698453086, -0.014544900813411973, -0.41158239994133095, -0.4663254758485154, -0.501279256834955, 0.15275442300295186, -0.0832874830460796, -0.48125922499472945, -0.7234759609606831, -0.39056395818544637, -0.6115424092612122, -0.4837381290199486, -0.7085993187765884, 0.17893149674471076, -0.3181017450596027, -0.20609138557033285, -0.30518436504775687, -0.3661081720962834, -0.6671989205375302, -0.19859766350156927, -0.3494359986140609, -0.4088882882528535, -0.563015118069086, -0.6300411254933925, -0.30774105199985824, -0.513565437319901, -0.5767933850929202, -0.38802808915773657, -0.4037167892339249, -0.15198954639880924, -0.8135291057398532, -0.6291741161588031, -0.39412465096011057, -0.2971151095536501, -0.5100115854826153, -0.4530221173143659, -0.38324748508148176, -0.26292738766376184},
    {-0.23038966112545858, 0.030727341861395547, -0.6334401258294795, -0.5321925635165445, -0.5058831235703735, 0.07612266175321808, -0.1469482123515211, -0.5683289609133062, -0.5613107675984391, -0.1558108195344674, -0.3505354849640503, 0.13475933465572718, -0.46958951989416065, -0.34734268391940704, -0.5750791654650702, -0.23970503613872127, -0.2896006824069721, 0.1601872341197964, -0.4839729262308937, -0.028960486019107237, 0.2203417291248426, -0.42426243101302397, -0.516477884116931, -0.7219845293705706, -0.6754077338219842, 0.19996304415670269, -0.2869328568546833, -0.1351914024144952, -0.17699374244548072, -0.23259641266959602, -0.5968485436984856, 0.07904077486290567, -0.0380687580314705, -0.306784068575135, -0.5778016359551365, -0.37572583749439126, -0.6673003354881756, -0.357876118955721, -0.5662543698488193, -0.2868647863964266, -0.43291675279495667, -0.3561801029728185, -0.30921584246488926, -0.41943446730596234, -0.7965995574835454, -0.006507891259431798, -0.3793501555125405, -0.5373818701847796, -0.4553568874628988, -0.8744886344083123, -0.6032043361967567, -0.6038905068403665, -0.6787909821806186, -0.45278038184150776, -0.4106854709528176, 0.12578624463956192, -0.6256487625228563, -0.7170368747034217, -0.5152275894135555, -0.47900004478681657, -0.3581706578713249, -0.23191956301246466, -0.32308593949845893, 0.017545811597915722},
    {-0.43635343384240544, 0.1971130269010204, -0.5606883591784968, -0.13487723858277595, -0.3826165114830392, 0.09598648673439207, -0.3694308631786542, -0.6741191597387168, -0.5051058996953661, -0.38019233067856645, -0.4778606698466644, -0.015762912207868282, -0.3149931981373922, -0.19756890023469484, -0.3819132572953563, -0.44752965798791355, -0.3154775022591584, -0.1224022951053331, -0.4163739173393593, 0.011107345241818702, -0.07024357318666778, -0.4828511971598443, -0.34342587408595127, -0.4567294859827244, -0.47106256873393565, 0.01505658267751604, -0.2789165054015635, 0.04502939092319328, -0.34500429276905464, -0.5118943691998388, -0.615934401154478, 0.09030648094939193, -0.27840127692161215, -0.5263906106645777, -0.5989123237422954, -0.12148236294025883, -0.6960999711941387, -0.2881397420562189, -0.6161111405369908, -0.28803073951564023, -0.22065708132846476, -0.5091973315554236, -0.3139857353110112, -0.27901463483471206, -0.7352309233141963, -0.004269818712993645, -0.2484945656060996, -0.3096168978894805, -0.19980663983953692, -0.7515228404274926, -0.3860021551027969, -0.5291339978496505, -0.5665569116505114, -0.5307392843738398, -0.5971695829357079, 0.017069248368837428, -0.5096438494733218, -0.3638206466508708, -0.2527849566810392, -0.39344896908840493, -0.5040024738776999, -0.312926963916596, -0.10878264926388118, -0.07435682585301212},
    {-0.8394492052713575, 0.012507372209433777, -0.4235327669606956, -0.5890508364201732, -0.5372504930672799, -0.25176648980314104, -0.4849580010363846, -0.7681006513055814, -0.2833299198141872, -0.34015091148524823, -0.44450536505972266, -0.11313423871804809, -0.5836079389911938, -0.009484552308069646, -0.6599922782644899, -0.18925431766016593, -0.6041410436866907, -0.07356393878144889, -0.42801313058287377, -0.23827947711594377, 0.21285502219673624, -0.6577567470363702, -0.07282448872359695, -0.4730621899303092, -0.5922406028546051, 0.2011559386293116, -0.5722560512373817, -0.19759439998107683, -0.15851136588730505, -0.3290240479914679, -0.8173425434688427, 0.027529026253650123, -0.42886840952611693, -0.599781811227496, -0.4568537910991328, -0.1280192555879338, -0.34963169600856153, -0.07811007489209236, -0.3111509201831266, -0.2653018510955892, -0.38317002344991746, -0.3541856237698174, -0.04737758968158697, -0.38400418360791716, -0.5617116948117384, -0.2185231597093574, -0.2665631586752584, -0.7080666819745134, -0.2966175878425895, -0.638340070676092, -0.17136766277276996, -0.5908470467498853, -0.5195955033967715, -0.6913338292908289, -0.3840584830213507, -0.24249154093180694, -0.5001587600340706, -0.7262578114027203, -0.3546133538235295, -0.4169063696805505, -0.1590947727149578, -0.43015318981844625, -0.3412964527454072, -0.36472118712364965},
    {-0.5120000623763175, -0.1860437167141469, -0.5421820998790473, -0.448268696216568, -0.5525956106798464, -0.16035433407344343, -0.14399255463863075, -0.5844976583297178, -0.4350868657986662, -0.1577944713840553, -0.4755161156951606, -0.0516671062549965, -0.5321345783331289, -0.6505780090276859, -0.5215670697917579, -0.511080860330824, -0.3894400389547189, -0.10820721917591221, -0.3621076753650225, -0.022973598875998168, 0.06243643101833305, -0.3527736060159768, -0.4895755822580151, -0.3266137206037586, -0.4332948589857089, 0.2790762817049712, -0.39486544677345464, -0.057684504328360725, -0.6208883097128277, -0.23165211398230395, -0.39355195426534473, -0.05959137542555083, -0.34150491011142964, -0.36724382465088024, -0.7040773213967063, -0.07318681071963336, -0.4492600604737501, -0.6053319861231152, -0.3607560910089515, -0.37634696818895896, -0.22953024547226947, -0.5314179644188064, -0.5182735413806647, -0.4543454481682513, -0.6871656819173474, -0.08258243099521265, -0.1542970485185101, -0.584655237880037, -0.4012608384857112, -0.4935814368208068, -0.1997712784254284, -0.30604463894942463, -0.8615042321044974, -0.4274610491467303, -0.557490011411003, 0.0007759900016303828, -0.5630126455266418, -0.4242985814569681, -0.5330766849250451, -0.5247045265424288, -0.4835433924123397, -0.5309258954605522, -0.5398857490663219, -0.5982829553142427},
    {-0.4272737209588958, 0.31023380586843663, -0.23328450972780568, -0.4369324238998101, -0.6205518184914529, 0.2740018624665559, -0.2403267218975379, -0.4692547756638586, -0.34531848575998514, 0.10613285038158246, -0.6160566869585983, -0.042490302438702006, -0.8886402857152071, -0.6132996444904677, -0.7606254607327236, -0.2507905833905203, -0.24879026707718174, -0.09242103734577384, -0.529878861862814, 0.003144831524658877, 0.29404575878157485, -0.6102472747397002, -0.44057007894610045, -0.5187192989863789, -0.6324187930513835, 0.25070539965135974, -0.6076049234842822, 0.058574266012343924, -0.457646465692868, -0.10660955205367216, -0.37700833657419747, -0.03506977170378155, -0.2248036038386456, -0.27021674474713187, -0.40332026968615486, 0.18781105793855013, -0.5871160106937365, -0.520180934815553, -0.4299790762909207, -0.2921309631653245, 0.0026163827434272317, -0.5417569588914474, -0.21915064170712453, -0.5372926752661986, -0.29556053249358377, 0.031481149049018095, -0.2652179307603731, -0.881313548838211, -0.419082261854319, -0.4324758513054352, -0.5116007056542208, -0.39632026044936663, -0.41535028988317935, -0.5996377316313144, -0.23469467470164235, -0.1809205327632051, -0.3508078854189967, -0.38201656541167944, -0.01621619500176974, -0.518605870883573, -0.4805718797973324, -0.29426213810110485, -0.34615612641838356, -0.21949029326783637},
    {-0.858563769023896, 0.12563454985165678, -0.6061683693280563, -0.6169459784668763, -0.3373864077148721, -0.1316689795429649, -0.3774315198654665, -0.5935326191335419, -0.2723263311949439, -0.23814209349367305, -0.6122040964800789, -0.15845350149110984, -0.565223919141369, -0.22078788561280663, -0.7856142190537745, -0.3860141927075256, -0.4685166447021691, -0.49238207217722674, -0.5258634433694634, -0.10972487924928638, -0.17538865611650417, -0.5313126522677095, -0.7221702876401009, -0.5805989181326278, -0.3709629519764392, 0.35787117818225067, -0.5773509776665102, -0.1604002815393414, -0.29731081921994995, -0.44659696438463825, -0.8539258439632135, 0.006565906604198921, -0.6671473141372323, -0.5277205375088627, -0.6637601612838684, -0.0649173153885927, -0.5587233422046087, -0.35069580886983714, -0.47673364071049246, -0.23553387734787928, -0.44430203893386316, -0.18894886811182932, -0.15700491815978532, -0.3832383407401776, -0.7597261273109095, -0.1875988395359944, -0.3231048174063109, -0.1911195214742943, -0.5038803963681706, -0.6702881513137917, -0.3093216101140434, -0.623299558713718, -0.30720533286379775, -0.5832739338877431, -0.4809342037820101, 0.03401532182148705, -0.3542518151437634, -0.7872011024901749, -0.5228715845336609, -0.32396875778255324, -0.022051644328127243, -0.45446983281516384, -0.3448416098194334, -0.4511520447538954},
    {-0.46347802504300695, -0.3201715111374414, -0.376203191644347, -0.13797170783376195, -0.6826339915802349, -0.38267759992428513, -0.6234104727809433, -0.24139589570854653, -0.039360915687457414, -0.42681337421332477, -0.5872530592135408, 0.012723958448861643, -0.6126315767843348, -0.4327748223837717, -0.3262200873899445, -0.48229144220634146, -0.12044248191703871, -0.03783401611405212, -0.4728247065906453, -0.060161218966758925, 0.08087949671404553, -0.451222474122843, -0.4607280958669885, -0.4541556886722642, -0.40701503501377895, 0.21623521706715987, -0.32424157360605893, 0.00920499930652126, -0.3137977021198831, -0.4311180260732167, -0.4914181304218142, 0.013929027469388277, -0.33461355839109497, -0.7133594940500928, -0.7262336243712535, -0.03609153861587065, -0.6586951119283891, -0.4531540057226209, -0.4387747620260009, -0.07854098160202942, -0.5451423066175466, -0.5930101580686294, -0.2971498460958833, -0.33177044088839974, -0.987514739857407, 0.00046068754379644086, -0.22001641127421967, -0.1589793201439638, -0.8123949391144042, -0.3410176958019145, -0.8546461227054885, -0.9070003703477372, -0.64962560390745, -0.6179404918102457, -0.717702719089609, -0.054314269796548985, -0.5886463102916966, -0.815805555182007, -0.5420115215404656, -0.24381283774181217, -0.3555462315110239, -0.32831320368583194, -0.22258499492470402, -0.18996010456746643},
    {-0.4543917185623905, 0.30362687086201035, -0.4478783481242963, -0.4684668005648005, -0.6623768426892809, 0.018451219722986145, -0.4464546125767497, -0.46243267673874366, -0.293666617711959, -0.27934553019532904, -0.45973263544151965, -0.10441723337486215, -0.4599534295122109, -0.5357487484527497, -0.7377062080720657, -0.42155810644051156, -0.3527929126551251, 0.2944945447042128, -0.5012766206085413, 0.024681727409262996, 0.06365770017023417, -0.4906514897571751, -0.4072008612534879, -0.5647282359842408, -0.73161256021212, 0.3521077661848847, -0.5221335884055478, -0.05684124054199401, -0.5774470200164596, -0.38069602881013415, -0.42776498748074077, -0.004381301312494691, -0.12836700405922086, -0.11372776494240146, -0.47190857728785823, -0.22535408996285006, -0.6378002426681819, -0.4261645898715667, -0.45779476245006784, -0.40184594868033263, -0.2386637749800796, -0.34597289126759906, -0.14642572869825063, -0.5247375081213972, -0.5558898197665602, -0.10276003850478749, -0.37071003439573236, -0.429458278967421, -0.20521833169017734, -0.7081989821876171, -0.54463815889287, -0.7348401788235914, -0.45236114493362345, -0.5227962264246983, -0.5923277570727185, -0.2516190928740077, -0.21253938349866386, -0.7896753921027949, -0.6272802242177401, -0.4240897252093112, -0.30252547311842376, -0.6086591190784213, -0.5951934177032415, -0.40909769372852234},
    {-0.49437815382666, 0.30305857056104735, -0.3342966894796887, -0.5079505105199303, -0.42744832797562166, 0.4208621976290254, -0.007763947803509143, -0.44928788220399823, -0.2768242021272853, 0.03396239925198318, -0.2822106486077452, -0.18458900633138348, -0.5762259779951121, -0.13394994321691292, -0.3120503598235657, -0.15391580974492453, -0.48994189253730064, 0.2304091832367465, -0.5147252370839775, 0.16432523088220216, 0.39315038754937803, -0.32907236532577927, -0.2821086698968317, -0.7276983027617155, -0.44424410616767596, 0.27150115393193247, -0.7483290425020488, 0.01953305522013559, -0.3737121273574584, 0.13031932382094774, -0.35884446184860125, 0.42399062616348615, 0.17014920626430902, -0.483840527819103, -0.7588594123970629, 0.07642661034716929, -0.49587081548460205, -0.43011726177270404, -0.5636001004862574, -0.35778371622512267, 0.09588236575469274, -0.563785436112059, -0.3618990126698231, -0.6408759946445024, -0.5526534209409426, 0.10851887752594154, -0.16363368307053106, -0.8163798892118111, 0.013919521021737135, -0.5372368002054709, -0.5010478677011572, -0.6802698632588626, -0.5372469294602059, -0.0082834271567801, -0.45198630067191686, -0.1255010244630608, -0.369057595227472, -0.455354630809058, -0.13100967349631581, -0.8637486558589517, -0.19935142194467623, -0.19184834380320598, -0.42351199687165214, -0.714510955482754},
    {-0.3858590174233333, 0.6206368845334608, -0.4081240715815963, -0.2450565642010448, -0.4302592003179306, 0.17891867679234957, -0.3674208199239282, -0.39282098153849593, 0.044589686905601916, -0.2753144928419484, -0.4658452927793996, -0.10069074334020921, -0.3389578085809219, -0.050260806547888816, -0.557973962297965, -0.3022961409866759, -0.14732155002844385, 0.05491086521245179, -0.4848839663809863, 0.150442559967662, 0.5720053264452012, -0.49344838073952524, -0.4805559200501922, -0.6613034364989703, -0.35520210643132066, 0.03341170951657198, -0.2793283280722283, -0.13071714985799254, -0.6839100573821212, -0.4389783080982623, -0.38581206177745064, 0.3606012635228897, -0.09419722347927041, -0.5135064426696279, -0.452986161057946, 0.22217466736837402, -0.3213200015432199, -0.39354814081985845, -0.49935776696772255, -0.3208793758246712, -0.45328924561838446, -0.39769173618495507, -0.1862992434078308, -0.20113987972160616, -0.4051339001517205, 0.4197755173395873, 0.03922140721718974, -0.41364464518179267, -0.22174862239007181, -0.6194498791273071, -0.4891532141141712, -0.533194114506247, -0.5668506179849203, -0.33095009064967457, -0.23610840943834777, -0.06254464739285019, 0.04949546826032183, -0.5786803803153311, 0.18336551647594626, -0.25609276780882506, -0.0022005204598648112, -0.36498808045153297, -0.03418050950889812, -0.32785103409252936},
    {-0.48037056671430917, 0.2596688645311873, -0.7416648910437891, -0.5461462684601481, -0.5247083200803093, 0.1312185618870223, -0.5295797312044045, -0.4226661211818546, 0.00332824172833418, -0.809508912066796, -0.7507999748297088, -0.13865465645394287, -0.6427443977699238, -0.2582698404579859, -0.5604971965935098, -0.7083002251516936, -0.14381713512567154, 0.2410670832746221, -0.7858109661292138, -0.3275570223558358, 0.14266681390786834, -0.6647607953411988, -0.5663806072886866, -0.8743449226246254, -0.5556366721039848, 0.04187720623469659, -0.6731229539920435, -0.21982148491588985, -0.5819863758881042, -0.5891964658751527, -0.5116370288845655, 0.05610222370639066, -0.4446357924150846, -0.8058484891518477, -0.533015565083939, -0.021924454257880185, -0.4900871939271992, -0.5748789782667383, -0.4367902922509888, -0.41501638723284423, -0.3401384952277363, -0.5715352243321813, -0.1683436372433621, -0.6142197738248025, -0.5424689099430122, -0.09496738592755144, -0.027516647880594762, -0.4584370383904436, -0.49066990885403156, -0.32712570785442685, -0.4418300556083631, -0.7052034756884051, -0.5785009448996901, -0.682903336196423, -0.5265170835284814, -0.141461571509343, -0.3757127635501296, -0.3969882037374782, -0.4682411393031274, -0.5074988477106795, -0.32559926476019735, -0.36395405951395277, -0.3157218063799752, -0.49415022495724914},
    {-0.5953794754120166, -0.038446802792617286, -0.27913001906176654, -0.23654691449074913, -0.6535685347589192, -0.27012170142456426, -0.26620885776345354, -0.5633714178833232, -0.299396641885396, -0.4635114641925557, -0.5316982172775326, -0.2504504896065525, -0.6429433949829215, -0.545957880313721, -0.5278938064087654, -0.37669981152663656, -0.13150658635432105, -0.20941223744544504, -0.282776427868905, 0.08994739482819669, 0.09559944744344141, -0.40499441808629566, -0.5600225811977864, -0.6357757666442776, -0.5046422779564891, -0.04511768919222074, -0.38935555703780617, -0.5214916616176352, -0.46585542435471533, -0.5698719871064816, -0.5559662790241224, 0.04294995473055398, -0.5916495790698892, -0.7083314186368328, -0.6008293918248387, -0.16824532045680218, -0.6110419708762713, -0.4688706141197483, -0.5005015731660166, -0.48887710535319157, -0.573736464501895, -0.4714068737819428, -0.18125392473267563, -0.5278709160413368, -0.5570663673420397, -0.19806469747034505, -0.388734764247046, -0.5453343371391279, -0.6869300446866076, -0.9502346891951581, -0.8124566018053138, -0.8502623979870405, -0.6845910112872958, -0.33618658252821154, -0.04792337660232434, -0.07678866464030024, -0.3048302681662205, -0.8319877287092657, -0.44333581251011134, -0.5423742884799738, -0.2501591171794335, -0.7460449436937536, -0.4019691665577737, -0.471280919428259},
    {-0.48170112376525137, 0.19200733771796422, -0.3087830668681107, -0.26366124339353564, -0.6130763109815921, -0.33772097712613675, -0.4472364441249899, 0.021769191423148884, 0.10041239283970978, -0.4404696915404631, -0.5188067138924667, -0.27438799876716413, -0.6921275827061539, -0.18338469313302969, -0.566072150117715, -0.48429850625218246, -0.0014949949442160408, 0.08995510182588608, -0.490919370537624, -0.10358472507239035, 0.42267378611577944, -0.6129944794675233, -0.51541481233435, -0.36961629940655455, -0.5880880286231687, 0.037556286310616346, 0.028735257976880865, -0.5641870204064761, -0.510295226502467, -0.5456091571851105, -0.7748549015317915, 0.1849681168644679, -0.5005953524829037, -0.7623157314290556, -0.6827448561242517, -0.06979371741002768, -0.6249873487372474, -0.3866369717761285, -0.15260069386440508, 0.06823682734735931, -0.7361410526425074, -0.48981139472016666, -0.029466804385457884, -0.39765589399774826, -0.7939252033237575, 0.10310152018650022, 0.009477087652054052, -0.26671281550090886, -0.6115014834998441, -0.5745576008208088, -0.42886885979204, -0.6198114738885928, -0.545089998004405, -0.5213255300414465, -0.2738571028493096, -0.3093826200385743, -0.4303570073999256, -0.6302760273093881, -0.3971663076351412, -0.07942088444071997, 0.033394072179075696, -0.46407206757321817, -0.19591059319644735, -0.3608775550643082},
    {-0.6445289639226206, 0.4435961981260274, -0.5557937221117084, -0.5014038357785047, -0.6131503367078074, 0.07848419305166625, -0.5494805650019459, -0.4610689518084523, 0.00951985656952606, -0.5816931876742161, -0.7039316955460334, -0.3002297223370737, -0.6068939599675626, -0.32528948874818975, -0.8643046958076213, -0.4254080551645298, -0.03507933726706534, 0.017744483839246816, -0.7306787063068203, 0.16226789709377146, 0.4855568700100019, -0.3887732750844641, -0.6407332186724936, -0.5829680161178542, -0.47161932300420445, 0.2982256044914138, -0.4133670965411684, -0.30762379007902646, -0.20424953100843274, -0.42376626505002074, -0.78733291059943, 0.5705935573959225, -0.29096571344972905, -0.7343837202225596, -0.6228430884136145, 0.18901472891789792, -0.39483748310296946, -0.24441481416547514, -0.16390665245641853, -0.11342662995862891, -0.4031915053286594, -0.21450443084041668, 0.08059949389811823, -0.8228850113832712, -0.9427462516326517, 0.30661571081816164, -0.15115854047672062, -0.3321437819602145, -0.2962357108720813, -0.47555009854929814, -0.31249365825453823, -0.5644942212545928, -0.6937801960908756, -0.45533303502268807, -0.42249258949747276, -0.14904425557652207, -0.25288721222513455, -0.4986315288818334, -0.25605341873229237, -0.42467716721639, -0.12693859871697524, -0.4537254586413848, -0.3745574233194469, -0.46727470472143456},
    {-0.7048367160862461, 0.4141482069229116, -0.5004211345481839, -0.25005705379252907, -0.4512570239750133, 0.2372957050999749, -0.4662491244574329, 0.0067488795147173375, -0.20242042010766195, -0.463943818167448, -0.5633573822693746, 0.00950657988485686, -0.6783733105331646, -0.3082547848207437, -0.5914974050363816, -0.5503824511454184, -0.27115349074342493, -0.28012640993378857, -0.5341698720626185, 0.10112927664407848, 0.3391148612873263, -0.5255814124682423, -0.6490207354461832, -0.5556913834115111, -0.5543896008072661, 0.49133958366380864, -0.24095535272859028, -0.2947423593870058, -0.38331472661295324, -0.3573989596792499, -0.6805805461839709, 0.2214240836232074, 0.29202867525207704, -0.8256668780777527, -0.7065392412884229, 0.05662925777037758, -0.5687871350958114, -0.3511383945762476, -0.13924431870873155, -0.19981215801867366, -0.6031651293438077, -0.5256151397565932, -0.1853602699163032, -0.7604425115211066, -0.6301880144773327, 0.24479867852298712, -0.40233428272201915, -0.5469081760188509, -0.19031493182714923, -0.6902207737730764, -0.6457265073737541, -0.6150166469502567, -0.6452440398227965, -0.6118871018805884, -0.289367930466125, -0.17766550625606997, -0.5118220159677134, -0.6544654023773956, -0.5623009407684543, -0.16741921336572266, -0.15353868090217399, -0.6645271966024633, -0.274200960092077, -0.3808558481555439},
    {-0.7187052513888317, 0.4613583432975614, -0.684176110497447, -0.6968979707512055, -0.6484440018332964, -0.03233126375864683, -0.6602229952216558, 0.10381012631034556, 0.0959257779416398, -0.5752106543980471, -0.5149073123852651, -0.07702780423612798, -0.729405267199177, -0.04241946303384775, -0.4712584298515171, -0.39352891309401505, -0.2988277898986334, -0.2495849560838478, -0.4406235771199104, -0.0644282686749376, 0.43452380005058266, -0.3971396697890141, -0.416895354000125, -0.6702156486106613, -0.5484571775338922, 0.45889916423918187, -0.6314277261022174, -0.3198148965919244, -0.4562000215875235, -0.49747488450456484, -0.6053100861153808, 0.13197163952170884, -0.19269898025743118, -0.8062359435906017, -0.387505849047198, 0.03766037440410964, -0.5586495148724873, -0.059297738660719614, -0.3665160036687388, -0.10485363205595244, -0.520311736670151, -0.5089912645490392, -0.09598972685882806, -0.6048337277923109, -0.7963449613483297, -0.07139598146856688, -0.33109758769337383, -0.38567086695392777, -0.18667926018792824, -0.8629639038998239, -0.6840035393014826, -0.6013477170185618, -0.8070599150731989, -0.5819554874673049, -0.3664174469328938, 0.08482197071045319, -0.3079292760712383, -0.6018070995837289, -0.3680899152700862, -0.4548490857468418, 0.0704487820009494, -0.41641042955130403, -0.4076572886631032, -0.5918748689299878},
    {-0.47599435123207, 0.6149406248572864, -0.46174960154372213, -0.4538593229839198, -0.6185416273986507, 0.09310084802911031, -0.1335030834307906, -0.2815771728460931, -0.13596600853056398, -0.2354465265992822, -0.5835343384392957, -0.32841214272928543, -0.45939155577696106, -0.20382710143873886, -0.47180933503501415, -0.5465869298412152, -0.0390318107082868, 0.04612850161626613, -0.22448680358429537, -0.05031730746814152, 0.5642111305356307, -0.5822237649198577, -0.45177781118723287, -0.6037487067662729, -0.40306812801451625, 0.28299748623549104, -0.5548122470020269, -0.24120752289604483, -0.3871159356161648, -0.3627873696861955, -0.7499153290069106, 0.3957906300268076, 0.05039993815967037, -0.7077084938766229, -0.2502162958789484, -0.09098323298334902, -0.43776403867592767, -0.10812274936539389, -0.4096895489481447, -0.30017292687279945, -0.2999845711103687, -0.4153864751184584, -0.009996530484203108, -0.4853596679099662, -0.5384154646473834, 0.12545129561233984, -0.24602300392484558, -0.48895577971525617, -0.27285882915864823, -0.4805225109196534, -0.3703904823795498, -0.42578251107503495, -0.346604481618938, -0.3047191327048079, -0.18860642399980523, 0.0526850014747264, -0.16078263052330036, -0.6396955949286725, -0.12560904205219592, -0.14112924782472333, 0.09647715721585813, -0.23298698261498021, -0.11933674751250667, -0.15411485720311155},
    {-0.2385464085689072, 0.3586217910749068, -0.3698583635908045, -0.2393235598976788, -0.03835221331989204, 0.1681175757308886, 0.2528891593346366, -0.007216723478291621, -0.2253192783235588, 0.19907553412485965, -0.0237350711333586, -0.37446358167938776, -0.023507581091642485, -0.21825274738937248, 0.08902118418877483, 0.06381332313470536, -0.135816628161845, -0.23253823306660976, -0.3150831034610149, -0.18241242081403983, -0.2355730911481148, 0.32388104040212945, 0.021025811009634778, -0.13151574667521387, 0.23183348855102665, -0.06496744708430822, -0.32649421322675437, -0.15501200198545442, -0.08708110391874058, 0.02099152281452952, 0.42727665540963333, -0.08282482719653272, -0.4060791960381047, 0.01016416079361855, -0.0952028997951808, -0.005429862518203825, 0.1659523736235377, 0.2061319369224202, 0.2899684954134168, -0.07910122465087462, -0.016056782681132857, 0.18056833355198865, 0.09022836708023363, 0.2780022093245949, -0.04757998980029629, -0.22789822238667728, 0.46553190043296444, -0.25765652112497706, 0.2029534446159749, 0.19134327832333511, -0.06165195287066363, -0.08607869664020056, 0.007263128025593008, 0.08445643363810164, 0.1531239815535326, -0.7880670174313782, -0.035409832122276136, 0.08598387560975022, 0.050387586012428716, 0.0767885955421342, -0.14569332832143775, -0.166490750173705, 0.06742602159491642, -0.4833025508643609},
    {-0.2489876504076554, -0.11930473759903124, -0.43693586926768707, -0.3262465770657112, -0.026710006900092842, 0.21564007536533542, 0.3127145704402101, -0.08730126358922886, -0.12024645004033238, 0.12582016620327596, 0.13407554373596156, -0.02895328553054944, -0.033819512277576465, 0.08976670827564553, 0.3349453929581346, -0.16051554932834197, -0.42257943589237257, -0.3522035981482403, -0.5173930542664652, -0.28097485742569156, 0.1826035834583765, 0.16156219470231503, 0.06857168496753115, 0.010846737559247612, 0.343707918309731, -0.11835480616129712, -0.18353285259919483, 0.16684935531398118, 0.16356236804005012, -0.09181479895555654, 0.051342611863657565, 0.35139248523859395, -0.2056097263595329, -0.025386494328951716, -0.5666927591351892, -0.1457979808910171, 0.27707555873930745, 0.3139647719385927, 0.4807705787895815, -0.014976288035055388, 0.33494671688941796, 0.1588727154756253, -0.09074178099565423, 0.16394428649699866, 0.08317012753534073, -0.5686135455353125, 0.41426334142138527, -0.3133565582440227, -0.06388375822371452, 0.5013563451458157, 0.4095265560307937, -0.08839479130819253, 0.10067941827871311, 0.33079321866072564, 0.27288537751858516, -0.6883024692965283, 0.29334759634314855, 0.43581797790323357, 0.3217664978112507, -0.3104836712606749, 0.054801530108877526, -0.48003868488921075, -0.12961763619086072, -0.5562519231904122},
    {-0.4167576698391896, -0.17210552872395762, -0.5464539227501283, -0.37502580893177384, 0.5742654754275841, 0.25593360374657487, 0.585181500255202, -0.14404635123935236, -0.4254045352365004, -0.14343691600704772, 0.24301624400178867, -0.13792754751788133, -0.256870449052742, 0.5460219142592877, 0.28728786964060127, -0.4578312468433226, -0.2379675135927075, -0.05006952812229924, -0.6868545589885697, 0.13359900933276492, -0.03286442527424906, 0.14282262997980075, -0.09283541176190424, -0.3220405422906872, 0.3848316295740976, 0.08558807036070415, -0.2129566353076518, -0.16056984404402125, 0.31826550516819024, -0.1773693500796631, -0.04693495043869468, 0.5248316722381345, -0.11440432340188755, 0.3483640349019232, -0.24214331279322523, 0.23824844518538305, 0.5655844871961079, 0.44984515342701054, 0.5487481820353803, 0.08986253429691043, 0.11874442464771744, 0.4068410386154806, -0.004113347505292135, 0.28380719811444116, -0.008087725682300687, -0.9299167738053394, 0.7251022438328225, -0.21572397275420999, 0.4134808568479847, 0.6370647580513433, 0.5232556376278846, 0.2875395910265289, 0.1625418478167251, 0.28824452779134907, 0.31013883458426517, -0.6312024988240655, 0.48520851267475285, 0.4026052659072138, 0.1325343439563936, -0.36307450015328074, -0.12405959121004276, -0.07031463179990645, 0.21796409034826478, -0.2719546783590856},
    {-0.40827747435536943, 0.05348073940561129, -0.24352293555870075, -0.031359305756729516, 0.4901281171548514, 0.5838482508670474, 0.3525813832579117, -0.09404776994562984, 0.006023605183487204, 0.15427589111892237, 0.08264402148231913, -0.15148470555735352, -0.36743693740946526, 0.12583196674242914, 0.07871594643598429, -0.18266736181384272, -0.3288225686197427, -0.08499827066619568, -0.49961074911830483, -0.2829336253856447, -0.3739809221401307, 0.23728411914293562, 0.25998889975858147, -0.33097254352237826, 0.7669038845600892, 0.28554537664771545, -0.024856466618351235, 0.06147915611932041, 0.19610318858845133, -0.0644385100345513, 0.018763153573870123, 0.5560665705377481, -0.31851529184403726, -0.05702309495414479, -0.5685493207774918, 0.17148248799483007, 0.5035272760841256, 0.0811404450362153, 0.7997462929001546, 0.13773976409909086, 0.005490113954702512, 0.5612530915053764, -0.1569707268821928, 0.3875382085104488, 0.042813401920354655, -0.43978899307261154, 0.602279749935652, -0.22135696422947704, 0.4404085053675636, 0.24042441197586892, 0.1615709544987586, 0.46326646907475894, 0.08865437035775858, 0.31021138966167877, 0.39350868798670924, -0.4675361724683462, 0.5350943554330329, 0.4091307060065976, 0.1722661146229244, -0.03535790160877504, 0.1644594978003978, -0.10349887745548908, 0.07909132312316366, -0.4761303265428356},
    {-0.625492546394914, 0.3922251569044728, -0.34827219822459227, 0.26254999856079, 0.2575178940666173, 0.18126632134558238, 0.49559842552616973, -0.05460461990389193, -0.15881100600297973, -0.25673260734531855, 0.17076521592050747, -0.27251918322945773, -0.45751281827167295, -0.2971596876555452, 0.21782822793697834, -0.4230911596589735, -0.29872364416286723, -0.20647036129659554, -0.5694773031131123, -0.11637416074371558, -0.3447612792218259, 0.353397907277405, 0.28682628914190517, -0.5192562473916975, 0.6818424510127298, 0.03428940352138803, -0.3463149391563689, -0.12383619129700357, 0.20508942256274207, 0.0848258295980557, 0.2510456222353156, 0.45550413985898336, 0.1639952282465413, 0.0004591503373997003, -0.5365325965312756, 0.003990564159690868, 0.40847447530349706, 0.40000907770850475, 0.21923955709851678, -0.4100944285290851, 0.09508996138844608, 0.0648830526895703, 0.08705688669697491, 0.31326938142249783, 0.07958724294394594, -0.5515606513421719, 0.22908358775238002, 0.03620679176215832, 0.07300064062588127, 0.3918093693661395, 0.5137231194729611, 0.23018940221048964, 0.2726909621152504, 0.23752072221458434, 0.18173096534297611, -0.5014309392011704, 0.4768709895949782, 0.4711333122314059, 0.28724585033925604, -0.07049580219621442, -0.15549812561068235, 0.20788526875361052, -0.14537425098184636, -0.6844949380624613},
    {-0.22706627611195884, -0.0402585722353051, -0.28275716255943584, -0.18078443879530412, 0.33341579392616366, 0.4159956578768031, 0.31876110954897713, -0.1190831948749564, -0.17123248719109238, -0.1486091766767911, 0.13220866621368568, -0.1448374861608463, -0.3195633530787802, -0.23634196132995208, 0.09236747178492215, -0.5358501495117428, -0.4377336103167781, -0.3861918080926418, -0.5944510115254492, -0.10592982023356841, -0.43646524850154367, -0.008381722941755505, 0.29256350285702226, -0.4920482609413484, 0.4723669230431931, -0.29763772207729483, -0.3766771319448167, -0.507194317879556, 0.2189751043710769, -0.05752962110890003, -0.04169539001628247, 0.7670168833262937, -0.03812102138790525, 0.4476060043628351, -0.24133257445221523, 0.13443212926171805, -0.20074247009729093, 0.4293867170351908, 0.8682094150247396, -0.3206964559332703, 0.24498349690453583, 0.022100167101111342, -0.2589753350809365, 0.21575481709606345, 0.06867252101888681, -0.5404895625469835, 0.49309873901720375, 0.20026129678897878, 0.29964488689831875, 0.026942448370753547, 0.556788199920199, 0.04774371606675476, 0.17615530198774704, 0.28370301260920094, 0.4084951702494712, -0.7677444666035487, 0.20194354017863542, 0.1968648727361675, 0.019308787107634076, -0.28597807992566066, -0.03867503721715757, 0.32341541770853827, -0.37011049193411677, -0.5198651923968942},
    {-0.46143673052388406, 0.17252747702113014, -0.5501467640547202, -0.39785114671575583, 0.3858854739698992, 0.30878857226605255, 0.35551867757835437, 0.17682833713930646, -0.47299503675348703, 0.002799184033644011, 0.012572664914285233, -0.34876031135553226, -0.11139188310724833, 0.11246133318211496, 0.08433546701604244, -0.5416138904181073, -0.36661182759183797, -0.48875634454428807, -0.5672351402418295, -0.4868687291598436, -0.05511378505920093, 0.14863133459734781, 0.19617878631318894, -0.20378880428131807, 0.34206830617823225, -0.19659579181612125, -0.5967790378438821, -0.24851740114562815, 0.22763367903084233, -0.19134169784300525, -0.09228694639356327, 0.7478175880737837, -0.2579700724613305, 0.10438537037443965, -0.09139188380588587, 0.10111012499201553, -0.3912600110907706, 0.6380352917043293, 0.528466542130737, -0.12838879059855707, 0.13388850213808098, 0.07392497727778574, -0.23046556320538292, 0.17883114389769067, -0.029397406674719646, -0.6170100657362616, 0.557214972359987, -0.010589222504442527, 0.2875460962067582, 0.31186305801737924, 0.23830894430051006, 0.2507298352441477, 0.21303627684247972, 0.35435546165508097, 0.11172364655744171, -0.6720552385862041, 0.3855937203335369, 0.46524691309442817, -0.06364023615956521, -0.5339272358990743, -0.17499743017227803, 0.3147534669161335, -0.35749195091753666, -0.8943100103359862},
    {-0.31342548474222887, -0.08750235014204587, -0.5730744863189526, -0.3937300178513664, 0.433878833066047, 0.4003399992250018, 0.7140377066307293, -0.015058212684575776, 0.0512928894694287, -0.10614746713045965, 0.28195259508843806, -0.3020704599397454, -0.10413335152226404, 0.1839142500701757, 0.12409431008315377, -0.7093642491043378, -0.380350837340713, -0.40329869556228454, -0.4723783573802822, -0.3494149610992995, -0.3651925199729253, 0.262854518507947, 0.5355941435834303, -0.02647248424542327, 0.36718168890042346, -0.04196443157588085, -0.6449465916327134, -0.25678675225024394, 0.13502872410244476, -0.11045192717032262, -0.162186150258122, 0.31109020935980886, -0.16341966435128114, -0.0148213342484187, -0.25764247344686264, 0.04446583400679261, 0.3444528449472691, 0.4230202751739711, 0.590591420525159, -0.33941012416051497, 0.4620331092827339, 0.113095397728934, 0.4952710639168583, 0.4576895133774736, 0.17634446838813328, -0.5010762316540588, 0.4331946323104855, 0.14961674229602082, 0.04446263579069823, 0.5628257903958478, 0.3666159416899706, 0.3048805394923089, 0.2936796141532046, 0.15338050068522718, 0.09157591109615645, -0.6604626974091545, 0.2540340971419936, 0.3312481630641775, -0.043955989675109775, -0.20658470757039246, 0.13545470484777766, 0.24425978168977105, -0.18769536334314343, -0.7327187486602852},
    {-0.4314929521525007, 0.21065957777406508, -0.5765640050250705, -0.35410728472990544, 0.546935969082667, 0.3570792265657271, 0.4117783552599472, -0.1220987270668258, 0.31246751023613495, -0.08034974966428153, -0.28205419104612783, -0.4612424846849628, -0.15150436000427478, -0.012900152199269831, 0.16986935102847286, -0.6685325859687546, -0.3693262698258377, -0.627060906113509, -0.5283369422756193, -0.1598952276198632, -0.17889576189487247, 0.27478767775028995, 0.4149799489902292, -0.5043707534639574, 0.4242864751368529, -0.05211036739406473, -0.7418684577756024, -0.14161673708595898, 0.03480945518058349, -0.5641785403594473, 0.060976540222761284, 0.21579015063533868, -0.2543996006549157, 0.15815621010981634, -0.4970727133074133, 0.28603633834756986, 0.4080055288172731, 0.33969841776527276, 0.4629777301150316, -0.24400095924035325, -0.14732829620968332, 0.4922049273723587, 0.0001263590663685867, 0.549204776279522, 0.13401384609463954, -0.6315183173814177, 0.5575853112476145, -0.05774333584968776, 0.5207090499250154, 0.43154463860998704, 0.14730051508747322, 0.07338092469986854, 0.1974832799903104, 0.03825170704138129, 0.35668031483636264, -0.6580411503063517, 0.5963233339709547, 0.4483531844329937, -0.24778006430648433, -0.18388123556011332, 0.33000982556849506, 0.5585360927951148, -0.21059411878950102, -0.633109611180108},
    {-0.6244072675120212, 0.233089103326598, -0.42177279985620064, -0.19572154446138465, 0.4429641889467884, 0.3588507095510849, 0.3255298571286883, -0.09347499631301855, -0.1876428579608977, -0.22588314948383684, -0.11972883106474727, -0.024978279929082692, -0.24263897570062878, 0.43278328639796537, 0.14312311500959143, -0.1858519864865253, -0.04697131943267179, -0.4987008173801022, -0.3506400237338062, -0.42000748559878215, -0.2954527049227665, 0.2228001240037776, 0.593240810572341, -0.13397203978422956, 0.5348167212768475, -0.046018825142222115, -0.48160599314864067, -0.11306415612018988, 0.08550372610905752, -0.18493764677215785, 0.616637893661694, 0.3777284226087057, 0.07901399609240241, 0.3118646574532518, -0.1735406831586784, -0.26715954691074695, 0.3459581457739616, 0.49397919290316916, 0.6421034454803759, -0.4916764647323129, 0.0005215372275862166, 0.24422586978771918, 0.16033278696604872, 0.4656826301974806, 0.015924375979605672, -0.6192037729731555, 0.46662386648388476, -0.27391816697503985, 0.4120916791242781, 0.8366101217573292, 0.3468699013202964, 0.45586687893240885, 0.5583679787120375, 0.2697070370887172, 0.1495404956940229, -0.7406291243749633, 0.7999697097266577, 0.6992925276655961, -0.11986145897426366, -0.20643997022137212, 0.24351884076819638, 0.5107948824611801, -0.13971003472241655, -0.3943377088077108},
    {-0.41988423967411853, 0.14637731249654115, -0.3347468679872113, -0.16389379918441085, 0.6534551001209294, 0.2794047254743676, 0.3975963920622425, -0.3565561308810614, -0.22236028377129213, -0.0596739951464713, 0.029964372504999736, 0.1317150850399188, -0.18111166062895556, 0.37284498814618694, 0.20569603674308579, -0.7010302456303661, -0.231700546046801, -0.29191068724991953, -0.4846151816036771, -0.20572279218768416, -0.08208560082015638, 0.4049330623266416, 0.432127445145385, -0.05090608341956189, 0.40779128210699367, -0.11207966318549814, -0.6379033407631154, -0.5279759482248254, 0.45984046858393496, -0.20989197387656425, 0.34244287800998685, 0.5829951937462847, -0.12190471903092594, 0.5742659142494795, -0.529079512043082, 0.0022185050658883767, 0.02756236706040237, 0.6518643513843276, 0.5841917162014986, -0.3869614555313952, 0.012734206677364347, 0.20047988458713678, -0.4108512116643499, 0.19108312564336336, -0.21666515807990422, -0.9193109458364458, 0.3956035738062349, -0.41101502883104124, 0.3242740255391709, 0.4854782013796377, 0.43326211952322163, 0.3550839676806394, 0.5556875132546536, 0.20407444817658799, 0.3463329313774899, -0.6614617207004704, 0.3083353366371574, 0.3682517876246665, -0.0782117662456461, -0.2685084945857538, 0.09328455057257784, -0.14509267704240866, 0.042267300697351066, -0.35501316569753927},
    {-0.031182558401345456, 0.024402088465408027, -0.2903071051249649, -0.6236651411197001, 0.07445609304184854, 0.6922106645108682, 0.45962907967261335, -0.022819431285679884, 0.025944268175165736, -0.2553470492410965, 0.189359931343006, -0.13440170958013536, -0.22563587499878676, 0.32764502412410834, -0.09727567360543198, -0.5786355327636833, -0.550524642845274, -0.11764514246506609, -0.47747076698145047, 0.08755376489171392, 0.18358647480326923, 0.14908239184931496, 0.17808644731304232, -0.6064128631295491, 0.35270052903755744, 0.008884449712588432, -0.4820236072329131, -0.4831839849061197, 0.4016085916215164, -0.42069113388504314, 0.15435467517747783, 0.36733165921966254, -0.25634358148082714, 0.23137943331214486, -0.310050263093447, -0.03368746769722451, 0.5257920744918294, 0.4660717672661031, 0.4153983019998094, -0.19645069956562, -0.08645565714890405, 0.11394563540580556, -0.1917993901588861, 0.25655848618401705, 0.26154285086300305, -0.8044210144430489, 0.3631755604565972, -0.03662753649340522, 0.4442217884142391, 0.251454806199549, 0.4128199753381864, 0.16730569707484452, 0.7207692987513589, 0.5955413431141675, 0.25241000071078773, -0.4723255812255443, 0.3595000998035254, 0.3327246619855445, -0.217694023393043, -0.4633039074764775, 0.06662256088581951, 0.2978838068170796, 0.01599534000119751, -0.8843681558091439},
    {-0.4326945097820338, -0.06910023406909045, -0.6345446969913673, -0.2999963574822356, 0.34839847438183036, 0.4379484075172369, 0.08134640675615609, -0.07816944186930691, -0.14290703596143203, 0.024776708396660897, 0.01732889869761707, -0.2517228255871076, -0.14634508526798995, 0.4003896082081298, 0.055222554405303256, -0.7014368464849488, -0.5931019559826962, -0.35541931007988653, -0.3463477177052153, -0.2848397157442309, -0.13858424762476704, 0.1306415808454502, 0.11872780323796547, -0.4130989178581359, 0.2730104354031929, -0.3817998493748914, -0.4254212304544729, -0.41902196369561967, 0.32716765427530087, -0.024909823453047934, -0.000856953883913529, 0.27348755152291665, 0.03974229963263987, 0.3248508565036416, -0.4283678393689639, -0.12229544555520797, 0.16881463146419476, 0.2892846867848255, 0.6724871117474064, -0.24000498431594708, 0.1142911466926262, 0.23911915841823683, -0.08759574004497368, 0.23708281136146642, -0.0576411868404379, -0.6086838943605035, 0.4959407526655736, 0.06508785153055885, -0.19535337874508057, 0.5188381465003958, 0.32862207675459576, 0.17783270143526872, 0.21457921011448117, 0.010787706398933746, 0.6020461607761796, -0.6449027304251633, 0.516509429072011, 0.2275571170014738, -0.20649300686306632, -0.1702075371781789, 0.21460914605018191, -0.10866032874367898, -0.2867248367875097, -0.23434118214295627},
    {-0.30352216983503166, -0.4143745392324596, -0.3318511803982478, -0.3959594249165548, 0.3161660869687873, 0.43030297160851505, 0.22643455740074714, -0.3655304021943504, 0.016442501395889837, 0.052924983091212165, 0.041589700128405946, -0.31014130185813965, -0.08942208962333702, 0.35432039624206185, 0.057854989057153416, -0.7465596932864813, -0.4087418060590964, -0.5151069099987757, -0.4271972671405367, -0.23060653638974277, -0.37283266672806764, 0.25679792682160313, 0.24815713893158742, -0.27503611751296686, 0.4394579140045328, -0.4279150338249297, -0.7639506177359894, -0.2892396817150184, 0.44366827834881684, -0.06144241030530897, -0.034835553452645586, 0.459961563247462, -0.10223068033547085, 0.313642067361372, -0.5655932740106397, 0.3905847279656509, 0.3085978242188183, 0.6474022840754178, 0.7221413860699876, -0.5440686928387559, 0.13388088566482176, 0.1695361869252709, -0.1945591091570781, 0.34313301555463, 0.025631731805663648, -0.424662992011385, 0.6368466800664683, -0.08531661841448536, 0.26722433436599335, 0.3476489896741429, 0.5644953607587831, -0.07938829807958665, 0.4983585338014175, 0.04574961432757166, 0.12163844423929326, -0.901201715410293, 0.6114539905243797, 0.34673427919808647, -0.02301874759256519, 0.08269119520369295, 0.20877896595136217, 0.1050694715064759, 0.05810603612615596, -0.48021164338834593},
    {-0.2893211642747966, -0.24981042464128808, -0.2370554726754043, -0.1857665249568465, 0.44422703380524015, 0.2638751733171838, 0.5416038130194095, -0.07596931589969415, -0.02755011821813029, -0.18497120739460518, -0.12052221721598524, -0.14057973840786472, -0.28889551611033343, 0.3695135980097033, -0.23921695036246304, -0.6168669484542495, -0.43812453872188484, -0.3334063337923458, -0.2886520440899702, -0.3813354940288568, -0.5248693511620935, 0.055268112846807195, 0.10754097324153453, -0.2740825514796594, 0.3799837680168258, -0.2757755321245524, -0.5435440302955298, -0.3042200516093547, 0.28350929167542643, -0.3195083645081776, 0.05321224357761518, 0.25155218728232104, -0.41759846818623647, 0.17395069961932078, -0.2289968075432144, 0.2684600753638964, 0.6530370685961704, 0.275423074116041, 0.5062086132827952, 0.03920439591588978, 0.26689502346400856, -0.02398241690764742, 0.35421398415403965, 0.14226116909551603, 0.3466298927362484, -0.28804600236070477, 0.5293460232862032, -0.051938797239062084, 0.4840332111103488, 0.20245363258945429, 0.6933250279792261, 0.01078460710941333, 0.41509774299897273, 0.5044854081652189, -0.015153193882501482, -0.46563421651141906, 0.515193748119114, 0.3365742336547148, -0.08676053206949215, -0.08955922173182244, 0.3079543737375504, 0.07322426195003137, 0.502321951299638, -0.6273609500170844},
    {-0.40072372979836346, -0.2943708206144726, -0.36876358021496136, -0.3646665486180841, 0.16161524290001358, -0.0305760130817939, 0.4964728490367644, -0.2084636127776122, -0.09338308131418437, 0.0329367392262744, -0.34714536579597743, -0.2685506129793411, -0.25181265165321143, 0.3687916099025403, -0.3551373697953345, -0.692538791651468, -0.6571860211840704, -0.1019112447617202, -0.0923818077676564, -0.46998740937788785, -0.6379372969029266, 0.0014349266715729756, 0.354476895169051, -0.011322782567490251, 0.4574607731256887, -0.055788419777848285, -0.7163104335584595, -0.1899763729438954, 0.12026363286745063, -0.27927756233326106, 0.35316684065267195, 0.3178326403580341, -0.5229993745559129, 0.4598885525217903, -0.5933192172451126, 0.12957864161136012, 0.216461153569285, -0.17100161773001354, 0.5604736721889865, -0.17444062844148217, 0.00041520748717616536, 0.34204919829700364, 0.22048321080968894, 0.0016395857643581367, 0.382364141526294, -0.37752643569130717, 0.6259360632688454, -0.07271725560764368, 0.3769873157096421, 0.06609827960596652, 0.3050664959723643, -0.08546443874583942, 0.3818315329695766, 0.33180524247713183, -0.006014414855431393, -0.69294277611127, 0.47654143455824516, 0.13937724805030435, 0.014607762910705951, -0.5521001392632914, 0.12831229131676772, -0.33404887896872004, 0.36145742767250816, -0.4636113125625282},
    {-0.31009496351136157, -0.4110008116088918, -0.5323959865741582, -0.2619920520332983, 0.12660295644879455, 0.2905373968339476, 0.2348916734767875, -0.4505067827512428, 0.10470813885959253, -0.013500385308947545, -0.06781594057126994, -0.27181970791743754, -0.5685320514844014, 0.3727903593273936, -0.20291049304771733, -0.5937146392769048, -0.49287417780061715, -0.4070236790768153, -0.3523264096913158, -0.06067179779517344, -0.24072312375394486, 0.19203596028308717, 0.19020227030635142, -0.2634071240055157, 0.49157377677211006, 0.018534060525521118, -0.5817302851559691, 0.020021037575748985, 0.08676838285196875, -0.09691241362990718, 0.18233644047826633, 0.33541090391987927, -0.49744605878431214, 0.16582569411342196, -0.3806501829807622, 0.2023211965887888, 0.21510842723132767, 0.4214860122352662, 0.48101037281346415, -0.4579521608411581, 0.37255302925932493, 0.2174364919794461, 0.25059974242950805, 0.4886558608279399, 0.1907974667599769, -0.4587409327788058, 0.863589080732625, 0.04017093685847673, 0.3196774687563437, 0.7416348795868831, 0.325519269793006, 0.3947171250758756, 0.4109110251124399, 0.3204516114350987, 0.2715410225638367, -0.779343312422628, 0.5727852363382703, 0.2255864436171098, 0.07253280951556818, -0.40536142736220065, 0.17965959232923898, -0.12643437012275588, 0.2516808008467802, -0.44133629064846447},
    {-0.24828949805275552, -0.2632106243407356, -0.5930013403251386, -0.2550097646588064, 0.2928266748901196, 0.5163082905959192, 0.5399239116764786, -0.5907761970537441, -0.3521332111212378, -0.08146252932511286, -0.2690129216784989, -0.10619604375992343, -0.37047926279097043, 0.3447166087063459, 0.3042707897892409, -0.6124185695920538, -0.3454916012174451, -0.4264246594559407, -0.44636541140253955, -0.50726897696443, -0.18218509961485665, 0.32616954154054956, 0.4397142724714095, -0.47441012466507043, 0.4411310832926272, -0.16863493093643425, -0.45870598202375124, -0.32810292616376413, 0.23267669009489855, 0.11960627527137294, 0.04235045370830866, 0.24864672939344237, -0.5125229076535026, 0.05070608984843596, -0.1610313758523135, 0.18071954222607345, 0.4549871869336383, 0.47308449349735715, 0.6525378087887803, -0.1523570315272087, 0.24388916060784135, 0.08333442202988234, 0.321089812300565, 0.4033260004972848, 0.1342936802838905, -0.421844913234024, 0.4516942922340084, -0.05254589792203624, 0.30547595818577616, 0.23986427514927477, 0.3438157078830813, 0.346068641521449, 0.08755375600530682, 0.7843437451493664, -0.021115646287695206, -0.3515890444772348, 0.5554739613365745, 0.22375383470905622, -0.09023724254770864, -0.41182539959956127, 0.023852781695850294, 0.30150319683428245, -0.20820383784400653, -0.4492379635538263},
    {-0.4721741937821982, -0.5464199806393506, -0.6077126217862041, -0.22248234983478785, 0.41438508822586956, 0.559245016877262, 0.4607012284444337, -0.1111666065310084, -0.10839932613381645, -0.012601221477839077, 0.22239949308319498, -0.11811835469909326, -0.2371367707112764, 0.26735557507957075, 0.20214791778775887, -0.6852197825725274, -0.5504014669713149, -0.882802739769676, -0.47308245397981097, -0.17987770880646822, -0.29923292087973885, 0.08326081638079325, 0.1897910338900604, -0.1303427986414024, 0.4849558093169591, 0.014712216817946405, -0.6424737226682868, -0.34122838158726165, 0.41276188985790646, -0.08012386711593003, -0.20722367889448762, 0.22643648805751793, -0.37282725028772873, -0.13241429496131693, -0.29988445400513986, 0.09191263110481507, 0.4088252128588726, 0.2654186631571777, 0.5420421842182084, -0.10818663813290165, 0.20478248942058638, 0.2916366485030785, 0.1301172177060582, 0.11787709776515264, 0.05909862180150855, -0.2023863199056568, 0.3472256948754715, -0.0961370090829457, 0.5215021430329159, 0.35112876969749385, 0.5464231344031969, 0.00908137806958446, 0.47600824076983766, 0.48342097922554894, -0.04800077743534628, -0.4909842083233939, 0.44663476293324933, 0.5719043401968121, -0.18096066593949497, -0.25273340051558574, 0.11098410169995546, -0.04459989315849435, -0.01052050530819949, -0.5740620102664445},
    {-0.30439372502110557, -0.33092535037706516, -0.4679554595924791, -0.29092377433289757, 0.5552159911684281, 0.3115995660126942, 0.5274108867807145, -0.21742530756086506, 0.3264386631186615, 0.027634392385467863, -0.006594824283384233, -0.0954130264641594, -0.6658866440513844, 0.29868830555905845, 0.3250175689738072, -0.6459506155647143, -0.37602159582527805, -0.5349945875908384, -0.5444285297401851, -0.014519112027516282, -0.27574243500658846, 0.09478694117306595, 0.10013407439314487, -0.15948026371465623, 0.3748708070529645, 0.10534139002999668, -0.49130634913358545, -0.3054998380600493, 0.3602618970493123, -0.20130932906920018, 0.27432746432551675, 0.5241306578754, -0.4766791215452502, 0.4245290339771016, -0.15846354123002515, 0.12759717432545728, 0.44020279118290756, 0.5638424599014988, 0.4910538724689471, -0.12110247591527883, 0.142220491072638, 0.33581553638268086, 0.3144446145368301, 0.6494936690480639, -0.16324585819063542, -0.4174825949265698, 0.6880501090915933, -0.22645140403361935, 0.5838111743762883, 0.3516609637085416, 0.5057977417877357, 0.12157471589794575, 0.33044731761928037, 0.5434011764875399, 0.32445139976361637, -0.4974641794256565, 0.459758108378139, 0.5955389240918346, 0.034674679017821335, -0.14949840768859626, 0.4299651957626425, -0.11368684689339222, 0.09278933549718822, -0.4796106852729244},
    {-0.4839796078370687, -0.15593201110214497, -0.477353273559083, -0.28482625548222357, 0.3139849408562151, 0.4178296935207169, 0.372659979280064, -0.057142417836286985, -0.05885350377759234, 0.21456039091454615, -0.28230010154899055, -0.17929125738565824, -0.4296586702197026, 0.40480879768165806, 0.22642008192228683, -0.5787698748060394, -0.4589039628927655, -0.2725725845458809, -0.2805020712848852, -0.2189031659900866, -0.3048109800296754, 0.09188594432138585, 0.28348907956305774, 0.07215308678630365, 0.538176837101011, -0.12086019539693423, -0.7030098918042587, -0.2845085916283691, 0.2566479637046965, 0.056356975822284605, 0.17942548831094546, 0.16814473022385376, -0.40854877289116626, 0.20268461606149984, 0.07620847351309779, 0.4626579427395994, 0.2806971704325714, 0.33071409995529316, 0.519093724112526, -0.1627113841123825, 0.3834441150690237, 0.6108998474881171, -0.008286140989080521, -0.02654585145866684, 0.2812935962039504, -0.6362944445062071, 0.5659310864173736, 0.21060832635758625, 0.7054613202690985, 0.303179773231279, 0.3640407321271038, 0.5368210046866478, 0.42862608091898863, 0.7951844152136948, 0.784361273464214, -0.6003337858229439, 0.4127106872191212, 0.6389378845468828, -0.08649245215038005, -0.267861354786925, 0.25062123140450115, 0.02936344507552067, 0.392229736967678, -0.6874296262851991},
    {-0.5294704079290963, -0.20936479736849134, -0.14663185604553822, -0.4415038680820665, 0.5174325366332941, 0.3756281408794066, 0.5546777469827299, 0.11133086405834022, 0.0956240606485098, 0.07345498195055364, -0.15916442655937535, -0.3320213023006183, -0.4960195946648823, 0.5237866084413819, 0.14712491590293947, -0.5618446181362127, -0.4554758983979027, -0.2763248190812154, -0.114386922759529, -0.08678334877879629, 0.049260628562960776, 0.07053744969750862, 0.16717621959520093, -0.11361127943764324, 0.45957578460167203, -0.09958715770131182, -0.3769211885347996, -0.5363979948072668, 0.14280684073575617, -0.0012863679783997118, 0.35221401741618275, 0.5101036178704915, -0.3419005204386587, 0.32021470200726804, -0.10740889476210887, 0.49772696339172007, 0.4570347978179202, 0.23122240306148026, 0.39705626378428277, 0.061406906114666815, 0.3305958756195208, 0.7261894668890295, -0.09086831050953764, 0.25762745765389194, 0.21226802325988225, -0.44233383994017217, 0.4706470185365143, 0.028913768161115145, 0.5478925436761004, 0.5111242599705212, 0.48039902969039217, 0.13999800900159967, 0.49757260696871053, 0.8852785461899632, 0.4549965776055349, -0.6501216955542705, 0.45574148118553603, 0.653634960048844, 0.15343012355022898, -0.5706360230305922, -0.1137342193027037, 0.13652885937812187, 0.120642481782837, -0.4498829555322402},
    {-0.3307199072422254, -0.048524606454903016, -0.5374015237667347, -0.45533854538077884, 0.4109294677893606, 0.4494675568826504, 0.28290191124466435, 0.07074767195649859, -0.44841742962628345, -0.22495508353109106, 0.16203909200445316, -0.057744993111443446, -0.3434096524173767, 0.5541187333538088, 0.3157393122902767, -0.5361596856519889, -0.5609493661633628, -0.2463103337200731, -0.5506223235142057, -0.1328591827950757, -0.3245258112078502, -0.06166612804409861, 0.3876708174309928, -0.034525219165200585, 0.521690935300848, -0.06756058702264837, -0.6258469867517217, -0.33983354020741424, 0.06824390839343299, -0.04089539963576204, 0.25916388023725934, 0.12019574528861734, -0.3858530155254661, 0.3213019117239345, -0.33561418829173506, 0.4863798884818664, 0.4700604176811956, 0.2316079337132092, 0.5317907172734122, -0.24134154592698145, 0.17855251929128446, 0.4065703853161246, -0.07819292507930178, 0.4280745724639138, 0.42193164315303183, -0.6298500471985035, 0.6888453908223875, -0.016378076589934242, 0.7576518738217465, 0.48854868004728796, 0.36073267264565295, 0.04443706518346936, 0.05912742264552593, 0.6948263013445183, 0.5397118970749659, -0.7660975090851627, 0.45467718418932274, 0.5714711441591391, -0.09899979521649965, -0.30602653288326925, 0.347034634455171, 0.16264799497683527, 0.26388585775136475, -0.5860357447040768},
    {-0.43258941727028666, -0.42596316695357234, -0.7106627230834563, -0.45215155308779986, 0.29889878342874016, 0.5610158531639348, 0.11201026726227563, -0.004687930166707816, -0.12932395452187948, 0.04111364522110477, -0.24694238996400794, -0.18377938309819258, -0.33999156398092617, 0.20880508467255618, 0.3206296594544266, -0.8496580049841954, -0.47717311848471367, -0.5313279714514544, -0.5487315870447937, -0.34105813150648706, 0.028557849911729532, 0.005820955280964549, 0.4446610282809259, 0.003598805088128301, 0.2972000312626409, 0.056022159501287, -0.5835882599466224, -0.46360416319630016, -0.002403231283115707, -0.1757767468147301, 0.3952386512729986, 0.23168416263861905, -0.16624895967279404, 0.31697205039260634, -0.5186090924760051, 0.26827003112099534, 0.21882910725110127, 0.14067872461293365, 0.5064733965096857, -0.2625690095700208, 0.018336515904372897, 0.5599936108987723, 0.13451698680105223, 0.5578686371028906, 0.3015390934959142, -0.6385254483983008, 0.518240061552545, -0.1541055552018646, 0.6164059159438733, 0.4999177080393894, 0.35481389717623446, -0.06362586529984535, 0.17048488099841294, 0.4683107259213037, 0.26866453852934774, -0.7366816402536859, 0.6497209473271424, 0.5337316242375063, -0.14664108215100757, -0.20592282108902832, 0.009526232085896992, -0.3573593891966546, 0.3345254833254214, -0.8152892512139347},
    {-0.1675744810169945, -0.4566913736786241, -0.32091457773934146, -0.37784783679776973, 0.4648587572087135, 0.5437013401152154, 0.4721263277499408, -0.1463463302352682, -0.17924586653265442, 0.07076593864958793, -0.018882375588030288, -0.13836094702458862, -0.20965480549432317, 0.4601145101310965, 0.09313320852806133, -0.5303871423201227, -0.5798897012200305, -0.19054835740241355, -0.4753644843120167, 0.11915033638469927, -0.2228495752050743, -0.18316808260671597, 0.052474710164635695, -0.2198420765061171, 0.30462625930022946, -0.03793793470669089, -0.5323123229719606, -0.3895431372800245, -0.14360758709029048, -0.1181821249349998, 0.2587770987488965, 0.2865788077472305, -0.2817552998759606, -0.18987278894444926, -0.25948875318287307, 0.10784398619453296, 0.34613918890589296, 0.30734955178992385, 0.47704935161747447, -0.081313083952652, 0.1785454318270808, 0.3916703334025193, -0.04874804582362985, 0.5392231922644047, -0.061918873660592115, -0.5258191218631136, 0.28382863740587133, 0.056943325775792156, 0.5732759573713639, 0.30120162351504404, 0.057526628270763165, 0.35495911618514026, 0.6103507741273991, 0.6935976580747977, 0.33994716065014347, -0.5437414830206636, 0.6510047023114447, 0.3805340504476115, -0.3731066670995953, -0.45641254404237713, 0.24284537770796646, 0.03518877360955874, -0.004852346739586682, -0.6033391789832397},
    {-0.6013687072242592, -0.29324116128743904, -0.4542301348896073, -0.371851848013956, 0.6276546029344553, 0.6289797635955147, 0.5713956346217793, -0.33301465473568026, -0.12339914828115991, -0.06096195851055646, 0.02512383384380639, -0.15004745180094184, -0.5151004476866644, 0.6268027179510317, 0.1398953373666557, -0.6221367454632659, -0.42915428776640924, -0.2503483674938367, -0.47097869831041894, -0.13729901302086533, -0.45398620239302395, 0.24824541226250954, 0.20118216112839007, -0.4560264958411369, 0.5752900085489333, -0.10390687446108622, -0.8160840002372332, -0.42904642116707364, 0.00422085715459052, -0.2686114616589111, 0.0847069057807241, 0.3859748940398991, -0.5213443971965256, 0.19305266273947025, -0.44927989297917986, 0.2262010413966227, 0.38486470065466766, 0.5272410458956478, 0.6595968954742936, -0.2394713066431038, -0.11378806751538276, 0.3893044793784499, 0.035325540374090664, 0.38524485700278605, 0.23315006219614975, -0.6333934758165295, 0.30144815326167945, -0.1337728485710726, 0.5633453748875434, 0.3639209470776609, 0.6365566296071405, 0.23205809578049363, 0.39447030274655925, 0.833454682760379, 0.348022032367308, -0.8500183226789707, 0.479783638175595, 0.6083680392636099, -0.0961465185442386, -0.23747517025492876, 0.4739092508204691, 0.09216583050787724, -0.038806811499400407, -0.6097010050652907},
    {-0.40753369401437833, 0.15082986615755428, -0.38412785316604864, -0.528819535853617, 0.7506567351733633, 0.4452005674709468, 0.7150149820629024, -0.16427591203980005, -0.26457884000008064, -0.02232669172680254, -0.16081633737813084, -0.027720536385339254, -0.3857346062146221, 0.4265089591752791, 0.13818575751720072, -0.76935573868712, -0.24737196761421185, -0.4131879281689226, -0.41158844776017706, -0.2992795874280506, -0.6172859111103066, 0.49515246920738815, 0.2562698731750516, -0.25042171632134635, 0.49055538213571587, -0.12885082657112013, -0.5509886411129039, -0.4708457008552491, 0.39760086330184913, -0.23812147494955554, 0.23266942562603296, 0.33779486226084054, -0.20162349078309644, 0.15135610651034925, -0.5984080206954581, 0.41004920561024394, 0.41784124707426534, 0.2865489204766637, 0.7123715589010193, -0.2450474893716512, 0.3069376054031394, 0.5910603753617321, 0.10777274017586663, 0.14026039382525302, 0.311649733477214, -0.4535549678478151, 0.6471332776139931, -0.3139023819495171, 0.5115781855081765, 0.7253847563179104, 0.46968573786127465, 0.13386099111482025, 0.5373248561869672, 0.6818077059997655, 0.3250786644283627, -0.5655065233956597, 0.6247624962933118, 0.5558173452581052, 0.08296635302137623, -0.3335435398491506, 0.00988821126347089, -0.023443425859656728, 0.012453108270215917, -0.881019487403006},
    {-0.3341111748470902, 0.04679830034457884, -0.14940632036688065, -0.4931608669875177, 0.45242036678964537, 0.2216635401552552, 0.36212808407664226, -0.2633030911971697, -0.3286472087831107, 0.3478638621692231, -0.021729390961310022, -0.16119589318404093, -0.4404446010439053, 0.6829117883062968, -0.18259691001874304, -0.8854641918862532, -0.45704804683821976, -0.3978253915065494, -0.5456212674764411, 0.12850297673512573, -0.31181470452824217, 0.3638988506918481, 0.35779588093946446, -0.2537641766025417, 0.5681463621607367, 0.1916037099736261, -0.4236969526735371, -0.271455005619167, 0.365780759894545, -0.19802830472786442, 0.12914878751088857, 0.47489183859932643, -0.3090741947387262, 0.03868449080216892, -0.758479541981689, 0.6521103205938493, 0.612220937749219, 0.20502969823288292, 0.9240248681234449, -0.15379731182434464, 0.27337530744197264, 0.3159912605371199, 0.2685149069908714, 0.10038976076441804, 0.35129858827838856, -0.6454429338569193, 0.6958487859351431, 0.11587167538445892, 0.6259223827673678, 0.5861961207760211, 0.4625241150326956, 0.1555174928344508, 0.488013544604697, 0.30438657287198, 0.26591033884029924, -0.7962554721862926, 0.5619831065166917, 0.592426183256332, -0.07728723336898133, -0.39722218220263583, 0.01784881582382471, 0.3463671733544381, 0.16599294788297975, -0.9038595120923704},
    {-0.6721811038936797, 0.04617595622609128, -0.6453424417402179, -0.4536316289110439, 0.5995182886432162, 0.6022130102473348, 0.43834718388945415, -0.14072124313793757, -0.05660161391137933, -0.03632417140967362, -0.07104621072996663, -0.16599236675282672, -0.4537960762097739, 0.37364299833212583, 0.10034020282678915, -0.5547755733967213, -0.3205855149822641, -0.42338120599827533, -0.5249484841907959, -0.20604553772723913, -0.5848075955306448, 0.016933304491899448, 0.09284476819349335, -0.27143894150141024, 0.6250211915653104, -0.07672674940688866, -0.43212681609153303, -0.4006508798903045, 0.18370806600870007, -0.21002381060437053, 0.11013399939045386, 0.34834162553152526, -0.4030119480132186, 0.44015074791099973, -0.37522362216948874, 0.5381017068498567, 0.5574723691499772, 0.2239894728822623, 0.48396892767371974, -0.2715767350331455, 0.043623006242690394, 0.4265213267570163, 0.12542464117015928, 0.1469276322230983, 0.23210673970442816, -0.6621073682087284, 0.5246877296835947, -0.15154419252045526, 0.4978167112058613, 0.6323061114074804, 0.6416326939159983, 0.5579802811802244, 0.506117304728639, 0.45937925933398094, 0.6226436119554729, -0.8018212438451503, 0.6279719345667474, 0.6289237383561737, 0.06164238568050562, -0.5540587013373238, 0.004330156050168936, 0.01861256684242428, -0.15332932805270294, -0.6764703456538577},
    {-0.47425013140694117, -0.17025982797013464, -0.6491575108566192, -0.8028586026659162, 0.531733745799071, 0.45633193985250575, 0.26448343782907313, -0.09952852107721609, -0.047077190491043516, -0.10150262988544674, 0.4151174674982944, -0.31436308671798197, -0.05098461287915793, 0.6794224357235636, 0.1296379409750125, -0.7675988091515048, -0.5907884879691485, -0.1869186523563289, -0.4391376378943796, -0.275691572261631, -0.32596062046600055, -0.11665472240795088, 0.47653800394357804, -0.30937336231881396, 0.35595111278070074, -0.008381898111158356, -0.7970148862311458, -0.6157628588869636, 0.48638563745654295, -0.08024537680503152, 0.10423542256023971, 0.2655564117071827, -0.5038339801330579, 0.06145152051132983, -0.562425167627476, 0.8074816826541303, 0.3118018161531618, -0.04775604016399402, 0.5958159405052423, -0.44979234359070536, 0.04746563876745248, 0.5560313514470574, 0.2103987222382554, 0.22249628124065143, 0.28410652630301975, -0.5758085494249573, 0.46197556712911214, 0.2514009355021071, 0.5497065417781892, 0.43725568934320125, 0.5401229689797629, 0.22258745574753405, 0.35549882421331036, 0.3150964124908059, 0.5615227761954543, -0.3852647769247027, 0.678621365503709, 0.788539821553119, 0.14646010251790467, -0.35094106823645616, 0.10372715585801978, 0.1067754819062322, 0.38070973102708033, -0.47808062928182504},
    {-0.04914742576482781, 0.4341798632434242, 0.25721680626644117, 0.4835966803947474, 0.38813086471682323, -0.3323549394057282, -0.7404653705049831, 0.11501184398169427, 0.5816848031509337, -0.604072132881192, 0.015041013857090614, -0.2587373496542498, 0.038113286799806495, 0.39717157336416636, 0.44737206298171645, -0.06835226748052921, 0.6400097858846154, 0.35120048211044036, 0.5008956546984981, -0.45004992891588713, 0.41405725188554915, 0.39172434362878905, 0.3838561735145253, 0.36749763660684703, 0.4815015665191827, -0.06497665715486904, 0.3060414288419323, -0.5753430608550789, 0.288066467842327, -0.6050889689319073, -0.2979562765608534, 0.4698840211672823, -0.44504437938300667, -0.636409413298417, 0.35249503714597863, -0.044795351745634475, 0.031036708024627453, 0.5157148266135964, 0.0035595712357712164, 0.7023641793645395, -0.33878783390909806, 0.33158643713712666, 0.505923773619082, -0.07847086552911035, -0.0858779577990844, -0.025574617886476133, 0.268787742638701, 0.3082795390335017, -0.8545173322292913, -0.1113393503288397, 0.2779017929174934, 0.3119858250598319, -0.19179740000358406, -0.09362406021122922, 0.0994488818515546, -0.10779839281558286, 0.19093034645556878, 0.352350805401222, -0.028159611383081113, 0.4249341295571814, 0.39888000135121454, 0.25162033694314107, 0.4977166447570633, 0.27463009128831095},
    {-0.42933784385965645, -0.1171829448202331, -0.28832985426920527, -0.25042529850576956, 0.23028712919604402, 0.20537405183742305, -0.278096645588905, -0.16067359840547885, -0.14700804224188976, -0.25188715848383486, -0.37388625995157554, -0.2952094964337477, -0.28523798760318503, -0.6426823222105735, -0.09361893227570516, -0.4394868392005068, -0.14079830674233743, -0.45977110813179384, -0.39317742584193355, -0.0739280683250823, 0.08985403344954437, -0.6904861405360236, -0.39150934832664325, -0.2161811532446414, -0.41837386589469877, -0.15932083758524312, -0.27238356981923917, -0.009234677099141135, -0.3005509203648918, -0.12396020020537103, -0.5304485997034227, -0.4763322661111466, -0.42860317618050625, -0.4343172799309252, -0.6401245564658765, -0.011106262008919787, 0.07738320703233866, -0.5058720579607199, -0.16646145117253663, -0.29930973336374567, 0.0813495099499144, -0.2595155789975998, 0.23740772281014771, -0.48187605781262227, -0.2923748583040788, -0.5993205228716451, -0.24974433845747807, -0.04190641014884918, -0.560328377294339, -0.313278490877232, 0.04122338409930363, -0.49652099665530813, -0.31806782349664486, -0.0946831860359385, -0.4194574275456062, -0.3159584452714095, -0.37324555816842064, -0.23000999299987862, -0.204291439241696, -0.13187530480792228, -0.0571194323461776, -0.3223436558551282, 0.12189739935267017, -0.5927693899621981},
    {-0.22109362673839858, 0.4268006421580292, -0.28826939912612887, -0.03263898152984703, -0.20239937319720214, 0.23190064023630957, -0.7285166591639807, -0.3872489985398696, 0.4544882371245957, -0.5438740297222129, -0.49432010393955506, 0.000649864695646788, -0.38343858619845145, -0.3973886689266148, -0.34538044155227715, -0.551451367945706, 0.20606106869750643, -0.3606890155340521, -0.06866037952168973, -0.07940734429425506, 0.7620636140355939, -0.40555813026203374, -0.20439788019346478, -0.18088758805711022, -0.5105004267410282, 0.35643884958255473, -0.23959827734338113, -0.12981277977042857, -0.28226260272104464, -0.223372010231438, -0.4177695205843141, 0.2088746559181528, -0.43716234237049484, -0.4293759041475232, -0.33488261468682107, 0.07818170765916597, -0.28628389410705, -0.20608286711678162, -0.22362032024247736, -0.039595293143494414, -0.2969963082476381, -0.3902463011168865, 0.44320124148761775, -0.5217989345453453, -0.3748756299192361, 0.17762205891077398, 0.18360797600621773, -0.09912845487708773, -0.18311878401900142, -0.4637996549053761, -0.49321993481828386, -0.47288546414602917, -0.6150110686231691, -0.05407879161900517, -0.1740582366230611, -0.17700976940293958, -0.42302242143192026, -0.4242072493350614, -0.3037168261205868, -0.1856883576972797, -0.5611654078217856, -0.09784910669403304, -0.48188703018258916, -0.2907892422821978},
    {-0.5554605246340942, 0.3783905139818843, -0.05725266088364937, -0.06467079782355516, -0.12357483009814527, -0.3206088378039401, -0.2772828799547551, 0.10481079607059979, 0.3348378751875852, -0.04097235784833159, -0.6554536124025528, -0.1997903401798913, -0.11138200102230426, -0.16122262720200212, -0.09107067169112625, -0.226056771486405, 0.1931751591640209, -0.6016778011574451, -0.18137592392836396, -0.3305496326372355, 0.4892916908235203, -0.08178030340657028, 0.024042920954305963, -0.09771656290887626, -0.3859246014342058, 0.04842645585476557, -0.29544487356457555, -0.39255266801460964, -0.2964529178049202, -0.642879195613637, -0.19190330800412467, -0.2317832927935128, -0.43655807734298335, -0.5082207505912733, -0.07339500913813517, -0.17652123650653098, -0.20842064378146924, -0.25865130933618324, -0.34709294071222563, 0.028210956632506053, -0.7257331605843466, -0.18904619760572564, 0.3584390708567438, -0.3865055015686922, -0.4190416832432843, -0.3184696996753586, -0.09491209648182497, 0.09479253204668966, -0.4139294405977531, -0.2255733870307233, -0.2769343703196356, -0.18358411496299037, -0.1673587461346868, -0.26255148211376644, -0.0025666669424588098, 0.09355806252402143, -0.2140545801875747, 0.14161933564333792, -0.21241053965739484, -0.029033008894875013, 0.12126731582610191, -0.2878308652457442, -0.09637103257678925, -0.35955404906560745},
    {-0.4979139806326373, 0.58313484550577, -0.47013273521426796, -0.45043115328609773, -0.16403870416545263, 0.03699090222378039, -0.30519989629946803, -0.1435758054632488, -0.16987771174447022, -0.2687958117772806, -0.544808397301821, 0.12503954233281292, -0.42067151122743, -0.5521229514987501, -0.5285165295499785, -0.4125675022840507, -0.09092702377125735, -0.03834011509202748, -0.38049872126706263, -0.10807930767095483, 0.2595840854726491, -0.3727696535090836, -0.5257737834334809, -0.4377308383649244, -0.38099926964087, 0.018179019614538626, -0.315947372497434, 0.10675080564070911, -0.31026665732815034, -0.21995205624489042, -0.40468341692442483, -0.11231575612055412, -0.1005597448806683, -0.29580067103651925, -0.510353331628082, -0.06985568840493774, -0.7814435057340039, -0.6128854159411318, -0.0734867472007541, -0.39540327630673816, -0.17422131219360382, -0.45183990865806184, -0.26522474767144144, -0.7331645192837374, -0.8896231254311424, -0.303044215265572, -0.48705503090668, -0.10911940316734334, 0.00835119674219869, -0.30905779704297104, -0.613427268909256, -0.14576421547701454, -0.35645906910734515, -0.5416937537141435, -0.22406450537821102, 0.1670538288646456, -0.22786209411336672, -0.2673926642910551, -0.153489356998897, -0.34263111021507586, 0.20234274000417102, -0.48897458259998394, -0.41364482419021775, -0.2904413481686883},
    {-0.35670919851178273, 0.01002319965962984, -0.19719644887776938, -0.41148230135502073, -0.09322148188974087, 0.08978357513689882, -0.39005066035813557, -0.12611931227002318, -0.4401971932172749, -0.03785810497978261, -0.5706274799846329, -0.027175212841035933, -0.4162121986590689, -0.571888921862446, -0.6008964291673351, -0.24681623764306782, -0.0114457898295545, -0.3498428361363335, -0.40366334986696484, 0.14420154137332233, 0.4254520857989706, -0.36050636992853624, -0.5960043886763801, -0.3962223054349063, -0.5155579820827254, 0.0018023204979718066, -0.41746420989706573, -0.12528252558071523, -0.4330370427892856, -0.012555136477436592, -0.3005552890734929, 0.29194760034706996, -0.08803144767784746, -0.5111532430609825, -0.21764740979043315, -0.2846438519104446, -0.524319312355013, -0.5314676243740696, -0.627215493230078, -0.4325898956654119, -0.19459606064763818, -0.11914175934246815, -0.18052918465210627, -0.3209176149132985, -0.5657575164207205, -0.287507189064476, 0.017950278440159784, -0.23149949018208713, -0.21404152822024813, -0.44756947348097037, -0.3971856192627751, -0.3831039840277436, -0.5938497604455951, -0.23918128272066227, -0.26739740205199575, -0.04974832605725815, -0.5239327883461657, -0.6783907359836099, -0.4620966144428073, -0.36385277393700294, -0.5115906973611514, -0.5463502495380245, -0.5393865817939307, -0.3351593759826012},
    {-0.6412795872145726, 0.42149954058396955, -0.402759695604797, 0.10304085841578355, -0.3821269391356414, 0.03777733027926169, -0.27864421229939224, -0.20529142275713452, -0.024538713951997533, -0.46783371842073135, -0.2892172446623607, -0.04311524579351998, -0.3760363487877292, -0.18708361434402335, -0.2877083467889457, -0.2152176237611242, 0.03394009571898861, -0.15987366835115036, -0.4392495389938352, -0.15914337727327824, 0.4782888978936641, -0.05110605835485566, -0.4483875783121473, -0.36611891505386285, -0.17530466716375942, 0.23053816863313487, 0.13590791266251845, 0.023015308263031768, -0.31562454469646956, -0.36294458765641163, -0.3924305006152327, 0.3145985553381815, -0.3484802421260199, -0.3429753627184645, -0.19271613225690512, -0.29709323007261723, -0.15282178260840207, -0.35651314553888525, -0.5962909300157389, -0.16085117713246275, -0.43807539651621186, -0.3771031084491056, -0.26655778521191514, -0.6579394613885619, -0.4350851728793217, -0.11669381605173511, -0.2396915810826701, 0.10743401685961973, -0.34074937595252935, -0.35202990369290865, -0.33392026689762605, -0.4025917754363857, -0.6038201455726991, -0.4450569301873117, -0.013732406022072572, -0.08584476572141053, -0.24434337617763394, -0.33089235277816753, -0.06250517351634492, -0.09351863989109008, -0.277524423408498, -0.3338991748025208, -0.19503684498876206, -0.1440240338777392},
    {-0.4076611364894959, 0.4606934612691406, -0.4372561545727652, 0.020088354543468728, 0.021439579134308856, 0.01450378772994697, -0.09226765805955087, -0.2376311529160662, -0.30468639591960267, -0.11147415866755857, -0.24098756689908377, -0.06459021719416547, -0.38798129815764887, -0.19541981117879964, -0.5485031134335353, -0.17210969318235703, -0.14665482259651255, -0.26524713182227266, -0.4064805832636449, -0.01908536736790583, 0.297521839660489, -0.6172257647766032, -0.3852635152412007, -0.6055302959450024, -0.3717270483825752, 0.2865438065516058, -0.28693179339476815, -0.2642937754161369, -0.3027104913246129, -0.14885831718652126, -0.42941786204767557, -0.13726083449097023, -0.1976297599421518, -0.15662941411506484, -0.2375879434603045, -0.2427571748924952, -0.38128816632263063, -0.26081691300629545, -0.4865576914754564, -0.112082506021358, -0.21277641850524748, -0.4208684826548409, -0.2528044250674826, -0.33903609786434274, -0.328737352645195, -0.19737694510265358, -0.3346050212058249, -0.12386765531588473, -0.42284283900833297, -0.3731359184792292, -0.5644753254444117, -0.528407582939714, -0.367336485773211, -0.7552957859109691, -0.26196485532178904, -0.2568211300107396, -0.3092603777708017, -0.25543456811964543, -0.2853163387633307, 0.03688088307815151, 0.141252714153564, -0.42613200594243106, -0.2937845301642493, -0.09264928688029175},
    {-0.2869197453332415, 0.2431815305729471, -0.32864288613312165, -0.07569839210711331, -0.04142576341490673, 0.033415010991887505, -0.06608691090057348, -0.4556419343098511, -0.1786559206856828, -0.3388116471898771, -0.2499939984492506, 0.051458309210174656, -0.5948278770363673, -0.2574912739745422, -0.4897441717759209, -0.06606939583093446, -0.4061885658612073, -0.43869877962317766, -0.7121947183392635, -0.00957599370137188, 0.05746117287487714, -0.48531893794020114, -0.3449294072813446, -0.5262700388455697, -0.29672385886774155, 0.37915421196710697, -0.1792717168490407, -0.30009500252625393, -0.5707091320314044, -0.27030350260395464, -0.716820913236897, 0.170466855061672, -0.09255216935658911, -0.06761819491062633, -0.5284815163227803, -0.16458069549317655, -0.4271600059097452, -0.5770012079012419, -0.4582570280538061, -0.1623367721318203, -0.3500265357264548, -0.3555558878973652, -0.01932283716384118, -0.334597609045479, -0.536428103130642, -0.21598139456565418, -0.4441921950792415, -0.3010346731710878, -0.24465302316345933, -0.5904588032093246, -0.44904432531382743, -0.45865418938338776, -0.5417386612343538, -0.32026438197201684, -0.15161146898646977, -0.08852196463344252, -0.4445516745271326, -0.25899679507029394, -0.13216159629587104, -0.27096890825555986, -0.3503836332515643, -0.522717019758199, -0.15064919020671116, -0.2940449227061703},
    {-0.020488158151855635, 0.6261712063094759, -0.441320355105175, -0.33829798166950115, -0.3799817154796735, 0.1449302909547011, -0.2830106288802051, -0.13342724008381088, -0.6712143924986417, -0.10376044472647356, -0.4381352986629793, -0.07614371556666039, -0.3917792244513612, -0.13162922780207112, -0.34386725758190545, -0.2500715279338677, -0.11771025608494272, -0.21845171495452062, -0.4627029661932452, -0.02904702448223351, 0.3729180704363749, -0.5076297412366515, -0.2638342366575368, -0.5181887464031015, -0.2903382592144798, 0.399170976748027, -0.48177888263384655, 0.03235493122862867, -0.5773053148959345, -0.21239893585632233, -0.5642211678142228, 0.2917636475097243, 0.11424833790707385, -0.4704796616668841, -0.582142623019763, -0.4306698871225289, -0.5405564703984789, -0.40044944943966204, -0.44022331819664473, -0.3310712358591896, -0.42903043937285795, -0.1837005379224506, -0.4962189782811451, -0.5241854846518239, -0.5947410750432135, 0.10065862825732556, -0.5707228061780334, -0.2536704106458867, -0.46343808874865283, -0.3160400896416386, -0.43097479508479714, -0.6740046864985249, -0.5485404425119806, -0.09853574764447336, -0.14434535065423326, 0.08228280235186823, -0.33050256361167907, -0.49884461226635174, -0.045543513644915413, -0.06655176138681666, 0.10669830187019569, -0.2947107566005155, -0.13197335518729972, -0.1354062055601111},
    {-0.42526382343615354, 0.05415117494332147, -0.44865165466928036, -0.06259694545430067, -0.4070729639882552, -0.019501737296569965, -0.4479589403024828, -0.1698736892695027, -0.010738894303414239, -0.327645920500906, -0.40705852041233226, -0.6210228756940365, -0.25813535571784935, -0.1984655643125174, -0.00762364676928269, -0.2536232648236647, 0.07434510550150905, -0.1790944766356032, -0.6590147548702243, -0.43789692582076095, 0.19702959884635945, -0.4134982383083977, -0.2728177131565424, -0.22628998069929318, -0.019800908350131752, 0.46784324254738413, -0.24426712256563218, -0.1401951765831137, -0.42328572005589044, -0.5471219619305566, -0.30178041560466673, -0.043855891992125424, -0.43456975434380224, -0.6385500180048599, -0.5195625365401573, -0.4318032963068001, -0.42392721048546217, -0.26249646188591097, -0.3833990001572319, -0.037379114984306815, -0.3028384042400015, -0.045207469540044065, -0.27388132654704445, -0.23063807601238517, -0.40254307081031887, 0.0002535890920041402, -0.2275977834424166, 0.1789094578164258, -0.6276319045441785, -0.24788074894835965, -0.25592406686758995, -0.1888384855368526, -0.7520321303151358, -0.47161132322468025, -0.18701891330421666, -0.010248140699958138, -0.4423165287975024, -0.3623103539927774, -0.1720577415699555, 0.5260854491647681, -0.38087911834080146, -0.24213992360052122, 0.0063614753768123965, -0.10554703464828533},
    {-0.3528321305765321, 0.06085066784803382, -0.3017941771574476, -0.3654436733827751, -0.3137162875950279, -0.20168195486889445, -0.3283492000863084, -0.4155840133437018, 0.12915717475100635, -0.28781247918701747, -0.4295731363774952, -0.06055677201721261, -0.3009206843234428, -0.30988912842319716, -0.516213008501323, -0.38805276273577693, 0.052152713794766915, -0.34858796748007653, -0.4673888266314681, 0.041594824786002384, 0.37172183148605414, -0.4389061025494392, -0.44254615824005544, -0.20998552636095483, -0.44741070032950087, 0.46802831300341247, -0.5418214754249672, -0.1440573782800498, -0.20553413488482833, -0.6462395844337309, -0.4163606536544238, 0.6162312769766329, -0.12016472359367927, -0.6906764811482581, -0.6104892613757182, -0.4368789912532185, -0.5415536760030918, -0.2943211686554997, -0.39349727811481217, 0.3022905867184937, -0.4579292241284194, -0.17944883655557126, -0.17480967106531164, -0.5740772452575946, -0.28626427158737516, -0.14806870157978924, -0.30859565052354576, 0.07458630308161818, -0.4563270383123544, -0.5036867311546954, -0.24336749332655666, -0.3314687708050114, -0.7848247067634345, -0.23138330641980506, -0.49599501959673703, -0.2016391959876305, -0.3015267333137679, -0.5286580742707694, -0.2859916652478931, -0.0330352551298339, -0.2598609181281791, -0.45144149081439355, 0.08789925052623816, -0.19858579703881427},
    {-0.42602976345287413, 0.3183847154711719, -0.3139244680089682, -0.17026104240948328, -0.3693426514447957, -0.1947515137737111, -0.36570991539598086, -0.1783627178702, 0.13425303154087323, -0.4811723887150869, -0.33005415223370566, -0.3234509884559459, -0.2644775974010346, -0.09289082657610304, -0.4077019819782549, -0.23346452740250662, 0.10916440352704306, 0.14290585506447856, -0.3275313177622348, 0.15541804416858213, 0.24310093123509877, -0.5212974664883031, -0.3159662073098971, -0.38167385194151393, -0.5834010075260285, 0.19926748739426609, -0.3406765449865962, -0.09510866823788039, -0.21421638169490995, -0.282271643995632, -0.6426705226617294, 0.2013832509905254, -0.15416218415692726, -0.42174603405694105, -0.3691125629131426, -0.16119860869740008, -0.41700906206695404, -0.12964065050941045, -0.5285447235944867, 0.06558154735517376, -0.08192239355275155, -0.1804687982500319, -0.23878837743195772, -0.36203928409026587, -0.5963575136534832, 0.13165981405317406, -0.04203725769652993, -0.14413681524873742, -0.41346316097682867, -0.5763664108740836, 0.05006004764830754, -0.38792784286279774, -0.6094799563895315, -0.31588676156809814, -0.2751798766049144, 0.16600642595819273, -0.5659672250974085, -0.5739917815336555, -0.5096411653076556, -0.13963952259994836, -0.5576878973674321, -0.4656805782172811, 0.01256144459908955, -0.02424967757113747},
    {-0.12260116192409919, 0.0639534236062627, -0.4763414704059707, -0.33369046895549503, -0.26285979050477265, -0.12949870636128408, -0.45080710800940127, -0.17264270396517142, -0.22651547597723465, -0.3073434912612306, -0.5227645998610755, -0.007195991780233989, -0.4683432842873758, 0.012240588748438346, -0.2592927837175313, -0.27510597824926264, 0.09469667761078457, 0.05909320474590249, -0.5671623458622496, 0.08245480268883812, 0.22083899012665703, -0.3458716492224444, -0.336323120462809, -0.3997990175474468, -0.6271069366329209, 0.13787309659693645, -0.5899938467047035, -0.16402566233472718, -0.11493149243760974, -0.061569431618839404, -0.5319323017920463, 0.2807365686613246, -0.16267087138192568, -0.87138127476576, -0.22710602036687774, -0.2515654879444532, -0.4657574880306838, 0.0024447879931305985, -0.5241262750833222, 0.025377116896498988, -0.24443776443958817, -0.3584412244918499, 0.1656014061927304, -0.39751690593576866, -0.4492611957494193, -0.02331282259071735, 0.16886412718937002, -0.20961197335396847, -0.0731288615839284, -0.4000771629313311, -0.1667326983126585, -0.2818960211639812, -0.4926101635224197, -0.29526004383166127, -0.10755636684685063, 0.34916388640598817, -0.40429134260147603, -0.27679284123812986, -0.7561441690440135, -0.1491881638917279, -0.2777121820333974, -0.1973525016935992, 0.04519821809951231, -0.22228430567677537},
    {-0.5656139842421105, 0.11215960194944032, -0.2599509185171398, -0.20695047848153592, -0.3238700401341316, -0.36720293566713746, 0.03927144143255125, -0.417681833578549, -0.09406311199552013, -0.553249639067106, -0.18879866185495608, -0.24871157002422825, -0.35796254386444276, -0.16703687584276608, -0.721679395549509, -0.30724490775789665, -0.2656764677651319, -0.2985119273621873, -0.4348238462458875, 0.030412949959827053, 0.470261953553614, -0.48428608243787086, -0.3231989567533394, -0.20918341387045025, -0.46494461881207416, 0.024740302940905918, -0.36191993749589585, -0.3103821689815439, -0.12727812721472698, -0.5091129177506777, -0.4725420477079751, 0.44549328991109793, -0.025295314045750215, -0.4442603344815725, -0.29044637627338277, -0.0825307812381518, -0.3975056826838768, -0.11828645912685451, -0.4351624645931035, -0.042868754259060365, -0.3800026448457414, -0.24538330258056945, 0.02433421123685782, -0.5443674613118407, -0.5951473342333888, 0.14847067842789818, -0.09533652413498679, -0.1755782788066949, -0.23826373559321262, -0.6266638065234855, 0.0813992051093242, -0.4853644692266762, -0.6998632928802876, -0.4837714704092274, -0.45388790480457275, -0.05149413099181865, -0.4178835700686724, -0.20669884551367274, -0.5027960421155759, -0.17493058635198946, -0.028343362675724702, -0.22162845528445754, 0.10449525349181107, -0.16681730808436446},
    {-0.14225742081219286, -0.04774463351720045, -0.47501513168745396, -0.3134055389581486, -0.341766212587969, -0.15538088076368212, -0.34008815111298446, -0.4204512140431948, 0.03823628252581484, -0.3404630106402111, -0.23688529242945797, -0.2964404830417371, -0.375862173235323, 0.04216999427219707, -0.24796460844474139, -0.5074159587257825, -0.2280888963191824, -0.08378395292271641, -0.5338320570390934, -0.22816667792065803, 0.5798237943310762, -0.5699322094815619, -0.1262251480360904, -0.49186573145100004, -0.35150394534898166, 0.3554987059991163, -0.4859968805142079, -0.32541895861676723, -0.32094246963240186, -0.4709783422141458, -0.417963132891496, 0.22981431655688667, -0.2379467773454423, -0.5149125462806449, -0.48738724833898533, -0.05705272240453645, -0.3768079540666623, 0.07612265828797114, -0.3391087269589725, -0.4158646633671933, -0.33497852957447116, -0.2567232676812403, -0.14129762521945194, -0.35975624781047977, -0.3911657134618646, 0.025534638193979328, -0.17204615980767393, -0.2738240138733688, -0.10329383892506622, -0.45975566325902817, -0.6644059478878008, -0.452645521041626, -0.7319078067201128, -0.2373934449873771, -0.14177864181257718, -0.12074768344546728, -0.2767299174807771, -0.3417278738254579, -0.4661002595817043, -0.22174353969251123, 0.0916134614438637, -0.3157713207162889, -0.3617242223934823, -0.21905200553770815},
    {-0.3450522155766715, 0.2204885107904463, -0.47023225667145147, -0.2453623329691687, -0.337251644837586, -0.06558785007586516, -0.29619923643899715, -0.5309385858792629, -0.2101699503194883, -0.3174227146210093, -0.43008574373996594, -0.295565221775353, -0.7079629448945143, -0.20728357393551416, -0.33708837130148017, -0.3329767881529101, -0.3331168118981148, -0.30258849776907143, -0.585570527192537, -0.14846276152796342, 0.16184928116824537, -0.46609088545993804, -0.43467078921552343, -0.6100193554883413, -0.49708008855981073, 0.24540105786987262, -0.23340643770235203, -0.3777132106942339, -0.5068655322314553, -0.5470163932487094, -0.2675003383266349, -0.12795482748121897, -0.6745361547380269, -0.36361349946280075, -0.3117943483292914, -0.19131587049589113, -0.7113288273128434, -0.4322557494419327, -0.629382701461729, -0.061263307975258675, -0.48738457464053214, -0.3781039354615849, -0.1455831922032421, -0.6050780290781832, -0.6383666076486156, 0.12412497930362537, -0.005019242986447181, -0.5797703871390529, -0.5657599149047564, -0.4042050311027769, -0.5409847853206495, -0.13371835192630296, -0.7320723878259469, -0.6369234647010587, -0.23881838546527073, -0.13694478366175838, -0.4698110522198261, -0.4225032251524267, -0.4987116125255162, -0.16569592489989093, -0.1710031874382051, -0.4898518868238725, -0.4645920695884913, -0.06236303187702121},
    {-0.6366724083418387, 0.33320706702583597, -0.5321270914864126, -0.12864301626671304, -0.4443609534989302, 0.22994434078767678, -0.48006964924974654, -0.41108100647431206, 0.0903663831713903, -0.25240534021213495, -0.38925820971735614, -0.27505384464630483, -0.7627382150135505, 0.0022653850296860114, -0.3425232962041769, -0.41176970567544363, -0.02705031645970332, -0.03199462233397845, -0.4415358493419706, -0.6910912311207121, 0.43860821994402793, -0.3720768209077113, -0.17990486247289014, -0.4072838729267087, -0.5376983787777627, 0.01627707884701025, -0.23749494256435347, -0.505177864249768, -0.16301247844682631, -0.4400658552376356, -0.422428702509681, 0.14710748295964618, -0.5961106226254493, -0.48240263547846257, -0.4142288019077523, -0.07365322382261211, -0.5337348018666516, -0.08416942515004408, -0.45511791020762116, -0.5037131279864675, -0.47337311818192485, -0.2376258361146362, 0.018414799379884366, -0.5713447253987098, -0.47081578456551565, 0.012633083059814866, -0.04641250056752287, -0.14503332060480545, -0.4596405532588957, -0.40695240691904144, -0.3010555875745306, -0.44493652581635684, -0.6592626870155509, -0.777534225062914, -0.37213930973423187, 0.3007173782241517, -0.19567592382261506, -0.3158212615340316, -0.08135749344561431, -0.3105180869619941, 0.03897670124922464, -0.5442273172380657, -0.013442637633662963, 0.1576305870593028},
    {-0.3190644073783577, 0.24752976192044387, -0.48017964624298054, -0.06725331624916024, -0.17547097025554204, -0.06610434278372382, -0.4832209962089415, -0.1574978776311025, 0.10902770020396489, -0.3622614473352663, -0.5079984342294024, -0.05032774378944582, -0.7896282717734247, 0.19864574412125785, -0.7026758836331306, -0.1624556170802596, -0.1574054339158517, -0.03326505273998501, -0.10396824160552645, -0.08959555728748544, 0.3320407133039405, -0.46936963121109204, -0.13068420874183562, -0.3099503930442956, -0.21263391440800927, 0.24086950579849412, -0.32979405502072545, -0.07654242235357764, -0.2698837217241098, -0.24923899569018487, -0.5003466077784078, -0.05773197122161325, -0.3287436321492468, -0.37079044511833176, -0.6196929219105591, 0.15230762980797521, -0.37161905502612014, 0.07840740529858709, 0.07707332609362104, -0.09695229917549135, -0.4903863788730872, -0.324884529305931, 0.03273807433804305, -0.4373064331392362, -0.7564218525239458, 0.05957252454798933, 0.20918270637842962, -0.017827084606980004, -0.38486227210193397, -0.49438783245577134, -0.14819461308856463, -0.26872283616822823, -0.6475132617487614, -0.3404583994463275, -0.44162157423376247, -0.12838053071515262, -0.4175465967961257, -0.26298685008971967, -0.7617341585830585, -0.0576543929266286, 0.5399204546439983, -0.5105599770782732, -0.2324282929008145, -0.18673346615805667},
    {-0.5180464467356435, 0.008060761066446159, -0.5986759643328861, -0.35614919914915993, -0.4054736375563127, -0.2745898673395675, -0.6560417838809052, -0.37526948909916097, -0.04743241181887804, -0.6938388534519627, -0.5413252729381699, -0.4442878581689753, -0.5513628814298848, -0.2985148040270493, -0.6278622561570869, -0.15910072301337524, 0.07971402355569823, -0.06492286165367397, -0.27611861980081903, -0.5216173968414077, -0.01154433117580637, -0.7363440054355426, -0.4849893158268614, -0.4663617815104207, -0.5199337305041207, 0.4160530102117946, -0.3251471189380689, -0.09220450880041375, -0.15061706484576437, -0.6541817209495273, -0.41852387664301155, 0.16527187968797938, -0.34998474352382475, -0.7430121347522417, -0.5822289368453293, -0.21208711177185086, -0.45428905087844973, -0.30838037380728395, -0.43811168249256394, -0.13624555678557398, -0.5980275561625487, -0.5625254856987338, -0.07542600104743465, -0.5551769886972225, -0.8171102142744021, 0.01680763756950888, -0.07275033162758465, -0.28406914902955305, -0.5367311713766703, -0.5790291173025898, -0.16585272761322076, -0.17103376897270314, -0.6579669280376662, -0.3506653926433665, -0.3524988056198241, -0.34475635636496993, -0.4718467596242073, -0.5449831142585299, -0.7099722223984757, 0.05656178220570357, -0.25856009398781143, -0.5344177659225583, -0.5572150580543196, -0.17415534285124012},
    {-0.3332998040775864, 0.32444241097182913, -0.30917531818604427, -0.14305273297243817, -0.46193747823187364, -0.0863863680845195, -0.6737315082879763, -0.1947912944217921, -0.0112829356012479, -0.5572787590384507, -0.5641331018857543, -0.4178792099892839, -0.5358897121729099, 0.11823782706502035, -0.35233655778468764, -0.531083788444594, -0.10067136604286864, -0.09023186073523648, -0.4427498265339191, -0.3508824668014723, 0.17129910163070375, -0.46454561097789254, -0.14549280704906978, -0.5597847064298029, -0.6900238383830241, 0.6012310163113854, -0.3904533540752134, -0.151254091581054, -0.41169000092621433, -0.3387749795442936, -0.5246478334940738, 0.06153089611766681, -0.389807459087147, -0.5181825417838754, -0.6990012081414746, -0.36441593926067417, -0.23560615285898123, -0.047502309425248856, -0.16197248901263767, -0.13921147400252346, -0.1615178255915408, -0.3129357013621829, 0.3293528001965637, -0.3016939179274206, -0.471271410330107, 0.030292966755361663, -0.034879562971169537, -0.4836604950367655, -0.3336024846915688, -0.5286807972967712, -0.3751337295188491, -0.6037657181517101, -0.50758983603397, -0.39086076967189193, -0.5226988533215831, -0.09024702922313649, -0.556630576129168, -0.7029955026724432, -0.46883865651187423, -0.19140632553201067, 0.1612637115448121, -0.6395083861127155, -0.13815531622413202, -0.2331093155277007},
    {-0.7579151772499975, 0.5827476984078492, -0.32247377569725494, -0.1034810636751259, -0.513637763003969, -0.10845041106357511, -0.4283450653000755, -0.05554400481834318, 0.0268532186326284, -0.6207300053398496, -0.2568641835205186, -0.16384441283486237, -0.5805108556424169, 0.021920108589718768, -0.40881628126467306, -0.628532905132488, 0.14846930335497946, 0.2164007576154727, -0.469770305161233, -0.12152357588178442, 0.5467898993123271, -0.5212133999998007, -0.4260827237906625, -0.4764569035266882, -0.48532721499092213, 0.2479487107892865, -0.3380070328807428, -0.5549482522763697, -0.14233308255148164, -0.3817863469104512, -0.49506756551663894, 0.20477254449969318, -0.44631095416483685, -0.6155462385247499, -0.5503923084668992, -0.1334340119773915, -0.7254156544363621, -0.2791840351098353, -0.5533460867606036, -0.4978398579173921, -0.5855787030928475, -0.5005004963007764, -0.01585435490917908, -0.404169284320361, -0.6946460201681349, 0.16363311204129724, 0.0002585441198167098, -0.10053511857080497, -0.22190436828207769, -0.46354643882466223, -0.44514962460000584, -0.34339943783187776, -0.54570754950021, -0.06395825502016682, -0.4045589772310205, -0.17855323106988913, -0.2046609507674352, -0.5380384621983819, -0.0768506866418277, -0.13170114518462248, 0.22861033332883587, -0.665120992432117, -0.2491392811459328, -0.8702725898376773},
    {-0.5151834375981419, 0.34193719706346426, -0.1387809299815719, 0.3506356999568876, -0.12955082379068414, -0.12478160406857614, -0.8087111622498282, -0.045161349722363915, 0.3821646166242035, -0.6344018908122542, -0.3044883985542161, -0.6181200497194068, -0.446366248750872, 0.15675224645752417, -0.4439250261827844, -0.8883949476860568, 0.27107711266675827, 0.10025024800877982, -0.38381056001565533, -0.26017052290048, 0.6526719623252444, -0.45417095206402947, -0.17825849677599873, -0.1977355242543216, -0.30059203802985607, 0.22238973722759822, -0.5491594439611224, -0.397738977628801, 0.01946125780585452, -0.5032745301919345, -0.5545313635373178, 0.4882804007983983, -0.25136084362712896, -0.7632765074980024, -0.3455620366769093, 0.19308800628485237, -0.2498343580385161, 0.19005070236878976, -0.2516817964256403, 0.2001610557119115, -0.4165857994849075, -0.14971543884172672, 0.2969692351459066, -0.4250390862336825, -0.5454262190805618, 0.3852440583651949, 0.2884776937125942, 0.009731169407155137, -0.32280136696716644, -0.639388038618219, -0.04210008485392816, -0.2368652254880182, -0.2887630225193392, 0.09001824673900079, -0.37382345850424953, -0.24124235993574367, 0.00938626263032828, -0.13980678504672003, -0.06586369875678619, 0.27144233388058264, 0.47795611766671, -0.11249635138197937, 0.004044906090548758, -0.5104386654552534},
    {-0.4535765211591682, 0.4983791653407591, -0.5316642436224396, -0.03233922468691479, -0.3169580559810999, 0.08430344220532275, -0.7513851207922784, -0.09109877794630339, 0.4976066543852112, -0.5756795234784573, -0.43125935813415256, -0.595697985089791, -0.4686970524894424, 0.23567139330057524, -0.42384139207861543, -0.6098581581844259, 0.17947359122700368, -0.04121131785935058, -0.7434360286915358, -0.21053552556410832, 0.6316042646005755, 0.030314996523503862, -0.6020074956501176, -0.2420914184517857, -0.3954308271445963, 0.2754332380957024, -0.3423356663548248, -0.628396086755957, -0.27921620253370105, -0.7447222973601446, -0.5554471441989202, 0.3739628902883987, -0.670532817566887, -0.9194530788789764, -0.5301168227265972, -0.3429810872631537, -0.5715321695746286, -0.276115409087181, -0.5497969463470597, 0.047445902036153925, -0.5652620782471308, -0.5758967588367921, 0.5016086182647828, -0.20303062191914095, -0.8063034241683121, 0.15995198264450675, 0.16958794535705873, -0.31563099584771215, -0.48967919049187997, -0.420864195756061, -0.15557362579823503, -0.5238988301609554, -0.6210312425301105, -0.17937363235126888, -0.1778644342053852, 0.030797977579878615, -0.4771458990822725, -0.23390588545780455, -0.10902923069815523, 0.1250048689084917, 0.2941443919779466, -0.18077170446623814, 0.20110321593033217, -0.23149433501582192},
    {-0.7664789214286261, 0.0823639779638591, -0.43966568850963134, 0.15844926912330615, -0.5082689474723231, -0.12234698199016147, -0.5583906484465841, -0.49409070083301837, 0.22327419870899298, -0.6681475657024547, -0.6721753460475, -0.3032974284071009, -0.4020880790211395, -0.11260935281483969, -0.5640544572584347, -0.4919664768911144, -0.0163050623067181, -0.3564368334112772, -0.5884222433272643, -0.44482795275884107, 0.49955237805873487, -0.7888463667933779, -0.4933983789165662, -0.40171425517984244, -0.32819082065078825, 0.31188954220461973, -0.2910716306735913, -0.5019085891681481, -0.37911098078622313, -0.6210714472020497, -0.5401042259219548, 0.20093363124691468, -0.5047525384909102, -0.7495757113208626, -0.5509894397313109, -0.11110582160702015, -0.6023910668270946, -0.10970955641507783, -0.44847635656941287, -0.32366888266193733, -0.916357974719306, -0.39730069398371676, 0.17111420433820035, -0.47389562960662407, -0.641289631917358, -0.2404942915785165, -0.04603946972074587, -0.49113192817005896, -0.4076287062596673, -0.7179956303769772, -0.5678293016315167, -0.5863275101592929, -0.6891967667923066, -0.5085561671033486, -0.16356214253510235, -0.171116082081329, -0.25218898646472554, -0.7431496849085779, -0.3451854777542339, 0.08554088789650832, -0.06385880933008127, -0.29633580822473876, -0.3358327547929204, -0.3411139722379628},
    {-0.5593592589881208, 0.47243427562207757, -0.31516627219654963, 0.041981458870370934, -0.6201378741312489, -0.06528293052338693, -0.7662212597950456, 0.14498622982574919, 0.5162737220083552, -0.6497731836101744, -0.3584050464495159, -0.40868844011486705, -0.4988504720502204, 0.0323816669733006, -0.6301359352773043, -0.4015946338517447, -0.05147117787183257, 0.08533698248400785, -0.5368964338571964, -0.4355566126725758, 0.6950013327887069, -0.4926707397684784, -0.4666217992182286, -0.04915902964601658, -0.18751400941271573, 0.17643306957903399, -0.30674549281974495, -0.5110740740183692, -0.3361499449262617, -0.6138960552124214, -0.5611349142974748, 0.5391593038847143, -0.4226170507237121, -0.7164134612796947, -0.33323847954997377, -0.015823685859164105, -0.26146963522188965, 0.18105251500929165, -0.04959127471944988, 0.050081966043264994, -0.8577778754946338, -0.6359116246314787, 0.4150305990803082, -0.22761566735809508, -0.5276293511784648, 0.2814747354700078, 0.15512044952198195, -0.14397060462108127, -0.6490192643777932, -0.5270482326229006, -0.3501774146685282, -0.16628266192229335, -0.5193066670485568, -0.7160791665219273, -0.10006138662818445, -0.05376075551025317, 0.024136444870134756, -0.22200742462690212, -0.3812795789305547, -0.060597616470606894, 0.33610708021067476, -0.3114601051274052, 0.44277010196631095, -0.5291351035192674},
    {-0.697252603275643, 0.5687294297919528, -0.4315820909697212, 0.12216944471005517, -0.23318626315009813, 0.05653910264948435, -0.5080118642606652, 0.26654269480106235, 0.5073731605433122, -0.6541017748967268, -0.5213036434062777, -0.4108377366308106, -0.5593910471319758, 0.20691483608470335, -0.4113938546711231, -0.41405253744130266, 0.17600142792413312, -0.09102103394470407, -0.4549904142080184, -0.49481502187593, 0.6662138680933133, -0.5206663965404079, -0.14085433344588322, -0.2656878603891983, -0.18445525157019158, 0.024145223146650765, -0.435531561668832, -0.32522717404273843, -0.44759655570891, -0.41573377339966755, -0.66468623797389, 0.41279297271458093, -0.1593852238756389, -0.5003823479701319, -0.2725340407743535, -0.04162527111497962, -0.45331366408259904, 0.055816134080399836, -0.07706845893196548, 0.16920737471038927, -0.6357175719260316, -0.4262277593762256, 0.34481332646226703, -0.5326487375644834, -0.485268003953394, 0.15867295495400308, 0.14179994767978063, -0.1504422544682087, -0.44064935316826237, -0.4438679388544652, 0.2004736463493416, -0.3747953180967707, -0.5594084943373517, -0.08820106474072918, -0.15930899042951524, -0.0888048825968611, -0.28177341839453485, -0.2892207012911647, -0.2606292000765934, 0.3661170540560725, 0.3978135334130692, 0.02252233653058157, 0.19480406491251828, -0.35636891451554126},
    {-0.6271588552287627, 0.6697133445339664, -0.5655931233996689, 0.19192930803254346, -0.3791520032807196, -0.2005738219880242, -0.6312412059234007, 0.15969609723092928, 0.40065395723172464, -0.7645196557459263, -0.4257984534824259, -0.6802697439767147, -0.45994220449418294, 0.12130661477366289, -0.43378764250181806, -0.590010450707396, 0.24765052146468067, -0.5085878306869032, -0.2530057368594924, -0.389208209233155, 0.6482449627016631, -0.6084624050547115, -0.35381158189013295, -0.27978225668569506, -0.7689366329066711, -0.09432670242691721, -0.4418460097111348, -0.4702530092117063, -0.16226036674805325, -0.5823303316971806, -0.6938275188443557, 0.39660216137209225, -0.16094413312259134, -0.834964869763667, -0.6845456615806922, -0.35879893401973767, -0.3060571488005326, 0.14972311468587696, -0.10031935042550165, -0.05569292608193968, -0.6887232336811531, -0.39810070434964695, 0.2828948530652905, -0.4720217459157398, -0.3954505810773736, 0.28272233527456775, -0.05516345049218909, -0.07587318053102203, -0.46806288453525174, -0.46311533525357845, -0.3604590533828975, -0.4348451105873298, -0.7477864634623125, -0.34437962794351523, -0.15975758648026517, 0.16027660327963664, -0.3389148739708368, -0.29074812780061127, -0.4016503993062024, 0.01934714747586032, 0.3494781220555997, -0.38964018475708745, 0.12755532424128138, -0.432784734324923},
    {-0.6523250457347655, 0.7538519387092723, -0.32647559382425945, -0.09763387107826857, -0.35032523692621104, -0.2940000590697749, -0.5309666405982403, 0.14501756151949116, 0.5061794995524926, -0.7799904697682772, -0.44567146257985485, -0.5376818906832801, -0.5050722677448277, -0.010503127408560313, -0.634041164272816, -0.5247377798642403, 0.17389076401158837, -0.3342874676719847, -0.7664956955415709, -0.5861231080390927, 0.6655775255418472, -0.32618305622835136, 0.11147400698675584, -0.2581932128177232, -0.3597461501388553, 0.19887965260117718, -0.29541858644567837, -0.496472426028755, -0.33256676209921493, -0.6437755649622352, -0.5961742171746457, 0.26211378555430365, -0.5110566451808249, -0.6494651821904319, -0.35276717348295195, -0.03932175587635649, -0.3815048520322616, 0.06133504880880463, -0.17262595071102635, -0.04734389188975314, -0.5638088779775706, -0.47544732839093234, 0.5675469864130627, -0.5159241552976519, -0.6557519214741453, 0.13346980752859453, 0.36599645788339574, 0.1738746680615092, -0.3683964785224097, -0.41473821776126163, -0.2767220137657129, -0.3443448128705605, -0.733204141691612, -0.491039801361165, -0.2657783257361713, -0.23565289614138177, 0.046477759216690825, -0.34081178210732394, -0.4295453462164256, 0.15220090900062525, 0.6425140771521003, -0.4548451871289006, 0.200406619723474, -0.49176013871274515},
    {-0.5416492819556603, 0.7936033284791091, -0.06179512612599651, -0.14112366647144517, -0.5234094831076934, -0.2533489985187569, -0.6497771004969843, 0.48235830701307425, 0.7128269117221815, -0.48337883678660465, -0.6515920798534366, -0.5408222077146233, -0.6172159432830164, 0.3903663974513807, -0.27190546727412096, -0.5488556082562186, 0.15430287773355447, 0.061993765358227634, -0.14550067524907812, -0.6244694706808288, 0.7561180215561001, -0.686366312031863, -0.30251819280165504, -0.2963033488866469, -0.10738257004111626, 0.14811709760903596, -0.33285251412210404, -0.778254993668342, -0.4999410586272447, -0.6288697238008141, -0.4955425924803901, 0.3221111657632957, -0.7197765064477123, -0.5860035870383289, -0.3505784616385112, 0.09848921712592255, -0.5407657989320114, 0.02045724693720992, -0.3215834632036404, 0.03776857101535733, -0.6370843409377175, -0.23719412304394133, 0.29201872558457487, -0.45287023148682076, -0.6787216584192138, -0.038353333086960546, 0.03722811922954724, -0.05359053961696722, -0.4927019453195633, -0.5268233985173716, 0.027291474700320055, -0.002165048118116056, -0.49192804663772965, -0.321245439707934, -0.4710589551827152, -0.06703113859645565, -0.0012547041030156094, -0.5784313701205814, -0.37329940077742224, 0.2834045851930058, 0.5351211595177039, 0.0596904827762274, 0.15610606661188928, -0.15942011507820353}
};

static const float b1[64] = {0.7261137458025548, 0.8851299375614019, 0.7404194893253546, 0.7850405916503641, 0.7145810907932548, 0.7557697539922825, 0.7548282397227455, 0.7539964721261387, 0.8563629480617124, 0.7163536216673785, 0.7220880319612372, 0.5753873083173345, 0.7917808680736748, 0.7595943340379235, 0.7747602977227477, 0.8368560882756015, 0.5787740034621901, 0.7377221710661503, 0.82472066026472, 0.5999064608201082, 0.7315445329167621, 0.6524123081757969, 0.720063768071387, 0.7975231539092128, 0.723612710610957, 0.6184937629112681, 0.766516208610349, 0.7578187123609509, 0.6298154571114545, 0.7758047009356, 0.7417731042101928, 0.8181323290262843, 0.8276448701501736, 0.8395354484692577, 0.7788346778681478, 0.790239697005694, 0.7679131482338405, 0.7713915778458602, 0.7797406938075816, 0.5895100989762059, 0.8519862266727858, 0.6986002750000647, 0.7778210692483734, 0.8113598805940337, 0.8012608254136866, 0.763071803881039, 0.7627090407927435, 0.8237361060780024, 0.8339207240661546, 0.7546609329597678, 0.7342674443097343, 0.8184809507530862, 0.8467060843667192, 0.8064313683140194, 0.5959456779667096, 0.8477661187331912, 0.7872299008148881, 0.849860162922308, 0.7841719868578858, 0.8161756188469609, 0.7649257561893344, 0.7542497052001162, 0.6495572448650099, 0.7923111336083689};

static const float w2[64][32] = {
    {0.36330546085237897, 0.7694866055241284, 0.26958410175939523, 0.6752163910200738, 0.0807634003539649, 0.652821587035588, 0.6627204497090669, 0.7114660414397551, 0.49153546014144084, 0.4081492499304886, 1.001966587560655, 0.5957600530105949, 0.6871956590203914, 0.6805124074379202, 0.5090357823997105, -0.16824026351928772, 0.7138900640734328, 0.4841639755241873, 0.6828235527445456, 0.738190566321679, 0.6607347323643922, 0.966491099825667, 0.3172494491514571, 0.6280206363797223, 0.3619199850963749, 0.5872405144143761, 0.4069676201805397, 0.5642576784685078, 0.831824161206941, 0.7963823553225489, 0.7825489027909114, 0.5825515641579122},
    {0.4679763849800098, 0.6434386597604705, 0.5614927914082636, 0.6815181078726573, 0.5163022765225115, 0.5241368011354398, 0.9522604398684356, 0.5715614493735885, 0.236116002537189, 0.40407482061881045, 0.6012656240409135, 0.46520342786681207, 0.796306179994141, 0.40299477496113206, 1.0830316722793583, -0.10511929077836535, 0.6397544729656249, 0.28601877774936807, 0.7958902596880026, 0.9443026734901769, 0.6748653287775723, 0.7089229600765657, 0.33069151427242566, 0.5736741859749839, 0.389406697960827, 0.30074590047207495, 0.8287029838149523, 0.5166008945745985, 0.6923548907052565, 0.6475794881550673, 0.7128479963362992, 0.6408677539848655},
    {0.5851635519729627, 0.34506768308911484, 0.20895131917063034, 0.7946048361908572, 0.3612477981686238, 0.3916762965284704, 0.7018142358703786, 0.6810416036325325, 0.41525002750024814, 0.6726723113789174, 0.785498707423797, 1.1988730096614508, 1.1251731125181355, 0.6907418482737724, 0.6644170435603566, 0.020554127290429155, 0.7766152675954936, 0.7938905869602693, 0.753524759613791, 0.9469306150164284, 0.7959835614113269, 0.6940720276733834, 0.4464178732028707, 0.44969015983376104, 0.6483570373337986, 0.4168074812706001, 0.38239821863075835, 0.12711144767740712, 0.6854807226010478, 0.482518464031495, 0.48344172223472415, 0.6703144903953129},
    {0.5279019770175061, 0.707016504282017, 0.36531836868565776, 0.5974504960009166, 0.18240631882150515, 0.6155887519087111, 0.7032924345434074, 0.6319193604587064, 0.6968896860813953, 0.9001158229895613, 0.43806479187749975, 0.7837328108266957, 0.514893081537785, 0.7652981806895496, 0.9462376714031082, -0.0341031739645824, 0.40747400029199315, 0.800947670120079, 0.30212894989343647, 1.0571307932774163, 0.48552328993138233, 0.6855650178140971, 0.5952880207446615, 0.7295035995356395, 0.25379914248389274, 0.4088432237029057, 0.8071661361571089, 0.25558507857052143, 0.6090962623080483, 0.8456936995605391, 0.7141409766590433, 0.325693661576496},
    {0.4441165203375887, 0.40894409526491443, 0.3187073180953829, 0.7782588070069768, -0.07140383332927927, 0.38896830991349557, 0.6082799159048534, 0.2030576964621949, 0.4956592528895245, 0.5342127410155684, 0.6298578112282058, 0.8578774678140719, 0.781801865276284, 0.8376121236422801, 0.501068733908006, 0.09009768078250678, 0.4282644411963616, 0.8405822157396847, 0.567789181707845, 0.7843219385560213, 0.48076332581366654, 0.5430715591968608, 0.5234333459581628, 0.774823550084121, 0.16540309376938736, 0.6052586389313614, 0.6442257278036609, 0.13926840441096608, 0.7324449050184596, 0.7077212098677567, 1.1611022784996494, 0.6062899436920776},
    {0.27550054131596485, 0.7216792575321346, 0.666611305278059, 0.4703783342618582, 0.47098926656375545, 0.35755798455693044, 0.672947500433204, 0.8146567589351246, 0.49234108833309004, 0.4883376044884035, 0.5836636661180702, 0.5729990548044841, 0.9198553799370135, 0.8262561833988019, 0.4196303337712883, 0.14294118695342026, 0.4900303231481068, 0.4531155247732809, 0.49418084582939475, 0.6267301718676779, 0.707192131037783, 0.72899243661329, 0.6947884983756022, 0.9241869552282415, 0.2632960550898854, 0.47738947797008724, 0.49222906789632287, 0.04954274071263714, 0.6373802377804632, 0.8042915544895072, 0.9630141258708932, 0.8102667318036334},
    {0.35839168697316826, 0.8724070235772869, 0.3032397737076473, 0.6061017433522333, 0.26547099138969693, 0.53790950544551, 0.7224950374672158, 0.6553484991077269, 0.8083190244122613, 0.741520735240588, 0.7825326584221913, 0.6980035655242514, 0.17266652469431876, 0.8220712989263869, 0.7717032220396385, -0.018114202009139203, 0.6211761950656042, 0.689806764846209, 0.3729406975455744, 0.6831120867782575, 0.24759157629610606, 0.9508930524204391, 0.6236300688862025, 0.7307185976362756, 0.32279820060515546, 0.3951514451773678, 0.4193002542043266, 0.19321426481287768, 0.7085697080258221, 0.8031824440660136, 0.7222084398677872, 0.42832191138969045},
    {0.48490305867571115, 0.6624661941806089, 0.2633956984065295, 0.3645236220682903, 0.08202423156185316, 0.37028475520295395, 0.5860630072474334, 0.56770149352276, 0.49480981981497824, 0.6618209724007202, 0.7331027162855533, 0.8041762939571467, 0.5993902392969145, 0.834797521675404, 0.9841130288037245, -0.12291318565813703, 0.5996618706376102, 0.5278611775212178, 0.9225496790150445, 1.1040041185215315, 0.32526201745970357, 0.6525751645800355, 0.48852087832202185, 0.6627144093198392, 0.3901471591414306, 0.2250804156744065, 0.39734338086302523, 0.21717253546318255, 0.7330085737019878, 0.6592098931894437, 0.713436904641329, 0.7375470403744975},
    {0.2763816116252084, 0.9099350727038019, 0.24369373231338354, 0.9243296259183609, 0.2753879227625282, 0.5062711169717996, 1.1139672282795097, 0.4323315782788252, 0.4692067420827159, 0.69391597329482, 0.5081737527460393, 0.4082289570114189, 0.6161178481325633, 0.798397748016603, 0.5066530045131822, 0.3414782014157568, 0.7220657013678669, 0.2836996998631426, 0.4870312886875185, 0.8837900119552137, 0.552809473338827, 0.9073693200758233, 0.4740322875594171, 0.7267317312006008, 0.3061502987345505, 0.23340362296208614, 0.5519892577118927, -0.2733514969147276, 0.8275859342237284, 0.5621406686206606, 0.8399124821428299, 0.5942349520470616},
    {0.12266599634143008, 0.9244230062133751, 0.626076884924593, 0.690799617587179, 0.1932953680151147, 0.5129448142956853, 0.6418667979699642, 0.643688210348451, 0.7312903518437432, 0.4202659845970379, 0.6551688799123441, 0.588982223689481, 0.9085786708255049, 0.7886508173225671, 0.5925487231184499, -0.2192148316779171, 0.3247866385184326, 0.739477038855308, 0.8772085977702255, 0.731782537394043, 0.20494313885180232, 0.8203872340577073, 0.5170751509274981, 0.7094466678808504, 0.23252474573225662, 0.5403421272574419, 0.5611767869454903, -0.058666297264485905, 0.8928124094260833, 0.5224028770798815, 0.6133735241907714, 0.539138855510969},
    {0.29732820125173054, 0.8307875608212085, 0.2958904291016106, 0.7432176113804555, 0.32145218423235766, 0.7682469937794519, 0.7191729912019541, 0.5895566718267484, 0.2202817698305747, 0.4925151545446708, 0.5970024946818346, 0.8025350381739889, 1.1243952037986311, 0.9292861971808837, 0.23438325320445463, 0.0943971905270533, 0.46483473148456045, 0.1782087931026907, 0.7432220357195847, 0.3750958197429485, 0.41506383780171713, 0.7156992150894383, 0.5550907326106466, 0.7430667906168469, 0.22038817217520154, 0.4589144575249269, 0.7013430586512109, 0.6326358453470655, 0.2398826888677522, 0.7906114528339042, 0.3971323379598698, 0.3591312327829571},
    {0.3356482492802262, 0.6763042072007971, 0.5551195203230572, 0.8233460561902886, 0.6727929764383838, 0.7760316518147072, 0.7176280844966101, 0.6606873829452112, 0.5026061938402853, 0.6427991412164505, 0.7624014100780548, 0.7947360725892465, 0.49982010109420755, 0.7743796439092642, 0.5455353373574104, -0.09280422921402717, 0.7933136906967992, 0.06525721727866085, 0.6908765129494405, 0.3870939336866, 0.18107308956510457, 0.41676879244242127, 0.6403861126556398, 0.31354868637820016, 0.3757462623375686, 0.35910752975680466, 0.5447519455744178, 0.061811919746687136, 0.4123271344663374, 0.7873066019715019, 0.7022039624153622, 0.7549601106326036},
    {0.17416718812794016, 0.5338909988724354, 0.3666445363464652, 0.5831815969697375, 0.33332738564750314, 0.33871424245258364, 0.6528955816551866, 0.5744415858606848, 0.3068398262530178, 0.6602868133711564, 0.6458413217227746, 0.9777363177997562, 0.8924877126042635, 0.6913010575734725, 0.857320417703451, -0.05520277479136001, 0.7258186878295554, 0.6744610449738097, 0.5942325214408243, 0.8944558899355658, 0.43471151095027494, 0.8489846762004792, 0.7274821599395975, 0.5903200365176858, 0.14991137559295287, 0.36875858155442176, 0.49390709525018894, 0.2359740410100021, 0.8430914216202758, 0.6049129485215389, 0.8714923605815351, 0.5584765216072956},
    {0.5605922553176578, 0.5665896200994415, 0.10764619106608507, 0.6124156257606285, 0.05419877414188312, 0.627198741767125, 0.8133648849568774, 0.4651842871344226, 0.7112619448481028, 0.802950498850198, 0.36222776197004314, 0.7468046582290913, 1.1004486708934706, 0.6702862297143816, 0.8284953696469083, 0.19284796326382098, 0.3276528392102774, 0.4644467710219292, 0.5665846663379213, 0.767967674596606, 0.7165101596086891, 0.35008106910299563, 0.5483783389496616, 0.6574051924791072, 0.4777756530547386, 0.40002499613593095, 0.4325840594461884, 0.24497081824132239, 0.6106991719617362, 0.6091865817191826, 0.7995308532105808, 0.5548571333044904},
    {0.39353121887965187, 0.6554725203635683, 0.34926490328143267, 0.7756472545510992, 0.3848427900321129, 0.3241044563750451, 0.645667308941237, 0.7525760299777781, 0.537755746880144, 0.5089917060314081, 0.6350721438306312, 0.5775023737917714, 0.6788185856078782, 0.6403348265257053, 0.7117973214920273, -0.12180666373970941, 0.5472520452701236, 0.5700328900770798, 0.6788775674754395, 0.9133188552869766, 0.7176327390099444, 0.7050808103342548, 0.5707715970196993, 0.8494312783500352, 0.025236439560897085, 0.10373639845098911, 0.5323348493456553, 0.698869760203619, 0.6699948096164007, 0.5334018630418503, 0.6474491143224866, 0.37968303633483197},
    {0.40664394602321324, 0.8695557838488985, 0.43414455786050515, 0.8657929984701753, 0.4458613352358262, 0.5311882950677784, 0.6949623546674094, 0.6120699924248458, 0.6746976698214235, 0.6688441840136808, 0.6765806125150967, 0.9299786162934648, 1.0908047990648648, 0.48104266423180075, 0.8159584774166058, 0.12781530310621647, 0.5547632210589957, 0.3156226704314869, 0.5266414393619047, 0.7413071853456479, 0.6110074361164001, 0.6200835688882788, 0.6403242322023907, 0.539159011317353, 0.22731642748936265, 0.18245043926964802, 0.6527510145904887, 0.3372503346732972, 0.5478949901441417, 0.7532040425421884, 0.6809843707901859, 0.4780375923046538},
    {0.547176634725634, 0.742327042170611, 0.4826898314032404, 0.7997940321251028, 0.14047070663155978, 0.5695968937147698, 0.5990883419174382, 0.7829149268873574, 0.8037376320673055, 0.8275888299105308, 0.7014419807146071, 0.6590621755530442, 0.3512198344980002, 0.161564262947691, 0.8319358882676968, -0.1919839196171231, 0.7657615674048758, 0.585550526410019, 0.6544580801670605, 0.5218039372003809, 0.6680315809950564, 0.8280176270277768, 0.6557110072128796, 0.6621294779591594, 0.4394048318695706, 0.31182417754143005, 0.49150303613592217, 0.15339213936239043, 0.7906440296535346, 0.8423643411243427, 0.792804786547518, 0.5556131759954714},
    {0.38286809368027935, 0.5743008634507789, 0.4323905519396864, 0.7528424886328291, 0.22171404237926934, 0.40413501862921897, 0.898187278491781, 0.6474189762602465, 0.4790572282274166, 0.7769403871038085, 0.6669755273915565, 0.703030253231714, 0.8993868823576538, 0.6552842172806075, 0.7628290010465728, 0.08047114944253667, 0.7632345897778687, 0.5114047132807276, 0.7152201597790385, 0.6626888637954182, 0.5780052368626777, 0.5045450033539207, 0.5450572290052457, 0.6336939654873016, 0.885255411066245, 0.44210016328063406, 0.5937448839639984, 0.10694800922255897, 0.637068159249362, 0.6709743219105441, 0.7438209330297866, 0.3402316899505112},
    {0.5876945740888257, 0.7597874344623569, 0.45001633813013514, 0.7802865211874034, 0.016640987039250543, 0.8075965465115902, 0.8611736056496102, 0.6173600651051941, 0.5428128293330956, 0.40282730400866806, 0.2687081873439331, 0.8690303947728131, 0.6186288142566452, 0.8495588167703713, 0.9785482951322589, -0.19405151922566688, 0.5943062735948396, 0.4732982669416512, 0.4055908406919795, 0.5705495135001469, 0.5967971907077803, 0.6635576333600557, 0.643888407423432, 0.8554282761641617, 0.2967644649255445, 0.3730306352833264, 0.7925567650044241, 0.24074079764870035, 0.5702962218602059, 0.6431245136424308, 0.9602340119191987, 0.5718519588708822},
    {0.15373580220833635, 0.3723652393740719, 0.42869433919450955, 0.34828825530568247, 0.0008441034932303609, 0.4218136321779029, 0.5384473244984719, 0.4796676994170075, 0.530403981891071, 0.9042602026637595, 1.134825712676492, 0.6264057322946565, 0.9040602929220949, 0.8647136723596698, 0.6047450211391286, -0.23487509679277865, 0.5254765671227188, 0.5763809096572255, 0.5573902082779592, 0.6211831385647375, 0.4333565917500161, 0.6306771482716599, 0.5852009259858766, 0.7705656859608678, 0.39120223766571643, 0.31739947050514916, 0.9635485660316989, 0.1374289994352865, 0.5206168613239982, 0.7578030853076573, 0.4796958586757522, 0.777225630286115},
    {0.6480490308622847, 0.6405791687914549, 0.4499831891576206, 0.5268118284028785, 0.334741488805829, 0.4674826060251626, 0.5309811865083196, 0.06222140244984999, 0.6827562348109127, 0.7474330142626258, 0.7450363624313664, 0.5334697917456871, 0.877000021105706, 0.91667048155458, 0.6129095977841117, -0.08816907495489443, 0.6770287206798645, 0.4601194695409042, 0.6342279965842563, 0.6197334475493887, 0.42219645366220776, 1.0250823641973512, 0.5627419799588453, 0.7758951920160845, 0.4429346979272606, 0.41882472589856345, 0.8057243647914079, 0.15249008961921007, 0.7185289452871068, 0.6095891807048386, 0.7322107275501688, 0.6689662301268273},
    {0.43270341400823287, 0.652973777771402, 0.548791665906913, 0.7890962075379332, 0.33263252209129673, 0.4032886517639752, 0.42690659946433196, 0.8828849153541527, 0.6651862572586154, 1.0219635280511525, 0.6178913793288504, 0.6253380533746886, 1.0389263689588921, 0.7764132203543497, 0.6832073423437278, -0.0003456746242386741, 0.8335753900943722, 0.5732609619709029, 0.6618198078014706, 0.4840547470904519, 0.4877356538085394, 0.8374366941721939, 0.11512713756957199, 0.5735225387514425, 0.30197382425540154, 0.3586453078808904, 0.9710750462188525, 0.47054537528964796, 0.7270396137695619, 0.59766285304671, 0.7088451456619551, 0.5863235756599138},
    {0.27935408379271265, 0.8690649331889272, 0.469131634012365, 0.42883696042992336, 0.33517979977124657, 0.38653528945304677, 0.6834231020151609, 0.8329933821645406, 0.7512089886643089, 0.6639888514312624, 0.5925409916606542, 0.5354739049706071, 0.8588831415624456, 0.7347317879892281, 0.6308114171375838, 0.10621236929951414, 0.5124272474359891, 0.7388310213785045, 0.5156171360003129, 0.5973311668427035, 0.30863104108846395, 0.8798489962734718, 0.6312854795215255, 0.6541477709769703, 0.3165170857290234, 0.4158208427655989, 0.7465102178865979, 0.46632055103480524, 0.7917631955961791, 0.6224527898303532, 0.6554464941381052, 0.6122814719746411},
    {0.09555795731828189, 0.8250819174017103, 0.06432842598636607, 0.8761928330111022, -0.16400692537742692, 0.6304270587677144, 0.5083778140045899, 0.5792124609432323, 0.18653968347461042, 0.8265700976298878, 0.6140127657221932, 0.7752807960018557, 0.8252612436123039, 0.5569040861536462, 0.8388873614444837, 0.11400276175961041, 0.528974472108005, 0.8227780066573501, 0.5906333818929286, 0.7774071683715978, 0.2584987374893653, 0.9129228847202974, 0.5451577751185122, 0.8142121013545959, 0.41654435034939935, 0.2810543353343177, 0.6724864038808956, 0.14137773543903986, 0.6048564334608926, 0.45159591161308765, 0.9883680133983382, 0.42867877362969237},
    {0.32830365241033, 0.706474029687371, 0.5875418860495748, 0.2871358045876548, 0.13512403443927487, 0.6893671911816489, 0.6249385703809335, 1.055111812437172, 0.10889232373055983, 0.5817135379791223, 0.9254782446011722, 1.2236017530314298, 0.5211882723191265, 0.5923111446032633, 0.7855516039678994, -0.19134529535985217, 0.7149139461943147, 0.5350463973393327, 0.5018800677573817, 0.8565779601052459, 0.05252197299277482, 0.6927672618623609, 0.33826416912220264, 0.39358492529505884, 0.17295891496513024, 0.1601505905491358, 0.568681486765039, 0.44343337826197365, 1.031376667900698, 0.5155467838650449, 0.8836898859074657, 0.3900704631261367},
    {0.2519550798450182, 0.3522014982751567, 0.26317728275859037, 0.5515535787697766, 0.46164932292387817, 0.3682428003727872, 0.5566317275887624, 0.31814816449296685, 0.9936595881806669, 0.4939689365482112, 0.5758860028532838, 0.5550727756875831, 0.739491924152598, 0.527409444284797, 0.5762839230635028, 0.034738317545040316, 0.6254889438666721, 0.4877038099612575, 0.4596953719696465, 0.8709077999958144, 0.3197394805529122, 0.575499441398903, 0.7254381855553892, 0.7192113353381372, 0.5406461286096438, 0.49793576330878936, 0.2856747203181763, 0.21295074930012103, 0.7412404938531277, 0.6272429575243574, 0.5196138467945823, 0.3987854238775601},
    {0.30422720777460743, 0.9267006480669698, 0.4715008033801614, 0.8480355478761922, 0.3271232710521142, 0.5275888636229814, 0.7760708273477701, 0.5038800146346719, 0.4366696587573713, 0.8225605000544517, 0.6785866958141442, 0.5574110146545671, 0.8592961793896248, 0.3809984417047325, 0.4252449552974691, 0.10456583060869769, 0.7580084319234208, 0.5553920205357693, 0.2811372800196476, 0.9121092447497727, 0.6560004956514416, 0.9517102620538661, 0.6725044408445234, 0.5778647098956244, 0.6857181917530736, 0.11412460370458768, 0.34980450059216517, 0.12817097112114903, 0.5167318300662834, 0.4914849647256274, 0.9429205881628002, 0.6706353401349433},
    {0.45966760339966234, 0.8614111044414765, 0.3376724229903928, 0.9537407470573314, 0.3446711994521856, 0.509659237562359, 0.8207065973560942, 0.3727473540441486, 0.2937072606055985, 0.9257124422266945, 0.8204916139609809, 0.6863449862275519, 0.6973070122626712, 0.9199005872365948, 0.48558322657399117, -0.0020311444494305344, 0.658360049041519, 0.4735432653077148, 0.8356647188866564, 0.5878204349941711, 0.6075320156972943, 0.7172222685555384, 0.5376005884752265, 0.5599674876647054, 0.41052197070173546, 0.39942488738023996, 0.6253786502717593, 0.1765758650173299, 0.685953114590987, 0.6387409906206206, 0.9072866336762935, 0.9289811569489034},
    {0.6667444730804438, 0.931374371548319, 0.10345329630602342, 0.8058486028196727, 0.49123192301100255, 0.2797935917315377, 0.5216881674252764, 0.689248485824483, 0.7842441647721702, 0.8671148372002794, 0.5944720784462529, 0.521456901881942, 0.7664900563766168, 0.5475959448978738, 0.5985789202375369, 0.18312319780086272, 0.5244994518769729, 0.9202811737513846, 0.4998785337987604, 0.8800191967542457, 0.7357789954010767, 0.47417420915696834, 0.6063986676187701, 1.0517815612629575, 0.5118616323541993, -0.04193223420244353, 0.44987848376931633, 0.1265926625477894, 0.4563669860507764, 0.6922878389733388, 0.7344342364953124, 0.2190012129640008},
    {0.052206715428875276, 0.49226386270343825, 0.16109416491774373, 0.4592836681354445, 0.3071733175403737, 0.6097257153763269, 0.9355305576787996, 0.40378844376607137, 0.431220436758762, 0.5907151862868999, 0.7430656817859462, 0.98611662083694, 0.4923357311029696, 0.5797343177471443, 0.7954491622595597, 0.17964324461932152, 0.8598961893941321, 1.0180687795752708, 0.5276240834306234, 0.6139793842393101, 0.27841624296692147, 0.9641518486019973, 0.5508586704822819, 0.7999379560622054, 0.5145727022069958, 0.34871901333475475, 0.4586445198262538, 0.4501071593692762, 0.6196919070092031, 0.4543114313418106, 0.6986125746811566, 0.526097285381881},
    {0.25511603219869095, 0.6824188775380975, 0.25231271918080367, 0.601017860276658, 0.1671280482105786, 0.828480900361069, 0.6598175131096703, 0.6104264828692286, 0.13363122032123623, 0.7772556206174663, 0.6291313522033097, 0.8240758975214959, 0.5887192821582979, 0.8914464919967324, 0.6388080098861236, -0.05210201951601947, 0.9156242050421309, 0.41398544562404754, 0.40255392339239937, 0.5705340955598592, 0.4517222426053535, 1.1549944900104339, 0.8409741915891507, 0.9268041463492281, 0.5013087596350269, 0.09732684421116769, 0.8586603202451483, 0.21290054408805337, 0.6748181877666994, 0.9345825002964376, 0.7233414432343584, 0.4921346188729592},
    {0.3990542059576078, 0.7196596722027852, 0.47767630012625983, 0.43088434431759876, 0.645682661832876, 0.6368513937306516, 0.8137146685074301, 0.8214316330254638, 0.6650047432071806, 0.6485933655522153, 0.7281635079999905, 0.5777496281364294, 0.9261672822295217, 0.8425956193210147, 0.8078036601640429, -0.14645138731360602, 0.7811620906752196, 0.6681859547780941, 0.4952339012719333, 0.8185284097657576, 0.5335723189740779, 1.0432057164780466, 0.5050870779202806, 0.43397386074056427, 0.3700979481371659, 0.3821471241480619, 0.9540547399039976, 0.265226641970093, 0.8271737830069992, 0.6523307519024961, 0.5194152819555036, 0.5027812785902739},
    {0.32104007805482737, 0.7076736167366787, 0.4269502776653654, 0.9216882728120193, 0.2887220754075277, 0.4212849281996709, 0.8794611945639486, 0.5375794744919159, 0.6864701087145244, 0.8576617963520868, 0.580270418692041, 0.6494303489439769, 1.0340982835340369, 0.454888414853641, 0.8894215734487512, 0.04021184793118893, 0.7552331961853115, 0.42075237944382715, 0.5401784095164284, 0.7574557906329479, 0.7692457757435492, 0.4172826029856127, 0.6901246867224771, 0.7885303487048485, 0.5278845732079617, 0.3431314491428854, 0.5825151664126363, -0.10052170552449538, 0.40420676821445206, 0.8461031277720593, 1.0205210260274817, 0.44465415870017444},
    {0.40621702852751795, 0.7432404357233849, 0.3779068925809292, 0.8982568348644775, 0.42142056279044354, 0.4683860670386247, 0.9202854911276838, 0.7004281595011789, 0.8208571219314776, 0.5131356004301427, 0.8582893101515797, 0.612767821555921, 0.9652462176769552, 0.5782387838681913, 0.7476833376136641, -0.2029110532293068, 0.5390728584563896, 0.515492456370542, 0.5589622398162833, 0.890501185263784, 0.48592522514742736, 0.7827448568705415, 0.464433757772909, 0.7111873254561896, 0.42169092583285706, 0.0625787328493267, 0.8010768003500511, 0.36745147121388716, 0.6161732324852979, 0.6296601940628062, 1.0157978826984764, 0.3868968608629752},
    {0.26679842362038997, 0.4892297023776679, 0.34104867384532916, 1.125959211174235, 0.054980129610253496, 0.3393548889077003, 0.7207726242477837, 0.5401354820211467, 0.3319776307268275, 0.8367919488788879, 0.9386645958733713, 0.9769306884184026, 0.9247494748719078, 0.884857987310967, 0.879297813381384, 0.048164629370972545, 0.4695412993293902, 0.3979971761636039, 0.5708363353906641, 0.8061927580141018, 0.3688847934376961, 0.8147347354580005, 0.48925650455599107, 0.54593703273908, 0.383593525592363, 0.09247884359383081, 0.6854229249423278, 0.07272184479112075, 0.68896803851461, 0.682051530297665, 0.6527093445548011, 0.5036487327682626},
    {0.5667258821452178, 0.7632496850924657, 0.40055904037724394, 0.5653913413984274, 0.7343240415153874, 0.27349238402757653, 0.6168071158244028, 0.5752889879175231, 0.7185049590519159, 0.5419992778863998, 0.5372168215619149, 0.663046798930288, 0.8541260450437473, 0.7067201679284241, 0.6044066712036137, -0.001599224060534282, 0.7944796083723715, 0.5381022704226003, 0.7565854546792772, 1.0541217227332966, 0.6765940374344235, 1.0124750905695667, 0.7798003936186427, 0.6469653685609681, 0.11212516419183287, 0.23243299739738088, 0.7244223601572587, 0.5643742500325409, 0.7095065080961174, 0.6352572898261781, 0.7751117250668628, 0.402389716432195},
    {0.39399236023060213, 0.8366155983441312, 0.2944785581039265, 0.5543898803016866, 0.42496038278915566, 0.4176022173597107, 0.7903234448569516, 0.5412245050538279, 0.7443901734733307, 0.4792051203112061, 0.682891177445049, 0.6846438408741357, 0.7624518142619675, 0.8722905549308854, 0.9462434154892116, -0.17249351440742022, 0.5283850743694908, 0.5994759622805751, 0.6385133769185768, 0.6729982117474484, 0.09170759217910662, 1.0423416806667516, 0.2969165501286939, 0.7224247898128175, 0.3036133014758943, 0.23837029578074026, 0.5799295232616181, 0.4588433965320355, 0.6896185210418062, 0.9103981465760425, 0.8246237128275526, 0.7436368173334189},
    {0.34810215614896073, 0.886381311001507, 0.4408256043728669, 0.757862362253431, 0.7287205061331516, 0.6527636519724547, 0.9978496593455157, 0.6057244808822883, 0.4856637302047423, 0.658333244943541, 0.661402988406614, 0.7875401213055965, 0.5242081325107295, 0.5010495036132971, 0.6339759061950283, 0.08746480128592103, 0.3567120280084504, 0.6095836647891503, 0.43913237274489275, 0.6137603659337734, 0.6906238821988799, 0.9518823663032003, 0.5305564981183319, 0.4296619858815801, 0.5064988261944385, 0.4103902425536934, 0.5402092397442863, -0.12219306926288523, 0.4397159339608792, 0.5838553703121813, 0.7860748245622735, 0.390599025330428},
    {0.09205095852838008, 0.6570790577171258, 0.6136310787480761, 0.6742072173163719, 0.2616220640265656, 0.8665972909095898, 0.939098685283982, 0.6467474807646489, 0.2639521910973691, 1.0948727228871735, 0.7415017492037446, 0.5863228626389057, 0.7768806894052205, 0.8374929761447213, 0.5560214109073618, -0.029324637976519543, 0.7986944953943265, 0.46582957678781406, 0.6536290105166901, 0.6387913481183034, 0.22973149423902609, 0.7476312249157286, 0.5234097396944062, 0.512763630164146, 0.1989881452421599, 0.34395211773569145, 0.5653978463494946, -0.00546326101521567, 1.0046528490707882, 0.791560780360828, 0.851534810685233, 0.5379841118836045},
    {0.42263918515531707, 0.5386198132663184, 0.45153634776085716, 0.8691280531283176, 0.18705312343466296, 0.36844419255200267, 0.5931272537876829, 0.6379594915279484, 0.5375585507676742, 0.5826502812011506, 0.38161779580911875, 0.6980236811243775, 0.7371657735758991, 1.0015173926372989, 0.7698420394063754, 0.17794312499980697, 0.6654653343224326, 0.3795646023146894, 0.3003287275552198, 0.5455398546663548, 0.3298084152478532, 0.48093924395897364, 0.4579988235735302, 0.5429158517216426, 0.3043969922903749, 0.3450846103284719, 0.4604500993576169, 0.273085723788017, 0.5603282428163355, 0.6680775436872584, 0.39813592119738245, 0.15273294349795113},
    {0.4816687750789455, 1.0352574424246328, 0.40698906921536276, 0.4541658572278911, 0.595008993706639, 0.3914414205398093, 1.0619990499861036, 0.6811401369866149, 0.6967869542105651, 0.3432751566799022, 0.4623079842869836, 0.7598740835940377, 0.9799464866649519, 0.7286171571266908, 0.8305081256109873, -0.1195013710207819, 0.5242577283525366, 0.525118055303417, 0.5752099313395016, 0.31030066252875077, 0.456966687748819, 0.6312211738173621, 0.44298898594449276, 0.7505505863755277, 0.4951527605086743, 0.23737328620975062, 0.7340317208509222, 0.08606969225550462, 0.6682055588738794, 0.8908783497236713, 0.7460974705080966, 0.3617267881209991},
    {0.389727250232741, 0.9581357076287815, 0.20638761394917243, 0.5652315524688492, 0.16029487039026835, 0.6446087003781918, 0.5225035727261412, 0.8193759138890195, 0.5965981751474665, 0.4707723981067565, 0.5575504568850143, 0.7806769949360325, 0.5995231389875157, 0.7028303556843013, 0.40771237902039636, -0.0012357352535772549, 0.6104843495155686, 0.4354998457320204, 0.6786012246327346, 0.5954553065993247, 0.08047505761061473, 0.9463502339834582, 0.27908840093849935, 0.718110183550231, 0.6281028009985521, 0.00782711565506532, 0.45264129999559694, 0.12204055993928273, 0.4987429439058577, 0.554516309075154, 0.94381916258333, 0.381606053084072},
    {0.32713609563770585, 0.8187853797019929, 0.44645661167276396, 0.5457919950001617, 0.3850092073245421, 0.18397206866439517, 0.888844511898193, 0.7188260580072573, 0.8724455892651355, 0.5111910310174074, 0.6799843937950778, 0.554815137280534, 0.7192788556939027, 0.937229258112241, 0.5299937983259366, -0.18425184760303295, 0.7680733185043872, 0.6191955248415145, 0.528477489872107, 0.7024212042604112, 0.3265669204114162, 0.43190005667274084, 0.26928865775764915, 0.8194791301725475, 0.17818781542367987, 0.05044145463672171, 0.8479705254733828, 0.25738220364115194, 0.595109076196867, 0.8858880754708297, 0.6768269403025755, 0.3769072217080356},
    {0.7560727716001815, 0.7730851729866609, 0.28680512825604026, 0.5674677659398496, 0.2647658617668999, 0.11687894662299186, 0.8708462510815556, 0.22833464502626036, 0.5951619138824076, 0.6918948222140301, 0.6890642105924661, 0.6451148008243472, 0.4547602249017013, 0.797545771152315, 0.8772188237463413, -0.27909409850102457, 0.5646941745825456, 0.5153321588264574, 0.42559274841946604, 0.7915387705667644, 0.5052616505336792, 0.8521165452563502, 0.12107954745951902, 1.0075314289524988, 0.1529392122077647, 0.1897889303565987, 0.5220304595653292, 0.2841202096799663, 0.7173085826189697, 0.6533141818563659, 0.3383206654671894, 0.42936484457004676},
    {0.5300394478298718, 0.5235382479054403, 0.5674972225388938, 0.5983314470307867, 0.1284528782185574, 0.6724722153126875, 0.9972420746144705, 0.7148436853812893, 0.6059398986210686, 0.688603242984415, 0.4531484963780024, 0.7523266949194996, 0.8666109606767146, 0.8887002766174014, 0.9458302174376347, -0.18698869865324322, 0.5603336433080222, 0.4578776449730987, 0.5887127299934277, 1.0040713744486776, 0.41236650072315645, 0.7640536818543822, 0.4529768189575052, 0.1598376111751916, 0.3965349411406423, 0.26550735312825263, 0.5728545620088682, 0.19184687634487643, 0.48818380154782975, 1.0029915313546947, 0.7940246297150897, 0.6730988834755467},
    {0.49712796388581754, 0.5994424487085014, 0.21094899526939845, 0.7135060044314705, 0.6384909501164078, 0.4470361211966107, 0.7168492193985248, 0.5229856040200714, 0.2809451473919316, 0.8649332754847423, 1.1277639067448033, 0.40614074475737666, 0.9015616143751052, 0.9633326748013118, 0.7810010763082169, 0.002855614152969967, 0.5622257342660014, 0.4952550659399299, 0.7098771968444887, 0.755862663063971, 0.7104088006036114, 0.674274803334334, 0.45967430852571933, 0.6879008757943178, 0.2877925666650545, 0.5074353759723584, 1.0144307390891962, 0.3217957783464429, 0.7682666497562288, 0.8466258085248601, 0.9041966426746068, 0.46727732402341543},
    {0.5288245387516182, 0.7711437885164368, 0.14828136588042537, 0.5508152011396579, 0.37558591403700764, 0.6883426127251212, 0.6529712204451226, 0.3374493972369327, 0.37184337162853015, 0.7549074634640475, 0.43901270452927893, 1.0555236710570803, 0.6452866494844227, 0.4758990015533777, 0.8188727996766996, 0.008191467796247558, 0.4939199223244848, 0.8602158120358896, 0.7311604921305653, 0.9049992530709768, 0.6175721945942401, 0.7100471098788765, 0.7939048325673381, 0.5499217156684879, 0.34575194851710844, 0.16102070680476135, 0.7731827406878078, 0.23864570444360314, 0.5764454003341045, 0.5771246487722205, 0.9950940997070008, 0.6452924083118224},
    {0.31998401426161704, 0.7697509120955064, 0.1526352862867953, 0.49353164024380314, 0.3370162566168915, 0.189869214310465, 0.8507739852872978, 0.5531566344599017, 0.47580774467157483, 0.7039196083088362, 0.53871612545274, 0.5902184387036444, 0.49925940745890823, 0.3941811915009996, 0.6575147308474903, -0.4518249569498115, 0.5502696466958595, 0.6484048283749252, 0.42833481432322135, 0.8712442484622568, 0.3758047482941817, 0.6214047284706012, 0.5463742762757606, 0.7117766981779952, 0.2422181754892713, 0.1057507064378456, 0.3503703049571552, 0.6966563434701891, 0.6095652479761364, 0.545265702460229, 0.5917316889531133, 0.6301262667603847},
    {0.44287055439768375, 0.900178488186048, 0.5811493732058747, 0.8301680890904553, 0.2891018457364405, 0.8102355539906089, 0.9665594468494393, 0.5821469086164017, 0.39754254819954915, 0.6286008370724805, 1.047132446543041, 0.6111874846781536, 0.7557582361106002, 0.9398258463437197, 1.0853649884388206, 0.04301122128143761, 0.6362617952623025, 0.3914585431528546, 0.567741913792259, 0.6594079225201173, 0.6873798201813283, 0.7329627065408875, 0.42307802175259385, 0.39031573302089884, 0.17179951180829267, 0.45376829013470144, 0.7508271161364245, 0.17211995316075288, 0.6777374311159156, 0.7711698041284837, 0.4500525123245893, 0.47905622090963274},
    {0.2114342228294953, 0.7375769472496705, 0.4810573709380611, 0.556334418810696, 0.34111079407441525, 0.5661957384840165, 0.7905054735194882, 0.8040970311904095, 0.540288661668015, 0.8042565439603284, 0.7944977800905799, 0.7840031045689843, 0.4855487313640205, 0.7605423975037143, 0.8521647291692052, -0.2290288415651887, 0.19834457477932796, 0.6511210898980406, 0.377970400387473, 0.4104662010833975, 0.0650165359389086, 0.8559190371735717, 0.5885746213256117, 0.6853974560563654, 0.5397428358738987, 0.19764579523405235, 0.6297865901245624, -0.031193887406103935, 0.12135602911260157, 0.8249416463315873, 0.5619502795070913, 0.5169131166539038},
    {0.37943631530022703, 0.8319556702248507, 0.6686944155292198, 0.737926534887431, 0.37266937835470154, 0.625583606109205, 0.8031242366967466, 0.5821464416996457, 0.6426854338794245, 0.8150933165616334, 0.42751082395702544, 0.8033612953516498, 0.8551317507563676, 0.8227645535311282, 0.8210113310602335, -0.16169718043274195, 0.2837988935809641, 0.7386587113550719, 0.7512709412227386, 0.639410702033116, 0.5179612390821073, 0.5735323425540179, 0.6511482607790117, 0.9574710902832422, 0.42457496612435147, -0.07571249141112288, 0.4305906290372239, 0.23565549476918657, 0.7233905343949724, 0.36564666827704223, 0.8537939291548048, 0.30567883353676695},
    {0.023295374648671215, 0.7096913722338587, 0.7821775623770235, 0.3989836118007068, 0.3652827990815794, 0.5302254130007991, 1.0077983500940269, 0.27084115380351975, 0.4921187858498286, 0.8158173027143922, 0.6260316528863966, 0.6390157002169741, 1.0865761548966504, 0.8152435341163081, 0.7250757587082578, -0.18606509145279077, 0.480483356146045, 0.29828431584098164, 0.5467078468475984, 0.7122469349666098, 0.49006273427760066, 0.6711693238285823, 0.4114406533051774, 0.7084362361363299, 0.19377427875392014, 0.28645880665514917, 0.5078220061707294, 0.27828339426324283, 0.7510670257494341, 0.6975153026772498, 0.2892522273996526, 0.5680107859192618},
    {0.6624680791187169, 0.7231520725643238, 0.3831231878924835, 0.8501202317542429, 0.4667185159249823, 0.30101789261967227, 0.9489832028421745, 0.7824648172571412, 0.7091533021371924, 0.6713047545656833, 0.6721923020569128, 0.8490018343393234, 0.5350032585809732, 0.7411982628065602, 1.0462918872175253, -0.00838746578226146, 0.8138332197906735, 0.6875216817430904, 0.5769124259474294, 0.5375758252244734, 0.48044583293523396, 0.8107544958321741, 0.27566252642905736, 0.837803982063345, 0.2586287241847046, 0.24048570087413157, 0.7420420906677583, 0.2836757530182789, 0.1801018054834115, 0.6188395785885441, 0.7021818328022434, 0.4704420585673844},
    {0.3057746741521373, 0.7252402406116407, 0.4916269888470117, 0.7425993264768481, 0.46808723646841294, 0.5777760207936928, 0.7448477907848939, 0.7185567349253184, 0.5389476249590861, 0.7082890664447674, 0.9042253191501668, 0.5668009836363573, 0.8573909433963439, 0.6632349487601708, 0.7073566667633855, 0.01711620630135722, 0.6618457628410092, 0.4306620548475561, 0.3860992625272179, 0.662161615149719, 0.638651748348198, 0.7572663822322988, 0.6099413571025198, 0.8760846448642798, 0.3974845483656696, 0.208579507229162, 0.7835006648048045, 0.17891900390101145, 0.5666620974523173, 0.6860091706736787, 0.7510713866202899, 0.5443964256512697},
    {0.3944906146269153, 0.5438172715103656, 0.5682310733419146, 0.9025284380623795, 0.3890226529644618, 0.5172197816043423, 0.643948053133801, 0.569562642696033, 0.7570835246932883, 0.6985256962080003, 0.6246026438293686, 0.7418795224610291, 0.7517474741282357, 0.7360528968351144, 0.5532657910729843, 0.19216522091723046, 0.43306321471263143, 0.8996490538403649, 0.6864263087336245, 0.5559048347013353, 0.312362082279212, 0.40215613718507476, 0.4135702871578203, 0.5993139527233204, 0.21493458309415475, 0.24055218444741067, 0.5873139305272873, 0.2554452014723161, 0.720301592619605, 0.8721943533143948, 0.6797538678123126, 0.767798763467722},
    {0.3934708480410882, 0.9319884089259116, 0.5239749036856413, 0.4216821621274078, 0.2380200095551423, 0.4371807116455654, 0.842312509648819, 0.567504791647787, 0.5280795982237144, 0.6810137389672425, 0.7083479297825003, 0.5663128009316213, 0.6006841388031892, 0.45918947461652476, 1.0171928189394943, 0.01449275110874934, 0.7107118738992728, 0.6214010475122937, 0.688087202700947, 0.8089481217648945, 0.3659164024671911, 0.667476480595815, 0.7609127808914753, 0.9530332617770143, 0.5021680446619234, 0.20834938236920902, 0.6935888402734418, -0.01587100913936589, 0.5265290910741446, 0.5628771399775769, 0.7749887211589754, 0.8110933551904244},
    {0.1578242375950535, 0.9708902519820543, 0.21878033406002434, 0.6253803248930682, 0.3617384863906648, 0.430029291190651, 0.8943656182691518, 0.6788429598535076, 0.6465100949219397, 0.5213936011733262, 0.6575589613179046, 0.694873168401932, 0.7589795983217847, 0.9291818527046131, 0.8240158300882048, 0.21928997997952057, 0.5264688085336034, 0.6189240977580652, 0.8290546605935212, 0.7385532696081414, 0.6429038217681539, 0.5170476701783059, 0.26982169712554843, 0.944239210953179, 0.45906589747397236, 0.3565343857024233, 0.555295117005923, 0.3382978404630021, 0.4396017090753228, 0.7136589448800956, 0.8819073562383222, 0.17623405869713027},
    {0.6724458738467222, 0.8519086220453352, 0.20011570695773767, 0.7699370410815749, 0.31452995312957194, 0.8221842878391633, 1.0012905863902104, 0.8875294963110664, 0.6241319477008328, 0.6789757850767704, 0.7803026086369371, 0.5927001546696069, 0.7159063147648458, 0.787545893449665, 1.0817057845789946, -0.2106508286763764, 0.4914315056559433, 0.31386031012411214, 0.6491740050563005, 0.7738604736733804, 0.30330147959876397, 0.7962216228822673, 0.4993297588818275, 0.7108139481797789, 0.19223399768489344, 0.3038862304600789, 0.45385581263759495, -0.09401203490681315, 0.566777444372762, 0.3814353762182238, 0.5497986194015907, 0.4090036336114487},
    {0.3219251794254574, 0.7193777425033625, 0.44689987103605283, 0.42913213610873546, 0.16020194805183763, 0.33413444336671333, 0.9171682945127578, 0.4761422937697817, 0.543544147566657, 1.0160142972413664, 0.7115167404722056, 0.34995720136625474, 0.7566713617801544, 0.9194088213885327, 0.6594853308973672, 0.0776800537077723, 0.5487772410843207, 0.6107158815870756, 0.29805403067341585, 0.5576882278132186, 0.5943817048335261, 0.6876231518470542, 0.6498058705172233, 0.8328127105720272, 0.4360834108113181, 0.6047272784247898, 0.6648871529027596, -0.015852488353464627, 0.5571150446349574, 0.5266542209041674, 0.8503003167563351, 0.39971920445173914},
    {0.22793800848680304, 0.6471079838398335, 0.26456147807597036, 0.8945339856718343, 0.3747422901216494, 0.4166897865888673, 0.7214051137029384, 0.8123179132055698, 0.33575282733770845, 0.7027625854085335, 0.6345900876309044, 0.6778261640869587, 0.8406245584044121, 0.47180413282898764, 0.9827945145613007, -0.174085146123207, 0.4908452210202616, 0.43936256292681425, 0.5440332574959291, 0.9332363191120736, 0.5082304713321658, 0.8031851628191049, 0.6817372932707356, 0.7389987730621786, 0.5458872878862974, -0.0829345181567796, 0.7282504703525609, 0.12973065538275858, 0.7146180194698467, 0.9366769113100148, 0.7131656587054934, 0.4025340664706474},
    {0.7001287791245313, 0.6227960600061643, 0.5103702732661215, 1.0589575858140512, 0.28590422763711415, 0.6074407020657916, 0.8625212356311985, 0.4525653702591149, 0.5320399632772833, 0.8289720574147064, 0.5931067500949873, 0.7895852561686919, 0.818523045072069, 0.955914219004871, 0.6938546861288645, -0.16427125083543354, 0.439323293126199, 0.727802554192113, 0.5605754641241587, 0.7451302334409527, 0.6934880274028575, 0.7589890376089978, 0.6577738314587575, 0.4899678500451042, 0.37955962439270874, 0.28093361552843293, 0.7967138701571267, 0.1144154930632684, 0.8041694024505468, 0.7814267826499778, 0.9124895336820893, 0.19086783129619622},
    {0.4067598412159752, 0.6356713198774622, 0.13878545490277805, 0.6930068346295781, 0.24060201641743484, 0.6999586372747311, 0.7939407317888838, 0.6924105656776818, 0.5786577959673255, 0.633824316854622, 0.5625229137086171, 0.7841393469978953, 0.8272868618895612, 0.3279211606663872, 0.4825195749061606, 0.07046110089405795, 0.5774116862400103, -0.01691137576686573, 0.799945722427819, 0.9973392192533986, 0.43443388060239524, 0.6825725197008211, 0.3546328604853895, 0.8192456849744355, 0.7453052322987794, 0.23749780414225832, 0.5704767278312468, 0.14165463238619438, 0.6983946405022761, 0.2690426365509808, 0.9406313835180136, 0.5617427681024308},
    {0.5890782825370837, 0.6865032701331886, 0.6273572393128738, 0.8920383673340959, 0.27205316977820276, 0.1385030315515623, 0.5097991607834306, 0.41725004165783186, 0.6216148491082263, 0.6747679908821045, 0.6382942184963101, 0.7577663627818786, 0.7789457356475522, 0.7596841197178237, 0.40691775819230647, 0.1404755106114331, 0.9200204781334064, 0.4223632100077879, 0.4820506363413972, 0.6014412953571595, 0.4851470937768135, 0.6612346189381205, 0.370648934720918, 0.5389432606048591, 0.04662414060125813, 0.15873491368010023, 0.3702199348456755, 0.019719912135980427, 0.4389771511592757, 0.7195924943254525, 0.7874704173648583, 0.19317266452644832},
    {0.26900216554314926, 0.7051306627357703, 0.2712809167651028, 0.5617987753244877, 0.4448099506076135, 0.5499320818787671, 0.7967709873511436, 0.9404338841052052, 0.7183047118810435, 0.41486253060110245, 0.871674541373373, 0.8996622428546717, 0.6523860427421563, 0.43694391232632696, 0.8989159614571192, -0.03819724044985097, 0.6819871020976468, 0.7122109767759579, 0.6539865125840482, 0.6260067637760531, 0.6184245224220809, 0.6498075085101982, 0.5349454285263541, 0.6369383019016995, 0.38273867571377246, 0.28824450840578064, 0.4097386260538335, 0.1973546705905991, 0.6809886897171055, 0.7092326631945199, 0.9041752757881498, 0.6712135302679716}
};

static const float b2[32] = {0.42533216423222175, 0.6968350524763773, 0.4477055416738272, 0.6433422292389236, 0.42986452320002994, 0.5265637713372752, 0.7042186453788578, 0.598777517244074, 0.4839481877189256, 0.6584907848442996, 0.6759742774867112, 0.6043005127019315, 0.7306318955716898, 0.6300873459733661, 0.6881156910424899, -0.07969961905007245, 0.5922096589479602, 0.518357340269253, 0.5538556983405861, 0.7294081825492067, 0.5016245177492115, 0.6902087292133496, 0.5062402852955129, 0.7061261606406741, 0.37887378648085224, 0.48433941714341466, 0.6034937458783172, 0.2718256451205503, 0.61835734795338, 0.7047761564796111, 0.7163834488708163, 0.5657159602363169};

static const float w3[32][16] = {
    {0.06693298596068643, -0.2031466331566779, -0.04651249673928194, 0.8473192859657098, 0.15630151698399353, 0.14677226160060275, 0.10339784606562845, 0.0160382499570731, 0.21613412121945225, -0.0896562584930077, 0.2582386744592009, 0.6237731808173588, 0.31629862208578585, 0.8546823886718973, 0.23699456295756613, 0.9340584310573451},
    {-0.32997197054835187, 0.02277203834558742, -0.1702771593024364, 0.29201966474635815, 0.48925138770432264, 0.9427380246275007, 0.7919844279108117, -0.2253929141756669, 0.18807161159038838, 0.286488548627301, -0.11012509971246039, 0.9646277743267611, 1.092924323542198, 1.0825684762089407, 0.511965008729812, 0.7961772934916349},
    {-0.2457160645731397, 0.044151788237246525, 0.04754869586809616, 0.4081744097388851, 0.4405246522717716, 0.2648238166280975, 0.7656849722475063, 0.11398342780087013, -0.3804325325207712, 0.21059523230346935, 0.33944446216341595, 0.45609965645087674, 0.5075153696655282, 1.184475821557616, 0.22470912542873908, 0.4694174422335686},
    {0.14010150933327, 0.45489362189552196, -0.18417568925921424, 0.6391562084067473, 0.6824004381841358, 0.32758218320112303, 0.5252847874658058, -0.2024303534349227, -0.24327629538093104, 0.06816568514789909, 0.04638063713114144, 1.0970709743990663, 0.8609002977480049, 0.6653113124578712, 0.38942342733204666, 0.7590901343978695},
    {-0.16602500476865978, -0.04402369625090404, 0.44863856761880666, 0.5240323973603418, 0.1994255942115998, 0.17664793500251802, 0.3341460309349735, -0.30138734954387203, 0.27444290197109855, 0.42719896428695786, -0.15679668247601505, 0.8005105992321561, 0.3611959644885711, 0.8594557118072255, 0.5264092500982692, 0.41170371870182654},
    {-0.07179324664736633, -0.033784927756423874, -0.5195251317326715, 0.6172161633618932, 0.7604747939201085, 1.1997114102754625, 0.2587165948200142, -0.18142182388937517, 0.5804856345386934, -0.2269682884567526, 0.00957067892269353, 0.6480666874635216, 0.38465125424066904, 1.2092547985685462, 0.3988385298086971, 0.4322348371588162},
    {-0.5006580174905109, -0.11988907929093327, -0.6497485003717497, 0.581207552105659, 0.7010731765383081, 0.819741208157421, 0.623852447151729, -0.2012524221671518, 0.017313718699173, -0.19020929825241004, -0.3330783527909716, 0.9653101440045159, 1.2313725427612587, 1.2266741116728266, 0.5600406596931561, 0.8923786658378352},
    {-0.01763975731897119, 0.23201032538571104, -0.28530267173887724, 0.7977812732298627, 0.6121821111266746, 0.753103131552718, 0.4275676878561319, -0.21468285876097457, 0.11298456499030471, -0.2889754115014463, 0.056759157852837756, 0.9384452985678988, 0.7484086620003298, 0.09548354583105206, 1.08655379203099, 0.753198129637351},
    {-0.5256325582990112, -0.08580379745392684, -0.17433491933018605, 0.40123798436173946, 0.29911034754286964, 0.7799961501341158, 0.3359650142887181, -0.04775362601461289, -0.09487424842885912, 0.2682548804328046, -0.4122874024708474, 0.4618083525378817, 0.46639006860351295, 0.5589901434891563, 0.6553828904824626, 1.055913891125629},
    {0.003038527917459738, 0.0379763139995632, -0.3920264020465812, 0.4427488383457742, 0.3602730587004723, 0.2976901334326431, 0.6346884035433683, -0.025438443166630062, 0.4526804316557774, -0.04951502684721556, 0.37981143849594995, 0.7019909882542564, 0.7769102394412017, 1.1113297165066054, 0.28768800379356957, 0.7275654587362085},
    {-0.08799246300043045, -0.16894837201462853, 0.0409407282530601, 0.7557148920643917, 0.8289893325330046, 0.8770070254030892, 0.6759161019089014, -0.11059880570236941, 0.08591947736427206, -0.37872335977535737, 0.0611692897296499, 0.8838174269521095, 0.7696020402074957, 0.793403823796965, 0.6806099223833453, 0.9674904825926645},
    {0.22538443196820257, -0.04137799800484475, 0.1687992818616732, 0.45250668938819055, 0.5045510993027156, 0.8582378472116926, 0.8165246493920042, 0.05857908146560523, 0.41475807124207315, 0.24790806104556834, 0.028444916767487786, 1.0742961326743148, 0.9844630482722521, 1.0302354014678943, 0.9939093589877884, 0.884747097416675},
    {-0.32781783000616604, -0.14006827477001366, -0.19212875641012114, 0.5712182340341758, 0.44525437355225006, 0.5771571363485299, 0.522951974516764, -0.41860958736271464, 4.545491656577929e-05, 0.10966489429509052, -0.13383567093981663, 0.6328789388741783, 0.8744294192658196, 0.9527275375466379, 0.988867833376343, 0.8280510311773587},
    {0.21190015893605021, -0.3662174514250653, 0.18227366935344488, 1.1329531090984746, 0.6307722556263013, 0.7551412654556919, 0.8889030780207955, -0.4518922318081692, 0.43600634276436284, -0.277509128221343, -0.12554369500213383, 0.5930736821502955, 0.8577207120341166, 0.7199748762300304, 0.6780850612839006, 0.934908880133824},
    {0.2073548201157585, -0.18480110051380574, -0.05787297027122634, 0.45332955553494736, 0.44200889975398566, 0.7234800929617566, 0.6619465568629911, -0.40408346824073105, 0.5716034295012657, -0.6869444201369259, -0.46443101269897674, 0.7800985677941771, 0.9063754285297949, 0.8642311541078052, 0.7750003124086389, 0.5702866432470495},
    {-0.28939323327782196, -0.11661351129795942, 0.3742492134820676, 0.007322102260203445, -0.43778460185898105, -0.007428122931251984, -0.17963991559549417, -0.021966812047088762, -0.2576632020419418, -0.2276099570384801, -0.25753849911583715, 0.22955060999920954, 0.03288831728011324, 0.20923327992395382, 0.13591926577942956, -0.35746083361003206},
    {0.03543165173129211, 0.12998752538897482, -0.44026113136722156, 0.7302169982957769, 0.6506915091477388, 1.0975578220989426, 0.3335949140883289, -0.10159374033524252, 0.3968584322153425, 0.10610658293059208, -0.17475522010671712, 0.9310421090979772, 0.8584065672332266, 0.5925542232680169, 0.017210759011941332, 0.979259366748703},
    {-0.18852316791876628, -0.20854606084801836, -0.033123185698351265, 0.45888246735379506, 1.2053096684064217, 1.140100633549653, 0.2610954020002667, 0.5164932958970957, 0.14207231082140348, 0.11547540903365935, -0.318430140395503, 0.7225178690312374, 0.8230175220903042, 0.4204086262447372, 0.35632753770779907, 0.6575660608781435},
    {0.10208949761719563, -0.09411503646349563, -0.007316080218834563, 0.7464726238699338, 0.6796811617014101, 0.6086670254451082, 0.8002703543675014, 0.4573633570903108, 0.2567147318126393, 0.5338477125273806, 0.5764625516365302, 0.9895492794582468, 0.8110069270617803, 0.6089166622980304, 0.5892299560037508, 0.4500978999702382},
    {-0.11086836903551359, -0.10748654949644741, -0.01674313575484321, 0.3482714852469093, 0.3349702997733867, 1.2880705074660261, 0.6114000417247117, -0.12460660775436003, -0.05121871433271423, -0.09204961206125784, -0.09126605029841958, 0.9043292353070836, 0.814942990867452, 1.058301390758308, 0.5673305698163056, 1.1580715172844496},
    {0.4141264223974892, 0.11252492060812344, 0.06717204100919384, 0.7049147385086771, 0.5670332222886539, 0.7194185019846697, 0.5191911988675204, 0.3578555250091827, 0.045926287878735005, -0.4485541264099421, -0.017081194556051876, 0.21103027264750301, 0.6614891265982531, 0.8250073956726656, 0.5174461601574891, 0.23926564555435056},
    {0.057608727177618904, -0.3518953789285502, 0.302914497038879, 0.48866875528235826, 0.6434558830038153, 1.1772807429230496, 0.571843283793777, 0.10410772246950413, -0.1433793275690419, -0.2397313291336882, -0.03408803576155755, 0.7533003591179582, 1.1019850364735122, 1.2866556593756626, 0.3759933481412452, 0.5996757672597713},
    {0.32551865722894024, -0.29797388590753404, 0.11599317460203885, 0.674286709395896, 0.6107401342473361, 0.4371844080770277, 0.5665888538174733, -0.32357056402686923, 0.49716024141943854, 0.22921570193806792, 0.05946495518608758, 0.672761250925599, 0.5076427417367728, 0.9377364879399881, 0.5545751667869411, 0.7572018762056801},
    {0.4508339828935065, -0.11459314707882341, -0.16842083018216084, 0.5207276892809366, 0.10473610966745661, 0.35921354131156513, 0.8564676377557221, 0.07809447543987082, 0.1227488775297473, 0.10128459209440074, 0.015979516613799913, 0.5091084979353289, 1.0054133153954328, 0.5718618221877095, 0.5066212362294336, 0.6085706292445142},
    {0.17389311076701577, -0.3279426257088442, 0.17692264557179221, 1.0064029734778481, 0.10369035922587533, 0.533375557476022, 0.7891468261221412, 0.0610022929767852, 0.5346428629220544, 0.3162639182371249, 0.4341215824710259, 0.60421159009326, 0.30309730873206703, 0.677977736924468, 0.32018687467732565, 0.2708625566790048},
    {-0.06386536685826161, 0.0008221446170301981, -0.056697517420901275, 0.808361634881429, 0.05101817477429834, 0.5709408533656729, 0.3050919690698277, 0.28989393054158946, 0.4260511493004567, 0.36314442435198974, -0.3784873513236087, 0.9260095478801612, 0.6139289222160712, 0.32638591222844066, 0.4468534254336074, 0.5617729833938462},
    {-0.3167342301880152, -0.09528538172954769, 0.2891067507602635, 0.3682844569803771, 0.8186306919348456, 0.4795342355686742, 0.6861348608833217, 0.05227843582882035, 0.5637026576850869, 0.0365642478947627, -0.313668811706716, 0.4028083026229173, 0.8083896410957203, 0.78493041116247, 0.897911691549357, 0.38416981893587765},
    {-0.21138577535978437, -0.09283044960424, 0.08964192382588315, 0.6800285415046491, 0.19627359655887253, 0.5787902132297424, 0.32358140056379053, 0.10979165062176559, 0.2948371001591709, -0.13089357869146764, 0.4786898721927859, 0.2715337842092171, 0.7405661234895983, -0.31530852841450396, 0.2247768516248767, 0.08073872052847943},
    {-0.3839864305937339, 0.678182004350599, 0.33397759882398753, 0.9401287511928001, 0.38801967242708457, 1.0280973502606232, 0.4864541733637052, -0.27894152997798516, 0.32909182504334983, 0.1741007657970963, 0.11722373192556669, 0.5526936997138738, 0.9606686969430898, 1.1213070352194945, 0.7889240363071199, 0.7747898763416893},
    {0.1019107383658859, 0.03818274025345203, 0.19109302099040806, 0.8569577976598238, 0.3867675085517758, 0.7240290561409155, 0.4280024309860343, -0.11701336036052351, 0.43568813992623434, -0.3543679865267061, -0.17636130726628096, 0.873694358450878, 0.8005789201543827, 0.9840697115358878, 0.7719489560697678, 0.5339442626550847},
    {-0.13813058236417017, -0.09851838944381346, -0.03595214810762728, 0.5941207400148385, 0.27047417289182546, 0.7942407029273724, 0.6778268938155538, 0.10308596869640972, 0.17385970258444144, -0.01066370047546371, 0.10001331567190948, 0.08745981336303277, 0.9308052433015179, 0.7844398260176291, 0.8933195410603124, 0.7286680673230643},
    {-0.06329548452641177, 0.3038123412321731, 0.18030123870932413, 0.22010982647641564, 0.6570797604309436, 0.6758528552641949, 0.42771682313386006, -0.18421365742120346, 0.3791382385124064, 0.4403947802000484, 0.07353795837214218, 0.765814484729594, 0.8009364757043296, 0.5303924435601438, 0.48043180173734656, 0.6504659703254303}
};

static const float b3[16] = {-0.01115380779446661, -0.05265002577400915, -0.025177248298407846, 0.3345099792686303, 0.27110369889776204, 0.47607665233930613, 0.4164365030048174, -0.039119441357706876, 0.15277387557678365, -0.05244637915855714, -0.016325139059914336, 0.5111849473058433, 0.520790430748131, 0.541117893917643, 0.4136949227850701, 0.4851603859883671};

static const float w4[16][12] = {
    {0.12808281877887656, -0.22042442216319302, -0.0677768222914463, -0.03411428546933893, -0.13861188615405995, -0.007077247709560019, -0.05260027919103372, -0.19618352055132127, -0.27633268834938035, -0.002034729982265823, 0.1318441458825732, 0.7104860184345488},
    {-0.38383515163599474, 0.28869637799643016, 0.16818040301115558, 0.3052434267761088, 0.5069988315909709, -0.005321828908333642, 0.1783840161053601, -0.3658452484520801, 0.14924659486658035, 0.04315358253151806, 0.6056595387678224, 0.1000739056127996},
    {-0.503575224948651, 0.43179031805899837, -0.3769292393613375, 0.40245249138529227, -0.2937975674769046, 0.2983459150695179, -0.2167149885050803, -0.07781800185483552, 0.30440021435586756, 0.32599434477350403, -0.015449863026339107, -0.2726718649274606},
    {-0.47022440326055365, -0.4274508366866956, -1.0577150413773253, 0.10937570952398308, -1.128321839986446, -0.6220321821613474, -0.5967776730340979, -0.15364898015035847, 0.022752727176293397, -1.0092555061258763, -0.7431147021994996, -0.25328370146431145},
    {-0.752372443694626, -0.3841623089546888, 0.5506032410660114, -0.565616580573711, -0.5246382337101162, -0.7409462098311155, -0.16673065558855724, 0.023096055633289814, -0.6704076332574846, -0.6724561012754948, -0.38340136417499343, -0.8954412539395625},
    {-0.801516494483961, -0.7578320851683801, -0.4248092105021203, -0.27260495641588156, -1.0738562223018262, -0.633635460678686, -0.6396975131291625, -0.9206091272919241, -0.7283398026377799, -0.3587577447005117, 0.011493991221478088, -0.5215436656360781},
    {-0.5918454921894393, -0.250722210214441, -0.7557649986773922, -0.6438712517840862, -0.46078503430380424, -0.1658362844788592, -0.5142540372586066, -1.2453924120793494, -0.04353421133785342, -0.8450782302268007, -0.8745282588052778, -0.04979237002945583},
    {-0.04424223331721767, 0.15294901307017045, 0.44545729595086075, 0.04319019089133886, -0.12460180186819202, 0.6803304774502437, 0.07330695102049006, -0.20980549851188784, -0.43927850477849195, 0.21569629025475462, -0.11266968463351873, 0.3194867935300971},
    {-0.013218876838859396, -0.6419701952436814, -0.7949542091601428, -1.1101128474824984, 0.22545967989096477, -0.004043160405530218, -0.1938295166137014, -0.6135885859166885, -0.9346476766968523, 0.04422480139803423, -0.4977118609088251, 0.20963896543758767},
    {-0.4236008835219351, 0.715475152904641, 0.14468144887792084, 0.2918049961678049, 0.010568813817125782, -0.06270384580865579, 0.011317569344165706, 0.5636679557193955, -0.50109940493816, -0.11166040807474424, -0.6017300144711788, -0.09149017034842041},
    {-0.2100794303909255, 0.6436236945889433, -0.6087590345501184, 0.28034746099257773, 0.4297611718033847, -0.2578393308108291, 0.8777133918901162, -0.14737219085438583, -1.2354410270740013, 0.13004970565705448, -0.13367584163750043, -0.015031377436669513},
    {-0.6396946854038376, -1.0886654396343713, -0.8767206571477659, -0.2714048290073094, -0.4061836970362465, -0.39853406224567595, -0.6480981691117667, -0.5573900854486611, -1.1814507040326858, -0.5300505170824577, -0.3493435163638174, -1.0370077303639358},
    {-0.5391845011227705, -1.0707586377422713, -0.4125208852245519, -0.6583186895600429, -0.7370455303833512, -1.2451121814882646, -0.3565127407990939, -0.4282933555806458, -0.30568781030595643, -0.5222370935918779, -0.714045355963799, -0.9975337696017027},
    {-0.866472182213106, -0.3709137407445691, -1.0354383371461642, -0.7026674484688046, -0.6199577480405022, -0.26866088556515333, -1.0634924660814793, -0.6173617602378745, 0.04988564644177978, -0.8184118534723405, -0.8565062846764303, -1.1290880466798856},
    {-0.43555846134179876, -0.9414960248456221, 0.03037755524990787, -1.3313093983278967, -0.7469464135564318, -0.5757180041714592, -0.7429852890684671, -0.4818837602837076, -1.0849505931957801, -0.33894848612400763, 0.07030304170019193, 0.16556657247748327},
    {-0.45891260045998905, 0.055999427769031884, -0.9215510125732826, -0.788980119216, 0.006546411092145054, -0.897044929155017, -0.6128891020966432, -0.8159541525475142, -1.1777861709793622, -0.46143310229739726, -1.4259394632488998, -0.4529195458981644}
};

static const float b4[12] = {-0.16461263132531614, -0.24599148232719184, -0.3226783560597536, -0.2535600245830258, -0.2152678723529375, -0.2993044817631631, -0.2454958653591002, -0.27340092870398236, -0.1403359493058569, -0.2686632206865707, -0.22352672413635233, -0.29746913704425615};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
