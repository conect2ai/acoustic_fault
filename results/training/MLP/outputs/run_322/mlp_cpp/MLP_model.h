#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {4.155026827444592, 4.3129796257874675, 0.020478465153502597, 0.23022132798994274, 0.1733578825969083, -0.9195484836732362, 2.53435320992587, -0.6182385385032976, -0.9018949635497611, 3.172949447885051, 0.5930916133249734, 0.2257650074223251, 4.12140231477615, -1.7220541801253462, 0.16380765979919298, -2.1710938142161686, 2.3487560194228747, 0.5672451317853653, 5.694090563814859, 5.081545621383299, 1.167085808597314, 3.8955070369228992, 2.143041369849516, -0.06628972707989968, 1.196838060016527, 0.29306477532120806, -0.5109426504820669, 0.25657887521389333, -1.3839868421145067, -0.2985100371184939, 1.8082367663679606, 4.0185669678772085},
    {1.822089345554289, 3.1140362981065555, -2.510402196044975, -1.7111249032210991, -3.5084333544690534, -2.838432296399325, 1.1848982112806463, -1.064874920257964, -2.1200957798338442, 1.206996839487373, -2.382171937594154, -4.254716240036675, 1.6769984703833496, -2.6489306101735104, -1.8475008629644902, -3.3267064975794294, -1.2300440206036625, -1.9777658403946528, 3.390957387124694, 2.197236493826334, 1.5331322432604728, 2.186590752748659, -2.3022061105593696, -1.6391432942446995, -0.30296038409996306, -1.902974775312628, -1.3321057898351538, 0.10419314988134466, -2.775374469012213, -4.1725223782270255, 0.0014819981536326274, 1.5607146260840992},
    {4.8954764461369455, 5.28533273584897, -2.6925128161620724, -2.2910898514089517, -1.7517223330492346, -2.3808933807457264, 3.58731698577407, -2.8633806059947426, -2.3649199877953224, 3.132030261953501, -0.45981501214812787, -2.0433568539151876, 1.7657713590253474, -2.5208792461891476, -1.5592483645976327, -3.5676549174865864, 1.054212395571773, -2.216829988321588, 5.20878453662522, 4.900217412690388, 3.402317561939115, 1.7446548952508367, 1.643295050147363, -2.231763304577109, -0.32062395609908445, -0.40515084897925163, -2.508520299526561, -0.7373629373275665, -2.2874262512111394, -2.0127899353161296, 0.11374250721855746, 4.031300418722523},
    {2.9376430393555246, 3.685560557431834, -3.653584214958827, -4.420117858518267, -3.6682351001542743, -4.912645515978871, 2.4114750346618115, -4.165338063423335, -4.680260118758679, 0.9013526255685104, -1.5842111980681346, -3.475889668662984, 0.9155855540779904, -3.798782377058149, -3.170556410548667, -4.830706019537995, -1.0077954758692147, -3.4991722825796283, 4.306740655277291, 3.945135945919214, -0.12140459879236941, 1.883378493443954, -0.1135621073694569, -2.177112005039831, -2.0502812974161992, -2.724878152777468, -2.322552382007107, -2.192299292829294, -4.231659850494932, -3.4393757019974918, -2.830315916707757, 4.861798284252555},
    {1.8053084588918349, 2.526289914110763, -2.9082680144610693, -5.549369481098115, -4.073487723789902, -4.239103713279775, 0.2054827500852796, -4.790768852252118, -5.224609189129405, 0.36294115687874745, -1.2574908460277536, -3.1149527191051307, 1.243498664222869, -3.505134532531837, -3.6524757024896575, -4.358604003525459, -1.9169178199744554, -4.3260736868260485, 3.9098236746435666, 2.8231546206099116, 0.07294502595051264, -0.03199166764971908, 1.139741443656683, -4.556536422030154, -2.194454631299977, -2.889331334021995, -4.6059553168716025, -3.1770373309257387, -3.8946714548240675, -3.298457076950775, -2.977882582831893, 2.8195699310542324},
    {2.080029939875322, 1.795177529959284, -3.369367796797771, -4.627212710993677, -2.7228664418685127, -3.1155114377068336, -0.10169567196423081, -5.248274547210312, -3.21963375664774, 0.42215654574963196, -3.262082455612375, -2.161902353777795, 0.5441097622696474, -3.9539692200484997, -4.498726284593307, -4.764896677576886, -2.026493572411894, -4.856723439846643, 1.9280750195345258, 3.323115273840637, 1.1832483529437636, -0.884141921504842, 1.40388547715726, -4.134162524464175, -3.12591813790122, -1.0790027007479133, -5.109839045366205, -2.403589962567473, -4.362713061653329, -2.7914620217046857, -3.9543598404435274, 3.3366010057931583},
    {1.4219642971981523, 1.95776286861596, -3.376088285473102, -4.3761165561899675, -4.384371540247754, -3.853487707067552, 0.989537299158304, -5.3312353233126935, -4.814375527237828, 0.23091991054895072, -2.3336762083126796, -4.2647768936615105, 0.753052526527922, -3.3692143855727377, -4.214261994365327, -3.7701234709509106, -1.3653813934723498, -4.521356585853017, 1.7171271145288993, 2.085901524254501, 0.2705673260053837, -0.2792962354366705, -0.2347828713244546, -3.015972058242975, -3.2251199928486827, -3.2156728359251145, -3.538034519053821, -3.3178453741495324, -4.108699735672537, -3.234212237355344, -4.189786291595646, 1.6553209093448507},
    {0.19576020336221464, 1.654040928486775, -3.1501614891674534, -5.945387521283971, -4.902612681955345, -3.5593607799712794, 0.31678461756926224, -4.790128546187974, -3.365980605906411, -2.0600665598359216, -3.287203025373641, -3.220633506370036, 0.608125516249055, -4.933559386717472, -4.237776134454531, -5.036793993994664, -2.442931894566662, -5.021972407925768, 0.7693943012706802, 1.9388275029409925, -1.1941450462777183, 0.6934621974418583, -1.1288761197987394, -3.531967736757473, -4.132584602354338, -3.976819164296404, -5.335280117271125, -3.2964700914184757, -4.871737459186585, -3.7929735009523635, -4.199816519770643, 2.603986576590905},
    {0.5769512509194016, 0.9832086071071353, -4.959227933998518, -4.997114432696646, -3.1212089118195796, -4.984030762288194, -0.7495567497369683, -4.4222965730191275, -2.728607799604238, -0.7659071476577438, -2.658141694840055, -4.598630796496434, 1.1555485234699534, -4.4643465848254, -3.6656615732099116, -4.737964944741771, -3.3556823550312616, -4.267696548787989, 1.6271273927679781, 1.7478969076265323, -1.365174770102211, 1.5136830411453046, 0.16840041800503616, -3.7168171108303136, -3.5363057239518167, -3.6980165280916055, -3.630106956015638, -3.3262271054358967, -4.555027455400835, -5.783194084792469, -3.7239774084404096, 2.3628440468910163},
    {0.9150338991348785, 2.670450193383066, -4.004765619414603, -4.9544560768290795, -3.938211427437487, -4.395080731337613, 1.0029481356403007, -3.229863820321125, -2.9955675082318063, 0.5631757075402961, -3.9631402284731982, -3.846751100867696, 1.5689029858264707, -4.42872138804853, -2.477907132704211, -5.415993893169368, -1.2898735036933795, -4.822793174884594, 2.7642154515105637, 3.642915527050375, 0.02495150093884367, 0.7859600041211813, -0.9471013851773201, -3.0885430996210186, -2.260028547958275, -2.758376902177025, -3.325421223126306, -2.7731301253881417, -5.1932894834814345, -5.8225439468171105, -2.1570806421001136, 1.5607641975573374},
    {0.742767696174132, 1.0491452066598574, -4.12379139691143, -3.1028157225611994, -4.567400916322653, -4.33177750107719, 1.1375913344988022, -3.0842704757887853, -2.932627952034347, 1.2314725416743968, -2.593375073183926, -4.180053320953935, 0.1672505064239912, -3.6414998480242144, -2.782342957486768, -4.447365836401913, -2.2844419740613615, -4.2523090120637095, 1.1104538923926146, 2.3639006443270345, 0.09563301227989529, 0.7041896016539987, -1.4342252072968042, -1.5551169068236403, -3.125430277083053, -3.431814480871519, -3.808277208649429, -2.46681858186358, -5.099494474586664, -4.515618406118471, -2.041199068805817, 0.48687203691023284},
    {-0.2485309045674983, 0.5131372385385743, -4.325045033724475, -4.537224703304059, -4.2820571856355585, -3.822978523619281, -0.873753408189303, -2.882171123637221, -2.3563800536339525, 0.4398600088118131, -4.404709712054801, -5.291736762512697, -0.3164481704040351, -5.216469908214559, -3.960073370477623, -4.634889983915764, -3.038677833166173, -3.0788331602529557, 1.2200523665132565, 1.1093243552861816, -0.7154972447369122, 1.1793102635858403, -1.3614669826380421, -2.4877587730619286, -2.0264870904849785, -2.672252561995501, -4.5887517543476495, -3.200729626075142, -3.780732815807301, -4.410167444690593, -2.892970981503285, 1.693752085322296},
    {0.016359672214568882, 0.3755420373200216, -3.6481958251802915, -2.711468872923835, -4.7876582467494115, -4.660800058661971, -0.5156277939000296, -3.672213749173844, -2.5817481834478535, -1.0124229237053768, -3.5681057807526977, -4.501496146398703, 0.22090094133095228, -4.325535866475649, -2.895749778400206, -4.492214465476142, -2.4943725418318645, -3.211072899857799, 0.17944592776962628, 1.3677024277413892, -1.0155160699176393, -0.38769014208635555, -2.1885237423272477, -2.878416396408952, -3.403936814405797, -2.5294013662288277, -3.165680378994801, -1.9663175866872842, -3.3010460020350885, -3.9913627541929984, -3.023424987701505, 2.361180731918044},
    {0.611412080609901, 1.8684566796381277, -4.480232742963159, -4.489509826506189, -4.579713425675315, -5.246381164800529, -0.7079725524083378, -3.2921557768858953, -3.27860565048497, 0.03587428547035626, -3.669228681036099, -3.7376913012390918, 0.7609441437904757, -3.9772739521098948, -3.363267342669729, -4.944524363049924, -3.141965630748737, -4.341315233015551, -0.3463862479970367, 1.8780762022322275, -0.5899530423577415, 0.42318643111054155, -1.8243391334616208, -3.919260621529224, -2.560860683116325, -2.6258367622752607, -4.116852379369434, -2.8093608591674823, -3.688148545539159, -5.500578134180372, -3.395329548562414, 1.825247018265566},
    {1.0945242283673289, 1.32444232353741, -3.9395576844452838, -3.6913268067206197, -3.881866884160319, -4.827205127627737, -0.17427762138385874, -3.535952793801395, -3.6093172766583566, 0.33635553548615965, -4.6021934790670755, -4.227440424096693, 1.401811980795993, -5.23586073390151, -3.156470587097499, -3.40017390578407, -1.5285914819976982, -4.414109663705735, 1.363817694076371, 2.0065095557949784, 0.046978982313672216, 1.4804310920223207, -0.8121992771750053, -1.915977925714331, -2.597510129410686, -1.8682847102386524, -4.413829914135457, -2.935631128784843, -3.661072256313175, -3.663574126166052, -2.519782027763199, 3.121436811707347},
    {1.6781782138527606, 3.037153965730432, -4.99618321664284, -5.12436484525761, -5.2271620503483724, -5.495437652687234, 0.2851937708331971, -3.7884840520904755, -4.820794930604285, 0.11218514323323792, -3.0503697475138263, -5.331708464639945, 1.344124375922445, -5.718296333844609, -3.473397865019789, -4.6498056453077234, -2.177244126070966, -4.26830241861225, 2.4816857239276287, 2.5378208210497926, 0.06827261602909776, 1.2808732902911062, -1.431502527318176, -3.8347394874728304, -3.557572849980211, -3.5517622189366294, -5.281056015260853, -2.1648782101680566, -4.708693254180112, -4.827323579964592, -3.8757090398844944, 3.4164270399388057},
    {1.5829191091222305, 3.5116705031209308, -3.213074467225124, -3.2359935486039255, -3.3567026654690606, -5.049169910511432, 2.0937297452616774, -3.5958066297828246, -3.4403679469846455, 0.8386093666753307, -2.4182172342540387, -3.015727140043664, 2.0402685535463783, -3.389315676910033, -3.3638570288769767, -5.249653632209538, -1.056381136783493, -3.6950992136302063, 3.1901839361828035, 4.7576097709493315, 0.051844114150077225, 2.239896865713729, -1.172071607075185, -2.8563655552282357, -1.5265056184219057, -3.2926432564697965, -2.9062441423835574, -2.174765251693036, -3.8283382353077746, -4.810035551016079, -2.0849361122845207, 3.9192218873024425},
    {3.6249011325105447, 4.59296917757771, -3.3298619143269015, -3.1221700702992354, -2.95536093205346, -3.414739922236899, 2.0054041102278575, -1.7259841044751592, -3.7168646805305663, 0.6861064843367325, -1.696654458474284, -2.238087279664019, 2.6049413730077595, -3.5510514967415814, -2.0464342280994985, -3.213819599952526, 0.4940550100226022, -1.6918107531753324, 3.871912736214713, 5.060781403303456, 1.5285921873269903, 3.265539898213715, 0.501886140458701, -2.6071424863845745, -1.172588313362963, -1.1276451066125524, -3.0163598278068013, -1.8849009717357408, -1.7546056493925175, -3.6356784208775155, -0.6449472190255741, 3.811885021992572},
    {3.514929734673085, 3.11037908436652, -3.6101666705659623, -1.8324648362225895, -3.262359600806159, -3.5319368303354777, 1.3889045132717672, -3.101988850067488, -3.8332339943053326, 0.6601523772650757, -2.5802056136925637, -1.768781628876821, 2.817795411778697, -3.781358767278996, -2.835141993436407, -4.139764219163652, -0.12201971163217527, -3.157743796034874, 3.3117646601770665, 4.565984364052267, 2.506972590653417, 1.4865564699511227, 1.8432254485236959, -2.9023414735692405, -0.6674896774934929, -0.7509628312695946, -3.7316247920870413, -1.5997326629465616, -3.1921319527349197, -1.8312835492090527, -2.051735583051974, 4.658542929088255},
    {1.6389640577191793, 3.044374062232702, -3.7175073701241086, -3.1514675972256287, -2.7678778284136953, -2.859356617442251, 1.202833684551, -3.4511432667040585, -3.124916566408727, 2.0575505854748175, -3.1403554535849008, -3.6708645679579703, 0.5414630644902281, -4.81412566034172, -3.1675757934696938, -3.6076111203769172, -1.9646294580089059, -4.5490470841784445, 3.378191990374262, 4.679308557962128, 1.514727609147387, 2.460864684834468, -0.09119509840191686, -2.224551190497368, -2.4318387977040015, -2.5153241282866197, -4.458956029773234, -1.7037391596824998, -2.813296548458468, -2.8430189149495124, -1.2993521374140204, 4.181563919939144},
    {2.671989832937163, 2.4006848776456384, -3.6534241551723547, -3.1903525878195684, -3.572704363339021, -4.58749505101863, 2.0678301551605376, -2.34709025268314, -4.927785070657133, 1.5617317273058593, -3.95132717437552, -4.403447288480332, 0.45935151254583845, -3.832490521931947, -4.10512687119545, -5.285245674849152, -1.3546877638848016, -3.486696666166982, 2.6753366063415744, 3.058812086275079, -0.06245397796182182, 2.6322347586211907, -1.0154731460021496, -3.0631487513625357, -1.5349498515858928, -2.8049510065665104, -2.6625132182202433, -1.8207513776717579, -4.586318690953141, -3.7242876579913085, -2.8986118959870106, 3.764487842916258},
    {2.8560042812153665, 3.816945543155367, -3.480653346224384, -2.6499220811616726, -1.4747916679506536, -4.2955897342372875, 2.8377628788569753, -2.5154472805650476, -3.3404135173450253, 2.913246834163536, -1.1832787609840296, -3.468862602803724, 2.675651748507582, -3.967454188330619, -1.2536373995465953, -4.382032261457886, -0.33383849594873066, -2.789179148851907, 5.34027331888525, 5.522372052402025, 1.5320130774393967, 4.244538856048307, 0.8225986407266711, -1.8533691269257038, -1.112035199140885, -2.063494477184557, -1.2769696144099671, 0.6123505209382232, -3.25675037685041, -2.386596304220962, -1.3342338503319289, 4.748790337451044},
    {4.775651792987062, 4.543134229617158, -3.19433049572145, -0.7406396849128793, -2.4256125024014814, -2.152357459410357, 2.4596477702047896, -1.8193533851720602, -2.4312518162664074, 3.66456895848698, -0.5009712487400705, -2.3252426549210745, 3.6974071991596826, -3.03365414764092, -1.9709594287432108, -2.850256607508014, 0.02594601051164333, -1.2696327829078247, 5.536891752708643, 5.069593210979458, 2.706333504703787, 3.604039724122253, 2.314063014506802, -0.528100313753363, -0.3417078584550959, -1.1852884829844026, -0.7926592564576515, -0.22826126540863734, -2.299263504795912, -3.026007103463434, 1.4372489329027176, 3.9323334018168574},
    {3.3166848852616244, 4.455869782335141, -3.997143155657954, -2.528507293987546, -2.325531442969209, -3.4463823377949594, 1.353918048007612, -2.4074214755050924, -3.0135914395179557, 2.4126972367838926, -1.5995901896762068, -2.6638719807000837, 1.523860991753958, -3.623766216351101, -2.9766474630495887, -3.126917534726175, -0.3833448950823053, -2.023711082655043, 4.205320365036422, 4.268542708639943, 1.1467673353160628, 2.511414676634894, 1.132380536441208, -1.352601462924928, -0.05075757980499515, -1.193086940051564, -2.1729050500709715, -1.2726338798416539, -3.5798633150883186, -2.6509872303822033, -0.17448599681771162, 4.612483789825374},
    {1.0262573008284825, 2.5318046962646386, -3.5857060101122014, -2.2406508645193983, -3.3964265277008776, -4.309053311552366, 1.8701138502652888, -3.2803976103442403, -3.8457858606184248, 2.0640824733840457, -2.8893986584095033, -4.9612261851351045, 0.6092371524959799, -4.3175973537009575, -3.449693335443485, -3.948016431962433, -0.89221095510389, -3.4102509666380216, 2.7581461986754006, 3.7654769810317332, 1.529357761253505, 2.043926996140994, -0.6537361686140191, -2.078519155774717, -1.6382804946973049, -2.868473901842483, -2.7963069783978685, -0.8311163452907667, -4.404034581194999, -3.593500963202968, -0.6148650207546738, 3.4514770151529666},
    {2.225500169662172, 2.8701622620157465, -2.317989325865227, -1.7038465715827964, -2.598091667102889, -3.9506377459359276, 1.1426365568201415, -1.9084299142725505, -3.0974939684336427, 1.239916759732199, -1.4921610293219976, -4.403028527842577, 0.434560350596061, -3.7908038057818323, -1.5519944933985075, -4.034995543195531, -2.2835459232913453, -2.83150094227271, 3.8392806576871363, 2.8957274818863112, 0.0023223933637270965, 2.7735908208365947, 1.3047508569383308, -2.6721606035015304, -1.7268735196490828, -2.4937019181548647, -2.757823332315717, 0.050220280861396724, -2.1174933519749546, -4.1685508793113835, -2.0545562713599037, 3.5789633958546587},
    {3.6012588726540504, 4.251557483915657, -2.7321521507729747, -1.3698471523751523, -2.6369714722142112, -2.9491110838575105, 2.7192178656055335, -3.0879837470605764, -2.947038961784795, 2.3192542271932326, -1.3056454601085286, -4.300543470463431, 2.520341422491885, -3.730327198186761, -3.2637680876416235, -4.525351667870341, -1.0578208393920852, -2.120381927896308, 3.1733864164130536, 3.5833713932608955, 2.0914254620085213, 2.934691035686051, 1.0046216787113045, -1.3383732881810442, -0.6204748636389669, -2.3303845511771897, -1.5869706418348652, -1.4922449785617964, -2.754565223586177, -4.303120183199147, -0.03283706401279637, 3.88922414090022},
    {2.3413404929968795, 4.177691205689736, -3.4451964217698947, -1.870674233016333, -2.6569093411177183, -4.212928421485366, 3.039737969517207, -2.4147272696141817, -3.440879545563715, 3.046441186250467, -3.3193742028537656, -4.630267095093061, 2.510566080297941, -3.5533891555731247, -2.766289226267032, -3.480477275917357, -1.0269129906718957, -2.79843610083438, 4.0071079407926735, 5.242431191144288, 0.3985468268746135, 2.4511342970074237, 1.117350592321538, -1.6637619687796144, -0.8021042411804287, -1.9504418390229685, -2.1015219891720904, -0.025386172087590145, -2.2269055667222797, -3.692497171873936, -0.42878542310291295, 4.905999800859256},
    {3.15812962424233, 3.6942605643234168, -3.7161265217054864, -1.8870277514044447, -4.088180893565501, -4.131724886813507, 1.5911953983023692, -2.893164174063731, -3.973183160731398, 1.5701868272734008, -3.2681881926541236, -4.41746443166525, 1.0513077637835653, -4.524238955809256, -3.129686802285806, -4.418185037299068, -1.780710951813347, -3.3530971660533564, 4.357149574678571, 4.610134306595581, 0.8048060715236961, 3.0199509835334, 0.09130243333098766, -2.580592663828485, -1.6575383704598434, -1.9036669366021166, -1.69881834599056, -1.0308520113953943, -2.8470835153370704, -4.030247729404647, -0.0908580788492377, 4.0449411024327},
    {1.958481831114549, 3.7770045087361006, -4.560660247700515, -0.9016076611889399, -3.499103231359828, -4.485881915251997, 2.0141771033239033, -2.0799939863882813, -4.427397447401057, 1.97609078978063, -3.6309012913071634, -4.779462727224004, 1.8402479211820804, -3.1530851451678874, -1.8939730607513627, -3.7728391892921898, -2.0329658785157925, -2.4885911755475947, 4.190755473435014, 3.2214408210302037, 1.5152696651882136, 1.8280400376919943, -1.2619303917617042, -2.4697158980461262, 0.15132483531195065, -1.472650420720699, -1.7018830754546048, 0.08543760753085572, -4.009376351671478, -4.469729648878809, -1.1038529713791878, 2.8675060158481944},
    {0.9852711103506958, 0.5682614927194912, 0.740440673036677, 0.09225856053820021, -1.7872580056515355, 0.9305528959612178, -0.7690676781095064, 0.2351679480907877, -0.6702540541948804, -1.9900783893222216, -2.4483968283632773, -0.17050188392457277, -0.5500555061338915, -0.3225937601478268, 0.4352255958607933, -0.09952871528546324, -0.10254485480463855, -0.7323341868100642, -2.292157907358301, -2.6254978132652274, 1.7714243265783316, -2.8238499333803695, 0.3886240490414152, 0.6123423730047222, 1.2499549366960239, 1.2469302678627903, 0.9600383231943943, 1.0860095593565433, -0.8893510944970571, 0.8354064588895262, 0.07226936753776889, 0.10478689488455152},
    {1.064035925112266, 1.5247782722435028, -2.6574429614121926, -0.9794346085467772, -1.4884861052905998, -1.3989755981171244, 0.4623760384704822, -1.0420935325130503, -0.44541906059806785, 1.5308627695189327, -1.7494500523489407, -2.3388566024834643, 1.0082744789168467, -1.4476593220361305, 0.20160646590578318, -2.73400668184829, -0.27474841320016413, -0.7400268632744657, 2.9735160336318516, 2.429365661542109, 0.5374778606241656, 0.44918140804708234, -0.04148464726216297, -0.9272500633676172, 0.9964746187520832, -0.19239458897743414, -0.37757985515878295, 0.617202344398641, -1.8543588781199611, -3.320765924077042, -0.31025494353715344, 0.7845961398608599},
    {-0.04285569479631954, -0.02239626562459173, 1.7320287588455756, -2.152912909307381, -0.842544261341311, 1.0442689646653955, -2.755212299523633, -1.5552654704417654, -1.4665356984812428, -3.1496040068954283, -1.8008196706063098, 1.2776928165009862, -0.3931381433732675, -1.1726821952210313, -0.9176961339982129, 1.0105771009562705, -2.2841751985454852, -1.0316737063844483, 1.092185362727766, -0.2334677144579173, -2.182276896385348, -1.8576113007610944, 1.073080094472042, -2.291947917337705, -0.9580253781752955, 0.329679133022672, -0.526772788037386, -3.2139244890023244, 0.056439863290938995, -1.1941439938629126, -2.635412742417333, 0.561156966383814},
    {-2.159844901963238, -2.2540471599268885, 0.12428393370585618, -2.309387156323092, -0.3951802643863694, -1.5422739376092556, -2.9758813012053484, -0.8063866181016306, -1.7613102823176006, -1.1319184404937412, -2.4997320011186024, -0.5566287109826218, -1.3351482128948249, -0.06561592297614743, -1.4429316037110886, 0.8665678020455906, -1.7321858424305998, -0.4612386756980082, -1.3537207649529346, -1.2055145452094045, -1.5222726368448363, -0.4410577831354599, -0.22502397484401485, -2.129240409663763, -0.9435891214938165, -1.6644728292156037, -1.0440459591160762, -2.718127118257849, -1.152020562380046, -1.187263778250681, -2.5379105617655875, 0.08624970360818814},
    {-0.28978420838508007, 0.10595559191357962, -0.1625790154600927, -2.6080421934692395, -2.027792228528685, -3.348816261323519, -0.08385236363605028, -2.472874739509203, -3.4296882289403072, -1.0374203202594339, -1.5139014758261844, -3.044242636278229, -0.3798068988648198, -2.829284455219822, -1.9897551965604339, -1.165007522114222, -0.9980666524916497, -2.2476021142144, -0.7402632039700655, -0.7608359638278659, -1.679277225838413, -0.6406298333784027, -1.139236460663166, -2.7747442452846767, -2.8444558658568297, -1.9055776785909009, -1.1641552422023025, -1.8866945971570384, -1.163813560934934, -3.2243904461984325, -2.916227595254361, 0.2593122060037332},
    {0.40681204664820714, -0.30454663447823854, -0.5852317116951666, -1.180588560757662, -1.871769522364729, -1.7161467077600425, -1.2542876247497514, -2.630210667385376, -1.9543298635227626, -0.9254092731119417, -1.7913383006273838, -2.43272393943344, -0.6078543347864985, -1.4483944016450363, -1.5907308729051244, -1.4957044434915583, -0.6503733567061503, -1.4249138934677719, -0.18729587612740084, 0.7069766259834482, -0.6489492444301552, -1.7562512667470485, -0.5611603927275131, -1.5694792104690103, -0.908023203459218, -0.28297516462282174, -3.1321690730653895, -1.6548774599927996, -0.8430146914868215, -2.0033062215809645, -2.9914604131055733, 1.069272730874694},
    {0.48219096490305613, 0.07977891011057538, -0.49017202980629615, -2.582482865451732, -1.6093151443438642, -3.1247683548084106, -2.2488400667068236, -3.2114773309730418, -1.2044507509075588, -0.9234217996926888, -3.6183350097625278, -2.469708708851731, -2.2315425876735664, -2.4521376786111495, -2.2735897811145205, -0.8847862593332531, -2.649898621614879, -3.04356192250008, -0.21984028442153117, -0.9674490130792587, -0.2004698806082885, -1.0281757936354308, -1.8234339860144348, -3.502569022144206, -1.8851677859060576, -0.9752786619600095, -1.8331518199688388, -2.1496178226763685, -2.485111919551892, -2.84336518011904, -2.5281271718655867, 1.1836207341767455},
    {-0.16643489862689181, 1.2954015566591932, -2.0438756151858346, -1.0412853691608193, -2.3783341542098824, -2.996633588929609, -1.7923092741153184, -1.7767568099063356, -0.9932069136339474, -2.257638506413858, -2.512344951984394, -2.3620636788490508, -1.655894228095656, -2.407884674775065, -2.9844477614753875, -1.9176259108228961, -0.5566093812529866, -0.3490194272298147, 1.363075464144476, 0.4132728459420192, -1.0876500820847745, -0.8445290293751124, -1.5334077942338875, -2.811194964968534, -1.3637638235550047, -0.5648875612757239, -2.8526317252319795, -1.7210686958317403, -2.8218454173410494, -1.1967306838393013, -1.6477834030923177, -0.5517358533293256},
    {-1.5107033594736032, 0.5733140734283957, -1.2456735182911933, -3.5254691981926958, -1.5005017788980486, -2.556296209650693, -0.9172527225955829, -3.3709351825623974, -0.3946857784591181, -1.8185455128404158, -1.7854814303051019, -2.961270122257155, -1.5682559642014504, -2.6702329302505037, -1.6850710752508549, -0.789219262866852, -1.8978406955466438, -1.0913499030625127, 0.9264035581790794, 0.6457434631903674, -2.1638517480717656, 0.47276336774357586, 0.1654987534301363, -3.1175170328378785, -1.9821673288160258, -2.423757553465592, -2.2281220211185064, -2.609945619705033, -3.2589339062235196, -1.4324450785573903, -3.21438913139978, 1.2592613992711947},
    {0.9205779547401766, 0.5456478043629253, -0.5591636060199419, -2.324851769543519, -1.3377755836906844, -1.3764802404476313, -1.2442382818199291, -2.78388374180034, -1.354738844430696, -2.764322871617001, -1.3024452308728256, -2.678407754401529, -1.2706936839550496, -2.695659827743576, -3.358850365459754, -1.6162621543070441, -1.1791922910230226, -3.4096367091450266, -0.48337414878708423, 1.3235503012653678, 0.17093839524221258, -0.6279084712696036, -0.5983582573180672, -2.629680622067502, -1.9911538815639986, -1.0774050742070038, -1.657607060571174, -1.5359375408553688, -3.3331539029175645, -3.0373592598524173, -2.4677219968228497, 1.085590343797491},
    {-1.258478677341861, -0.882522957363232, -0.38158283546950156, -2.5249633368489115, -2.2127003464949495, -1.9872929544916988, -2.933980426725394, -1.1028027204605433, -0.4188204691896751, -2.0600552780997488, -0.6854975981764664, -1.9516526671959311, -0.9166173844061004, -3.2897741930120636, -1.6385918390870666, -1.8654774035273476, -1.9571970027305885, -2.9054458625873756, -1.5034171678556028, 0.3148173044559768, -2.0219314374538064, -1.705940595289806, -1.6259848605160565, -2.356661823915335, -2.9195681588414217, -0.6679970760231011, -1.889744910023425, -1.3952314745451524, -3.06607700327954, -2.6526061666863083, -3.3289777911920395, -0.13244827064188308},
    {0.3781239396689824, 0.13612251404750034, -1.1303057600100685, -3.2354815508642543, -2.233150897965334, -2.915246480662125, -1.729198103371461, -1.491009709480171, -1.9770192641790172, -2.191824376193798, -2.172190015417941, -1.1659455537131223, -1.4875679476527, -1.763637473680189, -1.4593705475590553, -1.7920270044127262, -3.200808325482032, -3.1828146482685162, 0.28480248243666095, 0.48545828501153415, -1.711636679830977, -1.8773856504559008, -0.7934058028395828, -2.684580886946545, -3.289002477201883, -1.5335318215116374, -1.72307465585883, -2.239989521462813, -2.646732528243405, -2.438357071741286, -2.876141170660417, -0.5044664469883895},
    {-0.3602621091149351, -1.3309344305228266, -1.6460297227814038, -2.2486467340859093, -3.039477464527355, -2.178916249816884, -1.936617528040248, -3.2651602601384817, -0.737094945120619, -2.890841341019063, -3.060571121838239, -1.8487842755274153, -3.2579182814128655, -3.7973979337895076, -3.311477746617404, -2.9369174192861713, -3.5371051610601825, -4.15365469016694, -1.3880327068412581, -1.3590988565853772, -2.620341377522854, -1.143309889899561, -0.34918919716855357, -2.480074261352639, -3.636798711696386, -0.788021376960979, -1.97679359852038, -3.8069221347485724, -2.6026580762483746, -3.0204063021101097, -3.5066482621369723, -0.39179788761752216},
    {-1.869043489895744, -0.5519934867072321, -2.8151689832154476, -3.214047134162901, -3.7048522140424627, -1.8828841265430418, -2.736437649397504, -2.294066145571195, -3.6506642726599363, -1.8578078405881895, -3.2170334918037895, -3.109446539319479, -3.0170538946358736, -3.716976835623775, -1.9219113015202123, -3.274453352517654, -4.198988107179427, -2.934997381981369, 0.22802215852642338, -1.2194577993008442, -1.0809357881340693, -1.3876302076966023, -0.33819229038665366, -4.2240448020208765, -2.1395517179338674, -1.7974359864119835, -3.0882580804609305, -4.18954864923565, -3.760851953774589, -2.983293544653977, -2.470971071452548, -0.7044204670564851},
    {0.36458291005870347, 0.014878828388480406, -2.158285458801434, -3.9446109087240098, -3.185838512208348, -1.3006157909372382, -1.9110504235162231, -1.9394938573254379, -1.408699689194753, -1.867052189030725, -1.2568517465418436, -2.6720426698403807, -0.8495535019623855, -1.460293590751193, -2.603344664774482, -2.71837443555278, -2.485435554889331, -3.937610935476068, 1.239350286779858, 0.01182184805779035, -0.22272728966492916, -0.9975498302102351, 0.5769014590460941, -2.683718612089066, -1.4322422595419382, -0.16302376693098644, -2.9138883085815594, -1.883271880379581, -2.99686856944968, -2.579602384857642, -2.151174236329432, -0.3567669708618284},
    {-0.1041667968883923, 0.2897928930565458, -1.7885662357686263, -3.5506573580108003, -1.2804564406910146, -1.793706143136302, -1.6440432043234305, -3.2508565840457275, -2.2359343168516834, -2.6379296629349516, -1.0055358906403855, -2.32742325022979, -1.93672593950257, -1.2685441051811346, -2.821352507542857, -3.0357942077489346, -1.2831306335985428, -2.4092644812231883, 0.19542276594884253, -0.4706681539864534, -0.4149609165961183, -0.6912754063614712, 0.8729291570747109, -2.8922320960325183, -1.7325362083135376, -0.22377317172598732, -2.688080864844217, -3.817305213519781, -2.8298775781110836, -1.7191712505146153, -2.344876420721846, -0.5995804921597693},
    {-0.3098610790383665, 0.17470345272246593, -2.0148797380669365, -3.327745427431073, -2.2295220660977755, -1.9899111696240013, -2.9574830172556057, -3.602635797206784, -3.1717369301113894, -2.7297262050079834, -2.154856901347015, -1.678666784651734, -0.5755215659131302, -2.564740666138135, -2.1794063266642936, -0.840031607991694, -1.211261167070004, -1.1310392614147577, -0.6502060256268848, 0.42651301223285937, -1.9339164873034402, -0.6719335402265032, -0.36540695819895574, -2.322779474056801, -2.748545780132724, -1.2280729773613235, -2.28288332280299, -3.188122521859804, -2.9796297021853064, -1.07361186245888, -2.2315548132512495, 0.7122392329722038},
    {-0.30794196100397203, -0.5129167710507194, -1.9566617614142539, -1.7064970070912815, -0.5465824900626481, -1.4674994514154507, -0.34794120426042535, -1.5519437386374988, -2.9206421295242095, -1.7024832031311432, -1.6665989204649072, -0.2815423465418312, -0.05965659876592346, -1.1269548162081162, -2.3290358159633837, -1.996805771576216, 0.09788859830449513, -0.5511928244185366, 1.7148417774691445, 0.9869968866899359, -0.44702746358121664, 0.6083920695907883, -0.05136330965066138, -1.9898989455274905, -0.8005103708591481, -1.6408303396966633, -2.745936758725809, -2.236531741881004, -0.489010942895109, -0.5439259315681976, -2.0535138509096655, 1.5010275099892358},
    {0.8894413217754451, 0.2283631738165397, -0.6228253967677755, -2.3726451112904523, -2.2606794117149307, -2.8222662704617605, -1.7273955999949904, -2.2717556226843802, -1.6562834757838856, -3.52176266871019, -0.9039063183182343, -1.8935359322310268, -2.444160623117043, -0.5153459392263475, -1.5055779321909288, -2.422967475403959, -2.7544892052383636, -1.8862513667711456, 0.7310163001963982, -0.9811332714094871, -0.987175663974162, -1.6981288475535572, -0.3550512587573561, -2.453412703785438, -2.5917878907555045, -1.772869834363329, -2.8499966444506333, -1.8791771261615011, -1.6176892876464155, -1.2164061731439706, -3.417742469811766, -0.39018254885687254},
    {-0.2783370357966923, -0.7678856493346351, -0.9280600154798793, -3.598612551185062, -2.6402321245261047, -3.5614013704011835, -1.6474390718392276, -4.584013601380643, -3.239319751246631, -4.1256739586781865, -3.066256543483064, -3.91666604301526, -1.9461342847225211, -1.5266704501482042, -3.643503672011751, -1.8435589266439563, -2.4965706458288768, -4.022205006731023, 0.8513504542498685, -0.2099341463721767, -2.5389357352877164, -0.3275365825191425, -0.37152203922985133, -2.428494557873085, -2.544770118948177, -2.2661640389163993, -2.2448639769308567, -2.4420884290470743, -1.789841235788289, -2.3129264968305034, -4.235858988002598, 0.10004648662163809},
    {-1.2515927732005807, -0.6823038078917835, -3.199400417718618, -3.1645795691630543, -2.484627323171025, -2.958099218177714, -1.643228100655687, -4.106180900770037, -3.665321502921403, -3.5986109843292566, -2.532323341119307, -3.3611414099753207, -3.1403827949268543, -1.9624261763386257, -3.115109213389049, -2.1994703139364957, -2.9067094860446, -3.033178062956584, -0.8927684841771738, 0.04654789251177403, -2.2508254173127757, -1.1131417323605475, -1.44048500085074, -3.2777115209396, -2.88594410389704, -1.636683724503409, -3.796522847344365, -4.070979181620289, -3.2709413878513423, -2.6762431716422483, -3.474951983321556, -1.132254223275306},
    {2.0845838581112868, 1.1754698122499054, -1.377850924219228, -3.5300901609913744, -0.14001126643040088, -2.7322085283380027, -1.2622186387470773, -3.338975013100555, -1.322375090321824, -1.1354834985632307, -0.741803247928661, -1.863802191981012, 1.0558776170711024, -2.1124834726396453, -2.5065470895905815, -2.2966291941698227, 0.010224990173018235, -3.2594025739141763, 2.778006400952733, 1.3895021854953404, -1.0744562182538362, 0.00358441250641797, 1.3284363388988993, -3.2861234739518994, -1.5586479243736922, -1.9626937302128251, -1.876048393247014, -3.0420371227004566, -1.3539557824607487, -1.4549403047992264, -1.7846805232599077, 2.0562671373965866},
    {3.549652350439605, 1.5582177640384671, 0.36212532328575675, -3.5986389250068216, 0.2154998972647252, 0.19487353138400526, -0.6240808344803536, -2.231820349027192, -1.224965834548939, -2.5341289427067077, 1.52530094898891, 0.5971575284261287, 0.8400681252124916, 0.42632506681236215, -0.29362376002753066, -0.8957612394696829, 0.7401960350770291, -1.527554074829627, 2.9665656448159985, 2.731189091607789, -0.14621420365610605, 0.9621571709148495, 3.2711165827118482, -1.1747087184450185, -2.463838200416533, -0.8755173104321157, -0.37864023546334036, -2.5799409117714758, -0.06000475948696438, 0.03618626970953346, -2.7352477697321493, 0.9646330530955537},
    {1.3184938224394647, -0.2805991834055199, 0.07055930981505347, -2.9079412087229137, -1.280943348368843, -1.659195309864698, -2.274633946926491, -3.079645623448253, -2.5814966241019426, -3.396932936622516, -0.14117753966229582, -1.4188527117845062, -1.9802138365462962, -2.04274349359575, -2.267572658608031, -1.777168338978524, -1.9902834413252875, -3.1521526242625573, -0.3574236165010235, 0.00684552004724813, -2.0798288431074132, -0.3996445576914992, 0.397900439441424, -3.859500875522516, -2.7099348627326756, -1.2100224912754847, -2.915551187975047, -3.109840884587423, -1.6997719906488586, -0.540587367665548, -2.494193101558958, -0.41927495446049434},
    {0.5810929380174708, -0.2631071496719337, -0.6812099541988306, -2.8186438454618785, -2.1616989138934954, -2.1664866834218515, -1.4996875557284925, -3.3463975197277103, -2.4397958048894353, -3.506036130495872, -3.3961452945732113, -2.1126309164732415, -1.7780690144679345, -1.452406700673266, -2.9495423650197297, -3.538359608930115, -2.5071088539465927, -2.2933166920671515, -1.194283607940491, -0.24344539379698388, -2.144993160175575, -1.9969835603629544, 0.48668159916771037, -3.6949042531457175, -1.753135158678766, -0.5043484771733722, -2.4868164459209443, -3.8366422246778247, -3.2809486690485996, -2.9681741396459804, -3.679579173715171, 0.20054729368310834},
    {2.3587752863525835, -1.0431470656603727, -0.1462973361974807, -2.9136512064622577, 0.15004187213263867, -1.7579525890316203, -1.647650582955571, -3.441840973195006, -1.6328426030828018, -3.8001361768866144, -1.1712066508002499, -0.7996765033069956, -1.9401089838312822, -1.3259782550141084, -0.856729941662402, -0.6000357093552436, -0.9398243307917957, -1.969680058131515, 1.4151666351515735, -0.504301055992816, -1.0164137888545013, 0.14661093086424992, 2.523579382228532, -1.9278949113161234, -1.824912450495682, -0.12575021036680248, -2.286140264757289, -2.4515603231806433, -0.3569075261772828, 0.9717627929093222, -3.805429824969209, -0.3283429426577665},
    {1.9680773988636335, 0.4418422602105098, -0.011244018085495007, -2.0890169677800605, -2.5186541030080707, -2.351010761710025, -2.780132286706017, -2.270278038548498, -3.067627017777211, -3.9726662935007417, -1.843860003329001, -0.043718890622242296, -1.452789755656471, -2.465560240315762, -1.1693704079477303, -1.1716425321206347, -2.6231191473238393, -3.409165546931211, 1.804490009546519, 0.8983765178632706, -1.5741902241391086, -0.4513142302856866, 0.2652914485053354, -3.8427308038982066, -2.598565495634178, -0.9824674847962556, -1.9382471200072056, -2.657004249706054, -2.228412588488543, -0.47094963485044994, -3.656194937067804, 1.4218522659224935},
    {0.9697125979570671, 0.6144732050103898, -1.0865231213869648, -3.693099004656371, -2.8870778805754154, -3.059323179380854, -2.926322337861617, -2.3705947978891646, -3.0137338220518872, -4.256068005805517, -0.9952348055507099, -1.6121380364117692, -1.1647351446420282, -1.2389735929334673, -2.438096047209477, -1.3926601336254227, -2.019219412513641, -2.5171307811206067, 1.7025583761027603, -0.8193709239443822, -2.3226681832718414, -0.8757644647784556, 1.275846861973512, -4.528551612882555, -3.311096958380746, -0.8737460898638634, -3.376393917646671, -2.755064432642231, -1.642178310090624, -2.039858195011715, -4.081753583369363, -0.29725313413709886},
    {0.9930770448717581, 1.1578628109075824, 0.48232591869747216, -3.111912870957133, -1.3786286423079266, -1.3067541933998605, -1.1589164328878288, -2.559797414443493, -3.1589682911938333, -3.809503712724036, -0.383272995652284, 0.662514569021769, -0.46886787784170825, -1.1576839676326913, -1.9960961850735577, -0.36630405048213555, -2.5696984654323964, -2.603372586655743, 1.1997748202820213, 1.2985902902044835, -0.6523836214617071, -0.2360009558050198, 1.8815989800582054, -2.43159805290324, -1.795024894060164, -0.4146151783903709, -2.037339735958907, -2.716947182340429, -1.7721563330955554, -0.9367770674288625, -2.5590283724934784, 1.105349668910358},
    {2.611561622673308, 0.007132220160409429, -0.8375428295797176, -2.941699738942684, -1.3279010260536428, -1.8785634190849603, -2.649513737702306, -2.8575608196583384, -2.6650469923577784, -4.726697572814206, -1.8375924960972478, 0.37423916944277213, -1.640769738020073, -2.1423642815319384, -1.6682428750231528, -1.2538051565971753, -1.7218478421352594, -3.57985765373799, 0.9757343062905383, 1.1370393057869914, -1.1806065868226034, -1.2670600142639294, 2.2095091769197017, -3.6733720410392174, -2.630814003349326, 0.7949752967928398, -2.9647295592630254, -3.544280878254528, -0.8329593696959174, -0.7190582140646656, -3.13450592391426, 0.14690196451821882},
    {-2.516036004786462, -2.13806764405856, 1.1529870082591012, 1.356776157043484, 2.7909495633380943, -0.9413089930303437, -2.4277287180904144, 0.1478453023360108, 2.158265064624069, -0.37263557564028993, 1.3718074687141306, 1.6669919288851223, 1.4752190675880914, -0.7013933299136124, 1.854929155423259, 1.0540399317527687, 2.724263165991768, -0.150378178517027, -1.066644463824439, 1.656388123024066, -2.910054948155871, 1.8790197193532927, 0.31710535554812347, 0.27336664313558023, -0.059285414379283176, -1.5777556232589462, 0.8225462589648598, 0.30030359635080045, -2.0536406986696556, 1.3393160803358164, -0.25929585604805433, 0.21216094125139104},
    {-1.8234443792228088, -0.2637856770019996, 0.17538218244716985, 1.126638124250208, 1.7615943528491675, 0.7602328330514597, -0.8867374038708588, -0.04478215114459816, 2.2584856716358894, -0.8714861643587688, 2.69612007090905, 0.5596075328845622, 3.0977940046690526, -0.6407388029191456, 2.38489423502071, -0.5433382532447523, 2.3866046035802726, -0.7156509074125986, -1.3586373219465993, 1.0330159941367183, -2.874686443243071, 2.1499095677965374, 1.1273252798927202, 2.353060459912405, -1.99998897685603, -1.4924735658010337, 2.3219670395668772, 0.35581464525312206, -0.6989849312707327, 0.013865724606719195, 0.5025058126792428, -0.1823235801315331},
    {-0.7384174570737584, -2.1919470011953917, 2.1331407902958777, 0.8321520751335824, 1.3950804827479544, 0.15336166835594187, -2.8692207389187554, -0.7195445633016563, 1.8639109846640427, -1.2066714530814429, 1.774161006155137, 1.0358886741593392, 3.3018072684658213, 0.759584756516542, 3.339991205715877, 1.2099947494876626, 3.00370722059776, -0.2035543588382662, -2.1997323330447864, 1.2298696450394593, -3.649629457921139, 1.7546220581867664, 3.8174677573160505, 1.4550600626081578, -1.610731437155377, -1.7572451166130567, 2.433649716965253, -0.6164058448492276, -1.5353255486650133, 0.13758115463475243, -0.4322873230194469, -2.1165568981309084},
    {-1.2019016615553189, -1.127711736537133, 1.2396433787976655, 0.1263023056602073, 2.095651968097305, 0.11561490822329987, -1.014155510217122, -1.5523520271307734, 2.3659627140912285, 0.6224178060459402, 1.940316558696028, 2.6074877679525343, 2.963879136858195, -0.9952133393061795, 3.0236438316405385, 0.08452248686283151, 1.9409297766569715, 1.8623816544099907, 0.23605245739008981, 0.254237579004117, -2.450079122601773, 2.7384992637725554, 2.6991844793394075, 1.9310352393655057, -2.0340060899543975, -2.9572948826478664, 1.4664186676411133, -1.551067974576537, 0.3117247082203797, 2.0168549177331028, 0.775558582679857, -1.0784094083678568},
    {-0.6137080225502494, -2.31523686793922, 2.006342047997694, 0.5694059252892849, 0.3225804669495559, -1.31857860708599, -0.542388287897862, -1.6627586574803506, -0.08210673184769303, -0.345293798330752, 1.5541702701903564, 2.1164709832050086, 3.035320149977588, -0.689654105572177, 1.8681461078907857, -0.48072574693800757, 0.3330647110378082, 1.0323379252475695, -0.41548967542433646, -0.3350436769241745, -1.6955534739394849, 2.0905018492683336, 1.3755883862959584, 0.4324241031691271, -2.6205669402799425, -2.2356514064641115, 1.2268583333362397, -1.5779482352454839, -0.2923675208321868, 0.45160477874140204, -0.2558297476316464, -1.3364500704413294},
    {-2.7437383389938863, -3.087065326378518, 1.8022800207612715, 0.1113996303248889, 1.9975676548452004, -0.20608842901607405, -1.322662388246091, -0.5717581678039397, 1.5109924406683686, -1.9949090434897385, 2.476175940567667, 1.7153989849677913, 2.7470094621973717, -1.1383361237472773, 1.9069936790190352, -0.4446734928703631, 0.8223435668440459, 1.350826774769346, -2.6339193502955616, 0.587283614704502, -2.4916303141352247, 1.8701973845991358, 3.4004987802730215, 1.1019470522009556, -2.729030965875965, -1.4042340555948654, 1.1831156698781655, -1.2813768934124352, -1.998043998269301, 2.1240142413660617, -1.1699473135274614, -2.025145868984073},
    {-1.9663637147217552, -2.161616402056465, 0.8515100490812169, -0.6123034541641489, 0.9326888535413032, 0.08282894528257569, -2.6688602746444485, -1.7517695713666774, 1.4785370029322902, -2.2312511252946408, 1.334828140094626, 0.9366026459845297, 2.0150174507943537, -0.930998521879544, 2.7696058929388605, -1.0966435521149194, 0.6195292748624933, 0.8122355228055418, -2.413321849725153, -0.6871415628565543, -3.116001737882308, 2.2603290106632494, 3.100061391542475, 1.7532765652522293, -3.1483062930172045, -3.5679088043476095, 0.013718898734752471, -1.9706197747408956, -1.1633518349133347, 1.953127599558665, -0.5215201668170972, -2.8255702813770456},
    {-2.801272512679878, -2.857434238755399, 0.26228525746945003, 0.6893692912743841, 2.8774719258812222, 0.6470570505136459, -0.8489592083703333, -1.5081664759965434, 2.7690931887077874, -0.7069288961360108, 3.372498314453597, 2.521541646806633, 1.9053776307268675, -0.7588355683746109, 1.1420880544759242, 1.323233908686619, 1.4708752313117168, 1.3487410360690402, -0.6635901014294079, 1.136606552378654, -3.4475391441127496, 1.3847844196686752, 2.9814595114659284, 0.03774891562183506, -1.207845870733648, -3.066961643731819, 1.9280983111661378, -1.2079680792768055, -2.172580850654645, 0.7625850246477146, 0.7413143559516571, -2.7825514937156903},
    {-0.6840487675680285, -1.7812418020989516, 1.5698872149606469, -0.12219743646360152, 1.4730910639861823, -0.9485556318209869, -1.704228200762145, -1.0170564948639156, 1.8808446920370194, -1.4380157844915218, 2.9119119328483514, 1.6916332932924727, 3.3401630721037034, -1.671837749724056, 1.5537222303096947, 0.1708078085089628, 2.8984350864342163, 0.2648525262475326, -1.1596531546370867, 0.13565745260030132, -3.5091382128880024, 0.7912931866824171, 2.9853678429750508, 0.6195629680882994, -1.9536134836621362, -1.9845027483486322, 2.213910680623598, -2.3101759297564426, -0.6330680017153252, -0.18810790485447249, 0.6124993427485046, -1.2541861415383797},
    {-2.4394398772198276, -1.9679321901331828, 1.6611067905178751, -0.4764895331534544, 2.8495411053545316, -1.1461191088191713, -3.0555699100666316, -0.20980110947729022, 1.6977020899987383, 0.3465151263858727, 2.4270096285058, 1.937577815621285, 3.2359518452869485, -2.00742750827471, 2.695714704028695, 0.16673063607464633, 3.0300695090091705, -0.32873938130267694, -1.626201650926433, -0.12171995046212483, -3.8413349919168147, 1.8743175284160676, 2.139721367251489, 1.3768441947857628, -1.9675223692538921, -3.392392204698445, 0.8339737811977856, -0.3665591203146321, -1.7873433413192348, 1.9399626130945273, 1.1776911809536144, -1.9086451995980762},
    {-1.5709261422014198, -3.3273112711464914, 0.9835260662899864, 1.0894630012229893, 3.210381171315256, -1.3388998614484144, -2.1446077315773704, 0.15457742477342337, 1.450397404395625, -1.386563188009269, 1.7968590322854454, 0.4831678801889345, 3.6286129441220965, -0.33477296825143793, 2.5698972881898783, 0.3623424788777815, 2.419518606080681, 1.4968750689863548, -2.5700648880829537, -0.38494420856047296, -3.55748708101382, 1.6975712792281301, 3.6080053377973496, -0.29043430508422047, -0.4989700534356827, -3.2067620543455164, 1.4974950439306476, -2.1785112007771623, -1.9692287897519827, 1.7639018488621216, 1.7911200834996541, -0.9336215985318914},
    {-0.5334832156791228, -2.393929948433009, 1.011501730299263, 1.3854725440354645, 3.5815233602034207, 0.714672700872904, -2.344054895113295, -2.036241465945628, 2.0473404335628826, -0.34628024898858756, 3.863693372565256, 2.633855077813104, 3.899274103688906, -1.9768173236351534, 2.342756285705976, 1.54399664020244, 3.579508566763501, 1.2399858554922087, -2.6236092533169852, 0.9894556678148246, -4.125757744745538, 2.915279285034714, 3.522117174070015, 0.745335262394095, -1.4503239005074196, -3.1768384177508575, 2.9658079641269266, -1.3527296408873042, -1.5708649649088948, 2.0875964827937077, 2.1976798191192666, -1.2077964871741318},
    {-1.223279737657776, -3.1287423226237085, 0.7409096442115349, -0.20273703836187038, 3.54810018630306, -1.0264080005502412, -1.274482853356194, -1.1414494218910107, 3.2592751644274047, 0.44752979753017547, 3.657522108685037, 2.635616980181763, 3.304731271256818, -2.1827192312106973, 3.4789738618712933, 0.6809361599204339, 1.9858315831820208, 1.114278852914997, -2.9477109997297672, 0.47606111420383346, -3.7772552889290316, 1.2742918971712678, 3.158939082316597, 2.10791430054099, -2.0043246535011923, -2.3194937376898688, 1.176762316878792, -1.215683799838038, -2.2612099766689133, 2.67234458374464, 1.2875962302100106, -0.7988642784428639},
    {-0.21678170818588666, -3.073531145515447, 1.6112553823173439, 0.26072681472394454, 2.1104736092903678, -1.4211312434108634, -2.517842991845888, -1.318943807193446, 1.2281579490651708, -0.4942853477349733, 1.7172051691020882, 1.6895090478990176, 2.8859574928179796, -1.6207158982094712, 2.3345552285682305, 0.02733028438579998, 2.137212000595287, 1.0738324154006973, -3.023667907498049, 0.21422927232023453, -2.8965139636198214, 2.807801222976925, 3.181406693926784, 0.16346045573336745, -1.7605085282805069, -1.5687745672865865, 0.4979816596153526, -0.8488725423862786, -1.4218666609265669, 1.041161469559479, 0.824524986312864, -2.362865793424028},
    {-2.015141543185042, -1.4783371039059268, 0.8943047980236956, 1.364988813079018, 2.799124990111522, 0.002213245349154316, -2.2831407568305204, -1.2416452612218343, 1.6429275191840806, -0.7772197155392725, 2.814021535019, 0.71963553924749, 2.423467926239239, -0.5017668475384909, 2.3790185639454715, -1.0205417482951402, 1.2750174817607536, 0.980617933106645, -0.934372281892226, 1.3116754320062451, -3.5202433955861787, 2.9942589699816358, 3.5839120909764093, 1.4802227324293564, -1.5321638381518898, -2.648641029414852, 1.7797592915303704, -1.8659927084488217, -0.12680165559756928, 1.4878728079678918, 1.0742542928802579, -2.984374400675139},
    {-1.6949727730828497, -3.11859490501466, 1.647712606784959, 1.207906240135323, 3.138041405804627, -1.5546530235616032, -1.791204511290928, -2.162477152279768, 0.9069319505857487, 0.87358236043946, 3.2120621229861426, 2.5222429742813985, 3.427285654221865, -0.8573651492816671, 2.8881051305680785, -0.7040685143153427, 1.5733486925532285, 0.9599037686096377, -0.03690609496404473, 0.8549105865030447, -3.820083861551559, 3.098289620758139, 2.97701507868614, 1.0281999608964705, -0.7200885925283692, -1.4548085335534806, 1.6818243917307867, -2.2477845118747326, -1.1579625109545117, 1.2433034335267097, 2.04341521343766, -2.0665921408923262},
    {-2.257430823609442, -0.9099602154165172, 1.3090142685156365, 0.942347575728257, 3.8697367328440784, -0.22219841685310662, -1.4919877852613475, -2.366646399855191, 1.6285286028932093, -0.06722994612134729, 3.902964972519717, 2.5608380608018972, 4.284813043711761, -1.1849584944242602, 1.779850953480216, 0.8824258640240848, 3.5019854645514186, -4.337488642907088e-06, -0.9513711341246662, 1.7699419724118972, -2.1430020815530866, 2.5547870663884775, 4.3394722941879165, 0.13414101123332337, -1.8678070148082753, -2.7759131017428147, 0.7835354673348599, -2.0681453481870626, -0.90842846795234, 0.452589239077491, 1.2957515193458269, -0.7417857978655363},
    {-2.5176482162020632, -2.093586770122124, 1.2936984351911545, 1.361589225070792, 3.7457145939070418, -1.747372810453891, -3.2154484433750175, -2.3251884468867945, 0.8090477173773175, 0.5282685465374768, 3.934661325007221, 1.5939221819969756, 2.6535200028188317, -0.07928820351910977, 3.0660155729695693, 0.9458751300946523, 3.0052407692557472, -0.37849740764581624, -2.4884474261374128, 1.2208555952170423, -2.820422067205206, 3.2238073965195397, 2.7453424552130787, 1.6432018202899972, -2.0466271541668584, -2.740113925414417, 1.0352407769448992, -2.619355243219643, -2.034284867969156, 0.6339903453493977, 2.425474553449422, -0.9401172391532162},
    {-1.9396756511426836, -1.6628913698700571, 1.8986526557753527, 1.438554331901672, 2.9448359979327194, -1.1944246619290937, -2.0798286478356895, -0.7903433930662668, 2.7790706430551055, -0.7226365089189627, 3.277552851957731, 2.904712581159906, 2.5219666564304504, -1.6040329885117866, 3.2952053158687105, -0.516216059567785, 3.715200125155592, 1.277840056770245, -2.569990172933127, 1.3279859135886236, -2.8614400455159266, 2.974639515207686, 3.3701561625859213, 1.2402127857672147, -2.885478670083783, -2.799988145377697, 1.1218362998943612, -2.8316627150097364, -2.219759869348741, 0.4214837298362199, 0.3578120046335568, -2.938458819680702},
    {-1.1729060081654732, -1.562083304923429, 0.47345521108343647, 0.40089019951864513, 3.53873073139598, -0.6602854483504177, -0.8230872297822804, -0.5788718276561541, 1.8066256878254163, 1.0155055293984612, 3.128242888051449, 1.6430203967237123, 2.7040138082378107, 0.5464531668046205, 3.408048175114806, 1.0539971017319028, 3.209708351932048, 0.2912486272645553, -1.6539083443750868, 0.9022016055880815, -2.1708861744749552, 2.70667840168314, 3.507194710883115, 0.48251204329039504, -1.231648813194382, -1.5872818801969757, 2.8790036241425825, -2.441960416042328, -0.9615964264852329, 2.340816162336254, 1.5904357422039728, -1.3661717079057178},
    {-1.2550414794186213, -1.6422386298525187, 0.9426545151284884, 1.932003830164657, 2.495989569918001, 0.7564099305523385, -1.2376431304211508, -0.36597525524964014, 0.9272983818714438, 0.9549147772850494, 3.3583252023026673, 2.6407338493117845, 2.502840818724986, -1.2184019651741702, 3.439909245669018, -0.3745514199161729, 3.920552607351181, -0.14285324856110984, -2.813952493403612, 1.2400771072439745, -3.539095382159866, 2.343558690502728, 2.730422667935912, 1.3953302584273704, -2.0370144810979856, -2.387021497963916, 1.888570611749742, -0.7347875911649265, -1.078178833494511, 0.35444567453229203, 1.7713857467030711, -2.8396629916960436},
    {-0.6309089893866852, -2.23647555441535, 1.7389783941286956, 1.1587403552437425, 3.995394289776184, -0.6780200339016046, -1.9896942463101845, -1.3464304607634592, 1.391159063702715, 0.4600814195654364, 4.070521086016048, 2.966738956288551, 2.5547754575402184, -1.0444532823461468, 2.0038044499877987, 1.2427229048679798, 4.082281337705777, 1.1457578745521426, -2.0466597944927334, 0.7544064287018185, -2.4186628820380616, 2.536831534497754, 4.228770358676472, 2.1108419515846615, -1.3908037254591705, -1.3605418004013048, 1.7118415665866527, -2.2995556408941726, -0.1512600982040925, 0.9823017942335469, 1.3761517232100122, -2.4503100940074165},
    {-1.2038233581171134, -3.3224729374765065, 1.6761264578623178, 1.5530588684526943, 3.5691804602790973, -0.9169368771894001, -2.5524045699003675, -0.919845093483363, 1.7338345727330486, -0.07496305621921148, 3.5712074624795265, 1.269121673941561, 2.8368142294427123, -0.5306214431488157, 2.9160138387226517, 0.13697385578398105, 2.433313631016013, 0.47248661939550174, -1.9433104630100835, 1.6188924741699777, -3.360574268084846, 2.4407996555970497, 3.3196757872769287, 0.9488501042062912, -2.000014677193593, -3.2356175550246458, 2.205280037462878, -0.6938371531156873, -1.3173296726561587, 1.7746052778905035, 2.5866996293408717, -1.9657423613496021},
    {-0.3491638867691764, -2.141118295460361, -0.14111328030241538, 0.3707698572758957, 4.118918336163847, -1.5560258492631707, -2.6580186008569053, 0.09230851575116245, 1.1274290537931837, 0.5956133537015217, 2.615364438309811, 1.0981991760045966, 3.1598165658358273, -0.6933927622319515, 3.511582589640991, 1.449368772948695, 2.790289879493337, 0.5223156467906502, -1.6601638639386354, 0.24913089368783417, -3.5434644999897196, 1.6351970311817159, 1.8208873369583327, 2.380838316630304, -2.622363494813165, -1.8458973706505526, 2.2515239067085497, -2.20872558777746, -1.9121288942145107, 1.3384433017524158, 2.627242970740958, -1.5023962156188668},
    {-1.722605139939952, -1.5665367723678307, -0.25941415921270194, 0.38888846042784236, 2.797164959360127, -0.16168666180332333, -1.2498091689625797, -2.339465817262451, 2.1530495671990892, -0.022882433492423377, 3.353810678021823, 2.7769701274292857, 3.3104868129670586, -2.149166125040876, 2.5636957055950678, 0.40247828196104807, 3.8066401117719053, 1.757073487130693, -2.142140750689155, 1.9864754529888649, -3.345382499741115, 2.935787371133601, 3.2948097549121433, 2.6698524652533036, -2.554763234436684, -3.040688046275545, 2.0307368571533266, -0.9111801154472758, -2.4286907820685695, 1.041686257886543, 0.6831036098688488, -0.8559167964527677},
    {-0.31381592256592594, -3.3615107963622766, 1.4330973365238089, 0.8141967042323874, 4.1462987060972845, -1.0566092173377022, -2.5510821076356507, -2.115381425400258, 2.985597834170245, 0.6660652677458906, 2.1799638874005454, 2.84962275711452, 3.4944595935016576, 0.1471518637807713, 2.267753120717417, -0.10282893460488239, 4.166532284710178, -0.11667454241048048, -2.048350404647152, 0.20681702152333886, -4.064095867379314, 2.357069700871612, 2.458594465425486, 1.205152260331335, -2.436007412377766, -2.6400041759304167, 2.232287788103909, -3.1845886778468193, -1.0231061319886523, 0.48106993723051533, 1.8379643231651495, -2.4790422298644916},
    {-0.9263858217610579, -3.751360855781395, 2.025335504655225, 0.38447333776673365, 3.9348122214738686, -1.2023236926916028, -3.3922484737023435, -1.1594366247626096, 3.5223472579478647, -0.0571975700557744, 4.221694685009887, 2.8684649026783613, 3.695457401651299, -1.9568265791793635, 3.1078316335914193, -0.6609562385230393, 2.8078403329698736, 0.010046597559147616, -1.3536665636013498, -0.1959915993154239, -4.448650793069918, 3.414765825840186, 2.182904089299077, 2.319604241893887, -1.5807872414188469, -1.9664491071770251, 3.101206767206794, -1.2192153869415772, -2.239114457882363, 1.0140907622236914, 2.173569640898079, -3.0896731020899018},
    {-1.5593058347391546, -3.505636346312776, 1.140671659506281, 0.7408283127936038, 2.5400518016978086, -0.7566836593613264, -2.4284289684820353, -2.173809901727328, 3.0008974374025406, 0.03402905896727019, 3.7725775419311587, 1.6677228784410325, 4.263517862014956, -0.10423796813801463, 3.6573444422542347, -0.49523759115465144, 4.228882458826737, 0.5732485859914622, -2.723834159929889, 1.8135422933858074, -3.038105325440745, 2.875241914285591, 1.7820927990610411, 1.6199807516784275, -1.5126103964066264, -2.881635837292863, 1.9735638714414359, -3.2748736429722314, -1.893548313050712, -0.05265375154008413, 2.1062707365708278, -2.793847519931604},
    {-0.46411421484475623, -3.3033659989641895, 0.16040192384671795, 0.732996371195549, 3.8446841035035533, -0.5605383565126951, -2.2040808885448433, -0.7922720532343811, 2.7640891972146653, -0.6465992268373355, 2.546639514457273, 2.836534604130485, 4.172649915212685, -1.1562349131980874, 1.8540548514177595, -0.3627806343432849, 3.954546327797933, -0.19001354964855127, -1.7495295003017697, 0.09876849749084461, -4.590003219668633, 1.6182449330106565, 3.3578173678928867, 0.6428444305291172, -2.328448218486351, -3.2695411085338546, 2.615224259896875, -2.344395860365566, -2.044685363111011, 2.0109142323077247, 1.834507414217758, -2.514386016835539},
    {-0.7552745093126574, -1.631261504734059, 0.09896082335976966, 1.9455076086032799, 3.2916008106855275, -0.11617317196660767, -3.1259016498914143, -1.239952403582427, 1.190998706250072, 0.8574411205978866, 2.906026769785655, 3.4334170457952546, 4.081793096989395, -1.0900677498403668, 2.250893258124822, 0.15992196043580936, 3.768190487968653, -0.050854267426508504, -0.825398211591641, 1.7420727624265242, -4.114881741863233, 2.997150376169316, 2.4926227248493986, 0.5869475814177554, -3.0650447335191706, -3.389136056682899, 3.2671470594679657, -2.0617917737302127, -2.1380561516611474, 0.5806225015825275, 1.5338829560872793, -2.774986025924952},
    {1.7387455185812966, -0.9707277816560766, 0.6452907877875435, -0.4493554623120873, -0.023808197525364404, 0.7302167294813116, -1.5147710801120984, -0.1968913127796786, 1.48669868046905, -3.553186523661228, -1.1489835291754091, 0.20132091521927614, -0.7937946543509119, 0.017695354279494365, 0.8127755881604858, -0.10661801386770307, -0.8689316110861174, -0.9966143256777046, -2.164906778749721, -1.6142422365261033, -1.1984527320089855, -2.762441339346278, -0.1427184125446717, 0.3958945056787191, 0.9201400702665951, 1.6094101289331455, 0.4339037159161498, -0.09441737728915706, 0.10893050440192682, 1.6618506032587097, -0.9109475823673151, -0.11560995942803294},
    {0.8388706566983671, 1.4368076731635258, 1.9782045871394467, 0.0052128853248861835, 1.1872420823981131, 1.289783464122982, -0.002777844339202785, -1.3911424724696948, -0.07508868728472241, 0.8061939404765036, -0.012111761858256673, 0.15957874393184973, 1.3158251477007321, 1.5300141810248125, 0.23284483138791778, 0.3609399542896877, 1.1850887077513907, -0.47258011124385735, 1.659362168688083, 0.9135300454625367, -1.2087304185535566, -0.1176051213552705, -0.027372581786870895, 1.1497835472211468, -0.3329968637359657, 0.8547640718044967, -0.025857732741159704, -1.5078348666128212, 0.8503836553204084, -0.2954144601224166, -0.9599950796100815, -0.1389167305318948},
    {-0.03808673394878143, 0.9205575519826078, 1.570788121416821, -1.4342257077938663, -1.8011884325128054, -0.4483763108972667, -1.7476298865659703, -2.3542555603168673, -0.3092901517673195, -3.0355151910874882, -2.093157306551613, 0.5611897074663507, -2.018264159198617, -1.0496504071834045, -0.8314583461783479, -0.7507286896555867, -2.948622544856407, -2.8994408977724935, -0.7027326988932119, 0.19924317214997345, -1.2849955038324943, -1.4719724962014027, 0.023913626189954462, -3.010494674424359, -0.6636332061137178, 0.11265748159505762, -1.0045224033503075, -2.1594598452306553, -1.5769537573230312, -1.5269489649939936, -3.769477826759214, 0.18696633707540006},
    {-0.6600814011211175, -0.37538215566925187, 0.49127562538019875, -0.5707022560390748, -1.3694481263858775, 0.5083822767575005, -2.1531196348604285, -0.03500495388567681, -1.96843126886101, -1.6347688957801494, -1.2516815401515162, 0.27679154400509576, -0.9681025613823258, 0.8119182408883199, -0.9924761080161182, 1.090544108428815, -1.4980438700868568, -0.04122264931326768, -0.29746571496135027, -1.6494864059720302, -1.182576444396659, -1.131327650586122, 0.9555390642043, -2.595956154869363, -2.0703017375592254, -0.26324046456119066, -1.4323938573024784, -2.2511950415419366, -1.618965092522434, 0.019914721411412005, -2.8454362253675707, -0.7028789235759896},
    {-0.40958742000954745, 1.1777519008317139, 0.5642063577308873, -1.1955459399791974, -0.7884283098013618, -1.5578330428716223, -1.0856759689026856, -2.7102401178585764, -3.088973118654327, -2.3310784985276833, -0.8592218617420807, -1.3821490743919609, 0.8076227633176873, -1.8804563351458539, -1.085794877700925, -1.2169351931651275, -1.348811478117332, -1.518209630724811, -0.11065528847004497, -0.142603229923748, 0.10354291976037565, -0.43414666447925976, 1.6212097841283588, -1.4120358922875498, -1.4284940630202319, -0.35507381567055685, -0.7675106215408372, -2.8824797798376522, -0.812954644711245, -1.1211266242450204, -3.083140124353659, 0.6150078537129889},
    {0.9940041716189522, 0.14287032396763077, 0.032805419684026296, -1.699429452723219, -0.1173832966255255, -2.0977998888831046, 0.34176387958553267, -1.0509155170712146, -0.8462226888688854, -0.5474955304885754, -0.7739511499001052, -1.7648308684044771, -0.08421525577942837, -1.204253586392904, -1.4354664814358373, -1.1868894345119145, 0.23958696599071308, -1.1772963745583396, 0.21465877710137382, 0.9563413877666307, -0.5703002032658336, -0.3838487309377809, -0.985083534742294, -2.5045848100820467, -0.5700519462879233, 1.0230082648831504, -2.2990021183111127, 0.15366979882076726, 0.325276372712463, -1.5560945502521746, -2.267435879860706, 0.710264781928513},
    {0.4032587857050331, 1.0282642217252167, -0.83944094588691, -2.1236911495432373, -0.8825116668609849, -1.9152735660858236, -1.4850120764967099, -0.7598724863962216, -0.18435820557915877, -2.566382153116102, -2.7534691589124547, -0.8933177207966297, -1.650105740217026, -0.8160336589786945, -1.6383286151059713, -0.7060837511503427, -0.3909317390459265, -0.558073285075275, 0.02010202127509353, -0.6268503950263531, -1.4352084078923644, -2.110719111707171, -1.79752761900455, -2.850519162765179, -0.5406024300207942, -1.5792315268326935, -0.7137788370781989, -2.4625645258430966, -0.8597294715127847, -0.8893165499804502, -2.220578373297532, 0.03443744404300529},
    {-0.4850397301198289, 1.3170194507153807, -1.3824638915406764, -2.1352256107173258, -0.5145537400496986, -2.0341572835265693, -0.2543053848958759, -2.016199315910449, -0.1763234894331167, -2.0176209452395892, -0.7015750317157001, -0.17423146963724453, -2.3185694624199384, -1.2079515250634045, -2.3808856844905395, -1.1141469411024207, -0.46596035895959675, -0.3046683357496185, 1.604522275869555, -0.9408125692503371, -0.7424840415411224, -0.2183095711908548, -0.3460608624843511, -2.2834660934793374, 0.2280326667225536, -1.5372431841848035, -1.1315281282248424, -2.3415255919161484, -0.6412775967433825, 0.037424832078518516, -1.3634610669235008, 1.2311535170463104},
    {-1.307046171260797, 0.8808807867360106, 0.12557505787424642, -2.0593590221192897, 0.2348042337562907, -2.4712699977431685, -1.4638852980153947, -1.4822834098437334, 0.14435585864331205, -1.8452038254277685, -2.0042511086416206, -1.0440100280284685, -1.3499424119461298, -1.8123765795668323, -0.6265513711728043, -0.1962385862158529, -1.350610441313644, -1.2985813797758983, 1.5652976309208366, 0.9843282252462817, -0.9460231070395889, -0.3087373777700765, 0.6931992461065467, -2.370621550203997, -0.5317452654271596, -1.180522318880099, -0.8121235674088116, -2.903159809173818, -2.523893130114946, -0.8816797781037642, -1.7044955129770611, 1.5571740069467486},
    {0.633033904126068, -0.14389976718636924, -1.0762018921921486, -1.9645048511693306, -1.0035735483931019, -1.0152527815950458, -1.6238613787533687, -1.464280578012768, -1.4882191634241118, -2.4774784353776953, -2.1934016023446823, -0.49289609028435477, -1.4715223994189086, -2.7849024520861194, -2.492064443312193, -0.2824061440052213, -0.754300220375216, -2.7396928637558204, 1.8785697134284693, 0.16398793644636825, 0.8159868930638962, 0.37424585415201683, 1.5794177687311302, -1.4150873877637162, -0.5646241912946798, -0.0075795251394232535, -1.9242758099760662, -1.26539448152994, -2.885906282906082, -2.092543765797615, -2.651618432385869, 1.6107090096699295},
    {0.6934268418919525, -0.7135448644852765, -0.6161424069157452, -1.166368802500617, -0.46416301946461863, -0.541681993531123, -0.6573731878764977, -0.5482174642892369, 0.8094183262955775, -1.392042093525191, -1.0324621992350331, -1.3531981763571463, -0.9258398281636557, -1.9128581830819587, -2.07920001408117, -0.06363656666546053, -1.8552122482411664, -1.4698140965617748, -0.44138195247355366, -0.15021600747057717, -0.03910921130107802, -1.1188095699311267, -0.11580458953318913, -1.3310572732445531, -2.006558453613985, -2.0235519845636687, -0.7611528830547447, -0.9353079145878317, -1.8654464352496798, -1.9116179222665537, -2.0242097556088328, -1.2406774747771105},
    {-0.27393771908352427, -0.13624977038337518, -0.09847364325632445, -2.335287223500009, -1.643959756383965, -0.014498110165219355, -0.24314641409254942, -0.40033502820058925, 0.8064687689499327, -2.840641978354468, -0.7433566701047334, -0.25264473443468727, -1.7714991619037237, -1.385670541523447, -0.24323996174547222, 0.09307798394040637, -0.6314236436686932, -1.6247734152835118, -1.3576871683233396, -0.9579584246295642, -1.4216053480348085, -1.3891785769537364, -0.07166874217339123, -2.244121984541562, -1.7760509823093942, -1.5773914633257737, -2.114416729512778, -2.4219567564885107, -1.3861720079491715, -0.47010396833985807, -1.8237134951546836, 0.8945138756793884},
    {-1.1179389236188104, 0.3022087577570303, -1.6281758812479938, -3.191328437068893, -0.7919677969015603, -1.6466198683095696, -2.2998536014040396, -0.943474654490898, -0.3092138619363773, -2.4911412478707637, -2.721955829785183, -0.9624858480764122, -1.501133085467638, -1.178955534419221, -1.144165295459029, -2.0498360063976855, -1.7550647415719984, -2.0085902100498396, -1.190383235509268, -1.4238636675378458, -1.4271778402529134, -0.8562579398487702, -1.10817897576335, -1.7936206119051628, -1.9497604461966211, -0.19110575084181972, -1.845796143298573, -2.7806049196228315, -2.4481403706304623, -1.123977384762982, -1.9152867070260293, -1.2727829701493836},
    {0.6172395633172795, 0.30702138596902734, -0.6140125580896407, -2.512376134030962, -2.3044410166683003, -0.4678440519941571, -1.2687867680671692, -2.5547005547094908, -1.0411863052899868, -2.2840391261466246, -1.941144502983178, -1.8815865136236456, -1.2001355519310066, -1.5988118307515402, -2.288999819432153, -1.0532518495323544, -2.8625859134909524, -1.524789914164611, -1.065545557384815, -1.195496128355224, -1.0317361987166902, -0.47687834192864687, -0.0826035101671707, -1.6502764737575957, -1.2631108586030144, -0.8863546540636895, -1.5670102103360848, -3.4072441167010656, -2.755590296767429, -1.587593770789133, -1.4024972308478776, -0.3441877960640856},
    {1.6769802678633219, 1.221438798477112, -0.8209821767147596, -3.4231155435377447, -1.3956685687597912, -0.8503312819754076, -0.7467976812303727, -1.4194582682226764, -0.20022120002398094, -2.621815057333811, -1.614397428213773, 0.038812557147076245, -1.5158031128355816, -1.2274450826322483, -0.890946458236837, -1.9717616734668117, -0.8252474552820541, -2.990366337963525, 1.4836780051614633, 1.269347227369689, 0.7506096257699477, -0.917215225746752, 1.0411051243024567, -2.1794029723684694, -2.1355295221252146, -0.63232482382794, -3.21344761961681, -1.8528418895963599, -1.893615421581129, -0.7201820157894043, -1.1958665959231216, 1.6060895878093522},
    {-0.4206233138325164, -0.4798277974698758, 0.8752759272837416, -2.491836226406086, -1.2790799852627461, -1.1038640837803793, -1.1256431843916868, -1.0973992080734487, -1.7697796150243343, -1.7203372603746807, -0.12727764610370185, -1.1629090160077997, -1.604262670891707, -0.461340915798973, -0.9323567021989253, -1.2628068972512452, -2.18882174605438, -2.5443642764138885, 0.7036511996861219, -0.3192722183889438, -2.0049482681528152, 0.10748334420110368, 0.023539999037192123, -1.97739582430625, -1.3618145281342768, -0.22897873664280233, -1.2367020708801273, -2.831817514178645, -1.4065406855816265, 0.021080533833748274, -2.8893320224209966, 0.2710929232538939},
    {0.9979761563056081, 0.08303281606107114, -0.026422874031279037, -3.4547411645476904, -0.045075667748960636, -2.3000415133223493, -2.791424236626222, -1.4246114020053218, -2.2565549276438737, -3.699923719570882, -0.8787194922584612, -0.12216360918073361, -1.7699840195622545, -1.6844676736575288, -2.213099990847317, 0.48702605191709003, -1.6233924293811466, -0.5041711454181933, 1.2805360449514893, -0.49090420643448607, -0.8177121919594831, -0.14313408519978665, 0.859195426964953, -2.52434815888825, -2.9409063819805255, -0.9916235955127723, -2.318410311286545, -2.3107180866488792, -0.42295337306031394, -1.1455603845714795, -2.635549912431866, 0.8811815920495989},
    {0.5564953613584678, -0.4851962123377061, 1.2288164060151987, -2.2231828691761364, -0.49123360109288183, -0.8539251644451366, -1.4744087754048152, -2.3770276473379335, -1.0648979857067227, -3.855738632424359, -1.266553568992518, -0.29665590005426995, -1.270082326602154, 0.31526916322517146, -2.0899300999208186, 0.47099354245454866, -1.1322309989557793, -0.9456808839055413, 1.4628792525181722, -0.03222402099823858, -1.911049957140721, -0.9279948642718006, 2.4843738659500736, -3.161829043964437, -1.428361148795384, 0.12057310134913354, -1.8781553518013698, -3.108185303252299, 0.39741339642624707, 1.055272531311214, -2.170259047549486, 0.41861435281026593},
    {0.5129702731568437, -0.0831151617522675, 1.4209947059335346, -2.435787233896417, 0.01651032932859803, -1.2006741113841055, -2.330434482389826, -2.087468521776302, -0.0458616796711201, -2.5586815857564744, -0.13943007991323933, 1.1124851143602932, -2.3691698405837105, 0.31420662472531313, -1.1596740421420793, -1.444343195582199, -1.7276738820714712, -0.8047035243589495, 1.1022048552821628, -1.4915966340480649, -2.032152907500873, -1.2252610457423179, 1.1261197056911543, -1.672517034311383, -2.819431439222902, -0.9018958767959832, -0.8954117921742621, -3.192119414998529, -1.8183018228643382, 0.9988433013027914, -2.587828167970509, -1.0560815965938792},
    {1.0589775704048716, 0.4943973803849752, 0.05996263208511602, -2.738120521871583, -0.8709857350436988, -1.524088180181369, -2.4822013732239703, -3.714379313358133, -0.6157561457304378, -3.306256464232188, -0.7061654042427895, -0.6408570911607023, -1.3966153591340509, -0.6664031032501427, -1.078463479592788, -1.9125963970352717, -2.499769481210486, -2.832549564926672, 0.8408434685956578, -0.8997900582925914, -2.2954848348667376, -0.8635796654366077, 0.31630618601814525, -1.997867475892418, -1.4159862215637533, -1.4778977389099817, -0.9298962807265279, -1.8640831999783962, -2.5764514689106384, -1.6516465921328611, -3.884506417240723, 0.21129510509274713},
    {0.20339192681372478, 0.33935015115578715, -1.0354232884401111, -3.554477767338692, -0.5964367317500842, -1.0646547401033897, -2.420242293435215, -2.948075028886513, -1.8083601523959518, -3.4755167117641097, -0.5173730431182431, -0.028329895074530057, -1.2400582890945697, -0.2820417857333718, -2.42083510172576, -2.31030870899011, -2.474487853936076, -3.6195688547254945, -0.6294793694174852, 0.2509690837746597, -0.8095545973867447, -0.5352599449267573, -0.23486512051063588, -3.362500970837196, -2.1762481111597705, -1.8085858947446507, -2.014803257834568, -3.267511233400367, -1.791323577091131, -1.1953758885553893, -2.4939054228605784, 0.4228807707360902},
    {3.5562614977731695, 0.4565223902235804, 0.2112227653672077, -3.180892684128733, 1.1401675820748016, 0.1580218022096198, -1.2392633248858902, -3.7006461888960933, -0.9363079883449775, -3.7005664897544226, 1.2486171166414874, 2.116460939826207, -0.2489203234293878, 1.1706848486414145, -0.7775093404280544, 0.3568404202180601, -0.12644665498386443, -2.111384708409306, 1.1914625386548474, 0.6989815672825629, -0.17638072280765904, -0.3408510330560989, 1.4472224691534537, -3.8057065561955543, -1.3029184934746154, 0.6224860076885359, -1.6059441030742678, -3.806644733398433, 0.22898905372682632, 1.1297113864751676, -2.3017468165571913, 1.5825031898604869},
    {4.127461096838485, 0.13420203146625076, 1.8015037681556372, -2.534871247560004, 2.010141415696455, 2.319513290922173, -2.465812156016998, -3.0045831956198543, -1.4853536285497737, -3.913882328684215, 0.9142128749904964, 2.094389139169843, 0.21003146576308426, 1.8606456850899382, 0.9915088823233951, 1.8661060112228656, -0.690249824547108, -1.314443673197999, 1.170945757355733, 0.22931171741836473, -1.8669695279762755, -1.4507211103363145, 4.305569530230085, -1.7898877735116683, -1.9143851681460513, 0.6661373868785745, -0.3955630577217084, -4.254043521296031, 0.35544649088186264, 2.687897776086935, -2.2878977795245854, 0.9684459112580084},
    {2.815795188329233, -0.07514972161818156, 1.3669689861313512, -2.709135608283752, 0.8945334147602572, -0.317761968925506, -3.641907451340994, -3.843491687890313, -0.7825393713424071, -4.924850222508232, -0.32850171586606997, 0.4199660769833293, -1.7143478785194834, 0.5238761690115746, -0.44049022071056276, 1.2513841305780131, -2.284330103405868, -1.4971391316853468, 1.3233737996552246, 0.47855011936363795, -0.2451219209069142, -2.0183314648782047, 2.266759752547015, -2.8166975980062463, -1.7293448186317046, 0.15572115626879554, -0.7107546470792561, -3.3706771160316293, -0.8367432146354805, 0.4898212082432341, -4.1223361065623525, -0.1806187367332537},
    {1.9900914079786005, 0.17906737050743554, 1.0804607411805163, -3.2856986256034415, -1.1365902104129784, 0.15723673874534805, -1.8960532045361096, -2.6343040625572303, -1.5767688857105278, -4.18354353078405, -0.26910784913565344, 0.343078903183724, -2.083609553035072, -0.2824434078873315, -1.6535157013966708, -1.696141461452646, -1.9539135439063968, -2.109670796036354, 0.4451335070792381, -0.008241190672882103, -0.6428130431903734, -1.7599075962833786, 0.19690503380067972, -3.8561953351999283, -2.98757677029125, -1.0912970153389607, -1.7689340580933863, -2.923791278759625, -1.5891405279251238, 0.28863201246155484, -2.705251884004301, -1.0807684763023895},
    {3.090284886991209, -1.1653735713608682, 2.2237740251431113, -2.94822011532022, 0.9777534589860937, -0.4746254615915063, -3.8227247302407834, -1.8315922982109094, -1.2396767105657733, -4.644283482663444, 0.04945846435682796, 1.7124700483061142, -0.48550393001440156, 1.547396566068272, -0.4137829608404053, 0.41347261549964476, -0.5599608956060991, -2.247219889528996, -0.26638153303301754, -0.8274254941594064, -2.027622101412676, -0.37995463719589084, 1.7115410057987264, -2.1905143975583274, -3.123057857715093, 1.0237440946356873, -1.1904487287842453, -2.9308324106717225, -0.3145575678423428, 0.49388972345324816, -3.8027056933584285, -0.3106726558626348},
    {3.5543508124765575, -0.868380532953595, 2.575204977132271, -3.004454584502036, -0.025774484005702286, -0.40867324741871003, -1.5780966373020457, -2.685965511111505, -1.3841878904030485, -5.036684112529309, 0.15970197326864474, 1.2916957292979319, -0.38116202633140145, 0.1464398213936319, 0.23008062210693017, 1.7480525481209412, -2.1944559155920476, -2.3021072572195176, 0.8843987979474854, -0.7225979156337773, -1.5278309375056234, -1.30330197300084, 2.75096597416401, -3.179127261549054, -1.702932412385145, 0.03974313266253533, -2.4256225887955973, -3.140892067572748, -0.7733714157925782, 2.077589852490812, -3.340960520533814, 1.1654664354344264},
    {2.9497046275397847, 0.5410729803374745, 2.5060994513625157, -3.5292569304186023, 0.9100777549617355, 1.2929025932084033, -3.555195866879265, -2.3699081205095887, -2.1423237263229495, -4.721918816667312, 0.1731829267127438, 2.075271367912016, -2.1351912874585444, 0.10383731017902735, -0.5269017610592543, 1.1963248825687052, -2.069896272287619, -2.2688644578628545, 0.963713470649663, -1.1113288967746426, -0.7872140713482118, -1.059487851847546, 2.675986385412791, -1.9529103962628913, -2.0781187216071952, 0.6061392737274726, -2.6664587799019532, -4.067421253010917, -0.9556285676099404, 1.383776768207741, -2.916293059553691, 0.6241911212997042},
    {2.427655006870991, 0.3477620904435773, 2.668650531204539, -1.764696753666406, 0.9463152342554683, 1.5870550387255187, -3.481558563285647, -2.181749499358876, -1.2255128943745317, -4.738247508977313, -0.7830076487817788, 2.4736419132504652, -1.6545050256712375, 0.4692042971862011, -0.028469352283100765, 2.118060646487457, 0.12272282667808128, -1.5429300294717465, 0.32783043433217796, -0.5192977974966478, -0.04736827707552006, -1.275645275344626, 3.258782819752166, -3.163264824447382, -2.4340262737927425, 1.815254939707298, -0.8131255126320752, -2.965308558022484, -1.1543681588065275, 2.0764289640253293, -3.4075900846684277, 0.9120752296575143},
    {2.416515095180488, -0.4886828819303438, 1.5221524107575737, -3.0291498505343677, 1.4560284780696153, 1.5028957299097052, -3.396042634492901, -3.4043392930265144, -0.1137951765476943, -4.113558835776005, 1.4458298433661936, 2.930022148935385, -0.9235528613732431, 0.858722413549591, -0.48256885146181455, 1.539630516221168, -0.29262820884139423, -2.461832312778374, 1.2361286284567574, 0.1981198177020986, -1.3841252777558397, -0.5869384599938984, 3.6897115649686016, -2.8019777699974138, -2.210197591433987, 1.372963837803181, -2.4305883114016678, -4.300518569655994, 0.23781389483709817, 0.6793756019964505, -2.8402600745880684, -0.003228714080652401}
};

static const float b1[32] = {6.917372550939106, 6.6226296729722245, 5.898708126780079, 6.81883418515247, 6.651534079483453, 6.3788163376505205, 6.364496003999221, 6.719405407919397, 6.716193050141607, 6.684506766934627, 6.461287752042773, 6.6118455343360845, 7.030303537047, 6.351030462618531, 6.503939756364965, 6.4627667058748495, 6.806142696988107, 6.618854266273455, 6.88504606011194, 6.342079175692836, 6.759142894354166, 5.891497363175377, 6.807328829230775, 6.4935644478959755, 6.2961034000330605, 6.232485430464799, 6.763542050665554, 6.758839037107745, 6.551286913267718, 6.790867076597219, 6.895488455611317, 6.077349448114236};

static const float w2[32][16] = {
    {5.101592402583444, 4.724987486924503, 5.708925629665967, 4.991684514928938, 4.16364428521549, 4.60557608603275, 6.02017030327842, 4.041131393453413, 4.235488105007752, 5.491904414836758, 5.294421623882295, 5.190530599199314, -0.6399138989274382, 2.951828110251017, 6.313058947002902, 3.744994080453483},
    {3.9499485087692885, 4.117997018039293, 5.292322574941021, 4.646222035132696, 5.080789363097888, 4.59516498988711, 5.789636781096036, 5.331470316949983, 4.31927177863859, 4.887838152128731, 4.198579986982779, 4.6473579187917435, 0.3972289437284319, 2.979867966333209, 6.126884200691286, 3.8722772553611944},
    {4.897791396489036, 4.956033959892106, 4.437919216119801, 4.837820106712322, 4.247262065801661, 4.792079777341057, 5.214243741305944, 4.062455087642651, 5.728311008626288, 5.769882672899123, 4.8457196023962785, 5.375155594526791, -0.9082339016965788, 4.445409756499052, 4.778388210278941, 5.006323933257057},
    {4.085377197584197, 3.8512782364906277, 5.391712068866079, 5.424099491681444, 4.6631454801628935, 5.843051838320168, 4.438841099228408, 3.619679539173977, 5.03462720468383, 4.9804245382880605, 5.465928189196696, 5.72453979838462, 0.5418549298221816, 2.854044070685852, 6.203709897285667, 4.372613394793406},
    {5.575939650126269, 3.8900146758286556, 5.279656867596119, 5.265553076799803, 5.894833779588732, 5.0701497535297735, 4.836956149309314, 3.7185689842654237, 4.865315594783068, 6.010104809147252, 5.076105679319807, 5.44712860262731, -0.648259292929936, 3.9590271059571163, 5.609064802279018, 3.577999995824063},
    {4.618785233340223, 3.58148248096066, 5.216934231300443, 5.2064556626792395, 5.619258432444326, 5.497473745580929, 4.315976721908645, 4.9413206859351515, 5.488685822366798, 4.318778848218114, 4.5548397696171055, 4.627046690198375, 0.31636316475143633, 4.429520530078793, 5.884950059172044, 4.57526533068187},
    {6.067935980189611, 4.824445703399294, 5.287486526558411, 5.395185004322044, 4.8465652034460405, 6.785486345471068, 5.004554839686402, 4.322019775249445, 6.010291288451723, 5.159519657131947, 5.579295468128604, 5.798588736896764, -1.0402100927575, 4.547488689060263, 5.517053062854916, 5.565833485610286},
    {4.0311578591495145, 4.546412587496337, 4.681542522456787, 5.322522566438022, 5.453510929203091, 5.886829665026073, 3.954668206301345, 3.6119207208148936, 4.956522803768275, 4.973197929089281, 5.1452914589459775, 5.11354165273412, -0.14745983222708708, 4.263071848334072, 5.9163165668351105, 3.6675675952439226},
    {4.405712317498261, 3.5977778676439947, 4.679066359898829, 4.848209138783711, 5.493520053793902, 4.843066008460768, 5.924233538870239, 5.255795526771188, 3.8991113644027373, 6.080431277316558, 5.848854556645499, 4.262255727414866, -0.35525591523579475, 2.9103326003529624, 5.41785330185452, 3.8425573351633155},
    {4.75237775402346, 4.594395668500397, 6.5178144100308515, 6.748552619342409, 5.306385474423058, 5.50714297949342, 4.87396687565036, 5.174069628137324, 6.134880371370322, 5.736787476262444, 6.117132392252796, 5.4309270787733395, -0.28781057384697606, 4.4842146259797655, 5.874724947841681, 5.823056830454744},
    {5.541423454392388, 4.76996991811155, 4.4060181555799085, 4.725410359390506, 6.060225797953672, 4.992977975094092, 6.009647018073907, 5.520249439515669, 5.858380352634092, 5.478162839673538, 5.317858700075285, 5.696475954362361, 0.2210024027159415, 4.434247938558059, 6.505869010105677, 4.985768627938596},
    {5.191127960215162, 4.6727616067448094, 5.479922370068575, 5.613310796324452, 5.882605502500857, 5.432863744996747, 5.760248448062787, 4.283971464850633, 4.080806555322177, 5.424064668233135, 5.649549036474485, 4.7476852105167415, 0.013489509952240195, 3.22029327701497, 5.885238557342415, 4.924975013169645},
    {4.711102052813697, 5.44809236409509, 4.8874392468419785, 5.126687925937668, 4.398775336846566, 5.718824618256354, 6.29576898544517, 4.047305994185538, 4.5277537982716, 5.69893678118983, 5.67049558693217, 5.867312440332893, -0.6929503469063241, 4.838804209810009, 6.290036759193749, 5.54381799044492},
    {4.662619979626963, 5.255699272964358, 5.573748822456032, 5.018148046944718, 5.626073386801141, 4.872900278176111, 5.7586886048624475, 5.292959615847992, 4.270543150930038, 4.342946420576548, 4.609898315300184, 5.922257895154746, -0.06691133469419434, 4.05147802164009, 5.7219256537508745, 3.862425232764905},
    {5.317090248101438, 4.570113663539565, 6.09068151135137, 5.399347641123908, 5.363662658404215, 6.239386364027125, 5.160995266160926, 3.6652872769234937, 5.467707743852609, 4.558136685147693, 4.3638321941127804, 5.782424313396398, -0.4553446971561588, 3.3526205032686978, 6.331858324280617, 4.095192582562716},
    {4.984196307121629, 4.001267263162627, 4.951821498904075, 4.79029503575089, 5.84821602128697, 5.1274017229435405, 5.147679103411095, 3.81706959049226, 4.339878750585173, 4.574849761909691, 5.429744210285984, 4.781128202075827, -0.8477269021253115, 4.279666417110697, 5.771944809424482, 3.6104876432515045},
    {4.985659821688597, 4.51342462072191, 4.9798678332670265, 6.689296041156656, 4.775383766967587, 6.18706211879285, 4.702841214375533, 5.6746134760759945, 5.972527767678557, 5.22635227782316, 5.5994088505226935, 6.092177035981029, 0.6604727130828111, 4.824382401035864, 5.312632762505146, 4.0690652037959465},
    {4.958211942568669, 4.943665063188452, 4.632903906925612, 5.905902496242946, 5.922485669992295, 5.164079064541772, 4.305652924036255, 4.340860526940261, 4.271990369627675, 4.332381341405862, 4.107110547092097, 4.872096555926254, -1.1509139646120194, 3.652646123747931, 5.647627290870324, 4.2232835898983625},
    {4.004151662383358, 4.883351611246102, 5.06963724067134, 5.964888551495781, 5.417326324710671, 6.095636072458252, 4.34036008283258, 3.6981370424665543, 3.901245838647695, 4.140311866657178, 5.183796486555228, 5.748199507997886, -0.6142187995529663, 3.1254344971047865, 5.441561717238543, 3.726007423862617},
    {5.318749467478913, 5.257127907970571, 5.883313461943595, 4.616656377591631, 5.742598405663105, 5.3884814042009355, 4.696370994176276, 4.83118174209022, 4.6152027826647535, 5.092780325846772, 5.083900712559205, 4.897568766519579, -0.2579307316362329, 4.618428063617133, 5.161336088322965, 5.326501775559893},
    {4.974320402477614, 5.781277970979235, 5.007216228260169, 6.336307176821206, 5.374169636757792, 5.219687842113534, 5.688849865911121, 3.8664270167245265, 5.019316501503354, 5.543170577125666, 5.77497719823053, 5.551086632608015, 0.29293798998253195, 4.026289592344103, 5.95273798086076, 5.5267820268141135},
    {5.993068857440106, 6.138296831743723, 5.759229599318043, 5.933374919838936, 4.517060931331814, 5.294978189606934, 6.019733404932678, 4.492567995468123, 4.544633987209796, 4.939031813391875, 4.853576699773044, 5.167381230859383, -0.10476220201129734, 3.469775907435443, 5.4486076264627465, 5.632830876948962},
    {3.82155088083774, 5.733820905647975, 4.535583330343001, 5.795421606617488, 4.5669468107356055, 5.232266664757563, 5.858121232797378, 3.83229596628148, 4.55631912859658, 5.500455999435309, 5.236699157562762, 4.609152184769956, -1.0729805615406558, 3.750690460637193, 6.004472301987533, 4.082962073285735},
    {5.1176751720297, 4.612858136217376, 5.2110813840376045, 6.074802896958081, 5.758517141171574, 6.316985250632595, 5.836468185366363, 5.009976778694066, 4.183032583115107, 6.117755977095762, 4.3193980541820505, 5.885441338474992, -0.9023362607997273, 3.54712017686323, 5.167158696003608, 5.178357055855134},
    {5.378895643672886, 4.638686886187397, 6.224163844597225, 4.932751565486013, 4.8127007886428075, 5.388167710404724, 5.285756468618312, 4.455339356272494, 5.167126331888742, 5.008185012047117, 5.856062125805573, 4.960866105858407, -0.010179166625007499, 3.815034898585015, 5.457542534417745, 3.6718460325838596},
    {4.184690507960462, 5.1796506318884, 4.833185362628615, 4.599546647281334, 6.011157283385262, 5.775537139254329, 4.687774965511025, 4.4341043722818, 5.140304341712885, 4.999513523740445, 4.33410206009502, 6.049065691497704, -0.30355244206366, 4.368851156385448, 4.878320490422363, 5.20481101285496},
    {4.577761508656622, 5.0145999256490965, 4.85699463484804, 4.925337256279279, 6.044264654159609, 4.9174697046197755, 4.244372845906286, 5.19071397495878, 4.64001742663972, 5.997914986852694, 4.604987988592308, 5.886706890071261, 0.4533051508431393, 3.401934486939003, 6.485064445413512, 4.149843869547654},
    {5.406168908699002, 5.556614394055543, 5.428267386621316, 4.73632881835041, 5.0055480185848324, 6.148462527127338, 5.394948372468351, 4.047969656009318, 5.477806284319799, 5.467783338695029, 4.1034797672930114, 5.858099179700462, -1.1198670806660085, 3.690829578623739, 5.8187586963967215, 3.793877463355465},
    {4.426804529009427, 3.8414125916943327, 4.358812880885203, 5.583031250127788, 5.9029696386228405, 4.663039916108899, 4.771688613992841, 5.21834067241323, 4.126555403570716, 5.293650898757784, 4.752239969434525, 5.486669000976598, 0.4983744231190854, 4.486185441588269, 5.389056118120603, 4.718727312917818},
    {3.9601218331479573, 4.151771560490865, 6.171977281430008, 5.524935107259023, 4.700597078482043, 4.59964765327035, 5.574019831017799, 3.7496829940704095, 4.096686514833625, 6.131569857291659, 5.917897037167898, 5.0402684090653835, -0.9764365121075917, 3.152369294357049, 5.769083708615877, 4.123678976962022},
    {5.856171528355841, 4.123393094245502, 4.99449875039895, 5.0665734165896, 5.593994025788779, 6.623059900504533, 4.911648118181336, 4.8847842136254505, 4.3885968557596415, 5.69665932329406, 4.455691879639014, 6.310139603634479, 0.0705731546994883, 3.921185230644232, 6.109444242820503, 4.366125539071516},
    {4.8135039513892695, 3.5905478433391567, 4.1758698954703535, 4.904677295337786, 4.4420095692925745, 4.419339649005804, 4.8584155693857305, 4.77384886349113, 4.679696981442305, 4.031288029283009, 3.43789530385461, 3.879073465758286, -0.2866030654167267, 3.5587868306455395, 5.366724610560993, 4.423923856038174}
};

static const float b2[16] = {5.446616332960593, 5.927140235697891, 5.919021474638341, 5.996676296659501, 5.6933788794294715, 6.172665920683732, 5.959859057461155, 5.8837142130425315, 5.746366017818034, 6.044574813246135, 5.882506470748984, 6.077632783885677, -0.2341383478770375, 5.027696785626192, 6.040652280499134, 5.309004516325069};

static const float w3[16][12] = {
    {-3.37938286482096, -2.6128195651721184, -3.8881718746201623, -4.166824554629444, -3.61180854795265, -2.77841729434916, -3.335165891336182, -3.066970836426354, -3.1791635294110083, -2.4561766807627508, -4.2413527351310725, -3.7861987585314503},
    {-3.5365978003247274, -3.203518892758648, -3.1938632129358187, -3.9961209992470166, -2.30190346570551, -3.391400343319313, -2.8868792301130033, -3.7541693745290026, -3.5191440806070817, -2.908347766792282, -3.245299962390839, -3.173417045911252},
    {-3.6576283920930543, -3.6079923140967054, -3.0154557650524194, -3.2622270561628226, -3.776488015074813, -3.0017773152445564, -3.5454634307631245, -3.5517986225517513, -3.2893341564339824, -3.1611475023143707, -2.6959613982735466, -3.290046383708362},
    {-3.3222841846474314, -4.085671006522988, -2.473613209659112, -3.941935645110187, -4.18795126880014, -3.9991517984869187, -3.547617880938177, -3.3915929597599623, -3.5769438785719285, -3.630160836851446, -4.26870615261426, -3.8708336593724764},
    {-3.478707333318397, -3.6082214589818746, -2.9508950868394144, -2.6035890138043536, -2.476141346644272, -2.7311639576126368, -4.532218860788592, -3.7752407472400455, -4.070388354263898, -3.520851406280442, -3.8635085395291746, -3.4081661628611726},
    {-3.4174287346882104, -3.9992879547396916, -4.201334054859209, -3.38936879699981, -2.869975787046904, -4.594744411497593, -3.4229295672685875, -3.608270948593319, -3.274291194024581, -4.166206253309761, -3.5775151513632832, -2.3938841884881192},
    {-2.9593264524853233, -3.919337242234144, -4.012712688706508, -3.093450375860297, -4.055658376152727, -3.0177696618914296, -3.4005884298532565, -3.6954827122270957, -3.042426429008516, -4.2832924162875035, -3.7353967027122263, -3.498109133030764},
    {-3.301514990288349, -2.628995092353725, -3.5153420604885897, -3.0509593624122373, -3.624498957652901, -2.8057238269763, -2.652350502801133, -3.0192804808199694, -2.3421163598521946, -3.7343100681858865, -3.214656152583411, -3.1886313881480466},
    {-3.537762851548632, -2.809467264947839, -3.7984263094014215, -4.1468604673060385, -3.4354689267509726, -3.427491568826694, -4.204647662104472, -3.0473824688000923, -3.911193510387338, -2.2970495553967667, -4.270952831237068, -3.9596113684920775},
    {-4.025702615418291, -4.583809375939784, -2.8508109886147133, -3.3596520414082898, -2.8848211971719424, -4.467003650594239, -4.122838132177315, -3.359104704831776, -4.253639922092025, -4.1122285210876806, -2.4875261801806805, -4.225892308542996},
    {-3.755387957796114, -2.8378687983173734, -4.3924200703680665, -3.702964090132557, -4.247076363711105, -4.701068166757821, -3.1715589476649506, -4.474895960322663, -3.421247697255222, -2.6664061431095, -2.624788334473955, -2.3702318671016056},
    {-2.4410399701679464, -3.94788386877431, -3.711734185517775, -3.010604185572656, -3.918929482901567, -3.503000050313062, -2.9144391168821495, -4.391929971723561, -3.5802143417423555, -3.0396392097736245, -2.5825336981835063, -4.021757942208543},
    {0.43197877163260306, 0.2902281556559182, -0.7450878629994563, -0.481863875376253, -0.09190889210027157, -0.02895836934069287, 0.18158529583296715, 0.811313947224216, -1.0244087504547763, -0.5128983232959855, 0.5191305453200992, 0.26758697725960745},
    {-2.800880658450246, -2.569835382413499, -2.331334697453367, -2.826787077832148, -3.3885819301911377, -2.2206341066517674, -2.9874597476385163, -2.2005985657237574, -2.865087163971855, -3.363836609338875, -2.882168394967546, -3.0633748755237464},
    {-4.026304426276285, -3.4848088864058657, -4.186289158950831, -4.497142763095141, -3.184604288148762, -3.398618569238346, -3.54712876453059, -3.6477050737469083, -3.84358354470407, -4.133027080648685, -4.373658124513265, -4.036323920764466},
    {-4.066279130677498, -3.3323981587306695, -2.9164784794754395, -2.4876418055784297, -3.909089463322843, -3.234254495241803, -3.287344643064163, -2.213842463370483, -3.3111489487050427, -4.143625593542877, -3.5501042657818314, -3.3134231783721564}
};

static const float b3[12] = {-2.8422148175543933, -2.2307114051467614, -2.500703214411535, -2.837634353252152, -2.5637066809461877, -2.328259661816683, -2.279591617064477, -1.8290721451567082, -2.791008742931669, -2.5869362288547872, -2.582288659296058, -2.3343046488185304};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
