#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {1.6175806490948426, -1.3784672811019807, -0.19814965987733363, -0.9997242251062477, 3.2199964971809063, 1.3104357163100047, 3.4235309480958307, 0.5791249821987312, 1.9947972957314464, 3.246801881807254, -1.3884070267351003, 0.9293626372374035, 3.1361000424546734, -0.7707087377099975, 3.347090189209802, 3.1366683638389423, 0.1570270830079553, 3.1502039922089007, 0.45317178112084805, 0.9522033689284284, -0.34484342002413243, -0.39740282850862424, 3.164282261477106, 0.2899076443322525, 0.4388638824490062, -0.9251907111736731, -1.3961332127560826, 3.8098603438612426, -0.6234448659671317, 0.47797667309613195, 3.5557590156946164, 3.0984739220635573},
    {-0.6105211099734397, -1.6663285744257368, -1.7878064774261972, -1.8811799161909566, 0.05984925599417195, 0.5531697716904821, 1.6520890216514608, -1.4202714916966672, 2.0077520139058693, 2.171466683201903, -2.306415849490063, -2.1872530455650803, 2.3943997863987088, -1.9563914250788015, 3.3792278307854575, 2.870128666454411, -1.511235769079934, 2.0980319949137867, -1.1536904947055677, -0.5783858846497627, -1.9191201293915956, -2.246429363672054, 2.980399381620244, -1.5274771131028062, -1.0305282769821893, -1.860013580689078, -1.9870144293829624, 3.4586784102727344, -2.0458685693370455, -2.1444633603155716, 3.141543990276697, 2.3529949829763286},
    {-0.34412175929103644, -2.1769290844422122, -2.177257991951688, -1.9618615061920759, 0.6740119066677501, 0.3204682209727131, 2.216037187533807, -1.7601662494551142, 2.3262622801379162, 3.0216160105054235, -3.0399790209950286, -1.3820888915096066, 2.5282863593919638, -1.9048028722590788, 4.120994651345324, 3.6366217720185356, -1.5384593010582308, 2.7578595889623987, -1.7312174115216576, -1.5186372492450702, -2.476202721636749, -2.0599493785073157, 3.4921742481873914, -1.5539577243844576, -1.7669356876347813, -2.2786072210110717, -2.3769259775449036, 4.121152291615569, -2.276330880086596, -1.639107584362166, 3.625396756197585, 3.098680161828949},
    {-1.4584359416734878, -3.743066746273704, -3.252296449729079, -3.715172740036199, 0.3350223087092281, -1.30524180122333, 1.2203233902531414, -3.0846665086958556, 0.9787906364215989, 1.638734881202513, -4.206148669994551, -2.9411920304889123, 1.108730562195752, -3.370431889367993, 3.0654801447646194, 2.2715893560252076, -3.0302977606720516, 1.7929607049847154, -3.26873928600959, -2.310949347326373, -4.168440346415883, -3.960307670400829, 1.9621379555371097, -2.7741236038054313, -3.089604719100413, -3.707809531062303, -3.535844787960358, 3.216792107693022, -3.3901147889306125, -2.9000279817359944, 2.2977034661518974, 1.3337077809118487},
    {-2.5015170754847356, -4.324420128878177, -3.7043877370056064, -4.028880615426453, -0.7435539330223939, -1.6202479270565195, -0.3049933282407729, -3.786033765962649, -0.9418907895419817, 0.8972968487669929, -4.732184391361465, -3.3751738101273254, 0.04367604793777142, -3.9634633457842274, 1.1388430571225463, 0.6851170411342712, -4.119141786862461, 0.8056262503936157, -4.293729323801373, -3.657650875810422, -4.515603394165869, -4.142564378857584, 0.15996550338294893, -3.816136413577056, -3.813482155692539, -4.2497659503833285, -4.262511533936516, 2.171450234845007, -3.970132592457221, -3.223178967809302, 0.9193067862812022, 0.5616131686671048},
    {-2.951595816836943, -4.235353958138207, -3.967697595270957, -4.4739238051282015, -0.9437047579720753, -1.637096977637914, -1.0883817553077404, -3.917350508676527, -1.8661990557173551, 0.47959074868742013, -4.689184481132447, -3.3572930213789265, 0.20063908461652014, -4.027474590647784, 0.049017730010228355, -0.04944415940011127, -4.226859677033536, 0.1264045392892228, -4.413094555973681, -4.108118148441516, -4.423777985368325, -4.371742219128192, -0.29843695641468426, -4.018767443088155, -4.224564870400001, -4.663916827268653, -4.491451821267146, 1.4245402415667534, -4.33730948710882, -3.377909122926552, -0.021285327230995497, 0.10889929439530109},
    {-3.1822272862965457, -4.0773389174237185, -4.057726663226259, -3.8905726995600376, -1.3155767868609314, -1.5039317940208095, -1.2515995555258488, -3.940108692035838, -1.890052671665779, 0.30258795294337104, -4.299041206523369, -3.4443534508432863, 0.1119686110080029, -3.7468845752237807, -0.5686407146195591, -0.23435659252136348, -4.04036102766746, -0.1545823152059898, -4.068672363807583, -3.7829146628123773, -4.584626492061107, -4.243171706479958, -0.7523046567140925, -3.659506323978766, -4.341530850171331, -4.277117113476126, -4.091359193064859, 1.1110853159840741, -4.104958223779765, -3.7888963853363395, 0.11823193255863831, -0.004115890256227218},
    {-2.9263501344213423, -4.223475341399007, -4.147200819650214, -4.2415924748791, -0.38637414004912735, -1.642197729379757, -0.4645133766631621, -3.871782578798205, -1.7137076802821372, 0.795310041630646, -4.500329113452994, -3.7822741578896384, 0.1793101113932119, -4.108711854850062, -0.4073723846620043, -0.1232500708992953, -3.8728483467412183, 0.030418807127277944, -4.437247373364447, -3.712307999107943, -4.555972165969219, -4.406174591249697, -0.40194674696932314, -3.92103913889694, -4.2893522161385755, -4.35130209798011, -4.425724530002065, 1.4049914340941536, -4.22082939480544, -3.4137964739260798, 0.30902723246014185, 0.010742390425744871},
    {-2.171427998667908, -4.459333964269839, -3.957054150834777, -4.298219321827652, 0.09233854294339079, -1.4883003989691543, 0.143335429625139, -3.151108693510765, -1.05561881913143, 0.5905453177750745, -4.716472417559985, -3.4760238422206675, 0.27303165381474115, -3.859576972418017, 0.4886715106801759, 0.6313326019201531, -3.6852696885125575, 0.22093345017485902, -3.9964562599702766, -3.2401796384989434, -4.723559847843007, -4.231653827267243, 0.15779806677913133, -4.031511535055689, -3.9101437598577857, -4.253227936150525, -4.387630387405771, 1.7596262429719831, -4.080098631112945, -3.241253076743418, 0.3891325124205202, 0.12023188365758626},
    {-2.0929842593782655, -4.022693645317601, -4.0868573262280234, -3.8001281268341414, -0.028758918979413198, -1.4081554484316898, 1.0845251978277568, -3.17773312030934, -0.25484316765819687, 1.0513999327328103, -4.469929191149757, -3.6424171032225674, 0.6091969026925708, -3.8628149469363917, 1.602457855859325, 1.531526898380926, -3.7117018040200613, 1.0898128319764147, -3.583518547487354, -2.978338356391433, -4.230863311294934, -4.3710433092765655, 1.200425334467183, -3.8190320721815567, -3.8552501989511625, -4.007998399963356, -4.19848772319366, 2.31867251274788, -4.145204473398231, -3.4801208380619335, 1.466303580121174, 0.6895000824897417},
    {-2.482534783932486, -3.4597677093860053, -3.6823870061126103, -3.464659625747912, -0.6972479038891535, -1.284278368820646, 0.23835302798727237, -3.354583368614895, 0.24205373573384245, 0.6104649099074437, -4.071336769289974, -3.9034645848054255, 0.5210065043800476, -3.7226036874988, 1.7713942250211259, 1.3363223157317525, -3.439939073288074, 0.6764429085845621, -3.6784592469006974, -2.917318532567895, -4.126185099157881, -4.210212118666022, 1.0934258424707497, -3.938597333653424, -3.3965383924548576, -3.5718065073317553, -3.7168519414304932, 1.7163250365792149, -4.093746758556159, -3.5105923800597276, 1.0795606859461992, 0.5661075211671266},
    {-2.1391876620985792, -4.019989974354679, -3.794105216002613, -3.912668290995546, -0.32567963641626696, -1.0140585538176428, 0.4373761464027399, -3.515863397726276, -0.4573269192395167, 0.9572129656567763, -3.933579911994267, -3.785906879749273, 0.604090289965752, -3.5905611392274386, 1.2722569389778375, 1.4084661985815305, -3.512626549706569, 0.7236310795407438, -3.6718447476004585, -2.9775650244643295, -3.805217055821062, -4.089267694125978, 0.8989287066982348, -3.8120709122985468, -3.4690715871270594, -3.593831603108341, -3.7075602519475286, 1.5790133411733607, -3.999659915059335, -3.437986624762887, 1.2168885655123673, 0.22434733168311688},
    {-2.223451131858499, -3.6298477736559205, -3.7386990780883336, -3.796607007707268, -0.395218228976706, -0.7828081801491661, 0.5377187575863477, -3.5468798171691276, -0.01063274820037427, 1.040946685389666, -3.6443810206351204, -3.542889555169657, 1.0238919505438517, -3.7283377698689515, 1.7748593694529953, 1.6668899428036796, -3.8974017772740503, 1.3248007305709324, -3.7850848372695016, -2.985583753128141, -4.057455611480271, -4.228401817268195, 1.4846846172369057, -3.5190805755012393, -3.6113397023744325, -3.610369510507709, -3.742137136779456, 2.010316290347602, -3.950941397245349, -3.1359856096472294, 1.509221332391043, 0.5305544777284198},
    {-2.084928634323341, -3.8720412770717956, -3.632008291365506, -3.505289376256362, -0.5631614135609412, -1.2138456286601833, 0.480655256170129, -3.6625891054960378, -0.054956644074668534, 0.9367985612458912, -4.08698021280902, -3.5717790763432866, 0.7806752748810293, -3.6848490247677828, 1.7682697810122814, 1.5731033523218108, -3.584022229409459, 1.0732988732551987, -3.652685212561454, -2.9486935275664994, -4.219761814060299, -4.316199754458126, 1.2312012926311573, -3.359729033505967, -3.2354007432627965, -3.624183307676939, -4.133572756625702, 1.9652207726320032, -3.85532553759683, -3.108655107682651, 1.5296221857397443, 0.4249027729142238},
    {-1.6906465200824434, -3.7485706642721084, -3.5133949685519537, -3.531319104881284, -0.28323506969133555, -1.0897968277114063, 1.060625275351932, -2.841806312899241, 0.20827558100196358, 1.455774848468993, -4.216760009016819, -3.1908422140818486, 0.872411170780639, -3.454499292470831, 2.149945944771045, 1.9972552864487314, -3.427335180460238, 1.6422609415291576, -3.4760632459693594, -2.6794951238592306, -3.684444307797352, -4.00625271508109, 1.8315541915891684, -3.6258372701671595, -3.253468868646476, -3.6298898389389898, -3.616434886063077, 2.3708646756166827, -3.656773194770673, -3.041192014140177, 1.8963099734080393, 0.9156617892546046},
    {-1.761663631883244, -3.901580324750928, -3.6786128237212816, -3.939548735149568, -0.5932587809493695, -1.781581885078261, 0.5862833748422489, -3.256501991481379, -0.18417285464586652, 1.198729679324344, -4.609222078373988, -3.2773914101751513, 0.5369383000188119, -3.6392832779263244, 1.7166237486457465, 1.624245456131269, -3.46899944822939, 1.0749255208597746, -3.8357225091701137, -2.9182982256495733, -4.191065296522454, -3.9602244997699025, 1.3899100023377495, -3.4253958302213623, -3.457434560276164, -4.019400951283603, -3.9830739920765863, 2.59596418735782, -3.9304985918000663, -3.395365065489633, 1.3765278024909982, 0.637996644957151},
    {-1.4198637402502299, -3.8509586931828044, -3.3872692647286913, -3.903322199267523, 0.126132784087192, -1.6270668927448608, 1.6846648888229296, -3.055276585288941, 0.9659212572420836, 1.4062177688958484, -4.206577932348105, -2.7920342582299735, 0.9161618006825568, -3.3406178737884225, 2.7980675768797885, 2.1715138695201186, -2.984324664422835, 1.5758440844373742, -3.7261569434212074, -2.1769022488351686, -3.8837122838957714, -3.7035797120026297, 1.9630630348523093, -2.975491513880967, -3.015457020620679, -3.6281443455487024, -4.036644300699927, 2.6218118196713256, -3.521868855886733, -2.5819967438057083, 1.991167941726574, 1.1554107775012177},
    {-0.01839999982341666, -2.7880328940983468, -2.490509299321381, -2.876294621526385, 1.2344728859090393, -0.24674195457230833, 2.964103471207472, -2.18124764563388, 1.6298127628801098, 2.6078549776168476, -3.3565257449730472, -1.44887556699681, 2.2031872827115517, -2.495108350304154, 3.796607444633292, 3.1963244236629, -2.220037717670143, 2.780495287714619, -2.5429479249749978, -1.2219578981587822, -2.7076349203714867, -2.944866905738257, 3.255942486881726, -1.9077926473645066, -1.7967952274609753, -2.573505238647939, -3.153941019508684, 3.64496872157295, -2.94227169269158, -1.20992562989422, 3.199336452461349, 2.507719298309649},
    {-0.5103231992626771, -2.9510774052175415, -2.751107584617764, -2.901036018808878, 1.2253967120033282, -0.2557468843631884, 2.5352914643721896, -2.366609674747459, 1.3994785087374397, 2.2963500914634802, -3.3779026460262647, -1.4535092602049504, 1.8539802211593364, -2.3256779998865853, 3.391584887489268, 3.078936545257357, -2.562555607185433, 2.596548687234341, -2.584260266051049, -1.8014538483571894, -2.9260517209553547, -3.1154054694296525, 2.721666680633611, -2.31562162166925, -2.5700793849562964, -2.8004474396725434, -2.901400341336675, 3.2191520653455443, -3.0179116375232993, -1.7106223673113319, 3.053707497688104, 2.2781101670660178},
    {-1.5030498364810725, -3.5183878087829186, -3.501234554190416, -3.4158866439642113, -0.10168485799982424, -0.7037810456137694, 1.2895441187208987, -2.8871165240288605, 0.8184418671577435, 1.6283189323412073, -3.9740089109055052, -2.9489908725500085, 1.569611098682103, -3.1114775278982867, 3.0370911752066414, 2.3976431501739723, -3.364811481393435, 1.911743351037854, -3.196130228653427, -2.4933175612520104, -3.8491069448652753, -3.6877971252400665, 2.1405299819635144, -3.1737941546130815, -3.2223876800878375, -3.525724558574463, -3.558296803532457, 3.3121132935408126, -3.4092924088825836, -2.4313443773779744, 2.6663666179349836, 1.5879046245213655},
    {-1.367990073764991, -3.614177742001854, -3.325272484106603, -3.40937812644625, -0.3138652090714292, -0.5853115030890009, 1.258990055228847, -2.8411909539943845, 1.0932482855017382, 1.8017476763998015, -4.094090270271579, -2.857272006175616, 1.564081251958516, -3.706607214871854, 3.1486282710845273, 2.5999703805462895, -3.3234631584202208, 2.304682126275387, -3.136893029059763, -2.4758816947909854, -3.8176805356805175, -3.9228780677607316, 2.5294339171658686, -3.3143541232998928, -2.9906627730774322, -3.2748259213908595, -3.5193044038499623, 3.1861960106829734, -3.659671664986204, -2.999481446143621, 2.6739587303197383, 1.7753144428979268},
    {0.00988966362574298, -2.64453881699135, -2.6885327916279627, -2.551248746244582, 1.45168505018622, 0.2244466214960003, 2.716424687265045, -1.8197155388305535, 2.0350226029135396, 2.9295147113104987, -3.0775981131409322, -1.7156599022201242, 2.9580677499383325, -2.3177423609181305, 4.276574273073339, 3.7443954286811896, -2.0668256370358575, 3.410897002722916, -2.051610767583625, -0.9530188832999775, -2.6852894213528735, -2.7390427001838606, 3.5701862490990335, -2.0688549199581727, -1.643894667658628, -2.2291399493998543, -2.7933931292187597, 4.030533406807304, -2.6197863542397286, -1.6642680921075734, 3.665205087471847, 3.0579392420370546},
    {0.8956681934052894, -1.8625564600083706, -1.6562585691699014, -2.08911350131379, 1.8611670111818224, 0.6815279355908698, 3.458823182300261, -0.4454273628270934, 2.871569246411203, 3.4666776341655545, -2.138395724384908, -0.6356820859977237, 3.07207361345216, -1.1452157015110596, 4.426609201922265, 4.104701265089298, -1.2503033416099583, 3.859555742560542, -0.9009668590825655, 0.029367714312291047, -1.7176081077976364, -2.2053714411365237, 3.818921070241428, -0.91149828982278, -0.4388584500605241, -1.4143817731968926, -2.404243161535254, 4.307439330971375, -1.5988809120587018, -0.6310023661354994, 4.1108228078060245, 3.378797257851679},
    {0.032110075791973315, -2.647425552720847, -2.2977753344291534, -2.6255354637677373, 1.3127167877001416, -0.06360079810533195, 2.711550869156916, -1.916206410076117, 2.5339475613172167, 2.69449992950068, -2.9375706286902, -1.7182549362154, 2.2582956140532393, -2.57810895241907, 3.9658435308846003, 3.4308821025237903, -2.152629084397808, 2.8989438668691814, -1.5735601632513205, -0.6953280354585217, -2.606861793649903, -2.976570145580196, 3.4101251805125066, -1.6260621562095865, -1.69385976904041, -2.0985319458772635, -2.871504758879161, 3.8869108063889355, -2.399777287809142, -1.7142207680736328, 3.58585170771072, 2.5943796014996217},
    {-1.0922019048495724, -2.8078716728056614, -3.193575810965406, -3.059009300357824, 0.09263375709303588, -0.6211740279086189, 1.4619750713069042, -2.4943709681265127, 1.9971734008121929, 2.058819873343769, -3.7377318312130123, -2.3984851065232964, 1.5986922458647728, -3.109538012217154, 3.692216400348899, 3.1260113996375116, -2.8572200253968627, 2.5517359375993722, -2.4495907310687377, -1.715677054677882, -3.2588648041535926, -3.334697995824097, 3.142523578997792, -2.6306994371898047, -2.4102999019782354, -2.7344344493515234, -3.1759038499448287, 3.26526669886569, -3.040753021161362, -2.5628005195086154, 3.1197759708063093, 1.8726267265209606},
    {-0.6584963976304651, -2.7153955000099703, -2.882896421636007, -2.5595349492794197, 0.6384859789984968, -0.2953261189533405, 1.76357656562315, -2.3689206118377, 1.667831336420849, 2.2120248672666136, -3.1501690922027445, -2.4140246001163024, 1.7922962968791636, -2.844382040103999, 3.5640076199250705, 3.344959296317538, -2.545057141860723, 2.8561230964511934, -2.474260642072399, -1.5352529086535678, -2.64720389721914, -3.1205819048371066, 3.3119690642967865, -2.316203091386473, -2.177674995866767, -2.5678234349153746, -2.9544539898423845, 3.628814058614027, -2.9006132668446263, -1.99391061604716, 2.89425301576516, 2.2856746616642813},
    {-0.7287153340516328, -2.714820444310646, -2.711606449785926, -2.765205757898393, 0.8379924399068228, -0.3017382078909811, 2.447676855525166, -2.0632753716471086, 2.2934035494585343, 2.7385263949160774, -3.4111427843553113, -2.1467937386162905, 1.949993307520717, -2.332683066702861, 3.9844088902464923, 3.3235701212393045, -2.546803062529152, 3.190606039271545, -2.4622458489806514, -1.3567666006025543, -3.301938930496562, -2.945937563209364, 3.39013429475109, -2.0870789865676866, -2.0371548897598135, -2.7531682762847236, -2.713559048699176, 3.8356159790346673, -2.577387878156756, -1.8823892207241557, 3.4279958022266768, 2.5670323298856452},
    {-0.9607217977665202, -2.99634656273421, -2.830684276893819, -2.84530259556207, 0.5492948382636917, -0.2872812507540641, 2.0618433329039827, -2.292704671830823, 1.9684181364818147, 2.643520301200519, -3.4486653686044155, -2.261808107110178, 2.1763744133452407, -2.921199693205473, 4.0038498033332734, 3.489417645013204, -2.513135322123109, 2.8631857956666287, -2.3546572595564896, -1.4815318533470068, -2.948622217809134, -3.2823746947135275, 3.5268291415431734, -2.558869727524522, -2.1735918827943737, -2.6861859358369227, -2.779771672094507, 3.8631900623228574, -3.0953738058577347, -2.2127796397917354, 3.747174901195187, 2.463428194833527},
    {-1.0797225748980364, -2.7897229279378113, -2.9285116989539652, -2.884200012084311, 0.27501749316053903, -0.38251901300731717, 1.8684243356030223, -2.2631469092329928, 2.15355091946777, 2.179491998351996, -3.381092105429925, -2.719787674473797, 1.9404004941858095, -2.578470968931384, 4.351331709324657, 3.413756238847485, -2.715085002446293, 2.8874032809780514, -2.212115997235918, -1.424897971746036, -3.051215500327485, -3.3625621458416433, 3.5044491983123573, -2.539664787618875, -2.1535155186812514, -2.614541807506659, -2.8728840913838165, 3.5675492950235, -2.6901347925919046, -2.4482243835798876, 3.398347396150175, 1.9941207611760778},
    {-0.5219078220452726, -2.5660164371717675, -2.7444841320856557, -2.6240691204388447, 0.5738992192398493, -0.6590913689895868, 1.9358314053068963, -1.9827547062117044, 2.235884800629347, 2.3269571499215598, -3.2871364299666035, -2.2985911068566054, 1.8136360417677022, -2.7162994888212904, 3.7589823349932794, 3.4160397304089067, -2.215313262847602, 2.466029416680387, -1.7843799743622941, -0.938966163136821, -2.483671573431746, -2.881170928235387, 3.2728612200706313, -2.271605309459329, -1.8079418486389833, -2.119269645862475, -2.70917240083365, 3.6010958899452126, -2.6720299317438183, -2.4046592309007364, 2.925859187206567, 2.0574011714313802},
    {-0.9199374400599242, 0.5209442847356155, -1.223616248818277, 0.3615540550124486, -0.6523050075888762, 0.8928045323478945, -0.9660367791192132, -1.4595747715766605, -0.9495473483042425, 0.6539609640477546, 0.30554958118452896, -1.0446907015456268, 0.6266957434220846, -0.1417436159193656, -1.0931218021366198, 0.9202638300085166, -1.1328565819842416, 0.5393749355388167, -1.6492962875690895, -2.101014243851165, -0.15125647343945064, 0.03887844267693122, 0.4873519238110533, -1.1965793530426494, -1.2417880699774118, 0.18172937392313868, 0.6175620678007894, 0.3784947497352202, -0.47453783984708386, -0.41786498213456297, 0.7327274822400265, 0.32734907960318504},
    {-1.1974022561011635, -1.9278303094071165, -1.4905852208856163, -1.7154384961047993, 1.0118399379903102, -0.6597106446610129, 0.4754649418725773, -0.8857963601702813, 0.4301731245171922, 0.4271230993765116, -2.3178593250327264, -1.3648023003065335, 0.42525904256956665, -1.6217395605239346, 1.0935842168001364, 0.4050726783287999, -1.4582458969515006, 0.5512993023849173, -1.586791423271218, -1.2977900837270016, -2.2688049316250223, -2.2436985376121856, 0.5372995475279929, -1.6556185259153449, -0.6938537812798348, -1.7819840711263257, -1.9678833161756593, 0.9673226860249942, -1.7210046902084872, -0.8892668791509628, 0.6898506858509037, 0.21653353388386018},
    {-1.3895513970658964, -2.2475360756222478, -2.279897546193429, -2.2670734074855594, 0.64836246849815, -0.3215161219628382, -1.0206980716519551, -1.7440044955816196, -3.162492560934846, -0.2577294595684154, -1.6617159018689516, -0.8715414346754838, 0.013301373529945872, -1.885090001378848, -2.7543796404954635, -1.440331126227042, -2.1921541842863297, -0.23622091839110418, -3.040831944085244, -2.726958473149642, -2.4759422889074734, -1.5125210021547815, -1.7397647077116984, -2.0192614230225834, -2.6297977389355833, -2.5219260099149468, -2.006545076030857, -0.2873741733151744, -2.0495461782688555, -0.5278865037930391, -1.1504775814286228, -0.24923884990857495},
    {-0.8625109923724208, -2.0996351438191754, -1.4313227137038003, -2.140697131696947, 0.9960792582775801, 0.06788748761353006, -0.4238036887998977, -1.3027001711134738, -2.4695411807201717, -0.40539133598445276, -1.2954892571485848, -0.4424466370767628, 0.15273870394651942, -1.8799281944233952, -1.5175236970655375, -0.6820455091826997, -1.6291747315270233, -0.35094993772064453, -1.5336449827851315, -1.4836320091031698, -1.492769685568516, -1.448434562346359, -1.3063991540025914, -1.91673268878911, -2.0949018785812625, -2.169623377983168, -1.7961590127015499, -0.5263886949596607, -1.0131962168412028, -0.6286992430820812, -0.5470080871991165, -0.5099615299468608},
    {-2.385593574175412, -2.4396378257243003, -2.789493982161651, -2.2501697078458682, 0.0026359662014879626, -0.011141073112256409, -1.2595963752261472, -2.8461137177016242, -1.6542039526472454, 0.5259441166658542, -2.859456423166981, -1.7753620835002677, 0.24325090585109127, -3.1165575567604797, -0.7276007884376251, -0.3798871875157374, -2.910333384786165, -0.09773315740392792, -2.5838347547210483, -2.9194507876935845, -2.6510534202465856, -2.6682594576337464, -0.2773289586622997, -2.857747681564618, -2.654771619494377, -2.803052326629147, -2.0804141861722227, 0.5516587174601569, -2.711241938310845, -2.5725401214972927, 0.06697450981330387, 0.41362351514807005},
    {-2.336583209885808, -2.959503113793258, -2.8808453919786303, -3.029430251684456, 0.31775387068619043, -0.36371189262382686, -0.9909368867928072, -2.7331476025707575, -2.2356653007549636, 0.26489531395939353, -2.916263057134686, -1.865149520234689, 0.3847864898528411, -2.9397422161178555, -1.7264157456290063, -0.6466997852843138, -2.798301296192819, -0.1823412562534136, -3.0189712963895436, -2.7425545266644438, -2.7450463540838324, -2.4641091415507437, -1.1851380276972625, -2.6102942209063587, -2.8288418768199426, -2.86225312823174, -2.9474030889359524, 0.3546335714778668, -2.4052602486591756, -1.4786047672348566, -0.5826196584282431, 0.1277558398429596},
    {-2.7430146865093556, -2.7578284085770393, -2.763394713014825, -2.7280344450372707, -0.348811244006512, 0.0010763174521508754, -1.4808898708902158, -2.919154877065183, -2.0681298679743607, 0.25778895016953685, -2.5327498809452313, -2.0647900850382905, 0.00917251597364746, -2.983938194978041, -1.5848084601314203, -0.7546668978125519, -2.622128844785152, -0.23155508992648333, -2.846325900046855, -3.145530448873778, -2.9142501342561324, -2.9004195859481015, -0.7685810701288817, -3.0710182400584047, -2.8548830017004945, -2.929219376820901, -2.758897591956669, -0.2099761945317177, -2.953281732821339, -1.9766803640393114, -0.3252673280666765, -0.06654599936300977},
    {-1.6402937887223836, -2.198918269622267, -2.1868768836867893, -2.2186843882615666, 0.45818753491857755, 0.23695912016314918, -1.1279734920459674, -2.3315140382251043, -1.9436898769696247, 0.515612105380845, -1.9297091538737354, -1.9341832470820814, 0.049262117030929996, -2.392807987762876, -0.9858276424673735, -0.5696237377610275, -2.535918808655859, -0.014086806848005552, -2.506769038519399, -2.6738230641583303, -2.482086705099607, -2.7089630357013967, -0.5639582359838227, -2.3584940886035355, -2.439662471773989, -2.3457041492997095, -2.3768984618356734, -0.24070982693565884, -2.1870575592347175, -1.1417632139092528, -0.79325539115401, -0.11988760415930191},
    {-2.270815077137449, -2.862176855857269, -2.5869896510124395, -2.826499204861793, 0.8314637336239596, 0.19761901114681538, -0.8306001601414125, -2.702753907164061, -1.9885200077550576, 0.7459919564142521, -2.8314381861702826, -1.775430273821243, 0.9071361391717513, -2.9474025921822853, -1.4150737413437884, -0.3930853013213529, -2.402931870320716, -0.12912875883018698, -2.7968550463988966, -2.6882997263988933, -2.732732135576417, -2.9489291506310873, -0.9760372982669862, -2.9130899216715997, -2.9217566549330476, -2.9608385640048147, -2.893874199712999, 0.2730934162945026, -2.580202841119271, -1.1409028923013855, -0.32687805118053226, 0.07887212983658429},
    {-1.7166047336301569, -2.6709460590685827, -2.758288408056775, -2.764954577920995, 0.15522201573044173, 0.41705323027702745, -0.914127698949351, -2.943083457329048, -2.116129820380124, 1.2122525305458671, -3.1547764384189665, -2.2267830304975167, 0.7556100339486308, -3.2606097223474215, -1.5554638943420185, -0.2204131517132227, -2.976948557128477, 0.35294975691399894, -3.2140866284312124, -3.113057535318154, -2.961024515831688, -2.895111099632887, -0.3337904278890348, -2.915982943158001, -3.064799838282717, -3.251333970559945, -2.7519630714650862, 1.1442941692153865, -3.0840023082137926, -2.4261718138135695, 0.07358575579289324, 0.14546209839308705},
    {-2.426287748721618, -1.9506175692944683, -2.6717965484451254, -2.076048354466456, -0.21063234311877255, 0.1984553391657596, -1.4423625957686543, -2.795394968943152, -2.2691807433303905, 0.32014579067970134, -2.048673318986463, -2.2275691148631496, 0.8294037682392471, -2.8093328707400356, -1.912799159218933, -0.7924745722767027, -2.431212326381143, -0.004384091247306071, -2.4927284915529953, -2.4630115674707276, -2.662623144387796, -2.8002121684351478, -1.3211436908717895, -2.579322164521518, -2.648035210113155, -2.1700030529120022, -2.1820887680953045, 0.26245885553299875, -2.336303918571213, -1.931787438083767, -0.012955916327214257, -0.15241927454643453},
    {-1.9808255475194803, -2.776673138158898, -2.942156047284548, -3.075466903558182, 0.40899157680470355, -0.08273592777714801, -0.9622429092690524, -2.638025092080654, -2.4735653937731916, 0.2547877791069053, -2.7788882717563457, -1.9998082169908824, 0.2697590299166804, -2.9526439203164974, -2.2080560017065425, -0.8050927706394212, -2.9095497554483045, -0.7347087883493115, -2.759166457768436, -2.739637293090266, -3.0900429018043587, -2.570420373517737, -1.0785621397391663, -2.8584509697268516, -2.8052093158850138, -3.2602481943485704, -2.903936044370616, 0.24262648993616842, -2.8820891756915397, -1.4344664331002572, -0.4354665114325003, -0.4184488931415455},
    {-2.660265965525192, -2.788768499992876, -3.1107228265682036, -3.192850994430877, -0.25052925758854394, 0.13006702445240323, -1.7170097819834218, -3.196601305236837, -2.8527412552187323, 0.4606810785854142, -3.4034799885522053, -2.335112406265762, 0.2160705091213462, -2.9706386952364636, -2.225096835414406, -0.9756228102067751, -3.0777854364229706, -0.706112976779844, -3.506812731256494, -3.3275777329810294, -3.4288212585427322, -3.0816367760467447, -1.3651242224085016, -3.1622949631353627, -3.2562560609223263, -3.3559712663610783, -3.1065894573514186, -0.10681715061375106, -3.145751972303592, -2.3707738715112034, -0.6892073841674685, -0.34572895128978803},
    {-2.538101709890222, -3.335158949860708, -2.8260115939304327, -3.1128221477731093, -0.5073322059227892, -0.6764801893009773, -1.4990276431019331, -3.1573933498800772, -2.930306395426964, 0.18962603129202468, -3.150281453716191, -2.330738369232398, -0.30308373061196986, -3.1492517184249285, -2.3747029018004207, -0.9238292763388494, -3.1550329010354177, -0.7449451002757761, -3.4661701795972, -3.037642672812873, -3.60366120184842, -2.9397167181972708, -1.4168914855389612, -3.2764827047228224, -3.2706046894289016, -3.546906975763386, -3.163001307380448, -0.37857154253924197, -2.800744715034197, -2.148247549011712, -0.6618322962726447, -0.5544297479641013},
    {-2.3651690581185383, -2.9529507226617864, -2.5851053408813787, -3.2293557498791516, 0.2186343546409901, -0.39407532431454084, -1.331213560821644, -2.9308556213848944, -3.2977275368064554, 0.5558483178630406, -3.080391119331057, -1.9808172119594851, 0.1295343304012544, -3.20737625438018, -2.5753850520045676, -1.002333657975408, -3.1066711422713844, -0.34050134320197073, -3.5371250000615766, -3.4511297476235794, -3.51684237540623, -2.6719589856126382, -1.146691470227808, -3.0821442945664996, -3.272037660574658, -3.343420093275446, -3.1165486173802757, 0.1043269748857371, -3.1099321100401984, -2.163512716849315, -0.7298436427561915, 0.1513818680672632},
    {-2.4419776648603073, -2.9331433841698447, -2.7873667466123364, -3.0115178901854867, 0.3269769428776054, -0.4459655232457103, -1.0628560567007894, -3.149170049514527, -3.5679932845144897, 0.035094204802204, -3.0873336557009754, -1.825546798128578, -0.12446827370668248, -2.7184051472285704, -2.6432879940800578, -1.0743158451932568, -2.6249012411292645, -0.4467537245169002, -3.594145528960028, -3.1364036503044566, -3.213615987710145, -2.5964669748802947, -1.4352270528721578, -2.676824113937204, -2.8238328908661634, -2.907903545616546, -2.9372583974796367, -0.11438949697190597, -2.5159174785163723, -1.4972338830592873, -0.9809583427878569, -0.0049225962321940145},
    {-1.2250777012927403, -2.623771964225294, -1.8439478223398185, -2.712093342310946, 0.9668316682943443, -0.5615996189224486, -0.4131108799901064, -2.2748699845445386, -2.739355062961084, -0.04112369680088312, -2.4724150410533086, -0.8651723101558387, 0.21776257122665657, -2.4816132234952533, -2.3297854114079817, -0.7594728669585555, -2.25490814570688, -0.06788917686669106, -2.4180473055628213, -2.6500774666548055, -2.7415066970968183, -1.7503317343275844, -1.1453846122696014, -1.8993202805805895, -2.2757993518364823, -2.773824804701298, -3.220620056033224, 0.023828872390457077, -2.043609276280027, -0.8171949074551128, -0.29529286980981667, -0.11641133281441689},
    {-0.34940512120493744, -2.1937472606655355, -1.3628680720422288, -2.3474142927497677, 1.1192386244223502, 0.024337166224580185, 0.5174226522463383, -1.3144888089752238, -1.7526700249991396, 0.5555812889763925, -1.962365987053115, -0.03520029229891482, 0.7056795098676313, -1.072548610756682, -0.8723979742146043, 0.2511610361385387, -1.1603265803370628, 0.26341365881830314, -1.6265937492199103, -1.4203355382697627, -2.0026856213095763, -1.1882856195391907, 0.009827019758250852, -1.145010973234724, -1.3001337656261, -1.8226899205287692, -2.1642567049843793, 0.7498117923954737, -1.2152508295766773, 0.15685785729714027, 0.2457330827187725, 0.40043177705078864},
    {-1.5743022030429001, -2.8485104110901287, -2.3049995728723327, -2.8509783459645828, 0.575151195659017, -0.2681248649521534, -0.7234103881173415, -2.5611357388020672, -2.953310868044459, 0.25251893782313123, -2.5100234855178907, -0.778655901201399, -0.04575132449971455, -2.3853590761781422, -1.9296879026778977, -0.7461102207719751, -2.4469984752048184, -0.07085086025369794, -2.953189776139995, -2.8807393817043896, -2.6685035969746003, -1.542684798739289, -1.0328854511968828, -2.580974102215459, -2.7828349045381517, -2.916724113508402, -2.5186624646400526, -0.34784903058127714, -2.074281230166745, -0.4511016945056107, -0.6715167569616258, -0.3940708711522815},
    {-2.5144017747413105, -3.3846946059082987, -2.9159091206304257, -3.2526393501213233, 0.2332482143362348, -0.22798215015704715, -1.4760919026373338, -3.473836469610238, -3.4261127409322563, 0.09607829282983078, -3.2291025485256983, -1.7179449657583685, 0.1077082189112587, -3.5168981819425036, -2.9719044498069236, -1.1827601912632035, -3.5413038252099147, -0.23248229570132334, -3.8796926731581705, -3.7812187897654663, -3.540376616852966, -2.5834033626590274, -1.1450262247269427, -3.2933654779811636, -3.6998891351325267, -3.5053206636472294, -3.2715404401746717, -0.022554363294598492, -2.942913328581776, -1.6654112062888438, -0.6784735102274356, -0.18495986012228935},
    {-2.971518929573233, -3.4665385888609785, -3.356553454657019, -3.3829320536511234, -0.4540051531933331, -0.38588305204829015, -1.5816056257221696, -4.047295507574986, -3.168883858595853, 0.703947585375435, -3.490657079940997, -2.324053529299685, 0.18160704828859844, -3.6275426503880945, -2.299103527723447, -0.9512792567869114, -3.8905186453277847, -0.3067731731945306, -3.522526304187704, -3.81945439483434, -3.5269787053603756, -3.1569305556035236, -1.3917344742436824, -3.6437297847428893, -3.672979902596643, -3.83675679437656, -3.3326377753881835, 0.11913552497571185, -3.2712647536977664, -2.2294680255074124, -0.4968031695863524, 0.32776479424979715},
    {-1.626343829179813, -3.2584688877051624, -2.8280464251982824, -3.0479711050541303, 1.2830723167787477, 0.47346999608603535, 0.09091588856344117, -3.134065050986631, -2.4283652638479607, 1.5260943679387156, -3.2083294524137944, -1.1278749672117374, 1.1886805944918404, -2.749396741972638, -1.7124766942780736, 0.16059894615676418, -2.616794048523213, 1.1951337817869447, -3.234081566727914, -3.161922303696669, -3.1554076606491646, -2.1600397247199705, -0.1482684803025316, -2.4777841526930593, -2.874901378643096, -3.1462723265083716, -3.1147780380019214, 1.6141866688902506, -2.648093067788169, -0.7846771958546914, 0.655797278372421, 1.4638495494004522},
    {-0.4525425862728416, -2.4888059055145746, -1.8529101927386338, -2.377492557643776, 2.3806040855710853, 0.9315756124937297, 0.43794580004793315, -2.345708802225603, -3.2088447881747926, 1.7274045867020917, -2.1391422556619974, 0.3421429355558073, 1.5928280614024095, -1.7461061451446351, -2.745644796527886, -0.17473307763671886, -1.7657969397237983, 1.3783051252111407, -2.495951062151401, -2.8383504715035572, -2.2016953558854855, -1.0876181171022823, -0.7978164751565153, -1.5649319931432042, -2.45798426671452, -3.0036927824112256, -2.1488194665743086, 1.5182892772855439, -1.465982360223562, 0.3646673385662032, 0.7653118551074197, 1.8615387171619464},
    {-1.4102519767141268, -3.1593263012221984, -2.962390079376799, -3.311495965528367, 0.9427149231905528, 0.492254742654219, -1.1148451003828093, -3.4450425544495933, -4.050996588550244, 0.8756097610278969, -3.323512737450563, -1.0068997781307605, 0.36999331884277364, -3.133066471974979, -3.5311140473249885, -1.0425127313388816, -2.9715081786524853, 0.45408472112029363, -3.6172370059507526, -3.810039962254943, -3.277845287125443, -2.0043822479751463, -1.6395308904221177, -2.663638537803107, -3.3944589930479436, -3.2364265175173363, -2.7704316615903566, 0.4529908525527681, -2.511398209442084, -0.6278126908536401, -0.43320354866072447, 0.37037515163817986},
    {-2.5177175586535365, -3.1569250181833497, -3.470339289529508, -3.258678703701621, 0.42135542479185545, -0.13059114522203202, -1.1268136395912611, -3.8250677427042095, -3.5593600179335994, 0.31881381661917085, -3.45786118252112, -1.6739855384718634, 0.2509965006955319, -3.3230260088357815, -2.9173855513091667, -1.2470387440767996, -3.4135658659917976, -0.33053341656590957, -3.688236599503617, -3.835325541934292, -3.5137590286292095, -2.8118694942561215, -1.2515698636570003, -3.1835345650886038, -3.7544772281281253, -3.5180466569653204, -3.262490209795138, -0.028920381638124326, -3.2239140234277777, -1.1890974515325525, -0.3239123043026364, 0.1738996338090398},
    {-1.6835703813283043, -2.3654401318353373, -2.3136967414675427, -2.6906892464910936, 1.0825316555687876, 0.5460289500246637, -0.36024369359670017, -2.8575107668864734, -4.015811767549423, 0.8182491062360029, -2.295893361493002, -0.45760058137554577, 0.7263359572479433, -2.7432612882492053, -3.4309274595977635, -1.3745446530368657, -2.4725628117622396, 0.40337209010532643, -2.907665095098015, -3.650777361023328, -2.939779198480558, -1.3439334449650147, -1.481884495558661, -2.2653288810885264, -3.1555277659695182, -3.1205853891699755, -2.5382211013515774, 0.06233055773773403, -2.0158261383611062, -0.06308539855474009, -0.5165987116142547, 0.44834988654309904},
    {-1.579089024476691, -2.545303099622233, -2.79285859661516, -3.1608378968809725, 0.7881884925736236, 0.5309959660917414, -0.7269540296330484, -3.2291210897963443, -3.4983489654475703, 1.3814386974962463, -3.206149775914738, -1.2617267119599374, 0.8876240851974382, -2.631834719436149, -2.6444680064164605, -0.3308743573344185, -2.8371326918286646, 0.5921566852333541, -3.413455948958039, -3.4698526692250775, -3.2665520599295697, -1.8188300816732583, -0.5578123403572591, -2.6278842783272247, -3.107198673853667, -3.29055971079274, -2.899907299453831, 0.843930412209401, -2.777701136118856, -0.5117670072729262, 0.0731021633646867, 0.9122658312625015},
    {-1.752934911615713, -3.0799906631852574, -3.0937226348381137, -2.764198567985779, 0.9789593154494302, -0.036940088182870354, -0.8451324268275943, -3.5419663376235264, -3.710945087510303, 0.8239156432948792, -3.3414771294457957, -1.328585727162215, 0.43883418012368985, -3.1009909688035955, -2.906531817988325, -0.300580800642803, -3.1195501534379053, 0.24651974651322386, -3.3045246856426136, -3.498356104514098, -3.1760409022984977, -2.119599569564424, -0.8527151107174169, -2.6186899405606634, -3.5753054372369735, -3.3671757496245407, -3.02433142256959, 0.637243277620915, -2.772680408870045, -0.6873988000095388, -0.018121763620235348, 0.4455717581246641},
    {-1.5705615749736217, -2.855978223725154, -2.7720725403425566, -2.8528098991360453, 1.0691747295398535, 0.3210549300355279, -0.703153428809803, -3.349056149876455, -4.044877967939544, 0.7527733487001402, -2.996434893524397, -0.9680271838610215, 0.6001338136053282, -2.7802106218393234, -2.8923679583277657, -0.9747280151767325, -2.8791851977013483, 0.35244589866783016, -2.9805105008575294, -3.401668531069882, -3.067991935920498, -1.7563161212318352, -1.2633036260355899, -2.704687917585951, -3.494273487122025, -3.3128775423368633, -2.6896408649690033, 0.4490455449182721, -2.1990203671884636, -0.4604745744464079, -0.02120936352488955, 0.8305114343239816},
    {-0.9239877065622767, -2.4692767671168165, -2.507350576235557, -2.5711496458910617, 1.8406700952607191, 0.7780231126522626, 0.0677110768289518, -2.8846352762273737, -3.9691382083605564, 1.6468969286150985, -2.5718188320587836, -0.4566417308046485, 1.2947679712206417, -2.1504739117851415, -2.976469024672092, 0.027370070539621764, -2.5539143685353007, 1.0890420067488158, -2.7824815542740455, -3.305964399506624, -2.166454582031548, -0.9765941009035052, -0.6152284035958966, -1.9922487853885418, -2.8345329423409753, -2.785841950300039, -2.4337983356839885, 1.0456071403315794, -1.8571919517281803, -0.08588233799843532, 0.8203847077482609, 1.379269645933965},
    {2.3818793491939187, -1.6506011066609558, 1.5435032006679095, -1.3283115375096688, 2.3779838199425503, -2.543725143544908, 1.9425697676328009, 1.3562870215533376, -0.6596271756870494, -2.4164029092062473, -0.3503974763397952, 1.6429174588032815, -2.632834196720603, 1.436874306031177, -0.4660024891699361, -2.0372066629483627, 1.5364838388245232, -2.4548978093742955, 0.6188635015599409, 1.1294492080993275, -0.41212186888770663, 0.8747509483297337, -2.3351126769379604, 1.5508201718492938, 0.7670896090000701, -1.1348130305692614, -1.409280783944164, -1.6786864231918386, 1.0149450269039137, 1.9382338179640815, -2.3903791636711174, -2.6958891879554083},
    {2.2211590896626188, -1.9336378253843844, 2.0146140819954312, -1.3661684590818228, 2.7994076100733967, -2.7903897106090585, 2.264077675630985, 1.843867759304138, -0.2854402191759305, -2.0549512606896356, -0.3185930557366493, 2.3436113846650626, -2.4569179357636535, 1.4413795758343857, -0.41314424028853836, -2.3687826773894836, 1.7796116004983276, -2.318552026526847, 0.43797063284649956, 1.536870468568376, -0.4408227922857099, 1.664138340525648, -2.15597013799588, 1.880198348270941, 1.1837399726778113, -0.6468322353782366, -1.6240192406309162, -2.2855443326380667, 1.5042488176984834, 1.8409496819201867, -2.121925612324509, -2.653279818955195},
    {2.6515195200378026, -2.006879951791926, 2.101588536931795, -1.2886163593059814, 3.1415253739684132, -3.0713231124645453, 2.9517308099070863, 1.8232989408427662, -0.9683612363302415, -2.5931237528975757, -0.641090028147175, 2.758355496915227, -2.8829774735915237, 1.9222316322039548, -0.866366398845069, -2.603968317908192, 1.8697592612438716, -2.575422544311195, 0.4476581493177014, 1.6478359189932086, 0.09840077060267163, 1.8713751443799143, -2.9303417579563598, 2.166554546169517, 1.4126916656562079, -0.8974564403559573, -1.777051455785333, -2.253606097711021, 1.6831999142428409, 2.536565708714536, -2.603094703989991, -3.3396899094969577},
    {3.1196219970200203, -1.6941184921878323, 2.0898996497134705, -1.6871472715841487, 3.0332153852650707, -2.7657134327498034, 3.327357956982628, 1.8910517298281977, -0.12354863972994409, -2.3757554900209086, -0.25892732788011313, 2.7155046619156415, -2.770804757594453, 1.649447968736631, -0.17508184229383972, -2.5899108081315125, 2.2095683439004885, -2.475667450312452, 0.7839602136103465, 2.3580989973330198, 0.8232269917312739, 1.8773024521158055, -2.278884897876734, 2.1629475488742975, 1.8331700566132894, -0.6664034551807331, -1.5026239551855507, -1.8267868664965157, 2.102180726439114, 2.5987297589990974, -2.166120385109079, -2.833775365465112},
    {2.790219233368985, -1.5057929820031086, 2.0812693094376966, -1.2602186832299027, 2.7204753667362938, -2.903684325582567, 2.4794527062939435, 1.5133388867319173, -0.14239438163106646, -2.5711936494106182, -0.36688300102840526, 2.0631218677197287, -2.80484882991817, 1.922781347672484, -0.16988721163588455, -1.878496726531139, 1.8806915695579827, -2.785884065208867, 0.30919530737057227, 1.907714273589738, 0.7248427274146306, 1.9513145370283052, -1.9633347306283149, 1.799566401915711, 1.4018606565194893, -0.8164793812768284, -1.3948214552960239, -1.742291717477497, 1.6452951161448945, 2.1804226443287247, -2.582327935240938, -2.504947127445786},
    {2.064207455205121, -1.8762882812690154, 1.8740124541011927, -1.5400419076683411, 2.723261576010044, -3.0387248030361573, 2.5082204134388046, 1.7743259301736531, -0.6014611415472775, -2.8845270823976596, -0.36791643242390104, 2.4958589062060366, -3.009656640522852, 1.7438987622063196, -0.5552608889438346, -1.9238160436342955, 1.7925372129366406, -2.9782121358631928, 0.7793072569734903, 1.7646082104790135, 0.33774474124220477, 2.0148173877358744, -2.3471089835945786, 1.9832693171884659, 1.105382762762633, -0.7341997475880081, -1.2982795451311795, -2.1392740308952667, 1.8248850349544428, 2.1631092449564417, -2.680782328813699, -3.1348583301588415},
    {2.592361513903081, -2.0601274619017134, 2.3773715168831435, -2.1512212364843633, 2.8396043429339395, -3.1179425118627733, 2.5284065639130873, 1.803401135105111, -1.3192220859564427, -2.9110229693418073, -0.7619329622230746, 2.6969761237252063, -3.2939468216040373, 1.6466558826796023, -0.7948504990204672, -2.5770030177724053, 1.927336609403715, -3.4483401782997576, 0.10242048126415706, 1.5616102337994258, 0.13520194050857756, 1.6421162602392925, -2.495031571107314, 1.9931915012956662, 1.1035484306250496, -1.2073697918232316, -1.8740074966275801, -2.843622883521288, 2.1405414326119425, 2.497990768932753, -2.898547243450415, -3.287698364484108},
    {2.8607704232937627, -1.8951374868937578, 2.3417425668201295, -1.7289650490064694, 2.7806310567947956, -3.542175087789544, 2.7617985273449523, 1.8219739857567154, -0.7412523150675082, -3.4458656073658664, -0.5868211243525471, 2.7019653887865105, -3.248931529433187, 1.9108855857436704, -0.30747995576595083, -2.6698355295577665, 2.324243599552267, -2.9899791213002063, 0.45813671219125324, 1.8124981825928883, 0.7690734748981989, 1.831618517754972, -2.618096940006189, 2.309993245815445, 1.3629074744939131, -0.7516683328048895, -1.605962046504152, -2.6098514738423124, 2.221192521205653, 2.5758408486952056, -2.9771791504969207, -3.4693150604895133},
    {3.028827421027555, -1.9614949638126074, 2.4802058277037204, -2.0651193889196384, 3.052044622147126, -3.447799641959228, 3.2155276457711497, 2.09607991400822, -1.0407776151270334, -3.326554734844238, -0.918350995628429, 3.1984082195050734, -3.3443599636257044, 2.0534361357716517, -0.5467352502029161, -2.7590655318315505, 2.3626848291775473, -3.461536149842079, 1.0454038455837558, 1.9716981240937999, 0.5160866800713824, 1.9311630426512034, -2.6583490552115476, 2.317967526660743, 1.649688162790163, -0.8086938122568404, -2.0346246929412746, -2.6693060209777983, 2.018928275173667, 2.859567328210627, -3.2140476160171487, -3.4460777462343266},
    {3.0046890867549187, -1.9786180162469726, 2.5365619076806216, -1.4439075981514167, 3.4403444150907263, -3.7367935597030617, 2.8263608001643687, 2.18206226875553, -0.7801481703383621, -3.2150446463183204, -0.7513700853752988, 3.1344060785729715, -3.4404597167965347, 2.13429870996279, -0.5719713384329256, -2.8974013911448333, 2.4467682895421365, -3.268429399746322, 0.9948050924455526, 1.3908017452418338, 0.2456006560753833, 2.366302090347548, -2.7511313381388347, 2.605330630564289, 1.3801107629427252, -0.24586539474463742, -2.031549008006449, -2.244176319349231, 2.292459533119153, 2.621921908766464, -2.8086399924444825, -3.3178583709399216},
    {3.13665752396622, -1.7937161871065757, 2.3785191648131385, -1.3540974686129643, 3.3123651160772787, -2.8396532136968027, 2.804229152761368, 1.8559327935740815, -0.3792841869137698, -3.0755544665351113, -0.22553952668624913, 2.8997146863695127, -2.900365137950435, 1.8338276484796068, -0.787324903475711, -3.215347473719838, 2.286637973861669, -2.749371564734466, 0.9703128041521845, 1.8499915064861001, 0.39847111649544564, 2.4185219399307436, -2.355274982699672, 1.8918040996754932, 1.190705365716752, -0.99990988953747, -1.8572218966763105, -1.9521772756893085, 2.1435672751701342, 2.8769119995199612, -2.536223043968034, -2.834818818919781},
    {3.3108776974421663, -2.317507514891096, 2.573507289102176, -1.8546206523027042, 3.369389432770632, -3.674967900985936, 3.265996746230563, 2.2961886845114856, -0.23183030678071803, -2.997191775702609, -0.14140922949726156, 2.8624188714702536, -3.7012537735071604, 2.048211623013404, -0.5845449384758733, -2.7259632193261996, 2.241265449884924, -3.6485628496980165, 0.8486224738547347, 2.071811456040702, 0.20587833247940968, 2.3531412241745335, -2.4836666144167103, 2.4788252145831216, 1.6998478543097937, -1.457224598977509, -1.9223301152087664, -2.4997396708173367, 1.8527399396340916, 2.904411899578633, -2.921742124972345, -3.2443722075342594},
    {3.050681320513136, -2.477917659251837, 2.7128796995359044, -2.007727534934509, 3.4927737650769592, -3.5550281766576255, 3.128283786359374, 2.0815097189620593, -0.4828036999404156, -2.9576534050428207, -0.43439765396848573, 2.9777650505857967, -3.0603754979658215, 2.1445625209015167, -0.6354983549968495, -2.876265056494294, 2.033485110406821, -3.364792145348892, 0.5706961404386659, 2.154224292801056, 0.13731272739973785, 1.9554054205369096, -2.7947293557278936, 2.2472066245622795, 1.5290860394145946, -1.3241130196853659, -2.051143667621137, -2.9960932208804323, 2.0692812066388693, 2.9960087765457444, -3.045315681160264, -3.4855688161617273},
    {3.3937239858368136, -1.712014972092618, 2.7530091618585466, -1.5293991063225902, 3.3434199640947115, -3.16403170142029, 3.3528986747398073, 1.883489509775273, -0.6349402620730494, -2.9695946681895538, -0.1195660462577002, 3.241170046548525, -2.7428306426408975, 2.144188263702292, -0.560924472852756, -2.6507821865342374, 2.2575197354240193, -3.0029762067444525, 0.48791759692242825, 1.7093277562792313, 0.6175202536811647, 1.9963309359452894, -2.3145778634643506, 2.3778531538594594, 2.0408126506921813, -1.1472023595574652, -1.6864492262277297, -2.2038966972661282, 2.45751960558483, 3.128580757832716, -2.8324050973668906, -2.8877818391175953},
    {3.1445209866846393, -1.652755102337258, 2.6629626416631935, -1.5010843142567385, 3.144329360428951, -3.0747583732768717, 2.8736435842342862, 1.918184511229161, -1.0721910807588666, -2.898972129368273, 0.2105973600307104, 3.025056556016147, -3.1940050261424306, 1.81282845132295, -0.5995196162020917, -2.8073657734309485, 2.0118346854928655, -3.1562281962472913, 0.18497042510605405, 1.7734555850701395, 0.612614178590741, 2.2641179384192527, -2.695068625323008, 2.4152431266930896, 1.5320722021829865, -1.1414680768627299, -1.474702530714114, -2.3483928291065386, 2.3138545536171176, 3.131138851939019, -3.2387061468257192, -3.0911208581964718},
    {3.1282269871922646, -2.4058542154355966, 2.37751966598126, -1.611544704491191, 3.3961753048204955, -3.2381487399370714, 3.1524501723264606, 1.7814419601299547, -0.7136313141727506, -3.0749645150213096, -0.5301003179699734, 2.887516802412698, -3.0540204895575482, 1.9119118856638326, -0.6739927862750643, -3.072973651683099, 1.8076297611300693, -3.1889134435537825, 0.5200345139185072, 1.9763544778706827, 0.5650712678805927, 2.1320649797846944, -2.9873968198538154, 2.1455516028792405, 1.554198872769037, -1.4726404861054367, -1.8850820583682009, -2.514027149042688, 1.9883335412313472, 2.9213115685603714, -2.7652886221968966, -3.148361781705171},
    {3.2414654752228045, -2.1209092120179007, 2.715147703589841, -1.8479065825688439, 3.8051959022082187, -3.189853223236237, 3.561554511008152, 2.393822659100817, -0.7084638585804254, -2.5468835239742758, -0.5105795369189302, 2.9790415319280608, -2.9382094384004835, 2.220799628318709, -0.25962546745524356, -2.859358535750752, 2.381165898254372, -2.3167686767858684, 0.7845296747510786, 2.3372790508867727, 0.5949802011161186, 2.2671935123018945, -2.498394854808601, 2.4737136180124404, 1.6811224284174602, -1.0980362630013727, -1.8868665114420438, -2.1139722406760515, 2.778655153109365, 2.6511319611893502, -2.3501116071625385, -2.385994448002288},
    {3.4140139553649766, -2.3721296893545176, 2.841430703866339, -1.6889456106425043, 3.2233645687258994, -3.121434105193525, 3.344436624944665, 2.177662370269055, -0.7793296391311508, -3.0135771851490616, -0.30228556348341007, 3.548215679207851, -3.124137290567208, 2.1270106148837513, -0.46158341662962243, -3.0049336146728143, 2.463008089973367, -2.8355682935802125, 1.1759950795292058, 2.547513685764289, 0.748086695321212, 2.0238267589749714, -2.389526294757408, 2.507177652957828, 1.9802121386357139, -1.2586644908211306, -1.8323355638830021, -2.5256857634686036, 2.7625849942762155, 2.6358516220634596, -2.7055854772748336, -2.8951992232257266},
    {3.201495945759208, -2.3744772617242607, 2.6271650144245053, -1.7243975745352134, 3.222860283917402, -3.2605666029036837, 3.5747084581771045, 2.2177589831815867, -0.8395332076353886, -3.1434532320513537, -0.3059281999775386, 3.0339264797625116, -3.2882225888213603, 2.2370841883089403, -0.5276538829244393, -2.9760132558985686, 2.434376011031657, -2.9161681272582394, 0.44008653029245626, 2.0937022499556077, 0.6335755705474692, 1.9567797593127607, -2.74329648122258, 2.6008518173435586, 1.9609296825070681, -1.2604107501701374, -2.0972280823684066, -2.656376199007076, 2.476212610268811, 3.2005129216166424, -3.0526977509936106, -3.342162705923046},
    {3.921063175599589, -2.341914251780777, 3.063590762650541, -1.695826277442801, 3.866583193959707, -3.2345418106724675, 3.6409183896050985, 2.7356645498543255, -0.5694767439946582, -2.9456633519646136, 0.09457411291907865, 3.478632041295964, -3.3111190656577625, 2.465411534147215, -0.0705308798181505, -2.7603539105281887, 2.6448202031447683, -2.940350565268178, 1.2595277733154275, 2.515924108554567, 0.9612630427105345, 2.4194377992839313, -2.8069768112347457, 3.0928675142880606, 2.2327298048745696, -1.009605200646149, -2.015412898220408, -2.316493045836529, 2.7796571217073556, 3.6707683894227965, -2.6033610493779165, -2.955544543860227},
    {3.6068772195544407, -2.3518113537278644, 2.9641093892521395, -1.7075416554091627, 3.3450366780226664, -3.5897317633793224, 3.4438960216066388, 2.5858822876739116, -0.792488548221974, -3.4533028487315764, 0.19428671688747515, 3.3979655379715323, -3.4658083904497623, 2.536596553996367, -0.24117363605166156, -3.296164785527379, 2.5183659794575193, -3.2399426890888035, 1.1327102206711854, 2.44322797668848, 0.8565778192711624, 2.199118204203399, -2.9221727277868883, 2.8723297941020745, 2.3003243984740775, -1.386285948721771, -1.9512748944403087, -2.7968208599621143, 2.501336841814786, 2.989048668096297, -3.119194008902336, -3.266795294205977},
    {4.044514393734086, -2.1916878469593577, 2.6611678099498275, -1.9785464068134506, 3.8165411935620424, -3.4276576004336237, 3.6895395706952994, 3.108727632052589, -0.9350828469123881, -2.881436515529057, 0.08843438262391262, 3.248626727677014, -3.4278844366040326, 2.6954169155474994, 0.06114819721011983, -3.0072317257760908, 2.6310981224226957, -3.2994779833993544, 1.2030991043619372, 2.5073818315974323, 0.6076006864535959, 2.213154062472223, -2.9127919480590534, 3.0278217496479503, 2.856556109255173, -0.9625780905082233, -2.1950839949082166, -2.5864162395413683, 2.409097166121895, 3.555571209283037, -2.5525190801344695, -2.5342978195939976},
    {3.939459771079897, -2.139622438249467, 2.910121525907879, -1.497319980116917, 3.438147220664409, -3.271784442896503, 3.5146551155000476, 2.5463789121651668, -0.9716501750800532, -3.561423401071471, 0.31728656466571215, 3.399923998830064, -3.442388614063013, 2.4708513654595055, -0.3620327420152121, -3.5360662632198143, 2.4684983390061994, -3.7283521104356163, 1.1750719621298478, 2.4490175648080577, 0.9476150772562124, 2.1436355277954844, -3.3294196347909772, 2.8823168037202707, 2.325404902011307, -1.0834419411035445, -1.678557820478656, -2.8001208732693077, 2.714407986955833, 3.4819996008210956, -3.0518417286181965, -3.0742810596148447},
    {3.9386192902502883, -2.488344667753152, 3.158624595382992, -1.9439991546075774, 3.6298063089032215, -3.4283257309482282, 3.881758090228047, 2.81463913369185, -0.9420186609521656, -3.394744930154598, 0.1900804627225168, 3.619387274342677, -3.472771380824323, 3.2560259450367033, -0.13674125279846228, -3.3006224357912566, 3.121520185471919, -3.6548131747037047, 1.217758203372525, 2.8582136075631324, 0.43353161762437414, 1.9831365491712827, -3.2020584172457514, 2.9686054654057563, 2.564744125602015, -1.14423153725828, -2.0388037459869244, -2.5787279885512313, 2.751370549047211, 3.6728152486712, -2.9958403680792585, -3.017509585069071},
    {4.114488488888986, -2.383919386430769, 3.1825150890309146, -1.7264538557889335, 3.5863081283600864, -3.5314809757232837, 3.9192083875075183, 2.902350453586274, -0.2911413051633339, -2.9275064278036664, -0.22136211874186495, 3.3046993356608327, -3.1444532207987135, 2.9648846979344445, 0.454976232071565, -3.1295317791075252, 3.191955516527246, -3.474498218060101, 1.0511458591059217, 2.988510270344303, 0.5226589511581189, 2.2101799734288865, -2.939475632388134, 3.3319744341122726, 2.5905191946424764, -1.2653835392989858, -1.8434686947362005, -2.3471730316011046, 2.6800650074502, 3.901917415422323, -2.9196853878049227, -3.1326943845299975},
    {3.8444844244238796, -2.5707988037710443, 3.0585032961547873, -1.6022169921734957, 3.9549840370130207, -3.916469334023622, 3.817329032979803, 2.796871064860534, -1.1621043900567498, -3.1561519233413775, -0.42473038086939535, 3.5108869122276873, -3.707002628758604, 2.7249846686694728, -0.6614060904461577, -3.165942536196595, 2.894408752829559, -3.5355341641607865, 1.383644133251101, 2.711140308547612, 0.670081854392312, 2.4405934504998426, -3.1687549708187124, 2.9569864404474635, 2.548715233398053, -1.4229768148577653, -1.8693844091133975, -2.7464512535296426, 2.771137241954081, 3.374289268096412, -3.301041049224391, -3.4697962892476473},
    {3.958187184344753, -2.239635931198276, 3.0100747286741667, -1.689657523174982, 3.797800454915544, -3.7085708742236045, 3.6021882865566255, 2.903925069557949, -1.0507238567463477, -3.3030351479697884, -0.39792839412082304, 3.4722438481468907, -3.6022304481289895, 2.944857197218787, -0.5603403994993673, -3.429844639836169, 3.0563136782040634, -3.684455071195604, 1.2499246445720102, 2.6194255678399485, 0.4842282429637883, 2.3367655500605724, -3.2001479072411847, 2.987535030140671, 2.2100612011086422, -1.132015052586038, -2.0030518729148183, -2.679472855996518, 2.719590936718615, 3.783085644512671, -3.2891396087060647, -3.6777517484173936},
    {3.7890078583985636, -2.538066959528126, 2.628017110128319, -1.9696831226756708, 3.7653381270719977, -3.3256349030379124, 3.6592387340860895, 2.507013435324731, -1.5182230849151461, -3.46000801471412, -0.367773159165582, 3.1695186135852587, -3.275727598060081, 2.4683917582253647, -0.7368792862170241, -3.286373622122928, 2.629977391047757, -3.4603615156043843, 0.6390233111892158, 2.0512766041008943, 0.38967307247963406, 2.1310584475345835, -2.954820146488514, 2.8131444343058085, 2.20436599284816, -1.551859912537605, -2.171080200350335, -2.4680566043630976, 2.4089142737697675, 3.6948718843582995, -3.2391397540878613, -3.2612747150847605},
    {3.705417521854278, -2.8234713184721416, 3.2257418288995523, -2.2655313686252008, 3.896185189293588, -3.3988117480900684, 3.6685260986138477, 3.0622337213459305, -1.103296643941998, -3.057996616836262, -0.6112959051445226, 3.125721787482376, -3.5017124746972534, 2.658530425640545, -0.30211891015379483, -3.201146887128709, 2.7447698945842802, -3.317475503533602, 0.361029572606597, 2.2184068867360422, 0.1495782466837072, 2.2353546678372025, -3.372724347219358, 3.1487841696199568, 2.7164660239861202, -1.5246274209129127, -2.075319322230634, -2.4645472375627984, 2.542718706216125, 3.5183471658075964, -3.15317279670866, -3.25193284688131},
    {3.733266820257012, -2.734282196419709, 2.9555600575325935, -2.236997053007116, 3.711513752017081, -3.536683503299466, 3.6907760111430794, 2.9233434882858638, -1.0527576623245585, -3.04501605104148, -0.5845169317253345, 2.876128304265638, -3.546174375390578, 2.587671372147591, -0.6910752552705609, -3.047762606951793, 2.653786537173291, -3.316289960594465, 0.6072488069909656, 2.3617441464242073, 0.34899402626965603, 2.044941160807309, -3.2747278217128075, 2.7683956021019727, 2.28594195549763, -1.4255400537612544, -2.1919570090176057, -2.6372707394746904, 2.420921628349518, 3.3764344284554157, -3.1100735751950035, -3.41976520395883},
    {-0.16090617105941468, 0.7400299827407332, -1.0369653575145041, 0.46343082148707226, -0.03528059079368148, 0.8663591715953433, -1.1468593951896102, -1.2737711755236745, -2.2732622972836545, 0.36665461331322224, 0.8923645535195713, -0.0708019456626221, 0.5622246482374438, 0.0779579265654725, -2.3686299338259413, -0.25741676815538644, -0.5519902806158349, 0.6788725940425422, -1.538193373203154, -2.3956694471122524, -0.12387152671612225, 0.5043864441891851, -0.36802207196443143, -0.5665223308159738, -1.552925852872899, 0.1740239648439291, 0.8923676578503665, -0.5556218057368655, 0.09647925065300449, 0.2819488107126199, -0.19458370474145376, 0.07856912053917493},
    {-0.2647482125022488, -1.0564230451508922, 0.15374512155061731, -0.2921211724409862, 0.8259068044511501, -0.00858657799235451, 0.1691295085421226, 0.22478141102107851, -0.47724797743435887, -0.036934434085723715, 0.08858532056209231, 0.6703359837192334, 0.24759955734408007, 0.09030218918189716, -0.27286431405485906, -0.6953263597092879, 0.0051197244527435475, 0.133828203703728, -0.7788724154307778, -0.7533314519257328, -0.31876108343423937, -0.1934875339319911, -0.6810781705093556, -0.06468613087109297, -0.05931926416995592, -0.45147193774421496, -0.2887969121985104, -0.6080690214342055, -0.0921929982551989, 0.7754154769819712, -0.35657426397949354, 0.008110008125281055},
    {-1.4596904969609945, -1.9685464847265568, -2.1325411007005504, -1.9333117657243395, 0.5074964618872648, 0.32911547767478827, -1.1675830414805455, -2.048394822263833, -3.100028664660386, 0.33827917262470514, -1.9156977322829163, -0.8639321251572389, 0.01648069444319575, -1.9854766910797952, -2.5544318554290415, -1.1020816926331953, -2.546933649088365, 0.029396962686763794, -2.6427637925479557, -2.4664458098695112, -2.5869875671560605, -1.638678183074788, -1.3233535278442319, -1.9963135280188011, -2.757186414355793, -2.2217501761098815, -2.0291060395779272, 0.09492107066845526, -2.1021880229576295, -0.49991523016602457, -0.5757230506504405, 0.14594649180221383},
    {-0.8041980932403117, -1.6318935931544132, -1.3158674863416815, -1.82498848627712, 0.9204587682187857, 0.6243846620572246, -0.6958290356967209, -1.6444909941943517, -2.903209116225953, -0.3958407138777141, -1.2703834382243926, -0.32150727255219597, -0.026966562354647283, -1.9351881043886858, -2.1160109558343407, -0.6913579629617971, -1.8069774588220948, -0.22907324659139755, -1.5860685852311172, -1.6038955798847676, -1.4050479419970439, -1.0847782559274046, -1.019088312813253, -1.720555419252047, -2.184840537382766, -1.508216565917027, -1.2572388990164016, -0.20103332142303854, -1.4283298055689644, -0.6505471165117191, -0.6217824307096226, -0.44211406529633157},
    {-1.8038110008234702, -2.2878636270020247, -2.1086684313336717, -2.2778118227272524, 0.7446211744972216, -0.17666278462410756, -1.0277034157392864, -2.4808777010169254, -2.099488293216153, 0.0950536035314555, -2.5162449162724, -1.3811804873085678, 0.3917309865295623, -2.3441190608953857, -1.380633297310756, -0.5482574813807979, -2.4632442630622142, -0.2122535539572929, -2.060276546280991, -2.5093448303422283, -2.205168333432797, -2.0801883409636965, -0.7924083202014304, -2.3435091327984963, -2.6524580885538516, -2.4989084523025342, -2.162085540464798, 0.4846252650370275, -2.132961277000764, -1.1538551858355692, -0.621897392497999, 0.6625463723138709},
    {-1.6980831888207575, -2.008271706450608, -1.8894213428437108, -2.1197667352325205, 0.5254112688416791, 0.06892792178081371, -0.7131700558228363, -2.1601457319073423, -1.894676872502836, 0.5618828422580825, -2.0216249790439265, -1.0168452479939338, 0.24788262762874702, -1.9056557396164828, -1.1345472697869814, -0.03460305094315141, -1.9128374975827498, 0.18220224763377818, -2.2709212755569235, -2.377499893411163, -1.840484666879196, -1.802839377210162, -0.7167177986035043, -1.960509251807005, -2.3272918149641026, -2.041308035121379, -2.19648991628211, 0.008224941495190922, -1.7140416563843381, -1.0130604435246866, -0.21510362503736083, -0.033658018313659},
    {-2.1841974689175734, -2.044615775479009, -1.8733730643581192, -2.155469208192262, 0.05349296023450062, 0.15924700894078542, -0.9379820205867604, -2.4739332380592036, -2.3950064256333885, 0.45022859796754444, -1.8498535922194506, -1.6737779646009288, 0.3465427745013295, -2.179507701315445, -1.3441007623959846, -0.5475207219624921, -2.2363066978781463, 0.03470314524262511, -2.3978996502178704, -2.283056116695524, -1.9252160349805363, -2.0930312042123034, -0.6079323626182611, -2.2292757470535007, -2.516550961186001, -2.011168294928054, -2.0722091898619084, 0.3068464851475424, -2.38100458676395, -0.879588694667891, -0.20894422510160934, 0.10098161659988796},
    {-1.198071766465942, -1.6280640506186084, -1.3408117179593506, -1.9735703672692866, 0.8175458457622585, 0.5137920692070909, -0.7071762227728507, -1.6346027561856056, -1.5370786074472857, 0.6011536459934689, -1.3527742818300539, -1.172482645074315, 0.4563490194660711, -1.5002936485994056, -1.2201440584405197, -0.1708517098172993, -1.9201872615176996, -0.26765909513093156, -2.0897599840834356, -1.7961339326195542, -1.2425495956401744, -1.4340410635426255, -0.6319455321073474, -1.4975329696460422, -1.331244200585509, -1.8236187041302345, -1.6407083779964733, -0.056454669716639816, -1.257542144443109, -0.5423607633465619, -0.22335178033088857, 0.09478601221740178},
    {-1.2288678012627383, -1.918380784488136, -1.4228275472277554, -1.9352215228722922, 0.8442925998136911, 0.08968809193087303, -0.7195238021136164, -1.8951745628004342, -2.044082988052399, 0.3413118106999661, -2.0622729129945934, -1.3189524395983865, 0.5017411127409603, -2.0077337853878325, -1.6872972812489553, -0.6030402599917186, -1.675359652597821, -0.14757698177796058, -1.9435455487471442, -1.614913869220512, -2.0512613867067886, -1.9805067657210156, -0.8753573863709961, -1.7546728626098949, -1.9956617706451651, -1.811583726446714, -2.0451853820652395, -0.34653058818359295, -1.9463924149793703, -0.6424923263700326, -0.42329301354011695, -0.26113458348732776},
    {-1.0418416812917188, -1.8556163061526267, -2.1452519138678356, -2.0317998467738723, 0.6993306282878463, 0.33865234484915724, -0.7468503318039993, -2.1567498354179158, -2.1386634126267876, 1.2187937321066826, -1.8956191664773976, -0.7455303413481494, 1.0626236619585816, -2.1102375221881826, -1.9598163513334739, -0.29070469027831924, -1.736330879435438, 0.41210387488118577, -2.5546389227267308, -2.1985863927040445, -2.299442351031239, -1.9627817775776422, -0.5547501547887123, -1.9484192311602808, -2.5013517382751758, -2.183278894675786, -1.8194771151877642, 1.0159301063910577, -2.2122258907513386, -1.5374060066726325, 0.47640122534612017, 0.4692780308915762},
    {-1.7055878510802858, -1.0471508709972819, -1.8569505822169428, -0.9804370466096316, -0.13653531352303935, 0.8058633306573567, -1.115614047664246, -1.9975018361673538, -2.2702516120718275, 0.5319639616356495, -1.103189469790764, -0.9559186648645234, 1.0953277898030012, -1.4220749012352247, -2.038094839095705, -0.9423858945146839, -1.4809926906833546, 0.29541474544041624, -2.047593304591876, -2.260698766410833, -1.755578452720584, -1.5788194224336842, -0.6773318056937706, -1.905787257981167, -1.8906601626355424, -1.4996358366920854, -1.1789983788539429, -0.023003001769511755, -1.0673951454835788, -1.3520666398176124, -0.37914678279461095, -0.05103090812925251},
    {-1.5583403721622435, -1.4384775406713577, -1.8183249662895413, -1.9611459460185396, 0.8175391210557079, 0.8426786166012571, -0.779917781066722, -2.0545460391846855, -2.377377265491775, 0.5706013949574502, -1.9525298385559173, -0.9683424400233933, 0.6607068945620457, -2.26751557184215, -2.1624340635211237, -0.3688922386054699, -1.9642768181683343, -0.11574370953965223, -2.4225024519109164, -2.4218054710001207, -1.6965132133704843, -1.5388957963499799, -0.5114447865850344, -2.256431469787753, -2.2831463305584974, -2.2961604538000193, -1.9015048751030166, 0.13716717754485386, -1.6782316979476521, -0.7801149192433834, -0.19113240903614673, -0.014362529161161324},
    {-1.9491341705908005, -1.4638021190235158, -2.1902352974809913, -1.9860325455561114, -0.1758204390172087, 0.5530971450292115, -1.4998964310981875, -2.1975370457073256, -2.4887138602863472, 0.5716818103466813, -1.586594749109059, -1.351433053149973, 0.5030065682767562, -2.348258746867998, -2.064139282656912, -0.5703889113542789, -2.151039141166517, -0.6909671503232322, -2.913125141765191, -2.3059242954305166, -2.235794437488847, -1.6286245702838111, -0.9120619873507394, -2.237256655694683, -2.5974619348126327, -2.4005257953144854, -1.9268426633075908, 0.11665911183154076, -2.0742687282849133, -0.9311619360007557, -0.09742730944667315, 0.12751402932575814},
    {-1.641771061103208, -1.9075647190982594, -1.8153418530818746, -2.219238832458523, 0.7180758614913456, 0.5128018605661546, -1.4083012402867467, -2.0814920068774607, -2.428792696971254, 0.555486808435905, -1.9671309034508695, -0.9719631551820647, 0.29598018773540735, -2.2242438512358023, -2.2842718357781577, -0.7481916477413614, -2.242714811951549, -0.2641734355464608, -2.540688087174428, -2.3021290643603325, -1.9534915557189216, -0.8621277712470202, -1.2785776452971904, -1.7139929871087163, -2.263573957809791, -2.707293907524665, -2.146734767769309, -0.3667608846323834, -1.6929776632509643, -0.8401157130494663, -0.7946927830334851, 0.33625428901082727},
    {-1.5475883230442713, -1.7922651210979783, -2.02690979708264, -2.0371397071457196, 0.9225559157692917, 0.6575445246484155, -1.054071059048725, -2.197793731209703, -2.8054129854789216, 1.25088795330164, -1.6942598706859346, -0.8120003638539849, 0.5357192568718754, -2.25079370696335, -2.7040774169938273, -0.7023862326118643, -2.1173562598934867, 0.17978133999076762, -2.5298617910853425, -2.6167958043047888, -1.9975069186669099, -1.3129060035826965, -0.8248319505154387, -2.2440680072431807, -2.910358302820063, -2.3156096700913475, -1.6893589002483784, 0.378391561315911, -2.0934819482654583, -0.9868626115636011, -0.48849117130123354, 0.5235906059363451},
    {-1.1594057252585932, -2.1464278725264743, -1.4766650951258773, -2.267986767976251, 0.8201205094064878, 0.20816347966441415, -0.6445124923636882, -2.278964519518988, -2.8321346938689094, 0.3750138713959492, -1.6637229902213762, -0.7509133632264796, 0.030224475219962462, -1.6114832304559197, -2.7856967438008713, -1.1566312151515397, -1.9649554378495737, 0.3013661890670696, -2.2785051878939915, -2.738833377829565, -1.9425464741002056, -1.2771367267739822, -1.1618491872010075, -1.737864432679911, -2.4552477890307896, -2.5364555334337053, -2.029520031389996, -0.28257834481321753, -1.3275428347309801, -0.3273810716839665, -0.7535306926573957, 0.45752376077868784},
    {-1.0809523206954572, -1.7855798844583732, -1.322349202953418, -1.9447267397084262, 1.1539408821394095, 0.40966403919010863, -0.6818274370164903, -1.9984200791839577, -3.310837768268035, 0.5242679488340825, -1.3021047368307168, -0.3515647912726723, 0.8942325854174649, -1.538176805547632, -3.005078083002421, -0.9712429558518844, -1.7190712669365953, 0.11782824297365346, -1.8165638119875733, -2.4065243914085706, -1.941738121706185, -0.8998844936142403, -1.3166239951177434, -1.434227327935192, -1.7525864918141958, -2.168775727125874, -1.9374966776245797, -0.025319879888791575, -1.3399883111949535, 0.027342457567223352, -0.311236898522749, 0.6022827221465381},
    {-0.4978514884060468, -2.0766694201898384, -1.46176894699746, -2.2085643019873213, 1.2788693817677366, 0.5246796728363083, -0.019635538526928533, -1.6738585639244072, -3.3571701961801743, 0.7666661695623669, -1.2752363165845975, 0.4005135132526907, 0.6457589030577444, -0.9543275974979919, -2.9264759872389163, -0.7770626661116148, -1.5297370159779, 0.3361187147231637, -1.8056127820396632, -2.133592351662122, -1.7947257461914286, -0.5586588800802019, -1.2271726286450706, -1.435738854664417, -1.752172314395783, -2.0300909014760147, -2.0205593284321512, 0.3323825446043394, -1.241242180950442, 0.2244635644280507, -0.49865508352109517, 0.5406758563975238},
    {-0.5396866244097143, -1.8203376525882444, -1.5085991716434042, -2.0481087010227954, 1.317680944435559, 0.4610008921096711, -0.5996308625770091, -2.0244155797262544, -3.1512383337757446, 0.7110924679078747, -1.639071755540918, 0.10458993721516102, 0.2883648426583077, -1.685062602774735, -3.170402322351732, -0.958313464745822, -1.3895929929542372, -0.32473351748743445, -1.9040520583468679, -2.6499660426063834, -1.7308975728877858, -0.6341362693982334, -1.3283333832761837, -1.6010351732708723, -2.242093896996972, -2.1303878629860873, -1.90197832298779, -0.11977160217075164, -1.3634640927404313, 0.2002457675770611, -0.5129502404860543, 0.27546481674837314},
    {-1.6761132816154511, -2.3150425340198355, -1.8295891079684012, -2.300366932654834, 0.6510895797673713, 0.6945995122364583, -1.1722278628921552, -2.60308298151593, -2.9046112436042963, 0.41202378961549335, -2.182583703582984, -0.710001913180424, 0.3010473892989061, -2.207047040387165, -3.0406129853332557, -1.4333362760145556, -2.334029794518275, -0.3158873655258255, -2.7158221580340096, -3.0912899920851085, -2.5948521904766753, -1.1844498087870046, -1.3654838976658628, -2.2321134620090075, -2.8488750308873825, -2.82362403254885, -2.222614370342256, -0.27162564633893005, -1.9092552216870464, -0.38761568763494525, -0.5957077071490281, 0.26576890022378064},
    {-1.879938574974775, -2.275777779364937, -1.9586220866382196, -2.5660911939298567, 0.8320723282099731, 1.0212165684657875, -0.795689161349079, -3.039363258706105, -3.636567438869505, 1.0645298515815214, -1.9148290789461786, -0.55278169715524, 1.0151885258792857, -1.9226647460146262, -3.407716705190015, -1.0051788925661782, -2.3416137335622516, 0.4733269950137495, -2.803380695783722, -3.070904552522866, -2.5854880753632474, -1.069450217021115, -1.2090772090810427, -2.4068720776110624, -3.160432090253943, -2.4991563548301903, -2.4571974116623507, 0.07652060367908804, -1.840573226281295, -0.159380660990956, -0.2948887518735355, 0.7620361497927436},
    {-1.0828236517397425, -2.8247675977333984, -2.0138794365159898, -2.5829745740732486, 2.26069864979704, 0.8440259084717656, -0.25549630091207526, -2.38695072477224, -4.373202890273202, 1.2751150945630694, -1.912825635607437, 0.2402241338874752, 1.1597241420192064, -1.7250329687759745, -4.362760321392574, -1.5457929351401816, -2.1953593677033414, 0.7442280509192741, -3.0944304570737358, -3.354479030638677, -2.2438558792840246, -0.4361163175644448, -2.10073968687362, -1.6099016234363819, -2.78849198856256, -2.9641358033912026, -2.3955464750019244, 0.5926416822694925, -1.4560311718840726, 0.8062506036504502, -0.46613078220188864, 1.228186567915693},
    {0.20761339197206558, -1.5757407046435337, -0.9459769002893645, -1.281989040156682, 2.5741662436677997, 1.5810875026320326, 0.08494368711952431, -1.781734762476172, -4.634123749598699, 1.585785423856165, -0.6454991308807628, 1.4886654444360716, 1.2189495519734788, -0.23415450269892787, -4.846498291551871, -1.2988895711483273, -0.7660336385862492, 1.1432806868087293, -2.083133954595659, -2.540857555351511, -1.205597040196232, 0.6638624688469857, -1.8216016810226185, -0.9024716964815919, -2.351486223987746, -1.98293204877668, -0.9898460677831138, 0.7630057376055962, -0.4928455477967948, 1.578682371689547, -0.5789752947121781, 1.6253603161215469},
    {-0.5153948131928605, -1.9738127329594497, -1.60447278257475, -2.0287851761830633, 1.9017911199091115, 1.2306932660625431, -0.9074263710589606, -2.685205398778184, -4.666933291773313, 0.8642982891703206, -1.2402832850380094, 0.5870198545149459, 0.5763565735493893, -1.3000857415868248, -4.702970727253687, -1.6121276781850327, -1.7583403817802108, 0.4864553647848333, -2.7532301658261074, -3.3588102469704233, -1.965883184924663, -0.05520470541220064, -2.2114160282175495, -1.6337965266295724, -2.9356826281849675, -2.327398708432224, -1.819248742610884, 0.26441272782264336, -1.412685496160038, 0.8544067590870172, -0.991583404012149, 0.7729787749506163},
    {-1.7696275305335583, -2.4090702600847864, -2.484607059663644, -2.816443116026437, 1.1798903444176294, 0.2893568127642593, -0.9072476798843085, -3.494086541509278, -4.486284270300803, 0.8750647585691919, -2.374363687929212, -0.4647785634152046, 0.4761446800018296, -2.2484235209138883, -4.050213895795006, -1.7362354865897431, -2.7894225875017047, -0.005453858463054927, -3.1901537368225434, -3.505546465366115, -2.7009120566183107, -1.2174168666836391, -1.9194307919827351, -2.4074624241200517, -3.423301733719384, -3.4641936371828916, -2.2158480363018387, 0.08054282327288825, -2.2961891215996415, -0.040159173415547374, -0.8527906578036121, 0.32388076140322125},
    {-1.0560200104860593, -1.8182952111969888, -1.6880701533624267, -1.9943847995577806, 1.6414352939173702, 0.8703780114082991, -0.41454721971519715, -2.5446625156957277, -4.471703013999376, 1.1772006367000414, -1.1150814410560173, 0.2458333640364147, 0.5043685940892683, -1.4706999196970136, -4.4109854178712355, -1.7424872626403445, -1.7248369799091139, 0.2756036733223245, -2.4134378119673356, -3.185733740915719, -1.8598559607267369, -0.383590116092674, -2.169865066464943, -1.666418054530042, -2.4291735216669883, -2.247960888626914, -1.7318288215940651, -0.1222614605722198, -1.2756087750482106, 0.8784102465046622, -1.030646546869848, 0.7857132196693097},
    {-1.0767759261538679, -1.6105950670034448, -2.0323439979644315, -1.9185805596350693, 1.3795597779061135, 1.1429028389913984, -0.7812546542834159, -2.874976166209856, -4.512986497624223, 1.5202887496104367, -1.3376110440035265, -0.13972047690751005, 1.0898237396478228, -1.6501500475962672, -4.4140227609163905, -0.7937599787389313, -2.3302104988613475, 1.1352980333336515, -2.946005389402383, -3.7295531596692393, -2.102619123775407, -0.26736067217406545, -1.2185400937066482, -2.0993641436611052, -3.058020612180147, -2.6330422095042154, -1.6813467213844646, 0.4152107695404525, -1.6059571984356877, 0.5490863055760226, -0.28770630483133186, 1.2353162743008228},
    {-1.3353598585074606, -2.344431849518666, -2.2650457534830837, -2.001405536954245, 1.4268257714979526, 0.7910915180936013, -0.9903993565326984, -2.9014214584891014, -4.562942410523881, 1.0081977260250057, -1.5997744180785076, -0.09820202100244797, 0.6018388700849772, -1.8731577001687765, -4.279755167771614, -1.081549605163067, -2.2166344517999077, 0.25666425368768964, -2.7731294598402294, -3.741263127336593, -1.9649700287858518, -0.45468548715088947, -1.7894059920791636, -2.0072536401817347, -3.3237540143618176, -2.7288487059444417, -1.8566884025231418, -0.03479104112478526, -1.3420202452229613, 0.7564047144265962, -0.6229274696948405, 0.7660988179571756},
    {-0.9748890366470281, -2.333766797011366, -1.70640789934385, -2.198323329657858, 1.916521084606969, 1.1249041919328782, -0.648986028174312, -2.645070671795384, -4.778373936292923, 1.3758066088943661, -1.407536928216301, 0.5333887041179622, 0.692195827778736, -1.511037676283462, -4.671223085727938, -1.4341353848778022, -1.7878554487854708, 0.3453037035155882, -2.381433231689899, -3.4980644015959874, -2.0383608117777814, -0.033210504762745285, -1.9175891433047396, -1.902328517302056, -3.0823333027867847, -2.772628963672862, -1.6229672816064704, -0.11204443109608171, -1.275752092295542, 0.7412535244303468, -0.9270534971040578, 1.0460702144212093},
    {-0.17087191477394875, -1.4962405214381356, -1.0128259074775559, -1.4867914121103847, 1.895290594731125, 1.440886367986499, -0.9276633342263778, -2.3603132788521424, -5.015315910438957, 1.9502564262692776, -0.8241834138557814, 0.6172679698929914, 1.2428320348784088, -0.8270381816517757, -4.823369215598073, -0.992176727862759, -1.4580966534433604, 1.1849871107340815, -2.3609962402848486, -3.14263962936421, -1.3401786823183424, 0.6385336736874047, -1.6569524626093572, -1.376414675950772, -2.710674537257635, -2.0434404841433915, -1.2485744948169042, 0.2613123277856954, -0.7295444186367033, 1.332628011273701, -0.16623754389278977, 1.5892443683050252}
};

static const float b1[32] = {5.870716103389764, 5.447139836677649, 5.594042714812008, 5.398296887631607, 5.912304629748085, 5.666980628297924, 5.849313889846942, 5.618715559088363, 5.803036092821769, 5.802720704986261, 5.537846039306865, 5.696069061871882, 5.854354530894921, 5.568713675828145, 5.873603249963059, 5.924519375240075, 5.501893087181265, 5.9605190890487645, 5.50721892339864, 5.698543592822795, 5.5802521862630075, 5.496508324213435, 5.906015944266935, 5.5061579320996294, 5.620973349668999, 5.5579485966131665, 5.443153735126379, 5.99419914706584, 5.451195636987493, 5.689447467130415, 5.818884642782223, 5.999699714172486};

static const float w2[32][16] = {
    {4.8622168852962915, 4.937477271410584, 5.617221277276211, 5.172722365814862, 5.254423050147383, 4.982562332799695, 5.302955382974576, 5.210151934187987, 5.205713772298933, 5.494750800329911, 4.716850402404384, 3.076866102274954, 5.198156227034846, 5.05058626533374, 5.292463056464528, 5.5123049480224715},
    {4.547780627592256, 4.591240959751421, 5.160496058347099, 4.803244932964033, 5.025626739485672, 4.678843933990714, 4.660001506245233, 4.667713802057275, 4.573957035720634, 4.308259544469356, 4.883464084806717, 3.2762084127396127, 4.801771144294616, 4.949387911827229, 4.608776417279001, 4.728885175095477},
    {4.779887059849875, 4.513023404341064, 4.732876169305807, 4.776149284838257, 4.772004025949686, 4.779493118636375, 4.484828652744933, 4.681475714964149, 4.459643618146982, 4.734403928343339, 4.4974123534265145, 3.206522862288223, 4.686637366227061, 4.766239717516411, 5.07319379680074, 4.526321894186172},
    {4.732242621154431, 4.7407159087420965, 5.3593183178118355, 4.80381261592562, 4.615248451700023, 4.65772675058898, 4.794771005079938, 5.21075583344891, 4.829221620669415, 4.241171834237958, 4.7841050702974774, 3.347092305896503, 4.910108107996949, 4.526308066435367, 4.738704093597875, 4.819142089024063},
    {4.795850126972679, 5.428242120003811, 5.050705066181653, 4.765466188770326, 5.292621190925876, 5.031413317918972, 5.553278561544961, 4.9870083651597525, 4.937766235747693, 4.643112767928262, 5.5510913230069905, 2.969963546828046, 4.657306435453525, 5.3477169703638525, 5.50975128814466, 4.868550552580707},
    {4.720472330330656, 4.434722526872197, 4.499579513576684, 5.100175847188215, 4.7786004049585, 5.005212214784679, 4.373326366643137, 4.654695358332825, 4.402112305590676, 4.9538106784646265, 4.537430627778309, 3.0830865801319502, 5.104545058372893, 4.7344487181445825, 4.846152991002783, 4.832131606321878},
    {5.419886368956466, 5.51297927564983, 5.235708114686315, 5.240664161859757, 5.392353100971038, 5.0653534734302115, 5.577124920147999, 5.283075781557185, 5.495312324797505, 5.347788836866609, 5.673245866675537, 3.6422950769910156, 5.508908680836939, 5.091430787616751, 5.338598166917098, 5.433204039903885},
    {4.628535358310703, 4.962557353121519, 4.947838037138858, 4.8167111929625825, 4.624980194594819, 4.882404119355928, 5.109599818713929, 4.698888144571859, 4.488968776976194, 4.9985200387786115, 5.038861998063337, 3.15024447845597, 4.487578900685228, 4.630884210977583, 4.579060256037536, 4.714394776582872},
    {5.565599162993464, 5.472281840872913, 5.83454890712616, 5.104137532320526, 5.530191898811532, 5.104629335264612, 5.186630191416179, 5.165576157370644, 5.676943293395513, 5.196111619812306, 5.629228027737582, 3.912827643082114, 5.642595863616771, 5.3161452884461395, 5.323381262263665, 5.407093467869704},
    {4.215602222869777, 4.958889067165018, 4.763459766691359, 4.632896740947831, 4.6648613943892645, 4.610822362648161, 4.534136022941802, 4.501432232260287, 4.321278266000304, 4.610937407559533, 4.619125510899792, 3.138497243937025, 4.938249145879882, 4.374616215729199, 4.906631089898174, 4.304061116097902},
    {4.36733183551629, 4.043630043973641, 4.472818857130685, 4.774682443246173, 4.344823976079316, 4.645747225966059, 4.5706582917556515, 4.433214119979596, 4.430290854149604, 4.77161738652969, 4.521609815702259, 3.066942703424076, 4.339630786288418, 4.910153707150564, 4.741309394523035, 4.608807429978028},
    {4.8417133674252, 5.358119763294895, 4.965617415762546, 4.821341088018464, 5.019853841923232, 4.810278858632471, 5.4103541200412675, 5.050324426602372, 4.849483918463127, 5.1730638773659905, 5.542205120201918, 3.7581637222486153, 5.2868798153174135, 4.351947061703043, 5.276720683997117, 4.9321898210746005},
    {4.3434517601347995, 4.573588402950777, 4.795660605460644, 4.592463822833075, 4.436617874958824, 4.674028625735016, 4.4466139257692205, 5.011304695199881, 5.163558468136153, 4.316589693120938, 4.6781612813586815, 2.981849050327345, 4.904689419467029, 4.755207135527791, 4.948702158964348, 4.669239324891225},
    {5.0323839760070115, 4.184450626802917, 5.040587959590719, 4.8078191608125325, 4.713946803161704, 4.225863512065591, 4.695228894286674, 5.20219217672835, 4.393555014333239, 4.924377012879624, 5.031219134879992, 3.0035017676253117, 5.146737041961679, 4.671077549639268, 4.4549107305070335, 4.636188958280239},
    {5.523218477466807, 5.1835486230687104, 5.828896091483732, 5.080540320774136, 5.56443639770885, 5.343011133983583, 5.388479415873179, 5.5309444447311895, 5.370676410794105, 4.874075004479368, 5.481185863567383, 3.5236070217163884, 5.52993350476725, 5.249302137773059, 5.31912409376077, 5.0559305721573695},
    {5.045446769962977, 5.355984631177677, 5.109604117494274, 5.168044005228844, 4.6658236065861525, 5.02889636910656, 5.425202859680842, 4.923379656253846, 5.160719103809248, 4.971840998412919, 4.8269784351132685, 2.968352956838664, 5.145569841321795, 4.758846911077186, 4.515297510620026, 4.858444465100164},
    {4.6448444791720025, 4.717212059140772, 5.4114075497999945, 4.345643624829928, 5.219739673444155, 4.592948102841021, 5.163767978491199, 4.648632026879175, 4.617094050879475, 4.78800832227522, 4.971359042482098, 3.3804836129995657, 4.803992436465633, 5.211367155673785, 4.819670213409697, 4.713323707014202},
    {4.503113355491058, 4.918444953654959, 5.033486426226845, 4.475451461233166, 4.958649417640285, 5.06713838149878, 5.090090193260152, 4.715238179347255, 4.559011995965515, 4.88805197743607, 4.521174554902445, 3.2569930419769415, 4.790429445099315, 4.497941312872021, 4.40750026352422, 4.6805674681381095},
    {4.576588269506804, 3.9898121243862827, 5.116110701897144, 4.5029265162216685, 4.794750335437164, 4.669814390108765, 4.7088763232517445, 4.962387870155307, 4.4387765861164254, 4.624983706260973, 4.992917019496435, 2.6886310629712815, 4.713341317816957, 4.859905310639595, 4.523590793635685, 4.697656651034718},
    {4.682744920625634, 4.987446599272439, 4.829529741710686, 4.992014768018389, 5.009145393607726, 4.8153977839411395, 4.5503097761133855, 4.722348182288966, 4.658968380322967, 4.814081710953112, 5.05147574760124, 3.354930443962075, 5.137718244830392, 4.7127715762646405, 4.704960814902779, 4.523852320299265},
    {4.487509352907211, 4.325631717751004, 4.942120526195929, 4.295045932708528, 4.246286245378619, 4.657813632946462, 4.492036254114178, 4.5465189755048145, 4.413681275041147, 4.743113398266211, 4.915051121942979, 2.8984154297449116, 4.292220914991854, 4.555040941308213, 4.390978057583855, 4.31389251723704},
    {4.678387590871641, 4.6135709116527766, 4.557102139269356, 4.72011963465875, 4.792035314477455, 4.427469030434188, 4.530142442465964, 5.175794164317173, 4.591864344834111, 5.209207350169709, 4.78790437445187, 2.742381338753053, 4.689976386487434, 4.801679230705232, 4.649563700806369, 4.655281862895275},
    {4.8002989575116075, 5.532699571691833, 4.7598479977112325, 4.865092255721084, 4.943477079500659, 5.484804238952452, 5.3939822534054, 5.318426689133, 5.264134262578086, 5.136225513149175, 5.173819667950795, 3.078081802793715, 5.282901129634723, 4.7405357596497995, 5.13754303739668, 5.162169226050699},
    {4.668658732255413, 4.988195599398209, 4.516177411071392, 4.575941881590808, 4.967321673772458, 4.8282855273111585, 4.996443606811548, 4.701436325810968, 5.050414371205659, 4.842613790112975, 4.566629281594457, 3.0408163094995975, 4.79617479020578, 4.901033496564592, 4.954870634791628, 4.8612701108505805},
    {4.697108995430048, 4.567600951891505, 4.89869455894055, 4.625339909890182, 4.462308388781391, 4.916566385130602, 4.758909038812901, 4.7121776320875135, 4.5949951377580796, 4.920684575327916, 5.166178461337751, 3.825615675920681, 4.533170262898382, 4.565532313877006, 4.536480147974763, 4.445640798699243},
    {4.63400711231238, 4.258678810429974, 4.354352972099001, 4.621266673640333, 4.414010218825792, 4.791891922272345, 4.813122912540588, 4.5371388000627295, 4.467122614189037, 4.938617032779408, 4.184578635372787, 3.0899400884462924, 5.044684395300835, 5.089496119671326, 4.255212066614549, 4.556982383347283},
    {4.777599065326489, 4.615429778446909, 4.457640679327239, 4.916871343835794, 4.905051450956122, 5.016760963102137, 4.892991589998674, 4.890614696938248, 4.570483205140506, 4.383147250712898, 4.95172948802312, 3.38989460060024, 4.808669685619424, 4.726808365300423, 4.423905444964749, 4.677831825327925},
    {4.411310275470046, 4.4095765961393205, 4.854868435582017, 4.362114412647586, 4.7195830339817295, 4.610439783970911, 4.75702572368276, 4.606551221035667, 4.428032997525812, 4.693428541306279, 4.695507320961534, 3.3555458295146625, 4.563758545129281, 4.224358935759279, 4.727307452898161, 4.715919166993942},
    {4.719470695489539, 4.639996381634426, 3.9987085296267066, 4.82060006328197, 4.80942087440125, 4.6650973731810685, 4.557352733089396, 4.633745257767449, 4.446025941508162, 5.148288671816465, 4.439566991144492, 3.4332289454031564, 4.635205499552023, 5.02420300183791, 4.78889296840327, 4.858034995148603},
    {4.832504880742725, 5.387426625852688, 5.074462175434553, 5.096577374401634, 4.958442759037405, 5.289298716503645, 5.100115395952625, 5.026631084592159, 5.13162489548601, 5.134242822702913, 4.818030727590834, 3.408784768855274, 4.876052483895854, 5.2136897420851795, 5.2370314158464595, 5.220155274719437},
    {4.623302088874641, 5.221033410653051, 4.841307785347192, 4.946949452101997, 4.576751442006697, 4.926246113729038, 5.562682670287042, 5.027523237474313, 5.087894473307466, 4.992646316186382, 5.302690355433305, 3.554771041048381, 4.985195721809014, 4.876628799226119, 4.722988317702562, 4.601257858114666},
    {4.867442223555326, 5.372086180221531, 5.29812418527462, 4.6154471430073, 4.515194443637542, 4.624531342064994, 5.2631158726741605, 4.264712058954733, 4.4493890293247125, 4.72009768393992, 4.854990513895197, 3.217121143866568, 4.937999835452265, 4.547491201890343, 4.299653177443899, 4.762054429170556}
};

static const float b2[16] = {4.7479865419432175, 4.943122571412432, 4.644592924653292, 4.928104729910006, 4.857092514714107, 4.568454371304108, 4.841971827361441, 4.718586744155925, 4.848622495448911, 4.8211554295716965, 4.7726536448580275, 4.04596204338435, 4.719101538899852, 4.761306713270076, 4.9403495694384185, 4.569610352460385};

static const float w3[16][12] = {
    {-3.626610607655593, -3.383598006173712, -3.845469644435716, -2.8919643359389653, -4.104531091537965, -3.5954354612465296, -3.7347892109808143, -2.8997315593049855, -3.7435598098832212, -2.830290980595567, -3.8097312360154847, -3.3734825419041163},
    {-4.0586481262322165, -3.4446405932024122, -3.677702859582674, -3.7420157567925676, -3.4744262451929457, -3.4822108257661464, -3.336771256728233, -3.4661173965268075, -3.0318587321095953, -3.6879347349881, -3.959988111511982, -3.239616725997297},
    {-3.652746334868578, -4.1708034410242, -3.2392346873743603, -2.9358945006455217, -3.4604817757194417, -3.3672669399223114, -3.7896834908090167, -3.21379626171374, -3.3003150855732124, -3.4344854832705596, -4.023184632738371, -3.136736990825762},
    {-3.0718557473018016, -2.9276963330990977, -3.2095301745810705, -3.0977653892945973, -3.4483495812871396, -3.677329661244757, -3.9825338023041144, -3.520789943237217, -3.4442633414993447, -3.5959431271534696, -3.179526909681178, -3.714726374922901},
    {-3.7392813740333, -4.117460755161294, -3.4657834219873043, -3.8666650971691627, -3.1825961812811867, -3.3670558415435683, -3.678291562298136, -2.9085023823164127, -3.6287745084976875, -3.2464231476055434, -3.389793589326353, -3.6712308587335043},
    {-3.239780596265965, -3.503369254437798, -3.8063081801214693, -3.3587367789027645, -3.569423804667704, -3.829896545591236, -2.7904154956521414, -3.7077965915455042, -3.416618514703985, -3.4142920119884343, -3.7628816281759057, -3.939432860903474},
    {-3.611754770380703, -3.4269873747063717, -3.7256734494578456, -4.011446719337098, -3.306329867054912, -4.010339271870443, -3.1475328857536296, -3.3217856707152826, -3.3857650791603717, -3.393564406575773, -3.7103428178355498, -3.273070051188162},
    {-4.0566764280939775, -2.9001863284061797, -2.9820040964712877, -3.8161533378899555, -3.8515322178857967, -2.9493388116420696, -3.3439286160500146, -3.565925175172893, -3.4574405668046557, -3.0722254031165384, -2.8470769760697032, -3.737884564023444},
    {-3.1555141530034394, -3.41644693305457, -2.947390880873061, -3.3936149950265415, -3.4640908924844136, -3.5873708036955203, -3.383530702772776, -3.3253281527988667, -3.7901842334500935, -3.820296980211042, -3.228234631015934, -3.1183562705568177},
    {-3.1145710246010867, -3.5932007107063417, -3.1962570662704803, -3.790101761105594, -3.5802127315072982, -3.476560645867874, -3.6018397698701707, -3.6485213708450193, -3.4056431913593723, -2.9716133255148325, -2.964345320763683, -4.105693765610405},
    {-3.531881542247916, -3.6149628280174335, -3.6731591085474493, -3.6284748472955726, -3.3487097144728795, -3.3924959122928104, -3.172226712542931, -3.776571009099342, -3.8770548893719865, -3.460062795899621, -3.5043260744961016, -2.9559918512539824},
    {-2.332303958490677, -1.8489926426610288, -2.175310662432842, -2.5112237944356512, -1.973697904589172, -2.463738351003892, -2.80203158333928, -2.3398806663619385, -2.5004614635301508, -2.4312087643911107, -2.775127174957497, -1.7534354319903707},
    {-3.0333126988428027, -3.590140880444105, -3.3784937613355983, -3.515664939366297, -3.538352980925759, -3.487363963733887, -3.229273826454613, -3.0349701618422045, -3.217528223900222, -3.636429080901575, -3.225206271566925, -3.8536377904205388},
    {-3.419393026583957, -2.9801395944420577, -4.22152498955459, -3.4721197701289492, -2.635606722153152, -2.9142401022368127, -3.4717197425985096, -4.251326896120585, -3.922138285516937, -3.854524267485429, -3.456081862526624, -3.583714001527366},
    {-3.919219770772271, -3.636669624651258, -3.082187700953959, -3.294732316785869, -3.370535934855084, -3.6730198874149593, -3.787580927554006, -3.803041563708218, -3.3167071071351764, -3.5091765442634637, -3.5987236662910997, -3.309594096203633},
    {-2.8390350701204663, -3.5824942961770665, -3.7656753480944487, -3.118754439634045, -4.043100878528543, -3.2640997548159523, -3.3547209261902116, -3.7038566872450285, -3.1207764484538254, -4.089436560672244, -3.1376118803666246, -3.5301659173036453}
};

static const float b3[12] = {-1.9459305441317833, -2.0755683328673413, -1.8763484082064883, -1.9055326247413957, -1.7044247719134742, -1.86802907937839, -1.9083155870167698, -1.511355741851856, -1.3641479076853298, -1.4566601821077338, -1.7303707760107914, -1.4043936565474238};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
