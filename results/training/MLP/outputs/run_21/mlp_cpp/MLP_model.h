#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-4.023538925681974, 1.2181465029127605, -1.152166098942094, -3.3702377117574827, 0.19199630102399687, -5.091418760567951, 0.900950255076568, -2.618620720726752, 0.7539439220546974, -1.4645140909389072, -4.091847215955758, -1.5966203230226086, -2.850438591100172, 1.0649321627668056, -2.290753560279787, -2.1689049012819948, -1.4380825676189406, 0.6157320020952344, 1.4361837554398516, -3.451101075546088, 0.3478171985185098, -2.397107380364852, 2.21900760490914, 1.3172980807143628, -3.719286168421434, -0.2701845324234561, -3.0971846153551374, 0.7295702609400921, -2.967520205306149, 1.425561499455177, -4.067182917868742, -1.214411181076586},
    {2.672276279020119, 0.6244456652642318, 1.5639653904098005, 0.5108200492918885, -2.3484769362576206, 0.8910074587520561, -0.6844259294659238, 2.3277148929357807, 0.8597441858689762, -1.125096794663716, 0.2982209382092318, -2.042579498226525, 0.31620888972375405, 1.6217360767777225, -2.1160192588881155, 1.5103812338233806, -0.8792521921702219, -2.495562715823514, -2.9681626926660094, 1.9086195818430516, -0.7686906931511482, 1.6128893376692033, -2.7217997065980066, -2.3494282260686035, -0.5054498299086992, 1.6879526529060669, 2.120404181223508, -3.07418213310096, 2.0326681046999733, -0.023667618982246105, 2.2583916067390355, 0.2681972932333958},
    {-1.0471124892731407, -0.7713289754839977, 1.4791878028052263, 1.0961267937473846, 0.3815586299591245, 0.5688970394845295, -0.7695018685829021, -0.8249615686649208, 0.28851162488694215, 2.2415691585346336, 3.130454339629862, 2.885402857172858, 2.145555104289273, -2.519961280117785, 2.245349261933721, 3.299158205187345, 1.0112569949189316, -1.575223610866527, -1.429670412208618, 1.8384305008102046, -1.7151202260706566, 0.9531927623636898, 2.945591740306478, -1.017069410479967, 2.496710472400279, 3.172513383739641, 4.098177638541835, 1.6425072204410534, 3.1963312139089246, 3.099930345031545, 3.0556483042814606, 2.742513871181161},
    {-0.05856742340853098, 0.41944012365608774, 0.4476980700795873, 0.49196629728697594, -0.12075594984652599, -0.3343315403306588, 0.2562042071292529, -0.8405527233175651, 0.31450234611126915, 1.424237120565391, 3.3888940780567185, 4.341197960105011, 0.9020033990250682, -2.7338821348566875, 4.688101052218883, 1.5801487337358433, 2.723829307030479, -0.44061163926869046, 0.4678056452365194, 0.05147022317964102, -3.0168099304464815, 1.0522223849695926, 1.6617969152854075, 0.04910391377893495, 2.451518812170999, 1.3018726903489215, 3.4155486130879367, 1.6925992590095822, 3.6066418911448817, 1.1271356980761162, 2.7926662128590816, 1.4403158240794678},
    {1.3737994861927594, 1.8521785775293298, -0.23717119103431333, 2.3755782367318288, 1.098712789558678, 3.3934547952190104, -0.5809788650531542, 1.5640437900290678, -0.8557749180568006, 2.7639106321722244, 4.070568752013312, 1.069068687352393, 0.9796220618300893, -2.638480495857026, 2.858386239680923, 2.6506836559819207, 0.10976292069982221, -1.0300626703693065, 0.5207776123554417, -0.8686816924550033, -1.808614598659178, 3.522685341079115, 0.29559627414518735, 0.395308999055182, 2.488428015445292, -0.0646570446412904, 1.8338411465491915, 0.3971427594806211, 1.5318067651296434, 1.4941186818968728, 2.1296997675023452, -0.14970229144687738},
    {4.755113679843559, 1.6633214765544688, -0.5127804320970978, 4.723666016219049, 1.388575875391189, 6.0539543116619425, 3.592000585862963, 1.3197598858841217, 3.7067405408797787, 4.091946799692178, 6.453751270251402, 2.626095423075677, 3.6368057473014432, 0.37346331291328605, 3.800666602239886, 4.067505679796497, 3.0083501332044147, 0.8386506158089487, 3.7560620422575783, 0.5114679550959425, 1.3050558638761098, 4.079413240224977, 0.7259444446250214, 1.4290450140501325, 5.563256366737839, 1.704283444045637, 3.078814492491308, 1.7931348569480468, 4.052374222635362, 3.7122489069576052, 2.004773088419536, 3.06377447115708},
    {2.096920154292614, 2.0577784206796035, -0.09839689552249634, 5.553853750861787, 0.9690140821120844, 5.401843292770178, 3.5156842663929453, 2.5712048198429147, 2.594464469958347, 4.369928048314089, 6.052844129977726, 3.8235216221915262, 4.545114547969951, 1.5660065490677404, 3.846928207931491, 5.0053959081385155, 3.693807445388323, 1.6976444392418104, 2.507183750334504, -1.1321498620919117, 0.2554599185989798, 5.25489616359093, 1.2253650346589346, 2.0251147903769158, 6.5589057127411285, 2.5310536264916683, 4.052532557810383, 2.567086395662215, 4.202083042064706, 3.163775709076437, 1.963706090147716, 2.981494080143765},
    {-0.761413405430336, -2.1827905270463646, -1.7522793709703428, 2.3565804291473995, -1.5074336521306742, -0.4297142749694362, -1.2329232445564695, -0.7021784972900962, -0.2544257775657652, 0.5841793335653197, 0.7795037530481266, -2.2919751814227256, 0.8206296631951646, -0.3665868158322362, -1.086644617553522, 1.9435545090174746, -0.4473264983762899, -2.0277395360264454, -2.126416847534091, -0.6373894117789384, -0.2638721221097021, 1.5927640305966866, -0.5967637345278559, -2.112810775317358, 1.2657681387696698, -0.1795154581055622, 0.5870611034544616, -1.9678829266410183, 1.5848432509811343, 1.7913028098180794, -1.5371424962077636, -0.81752998610564},
    {1.6985083558222207, -0.8815509019924274, 0.23149422909761383, 0.7398114816546856, -1.3703603353818785, 2.145095808468031, -0.24399982920375396, -0.09579001585465954, -0.8193434942324066, 1.2585552443493413, 0.577357239326764, -1.649175445885175, 0.44189174918195895, 0.22548399546068587, 2.620409666382295, 1.888125420838758, -1.7865931888070294, -1.6378413864895018, -1.7173422186838163, 0.08008678244890365, 1.34526706918292, 1.732899029257586, -0.9239641514690881, -0.299741989851765, 2.082095853119761, 2.3729450744286464, 1.2397371331774587, 0.1907333296879542, 1.775579935170837, -0.3103600297553434, -1.4691647118737303, 1.400569317367504},
    {2.2703227516246467, -0.2958461510600118, 1.2101240877482187, 0.21124171786856863, 0.0736626692682658, 0.5882675922571284, 0.8616737330619825, 2.6849889392228707, 0.9000753179064226, -2.3179302825206385, -0.12678609133479904, -0.10447344717176432, -1.3657163181291048, 3.216995179692349, 1.068620319634164, -0.7114249324940325, -0.775913078315418, 0.8460333391066253, 1.0165063887857448, 3.4454414363271515, 2.262978934408712, 0.20657159076058423, -0.5742547553737168, -0.20615489106934864, 0.778135022555635, -1.0713284942243808, 1.032626862796701, -1.932939228108216, 0.30391681461182923, -1.363836162872499, 1.2273623032141767, 0.5217078987351159},
    {0.8161823793708922, 0.24781783109137623, -0.6919462828313949, 1.4335697858039924, -0.03686166651900542, 2.4752468349819585, 0.3230223487250274, 2.397590669640862, 1.7368739442939292, 0.6197587889542616, 2.2565427934042748, -0.546142181285039, -1.0563507818902595, 0.14128525506461903, 2.3911458469702143, 1.8554674822904176, 1.717766121844212, 3.2904846641231185, 1.0278708427195886, 0.8879188999639298, 1.7960817959288873, 2.415210407780287, -0.5811795187972677, 0.414223796813347, 0.46651260589704724, 1.709120193803583, 0.9163192505293714, 1.6838937646915089, 2.076059619420525, -0.1229100438341874, 3.221644593744734, 2.5073754221534634},
    {-1.2182383937474546, 2.399194227979089, 0.47461748877978993, -0.581918129129908, 1.236300114488491, -2.55012177938857, 2.01825522476823, -0.21927277261946307, -0.7295088221228427, -1.8873475946719904, -1.3961642008138617, 2.8436051705588397, -1.5309651856824007, 2.457677045564759, 2.914479345237077, -0.21223607305989634, -0.35782343927828053, 1.7584959262609874, -2.3119319797582483, 3.3823828871582715, -1.9503299024647385, 0.6506697483937705, 1.3826116482365247, 0.7245067802474516, 1.1322931475402074, 2.070286165923608, 0.23506581325910816, 0.9872461065275547, 2.176631001679712, 0.42677515536838495, 0.4334930988318312, 1.3711294221321848},
    {1.7425925171231036, -1.4846966706972928, 3.0141988560396946, 3.0018766914660757, -0.3421280024750121, 3.5354955728592343, 2.021123149465724, 1.3491715041690386, 4.144421171140226, 0.9065856878235006, -0.4845242470792186, -0.5537500614877616, 4.0829203190134375, 3.4251790261380295, -1.4762344483286038, 2.613245035435789, 1.1448457219260475, 0.09748973606866441, 0.4737071007834678, 1.1006560091754929, 2.005227174815472, 1.278402243054473, -2.817165616634396, -1.3124725282072127, -0.667513823895195, 2.3154122839886986, -1.2479691313831236, -2.4896891272574115, 1.6672250973978862, 1.7532043987734542, 0.05750602175598336, 2.2248694237439657},
    {2.005899240802889, 0.5858284623227021, -0.5324154808921829, 0.9580289993878852, 1.2372648488406834, 1.1926861842571177, 5.40824382479215, -0.062435124930766105, 1.01254471408166, 0.22323450154970353, 0.21935916020164972, 3.303574742360197, 1.0251010549446937, 1.909656655214878, 3.1851816354829574, 0.0421376567435917, 3.7557121233570223, 4.028308392345311, 3.4982713616415917, 0.4014582498976697, -0.8817050467295773, 1.6653834203531157, 0.507150684364954, 1.318571652566524, 4.89944669390466, -0.4880360074079337, 0.32349162623216793, 2.3163466143840745, 3.524658319106965, -3.957696984754378, 2.1773191666139082, 1.9740688055332691},
    {-1.2377453696141631, -1.5919697496180902, -0.612685504161068, 0.6487531809217238, 0.8559846105046617, 2.5274757650127393, 4.847996676761573, -1.1522574149421172, 0.4111649339805257, 4.081890831911324, -1.1589556704220458, 0.34599514362525474, -0.02399376276626573, 1.1540563264549273, 2.541782023247855, -1.0972478651023185, 1.432838026943521, 4.408468211790895, 4.644159186972374, -1.0191769552253649, -1.2668158688477291, 0.7603762213660774, 0.8241357750127922, 2.610038630143248, 3.616029972809654, -1.165496641840528, -2.179854086601591, 2.7707459484755024, 0.16274399330523415, -3.3970978197201243, -1.395621224766784, 2.061268345723718},
    {2.7051258967785254, -1.2368234262886233, 1.612445427823751, 0.37418168629554405, 0.5092973786969709, 3.3632373276007135, 2.6888533110664987, 0.8653523336394119, 0.7152397698005797, 2.984937291925699, -1.4838173458823536, 0.6455469434140333, 3.748450517575282, 3.114294158136254, -1.3828790216273852, -1.0255291215014548, 0.7804545931874559, 2.6349975226613402, 0.911739952514457, 1.501998104993478, 0.9599977954712527, 2.9585495993005444, -2.506243524281331, 0.19119018398948717, -0.06435650880948882, -0.49361377737584494, -2.2271786842369234, 0.15058394369907116, 0.9420085044769878, -2.593789850087255, -2.294522004911923, 2.1361787151792613},
    {0.8116738394122328, 2.1923703401712955, 1.26895661289778, 2.339106000831842, 1.9853981525793174, 3.81324539501789, 5.8207279641211755, 0.2807645558673128, -0.09890567521086166, 3.0942337344958784, 2.8556940689129093, 4.177620933877305, 1.084065131463957, 2.846934633894191, 3.5463203178503306, 1.6829332237113719, 4.006854877068797, 4.478773028244175, 2.9075568453297604, 0.9124404476282527, -0.22273419112649834, 0.9243103889201828, 0.5300654729601877, 3.995991109266949, 4.273058631485399, -1.598159917377645, 1.2728899144920747, 3.3692809785506768, 4.435833128376317, -3.3398399707488022, 1.096738726759203, 2.544185683737172},
    {0.9514062737959991, 2.411357380980445, -0.25056783902162383, 0.6760465154858954, 1.8669006790258775, 3.4184363508419913, 3.276513481652516, 0.6162103932274743, 1.7662828639433465, 3.058951980424158, 2.263437565527516, 3.812175961105068, 1.0434206550698213, 3.302888800765885, 3.09835097007355, 0.7617656152939734, 3.6069928545147194, 4.984231507209989, 4.028046294290777, 1.2569334890698531, 1.0999357121591242, 3.0144487532463065, 1.064897481303928, 3.0224996530040373, 4.0234646374541745, 0.6017859600831298, 1.8215482829161644, 2.5259500067331526, 3.22151822318077, -1.4208457531783523, 1.8101086797202173, 2.552484130738872},
    {-1.0417941875080179, -0.23743391077350548, 1.3217562097990148, -1.2129525476041283, 0.8371509032299251, -0.047815128639184946, 2.9379133901867824, -1.5906252026355685, -1.2500939276761809, 1.1008637263216792, -1.202069882857157, 1.371350519831491, 1.5626546150780247, -0.18664597685410447, 0.5782044095276005, 0.8463968575533916, 0.3050496719605282, 0.36478000674679467, 1.340218374244602, -0.7898396827766982, -2.1540617388669205, -0.866704211744396, 1.6219966925131715, 1.6219958335477394, 0.5267936919988788, -1.078304111933951, -1.2346518059790266, 1.9393868682100064, 1.927980552578468, 0.8556210090670067, 1.0611687280689213, -1.1030831139225077},
    {0.08890629847213448, 1.1127392313020132, 0.4325626442013334, -1.2236596841652783, 0.6839762569839611, -0.27502328519267766, 3.0725883713122335, -1.8756414422833498, -1.1484928984715257, 0.21796824500449397, -2.4330942445395274, 2.3869945207133405, -0.5564701268529647, 0.6065403288021168, 0.019720574074115742, 0.4688787168194687, 3.034433988106655, 1.316196586352483, -1.0459336154898349, -0.26061084935340395, -0.2863978366104351, -0.7307231950118178, 0.7374167059952546, 0.07005902119368634, 1.747728050585597, -1.174733645444555, 0.1889833165528894, 0.919027209957765, 2.0978049816617435, -0.030801938486882365, 0.925326401172942, -0.03165757239001134},
    {-2.6962680701710258, -1.321073885281879, -1.3445468611780433, -1.969692682446239, 0.0897608450906955, 0.07025225205649369, 1.6118320592304884, -0.30146547706281124, -2.417050755792538, -0.29517189094135443, -0.777702312745035, 1.9210080761495434, -1.8819120925650672, -2.9310228394535383, 1.6532232472692503, -2.0285426851669883, 2.9052656493962696, 0.6962587975996534, 1.9478416257818312, -1.245795085855769, -0.3426835486489015, -3.1305210552347282, 0.7177523990434302, -0.6463012200133866, -0.3907907312944324, -0.32769119575703637, -0.5228743970225358, 1.6343589945432364, 0.47850246760525617, -1.8169495774047801, -0.8676127121897828, -0.9720049185222698},
    {-1.73559219683237, -1.2196313670932382, -2.969429834597045, 0.4760173299738424, 1.0441096719546745, 0.20205793152202794, 2.888021781662286, -0.6324808243006502, -2.8380508405462206, -0.19668687598582235, -2.454875584643512, 1.0570193661532226, -3.803436710304068, -1.285844072659904, 1.0707479793849124, -1.8727748694067603, 2.7591121095342235, 4.4121253623763055, 0.7727059286433915, -1.2374648302497204, -1.9943123397437554, -0.9301376054113075, 0.8478356194726554, 0.5955979648480252, -0.23321255427364093, -3.6251919142906246, -1.714801076162765, 1.507368601827276, -0.049500137405904476, -5.119852373334617, 1.7913484292912263, -1.8309226323165058},
    {-2.7952099391215657, -2.743597339042171, 1.5781419569264024, -2.15803574449947, -0.8659725269208621, -1.3257695742425382, 1.6768190300023131, -2.4142806685261364, -0.15577774720301557, -1.6418679914692509, -2.5373855099009694, 1.905018551472082, 0.5582861500941356, -1.9608153087218303, 0.13284566287778757, -1.8886832923032202, 2.9235576292311483, 1.108746237433361, -0.6478860945349038, -0.46060577207483133, -2.1359770321279656, -2.3383463961330118, 0.6835626720545658, 0.48046244748912137, 1.0605898926170967, -2.8888231108543914, 0.8492797098032233, 2.7685822806979394, 1.3307401683581122, -3.101444469019836, 1.4697380482476368, -2.02273000110788},
    {-2.33065047299045, -1.1883341384930501, 0.06412132444647976, -1.1100819711340115, -2.953639386952597, -1.2841105888293578, -1.9727546509376446, -1.600970758757767, -3.3055050208398025, -3.319035714921545, -0.9091577212964059, -0.7336682876439631, -2.686284811947094, -2.4901903134189767, -0.9083607624902732, -2.0376232237997027, 0.10780480178072227, -0.20930076951042828, -2.0016984133920848, 1.48194753030984, -2.145684093999424, -3.878936211263886, -0.4750704870818578, 0.19896591246627332, -1.0369817930898804, -3.724825126163689, 0.3380767670778105, 1.6665865401623405, 0.09731317383407596, -2.751406832549913, 0.740108636244733, -2.9648914803262416},
    {-2.1489558757395852, 0.31305582893211265, -1.4823944436718945, 0.19669920995400658, 0.7895462984519379, -2.326798148403148, 2.1690084573983954, -1.2761578713598833, -1.83012303743051, -1.2644953000586483, -0.02286342042319495, 3.8933126887572724, -3.0073954181471803, -0.9499238819874574, 3.0951691915066557, -0.21750391075112321, 3.5266393797169777, 3.6499071927919515, 1.9792477020852994, 0.5953907668824636, -2.7539179054856375, -2.331945921595002, 2.6706518195615048, 2.9792428159436457, 2.201378978240984, -1.4690873078374267, 1.3346557897805216, 3.9895486943386644, 3.0838710320785747, -0.3232026237907746, 3.9918055285395755, -0.3989630724559002},
    {-2.7508591204314508, -1.6133599107885688, 0.7318735518131416, -3.570263676830451, -0.72249250752395, -3.8945708652072244, -1.8377441921699138, -2.6059722332344952, -1.3294832608741778, -1.9800358038033838, -1.136010054174005, 2.6506681621975527, -2.411028032159769, -2.476130879947306, 2.1959784683951877, -1.8484602900654137, -0.6945298947428887, -1.6065903443015666, -1.4297606359278057, 1.3640244899508633, -2.1923755873104143, -3.0611959681647725, 0.9747141245600628, 0.7258633394078842, -1.0974916979919884, -1.3311065326880946, -0.3937691636272869, 2.271327682127084, -1.446989416228236, 0.4304472797032565, 2.5400166548890315, -2.8937010854340417},
    {-3.676528932333836, -0.5357699332480138, 0.16219722137275977, -1.907318308668578, -1.0484241522181963, -2.754193442268214, -0.6714344714834696, -0.9512596709102316, -1.7970488631051516, -1.8820557162511045, -2.3495803286636, 0.8545098696467469, -3.694933240479566, -0.4502324678568466, 1.606433101309922, -2.733272780456034, -0.1573704489682375, 1.7957240811615192, 0.42833622648312547, 1.449848139299741, -1.5485876773698724, -3.078552620797203, 0.038562255457121636, -0.5140718697407767, -0.41071262816752774, -4.2695814767004325, -1.3595742262675234, 0.04229209394229582, -0.02909226610972466, -3.419853168465113, -0.1862834928949227, -3.045101233844472},
    {-0.6947806312299264, -1.6497444785798503, -1.4470255746516325, -1.5784036491675237, -0.9295787775715719, -1.45517305948769, -1.8143097768082188, -1.5361702501744727, 0.9159625955911693, 0.4613448912598769, 0.4861655810740522, 2.3093346807095387, -1.341959461446716, -0.6156116831070504, 0.1591538014483281, -2.0290265639890825, 0.9121328993188348, -0.3234475570860927, 0.03617085058311568, 1.1554089866237964, -2.7700800700881634, -1.6089530567937866, 1.376074865149495, -1.7118795059932597, 0.09815982296160812, 0.48356760893944933, 0.9337745258393971, 2.774002186073201, -0.603999186667147, 0.24692817513559262, 1.443872924901871, -2.2266788753846583},
    {-1.9871001950794118, 0.551493840370245, -0.9216309169257871, -0.891344951788051, -1.2102618993944705, -0.9769583572590764, 1.7594507953527079, -0.1563200230736227, -1.284623783627867, -1.503821302543101, 1.2475217826803604, 3.6336707489838895, -3.192867040747454, -0.8478973489385656, 2.285348937308052, -1.1742961243219356, 3.2819287911015502, 2.1268724732751902, 0.33178144421962746, 1.6216217298756983, -1.9789640765755467, -2.598095751759135, 0.5759730903466476, 0.9775363458228514, 2.1171296844778613, -0.3494212207739459, 1.373829017673522, 4.488469068810651, 2.743313407673793, -2.84046557428475, 3.9917704267447522, -1.237325730961535},
    {-0.7877878278665897, 0.9596834135370399, -0.42178020998851296, 2.1032585672457818, -0.5518459641466643, -0.9364879740291481, 0.5230585570561906, 1.1039104289916528, -0.08279625903255242, -0.40225827981980217, 0.4428260779678974, 1.9924839798223855, 0.3171250338471529, 0.7349690329043718, 3.4904625378682463, -0.06458789785500169, 2.1799813982470604, 3.5855257561227063, 2.3019270169372765, 1.235984388117546, -1.5177199765160014, -1.0517153213795742, 2.301321247081164, 2.133907984056138, 2.673718355199246, -0.23530824607637207, 1.846689193460794, 2.7333914420070373, 2.592933199570019, -1.2486348099607083, 0.4807892820054199, -1.1791153766225881},
    {-3.5763893210142355, 2.09224170962509, -3.5406190202907037, -4.846169757637318, 1.069925325125642, -4.240255953828759, 1.5133649017182629, -5.377282145566174, 0.8853900677411657, -3.680714725467933, -1.9957742578206354, -1.1961558527094662, -6.589741941401584, 0.8064650576366025, -2.5031401532524598, -4.496814572063058, 0.7632530233207789, 1.0293487960309768, 0.6184481381283441, -4.563754023459299, 0.5517752232111046, -4.230542639632205, 0.1236796195273889, 0.3754896267788086, -5.242786831702958, 1.343915103677587, -4.114584593905383, 1.3608755161749608, -5.074125234723199, 0.6575983002123836, -4.664884568702754, -4.1381501071002065},
    {-5.074590514327521, 0.9263464457119499, -2.50798584138312, -4.873954170977668, 1.6578395375585284, -5.534358615559626, 1.3758107754708713, -4.625622489803228, 0.1507858714409502, -1.392049340199395, -2.0176111092415683, 1.4207226509644872, -3.5386028522102952, 0.9764335852372085, 1.2374034622321213, -4.681876029116119, 1.293179059919846, 1.7930803560776065, 0.35401524858435013, -0.38326531483876214, -1.061871845724559, -2.943344953594082, 2.919053938754458, 0.11982625257996407, -3.298806054307299, 0.6315438606029359, -0.1979158466501468, 2.1326501436671834, -1.4700466680699191, 0.1651800277867316, -2.814891677297284, -3.840611427302793},
    {-0.6854424440766881, 1.1901217515473412, -2.1838829007527876, -2.8203529338344904, 2.123441474979062, -3.0802432723509505, 0.9163528024587017, -2.30463563637104, -0.16421338175273434, -0.5267236016330116, -1.5916932799485084, 1.5744552783574284, -1.2999074370556498, 2.092178960929375, -0.021428417107672484, -1.531841336630099, 1.1846291256902344, 1.7015695046026882, 1.3984138293547717, -1.380850984004334, 0.8551674895843215, -0.672533824802486, 1.5933194820621541, -1.0525212081370168, -3.2124506006682076, 1.8911444650637634, -2.4327784295552197, 2.0719026520368815, -2.7281993235528414, 0.3639602258871764, -3.662837350822689, -1.6154327119344023},
    {-3.68117746434959, -0.47115325317740386, -1.700021152281381, -1.2868476626406902, 0.5363677206963774, -3.860647263414144, -0.9404489349825987, -2.1151722197914893, 1.0359169373541413, -0.4128348252189521, -1.8517219724793033, 0.9733480889566656, -0.1498479596771192, 0.9975952877161921, -0.3760896960015073, -3.134622471551112, 1.3230789474578033, 0.9340448342381475, -0.46905259716367526, -2.4808053422093987, -1.1875281717257327, -2.057680414415672, 0.25512933921922537, -1.7029350225469733, -2.328821122409795, 1.7561977828163144, -0.35086038359158017, 2.1069001245830257, -3.317056125531647, 1.9867455554634588, -2.659806125795513, -0.6888472570447827},
    {-1.6243690376427726, -0.10213470396427635, 1.0812568451905895, -2.868781315078444, 0.06631867898741857, -2.4783964732816455, 0.4238181159445173, -2.195160921094807, 1.5693171621933513, -1.9788750507508457, -0.46667578670938753, 0.43797551586004846, -0.4641248889992226, 0.8199075345318227, -0.16218739669934923, -3.2793753958818397, 1.4878809919830451, -0.935841138306733, -0.17438094353279138, -0.1596780224967661, 1.0759424027509716, -2.732116260104362, 2.657892522122655, -0.9945925612302049, -3.499113008155467, 1.8324582631171222, -0.8862469832586943, 2.0924827937908357, -2.431241109581386, -0.4095708937769321, -1.1494003260261565, 0.8839993793885653},
    {-2.332894961316017, 1.7724413729326025, 0.8647512595579667, 0.18835232396513413, 1.8598201576779858, -2.8901789256516097, 0.43642057408411106, -1.9241823711359338, -1.479973909490809, 0.924814777675479, -1.1406602457787893, 1.1255424047207065, -1.5165590173642745, -0.5464433975570855, 0.5887372715029293, -1.8953325948441413, 1.4458852339743906, -1.6079442563903665, -2.0745879301096504, 1.982566915082347, -0.8400089669861867, -0.4152755544715015, 2.73409866175574, 2.175512502014499, -1.9630239604084907, -0.0308797212613729, 1.1806420972715415, 1.8936801206558351, -1.5334916250368236, -0.6620559027520388, -0.9188790614567625, 1.361747205061531},
    {0.342586425281687, 0.6099760203572199, -1.7086572099356607, -1.348372820606481, 3.0479991285256327, -2.14140536280683, 1.2742785664755145, -2.2161620417431536, 1.1808228794750937, 0.4723692648966678, -0.7279557342435053, 0.5685366640673355, 0.32536459943426543, -1.2807746747419462, -0.4992361727360239, 0.10063814923331633, 0.06989175227398578, 2.110797827389507, -0.8835792334112998, -1.3922092552065126, -2.643429066320532, 1.1170068393041028, 2.7211660021746447, 0.5611778160133944, -2.611759145294035, -1.0268849170990142, 1.8047254609258068, 1.3090332993363327, 0.5113758032357367, 1.4589955622142312, 1.0771584281356343, -0.6295951045223032},
    {0.6432668067508992, -0.5249388507615315, -2.8324260381878514, -0.37862048313182123, -1.4141582845109133, -1.509346471591307, -0.4540249172655248, 0.12230818242880012, 0.4841848669610353, -1.3961391004292993, -1.3324824805629698, 0.9868626347846197, -1.5444556351867444, -1.7674351749260846, -0.4428535957174502, 0.646305254051343, -0.21068679948544095, 0.7015038784350707, -0.18269557389050392, -0.5029647570889196, 1.7421088674680631, 0.3531909120366649, -0.6763067917434825, 1.9141622808354597, -1.828500242172732, 1.0754924033887714, -0.4998036254316836, 0.1354201797923692, -2.0838981509443775, -0.6075871227469738, -0.2878593733821884, -1.1016614227134727},
    {-1.294868956411993, -1.118586107906681, -1.8843344816472307, -1.0460645805000495, -1.4480005417533635, -1.7195627316318602, -0.9664021215361398, -0.6888495846019642, -1.1090436304432014, 0.09437498896133635, -1.006712230254188, 0.6928809867395801, -2.516100933965625, -0.23130026508021487, 1.9860753394284163, 0.026041840996667728, 1.4964384327258256, 0.4289604756050001, -0.967324317460479, 0.2853355730152153, 1.6432310034702295, -3.500858878303296, 0.7560988870299302, 0.774426935753088, -1.7642745972874727, 1.4296362370047166, 0.6590867361134921, -0.468087701495744, -1.0287125008499365, -0.4264195983004728, 0.7352020282331048, -0.7894171828981991},
    {-2.6360206399469304, -1.8784796675498368, -0.8149546590977677, -2.1821828246027564, -1.1367094791885877, 0.08695719591444437, 0.09615263067533605, -0.1778835702110771, -1.0586418523395973, -1.4695476795958249, -1.5846212991210744, 0.817798357036182, -1.3267920760662388, 0.8048909233187574, -0.7241802498173653, -0.6643755388792072, 1.364183949559889, -0.22054354653638358, -1.615037811214456, -0.625974917355432, 0.06454207684953962, -1.786246376704105, 1.8567925269300314, 0.5759150305281411, -1.1238804387029355, -2.146811925107737, 0.28061399872803633, -0.13962658134376693, 0.5368823795566016, 0.6857085205289463, -0.17503543737376934, 0.1544355709780251},
    {1.5328920867183424, 1.4666744255334907, 1.0641199981565073, -1.579318515457394, -0.8988090012035662, -2.0366545958901403, 0.3489781208646664, 1.8711305519006476, -0.6398159174829103, -2.431601662939404, -1.2638541287531404, 2.3556388019568453, 0.4888877822299, 2.4739392158848497, 0.12294868564418165, 0.887929988016035, -0.7725206869872692, 0.377162798601731, 0.2452219546016825, 2.2861603406132582, 1.280574669680782, 0.49883473698373254, 0.2165417074374075, 0.15152282331163794, -2.2872848329737874, 1.1070865839151676, -1.4556197797912431, 0.2802053936585113, 0.5275741398398337, 0.28381555961223365, 1.3152873389410273, -0.6218933525435515},
    {0.3895844905358961, -1.9198889299936914, 1.8454335767212198, 0.6693815325707878, 0.17541630552410106, -1.5171069824299712, 0.06998596691184829, 0.9123688374977241, -0.5523761468997415, -2.086172593823855, 0.9088689706022297, -0.03420319358640459, 0.13760870043260837, 0.09002832611931162, -0.07026626122481618, -0.4759728115346274, -0.17518324252313508, 1.552202468897422, -0.6500568147505802, -0.7969198006170858, 0.26999256241663633, -0.34001092857328147, -1.2031292834641811, -0.41109843954580655, 0.3294236623338082, 1.4688731603891907, -1.7387642978896891, 1.5900476356452633, -2.0460742919645405, 1.804962556406178, 0.5294295594195285, 0.8719751477593607},
    {0.5183668121442946, 2.2358985971587195, 0.574660855777743, 0.7416308205554683, -0.12488671576945266, -0.5655537776770081, 0.5122872929103175, 0.7849385503632672, -0.5829458141964671, -2.175531558171988, -0.4919424049682531, 2.787455880964474, -0.8776263104780605, -1.5421005444522244, 0.35700186452364446, 1.054335791926717, 0.2607938214558081, 0.13154981821189837, -0.5114467308668239, 1.3666830529846286, -1.6991265451380042, 0.41846036591947183, -0.24231434522664685, 2.534604558610585, -0.4385685374568691, -0.045432289618553626, 1.8458478005159373, 0.9971000443293598, 1.3736884868900354, -1.5169354651295288, 0.7190635379849747, 1.9105228550516165},
    {-1.2160107467427794, -2.06209784679154, -0.6666700806898627, -1.6469718052315792, 0.8084062204200276, 0.039190190462302044, -0.15326081985124132, -0.1844339001127226, -0.618782182895244, -1.5581599878863819, 0.39302917613595484, -2.5766057961670383, -0.7190721047067291, -1.8343512357451308, -1.8320789907956623, -2.272682067803053, -1.9314428183423031, 2.2516274589496823, -0.3878359798211907, -3.0368352315436824, -0.8460290955364013, -1.127413169251864, -0.3514262657480745, -1.9664038533655, -1.9022937586597517, 0.40854623491398456, 0.21377614329372016, 1.2984827769017682, -0.32238560498859825, 1.6308620278833175, -1.2131098832671958, -1.6851894816988433},
    {-0.8113555008799395, -1.8883151208242506, -1.316527610455056, 0.5478247739011329, -2.3485966584700937, -1.4027431015301826, -0.6650649200483681, 0.28337450455732627, -1.5645358580136313, -0.5559710721174126, -0.853278725584428, -0.5953575938340135, 2.509778255721904, -1.1978531274799271, 1.0043190595160427, 2.0190089566036717, 0.4238182808444129, -0.17577539394186928, -2.3378421377893583, 0.2556594136496474, 1.1487428408218159, 0.6932409929192872, -1.5936768932386656, 1.8484101641859667, -1.9444838690453996, 0.4695276722138398, 1.88033904623121, -0.5493339110379218, -0.4188065157007124, 0.34670348841720056, 0.6337836775226844, -1.081398253116607},
    {-0.41629450331495654, -1.4436202050676261, 2.7691897181738443, 1.9472598203990243, 1.9544970506100108, -1.077298034241142, 1.6367460630787138, -0.9910733417908891, -0.4830917291069272, -2.644794083360433, 2.2255808736492875, 0.4892955468651084, 1.110021996981437, -0.6383728731113416, 0.13303644522008168, 0.3774079170758549, 0.7788655414466386, -1.0435155646452423, 1.3608843734687615, 0.5886534459077711, 0.13962118077421307, -0.842684063984132, 2.7569811252755256, -0.15029505541446098, -0.6588275604500322, -0.8588724377870328, 1.6663238152220858, 1.116079475109034, 1.4066859792253723, 1.1425557110348683, -1.1079245237590944, -0.030106204252758808},
    {-0.9799142724848504, 2.133802086674699, 2.6619653306512627, -0.6351598852127432, -1.3999358660271486, -1.6677198166029616, -0.22914106777546742, -1.133105138587229, -2.5955871158026045, -1.928041206932293, 1.3419237524109997, 0.6675704220115651, -1.5026247827949122, 0.2721883184646244, -0.8842177323939976, -0.25464364539010065, -1.9407723556809435, -0.1549651463733502, -0.7107289673610698, 1.0929045466227192, -1.4744647283731973, 1.278374381839922, 2.3409339817345067, 0.6700269238907843, -0.17106578136051662, 1.0105784942934892, 0.27545351067510065, -1.0246971066411281, 0.02173110274161932, 1.1054264804330753, 0.6868429435319003, -0.0905852382886771},
    {-2.5258615487164584, 0.6679400611585411, 1.6495286912026161, 1.3529254829824549, -0.47656783548812337, -0.43483823080424755, -1.3506493701044588, 0.1278953464436731, -0.461028895845023, -1.1611126822943554, -1.547637656213701, 2.3088036516490615, 0.1693209451304335, -0.03464250382360237, 1.5308235950300852, 0.5755570073730202, 0.16409805443429185, 0.5552912611228273, 0.9666908017221038, 1.132769262474821, -1.6556735494064314, 2.3778642549761373, 2.1645523129570945, -0.0036713651826040025, -1.4075602866078092, 1.3414520515975072, -0.2200393918218198, -1.611738091862376, 0.2078616390493335, 1.7229771488782781, 2.3647874156895923, 2.497212544781527},
    {1.1187060122358643, -0.9330678438009791, 1.6169913841808314, 0.5114690343763033, 0.23739561021957106, 0.26708414029582944, -0.17912505991217442, 1.3702971786492357, -0.8787034952751616, -2.231989750468566, -0.6847663324227314, 1.0326617731601901, 0.4061861046141725, 0.3783868912066346, -1.420576630036412, -0.0981586968796218, -2.654695629704808, -1.8123941149264227, -1.9358114383961924, 3.0226599567876344, -1.348946349238856, -0.7918819958387442, -0.7736870219354942, -0.8014718268712845, 0.9448654333229921, 0.3299490229026173, 1.412189378406025, -0.4993787141793809, -0.1355280136889175, 2.381957950272477, -1.5126065660860508, 2.0349467594394284},
    {-0.3573509376799838, 0.9005857843259104, 1.9808375290939575, 0.24885107540225565, 1.994177253550463, 0.6327210296850526, -0.028324331265119785, -1.6677981812482936, -2.077612579745576, -0.9444578537270767, 0.2285206988504563, 1.4627416459791547, -0.18441808263480566, -1.7136826077707452, 0.34192659938844183, -0.29871332686241, -0.4897158214469788, -2.3020976123220973, -3.791368576060853, 2.3344584533084305, -3.142813785712322, 0.21858098863222275, 2.1553290075909652, 0.44950909588987353, 1.3722615002037886, 1.1834810509447322, 1.1190558778757485, 0.1768686223560298, -1.0878083043639333, -0.04475873293802641, -0.2661839201483108, 1.0978581413661297},
    {-2.459269141411467, -0.2563560548647097, 1.8191151168367656, -0.20374047934009284, 0.38751341013091783, -1.3352399104713892, -0.44365933840194205, -1.071625073602941, 0.11650915015018781, -0.9834613601686175, 1.5505266375752955, 2.452719707858211, 0.042799569553417856, -0.5603171322026327, 1.2754826786020022, -0.5887847035367627, -0.52911381712876, -2.599836526326621, 0.959182873083713, 2.7316066035442876, 0.43666724779929206, 0.07149187007623427, 1.7320970397642863, -1.7903030802672548, 0.591775728116415, 1.184802695294964, 0.6809021131729742, 2.1021906198180242, -1.3390632170676386, 2.3487154787342877, 2.3511349975856968, 2.918255541134251},
    {-1.3665838394006495, 2.899030583856944, 2.559108418565569, 1.4824015071549663, 0.193704845370273, -0.7100180141785852, 0.5627114840379277, 1.1318359172367265, 1.6954488749456749, -1.050916211198915, -0.22641956536174232, 3.0929411308572057, -0.13594720123729878, 1.7485302235720301, 1.8056536023045542, -0.585825081905892, 1.4151072553887714, -1.1472858238649717, -0.6706902751259138, 2.370925303179662, 0.5804553532169282, 1.1217371432148626, 1.5450878284143057, 2.4359327226240577, -0.19728848015862843, 2.1957558740060397, 0.4672120775116629, -0.7690110370816023, 1.8864386984162027, -0.4236374479523445, 1.8123136967981983, 2.8260121928696678},
    {-0.33964760126146687, -0.8716000349617216, -0.34011887316542105, -0.3581471981747566, 2.1606153147949594, -1.3113563188421626, 0.5658907338476276, -0.008618675469836353, 1.2141869783308594, 0.33103512446599687, -0.12074464012503294, 0.5315327210854154, -0.5319991085102104, 0.06343723843891512, 0.33211691547091793, -0.3378587890061759, -0.8254704517155174, 1.6938520684247842, 1.644510287182288, 0.7457611907535637, -0.4533680527015289, 0.5276668728734039, 0.027411265900475865, -1.3706965534946594, 1.3016503703802036, 1.5251168796428773, -1.9786756451018381, -1.0466356500514964, 1.4532967611881893, 1.3164783029269893, 2.110411276720702, 0.7267026117741798},
    {2.928148645935176, -0.4120020640618913, 2.247617200102846, 2.0608744397102523, -0.47304018944959075, 0.5985461626632589, -1.0274559597963722, 1.1563777074056123, -1.316977580501665, -0.14408385042778682, 2.180424427907385, 0.49287017907443353, 1.5410850043526179, -0.8505297965838363, -0.5676712803856968, -0.6534444880926938, -0.7937653112816465, 1.1938975506738039, 0.9842124510756168, 1.7422442534160292, 0.34459767582927775, 0.06065760017591371, -1.5993451142737622, 0.4847300836157552, -0.6598867776059933, 0.7184343712557522, 2.4851703885738945, -0.2690516873905908, 1.5268195679388876, -1.1439944605953736, 0.9523483682730968, 0.9411484941306401},
    {-1.3662587018696692, -0.7789001039233521, 1.596226881110567, -1.3673576195432868, -0.6227562680727389, -0.43838580943671684, 0.3743448475402646, -0.26094410123244904, -0.06574253494898981, -0.23150753497903237, 1.3976462904758937, 1.5953904650471973, 1.649031490684321, 1.5601739948371232, 1.4624379662842801, -1.2922838204833929, -0.09385717781781384, -0.33172523905794493, 1.129736694992231, 0.4181323521326033, 1.863844282258781, 0.6341865939922918, -0.002505354538368056, 2.6061448751705174, -0.07553585702547538, 2.150110075875731, 0.9224841081142277, 0.7044889091941774, -1.07682645061518, -1.7271434918588067, 0.5029011778821021, 0.7951977693717613},
    {1.9167284465577155, -2.382355740695503, -0.6496445220352512, -1.2258623454042028, -0.529881352006875, -0.021291339546939465, 0.2138589533140609, -0.8052129195970502, 1.0638553054558872, -1.125135632398499, -0.9028233253039423, -2.062284701185714, 1.2868973910231698, 0.3221557329619848, 1.1559398331824344, 0.29421263581636287, -0.3748727745591883, -1.0057586934130047, 0.37764128804368924, -1.8536932004341553, -0.34311107680169506, -0.9489496499886292, 1.085890311430697, 0.7891237188876099, -1.2256344387146003, -0.6159475203686893, 0.999996830254266, -1.3169446458236183, 1.0693039345289668, 0.824561999159832, 0.038253470003751636, 0.34744192122625334},
    {1.4160758043491048, -0.8366181265421256, 0.669761759734396, -0.4048075901571802, -0.6811861632558359, -2.44145606907668, 1.0555198822656064, 0.9046346486063968, -1.724832600256273, -1.7492495777240675, -2.436884894058913, -0.8137479679620173, 0.995137621526479, -0.6542489848646578, 1.8712524289688965, -0.9503708430419647, -1.5512576095523012, 0.8065779352730538, 0.6690466223931034, 1.5044547980430192, 1.8016366150917735, -1.3911639411267434, -0.22179078311309838, 0.6536375880345736, 0.34743062906278505, 0.7809408650905197, -1.5813397465298613, 0.7872511866436982, -1.2486919192405885, -0.3968932466111871, 0.9797898567356197, 0.7358250994473864},
    {1.077581243440994, 1.0882008948994577, -0.09318688519258485, 0.18894652670262052, -0.7004040150856932, -1.5457492544492197, -1.5728914063924633, -0.7687220819094603, -2.3859915595184154, 0.9664704226445926, -1.4669969366191835, 1.9593522134444548, -1.2005779477469605, -0.38215723403746776, -0.6386787411963661, 0.9251347611080468, 0.2695341431210168, -0.438335979650978, 0.2981978787032254, 0.7996315666258795, 1.3578668821283424, -0.06895071740441387, 1.3686701431451584, 1.5020125453819642, 0.6392858018522838, -1.3920872196136096, 0.8407339999253537, 0.4518853248143752, 1.1077623257410667, -1.2973708082448296, 2.4570376000742313, 1.1530820571222122},
    {-0.25783561696364987, -0.8499937194154202, 0.8381450533571492, -1.7704077543479917, -0.13651627514566553, 1.1575139456401513, -0.1236953121785129, -1.0459059021004469, -3.0059938525726313, -1.0415650718921012, -1.4497247097791377, 1.1182019350835433, -2.012198488368353, -0.12021779186303884, 0.8164893552278002, -1.439047415297843, 1.8262592037679828, 2.009347338627412, 0.8785778245108737, 2.244053816045363, -0.5122196757830829, -1.1297149172396477, -0.584075060757385, -1.300465879936125, -0.5662692193947827, 1.5804436770729535, 1.1778019981646215, 2.655373713039446, 1.1374713805381789, 0.3708399949177198, 1.0967505369767263, 1.6555843591492778},
    {0.7602754272707464, -0.35116891954296153, -0.7014724919868296, 1.729086412252232, -1.820666986972258, 1.4438476835005714, -1.2769660812737433, -1.8682615366576372, 0.0706360646530443, 1.1563659335020975, 1.4964295157733438, 1.1251126067431554, 1.0156078280643899, 0.2198194352975681, 2.1711428025454316, 0.18177118066131326, 0.9183450762885161, 2.5955884652656387, -0.42524750690273355, 0.40443602639340465, 0.24590402955158727, -0.8943504576021044, 0.6909474162972512, -0.8341033665697859, -0.3857701206605834, 1.7584301645529634, 1.5344409726243387, 1.9492394353799565, -0.46777866784972577, 0.15216942626716506, -0.7543471789140905, -0.6602954527841786},
    {-0.4926685594535853, 0.04678771693945673, -2.22873122194113, -0.3789718183170524, -0.09569996268310198, 1.3227134984706352, -0.4448650133183732, 0.6994730075475767, -1.9322496563964744, 2.567592664824806, 0.5620337922483861, 1.4249142304652167, 0.40018554310316273, -0.1763828115630201, 0.765089569072597, 0.3795856052554753, -1.8284966177782886, 0.15380872163477077, -0.4530594165110522, 0.2983545101064244, -0.8580075137876958, 1.3034799704968212, -1.4903265404623698, 0.6009301661275995, -0.37524258726608994, -1.487331292456016, 1.3060916180395266, -0.8215362014359175, -0.7797213357275653, -0.4203514554078363, 1.2358252444291649, -1.6722359949211607},
    {1.0940089396043264, -0.12805309600696452, 1.6281138551097498, -2.0468859933554384, -0.6798461737461889, -0.179669709945592, -1.54440392892979, -1.0316425635733177, 1.1573828635123324, 1.4055242394637468, -0.2377473324284753, -0.5186381444316123, -1.0839812208136084, -0.9210226936558189, 0.8246712208283167, 0.8528246724565542, 0.9132961597604748, -1.189164384112526, -0.06864038706356404, 0.23739641975604744, -1.6564796091011351, 0.1638491177013291, -1.679902981372555, 0.7495348299310077, -1.1093913949965493, 1.77561401994799, -2.3631634580682825, -0.6496205566100434, -0.34628274459074304, 1.771724067413197, -1.6093663234363496, 0.6268646097914984},
    {-1.0748840390603658, -1.510560701971025, -2.4933191535856047, -0.7607097419078719, 0.7614225574940438, -0.13418926402247625, 0.7536294058848678, 1.5352796156912403, -0.37111266890511574, 0.17548312390070267, 0.7034120569488315, -1.9660607106568753, -1.502192885851703, 1.7613398521701327, -1.4253884003613455, 0.8683509380283726, 1.2366394936367873, -0.08245814744818243, 0.8499344584532827, -1.1202492173652234, -1.7328665342302212, 1.4295486558077222, -0.8923744168444631, -1.5332771374615872, 0.10737284418878781, -0.4488715253768326, 0.2011641118383362, -1.4607889114630692, 0.13284288357658033, -0.17851532005967347, -0.4081534382092743, 0.7155092227295277},
    {-1.4487348498893389, 0.840703825745979, -2.4376408228564133, 1.5415784082439974, -0.7227817106503588, 0.052767293686382576, 0.2926911564181782, 0.0030067243989636487, 0.09795305893272713, -0.2446585449109504, -2.515972730151863, -2.4280063987746523, -2.2932921645489674, 0.8651106499090945, -0.6899184520226569, -1.961162667504302, 0.7322679752617911, 0.8883907382896137, -1.1366337838465383, -0.41422354826406077, -1.7116942533836124, 0.3995069034072643, 1.3813339218565759, -0.989733727550184, -1.1168253367859877, -0.04496246458657344, 1.268995076226888, 0.20773803696776655, 0.40252234826527206, 0.5565077890205896, 0.7377133793360574, 0.7824007595620114},
    {0.5158244961774101, -1.5253614384871017, -0.04895957978099108, 2.701662622959185, 1.3716684666974324, 1.334027076844437, -1.3001747755322628, 0.9694451982620569, 1.37813276495918, 0.030742068072196586, -0.5014520460775456, -1.1787655411685463, 0.015029875070490943, -0.7121077176703182, -1.2531983066691403, -0.08970080213439219, -1.1466699150271666, 2.0533083938332304, 1.5339715245355816, 0.9026581607556224, -0.38705287151990786, -0.31298126382283187, 2.254434933104842, -1.9322836692462775, -1.144793022528296, -0.7749834351118019, 1.821237349884525, -0.3285877003859169, -1.686200574184191, -1.2361106135065083, -1.31033422234116, -0.6115489071074647},
    {-1.1335457869467989, 0.31786431431023754, -0.431625722659395, 0.21144458910460237, 1.5408267499635484, 0.5764824231485106, 1.6539489026182304, 0.7934351526386139, 1.9211508417334722, 0.7166617490799754, 2.216637616245239, 1.9731533275365714, 1.98930080301632, -0.9431480502067052, 0.040406014409519554, 1.6392966306901058, 0.8375287339705273, 0.1190567100369827, 0.5423412093744653, -0.45269522002197915, 0.4225499494660691, -0.7423780308572124, 0.5962818601220584, -0.5124122031687136, 1.2734864379140864, -0.8017667691555057, 1.554380013127483, 1.9286913807028265, -0.9714230883349292, 1.3827363434015192, -1.0652439456978928, 1.3450166912860149},
    {1.2859183668070944, 1.5526779101797248, 2.1837300270550513, -1.108228498240505, 1.2147784790145302, 0.20295871358657577, 2.6108852309208084, -0.9846011484386105, 0.8336817527806268, -1.8975896816465543, 0.4978160380985762, -0.21370430930881812, -0.7043265140379127, 0.6717408770918861, -0.5910592491956175, -0.41576772020619623, 0.2020363411783324, -0.5372696335579137, -1.258983604472378, 0.4013203435514002, -0.6063226763744445, -0.20800704752433824, 0.5773821973509994, 2.5708127203314004, 0.8003952978800052, -1.2491007492104886, -0.28156584020004805, 0.10389040419489948, -1.2605363212023164, -1.017612188135342, 0.41832889536114864, 0.2661784843645165},
    {-1.7464539267538228, 1.29542481781794, -0.11611473024810585, -0.3861081238270067, -2.5427965127077488, -2.079580767187636, 1.0871440223540747, 0.7273518239658602, -0.6178963899470069, -0.927989689864975, -0.3033700660684205, -0.8973466331930566, -2.145864681054202, 0.9948695208491923, 0.28236087188259873, -1.3195148396019434, -1.0088797897805708, -0.5955507680802546, -1.938723986094788, 0.7126208034049721, 0.1638774408166098, -1.5859081975340288, 1.758582190085456, -1.9540150085275665, -1.8521403716267473, -0.28921170868021884, 1.1312933596455965, 0.9904533880539456, -0.7027457042345543, 0.8497098311477326, -0.44258407585064147, 0.6369388622962823},
    {1.0892422540289874, -1.9598875308418935, 0.2856959290283007, 1.2826673597164626, 0.43345380968203107, -1.078751563527283, 1.063648045630581, -1.1544783773660539, 0.42620075546962033, 0.23286417013526217, -0.696669792936076, -0.7191710683888186, 1.157129367535367, -1.5661691335300851, 0.16719640203119487, -1.65673467011745, -0.9430478300610249, -1.647536364209963, 1.5136846914715751, -2.0266279601059662, 1.610530296832628, -1.5266399582022048, 0.7467449114825506, -1.6621909704056694, -0.6022258298200601, 0.9235493194310441, 1.0901768612782896, 0.37672071430659937, 0.16971774601962172, -0.8419082825719241, 1.4159563895555132, 0.5668675424424571},
    {-0.3196242584691141, -1.636220844739456, -1.3415760153762872, 1.1361700018122016, 0.4660168759234759, -0.6439770504738368, -1.5605894893520618, -1.338183819086496, -0.9269958023865181, -1.3702431504058505, -1.376243547413558, -1.4145427218896605, 0.06854755999545566, -1.0436873690183008, -0.038133386238023016, -0.9338351981158823, 0.5056350915083505, -0.05005428452461905, -0.3233101041126842, -2.8105966219463645, 1.356121369640417, 0.13392923284668895, -1.9226312543092432, -1.829142639212981, 0.6673078388221373, -2.1215168948297083, -1.2837307665110265, -1.48580731578641, 0.1944561174358327, -1.2679208291014168, -0.8350803743997576, 0.6226553355667339},
    {-0.4477241767211588, -1.115563066460963, 0.3570728464325312, -0.8397007177241486, 1.5521277088299998, -0.0727146652687778, -1.1401192279339956, 0.20209468398703692, 1.4330135931889052, -1.335376563141236, -1.4184256227534522, -1.4350435079233181, -0.5053478246777418, -1.2504032591122036, -0.9870652298895388, -1.5305135664643252, -0.9936854565473006, -0.5196610760603211, 0.4153711411741202, -1.2011040763520195, -1.3064126297507743, 0.6429230503711363, 0.46635820131153694, -0.25620164350626706, 1.0784880913469879, -1.9392540259404176, -1.3028983269377528, 0.38039837119896114, -0.48457473768825093, -0.6111679553567373, -2.545728144979872, 1.0990806472102206},
    {0.18525903459811255, 1.0087276874433644, 1.6417195596424055, -1.6234243080776714, -1.2967962547486869, -1.7069767737486174, -1.8203112879602348, 0.4125127065918255, -0.25728877465291083, -0.7123484996386188, 0.1535600765916941, -0.48936976832896173, 0.8568395441707776, -0.5499311293958293, -0.7644702595500774, -1.5787293225940984, -0.14296576577231312, 0.11755824205503083, -1.286449749867677, 0.9582965040551353, 1.3856870143721203, 1.548606844085324, 1.0353905958984333, -0.4876441839077933, 0.4935749649617852, 0.06642729606026779, -1.1784412791163268, -0.2318439801822919, -1.4915343216027048, 1.7050265763514802, 0.6788956572409015, -0.27915030110713507},
    {-1.2601417066580283, 1.5317370208106316, 0.38194730486514655, -1.1833669133206244, -1.8675100668881257, 1.27801315397309, -0.9531597970705462, 1.6018235768482847, 1.4480776896240957, 0.8776926013748246, 0.5749988565947955, -0.30982391919488933, 0.8902997928585704, -0.0648651590072388, 0.10193152996549297, -0.5533749669977195, -0.5046486684184083, 0.7121245402199033, -1.6013089401594158, -1.4873668269509497, -0.6913912086750919, 0.5137863816503954, -0.8235148829729952, -0.344935225894812, 1.4346131082669507, 2.325762090904656, -1.4650273670082437, -1.0872526314901312, 0.9388410587409076, 2.3016552037676696, 0.9359851715335535, -1.0108123249651002},
    {-0.05360408508578324, -1.5056640444149836, 1.0531689749744233, -0.7894397855292935, 1.034965027116794, 1.4411337353040405, 1.783026113603451, 0.9943955941959249, -0.604022147691003, 0.6619685812642772, -0.6505060353393857, 0.5427745376541661, 0.1642199589755707, 2.080614708008493, 0.06917486179286618, 1.4098607315834837, 0.387294857661056, 0.15458693431724838, -1.3312228430626603, 1.1556380465917733, -1.7356392598396373, -0.35276665955455927, -0.9752911080457339, 0.44079134058208463, -0.9504437831843988, 1.8350687172375115, -1.546628625083252, 1.380571036471402, 1.3234000695613581, 0.34569223199034654, -1.4699799887873917, 0.28943161446881804},
    {-1.2021080905983232, 0.46582168917630223, -0.10670913602969627, -0.9593531004674388, 1.31735663707881, 1.0103549065267805, 1.3270928797562296, -0.7223251931489938, 1.3045573614675652, 0.09150405256243717, 1.5605324451184246, 0.0669756335858865, -1.0759190829415812, 1.3354675322025307, -1.5902686033612228, 0.4508229431422781, 0.045772302774527845, 0.27932238352743594, -1.5730968847644409, 0.7140651252479849, -2.0438377550496365, -0.7461692767994443, -2.6195626972064705, 1.2541063932086738, -0.05453034948878495, -0.20726831149517197, -0.32291600659834957, -0.47439277741714614, -0.6574167983300627, 0.55257570066327, -1.4556499809361354, 0.9399527729231097},
    {1.4007072766554503, 0.9772769597129011, 0.861338187857979, 1.7251670328330286, 1.7262317873141777, 1.0078999427762316, 1.7517227076449688, -1.2864356040618674, -0.8607185253509969, 0.9660770988703357, -0.03085741543068364, -0.42625261437312506, 0.14587096702239385, 1.3925085047873262, -0.9652537099213447, 1.349094746342316, -1.1773105084194007, -0.6860084011172614, -1.418058291613283, -0.3535223549849353, -0.6021894315812054, 0.1695681235763665, -0.07128292219923661, -0.4765534283807526, 0.6310886263402332, -1.465025349943451, -1.0406083865383253, -1.462088027560447, 0.7171105706841246, -1.058485483004829, 0.6163071957800121, 2.0567642351570856},
    {-0.2778958633003463, -1.4032399770534802, -0.7944031875524606, -0.017261275593971972, 0.8370343411258131, 0.326226312125468, 0.7532499161762531, 0.3491780482991489, -1.5191224456160097, -1.0060213008804513, -0.6755466232889611, 0.2458025147937257, 0.039727227323890675, -1.208771539175711, 0.6369899306313779, 1.6336266804107886, -1.9069705086700672, 1.6914882750488556, 0.5449069863281402, 0.22514615866413648, -1.1773292280271714, -0.748397453452888, -1.775928342542671, 1.4780580908725252, 0.5516027369608666, -0.9211226153003118, -0.28391938178387577, 1.2105105597374528, 0.9144137511638156, 1.565409649835418, 2.833504768407086, -0.34194095816143194},
    {-0.9018928421395787, -0.5999674244840947, -1.0188768794605514, 0.2463751004146707, 1.340559194591886, 0.08206041458008766, -0.2083493581788316, 0.7114689934981125, -0.8088497588328804, 1.7459080808682166, 1.134682646553803, -1.3031486897176263, -0.9105519346851029, -1.5244541618549563, -0.4564710467949289, -1.8059490450115978, -1.504267388289081, 0.8087277565762425, -0.5240260098463693, 0.9530707848825829, -1.819424569725886, -1.2853739741473447, -1.4685406083041734, -1.3532372228998992, 1.5553715412129026, 0.37824580842851807, 1.3266084584558469, -0.16537125731436683, 0.10646772768702982, -0.1504420096412324, 0.5780905411763406, -0.8201844973061474},
    {1.2656669654876673, 2.0842348474934522, 2.2129497020039306, -0.7956852646941346, -0.189093284035761, 0.6027269127718647, 1.5764039037520332, 1.0745199107562895, 0.7120954663405928, 2.0476581954665303, 2.6166622961329815, -0.5121290603955649, -0.053321778030462855, -1.264762718809715, -1.4931070057887463, -0.3030352299077999, 1.4493908166775782, -1.5413940179337562, 1.9832858236011968, 0.5248263822973671, 2.186916070356691, -0.08310708857749599, -0.17731618021447396, 1.001673699187328, 1.3839355881173623, -0.3886235555387906, 0.3593170511387015, -0.306998698736532, 1.1413402121642529, -0.7817363346781724, 0.920032590210834, 1.910155908446295},
    {0.4281851030333455, 1.032540621785291, -1.4351275029963106, -0.6621627547784051, -0.2714592600167392, 0.6453070586815483, -0.6520685038773415, -0.6739478096813156, 2.081943604673196, -2.0108457464619125, -0.4977623858551687, -0.5640489459237705, 1.4527171915684491, -1.601256712912923, -0.651270432337779, -0.15563117807242516, 1.3344792030787322, -1.8082572381451802, 2.2238296841542917, 1.678043042425589, 1.181741842099739, -0.8558621695252292, -0.770604580895394, -0.29397856503110836, 0.8828650792596634, -1.581153195745912, 0.5156002770417221, 0.5123816674464784, 0.2983293837298606, -0.5243747723410477, -0.838841150467719, -1.342071887212854},
    {-1.034120756574707, -2.0151467725048136, -2.0810376402882995, 0.42042966921956826, -1.6876403476969037, -2.522896815433314, -2.3734373884430737, -0.41043012840179544, -0.43988889008810006, -2.043129408421705, -3.0674047736845598, -0.15246125615986764, 0.964039916404383, 0.9661209410141435, 0.726912608500021, 0.39328463538342234, 0.5787493952544998, -1.6422121733165902, -1.3680679979170933, -1.16269733633348, 0.8846318553832628, 0.5450575408860229, 1.5075749015394957, -2.007266003126222, -1.4377134437071961, -0.6627585066037103, 0.7197569108994797, -0.8013567859292815, -1.396285865233117, 0.06850952982424545, -0.5588835284052066, -0.5811807515853581},
    {0.6800507343369266, -0.8488714554909641, -1.0796664723339375, 0.27716108563956127, -2.289798654945871, -0.40934912493350295, -1.7165814383550397, -1.5744219384847202, 1.1158730227921767, 0.716341923480173, -1.5803933712835718, -1.8437587887795606, -0.9355495957189792, 1.2646628034726783, 0.23027077541221014, 1.491737617591889, -0.2541652272293754, -1.2822429537884723, -0.1588997938969475, -1.4765989809851487, 1.9397098056582203, -1.300741576517533, 2.2159998911383774, 1.370199693526848, 0.22740560426904438, 1.465556575790385, -0.6859619173148723, -0.6598918322707781, 1.2116089881542638, -1.5487684712743932, 1.051782399740825, -1.6468510620943577},
    {-0.4133226549590671, 1.6519900025930925, 0.8794551096596059, 1.2343911070140816, -2.1141675440122767, -0.9039054420310563, 0.7887975910926983, 0.008937199337907667, 1.371674825893489, 1.2188983024824354, -0.08175920577641678, 0.5341329938864406, 1.7159324624329295, 2.920749959011631, -0.5611598023842201, -0.036150936926493724, -0.32749662258175544, -0.4533613172553061, 1.2318861853732364, -1.7402037990210273, 1.5727218071069693, 1.0367168822885986, 1.3501972727070137, 0.6181844960503236, -1.2450091754393184, 2.020748106993755, -0.7443703193505388, -0.4198034320077518, 0.7052421059670942, -0.756520634416962, -1.3716020676614586, 0.8490662697853991},
    {0.2105363515229105, -1.5677097677730572, 0.04373758594849048, -2.398146842166722, -0.6933871130375334, 0.37690404334064626, 1.0012743682270808, -0.0699594427200489, -0.046340210487941375, 0.3288520133725897, -1.2895440262159295, -0.5912168162936561, -0.9631948013675214, 0.9296343513847445, 0.7293074028981015, -1.3149975618723169, -1.711911819596978, -1.6170051758671975, 0.7508855742807213, 0.6834488010141881, 0.08463424149452008, -1.46932842963621, -1.155617305374253, 1.0788580677229866, 0.15152591622819414, -1.2656565503306512, 0.7408186922895579, -1.542526598555012, 0.02734688983517498, 0.2792662102165633, -1.0525554898925842, -1.3223664104326678},
    {-1.4303710879978464, -1.5469772697950839, -1.583047812030812, -2.339446668134928, -1.0166868015883699, -0.8413696636298202, -0.033696422683472324, 0.33458481741449875, -2.00059442045063, 1.2552149380684865, 1.3656984772015202, -1.2038582734024303, -1.7879517499113455, -0.11414069075278026, -1.0070661569204402, -1.6087594906219076, -0.9346333875739735, -0.8954341044561284, 0.10336540140275849, -1.1101408236932713, 1.407638267811209, -0.058207676877107706, -1.9390684751241856, 1.4102163855944643, -0.7210180746720221, -1.0495994977779481, 0.4129041877144577, -0.08770825636102483, 0.43272852601307804, 0.45103955479073277, 1.149849423383658, 0.09080539107567004},
    {1.315221842773759, 0.6723098640883427, -0.637474436091422, 1.756759188619147, 0.08754479634904627, -0.5015335945691195, -0.6753661240580068, 0.3301834277118218, -0.9595314392521963, -1.3203691435890421, 0.45844738818809044, -1.8395713887461558, 1.4824414195275193, 1.4903958883690493, 0.36399131750130176, 1.3673676394917904, 1.7002500793536477, 1.1350960657112854, -0.000917650035324948, -0.3134906998699176, -0.2545590831830333, -0.13179049223997977, 1.724786148633212, 1.8069473599878847, -1.1875060556069372, 0.7210263207839905, -0.1440903018679828, -0.8218732205593279, -0.3208117803370404, -1.6521994940556959, 1.626757489794766, -0.3515215450055227},
    {-1.2383121173753644, -0.26753170149857297, -1.7637031498559168, -0.6368587298939392, -1.8150024310313368, 0.4246631097290538, -1.7135951010323076, -1.4795442387772377, -0.8702106597896879, -2.1217802746103738, -2.211542483623943, -0.9240550950536689, -2.360174388424642, -1.0817064577740725, 0.3187166277486173, -1.794812397630014, -0.3746269783334291, 0.7132100928572378, -0.9409139306636688, 1.5351166378532677, -1.2182157552766326, -1.9846020965226359, -1.0951779159890358, -2.22502490202744, 0.5258043015340278, 1.3366910250079203, 0.9706866866683966, 1.5021441638412096, -0.15417659253845375, -1.5845457639505167, -0.6004971368960283, -0.6132148428832155},
    {-0.15895112401076372, 1.0472028872941554, 0.5273006909494771, -1.689650781523205, -1.778155623576366, -0.8839453802540862, 1.2466537220574299, 0.8219247930290903, -2.3352089642911897, -1.4250617186965668, 0.5336015413829368, -1.4259035210065119, 0.47528871945731804, 0.6157556399533887, -0.22577690592603805, -0.3667450173439108, -1.052992722975043, -0.5505965286575868, 0.9642562105499195, -0.7045767368617611, 1.6353508116495599, -1.5549405814440629, -2.3335220050104795, 1.0765602770489326, 0.6718379506503092, 1.2256483889794827, -1.135633816357284, 1.5783117289542095, -0.27576007962867555, 0.9723741129869724, -0.09614737742528821, 0.6210549252524253},
    {1.9055741149968066, 0.8633261494213299, 1.0036410109098206, -1.0489000493916523, 1.2886598182532552, -0.6417159796821099, -0.23934534043714473, 1.9722266835819193, -0.5089263617084654, -0.25473270740234444, 1.484920873562236, -0.8828535826253135, 0.9330537282448453, -0.5163344050455987, 1.03811737588492, 0.8147977378050443, 1.309654003519734, -1.1939393795067526, 0.7217522511561797, 0.2378508354987326, 0.34913505932655226, -0.7309160942534572, -0.02115288984077405, -1.7559885956870411, -1.4118041569581359, 1.1235889475486658, 1.5829168434233456, -1.0971906485209035, 0.359121560400788, 0.3815824555286168, -1.5758362220930977, -0.7909987219672305},
    {-0.8034321321445712, 2.2209481170473313, 1.4775440006536744, 1.55517330569284, -0.10011283799791569, -0.22842182326938498, 0.9036383644837928, 0.6445210253281891, 1.0222097445701464, -0.3095216249879628, -0.04812290837035056, 0.03813078705651139, 0.9669865870382539, 2.1169021920228484, -0.5831314068486706, 2.1495818487794423, -0.44881154286291053, 0.5791255116283823, 1.2981271740234788, -1.0042980807091766, 0.6286420296956312, 0.9431375652575698, 0.2383231876981184, -0.24670345510500877, 0.1101192669688371, 1.1137381672316535, -1.0033398806660523, 1.387334669409349, 0.8877884136582137, -0.3243402591975931, 1.4724674859012155, -0.43351992348636814},
    {-2.7750061744694325, 2.0984415684407773, -2.707775178082327, -4.6989515996540785, 0.5065137640477543, -3.6803873895551207, 0.24429224221562737, -4.208921950839528, 0.7912787827641813, -3.8813912461089193, -1.6487929853319412, -0.9660776426597832, -5.9798100382452075, 0.5850612199356074, 0.31572642174887194, -5.061483556713152, 1.3097208282918984, 0.6716794500424044, 0.22458617814519147, -1.2170461762906435, 0.6416569773335892, -3.530196389810141, 0.526201945335816, -1.3958020446947523, -4.188284919483, 0.8016435921574039, -1.7991360300890311, 1.6465505180455213, -3.849672852678193, -1.0050254845589746, -1.598989866662255, -3.791685314818432},
    {-3.2644283554194136, 0.8505102188151097, -1.480901585862113, -3.845198547637897, 0.9177859750508139, -4.055777755250416, 1.331796292482473, -4.234934339146332, -2.850327927735078, -2.622358592781357, -3.6750164954737623, -0.9485117521857517, -4.848031631509288, -0.6561128775072833, 1.1464089448736887, -4.363259542807943, 1.6204515440977982, 1.2437202169743844, -0.1623590495207484, 1.2442179103909168, -1.599836305046114, -5.056564249878843, 2.0472661857395855, -1.0637825655677728, -3.7947311267885246, -0.7486171468195896, -0.4827815579274046, 1.2743924214993152, -2.401059230053815, -3.100439846588018, -1.7220907609609701, -2.850404897730869},
    {-0.9035175994056626, 2.2607112756913086, -2.2663179113608445, -3.2175246328868203, 1.1062287412073208, -2.3884300714751223, -0.7146908711644464, -1.2237256485363364, 0.6354627781979485, 0.0010744429009449912, 0.02252854250662738, 1.0761480354447812, -0.4504271712896013, 2.179863907290418, -2.0620588269700377, -1.7186412587017128, 1.079318691950934, 1.5535550625772236, 0.7679252922047688, 0.8554161945552766, 1.002864156047099, -2.79199309418866, -0.2505736321930521, -0.5231262968143444, -2.8100941376047066, -0.9655441950496275, -1.6126178652486705, 0.49533558329436606, -1.792881862694715, 0.7837756849493236, -3.8394103302257743, -2.9394000830857205},
    {-2.528893975516634, 0.09571293491093608, -0.745169536912472, -2.0118889725262856, 1.8003326978813419, -2.9529794598063224, -0.5826808084156283, -1.305300241789358, -0.6520104078403496, -0.6105741138357408, -0.5331650542407019, -0.30971324616912776, -1.4974725503106885, 1.5131139624701466, -1.8672698874383002, -2.17999662096298, 1.4485281968824641, 0.6732530971671381, -0.40618493884444323, -1.6443797604945332, -0.20000925328011218, -0.7712783114641129, -0.3522923659535063, -1.1500816305632273, -1.8125720384456532, 1.8066069914012262, 0.707805601218432, 0.6002270440369963, -3.8127447826149745, 1.7237731290717813, -2.606389241090458, -1.5032577847760573},
    {-1.350661429434743, -1.1422995397693503, 1.746809646298015, -1.4926587397034101, 0.5206216588861573, -2.557113426255548, -1.0312274277733482, -2.4308412490903573, -0.03976388485786606, -1.7479320191746344, -0.19000580501176895, 0.700798436233116, -0.7669559497534383, -0.7721015268419941, -0.5509897866046709, -1.4632117709280814, 0.030052702005010232, -0.17934845611989103, -1.8186212143214808, -0.06504964761584194, 1.7336679348353574, -2.701638157827118, 1.6069686980437599, 0.8928716396632289, -3.1501605999418296, 1.675761708030484, 1.324136587476791, 2.018508279666468, -0.30691128929616057, 0.8959411862547435, -0.4844238659515961, 1.161416158619516},
    {-1.3951730689585824, 0.6991818005577847, 0.6071112637501895, 0.2073645165937534, 2.1769806304311645, -0.8605424655959021, -0.26610948390770256, -2.588308693855816, -1.5836037549633954, 0.8792773626554058, -1.8368780795626252, 0.7888973441852848, -3.058707790171933, 0.8011290241291691, 1.7343323643585096, -1.3073216344981202, 1.0082001587087206, -0.704501462038796, -1.662728897091304, 1.3534681317352553, 0.9474499677648415, -2.355296955962832, 2.3370795138379314, 2.5964457736989544, -1.955200687337738, 0.796847571420628, 0.5036160195349559, 2.817034011619811, -0.5415867005159012, -1.8954393239478222, 0.2747219194297239, -1.025013893815251},
    {-1.119774326910323, -0.6424776758367564, -0.6105130855100714, 0.8240818202948509, 3.3937414343150816, 0.7093759800303694, 0.8746245345214484, -2.0788493790027447, 1.676220808866048, 2.03984514278074, -1.5734744857743532, 0.5925974205275198, -1.1691743954444056, -0.20709674447475135, -0.4034138169886785, -0.28825381669340827, -0.15244567965921635, 2.603707004724684, -0.5880003573283737, -1.26368968151863, -2.9164338510619547, 1.0221080337643658, 2.4186144805143055, -0.0368714499641504, -1.2957924188083907, -0.17553264182418737, 1.8604352562337336, 1.8146201502938906, 0.31763360158944026, -0.8981759974152589, 0.4429119024468051, -0.09088661472749024},
    {0.2619531699089393, 1.32008974752742, -2.695393991281313, -1.76802691094766, -1.7159509649156968, 0.45874837031026644, 0.9214629876395563, 0.8945074407533051, -0.9408789969680434, -0.4577810453749053, 0.08083671860564863, 0.32274853974127404, -0.3604077982895185, -1.1446632598579853, 1.1895726560620703, 1.1971954125246511, 0.4414662211268584, -0.3704156309767458, -0.11959024054715707, -0.7393853666730116, 1.7580445640345472, -1.4747377514535902, -0.8557350716250665, 1.9988788509356608, 0.38253755743773954, -0.5622603317618605, -1.585065706813123, 1.7722520018233459, -0.6767272774653038, -2.049182511228399, -0.047671697515693175, -0.36296977330928587},
    {0.3198832147107169, 0.06274299171354308, -0.9617846408611483, -0.04823074783055517, -1.322682459643759, -2.76387347789811, -0.9518064034726524, -0.5261003492603579, -1.6262236351048083, 0.6229800472153343, -1.972625096560207, -1.2938495407460207, -1.8897077561107563, 1.1926636195867961, 1.4328951445867697, -1.8115659966085076, 1.0886996481535711, 0.7987474746472871, 1.3386631675394012, 1.6631978321458247, 1.7962332694704413, -2.596084823194287, 1.0497487890269024, -0.0005192170439805962, -2.022720949386055, 1.8322454258889622, 0.6642405178698433, -0.7933301154467131, -0.4932540713395362, -1.711063629715618, -0.12940240686064036, -0.0750415350836899},
    {-1.2663142201413633, -1.4108875189028744, -0.8356272202505146, -1.738103264832558, -0.5520952550611077, 0.4690504804433459, 1.4744809106602945, 0.7583223389006146, 0.31772446868476834, -0.7966764753452151, -0.8850640923918816, 1.3154241933719124, 0.18555229547736016, 0.7508149046427322, -0.6464596566589101, 0.1472424092701197, -0.005332415095961784, -1.1497092927769965, -0.2748466207396888, -0.03490389951181525, 0.019788125852277894, -1.1413723576588677, 1.668136335618978, -0.16484378232087835, -0.328701369277309, -2.7124039120646404, 1.0124744794818594, 1.4491467491334822, -0.21355360016272001, 0.5769150658858897, -0.13075945453650306, 1.6176495108352276},
    {0.9925325416166585, 1.768828561277913, 0.7571760862889974, 0.010469313951407705, -0.7599922870110318, -2.4217418660932073, -1.6140622779307443, 0.873589335004973, 0.6723054952539428, -0.7655426838524553, -0.4849462271134181, 2.345601966829388, -1.9889581155257658, 1.9712387615128466, 1.8442963270979067, -0.35546528193444066, -1.6685944833764759, 0.8678383720417322, -2.022517711493936, 2.0559807069827722, 1.384557471469128, 0.5973169499783383, -1.441634126215596, 1.7232409596549076, -1.8981538145893824, -1.250985067359328, -1.0095185813038245, 0.13901613368142335, -1.5651008726336109, -1.6876809075116224, 0.49299133952277674, 0.8017810526848043},
    {0.03567006479595575, 0.09753310073904306, 1.2971038888131055, 0.47660139706285276, 1.3697127096624901, 0.4886777709990762, -1.0997813124929274, 0.804821204781625, 0.16592363181315864, -1.7798040819486762, 0.27029877051193335, -0.1321624038072567, 1.2556038385477508, 2.1250597656350725, 0.8714686156854269, 1.101212885789167, 0.9747077249562254, 0.6447904920801626, 1.6827714579002468, 0.3624233827680812, -1.0260654132118938, -0.785065335662746, -0.40184368533484555, 0.3331699299807964, 1.1880528938014772, -0.0231479116938062, -1.7476832578088497, 1.8261805686967263, -2.336635201244664, 0.8509858550496151, 0.17527122923437122, 1.6644875761537739},
    {2.220642024948417, 2.2659601313590154, -1.3004116734108686, 1.62464816052974, 2.045568893359706, -0.5572701269120142, 1.1892835757734797, 1.8949357249240482, -1.6491340622023398, -1.5346111095984885, 1.4097370240200071, 2.4561998358198682, 0.8905763319665311, -0.04553385261132311, 0.4696597433488869, -0.16476415996167532, 2.1858243734816134, -1.004723070843046, -0.30942237975546305, 2.8923461642835395, -0.924036823768467, -0.7159062601933119, 0.8768483531592166, 2.5516199876236927, 0.46825442588933525, -0.8465350971964686, 0.3900636966919206, 2.637928145621984, 0.2998293503618928, -1.5602322263789783, -0.8367350059358024, 0.8448008039585881},
    {-0.7944150082647069, -3.037552475718869, -1.3755991755412393, 0.3004604264035949, -1.3394034828608594, 0.23782928856504987, -0.10732679867950003, -1.3657891008731535, 0.025252024427449265, -1.185137405083916, -0.07975772423307254, -1.4614547550098616, 0.13542609134503333, -0.9263807652296958, 0.0011914349257179024, -2.1404705994266786, -1.5082345446600658, 0.8545960864817985, -0.9067182121814215, -2.9302716318903204, -1.7246287182498745, -2.3417045490299184, -0.42574570507279597, -0.6802005745884884, -2.111078345867582, -0.5879756339228339, 0.4587850261113829, 1.3091031164981295, -1.4282457456059434, 1.4854988379163565, 0.4410144130983693, -2.4697454940641888},
    {1.5344367102254517, -2.641613724107502, -1.3823266393574432, 0.10049369891344181, -2.5974311071425307, -1.1633355620585448, -1.5116304564570282, 1.4973293961970169, -2.156102108930379, -0.3147508670871918, -0.42656841942080054, -2.426172178785442, 1.7717162183308404, -0.501584615052371, 0.8766568328403231, 0.4683110225305362, 1.2972588578854884, 0.5909133018096627, -2.017291822706884, -0.23109673815380447, 1.2957235716270714, -0.2337016766477455, -3.007388257340601, 1.3732277641070463, -2.1859828626490336, 1.4118996608171828, -0.9358404187989081, -0.7878982693942452, -0.2980221654899432, 0.0023041202236813284, 0.5599765338357702, -0.5323618662959981},
    {0.33206144400600507, 0.13295809047158366, 1.6886736763643466, 1.5745823915654944, 1.0196326655404309, -0.3754558292037683, 2.340797104316149, -0.690357781368085, -1.1774979551066658, -2.025481032271116, 2.354187860343931, -0.7404159578922669, 0.7573400352528501, 1.776766223150566, -0.7417394967362495, 0.3260444844878584, 0.5729678006136907, 1.121765543008369, 1.7865692715356614, 0.21287248847099716, -0.2097326139630552, -0.07317758853555574, 2.1319751849474846, 1.37189186281461, 0.7107717638491842, 0.05021257952389005, 1.2016590574579502, 2.6909370078820283, 1.42031140612079, -1.2428255737515104, -0.6685170275708461, 1.4678277839463991},
    {-0.31217176700993954, 2.5931817733187437, 2.1088956958567797, 0.42060089130268874, 0.5174853335411133, -1.808725536320819, 1.3289397796636548, -1.6535486071022392, -3.205295464978784, -1.8351864198894239, -0.7975827740743591, -0.9896652622049177, -1.6052983520208042, 1.4640960175606585, -1.1144049245687835, 0.3609133492233003, -1.3679725321134275, -0.8166036319389497, -2.074324268907397, -0.11346865970008595, 0.40643119035485475, -0.29429866615912925, 1.3288909511736073, -0.8749675491942918, -0.5239824706291625, -1.0296894109080243, 0.21561325122923788, -0.7030960409187857, -1.647274331443378, -0.586007794702945, 0.3899892011486038, -0.2338515920749796},
    {-2.0759640862792383, 1.2985982670500962, -0.20554186283740503, 0.5115846449898318, -0.5238382362550912, -1.691269470067128, -0.6114272562401799, 0.9763074202998833, 0.6667918361155691, -2.0350782279150406, -1.2184005475112052, 1.7272984981717308, -0.6503923151840413, -0.6561299168879745, 0.9056243116149161, -0.6426474611449811, 0.19050007398332364, -0.7148920288240647, 1.8023237883256122, 1.875271437695355, -0.8386082638287773, 1.4905443204820783, 1.4587083952879756, -1.07259174883703, -0.10112292729029385, 0.07882568260609142, -1.095693030758277, -2.2752922491153433, 0.18177134258087996, -0.7769121574695254, 1.0535217178250331, 1.8041735320854853},
    {0.464958977367623, 1.4560042268859643, 2.178771740192311, 0.9073033192092965, 0.14796794299644594, -0.31468947570197325, -0.3395170773292712, 1.2814989271029897, -0.6208135653428037, -1.6780989698744597, 0.7506237812910503, -0.22171457418944468, -1.079242554768086, 0.12705418649155717, -0.5045549168872753, -0.7396346187146897, -2.8735127662014524, -0.0386588448202283, -2.1738725584361305, 2.8078041015552135, -0.5860661576206687, -2.009881416017338, -1.079834909783352, -0.08369062917689951, -0.620566830966936, 1.1774174859341389, 1.4992414079063068, 0.6197062129821558, -1.9072443949476048, 0.5338664823002728, 0.19036016918369655, 0.6914008439623326},
    {-1.6916053466819083, -0.551393518226121, 0.2560952131526736, -1.1189815413851987, 1.993130712458503, -0.5018246835583984, -0.24407819797018634, -2.253258254279202, -2.777688226700438, -1.9297455804470105, -0.8032009484783429, -0.5196139242993574, -1.0080950216836462, -0.04762905617350779, 0.9503896677341518, -1.963789902183916, -1.463398616902691, -0.8727411133147488, -3.747981943475954, 1.1066528470739518, -2.630662359151878, -2.164937655216439, 2.243885192268887, -2.0178484971026536, 0.09554841905057618, 0.28328059979481895, -0.6927789952459422, 0.264068773875722, 0.757031831942786, -0.23684570304035124, 1.3001764545432701, -0.31146940161405606},
    {-2.342822294780948, 1.1014720385130237, -0.19899734456784518, 0.8159801697320515, 0.8435165481333987, -2.1267242195648137, 0.6408081903394318, -0.8043388016754976, -1.573719180027395, -0.4210955228842087, -0.3562570474391163, 0.1669335767299253, -1.923017970788998, -1.6540406646487151, 1.5738406779925849, -1.3441206001196402, -1.9213619226051082, -2.295422956685042, 0.3681478102473601, 3.054874864133124, 1.8209163248949114, -2.119239121753042, 2.2933576156482296, -1.5199307988632023, -0.04710319457596363, 0.9391965731811268, 2.003589954730993, 0.9854539804876834, -1.1105165662254284, 0.3843320201100326, 2.045545428213579, 1.5835445206719172},
    {-0.6817366221530747, 2.983191279557218, 1.2722243975236678, 1.6845978221894302, 1.8685644970029556, -0.90998805222488, -1.100692019596423, -0.4868992613367332, 2.109090217424085, 0.47972896129495046, -0.2727835962615487, 2.2675701215071586, -1.648118989842462, 0.07751389750462437, 0.6557280812626632, -1.2646904604220692, 1.9874792571870645, -0.2936675256747021, -0.45427566347721304, 1.4616195129287033, -0.8498446108370822, -0.9172045360128457, -0.22861196789019214, 2.978190238839959, -0.5813952557770715, 1.2741938842435394, -0.3601746525128478, -1.6730774489140956, 1.219807120003468, 0.4380837677929158, 0.9300836369441128, 2.4689327320228625},
    {-1.1466292026975637, 0.19767189563162532, 0.7352537555005315, -1.633043744769045, -1.037017164721902, 0.3858343986619575, 0.6057922466453063, -0.7991677282172079, -0.22823574277554462, 0.5585020599211833, -0.031075393253600092, -0.08948665684529039, 1.0444210516438162, -0.7675118571073254, 1.0024124299713355, -1.9314253126485985, -1.4698045764088616, 2.003556101531367, 1.2547868128230517, 1.0275250766732922, -0.7582166059564254, 1.6115464342395809, -0.7209968231682878, -0.19493067203045866, -0.44499845133659355, 0.4351794731763518, -2.8251027415093004, -0.5002289551714306, -1.061422542371298, 0.8600003315647965, 0.9849837634277258, 0.6332534140209165},
    {0.7996140548635196, -0.41072249418410717, 0.2618313495786906, 0.20063323842805975, -0.3344803632390265, 0.7852077558614421, -1.0305582636585309, 0.4407638767053362, -1.7215233356553754, -0.4662377343034421, 0.8984079956234993, 0.5682610821775155, -0.47844209155407086, -0.038036110313645066, 0.7058590758854647, 0.9800351856249969, -0.18003394052127433, -0.06083689977791158, 0.7683659305057032, -0.0066554150296402196, -0.48059850692490474, -1.6440816317914295, -1.017885252124574, 1.5582673788829506, 0.42569249343958593, -0.6623990613487725, 1.6003512502970008, 0.5248191895654487, -0.566225166088639, -0.2300726887892754, -0.18835824602437784, -0.8986520553413595},
    {-0.40376495312203603, 1.103844934140205, 1.4599559371725184, -0.8898713345868501, -1.2184629112250212, -1.6701746080219861, -0.14173160172404775, -0.7035470033783414, 0.2065265946578672, -0.23149097751688835, 1.4114126455361933, 2.1501372676484727, 1.063610499833309, -0.6318110979680601, 2.042389832542028, -0.6197226463673993, -0.3850778491732412, -0.9461049135592564, 0.5617635690947443, 0.6966147383690383, 1.1971850511806663, 1.505573914452265, 0.404439294640158, 1.1999831325092756, 0.3517506216980866, 2.184718890895044, -0.49452693217103255, -0.6970462291981483, -1.9854819262022396, -1.7846630218935897, 1.5483228490533922, 1.4507700358180078},
    {2.013909380113211, -2.0799406490558225, -0.46076273025214814, -1.4158480446608903, 0.8058429746137774, -1.1547709886734279, 0.9522146149029516, 0.5184365336540023, 0.8890586612301915, -0.6131073452679058, 1.5809644873763693, -1.9844770110810426, -0.9148023823015634, -1.3460122496625913, 1.4266277976644375, -1.294576979564038, 0.949652542819836, -0.06412970352134233, 1.454052136711183, -1.51925175978153, -1.0840288812654606, 0.23497822208668104, -0.7841151735256241, 0.8699302810503161, -0.7514888652712199, 0.3591404689652509, -0.326205174536276, -1.6536077665951427, 0.9136450823772203, 0.2640430222301885, 1.169824441994932, -0.8051580142636355},
    {-0.1658658007042376, -1.5190730203949419, 0.03957141263964682, -1.7089895810431492, 0.5590979031092039, -2.5609590682836134, -0.5357678511430285, 1.0906342073181752, 0.25467500821762523, -1.41999742624974, -2.215497300824706, -0.2932553718973869, -0.6473694039383997, 1.2119728161278007, 0.2881456277306923, -2.8993630414714233, -1.1733399844000458, -0.28282255484369, -0.01966565040643058, 1.1166278890560946, 1.8826380206909696, -1.5854708580651047, 1.4436978732513526, -0.8409804367638538, -1.276233386236055, 0.3882710285063784, -2.3450189225757665, 0.3302336249256186, -1.7107008153882244, -0.6939728988934136, -1.3698321635525623, -0.9920654806481237},
    {-0.028716213619645648, -0.7464979617114126, 0.9398855561714337, -1.8679119373301374, -1.5397968790701773, -1.132012783094452, -1.8610871272332976, -1.9166475963078882, -1.9072642609277806, -1.839778957665353, -2.249778272035651, -0.3127134016597987, -1.1981124014253726, -0.1347931548605227, -0.4628942064008412, -0.3900685658171812, 1.0868825928517243, 0.7978539905613121, -0.9236112584980709, -0.8871275485857737, -0.7476349309530607, -1.9487644866129696, 0.6078060263506238, -0.044575237175160126, -0.9977540772651422, -0.08344368710495109, 1.305253811126202, -0.20213296058421584, 0.4787051292290716, 0.792437256078135, 2.1418521619609097, 0.6656168274329888},
    {0.8946967050853948, -0.6331739550036215, -1.0885422711595243, -2.096670412968257, -1.7127616617805623, 0.9499993260935319, 0.6016834685677072, 0.49054774669122253, -2.697136278220422, -1.1712489134901485, -0.8836592072047543, 0.42452134363182464, -1.4855696509727208, -1.441714226704484, -0.4848442007206649, -1.064281792730184, 1.473170845525692, 1.7094972322527628, -0.3991608514262254, 1.6269354531286921, 1.4182783220885469, 1.0506666029233984, 0.9013863928229011, -2.1689071401906945, -1.805564146142888, 0.8035019204404714, -0.6539658498035303, 2.3727723524643385, 0.7753074594262083, 0.3100145994555504, -0.5230762859962954, 0.8510973019862282},
    {2.1549118953837896, -0.9286804188820886, -0.27475671762088905, -0.5246506786589709, -0.4816028765644733, 0.8506567285533185, -1.8417315260172078, -2.1392278900447437, 0.2313193796362447, -0.11616041756195505, -1.0361763742696855, -1.2949803260826138, 0.942813603355471, 0.5674443641129244, 2.4810309756918594, -0.29481430664971026, -0.0013589978680164862, 0.5011570537103017, -0.12082625242740803, 2.1131371633778744, -0.9546547165411247, -2.112047029880025, -1.8013767570404418, -1.6235196085584962, -0.9966797415318611, 0.9519641855907367, -0.36671567853623155, 1.4826038193187492, -1.3769742879840052, 0.4455421123129744, -1.3239160060576698, -2.3021712800516196}
};

static const float b1[32] = {7.965952455691615, 7.725120021543196, 8.237815026123773, 8.083935374032379, 7.429021534508578, 7.887519291933816, 7.743442869019405, 6.832707408714726, 7.845859321331852, 8.02062926377613, 8.363111189060259, 8.38800286920062, 8.075005699100961, 7.759611502731492, 7.2973403734562075, 8.149295553363539, 8.296545829650638, 8.056304868295422, 7.876725734121339, 7.894289838238005, 7.449562954712333, 7.912625809764989, 8.167145856002318, 8.07831799832494, 7.876945895588949, 7.5802917104504415, 7.862469006384642, 7.751409738207046, 7.815385280663264, 7.627940976628089, 8.278707807653069, 7.869654161578767};

static const float w2[32][16] = {
    {2.3822439238567714, 6.326771739653521, 6.624409558725401, 6.956735919579507, 7.064389415649516, 6.202866062477929, 6.7145155745142935, 6.8529475231371295, 4.113188063695282, 5.82413351360733, 6.667866635320746, 5.096750112853429, 5.828725804932774, 3.013349889082749, 5.58542852026662, 7.213251195899883},
    {2.0551748928229907, 6.317988555213104, 6.269149882188097, 6.3650660352497574, 6.2090465607512995, 5.141889169180812, 5.420228014417426, 6.070178834692213, 3.9915436984426163, 6.613160316435836, 6.798331745026743, 5.6375681513267475, 6.230772608346145, 2.442848189223928, 4.443189672741159, 6.280010223842729},
    {2.9683724738683597, 6.319126374589441, 6.767566375125544, 7.204255256677277, 5.401256763749944, 5.43584244734575, 6.5404963035462815, 7.325039638638431, 3.8691088977539074, 5.691132985880269, 7.515178860363645, 5.143621714206542, 7.051456307782339, 3.6933000567901346, 4.718852770455227, 5.651196646613642},
    {2.2165478647874384, 7.43606561162596, 7.349387682204073, 7.542998943693354, 6.263805702059728, 6.914818523152534, 7.575812980294378, 6.419374320894141, 3.4292863200254313, 6.813225493626211, 7.321795272973401, 6.088226349930666, 6.412967739099671, 2.56946494348894, 4.883380165767501, 5.7781611748309505},
    {2.09818402813693, 5.279062151104758, 6.45966453655824, 5.934902374990325, 5.355651274337761, 5.441057107394251, 5.3085616440637935, 6.208544156487355, 4.084702078525786, 6.062807048511534, 6.581461585883623, 5.251675498794025, 5.579428456060168, 3.97002208831831, 5.079079510460529, 7.1021699928017465},
    {3.3917440503432705, 6.983935432276902, 7.258273519618246, 6.793489566170856, 5.846546413792354, 5.524197755438513, 7.262612252201082, 6.7996110138398445, 3.632671720466318, 7.464792641055547, 6.144596813640594, 5.673888370121945, 6.346508598751869, 2.9623529550978804, 4.10140657366526, 6.400106305111952},
    {3.494005320557415, 6.56078678664955, 6.223038434266139, 7.495634764479953, 6.851123511738923, 6.6291657681493374, 6.42503757232766, 6.860389147329382, 3.9426055478424353, 7.2516273804639955, 6.0863082140836395, 5.848429020377097, 6.280868472864978, 2.365650402632401, 4.216100900745048, 5.465719989864024},
    {2.3872347801684013, 6.237926697953631, 6.190218304531928, 5.6811074844163665, 6.321496474900427, 5.421675869861744, 5.859285711017739, 5.6282337971224825, 3.559664555524636, 5.667141584721805, 6.099085495394288, 4.658783765574564, 5.747735902167202, 2.456461225214287, 4.9347926867485095, 6.750548328008583},
    {2.847497250852635, 5.89619835045998, 5.861090959427572, 7.372761286913651, 6.697195335664353, 6.050596330846059, 7.258773636170262, 6.067107894341302, 2.739314634077698, 6.7150184787638665, 7.058690064639382, 6.172027832952412, 6.85850584933937, 2.810823316960095, 4.148379055168595, 7.198162714892791},
    {2.7537473171269444, 7.143621942918081, 6.819922714943947, 6.576899727875864, 5.662070772341351, 6.581467934351579, 7.3961222301603335, 7.567589443222434, 3.5960655600786673, 6.342738776143733, 6.266801443491945, 4.946898436262934, 7.394074136613684, 3.6803292919516677, 5.397101380943373, 6.904347800805366},
    {2.8939410512046515, 6.5238729746241875, 6.659687004765809, 7.36894072680178, 5.7749142707115615, 5.8961182061497865, 7.482495477964262, 7.283110871407438, 3.4862532429973427, 6.53972061292033, 7.1936395278472585, 5.089501724029148, 6.641542677041339, 2.948040684605319, 5.187875569407713, 6.088192806104067},
    {2.828859921241341, 6.568300388977295, 6.077407295751445, 6.329444749090925, 6.256288144126344, 6.276917903982963, 7.2792722493874855, 6.4478527582897875, 3.763708411403499, 6.077980073574646, 7.5201241697158485, 5.011564213015689, 6.24273178672106, 2.657100195336575, 5.774554218165507, 6.124581769957079},
    {2.912435019852431, 6.816224629218917, 7.379998942748236, 6.295439662244752, 5.3009401002334355, 6.094072027164863, 6.620017877373392, 7.348177878155424, 3.0802097590793776, 7.14914620094258, 7.067338010675685, 5.612865253317152, 6.359209493132257, 3.0925512978490346, 5.609149163759402, 5.7874345331086845},
    {3.543139774931714, 5.3499076285444485, 6.3757796875159185, 6.245640290367465, 5.12278926182754, 6.217525977419354, 6.566941592279429, 6.761332518755739, 3.163368298323235, 5.674161800106086, 5.716388459584974, 5.224350948666305, 5.923956484057632, 2.9990384304769533, 5.029952018718402, 7.08280696491122},
    {3.3530905985852697, 6.234269614986457, 6.99077763470887, 6.360808751294685, 6.937691161092569, 6.273102566448445, 6.008523949623145, 7.030352056307086, 4.155707655965421, 6.012302351348368, 6.2255191611397365, 5.985912762478718, 6.481195854056374, 2.91769282301445, 4.278754135810526, 6.008195488013525},
    {3.0769446380501293, 7.115687515481956, 6.132585683997727, 7.241005994252921, 6.112286482361991, 6.515631527575227, 6.684317448827699, 7.697006994125213, 4.644031153545442, 5.954732204028867, 6.234445466940368, 5.1771740162424935, 6.597534672703031, 3.54700006541677, 4.259038371087284, 5.997290228525898},
    {2.6034376277057016, 6.0775518360000715, 6.678297395871613, 7.378503001398949, 6.035715603354927, 5.826615955920882, 7.522452564896446, 6.718538250967001, 3.286515108664204, 7.374875652278482, 5.923757987405307, 5.407774650367295, 6.5571491675436535, 3.4001290416604997, 4.363654258085481, 6.676867783037326},
    {1.8685484668010466, 6.0705158351963915, 5.604571088244886, 6.325249295745123, 6.228425366352532, 5.128642878177297, 7.087897405468899, 6.901374381133989, 3.0728190759620038, 7.1020279293897675, 7.1179874751752505, 4.432955829352723, 7.527513616113562, 2.8584147101546544, 4.17597524990374, 5.913307846348867},
    {2.850803019918305, 6.799493806534095, 5.7813100347421225, 7.5352333757801295, 5.577837670965294, 6.133523489492243, 5.788934450370098, 7.450867605240054, 3.9834097935168606, 6.343557950231367, 7.139287767129391, 6.073854544530945, 7.033868068337341, 3.80257076228039, 5.372940641557819, 5.8979743055602185},
    {3.15864683418595, 6.5026315552371, 5.878205740119617, 6.871306871833557, 5.721296306304898, 5.697809572368329, 6.456543773179916, 6.651373951016094, 2.7445393257610076, 6.632234543773627, 6.521794821578748, 5.6189422540223735, 6.000168254633617, 3.993920810147793, 4.7145454809200755, 6.847050300131339},
    {2.4188157577234453, 6.001063627183291, 6.792240617787061, 6.2151702875257895, 6.153665503219939, 5.360552318931495, 5.998932469769649, 5.580671067827918, 2.8385572988713714, 5.953579013925491, 5.326531244647421, 5.529138606663139, 6.906046522218194, 2.3552427104974853, 5.386270529868974, 6.697532330282275},
    {3.2830969970098445, 6.3935307698581045, 7.426883564959664, 7.064900102043276, 6.771362911384538, 6.918471523502161, 7.447396390352439, 5.875451170172681, 3.5570694731897197, 6.29620963051135, 6.900101759147704, 4.887137149579775, 7.356610277311884, 3.2130877915035008, 4.316665956727803, 6.5022163542673415},
    {2.0402994721094494, 6.154797244597742, 6.243226375775781, 6.548641127200976, 6.068823522964145, 5.953336456181918, 6.60798383752611, 6.863428283326281, 3.741812932414705, 6.944861959134969, 5.874248336892786, 4.4368109753260265, 6.102845787782485, 2.5873562595615875, 5.349910134119296, 5.98114401838409},
    {2.9621782313947627, 5.468166709450149, 5.651276449198432, 5.752903729955115, 6.912900206459407, 6.2230698487144265, 5.936385609068058, 6.4298264038520445, 3.4232363107587194, 6.659599175351859, 7.557929410398218, 5.224812857281731, 5.733544361310542, 4.117183411385039, 5.090185591718844, 5.672772487126053},
    {3.2071519606834684, 6.584561721374489, 7.584141207410302, 6.89706487512986, 6.2705638009116145, 5.772725567910704, 7.55210075237843, 6.626730693360814, 4.3229024658685455, 7.502990585323933, 6.304024698597792, 6.145599107099483, 7.897507829081381, 2.7349610222683607, 5.051892836383083, 7.301124327063516},
    {3.5608734723148854, 6.23851124164494, 6.531285653271266, 6.357058268079976, 5.740987635834573, 6.180261954503702, 5.582206983099891, 6.438341557252122, 4.380898324974476, 6.8134749287047605, 5.668187326093893, 4.550548435230191, 5.517514853223383, 3.400607158567847, 4.533273831901173, 6.143198928323952},
    {3.6253860419282753, 6.046922556989617, 7.617582330924517, 6.7695150469814305, 6.874445861751772, 6.513580635406591, 6.619068544042607, 6.138990966479272, 3.7591138081534488, 7.0749417386883104, 6.469797297358597, 6.330286409666671, 7.333780282947765, 2.9542687183278877, 5.694534314833973, 5.548853157888946},
    {1.9300011405161597, 5.681098207465385, 6.3050913598625975, 6.785866170146331, 6.589629719052619, 6.7621710048598045, 5.58357807129635, 6.768391593469632, 3.189353183593215, 5.682892360262207, 7.4285519065476615, 5.958060092784356, 6.830820361122508, 2.2383760801116503, 4.957260153883687, 6.977677709401214},
    {3.69689196632961, 5.960252320381856, 7.504440825055551, 7.122242965524737, 6.117507519982476, 5.9849793133246365, 6.283813227179863, 6.786008585478494, 4.044515243933108, 6.9119841340638635, 6.193228413586554, 5.843405768486157, 7.737530025691664, 3.8859360596399273, 4.876638294221239, 6.953433363411536},
    {2.467877865732173, 6.172023430079045, 6.4248041309824275, 7.471826514898653, 6.38253150276146, 6.705327771004251, 6.747933443538238, 5.572781036739631, 4.3979888307770025, 5.899086490140293, 6.9010899126809075, 5.996256716709649, 5.717394213348591, 4.018776089413169, 4.913839670986423, 6.688194584107562},
    {1.9257132669523696, 6.935799069866218, 6.5856615950018735, 7.74681274880076, 6.611279062590618, 6.741054223597599, 7.547699776994266, 7.118852858228618, 3.0771032986178795, 6.627532694033333, 7.336847676457975, 4.754185592525478, 6.089666000073023, 2.622729942194247, 4.888494337876938, 7.4684858755581125},
    {3.0674334348915218, 7.022177697152037, 6.452938388712193, 6.293596788304926, 6.892820035399722, 6.773333332533156, 6.983724556446908, 7.677699013243498, 4.176053419525805, 7.070001409666659, 6.049538740456015, 5.672521485401558, 6.238257595053656, 3.608938079442183, 4.973957202519966, 7.362009156819315}
};

static const float b2[16] = {3.3071842088144026, 6.835780216599882, 6.911225871990366, 7.104464453209967, 6.693105338370722, 6.776132992419951, 6.90009656129644, 7.083799854415981, 4.532063916523536, 6.946477755839504, 7.09515887597812, 5.841813956030349, 7.2740351126937695, 4.090843438055027, 5.702150445999398, 6.793582636823318};

static const float w3[16][12] = {
    {-1.8861001566664846, -3.001523289549812, -1.4703609747018351, -2.764188162349312, -1.9362862602658584, -1.4206753340744744, -2.2490090592935377, -2.348362770881032, -2.585388278018114, -1.7820448349496867, -3.2040860335134234, -1.6288928984067097},
    {-3.913272515718986, -4.388401171963366, -4.369330243556786, -5.16587086645391, -4.165356545723741, -4.71604998575868, -4.676885723096097, -3.6901852852267236, -5.347950647624256, -4.597030777395356, -5.3026673642416915, -3.5689690228974023},
    {-5.543193702362057, -4.245222943492295, -4.9741328821906725, -4.610591819621793, -5.036957726666838, -4.439489103878152, -4.600545807213473, -5.168876752300603, -5.288120657143063, -5.005214457168226, -3.6250499465748174, -5.1059985344806655},
    {-4.833366522725443, -3.878972656518734, -4.489288237187158, -4.492155374940839, -4.558883911584796, -5.033735956541743, -4.884857553503432, -5.324551168892681, -4.160679388579798, -4.396692354237504, -4.19029466640459, -4.323649916875269},
    {-5.1353235773778705, -5.185468487612058, -4.126984082388808, -4.425318943589828, -5.382234659514893, -3.834585510958658, -4.152959379319922, -5.320048077692808, -5.008961075978739, -4.951793384016925, -4.227581294652345, -3.855610143760827},
    {-4.711806643734854, -3.9739235707250358, -4.4612556622750255, -3.5849646500119454, -4.736005167236811, -4.803586159280258, -3.979235337861372, -4.954577547572963, -3.824199895722174, -5.119229843836403, -4.946580686746438, -4.385753328490671},
    {-5.372905212943863, -5.358496313872605, -5.450568768552833, -3.770041036518567, -3.928800726153655, -4.810873332505323, -4.407814331617257, -5.254364953321043, -4.186480541256979, -4.558738400508721, -5.307464923431555, -5.162935336349619},
    {-4.359853832192121, -3.7582392235621964, -4.965147782112286, -5.1069053150935595, -4.688367833769887, -4.926661881285349, -4.7514919778315505, -3.684463238856126, -4.143490861652015, -4.47016372868775, -5.032277652973388, -4.821454076125292},
    {-2.1819829610659953, -2.1743298956330825, -3.360762948708086, -3.093499436868189, -3.349802039380129, -2.210931645282509, -1.8624133926115587, -3.2768230639674445, -2.989487336374536, -3.3483737876476742, -3.741501193276588, -2.198024850835429},
    {-4.292564448826806, -5.321250526434725, -4.658150807230938, -5.858665452481709, -4.008486225754125, -4.536566704915784, -5.18330310763908, -4.446814177056355, -3.907348698364982, -3.7753247770719995, -4.895698319834274, -3.8742681709669267},
    {-4.369367037489109, -4.368937027589936, -4.253572223681888, -5.388175520735774, -4.772933751400673, -5.584216814104354, -4.988040800310299, -4.902889801434904, -5.097435965217153, -4.709556942376239, -4.371481061450192, -5.593658967881322},
    {-3.3529667587494827, -4.820984866311568, -4.1615680408430995, -3.212833482158198, -4.286341915475756, -3.301410247104533, -4.447309431931065, -4.575438776238258, -4.376634528340796, -3.2121649650624, -3.494212886121884, -4.136773473885206},
    {-5.279736402770819, -4.338758888155918, -4.231733606114033, -5.258688841214574, -5.338501800615872, -4.948767185776221, -4.488147686833146, -4.63784455204331, -4.51866743271835, -5.334518366882183, -4.941098632686334, -5.352909290694855},
    {-2.4356863348134095, -2.659175591663461, -2.2323049125739165, -2.4594339062214754, -1.6534929325706549, -2.201052720547587, -2.628252939471526, -1.0770412452582632, -2.7713585430924974, -2.5951874322623656, -1.6082300458344472, -2.1454909064539973},
    {-3.8492865007384354, -3.9269337160922326, -3.3352249448131914, -3.1352929576560884, -3.672883310629549, -3.6820981035849267, -2.942054117710798, -3.18857518437731, -3.426807434863741, -2.6026826472629154, -3.30868600130109, -4.0553628312980035},
    {-4.047012694931874, -5.2437740027720325, -5.147485815350982, -3.897695434458661, -4.339217465203391, -4.603084056131156, -5.396865460676004, -3.808850407223187, -4.9516392985950075, -5.365853014731789, -4.285175436771382, -5.158894838851815}
};

static const float b3[12] = {-3.2026568244137796, -2.9345424994732223, -2.890737841017901, -2.8029197324656674, -3.110923256774759, -3.04038059946659, -3.236160856938862, -2.0604797623109032, -2.6322021138066702, -3.198220192288673, -2.88872555255071, -2.9911729409663605};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
