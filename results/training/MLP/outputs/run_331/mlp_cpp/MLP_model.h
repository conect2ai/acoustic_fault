#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.7529896226875338, 0.021855998397360653, -0.447617025101124, 0.0946954408886624, 0.6695329078210591, -0.007730988397830656, -0.4752384569702253, 0.8845984005481319, 0.6680263124124808, 0.6829426402444517, 0.2779975638813137, 0.019497251596115997, 0.6217113875006732, 0.92014839475549, 0.7355583169027354, 0.5481311005125205, -0.037273625716178024, -0.020574413767486945, 0.5156720227233843, -0.15523937813252617, 0.20705779985057995, -0.24275585347233164, 0.26030661220145873, 0.6577134650734011, -0.12161817867072765, 0.5532469003972108, 0.0587650937467078, 0.8595134741971859, 0.6702403936301525, -0.005061608779961282, 0.833197442183129, -0.23431698040718368, -0.21365411658932237, 0.04137583273909549, -0.1512118993645883, 0.7421994626225829, -0.051947916451860726, 0.07813730086769283, 0.7999776937722809, 0.6064225006002448, 0.2996312030792942, 0.6731082941389249, 0.5979971584467287, 0.7709551001752727, 0.028460573715867726, 0.03115574098921116, 0.5791769618438909, 0.24214194398150402, 0.7919643653879989, 0.7189733457719976, 0.3082378239813364, 0.27593805053879505, 0.5259179259083412, -0.11179648959360164, 0.3656744006815509, 0.09490309658143138, 0.16801506449670264, 0.4392681469544341, 0.11583869054484404, 0.1894855244993086, -0.523638684049814, 0.7451489601708233, 0.36605553851927974, -0.2475155048727279},
    {0.6930062776895619, -0.22774650370108235, -0.09860802419303932, -0.2471958877741985, 0.6313636801265473, -0.8113880919457355, -0.541295814140851, -0.15810100481331843, 0.5868562127274759, 0.7065326869587157, -0.221321992489004, -0.22538374197386754, 0.44557913340903893, 0.5289020731083801, 0.5719118211682029, 0.504906088010118, -0.6117946032028889, 0.11823502954934802, 0.14579268999454223, -0.8356996629277742, 0.010105993055723572, -0.5396882456887673, -0.013611111749546798, 0.32261400540124807, -0.15437623244981577, 0.34363211245490377, -0.5454048577328547, 0.6749754397060819, 0.41159939868413326, -0.2906185681116007, 0.30172039278789287, -0.5142406121954978, 0.16251068110674263, -0.5610161750727121, -0.913966590398115, 0.1919724183047568, -0.6001832900730566, -0.8507046626835555, 0.3759968009473826, 0.20162261003654017, -0.4318725223228218, 0.4225923458882933, 0.2825547535207479, 0.6682594681899574, -0.19751182832050426, -0.08907904473016671, 0.626344482910642, -0.33075748482789064, 0.6162920376449829, 0.5147845719534105, -0.4745019525287286, 0.05730267183163518, 0.18978422102184542, -0.6508657210838068, -0.3591521021371709, 0.23086474070475613, -0.47537574704473246, 0.38329898951682745, -0.1157638228078675, 0.331019078349402, -0.5063904655725229, 0.587775940800356, 0.3152698219775354, -0.6086582205112624},
    {0.8038674438604267, -0.1424731990876384, -0.47393594882383133, -0.7042086182334494, 0.5668254696856635, -0.6845171800195998, -0.5260151311864146, -0.35100064356916727, 0.7071241263081268, 0.8333785507925846, -0.4369196435981664, -0.31451916823373216, 0.7523062035055523, 0.624116315464687, 0.7617741908161143, 0.6949756747710014, -0.4350386622186242, -0.3527277290247269, 0.6719528275800374, -0.7308211194023674, -0.0049955963953405205, -0.5555466070132878, -0.459901860982566, -0.16441263617117755, -0.4036534351773621, 0.7131344645491753, -0.6002485561120621, 0.5123584873910371, 0.8392889706566253, -0.3944086733764548, 0.8862538699412819, -0.2934132343016757, -0.5461230489408928, -0.5241928154173813, -0.5438265356632072, 0.4255728008596405, -0.6413615418718186, -0.48941490077782035, 0.9486771049091516, 0.6184555097918459, -0.22160697748991193, 0.40436266323063585, 0.028136392992626293, 0.698799692937188, -0.5154775687131096, -0.4179231567807224, 0.743563378987912, -0.30253089743446737, 0.5944119045031888, 1.0282771963078108, -0.4738290796408293, -0.49635497542101803, -0.267224251303261, -0.24294732143338815, -0.39240629916823877, 0.03013511651145518, -0.3990663685814086, 0.05570059670142675, -0.4300863778447964, 0.4015250630975677, -0.6690035592261466, 0.6992648950427992, -0.30497426308330733, -0.6318712222297614},
    {0.8437958718427935, -0.44655537579817595, -0.5381723458158034, -0.4256859214901858, 0.26311534079392357, -0.5701716212940436, -0.7412318700552535, -0.3290549049050245, 0.7608360342023315, 0.6327580087878685, -0.46284134003369337, -0.5442833679935994, 0.8064120949061624, 0.8187259664903416, 0.6148210602744442, 0.6942983258953851, -0.5038100461572893, -0.3730690778124537, 0.4614871114345848, -0.792713161403959, -0.2910972235413163, -0.5537331638763752, -0.513938762418885, -0.3626671175773105, -0.24345201886862308, 0.619527874962738, -0.7718615643650879, 0.5832805342948432, 0.7661259559307916, -0.5858527180098788, 0.5689426523036164, -0.6794664094568389, -0.48608831137574865, -0.6903564624094257, -0.572323404436093, 0.43349981512310926, -0.7316829636553882, -0.41427106399687985, 0.6416044879939071, 0.680449359276253, -0.12996788645386995, 0.48876499557435943, -0.04249660100628897, 0.7191155279530912, -0.3930214707468467, -0.4477691450013302, 0.7293240128697155, -0.5627147147747437, 0.45571694749360425, 0.9545403578999797, -0.4393715178407257, -0.47235436526965185, -0.1890235735931354, -0.5668326472807884, -0.4739386135841764, -0.2829783382991777, -0.45122269952117317, -0.7525094631053569, -0.6545452128172364, 0.35917250580251436, -0.5462282645118305, 0.3601777337851099, -0.5578230538544678, -0.7254922580060491},
    {0.6366828059622878, -0.2992671556444967, -0.7982565913331312, -0.46289567889069555, 0.6138936804033815, -0.6672171695850706, -0.9101946897261048, -0.2859287041735813, 0.8455550822965435, 0.8242292997955544, -0.7129239701378343, -0.5793205238572418, 0.4846538939042465, 0.4355186475008072, 0.6485988221063553, 0.7338307750890466, -0.4899633076998397, -0.44994852716457906, 0.2229304097920267, -0.39066821645411304, -0.3728013429536453, -0.7019367675787345, -0.5625388373466852, -0.46007940547468146, -0.4561977505019923, 0.5603301068264788, -1.1269323812898417, 0.5695370804068626, 0.7910394372622013, -0.25796819753084993, 0.12369824592385374, -0.8128493196180363, -0.7145661602715903, -0.8867120630044055, -0.37177426734479857, 0.4044357188850687, -0.6578145550535202, -0.48334981015150696, 0.5847163342413876, 0.5388390260524449, -0.48353581880515467, 0.7498214630298727, -0.13300203021345772, 0.5898862817549441, -0.764052054698495, -0.9778786642946183, 0.7025297594812019, -0.46215682710693895, 0.7535353497410552, 0.82495572037935, -0.5623559028073661, -1.0234270392097926, -0.3177322031171612, -0.7908639114527696, -0.6651201014652423, -0.5595462694469467, -0.42762628756578785, -0.6549737732882337, -0.7306677312520244, 0.5738097302630488, -0.8373974637370297, 0.44433684867509193, -0.5285100780572213, -0.47203809945441844},
    {0.275771820320673, -0.3026641218089414, -0.8612704882102956, -0.6837025987636051, 0.5031783874919615, -0.6807678070796214, -0.7971887753295226, -0.49084477016316186, 0.7682226420604339, 0.4374797251515767, -0.7582419197451901, -0.8926616083906656, 0.5225669877072161, 0.6144645695910829, 0.45246149767200355, 0.33191058170273463, -0.41811515199487814, -0.4502548213168666, 0.2746016622537204, -0.7004431053640158, -0.30919342574538594, -0.9073910511637822, -0.35664581518088057, -0.7970125752656946, -0.3021302073173078, 0.571848208654035, -0.728725305551303, 0.5791536239455081, 0.6839901956703524, -0.700886344392378, 0.11689884884839827, -0.7511694325978064, -0.5714578914176922, -0.5031552438114355, -0.22099937885241008, 0.471920399158086, -0.8827385513151643, -0.35311590203016463, 0.4671930263752873, 0.28476996969911494, -0.6396861814624366, 0.5530040879455316, -0.2672205599422613, 0.49654621028189755, -0.5683062433980969, -0.4664108751897154, 0.36010881101919623, -0.6632937337956522, 0.5192353815062754, 0.7970674574279493, -0.718149145869156, -0.8503975128847483, -0.5592546999940669, -0.7415595607034913, -0.615032512815348, -0.6149599393295019, -0.662972655114054, -0.6821395335270133, -0.6107153338776309, 0.7172386345699732, -0.7737296087231597, 0.5244700283378112, -0.6504284853430061, -0.39031235232956346},
    {0.6608362497011491, -0.4896317324880311, -0.5341703272237938, -0.5893655681790442, 0.3987682339045181, -0.6714226393845946, -0.9657711617459936, -0.4334068498155838, 0.6623276567904672, 0.3351079105987355, -0.6083388759114174, -0.610703881101849, 0.6138506297732514, 0.21912660984809385, 0.2623922078628267, 0.5118667026366269, -0.22644921158842132, -0.45925611762411633, -0.07845894809052602, -0.8787744343983609, -0.18631266841179359, -0.8290727640597609, -0.6595734916756202, -0.6685427851155652, -0.7373717637569458, 0.6483137545134738, -0.7551248861151203, 0.28774874697331676, 0.6095853231002745, -0.8959540930294934, 0.24884833462989436, -0.8121721228039279, -0.4611735749581898, -0.7508803634961693, -0.46105327814235225, 0.5320062227512637, -0.7965465113982265, -0.4658740803236716, 0.4774345165077873, 0.3409749136623319, -0.7453214452486169, 0.6765087694241432, -0.5160602471997121, 0.4794852825577253, -0.588619786672314, -0.6788800419435869, 0.4862381912412288, -0.661883309180989, 0.46244321892641116, 0.7907257187093593, -0.8286669783462469, -0.8536478482625627, -0.4496128226407359, -0.890036138146954, -0.6711474468673706, -0.8218479236088064, -0.776239753331597, -0.6270290136086066, -0.7041702890525963, 0.44098227518713556, -0.73480088815273, 0.6929026373868187, -0.7570322213495797, -0.5300759471725818},
    {0.3528219221807808, -0.5004351118949337, -0.5464049408084265, -0.6462841678122315, 0.5630496884842884, -0.8503741909475349, -0.5865556299570229, -0.6372943098992013, 0.7398936788235434, 0.38166148668838645, -0.9745083775976047, -0.6183204656421937, 0.389971473698186, 0.3911989441950828, 0.4595169537679668, 0.570264135260112, -0.696804825866757, -0.4098205634582674, 0.008389617971215759, -0.7423476640971639, -0.4475325770365524, -0.6199222822275772, -0.7056602523284269, -0.6759924560343648, -0.7217636779215915, 0.6692036897401108, -0.7619302867525035, 0.3121592395512488, 0.5189340291188885, -0.8085933564772818, 0.2057292931077074, -0.646132693439076, -0.7920274786785639, -0.7232654938639215, -0.6968393788854635, 0.3932078729258604, -0.7857441175928447, -0.42394201166352447, 0.4190188208723835, 0.1947689097765963, -0.6472577723213284, 0.6407380261160796, -0.37455466609266796, 0.5203239021338137, -0.856941648283585, -0.4954035074030404, 0.51682100575828, -0.7793219616252678, 0.32493480889550097, 0.6018140750368811, -0.7484819667647968, -0.707625980346331, -0.37544657790503105, -0.9369470783354668, -0.7647615560394797, -0.5019068437438864, -0.8959845844484623, -0.67207460486963, -0.5836765030591127, 0.19205172405497242, -0.8077778278218133, 0.5098648647678329, -0.7535851383073532, -0.7473774550881782},
    {0.46992428798500124, -0.469848228506447, -0.7408561917553355, -0.661048171942589, 0.5851400177170533, -0.7131577780128309, -0.6376498655209026, -0.6653174621295037, 0.7322173712016723, 0.6275338911447097, -1.0797993738952172, -0.6734253899774837, 0.3769863413801833, 0.8106726237111175, 0.6649503174120419, 0.6182936838785364, -0.5891414811493735, -0.4884927468137881, -0.0963935718761763, -0.827111185852006, -0.3513874727133149, -0.6073801668601599, -0.6044678914349981, -0.35778128074578286, -0.501333105777186, 0.6039338176880128, -0.8512048121118306, 0.6651914747766892, 0.41034583458359936, -0.5887943641809841, -0.03518769417832578, -0.737308652225104, -0.7431808037121187, -0.7095512278631652, -0.835055739230793, 0.5672923791748011, -0.765358392262299, -0.5094971087225921, 0.4336113322673154, 0.23747640958571958, -0.7222230522223555, 0.4227488738397412, -0.33121327586365734, 0.48255792836887546, -0.4674158525806793, -0.6139435552973569, 0.7252171270160908, -0.5672391873109535, 0.3696015995718935, 0.5232029705034822, -0.8346358337995161, -0.6847756194344434, -0.6811286001641872, -0.8427135555147053, -0.5967915436070147, -0.5219976227105275, -0.6881400020862448, -0.558544246576637, -0.5191720523772835, 0.19622947459656015, -0.7765942404708067, 0.45485171728817586, -0.6304666947115736, -0.5401714882986106},
    {0.3234786540739453, -0.6034568848988877, -0.5233982323345401, -0.628699145127658, 0.3163467690464256, -0.8229134900810554, -0.7007827292417622, -0.4454362453054076, 0.5431801406997206, 0.6692160983916553, -0.8002123536168304, -0.47923362020688043, 0.7549487433856696, 0.506544286522336, 0.8288078088209817, 0.7510552652868707, -0.35792862163409483, -0.2549147097188898, 0.30926091480082907, -0.7604221487668534, -0.37914296442962225, -0.7628954527981228, -0.5410976125480871, -0.4054896777605688, -0.4814066619818441, 0.7127961839030743, -0.42148453498167376, 0.3278473837778921, 0.5644417025890437, -0.4845101273700734, 0.1275946243753725, -0.7199371498265424, -0.7125627862144588, -0.7516179514605595, -0.5922602275707091, 0.47956193127720625, -0.7697171756525925, -0.6237706007413696, 0.4764638736307768, 0.3241507909686033, -0.6109050055237477, 0.5419708672206973, -0.35485100310100115, 0.44515282316186855, -0.5186463364822795, -0.5050507527622918, 0.6442377732358395, -0.8085082249028694, 0.32978668527172567, 0.5618722249900889, -0.797660307109079, -0.610504668390627, -0.39807778459478255, -0.9012239029697002, -1.030997063766398, -0.3910933804110319, -0.5267099880882914, -0.29370490699214813, -0.650619515613638, 0.5069064271096135, -0.6127754564300575, 0.39559224925173625, -0.6721720839909662, -0.684951895242871},
    {0.126156482741405, -0.4206215666916123, -0.7353594718684467, -0.6277416745125246, 0.18171943035948113, -0.7782886902455921, -0.8083766359978671, -0.6240409528979849, 0.16631707039321417, 0.4723976645751446, -0.6566177156781889, -0.4978135588854072, 0.16079991123283216, 0.5225395665988175, 0.4688539907895961, 0.590771384716612, -0.5565848769765946, -0.4940876942425749, -0.04868798617367031, -0.7829200980981342, -0.17166387534000374, -0.8337808075530828, -0.31432483267821315, -0.3497026318873748, -0.406234746974298, 0.6160438534317951, -0.6511910636838967, 0.327950900184051, 0.47466709000391816, -0.8356091632975579, 0.027812863359379762, -0.8465980295140269, -0.5745524400288352, -0.7546140698080503, -0.595236874300432, 0.12594977387179315, -0.7285693254242218, -0.6966578369965565, 0.48268627986095974, 0.2184979702885695, -0.4001159951092402, 0.20652297147634022, -0.8417339651499789, 0.3784380708664722, -0.6615509173829504, -0.4117405403611844, 0.6371050774423125, -0.757483720960577, 0.4042634503838246, 0.7928157789216121, -0.40204453864931716, -0.42862827498173706, -0.36415865517004403, -0.7403142949325479, -0.6149669897607818, -0.3250122360673412, -0.5243068184630884, -0.7656122245110312, -0.5821525459350749, -0.0679416949028256, -0.5549393659293589, 0.3982096259382113, -0.4372169316543313, -0.7052417618414838},
    {0.1321843999542412, -0.7493557865295524, -0.38415372932746766, -0.6904079531026744, 0.047297741785708065, -0.8693418750828844, -0.6153280293730748, -0.5496454647911552, 0.23947625249343146, 0.29096048548151304, -0.5875073890041224, -0.37253082402924537, -0.09878878203647067, 0.4211058595397879, 0.4183404871474242, 0.3927312182774735, -0.5450528715448361, -0.2666006665150705, -0.03640261934985949, -0.8320883176411198, -0.34759182978365244, -0.8501797865635257, -0.42863232413403185, -0.4839011818364386, -0.25963399963790773, 0.40393130888591217, -0.71273031331061, 0.17378573023473587, 0.2169083121274917, -0.37968955856508324, -0.05465091696280362, -0.6649724554253209, -0.4618242101954728, -0.49916060535247514, -0.8099183602961599, 0.07429226985462384, -0.3252880632245663, -0.8347902880219216, 0.4671302188740252, 0.20078858778472755, -0.8578819064234912, 0.10747439266793334, -0.7059601728958403, 0.15778918468014927, -0.2181152679783339, -0.9143703955186198, -0.07224131453233762, -0.7234652391908599, 0.24996118593710825, 0.1550874421023778, -0.8123369259919709, -0.4918768147360021, -0.4265746802721671, -0.6261382315581928, -0.7916002694587313, -0.31189066993802617, -0.5853577878716736, -0.7230827158388591, -0.5630215750389734, 0.12566200343057016, -0.7874902784375493, 0.05182807790281896, -0.3549114305263569, -0.7010944972111038},
    {0.23015198134601667, -0.8316418254857721, -0.5751805059915835, -0.5314071957764139, 0.2364177187115938, -0.7232471042301303, -0.8087693161116433, -0.5814680260992188, 0.18854713696074643, 0.2624875536227211, -0.7974791255546322, -0.7627862926407296, 0.07977028709514028, 0.3577024702462548, 0.6585122618177375, 0.636970724348921, -0.8750258040116379, -0.5838176403792115, 0.30909595955187313, -0.707991805749243, -0.3423504773278917, -0.9232377215983113, -0.42176414427297687, -0.5914087023104969, -0.43723719187957794, 0.43104627091777303, -0.43457230915145867, 0.11913232059563132, 0.17782034649601636, -0.7543761440726309, 0.12198132455825494, -0.7995707104765656, -0.4821721575546307, -0.6012445511393639, -0.6026057210562036, 0.033570937106054535, -0.7150611995506301, -0.8373833643342322, 0.3793656912758415, 0.14056848626557134, -0.8052271129651761, 0.416429565510607, -0.5084105635601748, -0.08394052385934997, -0.6077815377520333, -0.32838306106577075, 0.30728276474300337, -0.5866811731506671, 0.3685279861530801, 0.2756209915862827, -0.5791000249921802, -0.5119046249408455, -0.3867112607712894, -0.7838619722880483, -0.607566673900705, -0.06274313910068605, -0.6887737369641094, -0.7469375236033992, -0.6011732128456277, -0.02465113327391914, -0.8421208624499315, 0.23766234349060614, -0.6013014473205888, -0.7024664924274423},
    {0.37835789041155155, -0.9670266070234933, -0.5335613621957529, -0.770191316669221, 0.3037828884405963, -0.696293226083718, -0.7053749556357556, -0.6388792425362989, 0.20754187932080584, 0.37354209450218306, -0.8224959728843685, -0.8314165293474954, 0.4060081873432723, 0.3501376896095483, 0.3274281373944041, 0.6269289798783232, -0.5459845088185376, -0.39839186821467476, 0.003118742714611189, -0.5149140766872168, -0.5610478556049022, -0.6803493497697869, -0.4230373948275709, -0.20163034475714411, -0.28754390853569584, 0.2638642584917552, -0.772940813730947, 0.2907690352942252, 0.16118626800995006, -0.4824404717856575, -0.10453113776979037, -0.46228530928829614, -0.5543654655584634, -0.5413550768253792, -0.6912610689407799, 0.10221223026983647, -0.8618967056972056, -0.8119272128207108, 0.13193121305787972, 0.20246414743111021, -0.6642029917544636, 0.29046185444859074, -0.5865010092405184, 0.06714003648606372, -0.692837419061754, -0.6399351817110515, 0.12180374627804957, -0.792795551958813, 0.1644186308813, 0.10742056132284923, -0.7722094483632159, -0.7233572573215964, -0.5867221758768935, -1.0249615070835139, -0.8407502798553941, -0.32124439142908806, -0.886446129489623, -0.644551241284282, -0.6986509048488779, 0.41250499185213046, -0.7144060835002742, 0.11300011758682955, -0.6625331946072317, -0.8627417248906145},
    {0.5233679614226562, -0.7682100060879681, -0.8002940116775877, -0.4107042428234933, 0.44241816256196886, -0.7388407532885006, -0.9195794974414483, -0.6309375175399842, 0.709171774957952, 0.5717966235011512, -0.8034304607606464, -0.7330953028272811, 0.47010574408674566, 0.6236235122360825, 0.4706215685962521, 0.6268796036401476, -0.608748503417841, -0.5248070128938176, 0.03804986990977351, -0.6078180233779991, -0.06903391399235573, -0.5540136348881003, -0.6854984057919363, -0.43338573053293156, -0.24349082437637734, 0.6134239033614399, -0.7035034622415062, 0.6033824834312267, 0.5287979281194808, -0.6591805727358458, 0.1528454084621649, -0.873164319400097, -0.6701639129284074, -0.7045382513473736, -0.7857336218080945, 0.3292842537849054, -0.7262957984763501, -0.8059138130539253, 0.5546874628619246, 0.3178163412518755, -0.6664037110603497, 0.14300465272220653, -0.4003892877537882, 0.4844186791331441, -0.6424885302055864, -0.3168706680606798, 0.6086643419103345, -0.5949492834383046, 0.5074302579190845, 0.5171916018945721, -0.6246806467864926, -0.8539858819120042, -0.48646328004419437, -0.5558201548388998, -0.55613772052602, -0.23288339367031413, -0.7687361323978191, -0.6497916039095634, -0.7989448092711238, 0.5406173141474434, -0.6117621493203377, 0.4375204169106032, -0.26347190394772385, -0.6041433391374837},
    {0.5286618638009597, -0.5866532765779856, -0.6815678297923129, -0.7309207734627993, 0.6504015933042261, -0.7683987836967026, -0.5554349208095234, -0.6180353067348298, 0.5732410284220597, 0.671117725878648, -0.7893888388684953, -0.5505454773340689, 0.6265602438081672, 0.25452732372853365, 0.47471724910084284, 0.6569942263603291, -0.6363436870216478, -0.4425973741268761, 0.11214040328079473, -0.6233142136510251, -0.2993540243786054, -0.977800374636115, -0.6141449565879096, -0.4946136931120099, -0.5501816564328452, 0.733980867839827, -0.7277010634065542, 0.4662263801152072, 0.2418625028363796, -0.5877712401895016, -0.041568177728206285, -0.6566990416996121, -0.5052287264760094, -0.6432867981526887, -0.7683571732500809, 0.42441159966591757, -0.9010039593128677, -0.8784049134347237, 0.6297173311159118, 0.23243276281560135, -0.42743571519870105, 0.46380359190072395, -0.3576525274193153, 0.6029257544951447, -0.6875707151095106, -0.7484022258206035, 0.785084520505513, -0.49191548620872627, 0.5547324498383622, 0.7645824342924233, -0.6679420119172529, -0.445822951271491, -0.544850980169488, -0.6494678958904689, -1.0380063341309786, -0.5394903546855128, -0.698583067409651, -0.7861990501028782, -0.7554133406213487, 0.5769428931886493, -0.6206730093577792, 0.8208006244292322, -0.5469107137844561, -0.7114561213495835},
    {0.47197607388203183, -0.5004567717228648, -0.4303442136579349, -0.5555718034008724, 0.696682342538562, -0.8119390923308751, -0.8448266217167475, -0.5476108947603355, 0.8739495581800245, 0.8903492019794341, -0.6700472249752213, -0.42876435395542767, 0.4937891365374456, 0.6350600644127435, 0.6525686726361826, 0.6793435890445839, -0.559354637610928, -0.2789427603375446, 0.2597733938257706, -0.7103827516963663, -0.13399766163597368, -0.7090142207659765, -0.6862971503406062, -0.6736870993717651, -0.39433088019975415, 0.7173467151398346, -0.6241943944431365, 0.5058720167566728, 0.47674078850018664, -0.30378537863475485, 0.21987162466325677, -0.5533693081562086, -0.622839162920543, -0.5951425133901901, -0.6518790396649552, 0.5440548860375973, -0.7614625347788474, -0.6754359993652771, 0.7215252302375531, 0.6189645014023211, -0.5889933818214697, 0.6545323007936088, 0.05211031223787461, 0.38950692162482364, -0.5542741499670645, -0.6374237820899468, 0.5329580486585563, -0.833869625334547, 0.7570489415792888, 0.8619665603267671, -0.5495195414653286, -0.49086837524449906, -0.3355898312349828, -0.8574754081656377, -0.6635556868620437, -0.31875975635245524, -0.7213861720163517, -0.22540249311295626, -0.5638686809109936, 0.6015380984351605, -0.8185981691712587, 0.5581796616197582, -0.4243366223941738, -0.5950995405756194},
    {0.7315860991751183, -0.5509695109183355, -0.7596653833309847, -0.4559212092231625, 0.8015266164577882, -0.7303284796445672, -0.6458471293550768, -0.4036806087689478, 0.9502523323200117, 1.079165994523349, -0.567610427032774, -0.2107148101500244, 0.7487062582021599, 0.6680229889231395, 0.38897396621950076, 0.9843999335037981, -0.5389722882903121, -0.33701016108024917, 0.6092270795250289, -0.25766775133092734, -0.11888119071155084, -0.40094268034572306, -0.4145529167906079, -0.22123809470049122, -0.474278350141272, 0.6566766392703165, -0.5152533215122072, 0.7806415881215993, 0.5662605281693248, -0.2010970222002738, 0.7319385190905611, -0.42039529336875847, -0.5020373035049207, -0.7588013388794436, -0.7593197414353678, 0.6176740119206745, -0.3779012540425028, -0.43534073691052483, 0.8136005553801743, 0.6779949737516612, -0.23994198287986038, 0.5161333395951443, -0.025254592210672885, 0.837436537610366, -0.5933728757184903, -0.7374552863008269, 0.6216280276343918, -0.46064037354595044, 0.9216708511263341, 0.6377194926818218, -0.5234716080563556, -0.4351163071643232, -0.21597160454602132, -0.6571084946090491, -0.6928104866445506, -0.18214777986629008, -0.8968289636951315, -0.4242781701853188, -0.687582053262326, 0.6047929726186554, -0.6042961436034797, 0.50206044630909, -0.3549458361669297, -0.4322622890072825},
    {0.43185772576293086, -0.3726488662345497, -0.35805981194605124, -0.5581795876540113, 0.6984790453847893, -0.5036050383307767, -0.5129188293951141, -0.29930137171418, 0.8103143644142773, 0.7375547563276144, -0.4619036985361154, -0.5790983036676316, 0.5494554418436016, 0.7334628532050608, 0.7874957429532624, 0.7180651942223634, -0.6878134171840782, -0.5383611225043989, 0.4413268832940107, -0.5872962648084435, -0.05965858278603219, -0.5620028127465181, -0.577474588114847, -0.38972956711740064, -0.29519900011803074, 0.8775884055723592, -0.6310453148405301, 0.5850659932299992, 0.4237711178878462, -0.1420049003768076, 0.6264075631625984, -0.4073646981899178, -0.6090009336883753, -0.8232759933106067, -0.6516226348713914, 0.48026224713708243, -0.6088548919874628, -0.7409553945680311, 0.7201075385529653, 0.7019382861962006, -0.425112396148284, 0.6636045178231612, -0.23377669608191953, 0.7377183988298642, -0.7845953905993444, -0.7433515784641073, 0.6093773380988394, -0.3251198543153726, 0.7983625318400098, 0.8194366367537018, -0.5570307625207955, -0.5326101912714295, -0.7205446824711054, -0.8214712023447999, -0.4061358300484573, -0.5019504215885566, -0.4425761538914636, -0.6750522634777714, -0.6685132327751555, 0.47132109917271753, -0.71276780698759, 0.535319095312967, -0.7034841010072884, -0.2991187522716385},
    {0.45303848374323696, -0.5951364169030635, -0.6603771842469884, -0.553400653198429, 0.4062740038113623, -0.6833705043693807, -0.7029412043377818, -0.18181550034990757, 0.497816793292875, 0.8021593369085233, -0.3949078190845855, -0.5769826391211402, 0.727180506368343, 0.9278008464714809, 0.459082753814094, 0.636287856365994, -0.8395607107922416, -0.4629719753961426, 0.4078102427294219, -0.6995671323571689, -0.39507071713263175, -0.553216655231979, -0.33569642715209413, -0.4094543677855569, 0.026472111944126867, 0.6501159301316255, -0.9561805154552645, 0.6653521649222915, 0.3181033732069224, -0.447766043599773, 0.41532862348356303, -0.5285228706472305, -0.6229821404828926, -0.5014043819555671, -0.5860791543585739, 0.4981652486249046, -0.7974080273944285, -0.5641405069156863, 0.973446601182255, 0.518800034434711, -0.44001358852623196, 0.7372367501301317, -0.10878598245965851, 0.5963867039890585, -0.8857539562498261, -0.5422839577013356, 0.6771804331160333, -0.8007523645137254, 0.823574093082809, 0.7905231262110449, -0.6172709093981722, -0.5218029200706531, -0.25143485528963505, -0.7284032759596439, -0.7346464162052877, -0.1302856639791468, -0.6499187792758505, -0.3898321750716401, -0.7529977141860721, 0.38331844824040945, -0.6773116815393427, 0.5926313258177355, -0.23326501805470326, -0.4710444790447142},
    {0.6137189488723785, -0.6226931906389681, -0.49718027968653067, -0.5283236660011327, 0.6236152550889518, -0.9464947899725356, -0.9476319278017189, -0.3261906112470748, 0.8129926498461321, 0.8406103309358419, -0.57733930553298, -0.552844434835298, 0.33640497381816353, 0.5928933556556795, 0.6437395587867782, 0.7586753340263641, -0.8462164059825695, -0.441888726009159, 0.41539448570438053, -0.7217145043792087, -0.12206439960556915, -0.7093739154813763, -0.23648527224498644, -0.33038220998088685, -0.09588483689123103, 0.9274404567201758, -0.8178805772844675, 0.5796124656784615, 0.501108388707704, -0.5662085530446308, 0.4877100671099329, -0.4156604563821902, -0.5902940478195412, -0.6997254513746926, -0.6424804451639745, 0.5037025570460198, -0.8861103687574938, -0.6240383760583169, 0.8066231873345343, 0.42763956784392465, -0.3215526155456377, 0.6601797485459645, -0.16373931964898142, 0.6262160345562173, -0.7525862621978714, -0.6016851125622734, 0.5550299159777969, -0.7828511573104643, 0.6075080159080714, 0.6879554610558268, -0.8265152595179296, -0.6848039865703122, -0.18682311007166671, -0.7580801857830378, -0.6230062277257825, -0.2209192661709864, -0.6114284366466547, -0.7565459523093113, -0.6404206746099194, 0.5551432063904295, -0.7706359527093878, 0.5212495387294384, -0.18163653791019774, -0.6744684568704425},
    {0.5703782631169176, -0.5802065165077934, -0.4776607139445623, -0.3220765810248221, 0.7648196302666556, -0.7849672637050357, -0.5814507636794559, -0.09075121661304862, 0.4574267515171835, 1.014678786134209, -0.5332909994112656, -0.1575326239377581, 0.687597867724145, 0.496149807548133, 0.6856688491633192, 0.8623305595166171, -0.4892051993043169, -0.06804558111663526, 0.5098252331757649, -0.8817778447373904, -0.13473032106082808, -0.5396458319488303, -0.10912974021123023, 0.046282197931040076, -0.33421382136246075, 0.673140081142005, -0.459013610419175, 0.87397313782434, 0.6235911419863849, -0.47576130749284745, 0.8983922678370775, -0.5656415820213037, -0.4494256570559326, -0.771948277640639, -0.5372126692390555, 0.4989783842719505, -0.4337655341994346, -0.6454476900277198, 0.8317537773243812, 0.6666712367518411, -0.2688010228050945, 0.4971785165159317, -0.028528762304381592, 0.7129462372733202, -0.4799602505354214, -0.2552999380855537, 0.664433375164631, -0.42542211167411137, 0.725134424021053, 0.6552978681480774, -0.6592713288375878, -0.3118050347308911, -0.26476490194203617, -0.8636705854668599, -0.5136598991285052, 0.01793290580989123, -0.4873981915476356, -0.12323548333186639, -0.33961860720195, 0.6430366767736757, -0.7487520001604943, 0.8334945192849441, -0.10506827071811477, -0.39271698862472254},
    {0.8705819561247041, -0.4734303619488941, -0.38777265150192614, -0.2700228947548431, 0.6907529466169398, -0.5239321753051462, -0.342668794499018, -0.2450962865597094, 0.9268342786780546, 0.9299566368361165, -0.3580006383009875, -0.38242043100472456, 0.7310668919953907, 0.8333449592332528, 0.7789094305322501, 0.8279852388701543, -0.49721366078628104, -0.03486050520309477, 0.5765836635441765, -0.4996903407707447, -0.062057338023725164, -0.37083335133888234, 0.009142269801180356, 0.008914991454763545, -0.2078725628358775, 0.8518421436768919, -0.33995614368637755, 0.8009835009284921, 0.8107510904775689, -0.1583321662930171, 0.5410680817288491, -0.5428382012799011, -0.22618079444789457, -0.47849099741356466, -0.5731002341828199, 0.5261186309072432, -0.6066459080877331, -0.405074048967278, 0.8440974236599612, 0.9382489934804387, -0.06436150741137561, 0.400158456353221, 0.20835790091468662, 0.7153125344868008, -0.409430698955179, -0.22789691302397933, 0.5835293032728376, -0.45539167377896017, 0.698327878557421, 0.8646771078894273, -0.3765143721286007, -0.18115060767163793, 0.12237741832727006, -0.6005925255343995, -0.10590602596375331, 0.17881028683783867, -0.3585895905702304, -0.11750631097113676, -0.4648330982668763, 0.7255408308128041, -0.3977141323415833, 0.41138845395252854, 0.2206140796406386, -0.3259867865851076},
    {0.8591186222312012, -0.8389018911075657, -0.552538846396725, -0.5783294108856967, 0.7511751609433172, -0.6690574816968066, -0.5254734608567907, -0.05937435502352499, 0.6293731586272736, 0.704709233126714, -0.47055550116023, -0.2963705766086991, 0.8319364853972183, 0.6023198230635631, 0.6976238005335437, 0.6509797702073703, -0.8416423852063799, -0.18359211358729574, 0.43308078313713555, -0.6017546745370246, -0.013668970788980482, -0.6893593878386823, -0.4026932574119859, -0.40254837675299043, -0.19270970806739077, 0.7545185430204009, -0.5930876630737378, 0.8325801145348647, 0.6207724667421941, -0.45543702974889455, 0.5842366548602588, -0.6667606842265875, -0.45036139579192364, -0.4844529256131257, -0.6597303893438601, 0.4647633440119463, -0.8022498192736732, -0.8933678974006136, 0.6502776027694391, 0.48439369404349036, -0.14026805940841475, 0.5539874306753144, 0.015980966350951777, 0.597782267364476, -0.4321336372802638, -0.2898363925611779, 0.5427691847479199, -0.7500122927649612, 0.7281996922095361, 0.7861735663003137, -0.6164816955005566, -0.4416455671974856, -0.348105914170974, -0.5628328508389323, -0.7226644362685942, -0.10987627506325114, -0.6456412232265397, -0.35660052860467367, -0.5071129191642681, 0.6609437659803128, -0.775174175710653, 0.40326647415368294, 0.13774072334221177, -0.44066775160494265},
    {0.5188793744508483, -0.43222331421271143, -0.36609462518837044, -0.3712025739006644, 0.5331847527599161, -0.6596475490251739, -0.6736860133329784, -0.4165944386930254, 0.6081700957290819, 0.9686290627272949, -0.46389215210079937, -0.4313132958414804, 0.37058879846870063, 0.6529150956692499, 0.7749908079604055, 0.8769878258514011, -0.7781573506442968, -0.42812186195398405, 0.22580197326726703, -0.7923059681675106, 0.1563704768292009, -0.6331886130531972, -0.38484622631834153, -0.5656876975181115, -0.12218639493906601, 0.6465966035063625, -0.697255051611258, 0.764068125791433, 0.6248534100454103, -0.42828487743061955, 0.5233354662132818, -0.5572694522822832, -0.4796026877322768, -0.7209039478954006, -0.6110620607680805, 0.4560240495117979, -0.5488052629676957, -0.846034699514397, 0.8000835290301316, 0.6535157881575709, -0.3745397525532793, 0.6727198548028228, -0.008582005852947022, 0.4868744873685767, -0.6087941539411221, -0.4306043516925144, 0.5346557067831849, -0.8172319096378937, 0.8173423932969326, 0.5852588101954304, -0.7145841102365599, -0.49049187179822884, -0.22927037288523805, -0.7568223285383422, -0.6112929961709365, -0.12776142612763616, -0.37194230709926407, -0.442816309617982, -0.3202745500420118, 0.5563475958700373, -0.693524820525772, 0.43475558366623995, -0.03334582880182169, -0.4747580708234846},
    {0.7182241021831806, -0.5065823580823742, -0.4616100916056071, -0.629550286739567, 0.6696469746489832, -0.724191639896478, -0.3238158714269597, -0.2575105455904764, 0.8333522490233242, 0.7223904751132223, -0.41846456801748155, -0.6753303312388299, 0.4386968282055492, 0.6750318876420373, 0.5299182239655531, 0.9210580263430356, -0.7698406675413022, -0.3598285291065093, 0.5176648210357038, -0.7077265467610937, -0.24279003847156344, -0.5252482015975184, -0.1879060242160293, -0.1411285200701854, -0.25789425986420067, 0.7319558553024266, -0.9078651470409352, 0.8151952598585998, 0.5241100870599191, -0.2182605370102443, 0.7372475220756417, -0.4752757712321332, -0.48123910570325795, -0.6370358131499153, -0.7666929982296998, 0.4605141496375395, -0.5001084044225889, -0.6211368948561566, 0.5016831603121442, 0.688127591339385, -0.3455629666963358, 0.6053214076792846, 0.0035956851296324957, 0.36988519444659346, -0.4181779814373883, -0.3940923885171068, 0.3756884159251504, -0.7406533478492873, 0.43446182638958053, 0.6277625263774278, -0.6284521450447335, -0.5996267718807663, -0.43428262085684527, -0.8357987881290105, -0.6000017640571332, -0.14547281209480137, -0.496344748127251, -0.2554673559977732, -0.5386942374467715, 0.6668145745196477, -0.5781283620193085, 0.7678460041207791, -0.2811124918379921, -0.7170735935790736},
    {0.672760932790949, -0.46718123174297, -0.6595542126736027, -0.6477862614796348, 0.6408692749988666, -0.590494860319508, -0.5935433007935307, -0.18828446346103092, 0.6280666288754979, 0.8060498760275303, -0.3242816944241847, -0.597421530923135, 0.8549515990274502, 0.8880927755331259, 0.7296809890757517, 0.8956226124816448, -0.7152460946956593, -0.11727785735790466, 0.5767682677472049, -0.5832820408795906, -0.11800406886888219, -0.6522656969202631, -0.37559782659189694, 0.1130512901854906, -0.3429588377693598, 0.7432948754564034, -0.682137983853575, 0.6248917954218088, 0.3622863709641827, -0.5258723354422223, 0.6217694601258792, -0.5138459619195754, -0.44049182947015203, -0.4653629342044083, -0.8192941161962777, 0.3841036286978886, -0.7814827753250148, -0.5518726103082333, 0.8529943247579375, 0.7384773833922175, -0.19719656619382506, 0.699011431215969, -0.1639021853357909, 0.48721848635737514, -0.6044177355914624, -0.39623138737320834, 0.5565302954268412, -0.5467251722694643, 0.5645082472361151, 0.8006762965598712, -0.5959828325577698, -0.5410660865628437, -0.36804914659270405, -0.5654687083686772, -0.39571755596098757, -0.18071824664026762, -0.6481659971085098, -0.2427302491310448, -0.4465978031417931, 0.6532335159528191, -0.6202149126794725, 0.3247302113331002, -0.15510572194758407, -0.7856316376827749},
    {0.5850094195705344, -0.4331521875095723, -0.5893572308004807, -0.6519266980999475, 0.5911358144015297, -0.5274551261776288, -0.6913638898042787, -0.3272251058512809, 0.8417341504465742, 1.1539469662849453, -0.3987087804162581, -0.36940125438691307, 0.9150124881753936, 0.6586319005765671, 0.6139780174053496, 0.7658462559517158, -0.7170583614029973, -0.1633552400286355, 0.3692627708326898, -0.4069184013831739, 0.03792119695246101, -0.7221764418413216, -0.3128779953905118, -0.22157882426643422, -0.3007030428690219, 0.45289645074297613, -0.6638981870989362, 0.7659531797311843, 0.6299300122721878, -0.4701447019006332, 0.4049992251596419, -0.5512106004853964, -0.46385146564614466, -0.5468785090061622, -0.8336217587297406, 0.6060452736736016, -0.5766960012794059, -0.6286722413114141, 0.9777839624696015, 0.5536739598274194, -0.2457129186492486, 0.8730266300983314, -0.19462616287186493, 0.6532728138532193, -0.4511973101566751, -0.43429613937931033, 0.9729297340811793, -0.5583647478421806, 0.9130207823561168, 0.8045431421194661, -0.6726592822509022, -0.2750214313645699, -0.08968955002538921, -0.7875364312874142, -0.3467759488408464, -0.08449517547014049, -0.5528408873041345, -0.2731013809123695, -0.5110174210647764, 0.6078473284666178, -0.6302638706899605, 0.5843383321071154, -0.022266789622189222, -0.43546433581944244},
    {0.71853723666806, -0.4652679742967001, -0.6021550246342343, -0.6389631909899021, 0.718105887292596, -0.5985193495170894, -0.601417812182109, -0.3165515176350387, 0.49210414864150637, 0.7026131971820098, -0.32845407884985905, -0.544368637085605, 0.666974088973805, 0.5061527585212736, 0.997091875004772, 0.701269673381207, -0.6356501084137077, -0.3867830736423843, 0.46268847839357047, -0.7842067320499557, -0.1548725076919925, -0.5738447868510527, -0.19440243180296973, -0.01573418491967486, -0.42085967065648605, 0.68420907929876, -0.7108436753038182, 0.742237867836644, 0.5747806452440115, -0.20116071104863564, 0.5973575115143266, -0.5735237685565215, -0.2548657021680001, -0.6492075169582966, -0.7363612627603046, 0.5372235291968478, -0.6608512973707279, -0.6575289367575232, 0.8004156155944634, 0.7185848450737105, -0.45963472245197573, 0.6909936371583997, -0.09496600671012702, 0.6531231297156131, -0.4253691493224415, -0.6785167223987448, 0.6327779768705949, -0.6133919428679044, 0.657181761037545, 0.5789849970394805, -0.5758520129715973, -0.35497757847810707, -0.4517063966093486, -0.9317329311815123, -0.6811852463569669, -0.0355865062103449, -0.2780296593702797, -0.2542811791296584, -0.33455891044126146, 0.7314127961908721, -0.6636618276071242, 0.5384798248085504, -0.11976163996981967, -0.5755092354807685},
    {0.4952014761466362, -0.4022140216657642, -0.3776866050550606, -0.2774666398628165, 0.8524876936963516, -0.6024376497434816, -0.6943760224221865, -0.24174851465945532, 0.36629362805656823, 0.6478713972113681, -0.43104689449870126, -0.5049253545859071, 0.16523707846486324, 0.6842564028723439, 0.8198831673420174, 0.5943285518060349, -0.8160421791926991, -0.15657753918003628, 0.27791032939636273, -0.7450797212544278, 0.164447934149549, -0.6467416751322351, -0.09990152854788219, -0.03995536464799823, -0.18787725734043606, 0.5540884787023103, -0.6286133402137651, 0.7211318909923755, 0.4273298018944661, -0.19371595919250525, 0.4441599196588286, -0.5627144412217613, -0.17468102154123544, -0.682064100387815, -0.9033209710273843, 0.21615547890236492, -0.47637726919748447, -0.7010594299125592, 0.7269380323894981, 0.4741971440432108, -0.37386339522733464, 0.5565917437619262, 0.1955731225884554, 0.436816892733424, -0.5480860119041226, -0.37710127091449686, 0.8525079923542108, -0.7038069096667058, 0.716875812372927, 0.8822729061190389, -0.4833409034586685, -0.5612548730471031, -0.1880996212936836, -0.6243738626929577, -0.7087791985564424, 0.1793621040451691, -0.5212626936232205, -0.12757937588206242, -0.6286153949138126, 0.4812694030246928, -0.7001222577352186, 0.48508294565889776, -0.11372395648276556, -0.6969095590279851},
    {-0.04647237212591696, -0.12112285122849023, -0.25255542645116447, -0.14871257031159757, -0.4740589207975985, -0.374443305663404, -0.03296855205200071, -0.3642784617868478, -0.4496459336571279, -0.32827185848499585, -0.007889643697176135, -0.2382403315162322, -0.6969444071977619, -0.38810459157322935, -0.43370586468149047, -0.4233250542615811, -0.42705921778991063, -0.5232720893133795, -0.5725865669788744, -0.15359342766930245, -0.4921526861094414, -0.3648103823191229, -0.5112992207160999, -0.646126741799176, -0.12660477415165058, 0.011662229484309674, -0.49926048735601025, -0.34582360207189033, -0.3721404052813573, -0.3386643149036458, -0.43516717768818786, -0.3420302486865394, 0.05616333678685737, -0.3481440449718158, -0.2556596395783242, -0.2924033205472252, -0.17306407017395165, -0.5059292508949673, -0.2752475366232836, -0.5299317795379277, -0.7193343319516377, 0.18088479867560148, -0.44147733662835187, -0.4507156886361397, -0.0907034973246916, 0.14365908095714425, -0.42650305443415676, -0.5520901002867796, -0.7246871323142287, -0.5010819506958334, -0.266344141797443, -0.5052982899272267, -0.08411124974202575, -0.6076263035674442, -0.11363122207105887, 0.020145268944869385, -0.4025065153884758, -0.6617793365757968, -0.19228963426205617, -0.2022632280079045, -0.05951874320879341, -0.22322097970649526, -0.6654054644946972, -0.22402258259129526},
    {0.5406726189001696, -0.17451649511727163, -0.4476834895073001, -0.2878227003572216, 0.0903665588097517, -0.27048596176791445, -0.4899888412232613, -0.013165485908440735, 0.3007169020096274, -0.027775116891197254, -0.15074851171932813, -0.014422993607761907, 0.11068185887698982, 0.3678554284839112, 0.31650295019188274, 0.43242512588193815, -0.41249310039096215, -0.15151995739361937, 0.026071645705231603, -0.2999559084999403, 0.026604054010301463, -0.23956248398685512, -0.12522470419264636, -0.17065109145831148, -0.5808588102303436, 0.4071078893190132, -0.05078118698080326, 0.37264736977687246, 0.21537567144026964, 0.05675945269515214, 0.6507671166150034, -0.5227580888404536, -0.3488567945808093, -0.016029023861735256, -0.631314863737942, 0.39897692742104124, -0.3666126039956637, -0.13264590889923156, 0.4172713928729858, 0.4069156066438939, 0.0460090684752642, 0.3788807718457066, 0.30649356193300165, 0.6380123236670484, -0.09434766198120009, -0.012657615702037104, 0.3845316930311403, -0.08939250056601852, 0.15296333629694084, 0.4411168522052325, -0.3026161476649493, -0.1332063880288227, -0.052846981226977875, -0.3463907940337852, -0.27734573230829734, -0.20739508728992506, 0.0699457157474754, -0.23181973244970472, 0.03654880463574406, 0.1356276290363286, -0.49602685432301163, 0.03525088799849197, -0.17160518566664276, -0.05628645088211064},
    {-0.08461628498796116, -0.19182196479630756, -0.5917637860766399, -0.3485224547572674, -0.2541937148934456, -0.16759153385927134, -0.6447196602920797, -0.3528371748338377, -0.17690435561413081, -0.4370457846081463, -0.32658449200541156, -0.4240680120909741, -0.21295212792712204, 0.03939002482524913, -0.19206315015280584, -0.3450823221451662, -0.15121418783652224, -0.6274417803293922, -0.32702483107158414, -0.009511442272098119, -0.4945998306922927, -0.32767837820703055, -0.7133071332485226, -0.5196880747884096, -0.3029624923246765, -0.2422918245228488, -0.34323220250453895, -0.038555529945405065, -0.3253189786921365, -0.4437541212410384, -0.08591749535897843, -0.42082376758618534, -0.40536092648170163, -0.3593822841410816, -0.12091710030093979, 0.3518528981079769, -0.16711674121212866, 0.3220837591194014, -0.06136926015375908, -0.4531021670679761, -0.3288563163392971, 0.03641439863025549, -0.5209665604593022, 0.03207918467459516, -0.452388306282461, -0.4805057531694756, -0.2830260426901023, -0.4377004131221955, -0.4362588471929311, -0.2567277615161133, -0.36272693902330216, -0.5809557724249629, -0.5777679491857758, -0.2690590723046056, -0.6837662315014684, -0.48936143323633424, -0.6834817928719943, -0.6241256763249727, -0.5785058973912877, -0.28595952290317767, -0.1440031402660369, 0.2690228664056698, -0.9489632239133198, -0.10464498023916798},
    {-0.29025623548254964, -0.45424202326485996, -0.194405994294178, -0.20945731582017574, -0.018862584755402086, 0.11234823816238029, -0.3631551879651441, -0.29708472833218136, -0.24128854530765514, -0.5242963031024002, -0.5293704687537021, -0.3910332851911148, -0.36958018050641894, 0.22534775881635888, -0.07014586408926436, -0.5095019764340935, -0.25890416999589316, -0.4521875766297688, -0.12483372780166035, -0.515327823000611, -0.6429917963578525, -0.38074088151692687, -0.5303751288299644, -0.15556263814165738, -0.26165238234646765, -0.7673032539158741, -0.17059479753677623, -0.20531431283834445, 0.0009374789682862496, -0.6651638942344305, -0.21747364832190338, -0.4191734339641595, -0.3025231577086816, -0.8365562247340346, -0.3374522718918872, 0.06834587630714432, -0.45534188539339226, -0.18947338252686466, -0.14076221319626794, -0.008010288746950306, -0.6501379748117814, -0.18934952074550818, -0.4400935643562495, -0.0026081092363092343, -0.6975881418272492, -0.28257957072039613, -0.4443865734969732, -0.49371566591300603, -0.5708199516885188, -0.2912063144955844, -0.4552250532502638, -0.2114507804410429, -0.5637102588483409, -0.11628638399750701, -0.24335763003722632, -0.5930061023259897, -0.2799905463058331, -0.5363131350190931, -0.8598640394159066, -0.38778382769404285, -0.4352367188371361, -0.32009960628208767, -0.31637189752111433, -0.1949455669591404},
    {-0.08650943879911517, -0.425384236711529, -0.49501333898914845, -0.3355198723770353, 0.3283544285267512, -0.5057493097727007, -0.6252125683937809, -0.5742449418248264, 0.055449844837446735, -0.17729855080630053, -0.42546569593262884, -0.522534146651021, -0.014950908426788421, 0.29895936453752664, 0.08533559999446116, 0.07624783836162435, -0.3395387674606112, -0.5060747736142294, 0.05921338251918795, -0.4959377803037151, -0.5750207454999168, -0.28386709789092623, -0.8734317808270883, -0.039724686799751, -0.42633415129475144, -0.10227921521006536, -0.5782205912453574, -0.08512451668416222, 0.2877904111572514, -0.4563244131502287, 0.1868925647184726, -0.36164865235503624, -0.6028925767012356, -0.4575729878275469, -0.2472155947183769, 0.40307867900574906, -0.6068017271360603, -0.10183918241322622, 0.09235759693869221, 0.2527054723642024, -0.7635941282211101, 0.2770425345683239, -0.5391018065269796, 0.36329362776126894, -0.610010094026288, -0.2878787786689157, -0.25689770018209335, -0.26363317124954166, 0.10726435356638363, 0.07252489384114251, -0.6172818659638198, -0.5397246767982041, -0.45741986369115195, -0.39744144095548994, -0.6840604587974286, -0.3467881230684756, -0.7348756981753283, -0.6525694630912002, -0.5985502608027671, -0.19674467123426517, -0.43624981090192694, 0.108466556622665, -0.4625197164329867, -0.30726747491080525},
    {0.045190652702232256, -0.4893313772220554, -0.35752813567137504, -0.7701332476215932, 0.3738397580042412, -0.02313570539349088, -0.662507794558871, -0.40629808877854356, 0.3562380646763547, -0.2251991080346482, -0.39351489621839214, -0.3733781854967938, 0.3092633794434612, 0.23641575574716, 0.38969232715166285, -0.11568350395251686, -0.03354190594959023, -0.43478745178909906, 0.13969330677068215, -0.7161247445160496, -0.20123171819087107, -0.4778599872381506, -0.48194672519640014, -0.5240618594263243, -0.523106158860191, 0.2437523379754096, -0.5955426387503517, 0.17991073918213127, 0.10998042592428928, -0.5616315809942811, -0.058937514338493494, -0.6197235726152993, -0.5285446834195119, -0.5156770969816611, -0.34644316397556385, 0.183144704606074, -0.5295687069558825, -0.2259657436344711, 0.1227225169749282, -0.19094851791466017, -0.4719216298663101, 0.011566725074579877, -0.3698644610317496, 0.17058592323324848, -0.5553836608388125, -0.48262800875796535, -0.3091972099946749, -0.3617869082983106, 0.06799622281570289, 0.05636230487141075, -0.5550274890021676, -0.34889931515727457, -0.5253333684190862, -0.3230420138610537, -0.5444007554526673, -0.4387783860813152, -0.41989736277652756, -0.7009731973952359, -0.3739822241386178, -0.49978621466350126, -0.6538884001815257, -0.12191456591231276, -0.5690141277927909, -0.43255207961711134},
    {0.13715074065792587, -0.3537438597584396, -0.5191862035063226, -0.6028825946055696, 0.4324755369233654, -0.4592792463157652, -0.7079218561307136, -0.510153685113147, -0.12038001278266716, -0.47977109538250895, -0.7083287463848559, -0.6863972613651174, 0.05491734899041976, 0.23654354826188903, 0.3822047484299723, -0.07144884004984872, -0.1942555975733975, -0.6205741983263343, -0.02799013425199912, -0.37033890584486345, -0.5921242314931763, -0.43965325983440523, -0.7654512154319607, -0.570855047384645, -0.2841054641989668, 0.21844001865714355, -0.4573428349804832, 0.06698605452797579, 0.15630801030739472, -0.7323714036210809, -0.09687467237693599, -0.5805824748289549, -0.6695577840430222, -0.4187512639962007, -0.30513252324438667, -0.05140669636434631, -0.47789299839897864, -0.056225458395710845, 0.002821812384291933, -0.4685431048882563, -0.7036342350981487, 0.001486459589413029, -0.2516766334585016, -0.09019981252871435, -0.4349587117231852, -0.5463470465051099, 0.2950741036098282, -0.6707848063386809, -0.18732446608174413, 0.29585139196528043, -0.7200429813834016, -0.7705182333244722, -0.5345578890017728, -0.5555048978869648, -0.8921185788269722, -0.6787127360637134, -0.8349564234203803, -0.4755689851267407, -0.5967024272552787, -0.35099391427515697, -0.383414988259784, 0.19134965502350687, -0.6406077936465238, -0.4013868347983137},
    {-0.061679721511949406, -0.6067891544482806, -0.5454660684789244, -0.5588466435164927, -0.22521722966956254, -0.4070951913268729, -0.5318124326971403, -0.6325597247729277, 0.14285551698947613, -0.475824004650671, -0.49137522501104774, -0.7067279708714332, 0.06807868502997784, 0.13783828798952533, 0.07749257018583461, -0.15553170435345687, 0.08090802553443495, -0.7271327262400816, -0.040666186634400615, -0.31124997542109634, -0.2910718179031172, -0.6761353995727011, -0.5474681539542293, -0.5783558540837795, -0.7347720527442781, 0.056424888468687075, -0.575344537807688, -0.1170437114966131, 0.3633267478372913, -0.7862697922805073, -0.08181809948647614, -0.4059913923171391, -0.6582777183037598, -0.7270485600223465, -0.5775250602934162, -0.29328663105937525, -0.5584692045100332, -0.16000489927047257, -0.01303213187048007, -0.060723855974113276, -0.3419034130348565, -0.006292394097702293, -0.5613117562343415, -0.0344710924350924, -0.7440672476652276, -0.5182909371138062, -0.28772842558866163, -0.5542293379354748, -0.28204217226603656, 0.18517645177801165, -0.38728919807650397, -0.3265968651634936, -0.5023621552632177, -0.4347153886973624, -0.3899826733934891, -0.3753833418678486, -0.6788032499406479, -0.6290870349293964, -0.5485758587413423, -0.6415009581864101, -0.4182528338020719, 0.26525296374152013, -0.35469084163335846, -0.423529762130657},
    {0.20885157424363515, -0.5587330495397902, -0.4304770635963467, -0.6574714861392222, -0.025423823322347466, -0.6039098489102249, -0.5033164498389903, -0.6603992336874751, 0.180520333474353, -0.4550816613070323, -0.4455919979831538, -0.30350476389571585, 0.05839240239077133, 0.42114556943139486, -0.04379394558103781, -0.04391784873477034, -0.17369321470085386, -0.7443646365182063, 0.1518068169340576, -0.4877669387163346, -0.6461322362390518, -0.23821377406858624, -0.4147086048105308, -0.3468701845601081, -0.6819597076825766, -0.09416356590479315, -0.3029033900179872, -0.13408568184757017, 0.21231851093286813, -0.6818997288923475, -0.32618115632844374, -1.0009570486925743, -0.6054233230654787, -0.7853486541792231, -0.6812055367770802, 0.10396819538867665, -0.5520735811132145, 0.047647017605382876, -0.14627561265890515, 0.009646208542614639, -0.5243732693379757, -0.0853743056807485, -0.5933203880038358, 0.2076714999747418, -0.6573895602740989, -0.4912988730485317, -0.10800516928236778, -0.3056640126471289, -0.17747799619874202, 0.2049707382094021, -0.8238673248826405, -0.6100328319642687, -0.8665272420241321, -0.6451639444061216, -0.5765621467035732, -0.3852644158958848, -0.3114699802194788, -0.5125628728563755, -0.43977923813900277, -0.4183162201161319, -0.43902163989337856, 0.37735342175221503, -0.4478899492314969, -0.12140600564761683},
    {0.03756291642138032, -0.8445362843177443, -0.5075750191441597, -0.46003547876731443, -0.004095692542386757, -0.6589191140496559, -0.5550408792200191, -0.7262099671684205, 0.292796866468762, -0.08525952571225451, -0.39838225986550263, -0.5662696777836292, 0.05843411672173174, 0.3298807461728526, 0.1765039256407206, 0.029665398386606978, -0.2828046783469424, -0.5974973081910471, 0.15835294060470315, -0.3922305430483715, -0.8493956326680493, -0.3357572011330863, -0.7847663894424217, -0.656157963436969, -0.5865746374812938, 0.2529919208095368, -0.8830709949473945, -0.0764189078527873, -0.1327001250829875, -0.4556425672249847, 0.18877344415589623, -0.5701404050422302, -0.6453881702665705, -0.6249157917968029, -0.432238093956808, 0.15075071399759993, -0.6344392493952293, -0.16925363989355816, 0.0213916717986544, -0.17311885668089766, -0.5960123122048786, -0.00889098882765685, -0.6463830148404202, 0.029472315060177137, -0.5124708966674922, -0.51665743662534, -0.1066472324960255, -0.5643158042390403, 0.07976342941467088, 0.02428811623199305, -0.45238112925005664, -0.519747101690638, -0.5493536790598719, -0.47574557471350554, -0.5737071965387333, -0.34660523669970045, -0.4171037079034182, -0.5166510440283876, -0.5446711987030999, -0.21515270650256996, -0.581215833711596, 0.18423767609117098, -0.5686480334868098, -0.14741491233238002},
    {-0.41999472586841424, -0.4416367734219608, -0.3439161019327861, -0.21529032212640065, 0.022179591286064372, -0.4908931291167547, -0.4789596648252769, -0.27933189504013317, -0.1436530309702704, -0.28202327613413863, -0.48137700166688646, -0.2860679539657437, -0.01730000048033773, 0.2150949903117851, -0.029382251608585052, -0.05085049034083836, -0.26040461418747207, -0.7053674287560441, -0.28882633676408204, -0.43721988931751593, -0.5419573016231684, -0.6622081233574483, -0.36601718102796854, -0.2434035032692375, -0.6412923257767148, -0.14129151373514295, -0.5225296448872603, -0.19955394896292533, -0.0911877159904277, -0.6637185630635943, 0.1944836076727537, -0.558718692619318, -0.38005818338029634, -0.6328161073523888, -0.5722144914457399, -0.09643317567232958, -0.4785522528734673, -0.22100996308951898, 0.07928058916460212, -0.35209530715067744, -0.3317708789278428, -0.1605579177437888, -0.46061252872498654, -0.294190100076507, -0.5571105430808231, -0.4210155243726424, -0.4660587148654984, -0.39092432886702494, -0.35188150657548245, 0.03819549826591195, -0.24623165063664504, -0.4615320323104757, -0.29085700462214137, -0.30886970681366943, -0.41277333919260717, -0.5798576647466619, -0.16753259626204986, -0.6554608740373645, -0.5130276681055705, -0.3753650372954176, -0.5254187679363513, -0.29708528247831906, -0.38095286091446606, -0.624957029485801},
    {-0.06011236554416547, -0.45465398808330765, -0.5853287281199394, -0.7725852780758582, -0.0556072714595473, -0.6184474550420669, -0.5254078633932301, -0.7169088175811976, 0.07222624876046961, -0.4246874880834365, -0.5775490139664627, -0.4961971960410857, 0.2797790055724369, 0.321222653667503, 0.058767710936387864, -0.11052420456313602, -0.08633989609914357, -0.7021311336232511, 0.08855963933384041, -0.433958809717127, -0.48528445989258373, -0.6196201895548757, -0.3744837744826768, -0.6242646011312367, -0.7469646954314777, -0.18252542303456976, -0.7121501594365582, 0.07997722400246392, 0.02171966043395407, -0.7237064059264982, -0.0801786042116204, -0.3890463549767704, -0.4764755798482392, -0.6266733916588834, -0.4465903505389891, -0.016278772369643632, -0.4615061064168884, -0.45210130028605544, 0.08327892586414885, -0.22072190336203337, -0.3962306983998847, 0.22626942542981984, -0.612770985347791, -0.039939709208201966, -0.6655552886107525, -0.5212416463126068, -0.05618702875318473, -0.5467996434697437, -0.5686983794960352, 0.16172526046752755, -0.7020482675788093, -0.4132084730668337, -0.37077969459633625, -0.6332558714360322, -0.5805507512040949, -0.6839398467148695, -0.47618374539997527, -0.7582850288480406, -0.7689624117048885, -0.7034871797066751, -0.4344184504335605, 0.07458865108496644, -0.4426977253633496, -0.4954034180071542},
    {-0.026958731922828768, -0.9277118574067564, -0.6756594368755569, -0.7838801437608046, -0.20595066457182454, -0.4005813006239925, -0.4490044975205461, -0.733892101632309, -0.022302265237396784, -0.15245977029563484, -0.3690097921376963, -0.22364235688143166, 0.33245590228741617, -0.07756948086217852, 0.14069131005381907, -0.5942626731233923, -0.3939380287241389, -0.5728272851809957, -0.2980482503307697, -0.6231161705912455, -0.5611533983155874, -0.49680124623550503, -0.8889460977106977, -0.6445332458974754, -0.6184796849616374, 0.05097707051318346, -0.6087347828315391, 0.1326660638719771, -0.1664195145556679, -0.4135241549098298, 0.214167184865959, -0.476576105071956, -0.6645017565731501, -0.48426517520848006, -0.6096243501524468, 0.21291061736090464, -0.7170891777403722, -0.5639230618732399, -0.19446332754541854, -0.34328889024338893, -0.5054883433978543, 0.17265567118472433, -0.548767442782323, -0.008504029949184247, -0.8076527436812878, -0.6247589959756278, -0.4455356576368611, -0.45350099506534985, -0.3240519854221547, 0.030864289087211103, -0.5550126488358916, -0.4985966862612825, -0.20821330648804776, -0.6049232748175645, -0.6333082257052925, -0.29648733784902315, -0.45305378987141026, -0.5370069717671936, -0.4144124937307914, -0.4380219742496352, -0.6778748995968733, 0.09105218196675625, -0.3559370796516527, -0.4629702001774714},
    {-0.11393442400024505, -0.6804684454519081, -0.5324124428469701, -0.7844619976968809, 0.23876732048965055, -0.5150921507295195, -0.49487156010327177, -0.5280743368290991, 0.01934623914728367, -0.42153493541384734, -0.5479513492238354, -0.5617492230907218, 0.5488599113827555, 0.08779983335037339, 0.008052802256999211, -0.5495096814190652, -0.23933400502077712, -0.7468586831509243, -0.1722301492795636, -0.6207024257197598, -0.5934361763960758, -0.6618089185336351, -0.7385896786351539, -0.7695672220233862, -0.6551773171807997, -0.018522630424874283, -0.5640114220470206, -0.15852407060682752, -0.33470462130690837, -0.8858099793783679, 0.23851644629220986, -0.5878474984629336, -0.7513224310580766, -0.6156288430606138, -0.5762142871783769, 0.2591260071401419, -0.7046230644674238, -0.03821403249431732, -0.5074122975762528, -0.1768675542244652, -0.5557730143157196, 0.30181744843266795, -0.1696705963044109, -0.03837330511499916, -0.7976520794948766, -0.6607358055437109, -0.3535521270852438, -0.5773367594059765, -0.4612264283731687, -0.0914504831826141, -0.4402190892140226, -0.8504009904660197, -0.5857275349553654, -0.7792675457573429, -0.2422499959139563, -0.48375008974558126, -0.5091695770718543, -0.7977822059544263, -0.4650684906254721, -0.5731701768697195, -0.3950985912959463, 0.08076359896973245, -0.8503556620832572, -0.5791313556715665},
    {0.11665476738848224, -0.4565656417643726, -0.42591790944508, -0.6484859657143461, 0.11078725497078377, -0.2088792043451365, -0.28531563745174165, -0.5993398939148383, 0.020126282703972244, -0.14336110816820016, -0.596812232461759, -0.6189411315717861, 0.2845403566048516, 0.2539567565275353, 0.221760228277094, -0.36374542814185556, -0.11301847151043258, -0.5923240889034314, 0.3271115530166083, -0.5832648401477027, -0.7662441533449013, -0.831735963560886, -0.41363816195636777, -0.7503262575245566, -0.547033790127899, 0.38842810228466285, -0.6481662911057919, 0.1683192262814436, -0.22735199638835957, -0.647629195163703, 0.26154631344854534, -0.6978000887945376, -0.8322931005260614, -0.6889264436714057, -0.29849295888062843, 0.30451611271119894, -0.3917865305875363, -0.12350236118077795, -0.10803573098153994, -0.2146231392082836, -0.7502980055998885, 0.39845015715722815, -0.597972659077854, 0.4343659727192904, -0.6959453381490309, -0.4621476734750176, -0.11140482015352325, -0.7594722188132176, -0.6872243110210785, -0.2155458883361184, -0.47348440595001373, -0.4834500728065673, -0.7312619124237227, -0.5630827284457467, -0.7202337004901813, -0.918462360739633, -0.5227404354774973, -0.8160596823648081, -0.393187693175069, -0.1982282454311552, -0.46994723854158515, 0.021318728081780265, -0.6583976348251784, -0.5114110991649082},
    {0.055356134343918985, -0.3522748865843958, -0.5978215867736439, -0.6282968476333389, 0.1118075494494373, -0.24850564615141654, -0.9131032936578107, -0.3666162879957169, -0.09487694550417371, -0.603339592832691, -0.8615432984502778, -0.5945469741663725, 0.08713285865090781, 0.04772029363315659, 0.24906525773322913, -0.5269677593468106, -0.12120870955959157, -0.43784822259543354, -0.10543137629904363, -0.4098795229296534, -0.5917937517461862, -0.4439882495228123, -0.5217992636033355, -0.5785740713124059, -0.4473303175148761, 0.16769640660085586, -0.6122453096059438, -0.05830066700192391, -0.3755699417649934, -0.48156710590322743, 0.10959241056462503, -0.6002544183272978, -0.5415126469656992, -0.5466299663032953, -0.22074515545089204, 0.30948934642728176, -0.3571587009640981, 0.119333167201136, -0.4198990833495422, -0.350356030682974, -0.6722013766390487, 0.2992124301023008, -0.5307126705903715, 0.21052959184869094, -0.44002342218635043, -0.6080551421757924, -0.3316579251034715, -0.7060566141486286, -0.6617998904704692, -0.17289017535357953, -0.6348943923953959, -0.6346411370406159, -0.699484866825147, -0.46180324939953193, -0.812241395163787, -0.5874222144392507, -0.7797901360986891, -0.8487909704311611, -0.6575446935344131, -0.4339561916324779, -0.5918328871673896, -0.14884281836863156, -0.690260395991541, -0.6367665133887491},
    {0.00021776351018712754, -0.36260025165955484, -0.4477573314046913, -0.30922674107317044, -0.040984931787100255, -0.42204502452982684, -0.4397171983472407, -0.3995265006483522, 0.007747238082174458, -0.3938815463470769, -0.8112931513464656, -0.6894320794194413, 0.03244394295527567, -0.02730704743006595, 0.005859303908793198, -0.5397643512326984, -0.27875876908514846, -0.47288330639385623, -0.018983706402061606, -0.29059872702695766, -0.4077607275252274, -0.4755160551957399, -0.4993187053842148, -0.6715266092631257, -0.30611491008401887, -0.2927082256625237, -0.2939315976709322, -0.11002842146467326, -0.09434850948655164, -0.6308564455312811, -0.07819396769998772, -0.7592080178571923, -0.5776185764835964, -0.6517513898951642, -0.29357893647735445, 0.1647343746241895, -0.8088620331515782, -0.14401258691515703, -0.4143271464666949, -0.30965154956523194, -0.6141656804278965, 0.2657140643863256, -0.6708319187881728, 0.10029028192274973, -0.32541753999936146, -0.6396315903049767, -0.35934027898831067, -0.622721179545727, -0.4749571241411567, -0.31247173311207915, -0.677708790525404, -0.6229841623334793, -0.6886999574124206, -0.5674467373842754, -0.4745597421774198, -0.3914274915235974, -0.5118274717361391, -0.5892037561358824, -0.7194389010517549, -0.5684388015085279, -0.3310181983330231, -0.022296536734965837, -0.2180330324388874, -0.5709498055148692},
    {0.2484791005139238, -0.5021070256290704, -0.39928550757694226, -0.23494198198186064, 0.27524522580973704, -0.2870097374413984, -0.6075033142585685, -0.41596004850713314, 0.4550009853481407, -0.13260450918903446, -0.7967683852602208, -0.7357000742118203, 0.24732434224538496, -0.009933112904422954, -0.17107135231199055, -0.217977770152644, -0.023878953784518063, -0.5027986033231859, 0.09796231917354967, -0.003945859257413878, -0.4073567396152614, -0.45978934624785756, -0.5731894556837164, -0.7308486482048902, -0.8446687357208778, 0.029881293403866614, -0.4971929053662455, 0.18157466442483472, -0.06513717839528421, -0.5525345305064026, 0.5255199049835056, -0.7343924112880195, -0.5687509541718014, -0.5635997747548028, -0.3538791079242616, 0.01992417703838952, -0.445820303774862, -0.0041309266857842974, -0.13596958794142727, -0.2518204136772747, -0.33869135630076685, 0.27825932771614814, -0.4312999239200216, 0.40426651576421757, -0.5633652773257577, -0.3861828571393486, -0.4924024319788572, -0.3441128968625616, -0.43838185041155675, 0.011018763162944348, -0.351693856580324, -0.2950906850288506, -0.3899845432725161, -0.6714758049608429, -0.551659897196546, -0.4711714251758647, -0.587496215637381, -0.32817911654130316, -0.508543331629116, -0.30499635013586596, -0.5742801222193259, 0.17690271637537414, -0.30813254073484353, -0.507928167856901},
    {0.02191925183811964, -0.4921331153191308, -0.5428874090869161, -0.7475261210745235, -0.12331035541190011, -0.6471039066165499, -0.5304445424613714, -0.3478274618337614, -0.223546789561841, -0.6240709160859719, -0.5583035901942356, -0.6154604062519148, 0.11553330730722713, -0.09344758759191382, -0.21303302133710963, -0.4789098803010015, 0.025156592403934273, -0.5505644675394634, -0.12619704893531883, -0.16309566134023876, -0.9123352571156931, -0.49815385193132805, -0.5583283412083228, -0.5265110265511265, -0.723791079234373, 0.0011534420389802346, -0.419101383245403, -0.02039537753290915, -0.30720517425774774, -0.45295869809035744, 0.07921675285062098, -0.5291606320312023, -0.7742175029134545, -0.69904388834986, 0.01923425818022143, 0.11144340016305167, -0.5312961478584246, 0.06326544343209117, -0.3663778121289042, -0.363641238175015, -0.6334747432678699, 0.04839686165704556, -0.40048966131902636, 0.21042257290626729, -0.6077502588647404, -0.536855466325809, -0.486504088282598, -0.702926404778024, -0.4475874403217632, -0.18459987301392242, -0.32453337148643335, -0.5212272646477205, -0.4149606879964944, -0.6846699549213595, -0.4723945059574646, -0.6687030167176732, -0.8358660209506357, -0.7530841466228616, -0.5381107563266048, -0.4548734935374983, -0.5266269235857566, 0.1744577099265116, -0.7054899001911775, -0.37801110835108337},
    {-0.10151156182146882, -0.45606280527556703, -0.3896076656253174, -0.7160826827964314, -0.003695593009951973, -0.3398702312271239, -0.6026006270924397, -0.5240833891283433, 0.24399593029697553, -0.5070937167987469, -0.5343350673819253, -0.8759906278115012, -0.1879127131623608, 0.06634642182160616, 0.13337870824660536, -0.44252426439614184, -0.21790443204271592, -0.6347635197331415, -0.35487331475621525, -0.8256557057886394, -0.6317591036181415, -0.513194717384898, -0.6085668517805125, -0.7457172024130271, -0.4950895400154915, -0.09147697736887013, -0.5663872647689874, 0.05993775670950542, -0.17755453826605502, -0.6680790642530692, -0.21685200955004855, -0.7776497052163356, -0.8912258448576794, -0.7680169037400345, -0.12544619063629847, -0.08981350640453267, -0.28332485759462067, -0.20585881232887543, -0.3080159416905137, -0.14422513631330391, -0.686469750962675, 0.04270824163833325, -0.5835604518070038, 0.21830114066678896, -0.4395811414986272, -0.6470860822172495, -0.3958399732511541, -0.6710114588718378, -0.18702691579927078, -0.03928747441800189, -0.8107610581120853, -0.7410889200056543, -0.6808104232511196, -0.6282134505333689, -0.7399621934701889, -0.8407899611239872, -0.6187979756370956, -0.738612851905874, -0.627387422266041, -0.5014104618401055, -0.9320848297894662, 0.1290729663445779, -0.5075569009390187, -0.5194025802515086},
    {-0.1421711618825909, -0.2821442838622537, -0.6153547603340173, -0.9937233927356804, 0.023103076748115882, -0.4029135947405327, -0.7340222600030464, -0.5799800192979594, -0.18829485756817196, -0.48374421853225874, -0.23347432106839366, -0.7155078520015422, -0.21840584691544998, 0.1780377162616194, -0.10619918692424063, -0.402443424857454, 0.0891283202677276, -0.6046658690555735, -0.19585719269864768, -0.5714537330573992, -0.8583032776528601, -0.6923639269736577, -0.5615104996053677, -0.6263638369153833, -0.600929027927675, 0.09822524506286219, -0.5769646330925482, -0.022906190121654367, -0.07324448417963743, -0.957705095294018, -0.1459260566498334, -0.7343938939640947, -0.6285446716380759, -0.546881889019953, -0.3707582470611504, -0.15433078470456615, -0.47036034827974277, -0.18908266547221797, -0.24077399389220117, -0.32481884237716646, -0.8036696111160747, 0.2753493779132288, -0.45233999270454106, 0.11116642861139416, -0.6051190801077735, -0.7024728413431096, -0.3987485886211523, -0.7064679757998079, -0.33831301146180626, 0.09050389444398825, -0.759254410610388, -0.5812720523131757, -0.5640088777242863, -0.411389786158374, -0.8291949929512715, -0.4928485655398073, -0.9029626767329908, -0.82123590186274, -0.5913367793715504, -0.3607625946774037, -0.6982512914241356, -0.04806772111559006, -0.727773460470387, -0.832917395885901},
    {0.4786813736092664, 0.17950182419015906, -0.6193369688558863, -0.4515352029633473, 0.5461729347041245, -0.043894107773005876, -0.4570006128625518, -0.05141882040808073, 0.7096114692926846, 0.36816273699077595, -0.66702400421434, -0.7966690297268221, 0.42866330723900864, 0.5061570888815373, 0.6035712875402133, 0.2024498781048571, 0.3978561294674429, -0.6064265569068596, 0.1791701419184368, -0.3626941537933496, -0.5579623954606631, -0.4339671405642377, -0.5612895909285875, -0.35489174928113637, -0.7605421954201701, 0.5472395339296278, -0.6084785857675509, 0.4134487155767856, 0.39876008613693475, -0.7307485326815242, 0.515502248139387, -0.5479519571748336, -0.4210431258439863, -0.5535604264419623, -0.3757798399576564, 0.5292305083060181, -0.6709623585642001, 0.26817660049875836, 0.24879544176436605, 0.42656064592109216, -0.5480500842846769, 0.30875522067798405, -0.15020140222307116, 0.6086031986466622, -0.5357028862923602, -0.5336176364848834, 0.4622055162028349, -0.5232234972718093, 0.14624458081074468, 0.6231102803929561, -0.2554935738464968, -0.6110873852086773, -0.4650120861063254, -0.36720456931387235, -0.2648797852679996, -0.720797297728687, -0.5882035344898737, -0.4187144087347836, -0.47074532098934585, 0.19558477248414796, -0.6268555522715558, 0.46923284788935143, -0.42360692505579267, -0.352086175967229},
    {0.19317231758893025, 0.3276673250921615, -0.49809474580210694, -0.6749596352084525, 0.34467730586340006, 0.6418853892939163, -0.3755946624950494, 0.045248816567349165, 0.596137971050663, -0.02531737415390125, -0.1894353163019653, -0.47445090644749843, 0.6203697849302149, 0.5786080165248467, 0.5533012723494793, -0.38343725121885613, 0.47803168302317856, -0.5089518196611467, 0.26977113582836476, 0.263056570899595, -0.4332412639319345, -0.16589276129469138, -0.6519562761326945, -0.625028143159631, -0.42504440327500814, 0.5237631931338985, -0.17737583316691485, 0.4924896044218709, 0.27441393055463104, -0.5582133398144509, 0.5807186773623301, -0.4995171144485892, -0.5759991045749451, -0.6096606879177454, 0.14604983285654477, 0.4627853537606243, -0.23659702163352478, 0.4931871920206844, 0.19750572553591128, 0.289804316222757, -0.5118850764075578, 0.45066982590412963, -0.32962268487641494, 0.7993771034086193, -0.4464692436350334, -0.4554088276648054, 0.04213436994055279, 0.030148472204768562, -0.15607812971785004, 0.3745308628996486, 0.02361692009628973, -0.2783066939109774, -0.4741576061697855, -0.09329414704596702, -0.18528159695265886, -0.4793875670818013, -0.5917340974667797, -0.604969968017731, -0.7103459031677172, -0.30148200830116795, -0.3467786527547533, 0.562315460758604, -0.7238387733195347, -0.15793773256586996},
    {0.12826370874678944, -0.3816521358495606, -0.7493561969881118, -0.7917659531760566, 0.21462547608883828, 0.27326781056222804, -0.45525229579368603, -0.45295670209370137, 0.28943885645156553, -0.6077283491034979, -0.4771022987454451, -0.545823649755122, 0.11468636160828, -0.13697601739631915, 0.17695899503812054, -0.695591734832067, 0.15571031714946068, -0.7045085295912877, 0.12231384890933955, -0.07523992981125933, -0.5257857780455084, -0.6105295631004682, -0.7230770033132067, -0.8156402744297766, -0.7516050047489209, 0.27218267931787016, -0.6141949662239197, 0.18856999084065454, 0.19371555459479087, -0.6965379059512676, 0.3716458948093168, -0.4850429200161105, -0.72263581851467, -0.7418763463507894, 0.04120160520203585, 0.4910093363617611, -0.48209625513391086, 0.4195342880375253, -0.15743024627597646, 0.1905096590555795, -0.6411579999740687, 0.20067024257888322, -0.5198877561208126, 0.5057766855868544, -0.6377532278151931, -0.7946471005971221, -0.17253828340713057, -0.344624741645056, -0.2696643865989133, -0.146142247394695, -0.4259722302618835, -0.8248560218149966, -0.8347547850580034, -0.6338002318557321, -0.6791287332985565, -0.5015515319739027, -0.8254547373867779, -0.6302577964835322, -0.6712865930982838, -0.6287924241017501, -0.7313008750510113, 0.20582251911836538, -0.43852647632550834, -0.43077773061808455},
    {-0.028845186874286638, -0.4089885202500502, -0.7305500851203587, -0.6583408816715247, -0.03121469208580069, -0.45882156842619637, -0.7730342840778962, -0.5108383156739063, 0.006368414311302215, -0.4196967166980255, -0.6369826931823596, -0.648017237642275, 0.2271780865674716, -0.1619776091396513, 0.1800427854568389, -0.36071736193998405, 0.06428187588597321, -0.5334338665583197, -0.23084432923064785, -0.38416433123064997, -0.7536663611215919, -0.7910021986486215, -0.8041392066493697, -0.9717385063897579, -0.7108694393875099, 0.1146099138183806, -0.5188318345633244, -0.09249029421765237, 0.03064028586733404, -0.5088669160305117, -0.1378560789946696, -0.6041449835663076, -0.6143796605419932, -0.580558280674371, -0.19747175628505836, 0.0712394054058248, -0.6286288231967861, -0.18216934333192794, -0.410195706161053, -0.3681478357723083, -0.597242677135554, 0.41839983255271757, -0.6695048369332062, 0.11350235192537873, -0.6074362622423245, -0.518638468318595, -0.3143217568884347, -0.4520428355450033, -0.44254630282604934, -0.1585913530427271, -0.6785167070165344, -0.5268071200350738, -0.6266992852706343, -0.7504696118489455, -0.7860647084800331, -0.5180828100251603, -0.6927787743296331, -0.8218994707052343, -0.550206062462361, -0.6685919883934311, -0.46204014098189916, 0.07457713118735115, -0.5072454480518266, -0.4832134527278949},
    {0.07588482230256854, -0.07306648833437278, -0.7576103799176778, -0.5351194218750911, 0.17425179986576908, 0.04794496604892983, -0.36034854283291, 0.016123788775256966, 0.32328588887380966, -0.5318735761211203, -0.6419896936188048, -0.6211715861163173, 0.2642318392363775, -0.08851245189361728, 0.3756659900465152, -0.6846392371671868, 0.42520206139522276, -0.6842159358562767, 0.06925411173197911, -0.07909779455637937, -0.7804348993015969, -0.2599159439905437, -0.4574263562525842, -0.7282075713055808, -0.47664946576258205, 0.38620648884637204, -0.47317884302760305, -0.05177902492181979, -0.08446108164404977, -0.7360554744777029, -0.026617935429159044, -0.5946054734526139, -0.6916684567241405, -0.23020969418156592, 0.08904703603196487, 0.12365876329598316, -0.42088320629220266, 0.2001773563961056, -0.3772482116101454, -0.4812865260431743, -0.7780394966688847, 0.28009620800055524, -0.5056975303596374, 0.39679392256688684, -0.5509115247628844, -0.7046316180444893, -0.35771329425380544, -0.29870380745566094, -0.5887727482125448, -0.20690219796254472, -0.11259048467053816, -0.7813253725126007, -0.7060679271610127, -0.33244202206857393, -0.8016252887453009, -0.5338050856232002, -0.5915959126207955, -0.5441452509204622, -0.7752665662136121, -0.6605937463034374, -0.4706806885027547, 0.3889027636550629, -0.685254747673875, -0.2427374584492773},
    {0.45396796041692256, -0.35670417837069857, -0.615695407459631, -0.6945702152042236, 0.38864512699389575, -0.11213754220258293, -0.5754286097697547, -0.1907892545751439, 0.29695857414885074, -0.3653100595914274, -0.5541674701181203, -0.5601421439012089, 0.3854240603105389, 0.18591843379903294, 0.4167962527614828, -0.7221129256843802, 0.31172754529762714, -0.49406429247370254, 0.26223905134797043, -0.17430635074355452, -0.7799045721481103, -0.674235360004918, -0.5403870811916962, -0.6880607016897027, -0.6978024834902512, 0.5008999370096768, -0.6558662619879271, 0.08365480159432949, -0.054091498678192296, -0.6823975611724414, -0.10397990427148739, -0.583398324991344, -0.8050209029733552, -0.8082642064827182, -0.2367998087957182, 0.46502684448873827, -0.4620025937903242, 0.1341025630513636, -0.25598477519163926, -0.14307828912084822, -0.7208657368733952, 0.39328714378073254, -0.48038012358845306, 0.3388485878714709, -0.48686778635713623, -0.6431744090982079, -0.050960087943500015, -0.833660276117438, -0.2948863400801215, 0.12515487342137877, -0.6884511893070732, -0.8231313769472992, -0.6266217971581318, -0.6399461947404023, -0.5705490889107064, -0.7859236571308793, -0.8847495331132906, -0.5168691777083686, -0.6848246736660474, -0.23295204675723152, -0.40457973499433997, 0.5930776079469783, -0.472925189324186, -0.6206141682023048},
    {0.21429848159163867, -0.6010986965493683, -0.6856229216388308, -0.6125268902757425, 0.320536488853977, 0.08352835996376287, -0.5805073315927397, -0.33287913623708326, 0.15223867801935168, -0.45486686260970416, -0.7299814245022026, -0.8647404249386382, 0.41113381698420726, -0.1354441498512064, 0.014336915507349265, -0.4755170996278913, 0.002781062871442519, -0.7145904623788367, 0.058414422660620045, -0.04767828145814289, -0.3865385078071365, -0.46778275686352466, -0.7341703560105892, -0.768952071623944, -0.7085478600926924, 0.40964792364169256, -0.3789839026626459, 0.12566192604098497, -0.08170534633382402, -0.5568351396384885, 0.17641068566248683, -0.6305876036107415, -0.8713166759503859, -0.6144056010425121, -0.11369701316613925, 0.15825113456309628, -0.9145766926110352, 0.05398954823917355, -0.16822724238233186, -0.36659577499090895, -0.5245777086448161, 0.42505228413999857, -0.47944240942260485, 0.1492411982549633, -0.8280516411202238, -0.7547877998633387, -0.17055165067159878, -0.4553088963024947, -0.598243395676034, 0.05228671902959821, -0.7333122657045636, -0.7590028950223396, -0.6532085402258447, -0.520351792947484, -0.9145018077191348, -0.7724167772312927, -0.6236740668255238, -0.9446352677326089, -0.7188897683578154, -0.33247378212654044, -0.7636712584884894, 0.018400263000000062, -0.3300298076301191, -0.5335852710741683},
    {0.5093507269396209, -0.3829094883730524, -0.8593305205379013, -0.6780287993839443, 0.16793384022916305, 0.34903313465066327, -0.7898148384682031, -0.1816990331868698, 0.652911676010049, -0.5247934629905796, -0.6283910889535613, -0.5136145679874279, 0.4230591952604148, -0.08935412195418763, 0.17082092461610573, -0.5330708790382622, 0.27683055960573477, -0.6991161241093412, -0.07110801329393328, -0.12241306593272111, -0.7249481867910291, -0.5470350013189895, -0.5717813513071943, -0.5275517474625145, -0.6423734972165245, 0.3207541395375965, -0.4280633002322509, 0.20663665033942752, -0.16095599979856678, -0.8579659027652012, 0.2962518555236757, -0.49513794221407265, -0.5571603916843088, -0.6433117193287694, -0.08107095090154405, 0.4626979788774831, -0.3248631847239463, 0.21683378376206563, -0.2642684443934797, 0.039140653305157244, -0.7112360110493494, 0.47604593648435906, -0.3615998763310361, 0.3341459446676217, -0.5601352189926017, -0.8724007828803991, -0.5187803619608186, -0.4639617894490714, -0.2662866389595344, -0.14698273654415644, -0.10580137355045251, -0.7028809153095564, -0.6223423142819344, -0.291474041821097, -0.8886239248275973, -0.6209414917904944, -0.827612833468984, -0.6860434235707062, -0.8374856693085688, -0.49777967670969314, -0.45277329377080283, 0.38913813585612905, -0.6618427744811322, -0.5218816486320317},
    {0.23622716736360566, -0.2894915533777877, -0.458523999712647, -0.6441404252792333, 0.22457598070300447, 0.14609124423953504, -0.6874045504214176, 0.15279442168545343, 0.507338357459913, -0.24907277877804124, -0.6911069757105308, -0.7918729587420434, 0.309888460161654, 0.3234730610425629, 0.2938234287174679, -0.6588245634108503, 0.23632432844116016, -0.699735784379751, 0.18001407345033657, -0.15597297974368385, -0.6770728579419243, -0.6136943128706837, -0.8861815487998501, -0.7915782087809528, -0.7900045512496181, 0.5349336653227, -0.3727644796764027, 0.3261687041210203, -0.02088888316082296, -0.6140823094755492, 0.429198306105093, -0.891836041229157, -0.4986572240410812, -0.8291848372256941, 0.008800642353226352, 0.3721845752649367, -0.48631605057141364, 0.6048777333291334, -0.26710833916737464, -0.1840243164023792, -0.4345223249153196, 0.012407001257396385, -0.45419423237820666, 0.5658236123707784, -0.5991828615540161, -0.5723174937164719, -0.13548858147405438, -0.5477985443660577, -0.39622582681296376, 0.039407434761971075, -0.2994941382398727, -0.6497455940776591, -0.48101590479289386, -0.39040912056423344, -0.5781450679659919, -0.6642141346599294, -0.7164042101471034, -0.654882298275836, -0.6928444500598019, -0.2752048142867597, -0.6267724960894444, 0.7256228776201306, -0.8017146899861884, -0.35960014542160107},
    {-0.561043846165278, 0.6603295033695643, -0.2003789663326606, -0.6176137493216577, 0.19720686563850431, -0.08563972460040219, 0.260060490270349, 0.6584681653432087, 0.13159667113986323, 0.12396387441945937, -0.5522045665060253, -0.5364283720769036, 0.30142057332157907, 0.0787207201819416, 0.2523280394508066, -0.4124831274140115, 0.1207924338444316, 0.3115008482703368, -0.6537241743606811, -0.0007553554495246722, -0.004293354252930858, -0.3742835185166575, 0.14877551764476268, -0.1545946953027712, 0.02348281374630313, -0.30137738126855945, 0.4356107808780261, -0.23926034090954512, -0.27942757140374985, -0.5502571826385881, -0.4691400860760739, -0.2031427529529962, -0.07112350135561131, 0.18008974245372628, 0.3924612135881595, -0.34942143169166456, -0.4651006792292816, -0.08794982295235931, -0.1935088652241527, -0.5994791349850532, -0.36905807851786526, -0.36468078520858394, 0.42126291533916477, -0.040534729377596244, 0.2744982304031535, 0.03604640597972496, 0.4427622230892505, -0.144683546616276, -0.3718069766358762, -0.3754779886672636, -0.1939864652832398, -0.5871805816867673, 0.5326345410810019, -0.32899933595876496, 0.24150365550155606, -0.053432696664632025, -0.3663789244861658, 0.22309598407296719, -0.006832242461935043, -0.2398090849293078, -0.2039035820340598, 0.3129176325149165, 0.16681884556860718, -0.3531606387093284},
    {-0.42681978888618216, 0.6212660485969087, -0.2604238701818279, -0.5224684871173064, 0.4515358373383062, 0.22902766525635082, -0.3218966914078529, 0.3603832540766288, 0.4329373627426501, 0.3516568916536133, -0.38835720447683636, -0.47940827160606114, -0.13467086486533394, 0.1998433331197335, 0.45438805686773026, 0.24679224697674387, -0.20508664721841502, 0.025984938666312848, -0.41736249722980995, -0.15706268447603672, -0.04255014030207644, -0.4446806191592752, -0.0019566524033897063, -0.08600785958025275, -0.404533554900934, 0.13642931452199045, 0.4576514679752296, -0.5664470853900346, -0.06648875469081919, -0.47929574732984764, -0.32967969239248945, -0.5624572720320907, -0.37012325086546866, 0.1359184222686259, 0.6947476348248371, -0.32299389776303994, -0.10888022178833791, 0.1449719821106724, 0.16398638040432706, -0.48853411036686983, -0.5133466226194598, -0.4723844025224027, 0.5808511415234843, 0.09335232695310881, 0.5258628611938456, 0.5886325495329264, 0.5331079054655298, -0.065537634498869, 0.45192981794486714, -0.2019131717903646, -0.5113939987134734, -0.10583360359428373, 0.47395389838159524, -0.008411357972903433, 0.27072330766939956, -0.24309845258982746, -0.5753575752891886, 0.009733136311422527, 0.06231059705322912, -0.4688815954339253, -0.13299644541011302, 0.45297693891431534, 0.10172209079400897, -0.4656696417868737},
    {-0.07314431219326363, 0.5413160558462216, -0.23992988678799293, -0.2402310328970235, 0.4601958444210488, 0.21990975358655038, 0.11330365058052809, 0.5589716580947132, 0.4927384416028388, -0.055402748674985666, -0.2973629466138198, -0.4254308001563673, -0.2172375351270261, 0.39608113960615976, 0.42071570930537344, 0.14418898502554897, -0.3313112983546748, 0.15547332393218832, -0.7081152270278455, -0.2825470949924938, -0.2870738698267687, -0.24024774596486714, 0.07111794549557171, -0.32729385005809764, -0.5286321862837134, 0.35217485940716686, 0.3441764039430322, -0.511376004743166, -0.0736035444402434, -0.6751109230105776, -0.12535716967129706, -0.41437323241647495, -0.2920354833997995, 0.16172449503975236, 0.3325751457778994, -0.3114774987118144, -0.20382066850977398, 0.2995047283186264, 0.09045467595536018, -0.5363318759354543, -0.11475818234465364, -0.14741991425017917, 0.5571460011897921, 0.2087184439909076, 0.4958434152811918, 0.4013972752380248, 0.38782113191097145, -0.09416773399085994, 0.3907810715475375, -0.00873644725623787, -0.28770560090162894, -0.41879519420591965, 0.8166442004356531, -0.14595012511939678, 0.3231870065194526, -0.2901706629819816, -0.5086139185610116, 0.15370003232901477, 0.21094001716306454, -0.5846739932889746, 0.002750620255306769, 0.40007422495361855, 0.28139399329776243, -0.5417677708926831},
    {-0.293597862021154, 0.43197115091570176, -0.4435263443095859, -0.5567276189424669, 0.6646569496999885, 0.4032248180804476, 0.3054517032943078, 0.4768354838951254, 0.332070507961992, 0.016978004007576507, -0.4385808756319843, -0.5380102459161165, -0.3070389429679263, 0.41476362672234707, 0.17468838215139545, -0.06559590775016619, -0.21302354795695114, 0.3322570382400847, -0.5516543886022842, -0.5216245890253214, -0.3708590994304389, -0.2967760489260758, 0.11019374417967084, 0.14221939840237086, -0.5744352605133036, 0.22901220996019658, 0.14511314077243911, -0.0233957990402098, -0.20880425608824477, -0.4648235765790318, -0.5156241792281268, -0.36171700253238226, -0.14003490498568882, -0.02089265833031368, 0.39449639697578404, -0.18765874433371102, -0.5515731914358313, 0.2509670872947095, 0.2958799154919668, -0.6516871128386995, -0.21352022332289802, -0.0708708832145011, 0.6948647489769256, -0.008657770950939224, 0.36382545518149195, 0.04832970054566674, 0.3905666877782511, -0.43286089890762103, 0.31410791943730515, -0.2055010876167928, -0.370204535230681, -0.10578593712071852, 0.49954637739651714, 0.16068475420946426, 0.24744799002126175, -0.235291708615806, -0.3034629694875016, 0.14289972330437561, 0.2687150272801964, -0.503594866545074, -0.10034646676841615, 0.5130484286519624, 0.23559927245321832, -0.59701228385709},
    {-0.004398681757934651, 0.49513250032758443, -0.5963030328843947, -0.42931108538829127, 0.4816163075706126, 0.13038969158782301, 0.2770368316434183, 0.40903663615820557, 0.543159154711343, 0.272457257716634, -0.2625050608136182, -0.6211589006647412, -0.03825083802841169, 0.25595732232710505, 0.42278581311199737, -0.008077419147821391, 0.07806285831298948, 0.2505686138436666, -0.4724821355422195, -0.6640537790170715, -0.15729762918243304, -0.40895331291223835, 0.004778747598718026, 0.23254292040689709, -0.5278701342325463, 0.31167109111843194, 0.25897205506435883, -0.030375261286978376, -0.05214073987228265, -0.392842927827924, -0.3719461269682718, -0.08576683855532391, 0.011796226178568557, -0.2682476912846454, 0.6249959756108717, -0.051922866178668786, -0.3848299987041514, 0.1375617220060565, 0.35847047365707096, -0.34857039163467757, -0.4341668905401424, -0.029231429717054048, 0.6920449789891464, -0.11095334425605768, 0.013040074933836583, 0.6315272571281619, 0.6010929146137969, -0.17948327215486176, 0.40979748871182875, -0.026168979414272417, -0.7052247561279125, -0.18763148811835717, 0.38106155356964866, 0.11669819430975407, 0.3143129615626829, -0.21108825447505833, -0.5364180518479893, 0.09495744117669806, 0.09407859875426222, -0.34344691775768627, 0.1617000960409334, 0.23385728454182683, 0.03855243335392646, -0.4061628347928135},
    {-0.4196860477338724, 0.6994616837266926, -0.7395239217194614, -0.21452065352723387, 0.5924499271281717, 0.32947671852888705, 0.267394671568723, 0.6219154489725102, 0.2736496927132521, -0.17333345643844636, -0.4019843734753721, -0.3419029527357663, 0.10598408315027807, 0.25224822025100546, 0.32628511696748524, 0.04039980314987841, -0.4604689461705415, 0.17385173652719074, -0.6969856902549572, -0.29513779132975115, -0.1434654899249436, -0.4367692521209532, 0.13383208462547616, -0.17168516848575183, -0.07990624555167541, -0.003320913314794286, 0.29713665244940174, -0.20717469766363428, -0.21703660348875908, -0.6030670211402047, -0.5409970902560005, -0.20918056563966725, -0.05856394241547044, -0.2527118381104034, 0.48425961416496677, -0.4238602341719207, -0.1689700092934163, 0.30483635545946186, -0.18224567262412442, -0.6190883507339763, -0.20573256499252332, -0.05125929517407317, 0.4607165360377984, 0.3023629213097983, 0.49716745308580346, 0.4512230359891961, 0.328655067370386, -0.37305080986414196, 0.12182881461610638, 0.059599805342462946, -0.3162639815125035, -0.10011593006761134, 0.5024135862761049, -0.08929553977943239, 0.14113589737329324, -0.07974700570308081, -0.5061996093704271, 0.051589926687039586, 0.06327040269188985, -0.42530612283896235, -0.0832257016639439, 0.26070262137518, 0.44449648402007014, -0.49072996836768035},
    {-0.05039554247405537, 0.44280007586360687, -0.4020024123629681, -0.4939562876362455, 0.42351164735099567, 0.5032277600882155, -0.04115660790834606, 0.41077399072620685, 0.1618381102727526, -0.2709328745146001, -0.5132140532814059, -0.6032328356651099, 0.004929199003099759, 0.19182986770687802, -0.14566484012503675, -0.4702973007389261, -0.4176980019078126, 0.5017304430412717, -0.5837942087067007, -0.5320816469922645, -0.20069005813132357, -0.41206718189335456, 0.19130851033478016, 0.16054992630884077, -0.41843146535796305, 0.14333167634708377, -0.1342505075468818, -0.5988736206179098, -0.08875198746684154, -0.5977349774130258, -0.3534764382710409, -0.7943460741845003, -0.1047639426832429, -0.25786768865972304, 0.4380857481147904, -0.34756328780314877, -0.4924775858481711, 0.12421992608066391, -0.006244821528930797, -0.7776822791874908, -0.5154044465070043, -0.23571698114880435, 0.568966125555081, 0.09139863488059208, 0.43871216814547864, -0.001366140232190106, 0.34987897499648185, -0.6347996702325917, -0.03877931859187409, -0.16999657824974562, -0.40853913220836274, -0.4205887482466243, 0.1775940245025926, -0.1809911300524075, 0.1769738076603628, -0.35583509496960297, -0.42860083983240543, -0.266834371982005, 0.27489382953765307, -0.6208494228483478, -0.16157394156091243, 0.5804853969061461, 0.25717241863770957, -0.4656696277673251},
    {-0.18414240782037808, 0.4501377097136509, -0.36300806884220493, -0.463569689026887, 0.1611495695161804, 0.41769467166734603, 0.34193220649383516, 0.42822212310953744, 0.13608617594305467, -0.003926157252299445, -0.5178814475115543, -0.5973684209591578, -0.027822363468869054, 0.001993752300649505, -0.10118199057988259, 0.08248564857001645, -0.2507724637404523, 0.3566861166035526, -0.5393319055914471, -0.49370755879596917, -0.4371751731277625, -0.34970183255010245, 0.280228156731235, 0.09709552790045342, -0.15350561232084012, 0.23186116307865318, 0.22721256507305124, -0.4516869481762643, -0.5783619183088708, -0.5580697551406969, -0.39424413738056086, -0.6131605807985196, -0.15137518127136654, -0.3139012498646688, 0.516192096093148, -0.3225968666785951, -0.42314088255465515, 0.11565296551399964, 0.1580192456389513, -0.6664398782137553, -0.09429571148756095, -0.34460104353333176, 0.6174500376047912, -0.3548248234177803, 0.4033475366949015, 0.29732324370141505, 0.5680563409748324, -0.42906261277678787, 0.2386549050725764, -0.2299293803062015, -0.6051449242417717, -0.2268530220635688, 0.4545945894628514, -0.19744214005718563, 0.0040213386379970234, -0.14470058823640136, -0.36950129384154023, 0.1714400552153254, 0.19209988982030715, -0.4287430864835687, -0.2605096218940879, 0.21117661235003737, 0.35826524790478614, -0.5711560442231502},
    {-0.2803827632363873, 0.716608495923983, -0.153565829058539, -0.3603703958130537, 0.6137047283953703, 0.10241986518946476, 0.3298536845016774, 0.523733837659623, 0.2509451504863692, 0.1700997378266875, -0.6974731661216231, -0.47460902241979364, 0.033178772558865394, 0.2439492562943441, 0.3268034516829949, 0.14556893768700208, -0.4505195115896175, 0.01665550881352777, -0.8579073335236723, -0.35289571562689326, -0.4964076593162519, -0.41885596872014963, 0.060528179786211715, -0.0922612253823257, -0.11725190524360762, 0.10528665955036044, 0.1020918155247215, -0.5874355427809208, -0.4043087811033471, -0.2537578782441054, -0.5133819973732641, -0.33733930269075546, -0.06375527782893795, -0.3959336540549273, 0.22958527537728285, -0.393935831216966, -0.650740483704521, 0.5308275989408873, 0.19082716414131667, -0.5964183097113728, -0.4717910098746947, -0.346885637747639, 0.5926899203465104, 0.018031356817831686, 0.3234351463115657, 0.23711947276507672, 0.4247323051987407, -0.24419034415669422, 0.2844386167648996, 0.03594999642243816, -0.400488776999839, -0.14599569699012757, 0.5115538012248988, -0.09436111765064319, 0.4447960331718646, -0.5823579211211508, -0.4424925232541092, -0.19877817047668073, 0.20126915364591602, -0.7769031981106066, -0.1337330320584297, 0.22856994689195345, 0.24731627186244076, -0.7551592139823446},
    {-0.1628604519814337, 0.7840086124866799, -0.5013538951585516, -0.253181643507293, 0.5331832753274581, 0.2961357794158642, 0.30082041320837644, 0.535185107660006, 0.38611474257213046, -0.22719174901497022, -0.4246337903189379, -0.3181472641622662, 0.3120354475087099, 0.346844718687932, 0.3125347661970191, -0.0207880128573844, -0.09955017992002797, 0.15682709272265277, -0.5615980077454761, -0.6145297925975796, -0.2820567549203755, -0.4813836489965289, -0.20408341052174897, -0.20643040622688713, -0.46792466722901555, 0.13861284649189923, 0.28864914745006814, -0.42413780346474234, -0.536610274506447, -0.4676883950402155, -0.19328568599640158, -0.7853230653734588, -0.24956951255841972, -0.4360032897010041, 0.3655385711615456, -0.5380600113853429, -0.7688560170329065, 0.16213471729943302, 0.2973933874669562, -0.7115283895882994, -0.22932254460066429, -0.5287395607828932, 0.7836553610688464, 0.1457337338187815, 0.4931171137265571, 0.2857430369131422, 0.6840149447151274, -0.4217014170551632, 0.29606213628288, 0.2055104619987435, -0.4515457059743728, -0.24581419233840276, 0.25343515311810294, 0.1713810675521764, -0.036516192603302626, -0.48696942898019746, -0.5081504110503139, 0.19488969786751797, 0.5752023892597016, -0.7217814762329349, -0.05525746694651375, 0.5250364899317103, 0.38247798215016543, -0.4422742914966573},
    {-0.12025097897164336, 0.5132848871707567, -0.34617486409083226, -0.41480826574106566, 0.5631732117864082, 0.31505122023829185, 0.4144248434691619, 0.559562636161236, 0.33489279193330695, -0.06066240705646092, -0.3317657520208128, -0.3319115390174562, 0.07122523229850276, 0.45437196895160026, 0.34927390029963207, -0.0420119713314613, -0.4923866510302757, 0.32643071425833886, -0.7803567140901487, -0.4820342181207613, -0.26860956920704093, -0.44179007776158574, 0.16144157565952844, -0.2813583329245956, -0.1864267451134562, 0.3412698531550175, 0.20103823756231706, -0.47190370841388884, -0.5238915192208689, -0.3334816400357037, -0.2608525087072192, -0.44190215670879945, -0.09108402617461137, -0.23726912806125455, 0.4524262556094015, -0.6007965424221674, -0.6721733118723823, 0.1359510545208399, 0.01559177306410605, -0.5505844443984014, -0.43358344003659727, -0.3522402796319297, 0.6024621080577038, 0.10124240514330728, 0.5021083701729606, 0.18084743687824284, 0.4274699522984328, -0.3865888469892843, 0.40130725480686813, -0.03833824092910028, -0.13614921407535174, -0.38617810739124986, 0.745605680834526, -0.2116485424347599, 0.4055503305022042, -0.40948187494364713, -0.22905901188275224, 0.5226746799806665, 0.026113441906295175, -0.34027282317320373, -0.19106901002248994, 0.41895170545130245, 0.48472267300840843, -0.546408166356103},
    {0.21825845324575013, 0.7427379505758607, -0.396484561092994, -0.3897963072676375, 0.623821922577662, 0.25036038523635673, 0.23680261641331862, 0.7358130589381763, 0.3996163268396249, -0.29989520744244996, -0.39633238166935386, -0.5170985376812157, 0.5231090653528095, 0.28330492079855507, 0.30504415770307075, 0.2089574438216846, -0.058082878619698054, 0.45022631942237656, -0.5280408337123698, -0.4580235331113222, -0.27615551236934965, -0.5833496834211938, 0.11222818272160147, -0.37011869293319477, -0.4994846921182606, -0.31112249413770493, 0.3701828690108547, -0.6078052423739637, -0.38213194509392867, -0.4109961035086791, -0.38373199831122384, -0.3886160631828002, -0.47325695545105767, 0.11281244964889689, 0.5639049713163193, -0.3107180468578352, -0.5060950333880668, 0.15348798416491308, -0.027623918537434754, -0.40243350579588383, -0.4086991663842236, -0.2550832013787974, 0.60187381057228, 0.10015191602247718, 0.40681386101702777, 0.26656754457181236, 0.7549868585816438, -0.585438179533608, 0.4640142998053853, -0.23145561646102664, -0.4034045368072851, -0.5980323564669329, 0.6064187471250007, -0.03283956495528132, 0.4030250196269228, -0.47625108041634306, -0.50796101007185, 0.02857388852746587, 0.4215975106695146, -0.20411223922258614, -0.16413774120922733, 0.4172160180272181, 0.4609436257782137, -0.8406390688657205},
    {-0.2324323173656268, 0.7166057559935609, -0.530957479694973, -0.5361519091092766, 0.6704768802338535, 0.4500145100715203, 0.04861713603946163, 0.6957324320451482, 0.4762123704769751, -0.11559274547662397, -0.45499798794508145, -0.5559664465337166, -0.009214489369382278, -0.16712557808046546, 0.2872082846365035, -0.3024077757976523, -0.1595565969506584, 0.1126747544790245, -0.5134006183564184, -0.4585038224359319, -0.5129544906142715, -0.4964927176815413, 0.11972194944521869, -0.8055679433862541, -0.48624904843232186, -0.09015094995820401, 0.5958285772856033, -0.6421193634725048, -0.34348144765702415, -0.5985637977744919, -0.4799349005062886, -0.7637042727228707, -0.30185878729659393, -0.02021449563468575, 0.29485061725331657, -0.3293984066236827, -0.4833939657910647, 0.00248390555238056, -0.2983628915007969, -0.5655049707411857, -0.1164707704325471, -0.42016772837753774, 0.49306951669666765, -0.16633954791865535, 0.406021009518302, 0.26979967258397564, 0.3963441681656185, -0.6717873349638303, 0.3017938380917605, -0.023011373111585506, -0.469572000727111, -0.48807412202193257, 0.3935726129739351, -0.19419931436033427, 0.4079308978668602, -0.5091689206704979, -0.5540341987174744, -0.11554291147173022, 0.29204423687280534, -0.5563933243831057, -0.22093387465363, 0.5314613496264246, 0.19692153602623033, -0.6135228375036735},
    {-0.42377274440525103, 0.3059102223817305, -0.5179139773080914, -0.6530645807477327, 0.7689539305907356, 0.349158907550504, 0.1356317009262658, 0.8519638266732015, 0.7316222820266454, -0.25271612602662163, -0.5942116271642148, -0.6770504569465864, -0.08661191942184271, -0.12018960502457961, -0.033848392133546575, -0.5250026932981162, -0.16031388767546828, 0.26901670253322424, -0.467136164050515, -0.1455633031917027, -0.5572617470839633, -0.466207777980238, 0.3992207480764457, -0.2915107513222897, -0.6256306268167201, -0.04263133028835695, 0.3491304278357159, -0.434936501271905, -0.404837517073243, -0.6463326812539429, -0.24799570157832654, -0.7340264840113049, -0.35512440360564884, 0.18124045771242864, 0.31073572565328844, -0.5804952866853342, -0.6680400539260106, 0.3029322716513245, -0.25302258407895445, -0.6035750098381714, -0.42052654044606463, -0.44094218993529577, 0.37772230711594407, 0.2671386388853355, 0.7462919075812652, 0.4242776513498837, 0.5925912503277894, -0.560816036305825, 0.37749935908141136, 0.23783474151787876, -0.44591240984492386, -0.6985583668352708, 0.6805341663207601, -0.38407755301077656, 0.42332346121611647, -0.20950678527236932, -0.4272697731765317, 0.08383873313230134, 0.3259184205677714, -0.5507932888783517, -0.03519254625749085, 0.5380559565372083, 0.18483313158896872, -0.5877487562812366},
    {-0.34045681223783036, 0.44917277974462333, -0.3602494641432851, -0.26470649792831125, 0.380477148833476, 0.24644851665906164, 0.0671996943215124, 0.8123325374638386, 0.44517879199715715, -0.15239318300290297, -0.3094109635470142, -0.6270767040050421, -0.22872820213952091, 0.14283649527766526, -0.3634108496201156, -0.3188898549542805, -0.1403025683125668, 0.4211912040366747, -0.544955424977089, -0.14784067221751832, -0.5363868524685771, -0.4771807073626906, 0.17703964777863865, -0.44245819905989114, -0.5486786963800241, 0.14076323841337343, 0.26225642193771004, -0.5380705541140907, -0.45694225161614066, -0.5053221854869343, -0.3231032049957698, -0.31797172716820127, -0.34446141936494945, -0.06083292250963743, 0.5427474170269708, -0.45580143479763124, -0.5237553205653946, -0.06552879307920051, -0.36048944923107745, -0.5921064046854592, -0.6727009861954929, -0.12046622381371325, 0.39517820977381973, 0.03650990145809332, 0.19761304875425195, 0.16933700531464843, 0.29909576462332615, -0.6116083000849314, 0.17040536388578315, -0.06270129734522142, -0.059184319488290636, -0.37489514816643826, 0.2921497686413938, -0.6493516621781078, 0.4898779967114579, -0.2561482305503633, -0.5223435308183512, 0.20014521411090272, 0.2707362463288493, -0.1907031475655597, -0.22005127059720617, 0.5011949741553542, -0.2924642636000904, -0.38507541447622534},
    {-0.404866788164362, 0.6187418213627537, -0.5025458001459562, -0.5762536325921523, 0.6415721257324666, 0.3556678318452929, 0.19391867327266488, 0.6797350942288511, 0.5831770409645046, -0.16510616307357773, -0.45549022712449433, -0.5638070209399384, 0.09094935848712205, 0.36066522678775437, 0.013209581226416413, -0.3194438621716053, -0.2631687541418033, 0.3715506846758732, -0.5224049504608687, -0.3064566864633342, -0.3568250707341871, -0.748891047892514, 0.3257214844030379, -0.39317811363791916, -0.42547929536444984, 0.03337372548990671, 0.7244640383941366, -0.33602431264472793, -0.6908048607516363, -0.6135299295801387, -0.18357196447646268, -0.3270033486611858, -0.3115956460849193, 0.028150911327207977, 0.5549427864761445, -0.9972447548944616, -0.662266706773254, 0.10365634108511193, 0.10276282325885569, -0.4782134073407158, -0.19751231560735147, -0.2631250306782863, 0.7529883232329898, 0.4792718156772343, 0.6279505359289121, 0.14997914970034676, 0.47778336477275596, -0.18237137923852811, 0.17523717093729593, -0.2835487460457987, 0.1706754690781103, -0.22010191669888976, 0.3952015838523047, -0.2719560683072321, 0.2352035860374408, -0.3079832658852944, -0.5491305646913329, -0.003994061118605031, 0.23819419250014523, -0.4060838640499221, -0.24241314995270133, 0.533953323528412, 0.012458606615667583, -0.5478156724446087},
    {-0.3932784788863568, 0.6223630895886993, -0.38948766459708206, -0.4912174600231985, 0.6290959489432516, 0.4928960669845022, 0.2883310190154847, 0.757453962939946, 0.693954562891421, 0.1774233347891259, -0.46600314309256324, -0.5235054690317177, 0.3820321889898816, 0.2561201775561343, 0.20220397395192669, -0.21621262081326148, 0.030300350525976898, 0.44336727419329974, -0.3331721456861679, -0.3810876376891357, -0.7235385887620163, -0.5194867935448655, -0.0011244907531342426, -0.42813222431565, -0.6361983757821954, 0.2946777760032429, 0.40445413587298307, -0.5282192291716664, -0.7325992176161417, -0.41100944931685107, -0.378568896472357, -0.5985661564311977, -0.3868147982195838, -0.26722795356466905, 0.5223305052224088, -0.3429607298143543, -0.6472981454871243, 0.11530827269771103, 0.17893421298409895, -0.3222009772010268, -0.17266292576527725, -0.6251931480491304, 0.8904396923447038, 0.23482306444295448, 0.6094784363245483, 0.28461274382800533, 0.7190340913436449, -0.4958282442015163, -0.18712378421333567, -0.07266652564245718, -0.01218321697857033, -0.020726416871594464, 0.3934863774124924, 0.0020047365005455182, 0.5274140365272018, -0.41336041209650926, -0.647053687133405, 0.29513825709434516, 0.22741136585146712, -0.5102784786925769, -0.5652316550218488, 0.5561436083952436, 0.3214392398568277, -0.7239203094133568},
    {-0.5209617385677786, 0.5838515903074446, -0.3371640727617612, -0.6513075632196771, 0.5445893476723065, 0.25547343352359025, 0.2715669237124013, 0.4641273107760914, 0.467970860623709, -0.2777417519011288, -0.48056252874391087, -0.6167751195445612, 0.7864535511993912, 0.19529209810478573, 0.2842457898410025, -0.14868475715475, -0.28081629837718264, 0.6845839940430212, -0.4371623278750364, -0.3704511873866093, -0.2344820852774967, -0.32976233257705556, 0.09199069593016733, -0.3734417938919355, -0.16305888100811858, 0.21053549476012173, 0.365514119738785, -0.2651015663058563, -0.5813252408783297, -0.3897673978266543, -0.28310745070635746, -0.4751670657402552, -0.568423056761581, -0.24045703189659226, 0.5331241442126303, -0.5591268420253571, -0.610068295199003, 0.47112023050950363, 0.13432033123402415, -0.20548117379680342, -0.6502086285511568, -0.2946243159504717, 0.7293330272887059, 0.367099214527145, 0.6445464816636742, 0.40999604505387355, 0.5883272654428454, -0.5418571063917705, 0.19480910867232454, -0.43636758429922534, -0.16779958941680886, -0.6651327123296484, 0.48958955824198747, -0.25615041662045457, 0.3209996506944522, -0.38835766583446163, -0.6240382473152721, 0.3641471339653685, 0.2994027686282194, -0.6795010428099925, -0.4688946775216265, 0.7927190321567276, 0.6346755934764222, -0.6596691448622048},
    {-0.26837974543599236, 0.5157057362761622, -0.2511672617645054, -0.4155359239662686, 0.5388566623365277, 0.3622592057064688, 0.06713080339475364, 0.8579809600194682, 0.7711072079537028, -0.019162617913882244, -0.5236684325691011, -0.6350454146624426, 0.06622129532291644, 0.14614249592787612, 0.177095623321956, 0.1674709399854085, -0.4686615007741143, 0.7682955209114272, -0.4924672193716746, -0.40043937907322497, -0.34259810664816753, -0.5170130740612982, 0.08564207633653688, -0.3076693707802852, -0.32569415510503996, -0.039552078560179546, 0.5997984114342975, -0.4609191114795519, -0.394027460470386, -0.7135940051393037, -0.4705151266373524, -0.442092509394847, -0.5475164983160388, 0.18290987571685566, 0.5114480418848295, -0.3987939191900272, -0.5663399068901757, 0.33194300728487636, 0.20529331590601851, -0.5881572675374718, -0.6436659132616505, -0.23671501199423003, 0.6794712022297721, 0.2520354604540968, 0.19979460446075084, 0.37829428310651936, 0.24972139553720282, -0.4313336837705147, 0.21075063740496308, -0.5982266938943767, -0.16531021046735295, -0.3638623626697495, 0.6684158957467226, -0.3449534726569709, 0.7906505524413251, -0.5324578258880591, -0.7444715196804986, 0.18986074553150695, 0.13967934224224665, -0.43177092088853297, -0.8754808879722468, 0.6017096978697171, 0.1324604010935388, -0.4052616272251167},
    {-0.24874521604064684, 0.717144588485078, -0.3954621337071919, -0.5997166583559237, 0.5892224119565747, 0.32373101853556113, 0.04526826884751869, 0.6195897803980598, 0.49123120807698534, -0.05182657555459966, -0.4394279662634977, -0.37497722017704405, 0.03463674660513529, 0.13581594748547524, 0.4725559888122675, -0.12362108443838679, -0.1963681931444995, 0.46225855067961, -0.6411924841295332, -0.11016509840001308, -0.4163297650582755, -0.17619855582081892, 0.37950781744153683, -0.5575443417896551, -0.33677480366184676, 0.1958687827873766, 0.6070637114216261, -0.5651138101965892, -0.3358751824180173, -0.6681554278464744, -0.05920742986562057, -0.3694903159760458, -0.5082642251396947, 0.2079252363241434, 0.5149580316776943, -0.5193028474413182, -0.2784891677445383, 0.2738645433082636, -0.029802091710671615, -0.3353366326704427, -0.1575705927174671, -0.3628011975011787, 0.5356790455209088, 0.008529896082515068, 0.43182550951933235, 0.23474879399718623, 0.4613149040295898, -0.33133705922783935, 0.3019859410329407, -0.28451171798875374, -0.29109560180532545, -0.49733812668942107, 0.6046330413298292, -0.24924589016130733, 0.41633815028774546, -0.5334167080856242, -0.450657005582792, 0.460753473134572, 0.5157705559123118, -0.5402882894167668, -0.3555537789733238, 0.2758292295149996, 0.2976008970969636, -0.7628354135851769},
    {-0.41011905164170653, 0.5554008421293469, -0.5094803639760718, -0.7224722392196025, 0.2405233256182104, 0.11171899011816505, 0.33928426616813134, 0.6524079400971463, 0.33086382363123196, -0.21983530759164213, -0.6296120048284474, -0.641027922249031, 0.2828894093368291, 0.12901133916380225, 0.19565557760290175, -0.1866778350895795, -0.11339373257035226, 0.5735774903082723, -0.5871029760851855, -0.37043509190288765, -0.5246803837493977, -0.36804620768951335, 0.2920641125591649, -0.22835812641575207, -0.0632871094431582, 0.007396761842712678, 0.3546396195294765, -0.31926452431297603, -0.44789555962686906, -0.5511658316117756, -0.4957020617115519, -0.48430365830713, -0.40105517439509497, 0.09951186626454467, 0.5272396943828874, -0.4604329593362368, -0.36921733956867864, -0.1696427936182944, 0.09908615543293976, -0.43969070643776814, -0.31224104445114376, -0.38387531682432374, 0.58561685976441, -0.024183709345422622, 0.5314592732613345, 0.07072757595078942, 0.3781933471658131, -0.3967003753138639, 0.06860087757033054, -0.3228629916169649, -0.1933217971965504, -0.3123946663923019, 0.6366493579785889, -0.21373765591492774, 0.7357637690803971, -0.14785367837972532, -0.3761089702049663, 0.3063401603580736, 0.3404076978214939, -0.4342881707042362, -0.057371470837990816, 0.6230490783727962, 0.38995030372931927, -0.565975201170907},
    {-0.5256849507093051, 0.8298596732555236, -0.4973804618042749, -0.6125435242691166, 0.7132844646085937, 0.3540935493854708, 0.14180761571694844, 0.539006138631062, 0.8190189710184347, -0.12376433204700729, -0.4301667082753183, -0.5835364335156777, 0.47050844298183264, 0.13812076020705702, 0.3323616157084236, 0.09211876358465367, -0.02040974976736036, 0.504308151125159, -0.4919868290296869, 0.06110158206009406, -0.5679960524059549, -0.5460265847768204, 0.362673722332644, -0.03982775176761039, -0.4957012268722488, 0.12313281475129789, 0.31137773407465485, -0.27902157560700536, -0.33715003860349424, -0.3900204258987534, -0.38115231261185595, -0.4000999314486743, -0.42581761021099995, -0.02037887450070091, 0.7861033247276965, -0.6658101908173766, -0.4500562809525716, -0.06661565268642611, -0.28805661798999493, -0.5663982376515452, -0.2918358271067988, 0.05829516976351666, 0.7030521171898825, 0.4678078012241022, 0.7367085797467217, 0.4366050754338905, 0.7644683785632937, -0.5679223713329897, -0.10563844383017763, -0.3187193042396222, -0.05284033238827742, -0.3684976941828829, 0.5673717358999394, -0.4158483062555486, 0.768108316910299, -0.45711510657991766, -0.2559963929642159, 0.764166953067432, 0.2338142756217945, -0.5763105238066978, -0.24858154387991996, 0.624080553572144, 0.1414234777309856, -0.7287011950067457},
    {-0.433048408140571, 0.781631681239292, -0.649394891279856, -0.5766749837283353, 0.5283758459101554, 0.45127163466055464, 0.4870556199015392, 0.6984123908282495, 0.27917593318562856, -0.34142476884491657, -0.6541140865767242, -0.6630188522244803, 0.2132282932619421, 0.15063557667787952, 0.13968325137063287, -0.15328985680353008, -0.07739549150951171, 0.7006316461805294, -0.6042301061474077, 0.07871569361772071, -0.8517574606885585, -0.3993781999849768, 0.31620505362565027, -0.282064109219798, -0.5341886811064058, 0.0753794015137217, 0.45858552402933067, -0.42895518858844617, -0.45398621846995857, -0.5336973752477693, -0.8090488871350399, -0.46904384397851256, -0.5433359560289598, 0.03672185014900385, 0.573296179703999, -0.6167872541364445, -0.2622802151041051, 0.17862734798063412, -0.021806962766035158, -0.7505040859203236, -0.3994541866757174, 0.01068563430748263, 0.9075474255791164, 0.4598190819760698, 0.6873100653509556, 0.47764561368359937, 0.6056762532228355, -0.2603421377858144, 0.36480554444587926, -0.17011092423528718, -0.0979633982435131, -0.31916451511462895, 0.5843962343609117, -0.19415732578500727, 0.8510844012222527, -0.757229334354701, -0.3898561339321128, 0.3861140818516558, 0.15484253403366444, -0.38005033817165396, -0.42118015744414405, 0.6214678540061893, 0.17775936744582266, -0.5763322389384263},
    {-0.32663994831801885, 0.7452250967669124, -0.5710240575065321, -0.4493986948001864, 0.20582968323272563, 0.46073684833592254, 0.08377527601125478, 0.7285427118441422, 0.47988628132279304, -0.216602216663084, -0.6575903887171047, -0.42005655222677485, 0.18438040164589234, 0.391159308266114, 0.2580308314845148, -0.2807997979283942, -0.2258172195976191, 0.21761510275677237, -0.6441797141335235, -0.18099728958867736, -0.45692949982253805, -0.7385640656670928, 0.402996363478504, -0.6519764056940478, -0.4069789380015058, 0.06403089476559065, 0.24809781323823535, -0.5852195795326484, -0.4367122041518951, -0.4838891019495662, -0.5701851582156684, -0.814205549600759, -0.5862458918019643, -0.12830965853092866, 0.7013013980745728, -0.5669046408202967, -0.5418151945007491, 0.3276758491829926, -0.23845796198065597, -0.5249089885607972, -0.21010395080361152, -0.03692233558629193, 0.8708792958308115, 0.7309079162806643, 0.44920409558185437, 0.5538338879112379, 0.46997574715989415, -0.2560223069694473, -0.22058831635316808, -0.3882997859804729, -0.15508572231729809, -0.5527217644507735, 0.7103871819850407, -0.38193663261182964, 0.6889228278345253, -0.7820772184026267, -0.5839723300893647, 0.7197808363086665, 0.5156293341980895, -0.6749253338210944, -0.6145962518713145, 0.6225009101151233, 0.2436980821743526, -0.5129474641740548},
    {-0.4963183662123898, 0.7447905899783644, -0.6391757467567641, -0.5427087820324703, 0.41658432267112694, 0.259470944803467, 0.143044930413973, 0.5457587768069383, 0.6571634916874136, -0.13973137073356995, -0.5506578260878313, -0.49324486381602556, 0.15552482207042356, 0.26029959110418255, 0.018627351988367506, -0.2365625654778952, -0.2672573987101893, 0.5178659596039239, -0.4685976536486189, -0.06963270051662826, -0.32405988550724407, -0.5617132213813536, 0.5009261179927396, -0.274238542906521, -0.41004019665656627, 0.03653048454986504, 0.643147300016547, -0.7163262974188134, -0.5863787926191144, -0.629570547700316, -0.5613295410509013, -0.5965566176227681, -0.4028594103336078, -0.1861822750320236, 0.769567585974622, -0.6808361062614309, -0.5112348508083625, 0.3120005073714276, 0.18163505343963726, -0.47184837846592853, -0.18002336804167424, -0.2898824890048726, 0.791260210423431, 0.33660451356875176, 0.4849086039669195, 0.313994325957628, 0.5279320118796664, -0.7106818885368714, -0.051019491442613085, -0.193214829967864, -0.3416561163335941, -0.52333631595169, 0.7378781760710287, -0.14151904346524066, 0.4912813088980934, -0.33769049333241363, -0.16915035817542584, 0.3415153494708516, 0.30184856143806477, -0.4789097264655239, -0.29079243546509, 0.3845962445822888, 0.19089444613979362, -0.6265397029972287},
    {-0.010248143443702033, 0.7489303709123284, -0.620375916418099, -0.5489133047836687, 0.6192214411371829, 0.30510119365490046, 0.2756963674726494, 0.7414095061517402, 0.6380413720742779, -0.30209120664275124, -0.710952301702108, -0.8785841467443922, 0.3358846380149167, 0.2862829811225111, 0.013047313580484736, -0.08249776650143784, -0.3308880322299877, 0.49977879227001876, -0.5542643368600854, -0.3966352014057197, -0.5974107818991011, -0.5613560406271638, 0.3032031345436593, -0.6774784559456895, -0.386855858707833, 0.15278944075662115, 0.6311899530440099, -0.5356935922058306, -0.47146194111618966, -0.45410279403360476, -0.514592771635929, -0.602493374010523, -0.8631991467816688, -0.02293635799358846, 0.5265450475107919, -0.2674327975530012, -0.5411388921693719, 0.22796768889311664, 0.0393649971908456, -0.7698226469575514, -0.5296853076231167, -0.5718663761421398, 0.7469044803255698, 0.4108977744830754, 0.46825442479690127, 0.3349264672455975, 0.5975214422663426, -0.530307117519375, -0.1237011144738682, -0.04967233594252515, -0.26083453400042, -0.7063949259164248, 0.7910539845237016, -0.3507932401655893, 0.657210488627505, -0.6990542988082266, -0.5601915681925748, 0.6514447735360407, 0.26206623657537614, -0.7429559459958741, -0.4178592051659273, 0.5546600105321465, 0.13086518346619053, -0.8010591958337459},
    {-0.5254717138027687, 0.8497423758293685, -0.633954842056592, -0.6513137164572295, 0.6045303821244251, 0.4232214469153311, 0.05921256201609518, 0.6290336609475708, 0.49065217557815155, -0.34897547824187103, -0.4485965122774405, -0.5050336821629019, 0.2128290634526266, 0.4382077730645389, 0.05365785938927659, -0.0291007908054941, 0.09161963816390227, 0.5775206541469151, -0.4579537054904093, -0.2952158208263768, -0.418548877293095, -0.48677570222640065, 0.004212247361293291, -0.49802410476879705, -0.19991403129465907, 0.22456635235114586, 0.3150666798122776, -0.6507967913178055, -0.7825748566684241, -0.9338537705568798, -0.48445521724372964, -0.4529086616308006, -0.3120604758648164, 0.17633387749290536, 0.46433391249611067, -0.5492345822332226, -0.6061011166953276, -0.1123394564550728, 0.0005290837988311508, -0.42934899871356985, -0.5616280596359459, -0.3543900024023322, 0.6073375273478888, 0.40260499822857354, 0.7500195268506946, 0.39585366781706643, 0.8981092591952122, -0.6412202553431057, 0.020126307388452527, -0.3739022453252347, -0.3691818606635687, -0.3469700123415076, 0.5333640165135818, -0.13584667848509618, 0.8377466262753608, -0.4281609134271755, -0.477070998123556, 0.37089613632472607, 0.44677924685077774, -0.6312967328773081, -0.2814299696202006, 0.3652012266317809, 0.2381795474728726, -0.7970787230288486},
    {-0.4332141282471377, 0.6065684394085937, -0.34533954997249333, -0.4882005971124755, 0.7721217471463686, 0.4240079952615111, 0.23399003089445003, 0.8304731684462132, 0.6317852040916794, -0.399906423616634, -0.7097113183101188, -0.5766700535029335, 0.33168687929543444, 0.14189739707845317, 0.1363533604050999, 0.01157741015448447, -0.10725629973391818, 0.6611654116823094, -0.5861895255961505, 0.006591883325250922, -0.524288680543804, -0.7616168036500196, -0.053488114603646185, -0.3569674632335315, -0.7440809177256043, 0.11583047297277335, 0.6289175940426764, -0.4161677675022046, -0.6609597328526473, -0.36786343541940913, -0.34463186422013586, -0.6824826720019239, -0.5578040666981408, 0.22222405171368811, 0.6812758198986736, -0.5568765044756091, -0.6771401852187502, 0.03636166879785298, -0.32474057139372403, -0.5487391277516148, -0.4160831208811031, -0.5870661570603428, 0.8164192435924456, 0.3133490349330385, 0.5395253664866275, 0.16979026998079327, 0.7023233668780359, -0.44763787325475124, -0.09553637635537834, -0.2999957348896801, -0.29657557078655156, -0.24983053755443663, 0.32029634243116967, -0.509447932865741, 0.6640858039386023, -0.922819840634145, -0.5251020638663674, 0.4731320077136572, 0.20172949131996623, -0.42818256808822164, -0.45143412112357895, 0.48811258089578696, -0.1721886897277861, -0.6289480694925222},
    {-0.5683898497969796, 0.7046623783445286, -0.42324653377415083, -0.6094389928106948, 0.3971656164920827, 0.6637254006025279, 0.11833966935422818, 0.6444492505524179, 0.9247366978544479, -0.4669054932070427, -0.7492508666818717, -0.7506796043598231, 0.3952912863530045, 0.018524988347749037, 0.37154910259926494, -0.1694229915680525, -0.12871014853033313, 0.46012629786526194, -0.6700162930507356, -0.07883805053529323, -0.6462583798061519, -0.7482183714526616, -0.1893997410831799, -0.3585083526653881, -0.5996715253019587, 0.11353203992370975, 0.6546653302930098, -0.3945134296251453, -0.4039830425964691, -0.5888361800758328, -0.6581666815802513, -0.5948782020856868, -0.382736932685304, -0.03797059410196553, 0.43286961415078834, -0.38383200428490943, -0.6475152801260982, 0.13909519349696337, 0.07907112221947299, -0.5603007496549581, -0.2943523511052561, -0.2972740824388495, 0.6023968895683827, 0.49700968884742697, 0.4029576812362035, 0.12638581568173754, 0.4175261511168008, -0.6776070478213472, 0.2120967462160349, -0.4465338850393601, -0.5334705380627701, -0.27276439905619726, 0.522720167149601, -0.1615115454516209, 0.24552610400671937, -0.46972741371590854, -0.4542200228561092, 0.24812356296849974, 0.13004871310775085, -0.4595399494872011, -0.39375767982654647, 0.1990531131099336, 0.11642370178096602, -0.39736161036501083},
    {-0.5770247363796969, 0.6164267640298106, -0.7111656913573259, -0.6787840771889837, 0.496243531330372, 0.4007576713488599, 0.19756064591002034, 0.6269092489575834, 0.4770017682378525, -0.2500138182395288, -0.6209472844288931, -0.6846857949761089, 0.5167401791204616, 0.1427506908205523, 0.2135632968519755, -0.014273745781958311, -0.07436372624261198, 0.6228298183725491, -0.38712584006287454, -0.20049976027166355, -0.613760382876816, -0.6081166920703159, -0.22695281636094158, -0.4877247294009569, -0.6131862064923824, 0.08981961769586409, 0.3290404031654532, -0.475927449432137, -0.5996829168997289, -0.6678545635993414, -0.29013502628256976, -0.2964093222436015, -0.4565733001367456, 0.14950112994580547, 0.7006813880114127, -0.32490589522387503, -0.18873788891963902, 0.0585434216696529, -0.11906951845140527, -0.58914750312473, -0.6686498904695709, -0.45049260245940836, 0.7835524282540733, 0.17086979339191438, 0.5208210816502408, 0.6290924969049693, 0.5661034911949261, -0.8836384738108488, 0.0017419930480253195, -0.3653905383263845, -0.11119384452192528, -0.26782783682584244, 0.7740949411289494, -0.3759552637286071, 0.7233825074695532, -0.7429490934189988, -0.5204832861003577, 0.583641716251837, 0.49166640606057205, -0.684319953571562, -0.3023178504119593, 0.5088149405410138, 0.05239699541936854, -0.4428014837818347},
    {0.006048024622489913, -0.33617109285908175, -0.2598322809562923, -0.2571489137837574, -0.7011856127826098, 0.2078785208665526, 0.07021401345844927, 0.0452564671637745, -0.10937220970558087, -0.46071158189729505, -0.2533622038991704, -0.2707538009530241, -0.5934169035734485, -0.23681330521584443, -0.5149190224706671, -0.5797693756108295, -0.023961751509330914, -0.55534048825248, -0.17448224820838373, -0.048268509667471406, -0.648654147907717, -0.05258383231122536, -0.4257683436929962, -0.5922281833196109, -0.02548121748205146, -0.09034273459981813, 0.04567636882686976, -0.6651093184681178, -0.38220390120501446, -0.22411124916308608, -0.5831056913584908, -0.28573348094015344, -0.12836584761219985, 0.0630629582453967, -0.25404271594684813, -0.07739187108676204, -0.18419229833125694, -0.24199053367717516, -0.4254266566108864, -0.649638162694211, -0.52058980169301, 0.030856650098095108, -0.5522464400117351, -0.37706292975331923, -0.34696029872587897, -0.168913465885649, -0.42714974497265, -0.4241942598559013, -0.6263514615185866, -0.7369295301688257, -0.5942426600396878, -0.3526747687375573, -0.3412192865142096, -0.2366578810518216, -0.4672135070490641, -0.38851601164301125, -0.4910002829794597, -0.8188189312400449, -0.581140561563303, -0.19932177477088084, -0.08467507730970872, 0.06360331942543955, -0.5052865939537978, -0.14165946842999072},
    {-0.008078296056386805, 0.23526630648249675, 0.04575059750052967, 0.08688328681753228, 0.1303055055825263, 0.27057056354104264, -0.20566390684377941, -0.1397701943339265, 0.18319046238029082, -0.12256786724600462, -0.2041343140976588, -0.002102372557361069, 0.3878644138244058, 0.10351895908214122, -0.2770829926213239, 0.06485787863653268, 0.26414777745798435, 0.028583581001691026, 0.15426036282290825, 0.7381561092910066, -0.16688043396852992, 0.15140385675251664, -0.10142155290469004, -0.09496737473318914, -0.2052213603024831, 0.05829393124037593, 0.7158374655797378, 0.4943059716289962, 0.4164762634821126, -0.09590889582899875, 0.45151071600796844, -0.17095678689089946, -0.44786793322996976, 0.30051251720814626, 0.005401721125049472, 0.2741745950333273, 0.08085849370218111, 0.4802209030247999, 0.20081792439739476, 0.0786999107159347, 0.059190344401447846, 0.1734881601601003, -0.07050453975310923, 0.14530697137794452, -0.1593492137231752, -0.20130533736320183, -0.04016163407783947, 0.15092492955096226, -0.5469279129369136, 0.13513362105046556, 0.11345084000468907, -0.21528470767507898, -0.19806544368264353, 0.11605765641565441, 0.06158920163473925, -0.2648998132012905, 0.011800378304821673, -0.43577921566091193, 0.1871080508093386, -0.17171824783597048, 0.11674796607257786, 0.019984648250419325, -0.37894254465293725, 0.3262973453674313},
    {-0.2145308703862245, -0.2981055803535455, -0.5172286454552906, -0.299457845306705, -0.12367766781622011, 0.13989798353805316, -0.2830116890196261, -0.46420265928517307, -0.2756154587177208, -0.3535693904788125, -0.3234649229394943, -0.11673507578455206, -0.19486162747860306, 0.2878697380964137, -0.10070683905807563, -0.49225923011253425, 0.0002694837712413416, -0.5863560742975937, 0.03303863993594336, -0.1709900652996634, -0.42120750965798426, -0.13785818780621553, -0.7250076411659205, -0.5188111585761987, -0.22316878333220044, -0.3238150528613051, -0.4363301397244087, 0.14576882822040715, -0.21414249686918094, -0.4743496812502252, 0.11826002821780576, -0.116268130743713, -0.773183571221889, -0.3602471752537613, -0.0360752846966331, 0.1043832608085457, -0.1642502479829795, -0.07968939449574035, -0.3497891652693596, -0.05849146456013798, -0.6067216417503475, 0.2490376267251288, -0.23986707545282762, -0.06608671709552415, -0.5043180129001911, -0.37608013219356146, -0.17954314492800977, -0.47905083443842683, -0.1721166419756669, 0.10080119645296014, -0.29657707365211994, -0.11479633976596705, -0.6125642668084518, -0.00797874625180123, -0.4267052386331994, -0.35742266583851096, -0.37966414623530953, -0.6063293635865917, -0.5672061433266222, -0.07224258453010138, 0.051886110379675825, 0.12478046877258399, -0.6668640803013676, -0.19906650485521765},
    {-0.3519473397338059, -0.3465768659115121, -0.2938484246205122, -0.4426688956085712, -0.029878361533203814, -0.011356190365359155, -0.5110078806955156, -0.03489844339038633, 0.05615561199589779, -0.2987230711051922, -0.3461277625889282, -0.4056004090342095, -0.38039039239525546, 0.15245593351606013, -0.06496426399938023, -0.1978588003648196, -0.14594995457342977, -0.6015139749258265, -0.1414860383545642, -0.01161436873678431, -0.43947392261469787, -0.32016878809508864, -0.376264953986684, 0.009070950920828722, 0.14340020941307863, -0.2400936595901779, 0.10495010280779657, -0.18837082789264795, -0.17285164905639339, -0.07754055679835634, -0.17483429835208764, -0.21268873623179824, -0.20693941304264285, -0.39728557451030544, 0.02020907131566545, 0.14239372716073137, 0.058219644727397483, 0.10522677041409279, -0.19142100224376601, -0.20570307502296653, -0.8128900167884435, -0.1368265145494895, -0.3078389034511513, -0.17433222993344077, -0.3357715510262099, -0.4045025955216746, -0.3230790960903417, -0.2816843763723775, -0.3916187851933223, -0.2925322630832495, -0.4586763383450532, -0.4878436943194321, -0.31210230954625295, -0.22776984406282924, -0.3718846765483646, -0.48653467742580186, -0.3494825698229111, -0.45291404232534327, -0.5253136620752573, -0.44698613590701985, -0.12856942307320735, -0.20389470448441377, -0.3813723415351689, -0.16479424598670375},
    {0.05169386586461811, -0.26944807765707757, -0.36513519434464703, -0.48881548900626026, 0.27220262552510743, 0.10983352076317401, -0.6701987713261315, -0.2780563038805526, 0.30696396825528305, -0.14847713868835086, -0.1831056691871383, -0.09010936386954375, 0.17500336674944833, 0.578413451311256, 0.22539281664535443, 0.002542199620895703, 0.08056178615289819, -0.23603411355755494, 0.42172182976571587, -0.23611573699520874, -0.4459912966699455, -0.37218397628326594, -0.4634214408857013, -0.10280809574383842, -0.48524783262052623, 0.3819142337454457, -0.45420331089836896, 0.007460720425729024, 0.28660568299596006, -0.3525220745548947, 0.23846759940928694, -0.4730694118658168, -0.6078341314350777, -0.369920561471738, -0.26809568816753704, 0.08678580626567813, -0.4504990386736509, -0.09457596427902083, 0.5364572737531874, 0.1741971365094442, -0.5580307351490272, 0.2555212235095955, -0.19626463179163628, 0.5297009834930213, -0.5182228246908449, -0.43121700708820093, -0.09097467285560354, -0.24993176087493904, 0.10756392006848346, 0.12165514266873342, -0.23622501978099247, -0.508414088165281, -0.19220886569140613, -0.238220984092252, -0.4470134668699433, -0.39150303859848823, -0.603603365196017, -0.7044198504689116, -0.5340219605285557, -0.25290312285849126, -0.04660839733641267, 0.21635657376342515, -0.2129285793343903, -0.11276162285597244},
    {0.08613039175646205, -0.15819752828059555, -0.21030372070521192, -0.302382196400447, 0.29159876366795995, 0.047712536322074034, -0.9920077029169628, -0.35083099548090063, 0.12909135544748582, -0.47534900816770176, -0.516640730709093, -0.42295260635971366, 0.043621844102423445, 0.4119459234124191, 0.148271891689686, -0.20112973671551923, 0.04565597278773807, -0.5596151398643866, 0.20974814542378534, -0.17090192670231844, -0.23364502551298236, -0.6002187301723115, -0.2945368843974785, -0.525687545952412, -0.19017338901473466, -0.023094191164846185, -0.38003702461220745, 0.4026691572675544, 0.10134803893777732, -0.34208087056273107, -0.16003308735926117, -0.21690268589882705, -0.35982084877721865, -0.6005607416496949, -0.09937625495209931, 0.24708117852198794, -0.3313642867910624, -0.13779382078124056, 0.12338004751772533, -0.1467122234674177, -0.6025998789943628, -0.0025682910120659996, -0.4816162972213054, 0.2222518977668634, -0.5799067024216837, -0.16322942390135006, -0.044942271490706516, -0.2759979005235944, 0.09690700927017985, -0.11575600772539527, -0.3406846905331517, -0.23606853287936533, -0.5071886011231723, -0.6332997640164935, -0.4225528421526032, -0.5071816783261232, -0.31797266702854304, -0.6257469457812627, -0.36612158892006136, -0.2537704185052658, -0.3282564305778682, 0.2858365725715965, -0.5240989188261961, -0.3072059239260239},
    {0.43768593763006747, -0.47519311725904856, -0.2305873607398502, -0.39009263621019236, -0.043285144878734166, 0.12114958149845528, -0.5532983748941153, -0.58133428811308, -0.07205372255061927, -0.518174742805087, -0.4709593594731093, -0.625211326898639, 0.4024239111634171, -0.13520696331898252, 0.2550186383723516, -0.2904548015155063, -0.04175957242841737, -0.6029823458728286, -0.11038431785586442, -0.33516418172854345, -0.24811445912779778, -0.6927286670324277, -0.7751512801297892, -0.5113712717472468, -0.5193143662017765, 0.2720125472015388, -0.19558469953195345, 0.07767049338592368, 0.17063655089602162, -0.622981462732892, -0.040437249210147456, -0.33753592880606853, -0.4015951150281361, -0.7301142314898995, -0.4620305942534722, -0.0004337421949948054, -0.39499747980655925, -0.05749237446144394, 0.2066988198772368, -0.32614669805439145, -0.6858184636168646, 0.1747619974754102, -0.3443397127067786, 0.09283018467744139, -0.5613196194051505, -0.25507440199226383, 0.09102062015284183, -0.5926405020611941, -0.08103399262738903, 0.16269561074355227, -0.4838311123757918, -0.4208678421733357, -0.4695050937277291, -0.6613016059049672, -0.3022172345627989, -0.36204788964590173, -0.6310734174357683, -0.4743397751929989, -0.23749032420055385, -0.4641414477428716, -0.4495016949623549, 0.1953590028356796, -0.35368855303679814, -0.27113258112376243},
    {0.11178569665630457, -0.16981806283786005, -0.5490867376317574, -0.387854517319967, -0.04559536634380767, -0.26095036461280463, -0.3267763383275736, -0.8179553023977153, 0.003739739801054792, -0.15970202344591722, -0.464067466696811, -0.6415442546428438, 0.07254802219031886, -0.14708227442704197, 0.278850255732916, 0.0955813065019888, 0.13398635462427055, -0.48489198527527416, -0.11776988846662183, -0.14961466640424348, -0.7715403679613131, -0.408407562095193, -0.614319756580567, -0.6146010248169913, -0.3433143899203841, 0.007356184613972364, -0.33394218225302197, 0.07556111569244035, 0.15251647911330293, -0.6379099298553529, 0.04803611434695464, -0.2742777241029647, -0.3820780319430674, -0.4076326874564835, -0.364314271827226, -0.1771819450795003, -0.20633960332007556, 0.14445732878162867, -0.31248376115747933, 0.06211966382197893, -0.46154102082030707, 0.21216836346297252, -0.1863984286618711, -0.2443716871982153, -0.49721520538714825, -0.6063015025454606, -0.2645049776988061, -0.1622789614218984, -0.23648276875771948, -0.008256832416495746, -0.3245974371722467, -0.4651296001091133, -0.4108303235012072, -0.11819054275285586, -0.47688994378248756, -0.43850637923112384, -0.20513486003406856, -0.7023243514922323, -0.30985368800373436, -0.47112374413021096, -0.4052877620811068, 0.2967177651437864, -0.36490233163988695, 0.008654578999708517},
    {0.1564739919875883, -0.5538161508235108, -0.3769413094459158, -0.5281116143786712, -0.02714724095109638, -0.287912012921403, -0.5260648505642839, -0.492006066718401, 0.10165029748488649, -0.5502777499996153, -0.4372208828157261, -0.4926468122528704, 0.2572592588413217, 0.3769129690304514, 0.40505756589087283, 0.09070781547518622, 0.2790563856708746, -0.6517540023538247, 0.4077212228467979, 0.04933613897701709, -0.6117199235449023, -0.24008413720944516, -0.557401016579821, -0.38397101143138573, -0.29720666463623235, -0.04319950912604809, -0.5902339396371602, -0.1648619351204113, -0.1546198995923583, -0.36333612856258557, 0.00844900941085638, -0.40711194385281535, -0.5351448957678846, -0.5803480395830989, -0.09931285836919587, 0.13050053445152712, -0.39153563635050276, -0.12427831322570784, 0.07626633274727831, 0.2676713601585844, -0.2401856483956125, 0.2521436354656554, 0.03833085574974264, 0.19798068879700487, -0.11153339919941609, -0.5805357965693592, -0.0789522935389709, -0.30808404222093844, -0.456662772499316, -0.027994688347778605, -0.782566731990202, -0.27927720421247126, -0.4226335135942034, -0.6152611006411051, -0.4453408029446062, -0.21862916327505272, -0.27405517240799027, -0.3950219238948489, -0.2549139755615062, -0.49506038723302254, -0.31921671094907444, -0.01113366348852084, -0.45467297534986967, -0.02818935696109984},
    {0.16003944691359956, -0.8017574433443798, -0.1351232573158116, -0.47519299207431476, 0.21349203883477852, -0.09885177724729251, -0.6758444690162618, -0.35559979083774157, 0.7221805435745291, 0.23573407289863085, -0.14836010880682027, -0.2590951513877036, 0.41477317477266024, 0.3275997445709082, 0.14104016864316798, 0.24064541004477494, -0.08616770539732682, -0.6376441836154393, 0.16464119951646872, -0.27277545238257594, -0.3848721179289774, -0.28466115172878226, -0.6315587420703196, -0.38465637843740813, -0.005072716272537132, 0.12754193320385018, -0.5989506049830795, 0.3157759291879817, -0.1288408217211918, -0.2461588057425045, 0.2843782160015707, -0.7560961336038801, -0.5597504400898374, -0.46899123002398085, -0.05829060460889932, 0.19938274829555125, -0.03826345370186281, -0.0982896417948542, 0.016372911035328792, -0.02182001650720871, -0.48256198961568125, 0.2571151033115638, -0.33367874218005056, 0.1359085577569797, -0.671217019960683, -0.6257792627814173, -0.14806856000802643, -0.4223535631704412, 0.09307966897000579, 0.2035261077288135, -0.5772208014125331, -0.7297519082182736, -0.4736628300630917, -0.3608182497806013, -0.6733313064206577, -0.3560292934610552, -0.2309575282522335, -0.8418194687973269, -0.1719365156236894, -0.15073450726206533, -0.3865549974886585, 0.20345987904914062, -0.6342054319321133, 0.2434116625565253},
    {-0.29131533920539443, -0.08599343946542751, -0.22372003318569128, -0.3749972374573858, -0.05353634379515012, -0.2980622520086478, -0.23627637479409166, -0.28898380614395236, 0.7130660979795634, -0.0623045638792059, -0.07474844644956857, -0.1505906873282098, -0.2996329969604331, 0.1354835675688927, 0.06611584822776878, -0.03641746025280891, -0.28997762165278285, -0.29825262038155503, -0.0960940299851007, -0.26552088731037, -0.8131718583519864, -0.323911628638121, -0.6187392253013491, -0.40699862396310543, -0.3870173370289464, -0.2910615156089336, -0.2150697005715862, -0.03741844430120401, -0.05525378053992576, -0.213543595517649, 0.22159260723224322, -0.4876264574236104, -0.5451417818282955, -0.7636174959886638, -0.4891350136126761, 0.23617455352341307, -0.09114297774604885, -0.3027179845384605, 0.17129589082087324, -0.31479734651657515, -0.6046199570250129, -0.007637100021287182, -0.7138688396201051, 0.040142498298674195, -0.42130715584221795, -0.23010276795007809, -0.4239719932199909, -0.36967329453441383, -0.6425829865817106, 0.07136152628762385, -0.3264861624794412, 0.2080094500402029, -0.3256571044335312, -0.043883738691678935, -0.28688033641145444, -0.36789072639274967, -0.2911268082820709, -0.4432100125978076, -0.7317662886429893, -0.594073330984113, 0.02884626297974346, 0.11684087528909301, -0.5983672883956799, -0.010724520927270626},
    {-0.07489875580037615, -0.13884669258329962, -0.6868522061217656, -0.380989505210178, 0.09522222993036783, -0.3863649322408941, -0.19916696856451774, -0.3333257980202453, 0.2993210504233484, -0.4036656243769565, -0.28853351778307246, -0.36800416403822944, 0.0035822701761422794, 0.02147892811744025, -0.12322704323938363, -0.44236439063600475, 0.19859280932756604, -0.4528430593870932, 0.06580458451459575, -0.2909296812087292, -0.5798638297208996, -0.46891977630045234, -0.6064747065494167, -0.836238321060659, -0.7313917031944921, -0.1822936739379349, -0.7831350750651119, 0.388599167081122, -0.017090099459607426, -0.380730793294668, -0.19091594899259973, -0.8142947670677604, -0.5363062863142014, -0.5027570160859334, -0.3163609121898205, 0.3036669420024227, -0.29702450757500265, -0.16780006500136904, -0.1410455720266033, -0.35761618780491505, -0.3409618343230399, 0.10335257475222753, -0.5471319952219779, -0.21952268095013147, -0.44928542597806564, -0.2782837949066738, -0.30779163858791403, -0.36009185523086595, -0.40344868368261555, 0.2362887851286125, -0.27841299694157134, -0.3932703285133767, -0.45253640381410437, -0.3037086864344958, -0.38675588458290605, -0.41294841317525016, -0.5887614052839294, -0.6449819849496808, -0.3092984830030409, -0.3253433579720268, -0.42938328123636954, 0.32529447107870474, -0.47333159751629356, -0.33560993150647017},
    {-0.09620562167881254, -0.6197544430060871, -0.3898783228807115, -0.5467070454035069, -0.2528353891441439, -0.20380736399685853, -0.3422986065834476, -0.5930599689714274, 0.14086220961481208, -0.2235588884063453, -0.545742946339529, -0.48381836813723067, 0.327274795939799, 0.06006920761010446, 0.044383812694589055, -0.48462291287970993, -0.03525532515159654, -0.4523113365302563, -0.3640859000439997, -0.48475913962000405, -0.61096722884798, -0.19092708154628757, -0.7055749561094611, -0.6579643284930616, -0.4894753856554165, -0.03136772905156997, -0.33047599820305107, 0.040282015317265815, 0.29008511322027086, -0.41179318738037624, 0.028643263547799943, -0.3157020760856617, -0.6021626154068059, -0.5449088447679776, -0.42290384293114547, 0.45538535302157984, -0.3457697335384349, -0.04975107734052118, -0.47105391515279527, -0.22092718869056138, -0.4473946525003149, 0.1857327582161206, -0.4826734411518554, -0.25842891357838227, -0.5029802508624951, -0.6782864752841241, 0.02825132706113127, -0.4913226792152496, -0.2988949053447702, 0.2748591339242669, -0.5105497001095965, -0.43272233601903937, -0.434990905334379, -0.21495541979904995, -0.3678261928000724, -0.4878422351130763, -0.3491512738845994, -0.469717063875515, -0.5178415891141067, -0.17367599703845593, -0.3916076484476277, 0.05235519005297927, -0.7205313919458993, -0.24389071350141106},
    {-0.1384964142167974, -0.20211433866460182, -0.3593328844625902, -0.5355749309043107, 0.1868791705739193, -0.3043823448448016, -0.03728352120407059, -0.09730721846721085, 0.06260795143610451, -0.17072143454705657, -0.5600531969690891, -0.479795851301895, 0.5474588306565066, 0.14088405965805195, 0.11456214923131673, -0.7221703883752361, -0.14804439265728828, -0.6113691818531115, 0.05510996761635852, -0.44260215123604096, -0.5021787992427945, -0.35907986046008855, -0.5064110271149478, -0.7263212704527449, -0.6292934425586734, 0.22713175684902245, -0.5350664911141575, 0.1713364273374239, 0.0747246649393959, -0.4977340868887804, 0.16985534966277058, -0.3298925340166178, -0.5482818870512446, -0.6978276470108761, -0.045807577436029326, 0.12500775150354015, -0.6285943093137527, 0.07420943523497091, -0.38129496829774834, -0.29162931216997745, -0.46679948457531684, 0.5099634668600264, -0.7595324497673765, 0.2204861177868084, -0.4546794184352484, -0.7815737237383859, -0.19620054680052482, -0.05786687664746585, -0.28615320434630953, -0.187749587485389, -0.2199559386680021, -0.4662235354139805, -0.3009810277345074, -0.4575214028363826, -0.11911425817106294, -0.498121578800097, -0.16898887373265034, -0.47232377372301976, -0.3117714165576851, -0.5748582450301114, -0.30424708174114257, 0.3090146937328489, -0.4648697147999862, -0.026937193977665756},
    {0.09861383394360972, -0.17410587632969443, -0.16417390629665773, -0.5941247113064743, 0.36315950030170685, -0.07451470172959827, -0.3940237358084872, -0.2068467037469131, 0.18931062739504745, 0.06638629902253788, -0.34966906541505055, -0.43503881764288477, 0.4676711201250643, 0.5397341632264919, 0.1505156621912041, -0.2491398888615673, 0.17355338963882622, -0.6577142165040828, 0.152524494075714, 0.012996503610040878, -0.5688213340458168, -0.12103359313715378, -0.6774416443159604, -0.6330465938451901, -0.4536963431800789, 0.17951050640153657, -0.35397272062553253, -0.0830719035687421, -0.0741106756147785, -0.06788457501629852, 0.05821928846408432, -0.5052804646218677, -0.8437906958887331, -0.23543406862431712, -0.07945825256237597, 0.4069906497046297, -0.27255935098460127, 0.3437771948426271, -0.21253859485844642, -0.010312336031159415, -0.7873533255325047, 0.34896440431384207, -0.36509872250455055, 0.31800530126016474, -0.42953669974254094, -0.6854530898478363, -0.15627116279377826, -0.3367611580101904, -0.7094916903315842, 0.052358092945746414, -0.2908564080301345, -0.30511701184819956, -0.15501002245377393, -0.5145528489958785, -0.41192845019175295, -0.5506774457429668, -0.6810200581541022, -0.6745557099985436, -0.5890729363988356, -0.10111696823799074, 0.0694616375242527, 0.3151461972025247, -0.7451739361713265, -0.212229020642149},
    {-0.028899437290129296, 0.06460205760341035, -0.5414064389710495, -0.37387536253467013, 0.22815418886930705, 0.3827155012940883, -0.5306683258109037, 0.10356330567841518, 0.12903419582096942, -0.5205953599208424, -0.4940052401232918, -0.5703236033026013, 0.21378747421760153, 0.15970144785602602, -0.23865424270284055, -0.41307324812001456, 0.21306563522095923, -0.896649272548792, 0.03904411439554569, -0.1386833629404765, -0.24689476686017073, -0.6334145588579464, -0.8295666215038336, -0.7360839556571435, -0.3496929874703554, 0.23685713418540333, -0.2507153977054769, 0.03391549184787704, -0.03246067479908305, -0.3044119654234019, 0.2565468659573456, -0.6978298590987264, -0.5130175663312592, -0.13804591087326878, -0.19222543890961616, 0.03858273549641207, -0.2819958554457775, 0.10677578357295765, -0.5067450125731265, -0.3745593524243076, -0.33135024769108135, 0.01742308342580353, -0.37267458112823426, 0.6114285674318609, -0.2849139444927615, -0.37056185223128546, -0.3294646965707981, -0.5876581253235059, -0.5706723178155246, -0.13482371575983212, -0.38456277866669925, -0.8829262218914956, -0.16447790270062057, -0.42342057366112795, -0.1776584339735255, -0.40777208062922526, -0.6389864816029835, -0.6414554241774039, -0.4264025261669989, -0.32000437835574314, -0.3320265157552919, 0.2555205525371269, -0.6088084101932258, -0.004704291471575312},
    {0.18796339167733275, -0.41004298539883316, -0.3366953899609072, -0.49619555031266577, -0.09938139304343092, 0.3271186141442755, -0.7697226390748587, -0.14172336494443785, 0.11750280108450167, -0.4341712508432821, -0.49626704893724316, -0.46769241331909595, 0.33959726748210706, -0.3016298035992502, -0.10060804012777289, -0.7629343394972319, 0.35683697045457974, -0.37289858840546153, 0.11065664816764481, 0.31147568590542574, -0.4630376696416901, -0.6328614748143166, -0.2749036532167529, -0.5544338119003072, -0.627752891497169, -0.05778785564916141, -0.16161127162104819, -0.07558052606465313, 0.06220993577239102, -0.6666540284294453, 0.005619380093907162, -0.4586086145168648, -0.5069912319359184, -0.36358168165108173, 0.21087433895806376, 0.2410123873392392, -0.2884620903139199, 0.23051811184834195, -0.23538758489938696, -0.7019624844982983, -0.44349764777670003, 0.11326992947823525, -0.39991454604926985, 0.13736102578219267, -0.03449836900399541, -0.6025978845521935, -0.03749911683339318, -0.47012597162175784, -0.4170851766779613, -0.37588793193031883, -0.4295699678939248, -0.6632557011185102, -0.40466782545334823, -0.4845501823831352, -0.5689888601205833, -0.0073524082116836025, -0.441369531726758, -0.2854343603071816, -0.32986762984973944, -0.381379358856773, -0.3172974346455321, 0.21093988078814974, -0.43183096733747756, -0.247332766560513},
    {0.03893626135475833, -0.20615463759859368, -0.3872312843548906, -0.35425998819066035, 0.1447255020473514, 0.34733492491991, -0.2160793842342554, -0.392906502241071, 0.40203575537668146, -0.3145042114102123, -0.5884999978323215, -0.7084311999059841, 0.6613366908880274, 0.01453037243579079, 0.0536446157153293, -0.5171608906596052, 0.3618089774372039, -0.518327006166268, 0.09496285968858997, 0.17151419355743275, -0.6199443000871621, -0.3558860501297255, -0.7707126134478343, -0.38089686282333624, -0.6425332845727149, 0.26219786923801625, -0.4057583902130158, -0.24625056553526084, 0.1781345025389971, -0.3871577532823134, 0.3201350886107112, -0.6301773554705798, -0.6079596447200232, -0.5511198861720762, 0.33258961803863274, 0.4300151781309893, -0.21825089408915527, 0.3289031015422531, -0.046889118730037344, -0.12285918761490512, -0.30241957796738095, 0.2760855307055625, -0.34658713482062325, 0.28188230432168043, -0.43137683810258515, -0.6622150731101939, -0.12615194198054325, -0.3743463447523029, -0.3817310421989387, -0.18886381374242042, -0.07246811212582581, -0.5970858728339576, -0.3192867715227285, -0.23326905307837353, -0.7713567363309658, -0.6652265765847172, -0.6017785701772281, -0.609742469133661, -0.30588722199403073, -0.26278151083473533, 0.01261231354384212, 0.1858328349706574, -0.20164571268371068, 0.029363633288336327},
    {0.14405590217041248, -0.2844625815248725, -0.4052782587922739, -0.5511836910782867, 0.11710528727173927, 0.3209787155787187, -0.24186237553784604, -0.13949036052252323, 0.33298866217419804, -0.4294632863439324, -0.15889262093330966, -0.48583047209509833, 0.5635702957317679, 0.31119645524558154, -0.2803209527290508, -0.6127765339392571, 0.2972262418152202, -0.5357623514420723, 0.04283821872807864, 0.45390264307364453, -0.31812895551068193, -0.21292781317133494, -0.649874178915809, -0.4717135775219075, -0.43070761511958094, 0.13485347686464347, -0.38425143664858064, 0.1459010071655166, -0.4455144884663283, -0.3271838135515421, 0.5604197157069005, -0.4327263466040428, -0.41912548356274054, -0.5414899699193759, 0.046659115366261064, 0.07732041209839188, 0.04871214181089519, 0.39360328627928354, -0.04508689942671125, -0.21121151758815893, -0.41621924433040236, 0.09623377451693091, -0.5068594602052604, 0.3672465607028877, -0.5268464591564478, -0.46464649669179653, -0.384474804948006, -0.3399102515808104, -0.4796810304407584, -0.3877330994930087, -0.3421079521963421, -0.5445441487639641, -0.21736470415312908, -0.22456781606063075, -0.2510231044891012, -0.6189372156672394, -0.4458303160778107, -0.692752188624218, -0.5538919412938079, -0.608845322012966, -0.16358931335402685, 0.28264543310152485, -0.5231657360086522, -0.24817243507042885},
    {-0.07057338629528076, -0.017738858513485847, -0.6308036331455845, -0.614047340152289, 0.2910142545980655, 0.12203818507057584, -0.16053110150033106, -0.28477486825029863, 0.3245004747477755, -0.3451133251708641, -0.39856276301786414, -0.5608387213388885, 0.08456278035031181, 0.2520984871278056, -0.00047212309177702816, -0.4296328457503694, 0.21998724934883404, -0.488020954896079, -0.4530809904026396, -0.45618804168201305, -0.5026677576839594, -0.36573447349231825, -0.6297550065979457, -0.9594672497540634, -0.6618070593760701, 0.03109924164826157, -0.5006478757307676, -0.09186033745772032, -0.20694370941100385, -0.6395170309723928, -0.16528244671677786, -0.45222058884112537, -0.3203040032611601, -0.388625728047402, -0.0030209207776418453, 0.14208717199101134, -0.25367689393292503, 0.28653091743908043, -0.5269665350719025, -0.6591945681015052, -0.7750103843858408, -0.01439112027707251, -0.19540948676654596, 0.3195932925938035, -0.6955194203310759, -0.3931173951983301, -0.2550468258023123, -0.01818389831420886, -0.24958809870224924, 0.2513519557757985, -0.2816779175857928, -0.5333832307289188, -0.6989378328290402, -0.10758053604294049, -0.5440092858162012, -0.5310678132833362, -0.6633143622606108, -0.8829839463718124, -0.41419627507484447, -0.6919511971758919, -0.5543818199064472, 0.30633072086676855, -0.505255885914571, -0.18930820402518944},
    {0.24578012361331406, -0.12652757014541602, -0.5747499373221876, -0.7637858288779694, 0.31025022878798425, 0.2846129187886182, -0.5584958198477358, -0.47094124723918684, 0.41486782274989864, -0.5102233387268855, -0.3701103921672811, -0.5367122013181347, 0.09970801402377534, 0.35806014959547333, -0.08385193335824101, -0.5511491119968118, 0.416924493062794, -0.666858307497213, -0.2539554133393894, -0.19269237563471175, -0.5259730387867642, -0.6763584694676043, -0.7230465564704036, -0.7039727969637104, -0.7082714982401063, 0.18106007445049133, -0.2691528035157505, 0.16343873960894886, -0.1501009878557279, -0.6672189011720612, 0.5512560178350135, -0.6255109350722845, -0.7555194424952755, -0.5401593011335429, 0.034222814786558114, 0.001773960073974598, -0.41122875101354783, 0.34646783488170035, -0.24339644034862393, -0.25654958237463515, -0.46236347432141817, 0.3499610238744971, -0.4752126434134785, 0.4145961128185049, -0.5349279733160123, -0.40952981232162977, -0.4259548804194742, -0.43345882250967516, -0.543348588130851, -0.1676253782493303, -0.41104791343456815, -0.4148159013545703, -0.5746171336395055, -0.45300728058858253, -0.43263504441306644, -0.638737451783286, -0.4851599846196662, -0.5115282300023691, -0.6728377580979193, -0.4874592331966447, -0.31610360460015785, 0.44502632720369584, -0.7180762688242021, -0.49362937382430766},
    {0.2524362794867866, 0.25018899621450064, -0.7511834074192707, -0.6234358493766099, 0.4105435893531024, 0.6133408029924428, -0.8302845746930912, 0.14817775651714882, 0.6028730968269275, -0.35865140805077583, -0.39144063557243236, -0.4031012999250278, 0.383471953180543, 0.27470760751816, 0.3393519474755339, -0.7991827904376814, 0.5902604567850582, -0.665972882973676, 0.2868863272790602, 0.378352972810238, -0.3513973273168395, -0.3257326076581174, -0.7411967840541296, -0.5499042709439222, -0.5101420224903083, 0.36504046083751435, -0.01807913010108077, 0.049672533326294246, 0.18018663565152038, -0.42354910211622954, 0.5431835681716711, -0.5315788698241649, -0.5316554806110217, -0.28202747436740416, 0.43429713363084593, 0.5398327434207035, -0.019162823604741884, 0.6395932682015675, -0.3492433513920153, 0.20839494169816486, -0.4562427714142618, 0.4040596048862016, -0.32885437467732304, 0.6026775526814723, -0.5013621599724075, -0.6735637060338429, 0.19609513863920336, -0.17081326613779518, -0.6089165995670761, 0.11972092029212737, -0.0145577841547767, -0.5562342449495279, -0.5183783969572555, 0.1402759654582634, -0.4237636818584563, -0.7359008457902214, -0.5834317291562027, -0.566033346794284, -0.5686852708218949, 0.11575138917388773, -0.4240465357648883, 0.3615412919977591, -0.9457366123267252, -0.3621563138030922},
    {0.4723941288928458, 0.44247598687998607, -0.5122303522808007, -0.5723927597437019, 0.4001044579305899, 0.7672659863881219, -0.07157722496276822, 0.12570843471102963, 0.5984515899637293, -0.4309174887540052, -0.6060203188112311, -0.6340636142539682, 0.5478542924023719, 0.25192427821011776, 0.21307045715747883, -0.729807944778072, 0.7315646251392588, -0.6542783248797825, 0.056756437759847476, 0.5279124045949065, -0.5260027270043601, 0.30258657877203754, -0.5900066737773451, -0.5025170376948269, -0.5074627310474213, 0.4306844369291824, 0.18796925612307444, -0.060469606992864126, 0.025936929195467435, -0.4454977854836378, 0.6215096761972072, -0.21086379462653956, -0.5745583245366975, -0.2935083135463153, 0.5730372066202496, 0.38815372963069616, -0.24355738316239936, 0.6628581325564634, -0.3625286136084828, 0.04916768470562175, -0.09647942266577728, 0.38056836582090403, -0.40696855911053653, 0.6210592553845825, -0.40364722535656905, -0.8473486062517968, 0.042052091864124, 0.16248392337492898, -0.6388097956832673, -0.29518951562370493, 0.5862704385259776, -0.37518381832588515, -0.3354449250975046, 0.14033758063238516, -0.48429328387928994, -0.7240775656910544, -0.39669496658166237, -0.32893779557217323, -0.46940380364190026, -0.056647804116874756, -0.34106646564841253, 0.5088778746690803, -0.7830419529531776, 0.15312331270902893},
    {0.13453593254240678, 0.003631490687903545, -0.6661137431535535, -0.5411679317058278, 0.33446508721423523, 0.6109618267839765, -0.41893541622458774, 0.02304410873720167, 0.5295360828060572, -0.7386770249242385, -0.45767569564669713, -0.484229364949903, 0.56669602191454, 0.06807510662323975, -0.06468666792134586, -0.6717591278172048, 0.23866107203934506, -0.5564404130761766, 0.13401729551607175, 0.4624009599303562, -0.45565912021582794, -0.10191493376024822, -0.8518456217912395, -0.5016559163646837, -0.7208429499341522, 0.45793630222328763, -0.06874799703756684, 0.15755818283799733, -0.36509784130835793, -0.5218586628879834, 0.3619579360524917, -0.47848960687838044, -0.5759553138246533, -0.44389049597442226, 0.5389080110985012, 0.16236181461927665, -0.1729690106100859, 0.6599270429183415, -0.2541225008936879, 0.2801244764652372, -0.6389198296535411, 0.17990226077179983, -0.5131665355824321, 0.4694487387422838, -0.5661713013990967, -0.7002637242937503, -0.3878281088578065, -0.19126965452757763, -0.653673155509155, -0.2915196675716609, -0.08987818825478626, -0.4988753726808905, -0.4539969301490661, -0.15162340075992053, -0.5169421989552454, -0.8133973634973434, -0.850879712263022, -0.40931161481664535, -0.34426566519979107, -0.3263135912027286, -0.13506896390891987, 0.2636497069287938, -0.5918892940201711, 0.022695072545198845},
    {0.16670822543941963, -0.4570833713461425, -0.5604662612595425, -0.37343176278922036, 0.20625142172784813, 0.4956186940234487, -0.4404952924571538, -0.4344607920623849, 0.12757430697824648, -0.49488542106875444, -0.6671680188049285, -0.4763351983585064, 0.2280099823920892, 0.14062982301771623, -0.021924070553333907, -0.581195256920102, 0.5634402683807201, -0.6533539929307287, 0.21257718384842456, 0.009784224035619791, -0.5954005150521156, -0.46331845978165337, -0.7243326050467788, -0.4238733282737207, -0.6643895538278584, 0.29417704817347806, -0.40743635387253063, -0.15954105905869354, -0.09829865372456802, -0.2635823631583457, 0.10918233720301813, -0.4900502432018442, -0.752277205690002, -0.31293461423867625, 0.06859502090432824, 0.1968659061301815, -0.24748511194767758, 0.35755039636347286, -0.3100061767365656, -0.11781587575059624, -0.7706308949970524, 0.41302092839770477, -0.3708307701596064, 0.2155177100465696, -0.40927574822711077, -0.8293076868998757, -0.1786961489533504, -0.3384850491719422, -0.49992042174751133, -0.2766984256018546, -0.5892639012671377, -0.37647394560129843, -0.8218111029529847, -0.404448722492036, -0.8018892249322646, -0.5478264196408804, -0.8013143265153803, -0.684146034252489, -0.5000274911432304, -0.21330543991164383, -0.3253298742543173, 0.5521394440757814, -0.6749769980815192, 0.2637662391753435},
    {0.13533792435370964, 0.05514105004357907, -0.5045535856383223, -0.5874381556895009, 0.543407654190696, 0.49029838522673796, -0.2814011381192677, -0.103710334352221, 0.45472428682041893, -0.3821232149578655, -0.8467203889807309, -0.3434093892310526, 0.39176324787820704, 0.3443026618462669, 0.2959291240114888, -1.0511139885838807, 0.565081536799783, -0.4264392539877748, 0.07241180821627682, 0.4440316268563445, -0.6385302909736729, -0.05722073508226096, -0.7615454617504019, -0.7588493908136661, -0.5951337240990007, 0.36640944686142807, -0.04049770475019714, -0.2502020555443757, -0.07311728893045352, -0.5436982412164046, 0.31120576417667084, -0.6435261225351797, -0.7471410430104007, -0.5922465496803275, 0.4444346343502071, 0.19884930912624013, -0.06948693673468648, 0.32707927746698856, -0.7632812616930642, -0.4490975945421324, -0.5961401385963772, 0.289347426334672, -0.45930622864866866, 0.4186636880733834, -0.44583266262294924, -0.5809325052208266, -0.21611958165975123, -0.5592368550449976, -0.3697117619978365, -0.2896720863365151, 0.16441752544057636, -0.641723774887455, -0.5534967200217203, -0.024338792498430354, -0.6851641041732517, -0.6874840540706075, -0.7096832094307072, -0.5089819028884055, -0.6815990327138521, -0.08570955776724466, -0.5210331814661333, 0.44030778386248964, -0.6293242949631466, -0.19080130812606177},
    {0.10055985542241079, 0.04726366383198531, -0.659374985585899, -0.7422253401138169, 0.23425649256013542, 0.7569758770082211, -0.4616324224089153, 0.061573296129122955, 0.4015121122927938, -0.6369133275599919, -0.5170978635322621, -0.6156288527063617, 0.255605819789145, 0.028976217639966908, -0.15398233517195337, -0.7420740814431771, 0.7361714835631097, -0.7163239384577104, 0.04918252307716887, 0.22648233127601183, -0.6840539157907801, 0.21621225911498715, -0.7491502156897146, -0.5737757169501566, -0.5246405965475255, 0.1653577909474052, -0.07685302985160862, -0.004924588045993885, -0.31005717799864024, -0.5170398762794751, 0.4285722384081342, -0.4465726678105444, -0.7557008984275612, -0.28157260324806527, 0.35005114901664924, 0.27801036712347055, -0.248454344140038, 0.5312499350493195, -0.6737482383069618, -0.3775878225919542, -0.5355613492555923, 0.19354307595549372, -0.41777025829931347, 0.4656684661097668, -0.4806624429713407, -0.6980887734281314, -0.2784701356487647, -0.4407108274912393, -0.6443194316674117, -0.07103014666495124, -0.11459057190054532, -0.3324325377485279, -0.4070127621035226, -0.26257399295335593, -0.7598600143512257, -0.6762712744302918, -0.8913582687369008, -0.6006540007161673, -0.5917146183965946, -0.16899660138013853, -0.3038228718730564, 0.8072719703944711, -1.016690251638352, -0.10479731838991019},
    {0.03166845418998246, -0.009595284070857845, -0.4773761305544579, -0.493046164182745, 0.20300037567742368, 0.469340232839138, -0.3758440045459091, 0.07054192240278641, 0.37034131145493204, -0.7833114393818938, -0.6299075780756974, -0.5110595376811357, 0.38152902766540786, -0.08797164277996597, 0.021089356122178632, -0.6843216809212385, 0.33948519132850913, -0.4979064529527924, 0.2398249726584539, 0.45608399866701305, -0.5372611708094276, -0.3447375862091836, -0.5436206483924312, -0.4155033687146617, -0.797770884913944, 0.49155610458607335, 0.04234490145563704, -0.021205888957829908, -0.1537839965276608, -0.6469543863524728, 0.571104668503531, -0.5597620539114077, -0.6037307870767343, -0.3886886582658549, 0.24990585822035888, 0.5011989075889053, -0.1413621361215113, 0.5001307365492714, -0.5534667580233851, -0.5112880124072073, -0.5390375603223284, 0.6982971641106301, -0.5140624904222681, 0.36489516860736665, -0.4156645327748236, -0.583293135761824, -0.2159228331814968, -0.16345235074086592, -0.6697485041644597, -0.18752941717714766, -0.256254795588245, -0.7120010422915738, -0.5040325403469175, -0.23823482807535973, -0.38780876692759914, -0.5999519313289937, -0.5181498343219302, -0.9114231361635675, -0.36180397236501866, -0.24755875838072988, -0.5197431729442664, 0.538021438070609, -0.8485520240980269, -0.18621184605696675},
    {0.28472344265899824, -0.03708100611703241, -0.47333951384151013, -0.6019298903676634, 0.3359256512315043, 0.6614955524770404, -0.6024390841170528, -0.18264083423834004, 0.40716533998245813, -0.6828554126861935, -0.6354536556412168, -0.6213354920953407, 0.5523259157386722, -0.035794121629330634, -0.1724275568345914, -0.6194586156063712, 0.6282815157306132, -0.6247088496721198, 0.035511905521465804, 0.6755670971667647, -0.5312314050329355, -0.2355827814973176, -0.681650014130698, -0.7522788512418511, -0.6079898733866942, 0.5201329478829236, 0.021261730215193016, 0.1498913330386693, -0.030172994385545146, -0.5438518974695661, 0.44576447636518723, -0.7563119292737129, -0.6949780192867482, -0.23874959470570448, 0.0858693396235871, 0.2346249194298658, -0.18228255907519295, 0.5629279105589328, -0.3153395340337891, -0.1332546017157898, -0.6826037187206577, 0.6089369401897212, -0.3164780613624149, 0.5880781803980089, -0.5771702048576979, -0.8575168157684523, -0.20984892751855738, -0.1174650329069951, -0.7329177859397819, -0.2920519841529401, -0.12563530443645307, -0.519565417947463, -0.4373274707589995, 0.03800634941199873, -0.6107245886003382, -0.8658916406656841, -0.459266773989452, -0.48917172872058573, -0.6208317326002329, -0.269428311370313, -0.4605689974338209, 0.506956967479623, -0.9117468734837204, 0.06300733062458617},
    {-0.19810188941894807, -0.13619942194744836, -0.32748049721638467, -0.6380595457944739, 0.24785934698142753, 0.8640798589914186, -0.297017165344432, 0.0753913184313635, 0.6263059680405353, -0.5252049596641059, -0.4630035622331467, -0.5801583490457984, 0.5160884504105161, 0.4731219700542572, 0.24111623750749045, -0.8603544320952522, 0.6216249524927451, -0.743761161711551, -0.13848467041697538, 0.5229816795096415, -0.9501606985171871, -0.028395968886588848, -0.7418503269437117, -0.544224170241752, -0.43818649243845537, 0.43089304550325064, -0.18562990627292283, -0.27578146720553737, -0.10209331130239924, -0.5121178713630476, 0.5306079041098138, -0.5368259465852041, -0.772744488885617, -0.21090691448971557, 0.6083859465032608, 0.48543105754855564, -0.032331531031937956, 0.6166441647215247, -0.6574710616744651, -0.40293527710541305, -0.3910897764868857, 0.29591802984576826, -0.35340746806597945, 0.39871365113696466, -0.11113447428454813, -0.4335897193837888, -0.21819153566692176, -0.22466086387882747, -0.5560231517940442, -0.23030441699780466, -0.13471360815873656, -0.6554609033025197, -0.5435767810055491, -0.03852183858974601, -0.43920163295529, -0.6603916331596856, -0.6318755271470612, -0.7697090840478485, -0.7683642591005488, -0.06341921223971633, -0.28341051145784885, 0.5463767330187442, -0.7878700328308742, 0.052509523605071357}
};

static const float b1[64] = {0.7174804048135598, 0.8462278112986771, 0.7841459095734356, 0.8483847542589025, 0.7503796018877439, 0.8459392547393095, 0.8932610707475719, 0.8379965901192744, 0.8717156489368295, 0.8434956607444786, 0.8361854700945662, 0.8341670088961884, 0.8537130931114087, 0.7703183928001457, 0.7507852344788508, 0.8585166630295423, 0.7340509302282607, 0.7954361673200505, 0.6785457457434408, 0.8818794467018908, 0.8371587555749258, 0.8590077760379297, 0.8067744236225679, 0.8474527460113463, 0.8724746992980043, 0.80271624857271, 0.8682701535916728, 0.839090127058739, 0.7336756830284807, 0.8514498969914003, 0.8402316255056681, 0.8479702203311599, 0.847569780030045, 0.8690111424861511, 0.8284764141274682, 0.686998013343196, 0.850391237660419, 0.7759328396383774, 0.8240585603724602, 0.8276536563399498, 0.8531709884948978, 0.708983426728248, 0.8493111454785284, 0.7315883205252202, 0.8466763452008479, 0.7886982632150009, 0.7625035205490726, 0.7987496828785673, 0.8493789366212559, 0.8187293787264508, 0.8600666380308862, 0.8047511316983946, 0.8323446557230549, 0.8038528393861665, 0.846762509870251, 0.8086284764540776, 0.8632709566609502, 0.8401058170093653, 0.8430378805100261, 0.8276500120983848, 0.7679320015122868, 0.69856070304532, 0.8264798067162697, 0.8220573895577267};

static const float w2[64][32] = {
    {0.8716717347771586, -0.08404507142053319, -0.1444673202426345, 0.8947956467543108, 0.027809869011789515, 0.533564764610386, 0.367708714511896, 0.8172891868961097, 1.0290935956986347, 0.7276685605712575, 0.4916096880126865, 0.6784248195417988, 0.7780743496320072, 0.6297635642908891, 1.1454734861343114, 0.4756263922461425, 0.8972341394017909, 0.7638598719400024, 0.6767585256800684, -0.16799570339191808, 0.5837588729256177, 0.0892279757985665, 0.7704612483998328, 0.1823461088479463, 0.7228277119516133, 0.6662115781661897, 0.7093721572611508, 1.0354597948977236, 0.5334938219052675, 0.7856286905274078, 0.8013079991968105, 0.8489460086029712},
    {0.6349576603911793, -0.07360647319773357, -0.17166365271463402, 0.5943155372754508, -0.07959950697932774, 0.5415493952946236, 0.6001421501534694, 0.8029295575160431, 0.6673380155451634, 0.5504591207933546, 1.2833497739104052, 0.7744958274525698, 0.9490947131382788, 0.8084751747787837, 1.3683015058567292, 1.1638647986978166, 1.1916490818257512, 0.7467310654920513, 0.8067660467945761, -0.05147516228746483, 0.6989648682615878, -0.3477996356111513, 0.7435873604103097, -0.07313530715701212, 0.6536493033279622, 0.9971000102414325, 0.6223907949456121, 0.9584232779156622, 1.0942624998829495, 0.39993460170718054, 0.8673682590936169, 1.103634871748246},
    {1.0402933696795265, 0.031157318221322113, 0.0825739280614571, 0.9213779283376589, 0.008883114995286814, 0.5605680565507493, 0.9473550214205909, 0.8786933767569864, 0.5015833475431313, 0.6110219309311358, 0.6766016161510969, 0.8952809777688441, 0.6776604679916731, 1.056251882855461, 0.6250148777793676, 0.8904621253812519, 0.6691436649274756, 0.9260734933784374, 0.9424569196755003, -0.14806729330441493, 0.4667295508460151, -0.09400214728648378, 0.8892042934906477, -0.04989147791892056, 0.8590071514986444, 1.0198895636689966, 0.8195398611361068, 0.7231511353912988, 0.6871543886836812, 0.9196129664175403, 0.7608781802394402, 0.7437303700681457},
    {0.6480918669641123, -0.33729363809993557, 0.12968724600180478, 0.5472948297668871, -0.16167512201536785, 0.6070326746150796, 0.32918536133902077, 0.8153138077577674, 0.6749176975559298, 0.5415679127807589, 0.886539261591276, 0.35158046450717434, 0.6704323112875435, 0.5725442201748332, 1.0116254063913708, 0.8407382836167419, 0.49651272925066775, 1.0267038605418886, 0.6926592756044425, 0.13546270031232668, 0.9619444461520401, 0.05415479802072101, 0.8311951556373773, -0.03764018739256008, 0.5923936811984478, 0.9609306500578193, 0.6685548312186825, 0.37914723497024616, 0.974061791073613, 0.8248880194658188, 0.4758337583661205, 0.5509209047190863},
    {0.6395343975763812, -0.24927933892222864, -0.19471558719138746, 0.8617143347960525, 0.05386315293905725, 0.5991541597530615, 0.11491443877914975, 0.49087362917089633, 0.7715160105041495, 0.507591113290994, 0.8196095844290457, 0.7483252904055228, 0.9413544842361211, 0.6302702710058764, 0.6610235640738568, 0.63407465978863, 0.5994348383686144, 0.7068711413529726, 0.7593425345229283, -0.1679277370207514, 0.681356483737638, 0.045045052230877985, 0.8913039264035397, 0.03249885982013587, 0.6692883414504025, 0.7479403986549702, 0.6241483160267512, 0.9086036592632866, 0.5150755163805132, 1.0949892956837828, 0.8719745244278935, 1.0423567080493663},
    {0.7275456450519663, 0.05886613690495968, 0.02553257565816286, 0.9319733514303199, -0.029661101116862, 0.6269852926738514, 0.5370613727093213, 0.578552140937872, 0.3818519418642123, 0.7384766676921428, 1.10758456468651, 0.6272855220644494, 0.8147705013706629, 0.6289647524612665, 0.6327547074860942, 0.781559930965615, 0.6096127772355281, 0.630942680945603, 1.0353857837908416, -0.15174610318684487, 0.8129209667942956, 0.14266478334012817, 0.8536624400913287, -0.06575018628794511, 0.8163612558427331, 0.659875523206395, 0.7813016624376473, 0.8916338891294638, 0.7926595772040009, 0.9819292687835278, 0.6567334452001402, 0.8059196318219528},
    {0.6677454312201141, 0.12697710267452095, 0.08576262674125529, 0.3038679184021014, 0.037822748810518426, 0.5013352184053887, 0.3597078071882056, 0.9788472315610464, 0.5315396138876098, 0.8788172386666877, 0.7440056183719417, 0.7825401806831241, 0.7374149609399288, 0.8012453302624366, 0.989942377029496, 0.9224493271137051, 0.6845438851044312, 0.5743487709033192, 0.6073681312055332, -0.00919709394156922, 0.668636304691751, -0.38701379805228187, 0.8279169021281073, -0.2028669985834846, 0.56135057459661, 0.8886685752644864, 0.7787541118202401, 0.7259798090978508, 0.7467132133200858, 0.45296472217455225, 0.9447901196953823, 0.5311905514010727},
    {0.9139810850154532, -0.016793612368424953, 0.009852396028476342, 0.7064700847169344, -0.2920590461490636, 0.5601555063924687, 0.7094345793752549, 0.46869020890853375, 1.006563564524479, 0.34029154861045824, 1.166640512921306, 0.6772719404388893, 0.9584845722187743, 0.8357443222362981, 1.007897576429497, 0.7128614152425811, 0.8100202516766876, 0.6816333239835007, 0.4701866762902162, -0.3594335378713732, 0.798895190240057, 0.3108673799724091, 1.1462296586682408, 0.1362085854894225, 0.5293723875416682, 0.718583102370001, 0.6144248975223309, 0.9975723038417077, 0.5211050027514247, 0.873841152326583, 0.9427323547145521, 0.7741864751687427},
    {0.6340618390955293, -0.08660778303964502, 0.07685235529452622, 0.45448088784896623, -0.164038748807579, 0.4743971219642336, 0.6236562577754889, 0.790730732381854, 0.6471055336083787, 0.5159619064891066, 1.1031613243920053, 0.5863515963594873, 0.8341924311382677, 0.5172477284257426, 0.8339852279351933, 0.5624440599991979, 1.080641247050014, 0.6336400136430641, 0.8901144757190947, 0.005265646775505909, 0.6605308703570367, -0.05363720331709038, 0.7975604383805724, 0.016238340648514, 0.4418688597058665, 1.006187492080054, 0.6879665389999141, 0.637090270566207, 0.7295371626733295, 0.8842050701985689, 0.7428557354069815, 0.9271443919471907},
    {0.9723545507418025, 0.1362950655588449, -0.3378007848568009, 0.6627120689412348, -0.03301921914604445, 0.4919446366251999, 0.44581090209710345, 0.4394222806192119, 0.78553081230662, 0.3640788327126864, 0.6517417220367254, 0.5878653796696675, 0.9247846850149134, 0.5815392627305601, 0.965156191946406, 1.0248106266231634, 1.122291872919168, 0.7692031847182321, 0.6812488001864515, -0.09723159662331836, 0.6970228188718999, -0.31788727306214276, 0.87166795175874, 0.18448008383446066, 0.5436062186901107, 1.0323646556455455, 0.7772481051603357, 0.7209452974603785, 0.8167033127371434, 0.8485081149422674, 1.1237350273515418, 0.7653277761147498},
    {0.7911799492627819, -0.33287086984587455, -0.43945523525575436, 0.7585411708723434, 0.06936539544082093, 0.35860040603629506, 0.5421837688100845, 0.8141493122431442, 0.6468177788842668, 0.6123880290981362, 0.7483660619613318, 0.6718432345078597, 1.044907498420568, 0.6928677746209099, 0.897139103511397, 1.0370440375202923, 0.9374696502235694, 0.9734432576248411, 0.982728577949526, 0.10905961548190699, 0.9162144972677386, 0.04685630773966778, 0.5671505967165446, 0.04582576838680428, 0.6109907504467745, 0.7166385301471047, 0.8306485196778426, 0.7796575541495309, 0.813057365366057, 0.9663195224213349, 0.8321904505791542, 0.8764227629735265},
    {0.8996014085878361, 0.020011353232850474, -0.022076676032725617, 0.4355104221993452, -0.06202597634489749, 0.6875634348525994, 0.43355652250759136, 0.8594293077105414, 0.6298463865842426, 0.5162572411741931, 0.3820356029213256, 0.650698919504027, 1.2079002632298947, 0.5051100210297778, 0.6612531799683964, 0.8224622672910873, 0.9414070384892382, 1.0592418477101226, 0.6881213577013453, -0.06802461116982694, 0.8796268617343157, 0.07544424453247088, 0.6342891579266213, -0.17655766246781382, 0.3334117906468733, 0.7062649998687847, 0.899852456713595, 0.8905085633031111, 1.0164949060753354, 0.962486643667157, 0.9135486645933406, 0.7438509158983586},
    {0.7370818805678143, -0.19763176418422884, -0.07860572397212943, 0.5338196375444346, -0.3365237532086205, 0.35952223526948274, 0.3017409538020974, 0.6029711944316336, 0.9454721229843875, 0.3996084129610402, 0.8635524255879118, 0.4151872304909859, 0.9278310066697637, 0.4796155682833646, 0.5404040324931346, 1.0208048289358234, 0.7872717217610434, 0.6685152986064754, 0.7277141521781714, 0.18886833831010524, 0.7195866745767395, -0.08304119669634308, 1.0447273276525877, -0.2867079743180092, 0.5805285839073336, 0.5419516678280988, 0.6509241923532031, 0.5767035292655159, 0.775621597509365, 0.8863027196942893, 0.9603315014994646, 0.6920952875590589},
    {0.5750807659649448, -0.3340179189086692, -0.11476976155013201, 0.7766443843252744, -0.2721498594755991, 0.5193691830125899, 0.5169650555207815, 0.5682554664129533, 0.27069131199688207, 0.29875755529080755, 0.7217380141249881, 0.511883299577226, 0.5005107374855725, 0.5967165918422201, 0.9346736188581959, 0.5473286764360692, 0.4297319504062146, 0.7642718818229607, 0.7738442266924821, -0.03136856743738589, 0.7540171120492534, -0.060805934784726096, 0.8270859511336667, -0.26269127988060975, 0.3917736683430348, 0.550561670464529, 0.6731705140184168, 0.7564410683279758, 0.8584864997313691, 0.8661442278850682, 0.7631004163670176, 0.7316057945330051},
    {0.7021775782537002, 0.2625277578251126, 0.14483754856228348, 0.710505935841417, -0.0944724106255457, 0.7848533257523543, 0.5134876679329483, 0.6449283966962365, 1.1039580993643119, 0.4535612126508162, 0.6584493846418967, 0.6548530625366912, 0.7522893401024109, 0.6445921853374346, 0.905163482100113, 0.9569761839045279, 1.0966340335047118, 0.85186170647576, 0.5069595360142927, 0.274608162931611, 0.7493969061552043, 0.09722839303419913, 0.6490513999188018, 0.17932190982436735, 0.615559169445513, 0.6507527861849045, 0.8067836342946594, 0.7351466200027413, 0.6256419680140342, 0.7504485964414138, 0.810867727933254, 0.9227852339354781},
    {0.6794343580252377, 0.05530213561268415, -0.015963024493969715, 0.5184902605362136, 0.10549599727188005, 0.6251852483720213, 0.48027358807191184, 0.7251089643004778, 0.7568621796959422, 0.659068594307517, 0.8431925553152853, 0.7746308016819039, 0.662426960686228, 0.9588717359957493, 0.8182657804396786, 0.9043832577709134, 0.5488945474820012, 0.614540484332164, 0.8440872704851843, -0.018943978303531173, 0.8002430775557823, -0.17664027324500872, 0.4748329182153204, -0.4154583498231802, 0.5173846291165427, 0.7209558185645873, 0.9511559015463824, 0.9769299779766546, 0.5073857654024455, 0.6330639534361594, 0.8137969138944472, 0.7097265464043812},
    {0.7438031863193431, -0.15065403257081325, -0.219608426901951, 0.9022107214465389, -0.40756196178913595, 0.7324395928803143, 0.4895912426310408, 0.5447480537450317, 0.4534696565175268, 0.8541776862734608, 0.3870321410690748, 0.5405172409984011, 0.742732760875924, 0.9730447184672667, 0.7392920888154826, 0.5225155028276364, 0.529325284154507, 0.698780180453903, 0.9944025209986815, -0.05526288136708122, 1.0696296025509155, -0.060818271713169954, 0.7392863530482016, -0.050128923615021366, 0.557888902150498, 0.8828273996501075, 0.938318614306206, 1.1171376268481055, 0.46875927353386493, 0.7261519556847973, 0.8786923815137077, 0.6692982372057394},
    {0.9403608641601948, -0.14587806645427714, -0.0005864946720675446, 0.6874037441791184, -0.05209817489910782, 0.5601611206020459, 0.6719841581340565, 0.5138296319083572, 0.5711965661607171, 0.7575445856819372, 0.7054417924122653, 0.7271201184668558, 0.4752632953297729, 0.5892545885475982, 0.612225222981818, 1.0027992844000817, 0.8298893459145078, 0.8244802838983322, 0.8306730936625035, 0.06944629110091742, 0.7768080034915421, 0.472775505714393, 0.851335614749618, 0.22478210559447812, 0.6457734359677573, 0.4722273285650868, 0.7617663534561341, 1.1703682299854865, 0.9916901321208181, 0.8990767033419599, 1.0534102112231767, 0.8086792450749548},
    {0.8183296294922743, -0.07325463091741691, 0.20690493364218085, 1.0971850770244078, 0.023123233151171846, 0.5496790445275119, 0.6333808640299395, 0.8986570188929738, 0.7681108536613199, 0.7384321960364, 0.5228709728850195, 0.6350743414948585, 0.8748630152719148, 0.5871475628029301, 0.5834157817072478, 0.6319022922778683, 0.7186050351206003, 0.549063177666257, 0.7163497721291182, -0.06211318620925164, 0.617198567779963, 0.004767427206455713, 0.869056107004409, -0.27185654600180953, 0.4549355884135856, 0.8092217040894255, 0.6345685546016286, 0.8676091388224789, 0.7573613493115571, 0.7070505954528924, 0.7431833957185784, 0.7118798655936426},
    {0.764394870501054, -0.062213538597643246, -0.07830534688038192, 0.4935987712275974, -0.0748605910076293, 0.4627732134463985, 0.4967993814464636, 0.782109400036011, 0.6725946094345633, 0.7267123298995379, 0.4272795858804471, 0.5416010169513618, 0.9462986295040084, 0.7396740453623941, 0.8401995507850217, 0.8211209592426993, 0.45945856352842207, 0.5163988433831412, 0.7492697936739985, 0.20423554859745574, 0.6418725259534466, 0.2660820256264467, 0.7459726266387015, -0.2595637610222208, 0.3768095411815911, 0.8233005752967038, 0.9106057079911487, 0.9491028601002836, 1.1755972182707324, 0.6515641825534869, 0.6192549690605538, 0.7565760218256136},
    {0.7084529499829797, -0.13876424660911907, -0.2789674866996059, 0.697392736904715, -0.238227933365174, 0.5140712800726537, 0.31599444853577924, 0.8232518602379644, 0.5491326154347266, 0.36403609885994875, 0.8416998483750652, 1.0140818664520985, 0.8198557488773648, 0.8018528177468391, 0.827183227158011, 0.9461185978842486, 0.7282065421719813, 0.9369614401408285, 0.6935694184150673, 0.11647333116575284, 0.8274510310650723, -0.2534840770263816, 0.6305390598225641, -0.4782723433805857, 0.49360629312508014, 0.9910168077357385, 0.7583365797629115, 0.6835703026051295, 1.0401210183018033, 0.9578378750238749, 0.8743902778053058, 0.8430601723205966},
    {0.9712171160076924, -0.4400651082709065, -0.023280807872066607, 0.486993415869111, 0.12650501226560162, 0.6634086699540108, 0.3082359704438806, 0.8519546074304388, 0.6968863962693902, 0.20911315371807912, 0.7192187488286773, 0.5024821123270161, 0.8023722741222474, 0.8526385949132629, 0.7015298287696742, 0.9517662008068725, 0.8198490453264397, 0.9167442194444275, 0.8754425002179015, 0.27228909217083, 0.6579846416374183, -0.027685370988969536, 0.6564462767246686, -0.3074092519552362, 0.4480710162671447, 0.5926091241715493, 0.9677406044092993, 0.528481816030946, 0.9226036951077433, 0.7439833369549501, 0.594650342782572, 0.7219704054433622},
    {0.5427760818950341, 0.025417933826399057, 0.19950567314859102, 0.7847587800836824, 0.008216096959167715, 0.7079212423809019, 0.45776919129423754, 0.704710092983411, 0.848451536117458, 0.4417084567892367, 0.7098250977522342, 0.630167962368974, 1.0007815044682316, 0.8023180083781355, 0.8052179323504333, 1.017341785449691, 0.32170948601507726, 0.8117518431952929, 1.1057765008440505, -0.23728697655396058, 0.8953157171549359, 0.22807418176812852, 0.5231483177974285, 0.1415778324287465, 0.8956869689740783, 0.9006978442218593, 0.8227784035759841, 0.5130405844923687, 0.6878871301020716, 0.6322703993823761, 0.8104589785070373, 0.6375005903600598},
    {0.652087424367078, 0.11763131550743193, -0.07704247351859239, 0.7271322688401208, -0.11320377387657429, 0.4854162902544447, 0.6112143165720264, 0.6179836336020404, 0.7910053424744915, 0.7827671633339215, 0.8818201894914629, 0.5593403958277972, 0.6551419083372675, 0.4970042582300396, 0.9688509262231977, 1.2411889823639946, 0.5946294803070129, 0.8570333423019662, 0.9209718025376318, -0.04845408723962775, 0.8528049362030224, -0.3563664870102618, 0.7917502491488905, 0.11893701564715972, 0.49704792481728655, 0.3572225736781721, 0.7846148928197496, 0.7798523543731062, 0.8700722935406692, 0.8966786943754961, 1.01363190097099, 0.95040035851564},
    {0.4462938054825224, -0.023039173509230498, 0.13267848990737313, 0.6132097356553418, -0.09310466591297388, 0.5298166520344569, 0.8121532768388634, 0.8845973296928961, 0.5148203893333841, 0.6336860095382145, 0.7101443832752449, 0.904288342557344, 0.7980732172106332, 0.5976201789640748, 1.2222256929692266, 0.5584895430249089, 0.3284871834079415, 0.6780633531759587, 1.0259239757897947, 0.02229737387643172, 0.373226517597338, -0.040374152283447436, 0.7807216241411572, 0.17520028618578437, 0.23036066087639429, 0.9098237050186395, 0.8578318166179857, 0.8913259563561791, 0.7443485080896085, 0.7772721761465603, 0.7658073238942794, 0.8898099425940991},
    {0.356842577859272, -0.23643431304191972, 0.12125087383845941, 0.9050002667730889, -0.10479404068398872, 0.9387210727739035, 0.5727796879418223, 0.6139085523543079, 0.9244721067706063, 0.5209885320488935, 0.982820043288087, 0.5101065675402395, 0.7229160230532283, 0.714797734193318, 0.7875798217744769, 0.955047418631786, 0.7641936877120646, 0.7504729559513559, 0.8151192261465003, -0.09863844489116068, 0.34771885411243175, -0.12099245435133459, 0.8024507384564913, 0.13287968317657808, 0.5566429278650402, 0.9548739036825283, 0.7573481740816805, 0.8093481125436167, 0.8125567187251888, 0.5789518382755382, 0.6722881176697196, 0.7536678666568698},
    {0.768815045114039, 0.007026616162565326, -0.3370765492097297, 0.7670648537072737, -0.00966546704533971, 0.17432247839259912, 0.9030304606175796, 0.9419729042393284, 0.5493738882335322, 0.7294362183684936, 0.714287877269229, 0.7583745822845925, 0.7225856086361798, 0.8846393637843094, 0.5590259778404514, 0.5707882656841392, 0.8563694685359409, 0.6086262884996979, 0.9277946295962031, -0.24644317471961283, 0.7154671877329553, -0.141002805185212, 0.9917234838342961, -0.2617107924948375, 0.2345678070453742, 0.6046030834591299, 0.5381419983359608, 0.8815997705607214, 0.8191561797289725, 1.1459186993617194, 0.8331035416003304, 0.5790624710684069},
    {0.5455298412780746, -0.044941301852410284, -0.26726654237477127, 0.7481875001809655, -0.33053742041624845, 0.5573369832996449, 0.6451910641129228, 0.7827000247684308, 0.49510264388711206, 0.4316775929685198, 0.8768680384402071, 0.6647125660113554, 0.8866856398441207, 0.8217080140807974, 0.9089793530074731, 0.9253742148886733, 0.8705434724574317, 0.6657658604920933, 0.563292790934789, -0.11079974279042011, 1.2141848759349037, -0.23075897824048106, 0.7764526808758159, -0.2830478316006421, 0.302378277367283, 0.6537687853733309, 0.8049863349587644, 1.0702568826151737, 0.8587375814673213, 0.6308078666237295, 0.7658629078207158, 0.7566148952595964},
    {0.4354770355817732, -0.11475068389438682, -0.12870838280034994, 0.5455233843892825, 0.04725898818168172, 0.4805374414854751, 0.5243701308731136, 1.1170443504081435, 0.6035623225089488, 0.4002456087707369, 0.9207774654942026, 0.7282445494651191, 0.6673322009585291, 0.6799657854404002, 0.6302561289396825, 0.5372945364190829, 0.7353349137866516, 0.7595620441875505, 0.5400946451197625, 0.10466313561341668, 0.5573055990160933, -0.10510116042918183, 0.7259767747546132, -0.13281638593383077, 0.7124797150598802, 0.8448731200050236, 0.6585321982033773, 0.5883287238519799, 0.798257867243407, 0.5254152808331711, 0.7630460769631906, 0.9348667927343207},
    {0.8089864668271965, -0.05429565171216041, 0.08182418702720536, 0.7013638363946807, 0.053092020956194044, 0.2884759091688596, 0.6609454438149376, 0.9306198368041974, 0.5783924431719611, 0.5568635445328817, 0.9180221601524503, 0.8771149418202921, 1.0231893103915886, 0.5189372413251166, 0.5120157676689643, 0.5995792194460491, 0.9634288604182978, 0.49051938090127184, 0.7833004785701269, -0.22843694142597296, 1.053769555994438, -0.23207304617649147, 0.785889927284933, 0.036331304103072136, 0.5108498482674199, 0.5952451287282257, 0.8854761021747408, 0.6674489805658113, 0.5806867922696696, 0.6260143455161351, 0.7150612231254926, 0.4589211103389111},
    {0.9256268577088269, 0.020207001993513166, -0.2601263126966853, 0.7070733537417705, -0.24027427848555968, 0.6174094337020292, 0.37292405041381543, 0.6818562266786163, 0.6955123798640195, 0.6074846560914123, 0.8989503534461498, 0.6645451841278728, 1.091013990012084, 0.7035354900346672, 0.7763469077155332, 0.8719814260218088, 0.6966017059317239, 0.96086630409655, 0.5813115889456686, -0.0592125464840975, 0.7872292574805345, -0.05930354692461416, 0.7053835977618635, -0.085582217332565, 0.402347607576425, 0.4434373774810575, 0.7979940701862386, 0.8513281093930166, 1.0665443988674936, 0.5682411537554616, 0.8092165069764788, 0.7842376969680801},
    {0.5663314338042754, 0.07352975996761242, -0.04830974698283026, 0.5993364278688708, -0.1701617282632505, 0.5074591761231753, 0.8257187320156064, 0.7161907249339521, 0.5258792512126605, 0.5404746993641519, 0.609939864156735, 0.5638907408387696, 0.7757316934683539, 0.5956818531159641, 1.1372144286741321, 0.8365300557886128, 0.5570121939480023, 0.7982953264470412, 0.9858152292299714, -0.28061608965322804, 0.9000510809031236, -0.16574239425233048, 0.8339934712505188, 0.09192398198310044, 0.24709673126587858, 0.8746385827204931, 0.693416704274579, 0.6918222734226461, 0.6830047464495422, 0.7068574501749083, 0.834287119043575, 0.8831609102593151},
    {0.8224641374640376, -0.23181160270452605, 0.2180448696042864, 0.5361810967621017, 0.3495026143638707, 0.5509498895433155, 0.8084700457680866, 0.69364557150695, 0.5458484970845768, 0.5809942517432793, 0.8415461544985511, 0.6699534942017945, 0.6946783252793338, 0.6719941331704421, 0.9975056136995536, 0.7964074895318898, 0.35660685657547764, 0.9044952253432779, 0.7175442948398203, -0.16622891399141046, 0.7285942295134445, -0.33448050479850355, 0.8812416116352867, -0.14971821440271246, 0.13535021327935873, 1.080734453586282, 0.7651215832041287, 0.7876333338902919, 0.8664890439479268, 0.6660276768713702, 0.849760298756671, 0.7687323902656668},
    {0.672582125248536, -0.2578084446256373, -0.3264062803969502, 0.5893423671664895, 0.0290459333874858, 0.5686574073236986, 0.8676204270809847, 0.8724082332547021, 0.7881809449193597, 0.42607263951470636, 1.12630433141013, 0.6310383754008253, 0.5301020265303016, 0.4897950282232785, 0.9933211806422265, 0.6085598911654425, 0.5962329208822786, 0.45670134082915326, 0.7638524633052266, 0.09492302057957572, 0.7936588622708051, 0.022346353263802535, 0.8680503085622711, -0.03439999625698576, 0.5810758881504193, 0.8466524472799238, 0.8435090479651889, 0.9109546119931172, 0.6431707633664249, 0.8457086568717639, 0.7995301260718449, 0.7614576140947503},
    {0.7159610547766844, 0.11316747868752007, -0.15550235467442844, 0.6994028591151346, -0.09669827319325207, 0.5580590350475962, 0.3371722401363497, 0.7480827676896744, 0.9684723988766254, 0.6895286183058793, 0.7352574674917376, 0.8358719484114371, 0.8313708447610986, 0.9747428741824986, 0.8636368786545517, 1.0875418213656622, 0.8461433949923022, 1.0616932574920348, 1.0115056972257326, -0.19999210271660478, 0.5058529860711722, -0.19698816781392603, 0.7998378414012781, -0.1274254831184884, 0.4921498807232569, 1.018352810850093, 0.8021386842371421, 0.441292009703893, 1.121672466138437, 0.8019646487441522, 0.4062874352771155, 0.9277043110152934},
    {0.49904550488621513, 0.08922660259816996, -0.05352143258157319, 0.9836736358379986, 0.05301644061982738, 0.5429917242684319, 0.4887679289843482, 0.6896669376523984, 0.6937504002222002, 0.588750149871312, 0.7821679894833201, 0.3949449824288602, 0.8835962542841566, 0.9685054542770305, 0.7150667774688202, 0.7034153055355473, 0.579700861192207, 0.8370735926877092, 0.7478863896941479, -0.08362682796853307, 0.41590002061324527, -0.18789652857070674, 0.5935591350642465, -0.16678542442349265, 0.4359881129967069, 1.0547949889467376, 0.3340473281428109, 0.7143356557592145, 0.7144031815331608, 0.6447068196617071, 0.7375400993468063, 0.8309215182287452},
    {0.667118999668928, -0.30221545431705993, -0.036997287417826444, 0.5524267947092856, -0.06910530904172034, 0.6385308738501656, 0.42261257175014855, 1.0488960181095346, 0.5701440044951924, 0.7045978327399126, 0.7613202066157352, 0.5910805234306967, 0.4607965773946618, 0.5877288524993375, 0.6972369018920611, 1.0210610898994408, 0.8596857933487484, 0.8054553648164591, 1.0717074138935136, -0.20209837028229577, 0.7142243099280646, -0.03537293723559545, 0.7064134059823026, 0.32516176597714086, 0.6520469942005152, 1.0027733959877385, 0.7716020428363303, 0.5968755633784858, 0.7716259377047011, 0.7244338398430387, 0.5169538995019374, 0.695979796233267},
    {0.8378972674124039, 0.022193338346304974, 0.18682112421642927, 0.5444342941265671, -0.14509509963877362, 0.12230813087248009, 0.6881511082748327, 0.8110585001336641, 0.8246417940975068, 0.5500189247351508, 0.807709822581597, 0.7779815465469826, 0.8187834046284003, 0.8317558267717499, 0.6355486071889699, 1.1441129997150323, 1.1143371520296474, 1.0171546809630756, 0.6674158603872854, 0.014750459216963838, 1.006001874653652, 0.09361238859449647, 0.6646809481945617, 0.09017670936966715, 0.713321686454388, 0.8750978201194313, 0.5878403557572738, 0.49412110970005163, 0.4913504127824056, 0.7418269802945849, 0.9656789890841317, 1.086172913398414},
    {0.6312610266625399, 0.07538523000484798, -0.06159807779205396, 0.5605592203834179, 0.14812332763341196, 0.710632911542151, 0.6060745297252276, 0.7831349176807656, 0.8413431805354765, 0.5683621258364713, 0.991344837986157, 0.708094155685894, 0.6287948610551213, 0.896784920223551, 0.4517653382540843, 0.7174000420099053, 0.6888931280293745, 0.8013015864346696, 0.701884451476483, -0.41260795774444986, 1.0028750177664056, 0.2411769601742146, 0.9729126119521102, 0.14606460620740952, 0.516731852000081, 0.8600388435536419, 0.8694511297982511, 0.6050156825203034, 0.7924424020582659, 0.910601172279557, 0.597908727891074, 0.8141317698042562},
    {0.7148521124488293, -0.05014239464952442, 0.059965387894550456, 0.7857682982944127, -0.21129977062152416, 0.6951599968865485, 0.6856694563716471, 0.896872218358358, 0.8972391796339322, 0.5486424489576492, 0.633269551249425, 0.4556674804145156, 0.6377875235378252, 0.7583897941377052, 0.6115300011000192, 0.6212745954860804, 0.8001058607301074, 0.8140376205209062, 0.8879227238245189, 0.01541221249545335, 1.0131405890599567, 0.0487629054411588, 0.9743508918780055, -0.06639415905560124, 0.8025483488331011, 1.0326771260226035, 0.839858678054207, 0.9155026027822647, 0.6313887938740386, 0.8602072551796823, 1.007123686666143, 0.5787260156296742},
    {0.4761213183686581, -0.04957986267568114, 0.04328044409629874, 0.3896140260500724, -0.02236001165737906, 0.3903124149963367, 0.5502661115845016, 1.0778266854795069, 0.5935447734074897, 0.3473283041604731, 0.7769808929651888, 0.7974577650536225, 0.6429053107079142, 0.4845035470812316, 0.6180643592507651, 0.7706180523817532, 0.5458287208103315, 0.6116533716723759, 0.7697116064310426, -0.09786717514991289, 0.8759468889685154, 0.01057691636828698, 0.8628560033843783, -0.25051402739323003, 0.14942887770323052, 1.1840304575269454, 0.6888792202305806, 0.41703566501042616, 0.7344831585238588, 0.8279684941772993, 0.9586649206693661, 0.8688075836733965},
    {0.6526146689475879, -0.03864451465301938, -0.13702873623747303, 0.6455404524003805, -0.27004310018957517, 0.4758639578230372, 0.808145555007342, 0.9433057316587903, 0.42871118413595266, 0.7575601959943323, 0.8209529625569146, 0.5022521507679354, 0.7141538838973368, 0.6387633477936027, 0.5442670195594865, 0.5637766613665869, 0.4700061578181351, 1.0541923048481063, 0.4731256461952283, 0.16675282708236255, 0.6968265346362531, -0.13750515499277313, 0.8032719964095985, -0.14433533358862152, 0.8668404808476302, 0.821728669065338, 0.6079002021139617, 0.45314801815501726, 0.544619789212346, 0.5150039481844438, 0.7848155908266093, 0.4730932812174405},
    {1.049161810808394, -0.01059380011503131, -0.3351483997939266, 0.6006058939621455, -0.006323589773097955, 0.7039554243450244, 0.6910716985948729, 0.7756299038437425, 0.7595267333035403, 0.4366353189719974, 1.0494357314981002, 0.9238231241764678, 0.9592386553497674, 0.937572879102287, 0.7651160494834601, 0.6618430235449416, 0.6905068142556996, 0.721320171873476, 0.5259451058726513, -0.08935416702407396, 0.7850904072882461, -0.295757658522381, 0.7933616830922203, -0.1450716238636643, 0.6754670694215932, 1.1352373198731414, 0.6288985591048881, 0.6994191455466526, 0.8774148940481549, 0.8621186608991626, 1.0258504444962717, 0.8754341079665536},
    {0.3593005641481429, -0.636848197107541, -0.15441515571936662, 0.6663634474042331, 0.2399863221408086, 0.4409607849092993, 0.3886194627034072, 0.8783992335220165, 1.0612016315325359, 0.22673605123912605, 0.6131591264625182, 0.7160618727500327, 0.6648811968029554, 0.3911216380611102, 0.9812161877754353, 0.7639788554390943, 0.7353206390638722, 0.44375715943991334, 0.7749699107246762, -0.09234915019832038, 0.5310432986836466, 0.3767343663533494, 0.7633690335189378, -0.10629201448234649, 0.8710927371499239, 0.6995529837548127, 0.7276043557005016, 0.6710467166199968, 0.9288347229775565, 0.6522424377996752, 0.34803303302012767, 0.3907089736737193},
    {0.8235682290835417, 0.35521736190346226, -0.40265890974913665, 0.8772386721018046, -0.05943201134184566, 0.47367472496578805, 0.49421112570943915, 0.6344176121498784, 0.7164223420513313, 0.36725224403521073, 0.8770257695475874, 0.8792557273588063, 0.972452027166969, 0.770713039107281, 1.019717754043901, 1.0943216839581158, 0.8828207852359422, 1.0567523181016407, 0.8364978877435687, -0.193064981556874, 0.666692401393373, -0.5750306502218687, 0.5330259269890207, -0.08651286805494776, 0.2650036727546504, 1.1271700424610678, 0.8492490648221849, 0.9645953431195825, 0.7444169049806881, 0.7622251208294231, 0.40201972462730107, 0.7674593674751231},
    {0.8749812362536873, -0.272633835304695, -0.0001232095180588372, 0.3760482302097924, -0.056093222219961374, 0.5570601851385936, 0.8762911377823354, 0.7954154398342678, 0.8112025533985588, 0.8691371734186424, 0.6398504381113664, 0.7578278533838488, 0.6225114084524442, 1.0858928278942608, 0.4397161425421458, 0.9722213106749452, 0.8392090540706642, 0.9949847548172104, 1.0555817791052822, 0.08901172411178017, 0.9364175133369299, -0.009238031301498355, 0.7741038563834766, 0.1550431010662657, 0.5972681451171599, 0.8585381589970069, 0.5660835092118234, 0.5879635306517181, 0.9328420610912441, 0.7352987809466218, 0.6029119544283935, 0.677796333374715},
    {0.6217102763417889, 0.15582418586915725, 0.07587333944967063, 0.6355050062089087, 0.08987790690624317, 0.3845057344206853, 0.5207296991904117, 0.8614755580472594, 0.6912156623029271, 0.7819264877743588, 0.8213722169185305, 0.9051506951240668, 0.4496394503430654, 1.0846173529125847, 0.6779126064733881, 0.5677292327905344, 0.49294445562933575, 1.083453642952876, 0.7842194755772236, -0.018103342931304216, 0.667551842254114, -0.18876356077760956, 0.7631743269476201, 0.10812399075629398, 0.9054561361314347, 0.7541060383787226, 0.6949944373732769, 1.1191676529788699, 0.6725804704729027, 0.9249067083329451, 0.7323508242347172, 0.5126904844799324},
    {1.0130249045272341, 0.08716006586348268, -0.10051349154971684, 0.6246707112659022, -0.06553777064000713, 0.6860811975193171, 0.8199313382886869, 0.7515007064979313, 0.9109076852137415, 0.7128485943491066, 0.5887767122132676, 0.40729862710134385, 0.9641295231716221, 0.8382966453630057, 1.0859319926514428, 0.8500996553664293, 0.4384429155113537, 0.8241548558646103, 0.6162729221270262, -0.16712066999372127, 0.7982696185691155, 0.22176559731595888, 0.7270434911332315, -0.24646528845070373, 0.44124564168678326, 0.6976300671705747, 0.5933010293835835, 0.6406301228203002, 1.03376061516518, 0.8780850325359992, 0.518016234531072, 0.8070080139655128},
    {0.7602667700447259, -0.18734880052430533, -0.27561755214263267, 0.7469868975798295, -0.37593261148024126, 0.4216841047337174, 0.44722551176013053, 0.6501009526790047, 0.8327706087217571, 0.5399407153909561, 0.9035828202921451, 0.8204980883672665, 1.0236235221570869, 1.1781145592525852, 1.0302100663559488, 0.8818492249417439, 1.154945722369644, 0.7204411674100095, 0.9268569745923964, -0.20612458505462888, 1.106724571828751, -0.42656931945017995, 0.7112776430211485, -0.3289299516870345, 0.7945750195248631, 0.6032825539696247, 0.7185176023120237, 0.817035836784321, 0.9903224167389265, 0.7378512679139834, 0.7791703775852051, 0.781685998650935},
    {0.8655167551720043, -0.07972561196224265, -0.0005952494765046735, 0.7051892017289816, 0.0905626294238929, 0.6095391844274053, 0.5421273144884621, 0.8058488200459609, 0.708710261575581, 0.4528127813790075, 0.8162381500905632, 0.8494636168922782, 0.607518292700916, 0.6012104255119721, 0.606812569341492, 0.8056500373014747, 0.464860917976138, 0.645973024357366, 0.7763426586784963, -0.047658082457622375, 0.934500358964325, -0.023331986136176777, 0.6394151552600659, 0.13384977812756135, 0.4431473476197502, 0.6203233136411863, 0.7730968568455888, 0.9698475102919499, 0.972822400524572, 0.8381120044358651, 0.7220103501466059, 0.7923974576247393},
    {0.8186486971331762, 0.06106298151771465, 0.056284788548435334, 0.9033474816547001, 0.08171944354061991, 0.351766093538522, 0.4899220533929616, 0.7815538655070005, 0.6727571300158282, 0.6801252857632496, 0.6436730237838915, 0.8441454736683314, 1.0132795717855996, 0.755707356553207, 0.4953928012587514, 1.0307074962588534, 0.6414855635337783, 0.5741551268021693, 1.2622779750955218, -0.16668956701399953, 0.772648789015431, -0.3280189602123681, 0.9161104420069988, -0.04184365637280351, 0.4426360354708214, 0.7799247743761858, 0.9227575320709909, 1.0646789604294244, 0.6450539454899198, 0.8704875847625855, 0.7231280759705484, 0.5605434111274868},
    {0.5190330063130454, -0.13124461001381982, -0.011571154712020592, 0.9438724346969933, -0.07524303326086558, 0.45202588896346035, 0.42927312626324426, 0.7535957905011814, 0.659007854253066, 0.4267990048851793, 0.9117894468501274, 0.7846834502526987, 1.1444505196075752, 0.38207979313208074, 0.6318986105235049, 0.6175008535986494, 0.9074578850276118, 0.6700607302610999, 0.8483918867610335, 0.3254929386851779, 0.9296376643016119, 0.02263722243522566, 0.45881459913602146, -0.2544043407017637, 0.6493047318841838, 0.6304770165100123, 0.7038968444742374, 0.5012433945918701, 0.8598262899792323, 0.7860026630067695, 0.680255292506365, 0.8302828019530953},
    {0.8742274567159226, -0.21148235314363928, 0.09287271510339322, 0.8603540761252072, -0.2674736628672641, 0.48521229644178065, 0.8060865854940189, 0.749022840329765, 0.9931641923754493, 0.7854337291680106, 0.9588202582495011, 0.6080228447686828, 0.7218022869202949, 0.8717206670249037, 0.6102165007820143, 0.8861383496399765, 0.7797596868964977, 0.7004885633571344, 0.8895578600632819, 0.07784959425502591, 0.7558654034364388, -0.003344619325844709, 1.0884161875613423, -0.050156246822581324, 0.8137466536246234, 0.894215089751881, 0.7393692195086121, 0.7060323098562044, 0.9498978577009544, 1.0846494567330631, 0.4616084092440045, 0.49197568527253},
    {0.5747040306267187, 0.07803638557345281, -0.1758836658510673, 0.724584397296235, -0.219268500186488, 0.6156075559669582, 0.636876509887359, 1.0724002118411775, 0.7561109375094195, 0.5868525947913926, 0.43192439259451054, 0.8555030275629268, 0.9001710464782371, 0.9019362848334468, 0.6347687808202719, 0.8157336941405589, 0.7129703042487445, 0.7670585931962013, 0.8894874514435988, -0.11973162401835517, 0.9324088283508115, -0.295298861786025, 1.0120807337362008, -0.3348478660830112, 0.5188339693672609, 0.5961681854787928, 0.40374282521717053, 0.8387815523519684, 1.0131464609932408, 0.6739096175466419, 0.8340253610947108, 0.8016556220702608},
    {0.6568627049384267, -0.008282646883802652, -0.20192503641874066, 0.3248817492004307, 0.15194033392980286, 0.5190823125744156, 0.8842477086046224, 0.8975012527533003, 0.9354865537927163, 0.6405260061080815, 0.7858626259722985, 0.5700150306911023, 1.0290507599139667, 0.8416429134539338, 0.7994664667123317, 0.7601242386172049, 0.714806253521281, 0.66942352458385, 0.7014098511402995, 0.2309995495228504, 0.9333505721971156, -0.23230297626966326, 0.8473643102359657, -0.10760626785354845, 0.4738253033293662, 0.8755754442525272, 0.8261239094661258, 0.9752631500856053, 0.7569269761846925, 0.6174672997479916, 0.48821143258095206, 0.7167522654992671},
    {1.0852547448458567, -0.22984184416766215, -0.018978234890204525, 0.45503395562341936, -0.0459213683561702, 0.3700074298231645, 0.8754457825817159, 0.6349682147708183, 0.7551879235628784, 0.6244512867600531, 0.6015472695361109, 0.6355997903280468, 0.7834812319082675, 0.5312455665022247, 0.8077540750033882, 0.675184997350765, 0.8633857598318032, 0.5732570994605612, 0.887918072461866, -0.06507725488144803, 0.6419179283770237, -0.020928929272042193, 0.8028386606377231, -0.4285336910402147, 0.43347968273332427, 0.7558174303078918, 0.7847861719642282, 0.8693667281044416, 0.8534274190376595, 0.9457256770218756, 1.0991622901325984, 0.8336261092821319},
    {0.3916380323507543, -0.1557436514067604, -0.042642903664290244, 0.6865375545423432, -0.3815394174652903, 0.38851817942506073, 0.44180197656221076, 0.8445646059818785, 0.5712461872096111, 0.33456853384778096, 0.7703262705483466, 0.8008871203624794, 0.9996128685695466, 0.5735900970489223, 0.9979347873215689, 0.711919547216823, 0.8502389166737038, 0.5155225239017692, 0.654626500059191, -0.10896582511334053, 0.5975900862610252, -0.0003268673167447675, 0.682036384187699, 0.082331751168379, 0.568139117090113, 0.8893568132016779, 0.8812877769586591, 0.8578378395934607, 0.6348580707687796, 0.9832162406314394, 0.8918397348228512, 0.6355672778079278},
    {0.8131901873614409, -0.19924373574811077, -0.1315396311317674, 0.620078524534489, -0.07698096485306741, 0.26561319344668805, 0.8758053655381781, 0.8678059830457155, 0.6289062008564598, 0.3554399085419993, 0.6116494238681681, 0.9483800636247597, 0.9151468828240533, 0.6001658096303153, 1.1318687609962337, 0.581052356130393, 0.960264191570719, 0.611946594061972, 1.0212584509506022, 0.03175714683296702, 0.5864975410612578, -0.1780881825914761, 1.1120203209940411, -0.02409797953997505, 0.6367157370911394, 0.988338116184457, 0.8154859294850889, 1.0100730391804982, 0.8410437956990493, 0.7719599331664222, 0.8244753385305641, 0.8204554366137695},
    {0.6845870331484301, -0.06000845411624958, -0.021733826570848117, 0.5701253957299559, 0.04853604634172801, 0.42910158482472804, 0.6153362193621615, 0.8336766354378806, 0.5567767476510143, 0.669572459361977, 0.772118360250465, 0.8221721111467124, 0.654276840985079, 0.6590610603601681, 1.014937252016229, 0.5030537471867877, 0.5043933510796883, 0.4994425675536746, 0.9483315478131166, 0.07461169826545286, 0.8105546742762448, 0.13699746510051442, 0.7546397059172921, 0.35479791841802844, 0.809080886790617, 0.6147701525110526, 0.4991239997009713, 1.3293609379868025, 0.5195537321065038, 1.0218129800390952, 0.84111406560735, 0.7153819189231282},
    {0.47385279656529644, -0.1268725588567921, -0.10154548128578508, 0.7125920692911051, 0.020182267499337325, 0.4438655633555957, 0.5101490246130094, 0.7852103463959617, 0.9152646891270447, 0.2793609400239947, 0.7923332775993707, 0.7824555826764329, 0.9411231118449292, 0.6004678605157437, 0.1780290971290016, 0.7855580629699821, 0.7511924018700931, 0.8717750503962423, 0.6898443601689899, 0.05483510560622117, 0.8799301580846478, 0.2175701419607216, 1.1503316474239282, 0.04743418686768011, 0.7564806764282822, 0.6567833370243619, 1.1654569197216438, 0.7994477241073121, 0.7815897244648573, 0.60145473510385, 0.7364284981911945, 0.8998786837402816},
    {1.1199576526763084, 0.025697636853915032, 0.04959591918986446, 0.7515675990598486, -0.18013774766595425, 0.41985706993412064, 0.6149254958703215, 0.6392817569267184, 0.6516838583501043, 0.626314858647299, 0.9949949693347334, 1.0362264363491003, 0.8238111441699472, 0.7196451181635563, 0.7687458960063966, 0.6759505799430473, 0.8458545542163036, 0.6115169582840412, 0.6753782611459634, 0.2102528481480939, 0.820634170945345, -0.0641313707886947, 0.49927421255923077, 0.015486999010925524, 0.6583211474842433, 0.4821849981806787, 0.5694769143409141, 0.7245065462679521, 0.7047616827542469, 0.8608010382276504, 0.7103761377841806, 0.7320918264402129},
    {0.6725314398222055, -0.16463824786337836, 0.137000722258653, 0.6977779006680372, 0.06172819254430492, 0.5785777116074395, 0.5369266907691452, 0.5213313972650827, 0.4407343104827347, 1.0279120833855449, 0.8173991018486212, 0.7410245709883685, 0.5628497659800296, 1.195586546422384, 0.8204367837904175, 0.6934351389997133, 0.746516565909626, 0.5666487303840839, 0.484681523900781, -0.24070081313401573, 0.5062740947806136, -0.42006831071667944, 0.9484115520352726, -0.20279555813023115, 0.5842542486503987, 1.068737012850581, 0.7156815741216062, 0.81308777805764, 0.8346942171215557, 0.5632766518756037, 0.6649666274315899, 0.8784149853031545},
    {0.6440254667724308, -0.08204606324140785, 0.01496232252443897, 0.41530509608009836, 0.015344097255081667, 0.4755214394233125, 0.9604933692208236, 0.7764624236040999, 0.7376775070304936, 0.6459389350805793, 0.6334387474669777, 0.8043667922883128, 1.071724366130479, 0.7736822493100325, 0.7868578694918575, 0.7015751568834747, 0.5950225091416345, 0.6332964522531187, 1.1928582479619727, 0.07989250860350681, 0.48821191329800745, 0.32656237450687864, 0.7037035686866113, -0.08121554092801485, 0.6912003134610505, 0.8216230845877457, 0.5848309476848774, 1.0155462300733187, 0.7138832125704628, 0.9257334123519801, 0.670715671276657, 0.6217636180174221},
    {0.6448189020576294, -0.35999310748585206, -0.3460744197257722, 0.4691787760468249, -0.22748581124541217, 0.30594723884448405, 0.26559052980985, 0.8637738673363246, 0.813251993194028, 0.6383356988226391, 0.6507676106071293, 0.5248712802620833, 0.48012959883721057, 0.5702246401559945, 0.7166257304393963, 0.652254402606145, 0.8613036699153933, 0.7164755716456374, 0.6150273154202595, -0.24905005588066145, 0.5603487583829861, -0.14351012382408945, 0.5615225013687923, 0.11438945744991268, 0.5869997347087658, 1.071862271266957, 0.8194130087470064, 0.8352550419459064, 0.892839502814657, 0.8565566348997402, 0.6218905163501818, 0.8663630574992583}
};

static const float b2[32] = {0.6922502672494664, -0.05792300664247455, -0.08251458260804487, 0.6291499760115302, -0.04221976113926992, 0.5072445985637368, 0.6021964402659149, 0.7155104835429424, 0.6239328124356042, 0.5868504072768747, 0.6927345901073332, 0.6394200323163944, 0.725562821832532, 0.7115359921805848, 0.7158396554971871, 0.7284633115913124, 0.7205144975766115, 0.7070762840530328, 0.7185418887218972, -0.05994334047867223, 0.6806253908091994, -0.018099674057244955, 0.7397552432604549, -0.07774475838852528, 0.505768394177135, 0.7403846680102358, 0.6979976085942159, 0.6750427881774063, 0.6756196908721721, 0.7021294170185002, 0.7565281369226939, 0.7490510444362706};

static const float w3[32][16] = {
    {-0.09288505415686842, 1.1222011271253525, 0.9260936984172049, -0.13171516036577038, 0.7380201232066372, 0.057757668449672915, 1.0084007074734076, -0.10945205599490382, -0.04348074411657413, 0.5750818052329253, 0.7306674098184975, 0.9514126133769154, -0.2071010467978146, 0.9611354394827685, 0.25446167251016827, 0.6234872598967153},
    {-0.32022338025650604, 0.15035945624219837, -0.312179133420426, -0.08374134241318441, -0.18191701334388083, -0.0790878492466438, -0.06134665460216041, -0.05021658866170978, -0.023390690112977387, -0.3311548028325246, -0.09966171980660637, 0.11568785709524193, -0.18739379927583366, 0.23176076517163144, 0.28738949909618106, -0.10797681958391586},
    {0.22438916620687802, 0.1974345633130349, -0.07522713499542184, -0.013864313157344179, 0.4542747092355262, -0.06527576584914088, 0.3657916711904557, -0.32936063845382535, -0.1202210764684058, -0.15118936728720736, -0.20828881554813017, -0.2245304865542077, 0.4074689770353013, -0.48649189306744745, 0.2086328116451898, -0.3402585137338937},
    {-0.10405410537087982, 0.674764227444992, 0.9366601193452313, -0.08254084319459362, 0.8138042774975366, 0.35949059573170566, 1.2552897073989058, -0.04111358835328372, -0.17170418851880181, 0.1945549275919315, 0.6106066318887945, 0.9850087910758357, 0.22714585838227705, 0.7494292680571981, 0.26326645005291444, 1.0390556478057191},
    {0.021906108219495027, -0.015761588476275363, -0.3061780467489775, 0.2180551256498312, -0.2608695742347917, -0.16727190387508156, -0.3456915441358398, 0.015712768113801966, 0.15945267029040364, 0.59438415016528, -0.19861677594658292, 0.24270698862759058, 0.07094165648123982, 0.21122272801952807, 0.1392779239303362, -0.03115765373648365},
    {-0.12472359380337729, 0.7300506571184371, 0.47503345616722875, 0.10420305261402092, 0.3174665731152713, -0.22009889502099061, 0.6781512502648117, -0.07974598703490464, 0.0065478268913321995, 0.27307276590209595, 0.7051268742786532, 0.9212927993667662, -0.00642660927354694, 0.9955802977581772, 0.31765194095911053, 0.2377144080050792},
    {0.1945859098501486, 0.48948389164865674, 0.47622792176037204, -0.28387632018977277, 0.8798163350299303, -0.36626519031076793, 1.2255773390169498, 0.016525357089200478, -0.2737896076003616, -0.19063059570660276, 0.28136451811267815, 1.126965310391727, -0.0982557180917131, 1.3980927448450702, -0.14318383134998808, 0.521069985904607},
    {-0.1288568064837729, 0.7578963928436396, 1.123035902141833, -0.20467042714513495, 0.8888818400238695, -0.002664561387270619, 1.1100666753923063, -0.03285465894188967, -0.2782864884110096, -0.0055179954553292035, 1.0321727343204876, 1.1223694141974057, -0.5408368094357408, 0.767827805396252, -0.5344705306551399, 0.5027275115915939},
    {0.19126509038710246, 0.8887245059929965, 0.7126457049434762, -0.04043204279490792, 0.9958171716186432, 0.2740036031209154, 1.144288255322437, -0.22491745634068114, 0.04443322221329012, 0.05194216598489903, 0.9265385298002058, 0.9328564624473048, -0.37360288674367675, 0.21955243912696545, 0.49525536222095445, 0.6798291820375132},
    {-0.06189028809752696, 0.5546403233283566, 0.33938650285201577, -0.44190935853314617, 0.5068713950417209, -0.5412514883512544, 0.582565931904041, 0.00676846210091891, -0.3966608424605949, 0.33952478907855027, 0.6334430090342167, 1.316643418717544, -0.19059962198213554, 1.057286877032425, 0.17391538130988493, 0.5437379755895738},
    {0.1507072111907491, 0.7957171606859224, 1.2167947743640728, -0.29207303502393944, 0.7811472384105858, 0.004965006975575251, 0.6925594666998656, 0.22792447963576237, -0.04946375489493898, 0.08002592444396732, 1.4803800828253673, 1.035132943183484, 0.009568847388829259, 0.5077439132300112, -0.0943064531060672, 0.4915957613647481},
    {-0.34734531597609863, 0.5614448551861193, 1.0641350808823375, -0.27331022764290813, 1.5756329044672532, -0.5378764824419667, 0.8325319626471257, 0.21814322202348146, 0.5494572630074517, 0.15753600580434482, 0.5458430749752684, 0.9855312015188586, -0.3275598719274903, 1.1268384621098861, 0.07332292878314625, 0.831482629936724},
    {-0.1549784107283677, 0.7380909289635537, 0.8137594319404997, 0.058454059999002383, 0.6411764362888963, 0.21068118060723912, 1.0350723661763885, -0.22730839765756392, 0.2074999702166759, 0.2093863791550951, 1.1162826839033873, 0.6375499295800262, -0.2888984100338902, 0.8453284299584823, 0.00464908069545414, 0.7628762512685184},
    {-0.13206548983948946, 0.6473679998939158, 1.1799768465831795, 0.04767369938594797, 0.3599208512811164, 0.262029049426753, 0.9890900019843898, 0.044359123123084064, 0.17106100239053534, 0.08453439251188785, 0.9133425239083136, 1.350663639734111, 0.39170513056105055, 0.9997353112225215, 0.12130362276731246, 0.7345816625256891},
    {-0.43666449109365596, 0.5291049515690013, 0.4440450973148848, 0.2801597485450599, 1.182207426201174, -0.05905164895241775, 0.9260424770950693, -0.06721533509972766, 0.08135123875711012, -0.01677120515502052, 1.1119916866564892, 1.1553345048023709, 0.2209265556415015, 0.8335944993818344, 0.02372619652500292, 1.010582385819906},
    {-0.31148160228060984, 0.6892160465861105, 1.1447580958381276, -0.48176164727732285, 0.8185853807170497, -0.27787865770816644, 0.659733347983989, -0.05637413288036148, -0.31304274139645916, -0.3177128205475572, 0.9256051851785497, 1.2189850666851703, 0.15871141836848557, 1.0221012758765395, -0.09957023242230044, 0.4914800604621248},
    {-0.0019854542191861733, 0.6302432712714449, 0.6425078988080243, 0.5500949825383469, 0.8959503504294936, 0.06001233095942587, 0.816811020686874, -0.016334266804698818, 0.138546268225957, -0.4161596189674474, 0.915910675577095, 0.8324338486716044, -0.04568977776857893, 0.9310721415651452, -0.13046888558935096, 0.7156481876368133},
    {-0.04121982171456166, 1.152483788531029, 0.7803733413474755, -0.07459576339380952, 0.8431616795150197, -0.25761577726157625, 0.7217596162473502, -0.0028640692440177816, -0.08239268723042491, -0.063833178337239, 0.96075704995412, 0.3560568520326521, -0.004299860479858882, 1.508321610985723, 0.06143255088220145, 0.5962729547868485},
    {-0.10936286258120657, 1.110184585963495, 0.8538235083272846, -0.26392971118383923, 0.917083180594139, 0.06832688550504322, 0.9593564400444263, 0.1272883604419277, -0.3740236928443421, 0.39355228879040693, 0.7493683471510691, 1.0952866532663978, -0.12916455008265476, 0.8396660837054408, -0.18096969938764235, 0.9070285445369014},
    {-0.12184963117304547, -0.25414199946849075, -0.14661872141559773, 0.474785098765458, -0.23541758862797316, 0.37984658359319345, -0.01857782687232121, -0.4104861459405441, -0.4311136738363126, 0.43579620957570436, -0.23417608320547378, -0.05853329935640396, 0.12044185260392415, 0.39060533779902745, 0.17855404201084335, 0.2563767780202081},
    {-0.09693302389349201, 0.8210672365133769, 0.7656302024806009, -0.06324769516339648, 1.0019670616912237, 0.41077831888336, 1.6679906058588434, -0.09833032845427209, -0.24800960842052414, 0.1678984905952444, 1.0901050270242207, 0.9778375069754244, -0.14711111989954825, 1.1082590903849119, 0.13978644795710352, 0.9315916241747805},
    {-0.03754059802204776, 0.26497001955965555, 0.007949418167640207, 0.18554656038497777, -0.17784752035313056, -0.3891928781645221, 0.437653732459506, 0.225362140376649, -0.17132926305975726, -0.18445709666363022, -0.14922172731037453, -0.15013321155596415, 0.23761502350647845, 0.02292662044010026, 0.5154063374070286, 0.01652098810690178},
    {-0.16669872635114766, 0.831228113647186, 0.6659483776398065, -0.2930606417860255, 1.1513310851354728, -0.39079107970849913, 0.7288286756303105, -0.41535582177069313, 0.1504711558439924, -0.19013135476716184, 0.7856617014450108, 1.0220404057807129, -0.29790306176610815, 1.040766282466795, 0.01421788108365661, 0.6278094371760109},
    {0.12124646180965275, -0.16832765669921682, -0.3412388046375629, -0.22724557215425242, 0.14035271362163898, 0.03156698576957879, 0.4884830606828189, 0.0035518128507947807, -0.18040738301434353, -0.35375016475961624, -0.2571919870496758, 0.27408208680570856, -0.19912598276327523, -0.40539174345011997, 0.18844089133934858, 0.17082167125615766},
    {0.12242986864953481, 0.5372441565197166, 0.8329650752449157, -0.059930683391823024, 0.937621361440119, 0.28625487704010166, 0.8371157436602643, 0.15789028732148502, -0.47050982383421225, -0.44618914836124374, 0.47663548282422324, 1.310146361914236, 0.26528777448180313, 0.4877553054578206, -0.07476165850996266, 0.3709543465397902},
    {-0.35310481381003106, 1.197295060831624, 1.0843974668398448, 0.21917834070044465, 0.7836980501448516, -0.6257516119811827, 0.7803005604631384, -0.05355831339009838, -0.06772093228993752, -0.8109262364944957, 0.762639592358363, 1.0079505106326485, -0.1539124883294686, 0.8318998030492971, -0.3108363381028428, 0.8369989646734104},
    {-0.34825398471012, 0.39866600599782454, 0.7428448981016756, -0.1981455613645427, 1.1676087795605554, 0.3717045861030153, 0.3931289396414739, -0.22864239423011462, -0.009303510896321745, 0.05591445858761638, 1.1701552968319582, 0.8550023616185787, -0.753679069980801, 1.1407886721381733, -0.31422333825325754, 0.7430026051432104},
    {-0.016607494867790878, 0.8746127465520717, 0.8846650943628593, 0.12332372639168225, 0.7096962630946991, 0.11231660311410163, 1.0325226888129215, -0.4524508712728684, -0.17240965543270448, 0.04188664489741868, 1.22600107945864, 0.5628513209577122, 0.2183571326943826, 0.7557605089989455, -0.09045455323274249, 0.9016788593762609},
    {0.04561871321952995, 0.8885606841699202, 1.0307144332851632, -0.09379798021137539, 0.6509705936702789, -0.19977856572195282, 0.87165698236249, 0.17723056781390018, -0.42074850474283293, -0.13159858045367812, 1.1833358880591869, 0.9043865678418754, -0.3704942101811329, 0.9042717209832942, 0.360000685275593, 0.7674864621650817},
    {-0.23484557318942723, 0.9962641498707656, 0.910190901892907, 0.3089357458877619, 1.1541365502524907, -0.06431408310754212, 0.7552844397303005, -0.040812030663200834, 0.23808697466554982, -0.29724620677424496, 0.9181599705813218, 1.0166283705535302, -0.32385453866267017, 0.9614147225038672, -0.023124965504377308, 0.8586185077380061},
    {-0.16697103073557087, 0.7089078633464974, 1.1267296920470473, 0.048144381821541064, 0.658550459097468, -0.6500357773287788, 1.2590236455440564, 0.24279453453076072, -0.028547741912958446, 0.44406275211381135, 0.8053943975607423, 0.5355259729862316, 0.3654798044055611, 0.6877598214554695, -0.2621743897001088, 0.8724698498842196},
    {-0.09694650163906633, 0.6282017437592868, 0.7502383245519255, 0.1330904992507488, 0.802364406837187, 0.2508304941066846, 1.106401994406102, -0.07521072157594919, 0.25123457892780604, -0.3873910608446834, 0.8270531356711354, 0.7686793890914995, -0.4662239491342127, 0.9392041970093655, -0.005155049128415761, 0.8959283131208892}
};

static const float b3[16] = {0.00861128854759387, 0.4754851424485782, 0.5124196503573529, -0.06257229489786238, 0.5093418697997701, -0.03360270759935563, 0.5159807295896404, -0.03126331835662408, -0.04523787982526715, -0.03430029058717636, 0.43319456150704116, 0.5955749598358919, -0.05182793474437226, 0.5099567795248278, -0.031992659423760915, 0.6272787267760914};

static const float w4[16][12] = {
    {-0.4203112637422287, -0.14375003964830413, -0.9297995850533871, 1.096626832659863, -0.17145653762229152, 0.43905640942684254, 0.6932459439892066, -0.24285592344206913, 0.037298740963966674, -0.2669691784634247, 0.041319595733334574, 0.4532692704733605},
    {-0.5806733707456245, -0.5470122134291323, -0.41681932765608215, -0.7368984154830958, -1.1377797865420032, -0.3456399693968915, -0.26892601178828773, -0.9880967268172794, -1.0009290878915664, -0.538836741765827, -0.3987598209019209, -1.0657862600910548},
    {-0.8753253863442021, -0.9840301879086696, -0.3489301817999259, -0.8162456473150251, -0.6362812271997927, -1.075461782194992, -0.48286736381520706, -0.2174655646499952, -0.44165869779430983, -0.7358865803668274, -1.0807829711602877, -0.8905230323252201},
    {-0.06686598982090901, 0.049544343513583125, -0.08027844538634077, -0.11296302347198015, 0.4441712785970749, -0.3311597856632586, 0.11814237450097237, -0.14034079716624465, -0.4840248955960607, -0.22521398739067514, 0.34231940247996845, 0.06897694020214666},
    {-0.5291790858634049, -0.9879099116167144, -1.0382315972486074, -1.103856214151612, -0.3972662029253297, -0.8160074616436862, -0.36080824693160035, -0.21950467880878063, -0.2418139188042285, -0.6007402466258676, -1.0705606280454074, -0.28855493568647206},
    {0.3796470884072024, 0.11224906222652715, -0.30520075775757516, 0.7780198087371015, -0.30567922279320425, -0.1172968833284806, 0.020710961266985413, -0.006096551765671812, 0.1449633723879433, 0.1543052726362172, 0.13121391862159124, 0.03514050997277374},
    {-0.917456166421413, -0.5750318560100882, -0.4175853475385879, -0.42156558214401524, -0.5063548418727573, -0.7372878894602434, -0.42100756055830557, -0.8150842212487799, -0.6974862824795331, -0.9560434201989044, -1.2110906587658354, -0.6476898750944241},
    {0.364250779274194, -0.12939736588363682, 0.22426189040475955, 0.41351164963755094, -0.002517233094904995, 0.022166421995046138, -0.016355823513899772, 0.3812174951866321, 0.3798891048512382, -0.3068568850936722, 0.3330150428511158, 0.40645799914166736},
    {-0.07257479385500593, -0.0704903691513998, 0.3213100017292685, 0.6716718590194007, -0.2145233466964994, 0.09014915946504505, -0.05802456281433213, 0.14391037481528177, 0.40460340067510353, -0.43103497995725737, 0.09552589525318243, -0.6140342646009921},
    {-0.5114507071881889, -0.3544843098774923, 0.0910748046377938, -0.2493871797957938, 0.365248898403763, -0.5606219469280037, -0.013438352304376152, -0.34813391462416715, 0.7094190468714867, -0.1457746956635898, -0.06802838905324708, 0.21134540706429955},
    {-0.7458222607806818, -0.020196610999883447, -1.1949082881761188, -0.914347051264281, -1.1443736406430458, -0.654943401972691, -1.2146411707687572, -0.9015655406472542, -0.982749324092091, -1.1505255317295953, -0.5651712893391655, -0.8538797720912779},
    {-0.632712123162604, -0.5528691812848858, -0.5339564632174911, -0.9793965965798839, -0.5212032259060954, -0.6558886089230455, -1.0800432439826249, -0.898445676741686, -0.513499342542321, -0.30016624433431294, -0.35955830565236857, -1.1695429531155699},
    {0.12395562461205607, 0.40496704544339157, -0.2960364288907652, 0.43790106967239806, -0.04667730350738012, -0.2973296989891603, -0.13278129862291266, 0.3045277713756385, -0.4414397704140521, 0.06992463487916442, 0.5967577389450525, -0.24841193732367461},
    {-0.8147057447453022, -1.0488200564870782, -1.0454350858288415, -0.19735186299783972, -0.5083423717019362, -0.931087335016633, -1.1446100102262142, -0.780277700900986, -0.6485216344003949, -0.32680720383678824, -0.22453886973123793, -0.2586944084202228},
    {0.3681922266783768, -0.04439210830740958, 0.5895077224248261, -0.03150103941918156, -0.08972227486610697, 0.22826621018296192, 0.12317801155215756, 0.2414886618601426, -0.014463155284798048, 0.28650801855750097, -0.0693668330807175, 0.0038998455252242633},
    {-0.42402546602622637, -0.9499882147369263, -0.5327242868858332, -0.40258239211245295, -0.7966488443099753, -0.25648277512408435, -0.4498696446237049, -0.766991977521485, -1.1721493007369395, -1.0258599460044744, -0.6192438380958661, -0.3426901119988387}
};

static const float b4[12] = {-0.21415834335980874, -0.15820318694268964, -0.32359617720983236, -0.21154572226058027, -0.24988878473633797, -0.2977078054771584, -0.2998970713893435, -0.2529724710868734, -0.12978944726603184, -0.25329860893871897, -0.20413964690568667, -0.2207125944915224};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
