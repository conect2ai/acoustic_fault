#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {3.0343086088725593, 1.1289099639826048, 1.5227702090532154, 1.0414443015340118, 2.2002929309784793, 2.8777573603602558, 1.4354390442855571, 0.4423734337337225, -0.7271324921433302, 3.5745152658921766, 0.2482422356463097, 0.9053298130542562, 3.466018976200875, 1.2618260202241862, 0.914211303409752, 0.18273496681809445, 1.1865987491639536, 0.7541531500703501, 2.5911954391223566, 0.5482295411147663, -0.10732796348536161, 0.5243867134079901, -0.015250277278519075, 3.9292535803793087, 3.3236652907873316, 2.6698591941963605, 3.3127170558917554, 1.6573442324459284, 1.2211779554741065, 1.7460553673710981, 1.2932749365747684, 1.9533552910431278},
    {2.7063889164119734, 1.5517317389994667, 1.2387157381157605, -0.44690541039767606, 2.172602245162533, 3.2457733132836086, 2.068702418665114, -0.2247092443574104, -3.5513649655747495, 2.88908777685553, -2.9914935592594514, -2.21617595792341, 3.2612316535536165, 0.8680195034821462, -0.04976803323928502, -0.6998399055833624, 1.6693854075571635, 0.8627798778215299, 2.149638804393112, 0.031530639993429595, -0.7696152655226206, -0.4942546746978915, -1.9083836751054475, 3.1159910056419577, 2.6706801693122326, 3.0644668491778733, 2.870202218592547, 1.749756381288814, 0.8771259143447396, -2.485957650857226, 0.23243497091442106, 2.0150682025417828},
    {3.7677629710704363, -0.22416351273811658, -0.512599427685495, -1.5254178898114898, 2.048727435927579, 3.8329766182842806, 1.066952976102462, -2.1180000191026966, -2.8680626745801865, 4.150508064655246, -2.736160650197572, -1.942320544425042, 3.7072081871758575, -1.0603132682521699, -1.1362595754073068, -2.082821392607505, 0.9430171974229568, -0.7601832426817503, 3.1378404726741604, -1.6018209629319886, -2.5687480343985873, -2.119682178891888, -2.6171543840851044, 4.436662997055601, 3.9657204026637434, 3.8992120464655504, 3.796277128298627, 1.7150846215793638, -0.5251197909224038, -0.17305744585423977, -1.1103426430973053, 1.8225923151543082},
    {3.137060717495566, -1.8652610573912631, -2.180836795236608, -3.3120069847598548, 0.949912056891314, 3.1002301494410034, 0.11021685910243514, -3.0534708537063247, -4.008722284027433, 4.380323059200135, -3.502496630536037, -3.1314565744532006, 3.5292931203531093, -2.9501961982887726, -3.1475449368278445, -3.753218097929157, -0.25783123876860403, -2.4077775981321143, 2.761107990030455, -3.2939426095170417, -3.7218239029862734, -3.361603254514267, -3.7683228957082346, 4.488033901210008, 3.892842226934316, 3.303612615257111, 3.41626180419608, 1.1800537252200858, -2.666588105611063, -1.1553503705938388, -3.1554193404168545, 1.24577451557582},
    {2.7300124062467828, -2.957043345110286, -3.395076452220669, -3.8125756942271276, 0.06393889950687132, 2.090148622995839, -1.461811430588924, -4.038005034762939, -4.230774962882312, 3.6578941741998254, -3.8191262784045845, -3.375797493440258, 2.720664331255968, -3.7060499680468557, -3.5756723466878997, -4.30005498811665, -1.2229466307542745, -3.2879280271182942, 1.643256371760484, -3.7834782222181724, -4.453964600169466, -4.335834204178442, -4.044787733480182, 3.963064414295364, 2.488466983792287, 2.0186353719094687, 2.8535605572778673, -0.42581524431432083, -3.1421113669886016, -0.7371381324321249, -3.7447458931290383, 0.025616103001427318},
    {2.4950100457594218, -2.852008359280683, -3.36399169608869, -3.867637017917114, -0.5752941865758179, 1.2761478705416127, -1.888767442060874, -3.9798194900814723, -3.688195776387173, 3.134615254337398, -3.6097452156529264, -3.6467612465084573, 1.9903164229488104, -3.9449146858323823, -3.5643348049461694, -4.023605233006603, -1.7062402082236767, -3.4449636112391775, 0.7503151333613803, -4.015214337089842, -4.687463165913029, -4.396793838580719, -4.160091264997026, 3.0463851145072987, 1.4782651945120953, 0.6687439879455523, 2.522733103270664, -1.0049136224287714, -3.4353048454536723, -0.534072538492572, -3.7040278830336524, -1.1226813742823347},
    {2.1659342691018186, -2.6093516194662905, -3.1532094002630746, -3.6355744151274156, -0.8277198919878713, 0.4199063731793644, -1.6347135770284265, -3.7286565978284427, -4.197325792111727, 2.3180591089755533, -3.8793566640738395, -3.630105404969821, 1.3012661853468566, -3.5427213202231047, -3.1745414116393778, -3.957994641570738, -2.074537998842776, -3.201960653469368, -0.16480167433517098, -3.858278155593161, -4.454092995644941, -4.074582536879572, -4.020535564511696, 2.1416134756007366, 0.48064483033607625, -0.0773407605493959, 1.9469586206521738, -1.5535844153352931, -2.8702572206762365, -0.9098578813279463, -3.4474453595213044, -1.2156396819177928},
    {2.0871221407826694, -2.8752099622905916, -3.1847886409864685, -3.8088990339066155, -0.793551699201823, 0.704367483870218, -1.7863776116776293, -3.854414107822271, -4.5011077614660175, 2.4198731733534578, -4.204569429432204, -3.6559664830370404, 1.4032496897657976, -3.903233464913909, -3.6044336594078352, -4.074700614809092, -1.9960782552803147, -3.0702656744370858, -0.4925100425648116, -3.8111122975393457, -4.303073947107526, -4.256753665552486, -4.39826649695607, 2.4638864765959636, 0.6868714282219627, 0.28739636739385627, 2.0264139126631324, -1.3445766692814218, -3.2194354177119893, -1.436378483561174, -3.7795274910804744, -1.54997827216912},
    {2.1996549836317376, -2.9709497840541745, -3.0466361099504202, -3.758770439544119, -0.3531571492689949, 1.2898336690928582, -1.2728920146318055, -3.826249819713796, -4.412657450930102, 3.0495477497490953, -4.1061853258919525, -3.8078013665404673, 2.3088522988457174, -3.8172985563062336, -3.5125776477249513, -4.091205661595608, -1.9591911139057, -3.027798296040963, 0.5128934801953113, -3.8785580620098403, -4.251567211456125, -3.8064485601594202, -4.286767526750757, 3.2639066580527816, 1.789696116671111, 1.0296838264365853, 2.533303696183848, -1.1290104200853945, -3.4600308358184737, -1.6543664357514063, -3.824239243823739, -1.1843453835087014},
    {2.3394098953150255, -2.362319968746499, -2.9304531739075106, -3.6385715812321986, -0.060440290570303264, 2.1655092384956287, -0.31676074311157093, -3.4273350278544528, -4.510606202499642, 2.9809409500694266, -4.451871621004485, -3.8953826003766587, 2.6555216191497064, -3.122952395719237, -3.239425967895043, -3.900006848475304, -1.1860118514841536, -2.6861596400842034, 0.9084221746171859, -3.4074784701719874, -4.26059135614727, -3.7598928246242505, -4.213774416259489, 3.413303025298985, 2.1226671510006363, 2.488301382210605, 2.564482418802975, -0.4552868152892687, -3.0926468895563812, -2.2711498305398905, -3.405579949149793, -0.39914216352368664},
    {0.7426391244973246, -2.1283848946885713, -2.7968413957409712, -3.633321404800445, -0.5486794419221053, 1.9130176006180266, -0.3010482794495601, -3.5436980258449022, -4.812910171385517, 1.5219589322861105, -4.334189469469072, -3.9662825801382815, 1.4163404008942126, -2.942965465329396, -3.216358358652174, -3.714850922730943, -1.4092883889370087, -2.706569815157997, -0.17078883541124185, -3.3115082074397524, -3.8465331163968193, -3.550478901828434, -4.193466148182503, 1.9113160639614755, 1.0301339712529927, 1.7464985287997257, 1.4095680062624492, -1.43872011317644, -2.7440691460994713, -3.0954991671747285, -3.5152425370106024, -1.1333624320515976},
    {0.8632732378774716, -2.575639817875995, -3.223394975033983, -3.70973959913295, -0.7421759149075485, 0.9159772912524601, -0.9445493031541826, -3.414759102689416, -4.479613440621803, 1.289404883010187, -4.2202718521342195, -3.6591881068504315, 1.2549021559817113, -3.4376130148881643, -3.4307485262333794, -3.7054723845744086, -1.8645135970131645, -2.9297221546956265, -0.5543975422066568, -3.3928528243431137, -3.953059694331742, -3.7848639910127293, -3.9458352079106627, 1.5158397866090996, 0.6663048837428494, 1.3664786584428463, 1.3412792906429738, -1.519463417989117, -3.1101566736155535, -2.403014928778765, -3.6368349484990157, -1.3388564688730746},
    {1.4212802146070789, -2.585997185062374, -2.941485982226276, -3.514231854475763, -0.5390632629490696, 1.2691561275557757, -0.8660661068993368, -3.453852583767812, -4.525272341254045, 1.4276644490784878, -3.982946488383007, -3.93619071248442, 1.4187034925684074, -3.306881897872828, -3.2794971541106466, -3.8175619442786752, -1.6029330473780905, -2.939567211981457, -0.09137833788940236, -3.2205633919328798, -3.9295760413818717, -3.4057926400289085, -3.806712297787928, 1.884227305013981, 0.7023683325372232, 1.6071387974285956, 1.3224596379203981, -1.1640513163261799, -3.1479530557117847, -2.259122600198365, -3.4502934618249115, -1.1314090213401016},
    {1.4534362832270102, -2.814621340642951, -2.9086107590954895, -3.7059847471809384, -0.5460480965298685, 1.1188217356803298, -1.0017428272814604, -3.5124045216849633, -4.457450209742308, 1.7937647022012058, -4.254957297343966, -4.022125256226171, 1.394153032092834, -3.489711409810758, -3.6790629424283874, -3.948101436845819, -1.6320393768028052, -2.825151246642975, -0.34873671263460043, -3.461257284624407, -3.798454953109465, -3.5400866798238257, -4.275032706136705, 2.1313334614347292, 0.7890430298832561, 1.3202577349194207, 1.292846902282276, -1.2035796609818006, -3.109570173060348, -2.7133013750232995, -3.425868769574938, -1.3473248124345467},
    {2.3605485929517376, -1.9925355121096795, -2.454316892112319, -3.563772953732594, 0.3495553447091489, 2.1337588290224128, -0.7594276364007251, -3.280205674783398, -4.547417494887759, 2.6195025260288824, -4.1846134404339095, -4.003534123821631, 2.0176185543588097, -3.117629199065104, -3.1347291805097868, -3.5097165808741058, -0.9643805272305986, -2.30502296427912, 0.5591963208755552, -3.017386020761354, -3.9331355502901197, -3.49537686385125, -4.112869689948933, 2.64557181720746, 1.47467177225395, 2.165682524229346, 2.0356692761827158, -0.5813857334574595, -2.8879746346264095, -2.490245404299794, -3.168310000872336, -0.7368852191566143},
    {2.9400569454783785, -2.0758086402326255, -2.8101055574393428, -3.5710588212200376, 0.4533307334790813, 2.3763565638252255, -0.43752611292178095, -3.4336766556955594, -4.664037288922876, 3.3063987543856523, -4.358320907676292, -4.115022390086255, 2.7768497677971853, -3.201298220339873, -3.1687045912851315, -3.8576057269458315, -0.7685012671157769, -2.567918586190602, 1.3183046041985, -3.477323559987115, -4.031987100296017, -3.628699935169002, -4.445662366757622, 3.5915332392935624, 2.500808756243945, 2.440701449247435, 2.808810276784494, -0.10027397735013552, -2.9435865630690525, -2.2801280821447456, -3.4909378413758687, 0.09934828820040999},
    {3.2616969217339338, -1.5878238145398724, -2.368839354457795, -3.4402597089442937, 1.2492550884195106, 3.185131278226137, 0.11545653031039896, -3.054392814946, -4.349358285170867, 3.8395824600096207, -3.739143850465531, -3.526815888690303, 3.3849923285257275, -2.7167920256572224, -3.0396249330480023, -3.530383388796514, -0.2954109657894868, -2.0196689065498052, 2.506798969487089, -3.1637068149023357, -3.953099244528792, -3.2461026176920704, -4.125957100161255, 4.304975691161731, 3.495496213414802, 3.3673183854226396, 3.4978706582540395, 0.9751708806192139, -2.486506214485578, -1.7775746993805208, -3.113815366674951, 1.0005941492603398},
    {3.9814891917241346, -1.2687250005799726, -1.5316409558270188, -2.5060178489578626, 1.7166207203871056, 3.5550093936572704, 0.6956459320839036, -2.2486258118281235, -3.5617686203856675, 4.390252189894378, -2.8023876538046735, -2.6284854807567366, 4.0546461816629735, -1.8203953042218837, -2.059127874594664, -2.6911997182906693, 0.03863905820895335, -1.1519916414384757, 2.8122431666056387, -2.2126001667333846, -2.9813529902460005, -2.60148147245357, -3.060288245471834, 4.411528792900085, 3.786347598025837, 3.5895149845129324, 3.9653704669801075, 1.5883003345379343, -1.8490557313812754, -0.4605803317939079, -1.9615949396843158, 1.5065053174710201},
    {3.714686435487639, -1.7592488322595488, -2.017064118572091, -2.649068358921494, 1.1005913673209877, 3.0608463744159304, -0.3466790751489217, -2.58038186070557, -3.122227787715971, 4.045376885617671, -2.863966689528388, -2.4181066184951527, 3.5927878297818747, -2.4596302295346217, -2.373751021084709, -2.759292703328706, -0.5794437496510099, -1.970076869087884, 2.1155958437020157, -2.52380320270579, -3.4000129357616724, -2.9557896287923566, -3.0273829897574758, 4.281574794613499, 3.5457044462236134, 3.255646095720048, 3.5239735092945743, 0.6815766466216384, -2.0085975500537403, -0.04711377993880819, -2.376963794873342, 0.5891429336067728},
    {3.3632776513540157, -2.0369750462944634, -2.283220032150455, -3.2842119285174105, 0.7914522744568467, 3.113599748803764, -0.5785401453264918, -3.0247254657507794, -4.136366353664388, 3.8468328581325193, -3.688218602939089, -3.084760619801286, 3.434038231427669, -3.0132371354375937, -3.123847579960719, -3.3909564106782395, -0.753110013950134, -2.477850362481705, 1.8444813897566208, -3.059237845051345, -3.947728374114353, -3.206778335049761, -3.918689915587993, 4.156591225505349, 3.185336708482196, 3.2343389276667316, 3.5703431114228024, 0.4833535961981443, -2.810176093833575, -0.7860813203348804, -3.0673736287267412, 0.21000042920765688},
    {3.4751540834376398, -1.8983961560644511, -2.324457664329102, -3.4627331469719045, 1.193485675539634, 3.3174647293496227, 0.4222665993954798, -2.6405274303182984, -4.563224076161298, 3.7922446842254747, -3.9344364994331613, -3.406508744824144, 3.2400652918208945, -2.402654962299381, -3.092161106837084, -3.536129232088321, -0.03891619790676534, -2.1717727885420297, 2.174266607826851, -2.793376384785213, -3.68638800694465, -2.9504949704969152, -3.633304398422557, 4.335486974346347, 3.3904521626912536, 3.187544409766124, 3.5439389966582278, 1.2359785658337874, -2.586456937953779, -1.7315508345125332, -3.0333923556695908, 1.1793059383655564},
    {3.975756583300145, -0.517497130224656, -0.8259883715244315, -2.066646974481463, 2.3365738671865044, 3.9568050217160384, 1.4814737255402508, -1.5628808371754797, -3.6312814429525186, 4.685011327540274, -3.1751400064653246, -2.261864009618942, 4.13453887483759, -1.1460715599102143, -1.8689838225411914, -2.0460345823436707, 0.809555585543179, -0.919546599906146, 2.915249003904228, -1.569462555612911, -2.3199548674325965, -2.0397016604868323, -2.984232942189403, 4.70121901155263, 4.094654859086304, 3.860009230897767, 4.05089100588198, 1.9336735490264134, -1.0616892932741735, -0.5488541677730167, -1.600483552496459, 1.6614012388713422},
    {4.274717433569189, 0.23908839831295978, 0.08979247484036171, -1.3291986735965111, 2.734102682120144, 4.006763291195655, 1.5289192257064181, -1.0631126346876367, -2.7537031133171537, 4.577841948160452, -2.2989073355464362, -1.8346313951051083, 4.372433671271251, -0.4529385355124782, -0.9207681403161452, -1.1692426831984022, 1.1747823954802963, -0.3577037003520421, 3.1057745285014033, -0.9637066521949491, -1.3398885865372665, -1.0077193566842826, -1.9731657008384083, 4.664130796159231, 4.46224983734464, 4.090048150620279, 4.437630636290758, 2.402426752562649, -0.35502569286027647, 0.001014912190227932, -0.49311541362846445, 2.009282742093502},
    {3.8528054778708434, -0.43251692932314845, -0.8012570319252258, -2.270493413293887, 2.0794958966986896, 3.7454376012492934, 1.3279487742683667, -1.9781402000802746, -3.8610183082100047, 4.237895739870781, -3.4156182096834224, -2.686086984667344, 3.994556874840305, -1.3110377043504347, -1.7704265027804313, -2.161166356072271, 0.6438487211594998, -1.1953184824363552, 3.0384509348653985, -1.7226828430947938, -2.427768938807287, -1.9960565885897037, -3.08647690926073, 4.506407828645064, 4.151577298232153, 3.8977986942135545, 3.9014121461579103, 2.0654332777672844, -1.0730043803413387, -1.4399632408909173, -1.592241642655339, 1.980652537598049},
    {3.297519044317008, -1.025392529897913, -1.1720807934854802, -3.002142065267192, 1.6504294301630948, 3.7123943816529503, 1.369802302495685, -2.299836440961819, -4.183672778507118, 3.891672405862315, -3.9701779864384075, -3.390083137528089, 3.667087924557231, -1.9888991149959512, -2.3022598574499438, -2.630462997329338, 0.6541639667152205, -1.327651632821935, 2.73644007338636, -2.3682178244501264, -3.1322502161076637, -2.7410023639618935, -3.3501059943091356, 4.052853414041497, 3.6616421692882715, 3.882682523449081, 3.538496186966108, 1.8328077006532772, -1.6394552203909478, -2.1597809019788263, -2.1177624907862107, 1.8110120194717771},
    {3.4134927572962463, -1.0413472844530864, -1.3513947943952571, -2.230280424416042, 1.3560536651300865, 3.354918323177855, 0.7166377297900309, -2.128603045351254, -3.680581271685091, 3.8255733414435045, -3.320264766579436, -2.609573790917015, 3.5960236726268895, -2.000668283851511, -1.9655904039290542, -2.4137298049663456, 0.3983911316533761, -1.4775369944321977, 2.4102399873113747, -2.202161327959647, -2.702923189061373, -2.4203203768100185, -3.23406944070098, 4.0897245821892945, 3.6667089327421123, 3.645834523241781, 3.3830130278892985, 1.3253398618586685, -1.5206403407458706, -1.207484921270122, -1.9526572892655534, 1.1627550471809072},
    {3.779370140502822, -0.7134886804161208, -1.280497917598342, -2.4203052176242292, 1.7036633102100218, 3.661896381112732, 1.0178764950188548, -2.1655965702475344, -3.930562378482847, 4.289472525499401, -3.25854695049805, -2.919149067111003, 3.6964799591897477, -1.5215703515946082, -2.0200811138313775, -2.4981359483847254, 0.6361559783669442, -1.267528837540152, 2.634156102111097, -2.0200627347290254, -2.9461081035641206, -2.648540986580524, -3.017648705786481, 4.549514684656557, 3.792536367501237, 3.9053765868611516, 3.7676392302866946, 1.54390256686936, -1.171137907676323, -1.024368664711301, -2.0172432131041127, 1.553713697448004},
    {3.7589261404813588, -0.84833879803181, -1.2412009207170362, -2.747385805511368, 2.034466834654268, 3.7490021845010038, 1.1905713533805469, -2.2821207295012975, -4.054022326593779, 4.404528039858102, -3.8336775253535165, -3.20617538583503, 3.968859549406094, -1.8389750805478724, -2.1222927549012156, -2.566316951085038, 0.425716125397964, -1.297646775772715, 2.591366622607568, -2.1676202822021566, -3.226876683976663, -2.776956339596321, -3.189580526754956, 4.51743888626027, 3.767412256182676, 3.6872595939563615, 3.899694948473718, 1.8295556294370239, -1.4834190239125409, -1.8711354117301195, -1.9509899553337287, 1.7263946876831604},
    {3.5089703968127397, -0.9210513317254623, -1.1169919011368539, -2.5718117159316374, 2.037599256331815, 3.8161806349156002, 1.2072309380761626, -2.1935175648846514, -4.167130850898515, 4.114207564023141, -3.590102574539825, -3.057316265338966, 3.819038207592227, -1.6444991692788729, -2.010969074386354, -2.585362643120968, 1.0120257126926453, -1.1135249650874213, 2.5933931229148848, -2.088490065425755, -2.5963711503159357, -2.3593127776096643, -3.2599402216910507, 4.053667223338, 3.8653008260851145, 3.8259859747986247, 3.5978284080605, 1.8411791659287327, -1.4270795810300847, -2.2338436679984657, -2.0266233154544184, 1.5830301274296414},
    {3.1860364192550197, -0.31997192178503414, -0.8539211921933604, -2.224009784767645, 2.0590482541877475, 3.417314747348843, 1.615360529186369, -1.3678990525594616, -4.08442619224315, 3.8027934929763374, -3.49082967160017, -2.8695328102239084, 3.7975029216660596, -1.2296737749141584, -1.5837066643167195, -1.7958290228596179, 1.339892396566965, -0.742225661185484, 2.9025222091378344, -1.382674063233697, -2.209233337325456, -1.9130481769687786, -3.146475508790844, 4.128512345149479, 3.902762293342206, 3.835180460040134, 3.6050795729095357, 2.1104294532917502, -1.2124806304350497, -2.4411623140073693, -1.725043232736134, 2.0119285949977725},
    {-0.2857776712024051, -0.3689883144829824, -0.3539186221861359, 0.23025797016003755, -1.1615824286319245, -1.3503595484295405, -1.6083780085255914, -1.1735471563209647, 0.3951890153015466, -1.9195685401285172, -1.2358884779410426, -1.4612130880469951, -1.5105553865923063, -0.426332799559709, 0.23209988291792302, 0.6697971142221323, -1.9395533325761223, -0.31679188977214207, -1.9204991670431004, 0.19130725704741458, -0.09790077229027448, -1.4710771714073256, -0.4232992601613384, -1.971714500670468, -2.4674971783253143, -1.888695383192206, -1.1016881726494934, -1.773303523929007, 0.0638850778139363, 0.496240498283915, 0.3184376132266283, -2.323267183314812},
    {0.6023735648599667, -0.3509421529285397, -0.5180894962089756, -0.9046179226376975, 0.276451517499971, 0.7817662345422619, -0.26643509540764415, -1.64970381419638, -2.806389446820464, 1.290137007703477, -2.4969822461063083, -1.63390025254471, 1.1968232503039256, -1.0924041869583714, -0.7027167420842927, -1.2668701166574057, -0.5091823169746668, -1.0229725100496172, 0.4160111980816139, -1.3168874162322304, -2.034241844225302, -1.4023925668560326, -2.286478249726667, 1.8466564844559645, 0.6577821962987008, 1.1010519840020485, 1.2759592833358777, -0.7759291684031946, -0.3928239882143957, -0.6499049115539725, -0.5447888531120912, -0.4403860890155762},
    {-0.7883734241572432, -2.8875497472289897, -2.5636861755592517, -1.7331702312561554, -2.520082020854306, -2.802828400348639, -3.206519693335191, -2.8038587775346646, -1.0061583601228228, -0.5019657413412937, -1.5752529984735693, -1.597016434213318, -1.6359223378070882, -2.947810985194195, -2.2689791963264248, -2.4856522255158957, -2.8460412460874016, -2.417659461096149, -2.760670178004381, -2.8694509023785435, -2.318993149728774, -2.6373152883496895, -2.3209249594615033, -0.7563081236428104, -2.3447768317669277, -2.945371860791127, -0.9481472585558042, -2.6368554240772157, -2.2445399328312075, 1.1532860486188377, -1.9193538251060622, -2.8364858839922986},
    {-1.0733484822268473, -1.9904412618963314, -2.258378059232035, -1.5054439465385805, -1.9971745059113395, -2.4580390619362977, -2.4813446902202, -1.9253964327686843, -1.3386481333522593, -1.0995417512046421, -1.5126028245096947, -1.6994120126697405, -1.6360079085521204, -2.3055392600103373, -1.7605751337550102, -1.4181320355428986, -2.762444223911078, -1.9251953035657994, -2.741759264009301, -1.984664008875315, -1.2111334724310339, -1.8377640382096794, -1.416946878226651, -0.7170072221713278, -2.3670957842473257, -2.2171495125423153, -1.2037840936565771, -2.171497673354342, -1.7095682631214038, -0.3989897992849809, -1.9545095668168342, -2.8024722522799577},
    {-0.6629551266517295, -2.8067452939436444, -2.594834065955239, -2.499902588107142, -1.935003204770394, -0.9183805783256355, -2.055615233613427, -2.655217617082306, -2.8583132083693683, 0.2604514490957472, -2.308863347843411, -2.3647054891373203, -0.5295407598070819, -3.0704873698401047, -2.4652484649210127, -2.6071742426101374, -2.5692106138703408, -2.954233626447672, -2.228812001512347, -2.9152952744161684, -2.9179782513604478, -2.717576670808944, -2.629046383638555, 0.13577539849746517, -0.9899981291025849, -1.183771664465002, -0.23563158735748027, -2.453939836356559, -2.2095293111695096, -0.19747515086663275, -2.692092932213886, -2.222237076380719},
    {-0.23640803400368388, -2.7057437271913125, -2.7786527533911882, -1.9966931317170016, -2.1305849892328683, -1.3647512025311583, -2.6691935880003266, -2.5965057061234114, -2.7279316568209984, 0.2036967801027946, -2.1227507709950735, -2.429948331742736, -0.6188953269855109, -2.8532892243317525, -2.308834623113022, -2.676732437914546, -2.383938455644082, -2.626534087616813, -2.309903956223467, -2.935362461011651, -2.7601579257943345, -2.8083805654580942, -2.208213318817211, -0.12474576268685872, -1.710452873902413, -1.4504025436447072, -0.42391117377641196, -2.533907105834395, -2.3064605864047447, 0.23118202364350368, -2.2278233016830726, -2.6170351298855667},
    {-0.7426587214535725, -2.5867374430163115, -2.514870760228828, -2.3029852856349757, -2.0254476267574066, -1.616562623663656, -2.6617533155653557, -2.8233565997928047, -2.6770504113909066, -0.1106144017779721, -2.4116804796280658, -2.466202467912881, -1.227619385643964, -2.711535603573223, -2.5366981153785537, -2.4631046983952447, -2.6878961449325818, -2.4499359112062398, -2.305795669121911, -2.6503001179531367, -2.301525534398756, -2.5956248425745465, -2.0105516368335405, -0.27149619997154173, -1.6710887475312206, -1.713716687830602, -0.5848717192814009, -2.5931890306109806, -2.2542600704210445, 0.054288365702817636, -2.656072594273476, -2.481288498271291},
    {-1.1699867824909722, -2.6275832853343513, -2.824751137437553, -2.2964927103200865, -2.2431058551794707, -1.7427034920367337, -2.500198345617925, -2.416311238621839, -2.2131962254925015, -0.19816350758991835, -2.0475882975658415, -1.8925752736006471, -1.2064046106981576, -3.0083960470317055, -2.635911298585078, -2.425154524666502, -3.0836173344729936, -2.307156095391462, -2.2609462525618955, -2.7126888689175503, -2.5553160807868567, -1.9314084529433568, -2.121156611190969, -0.12117735989486407, -1.277098739045222, -1.6345456311797903, -0.6243665749778484, -2.799342892525008, -2.0307907655261084, 0.35994258030233894, -2.6631544001940113, -2.9652160171223727},
    {-0.5468532944891558, -2.496389090987508, -2.6668172839243245, -2.463135155673324, -2.23397904394756, -1.6355619007039373, -2.57056257553232, -2.993455661924027, -2.7666998608458404, 0.16251427665947182, -2.1743140396040572, -2.1731329772925703, -0.8172760177445566, -2.904944336796727, -2.5495369911758665, -2.5580747484022885, -2.8371070851883067, -2.75836684241261, -2.2911566876504046, -2.7928567967245175, -2.904201992686683, -2.624971745616068, -2.709474977469844, 0.29823097516153024, -1.9930583977887992, -2.0392858832920826, -0.19312399865028174, -2.7978264418914045, -2.3312087605343477, 0.4184537545354392, -2.831819893353642, -3.1413970870114127},
    {0.5842932098686142, -2.6260248856634116, -2.3019360440934458, -2.503961433853824, -2.0384135552109823, -1.761915083359397, -2.588371358123759, -3.4297139042099203, -2.4065856861939143, 0.40248283176079563, -2.2243631517136664, -2.6779279332182795, -0.2948504248789629, -2.862984879410812, -2.506717686261111, -2.6071911211465397, -2.842195264237562, -2.3842115633270136, -2.1572126621491337, -2.8314179730134303, -3.0272465791270005, -3.2856739910385704, -2.8430878631014767, 0.7750477534416754, -1.4741019443530083, -1.9585138532665909, 0.40973022274983906, -2.714670542711493, -2.398579069731411, 0.3620864423863009, -2.7391621368271992, -3.0841511856040977},
    {-0.7339150846674588, -2.709070776779082, -2.255303945063862, -2.192910844121607, -2.4228612226153783, -2.2080635231267745, -2.5031458331590866, -2.7435726424792963, -2.2461028194782906, -0.6069307598123379, -2.6176421596273585, -2.3168412280201593, -1.337785216963701, -2.340059678122054, -2.4383578610383, -2.1338665151077723, -2.8973507510277665, -2.5949900708029046, -2.564751003565892, -2.479803525004128, -2.2296965182304995, -2.7827985475047035, -2.6305754251987077, -0.582218185096716, -2.2975782790931136, -2.253138063039207, -0.9716082516783096, -2.694228538332303, -2.1447994867157756, -0.15214647373727966, -2.3299384011421056, -3.2348613399076704},
    {-0.5047819068817307, -2.9996740781549946, -2.8887907840032225, -2.58025757098856, -2.5485942096673884, -2.21988407044974, -2.9292930079020736, -2.8491983826826734, -2.6541980410440695, -0.5910194429969398, -2.5469338352482693, -2.678893045427622, -0.9768992155101537, -2.8744316730716055, -2.79409202918583, -2.407761067840576, -2.9014734407929548, -2.9743150127940106, -2.4205978047442556, -2.9634096418036977, -2.589257812636254, -2.700053371158926, -2.591325779710349, -0.16956839514638636, -1.8691960067447415, -2.231653815408169, -0.05887420125585017, -2.9047003644978626, -2.7954996962939065, 0.23551230908871487, -2.930967131956457, -3.25426076670836},
    {-1.034715790301216, -2.8575773673934783, -2.759332415402489, -2.35400566042963, -2.7335969471488957, -2.277145200886064, -2.9831634921047323, -3.2055649149125776, -2.8703994874039824, -0.3645925516577291, -2.617872509459834, -2.8090449131708954, -1.4200516009683226, -2.982525817943786, -2.5487658258287946, -2.7643092545209105, -3.098486277307087, -2.705229359354358, -2.6414853324141854, -2.868607401585165, -3.022112898598646, -3.0703987144855334, -3.0261607673924384, -0.4014860201298166, -2.1271633216062473, -2.246527262028187, -0.892149468047332, -3.021490548140976, -2.807750690632041, 0.17447610674765232, -2.6538028760343058, -3.2862544596354804},
    {-0.903432908070469, -3.441936658026807, -3.4902282094957355, -2.7976847161327445, -2.9083421018098243, -2.5391467279936077, -3.164373171828291, -3.6415024379470866, -2.9017221533454216, -0.26183408887762627, -3.0437124864060388, -3.187976094856411, -1.8100474096403374, -3.159146136977075, -3.105652928185202, -2.9285862102330453, -3.244710005449211, -3.1939129320000643, -2.678886927153468, -3.1041965043069077, -3.2380076681613823, -3.5892377030481866, -3.103599268778405, -0.6346885010921484, -2.251016203072037, -2.6127194592116054, -1.06031822632748, -3.1460733967808747, -3.1333740283785336, 0.1624792322312194, -3.108616814016815, -3.160192310380991},
    {0.06148723133529107, -2.9802859146815948, -3.07241144275113, -2.5502056320846944, -2.5472707367028113, -2.6670700887972374, -3.177343212080328, -3.4873111315094776, -2.4947508483994474, 0.34444362852552163, -2.665124945220382, -2.607034764677314, -0.8454148462448843, -3.0024019189364592, -2.798941686910583, -2.8083521603876855, -3.041943359551712, -3.1748992446289073, -2.7112154298022992, -3.193082578554592, -3.156166401199024, -3.238606049522571, -2.972213486468183, -0.1323908627479802, -2.0368432034896222, -2.524655930616054, -0.18567465127261115, -3.13841617572198, -2.6401985843874196, 1.1732874800738209, -2.9381685349975752, -3.3798258206998453},
    {0.07944114988169568, -2.8918154762865247, -2.956624706118384, -1.7481928762033583, -2.8625045964635696, -2.7363029897253868, -3.5154596942187935, -3.322331156669592, -1.9216672382354825, -0.24806767448716235, -2.244644566726283, -2.727239604049478, -0.9811956326021689, -2.646734917161761, -1.9643987738452369, -2.383200457826337, -3.522804500445456, -2.824709159420412, -2.7932277815603164, -2.6165442543823074, -2.92095847433927, -3.114904041591528, -2.7997264159176765, -0.7270223903500731, -2.3074113165397754, -2.6713691926576026, -0.3413802571284954, -3.5259853903669938, -2.578953132600802, 0.7606321812736782, -2.0982285577128508, -3.595433735152208},
    {-0.4493946939726539, -2.6909192890976934, -2.6387772677926726, -1.6722056585594751, -2.2238357971458753, -2.5964697843444378, -2.704405588469504, -2.4295486500249797, -1.486684156979693, -0.3342329181032025, -1.7069336206603247, -2.224389463360598, -0.5965233576053393, -2.3948550484268174, -1.9915198460860624, -2.4466881283293906, -2.7130685123830953, -2.9112057802885296, -2.273725504321814, -2.7854232649269663, -2.2538026098714687, -2.4035743520495285, -2.1524208433228025, -0.44018498804779627, -1.7380616264239914, -2.4306897868195207, -0.2319543668850717, -2.3989889294186435, -2.6029009063156403, 0.6123633619533652, -2.4122610350441906, -2.925122958753363},
    {0.6907423135732431, -2.09568347894353, -1.9905692203868257, -1.2157189589311168, -1.3923823301873042, -1.1129927829049118, -2.324985552665872, -2.2439758885648273, -1.2237802837961669, 0.6618676436754217, -1.824296288174622, -1.8636444515186152, 0.07011240953474158, -1.7877973170699795, -1.1897031930426767, -1.8069333177123166, -2.1804241224464342, -1.8574096080575617, -1.4922087165336784, -1.8836683927126205, -2.0262857821470055, -2.0623523240953583, -1.8888923619423754, 0.6291370257023363, -0.9465248921967869, -1.3988978366606364, 0.6925686354579476, -2.0647330561256876, -1.7406055321269, 1.1078899077428723, -1.5852578168181628, -2.02670115713511},
    {-0.648253730393226, -3.2802314570652142, -2.8674417042886824, -1.7679668555128103, -2.65170244137363, -2.6643899501582866, -3.3413203052354543, -2.8600857874339765, -1.3340646658957576, -0.5133481512828487, -1.9075717847203426, -2.204630787080666, -1.5172218784054852, -2.9186377486540582, -2.1845774678162044, -2.4603483383332625, -3.1140233837152476, -2.573315175874973, -2.995905587205019, -2.972024043621531, -2.78327818250946, -2.933694360185228, -2.4395106064519734, -0.7738857249079615, -2.377003064707596, -2.725068660483887, -0.7659903529654893, -3.0030400908437276, -2.398457093978801, 0.9957172865112146, -2.266985359562166, -3.4343553689229185},
    {-0.44958346274112687, -3.704298386714591, -3.4298045420560093, -2.118854069939669, -3.1219880420047477, -3.3732578391288164, -3.627925758473494, -3.3973022154485193, -2.4764653241584265, -0.26962362973196463, -2.581676900772546, -2.486833750501738, -1.4974131197780927, -3.4457566225944314, -2.9164271203047503, -2.9876660539120965, -3.7103142660227717, -3.28037227389597, -3.4477831348160572, -3.4402555473364616, -3.458957454636367, -3.3978946259489264, -2.719334687685238, -0.7577959822641954, -2.735759606454223, -3.355929309943647, -0.8044168992080658, -3.5905713755696103, -2.8791038358841905, 0.6685612004534841, -2.5725178608317094, -3.58503796485151},
    {-0.3915569424318083, -3.5663842394858047, -3.456466503231056, -2.6224796193044866, -2.7479943406496705, -2.6080608176411073, -3.276226338844864, -3.5326344003638903, -3.00405547226814, 0.008333258886018173, -3.1654914855127694, -3.3622117027732856, -0.9513520168464573, -3.6308438855589764, -3.1985711367379124, -3.5891409225782627, -3.2362049293759725, -3.4472590802687013, -2.7566781894766983, -3.7678510119211803, -3.4675553911718655, -3.810299007424947, -3.195506267386061, -0.5401181409333262, -2.296047667753055, -2.646259800641789, -0.4123702584874265, -3.4119087083369433, -3.212335183591848, 0.6282234984995388, -3.3649744580485668, -3.2843385380592247},
    {2.1271536114132, -2.23688639992967, -1.9854263522324571, -0.8236106444577717, -1.235385020491383, -1.169361022630302, -2.7787962261227497, -3.050129362609655, -1.1331235582870174, 2.2111163356478216, -1.8489038894304777, -1.7184433640632668, 1.5813004492983955, -2.2338547128490087, -1.3929105396008918, -1.9856510794679043, -2.686091630421271, -2.1643223509332348, -0.7610156794259672, -2.1821619389679885, -2.423912648605505, -2.970641688389012, -2.1738317518981134, 2.0977950671032266, 0.3925282968210158, -1.0053523208780777, 2.2678218097894733, -2.3444921806158314, -1.6932107005984978, 2.1442285294001553, -1.1093810862298523, -2.1152139115763817},
    {2.57270441066313, -1.680621067051153, -1.5716526084338631, 0.38371848962405797, -1.2929862225000068, -2.011426744530545, -3.2899536715108595, -2.515980382245371, 1.4841214437710757, 2.0644758260550784, 0.5096991399314218, -0.05256633033646524, 0.9982668324450052, -1.3926518728365107, -0.01231686764208336, -1.0495569744968642, -2.804227216222731, -1.6885415670736332, -1.2969439296761618, -1.4235099928941775, -1.768756929074488, -1.9447221567321717, -0.8061818489648607, 1.4190317230022211, -0.3456564184413987, -2.305014633046174, 1.9812983824575727, -2.4235150857644427, -0.7425700895996497, 3.3914461152560715, -0.061395806572236214, -2.4730184779623596},
    {0.7928843960456576, -3.2263110031502675, -2.727358281412118, -1.2262750573786683, -2.6237166211613197, -3.258807182723375, -4.025248259817249, -3.3699349584676335, -0.3590479865657879, 0.6808667199895181, -1.454458633222128, -1.7235120613374502, -0.7314518949408352, -3.067951156437791, -1.6888696973891646, -2.287846983125448, -3.524921404822168, -2.8384636819288995, -2.597450363770683, -3.0179711693482845, -2.600714977512469, -3.2494540926208555, -2.1999924439731533, -0.05324782034747359, -2.016936917002637, -3.3991518648606704, 0.33651444480618303, -3.120639703470765, -2.2526188122924826, 2.1785197525448936, -1.8417811018288022, -3.400637296510256},
    {-0.3478201427135403, -3.3750637437119035, -3.3348115089311543, -2.376299739344403, -3.097970948561827, -3.241923181617752, -3.787708275489135, -3.6119337859996685, -2.1557059875401947, -0.35809486507335236, -2.634346342549199, -2.8712155673605904, -1.568516464933577, -3.3804775528996442, -2.5788325391471196, -3.0844643325955023, -3.719921876472744, -3.2341708787332104, -2.8974746462822876, -3.4601269700738215, -3.324466388844749, -3.5114774156551447, -3.1771863667398126, -0.5579237079430145, -2.109514484758716, -3.226171520467341, -0.49347382876703333, -3.2728323625507283, -2.824881620740682, 0.9299826606596838, -2.7427418593213027, -3.3241208846400836},
    {0.663872760086546, -2.7607393556410966, -2.792915973886697, -0.9775188227267247, -2.479239055273712, -3.2969474328475035, -3.8693862755642185, -3.0374738161496837, 0.22582839556511664, 0.311234574500123, -0.7351849875040187, -1.3252786247796986, -1.1066108545226196, -2.7533239473083033, -1.2333707282790294, -1.968924606316405, -3.7199562712299503, -2.6300069637895698, -3.194046513984061, -2.46406171353162, -2.150520291249667, -2.770375039823248, -1.68695605002072, -0.19116489498372388, -2.5482795344120275, -3.395226616895375, 0.25830295462000097, -3.517655746972315, -2.1803397624504917, 2.185713278265148, -1.78098978598008, -3.9254299803491404},
    {1.4220910326565421, -2.6581886407896436, -2.191232721199799, -0.6471623827474852, -2.08810791400152, -2.7774630629168584, -3.5487871550285863, -3.4655697956097558, -0.26805114850008216, 0.5159587710418612, -1.7932706904710285, -2.013824531430353, -0.2922827661038751, -2.514978698726104, -1.3104289674023604, -1.9108597674897692, -3.6640002411883295, -2.3418040185410964, -2.807831768251088, -2.2822501356237854, -2.6671032132186574, -3.1583168496875778, -2.324818373526096, 0.5688251190522834, -2.0291757075939985, -2.9181079730636243, 0.6927742398738681, -3.2875820888152925, -1.6866532317751453, 1.8373068620557014, -1.136142606626385, -3.6855716360850774},
    {0.9555283148213071, -2.8250893988918246, -2.5680475069903554, -1.3121423514839086, -2.385623938503577, -2.899328435528376, -3.7562937956469766, -3.4497618983859186, -0.9897998993770396, 0.6034929918015621, -1.9848804723896796, -2.453725069983838, -0.33245676877078084, -2.99421888112249, -1.788675923039195, -1.9497530468146564, -3.6393124359543605, -2.867324601000055, -2.8719262868379287, -2.641127696391213, -2.601140466662298, -3.4658511927019027, -2.798433708528567, 0.3989891168511191, -1.9656661650258207, -3.007107910508277, 0.7275524600721596, -3.3640227675068766, -2.1779765891592913, 1.3979815866538012, -1.851648286598564, -3.584080724196385},
    {1.3568206358359198, -2.9572975188983297, -2.654628710072297, -1.1572811491250263, -2.6357227103748584, -2.8788415626104604, -4.1543578885917105, -3.148909807659771, -0.13466428857387858, 0.7600950319988311, -1.3641211458395752, -1.897812857147595, -0.6659062658794276, -2.9031969967249323, -1.5069037631813518, -2.1080550999049814, -3.484144406883521, -2.8594951732967284, -2.965274132335184, -2.6093344166190464, -2.469721654277494, -2.8650941326894848, -2.2356008038751676, 0.6140430111377772, -1.9811734607976967, -3.2206208726888184, 0.5702542901729066, -3.311441908689363, -1.7053501837246052, 2.2674451585197706, -1.8003058860380892, -3.531934770892134},
    {1.6800618185263094, -2.3894756494221108, -1.7096346438705654, -0.2977229930632973, -1.8482313597143945, -2.5832219748954874, -3.8334063163308323, -2.7190695088913315, 0.1932319360744355, 1.1199326683996915, -0.5928704987097626, -1.2161271005551235, 0.11207499935099309, -1.6760146316145486, -0.5823013118375872, -1.3090241818448614, -3.3559254309399256, -2.030490195654565, -2.12260468794739, -1.8364384162831309, -2.0444365775776365, -2.4263257018343554, -1.4729970824690346, 1.0927451596803446, -1.2980344179893641, -2.773021719601546, 1.0246457688465043, -2.9969101355858982, -1.0038047796799159, 2.367754198463936, -0.6029225433319684, -3.0920844157681047},
    {1.773692356579864, 1.4016841884918068, 1.6125901073907531, 1.3511978039121602, 2.077403964724931, 1.0437901616775658, -0.307405424288075, -0.8800979631394975, 0.12044132795736949, -2.191535979344154, -1.8617773106683029, -2.072953856473104, 1.7000385477572906, 1.3321027681245043, 1.6378369024323096, 1.1760921292153081, -1.1403234220095155, 1.5664714023672317, -2.09949414606512, 1.0674308613945385, 0.2298447295595167, -1.5108320236065722, -1.034476772818935, -1.681980253173068, -1.6710870553756425, 0.5967543066124495, 1.6036567366973205, -2.052787691698378, 1.8526406915844538, -2.2531068452800977, 1.7802098655002052, -1.9690842400236368},
    {2.8228497674434307, 2.0958537316262245, 1.9142697287219252, 1.9486049004104686, 2.2765443005426156, 1.7405364726691017, 0.6165804561811107, -1.1066899857517514, 0.6137219732606196, -1.0407773073470499, -0.8849534258165114, -1.3927287128365915, 2.59091558943293, 2.1318739599643908, 2.155844780291062, 1.722568820845685, -0.7369413044565111, 2.073976266148344, -1.487680552821007, 1.8278286737197205, 0.3584659259449579, -1.2444071176690867, -0.8721435280645196, 0.0010564107202925296, -0.532448118106101, 1.0444153309420143, 2.632720685848098, -1.1571300216573364, 2.1259393362281482, -1.665811405751411, 2.2508462277942054, -1.467764153297686},
    {3.078882645973199, 2.232214403770864, 2.5321080099355378, 2.678024692705187, 2.817960306650818, 2.007987578059086, 0.40838903536965937, -1.3404655646359875, 0.8966043364806604, -1.4960458337575249, -1.1742498991810015, -1.8919864155230084, 2.7878401711498118, 1.8627140675903149, 2.6989536732166006, 1.7945789799231628, -1.0869198242090499, 2.6059777017982824, -1.7967826506268743, 1.7617041146349404, 0.1783582668669355, -1.4275452014548735, -1.1434072016691867, -0.6310259363869474, -1.6014747746287197, 1.4992555689994769, 3.0437257830539606, -2.0986158485255557, 2.6570053064551007, -2.3695429361433473, 2.588506296065136, -1.9056769391991342},
    {2.78356569003581, 2.3845038794092948, 2.472648418667157, 2.5391043764934698, 3.042507407684218, 2.262567308399018, 1.0458866341110458, -0.8112246154727448, 1.0683707143988015, -1.5508401957340838, -1.533367113334022, -2.352809922059115, 2.9190253523886454, 2.287134601173061, 2.747195971451606, 1.622204087950704, -0.8523636463915897, 2.541712322454316, -1.3218023754718853, 1.927416374502675, 1.1202080253644893, -1.2273625787773472, -1.0583172426626335, -0.06658792002240121, -1.468831592263938, 1.8560376365280309, 3.1250697168423027, -1.6587107804146912, 2.932952822502566, -2.1893272638679595, 2.456160246306798, -1.2719018200392995},
    {2.8699040713063173, 2.0012545887668005, 2.288628642284, 1.9871408688276422, 2.973188870453062, 2.16504087985809, 1.2976485605593235, -0.31485692475787763, 1.1489415554711724, -0.7860776893695955, -1.1748600561737095, -1.8166218436995136, 2.408642200155513, 2.2394855594615346, 2.51170255084675, 1.5570614158125327, -0.47536845292877045, 2.442056616644044, -0.8677774505268955, 2.105814188330476, 0.8514697462034594, -0.9335787586423551, -0.40568546687146084, 0.6859930028018707, -0.5249388263931019, 1.8875893681246723, 2.8731900224582403, -0.8691541423065969, 2.5699291488803024, -2.4183194046511134, 2.089761628210047, -0.8766794752680379},
    {2.773119923917657, 2.1022544712552724, 2.4525477395784923, 2.3322486689143718, 2.811298179293071, 2.2695810409733337, 0.501523067257475, -0.3767679512237672, 0.9213084200986144, -0.9308596414638062, -1.263062405388478, -1.9281122702116835, 2.601909317636884, 2.141529947580418, 2.416976538644194, 1.422933069512631, -1.211064728476226, 2.7410753304946587, -1.5418851037669892, 1.9500183616621272, 0.755709270561637, -0.8590979425137252, -0.7510788547119505, 0.3875394817737749, -0.4435245969668812, 1.6363253919669125, 2.7050065513323323, -0.9002212997212592, 2.5580444798454667, -2.6525331867701976, 2.324328654317966, -1.0255651596843027},
    {2.8368741110503732, 2.2143281405578246, 2.5970631667480304, 2.20363880792501, 2.773452511808755, 2.166439350863782, -0.13197080775648218, -0.9715384471724129, 0.9291616513937325, -1.5126716389555699, -1.9263307557418508, -2.7515406871886254, 2.6376166654569557, 2.2007153558841193, 2.3547076465853345, 1.2563825330050704, -1.7915306665893804, 2.648537872370762, -2.365664834337659, 1.8646547288828068, 0.46985429222949476, -1.77025503051453, -1.238510398605466, -0.569733089724759, -1.5374713677173013, 1.3623183957378917, 2.912356566055053, -1.746556666547065, 2.8246464419495063, -3.110745778613022, 2.582999301280878, -1.8202478572863545},
    {2.6310525950543275, 2.04962139632375, 2.5017258269879226, 2.681495758070675, 2.7969328997813467, 2.39765256040899, 0.3564006222938707, -0.8073225422252197, 0.8234707723093606, -1.8556579762329928, -2.105142980837841, -2.695965346061928, 2.9044356101781648, 2.092668296874823, 2.582535075804062, 1.5583477139042154, -1.5178897841044559, 2.455429102738441, -2.2525287116367334, 1.9947387413130915, 0.5457806876558245, -1.4749810462170863, -1.0865592520459733, -0.8111623043998502, -1.8083550832481912, 1.5115314991959778, 2.7714064194670613, -1.8452088087845542, 2.573607045082352, -3.2816057998978496, 2.5889049649357765, -1.5913924976927263},
    {3.1648619692098237, 2.4965084724650546, 2.795227839356029, 2.8185668702921074, 3.0504439891247976, 2.0264571345783176, 0.5001039762037236, -0.8009636158950817, 0.753829231621119, -1.5520452871821158, -2.1027829998844085, -2.562230247616097, 3.0470575493733776, 2.033546193761384, 2.704597920704411, 1.7232389193007, -0.9475866204107609, 2.5382780180470577, -2.2372732502685424, 2.020138948738398, 0.8371252463679991, -1.4939303231758496, -1.4257809509390158, -0.8024820994447677, -1.383485424391312, 1.9435695018078893, 3.239902325337688, -1.8409524648560764, 2.8486135125387895, -2.7985690802380727, 2.6118356088907344, -1.746588393633307},
    {3.0734364364954727, 2.2268577168848336, 2.702542328907703, 2.8056899340873143, 3.018391866691641, 2.2266374068899273, 0.34857584443799283, -1.0311392985643701, 1.1808376085080126, -1.7676592248251026, -2.4463337647739083, -2.818660732463642, 2.9880518331065375, 2.26500987591111, 2.8827483487755345, 2.0885259811652364, -1.2216154276875386, 2.658471533012361, -2.3119085408476274, 1.9192877668629043, 0.7290465312199244, -1.578107486807082, -1.5286890263977062, -1.144574136794941, -1.6996126320098732, 1.633040063281268, 3.0643773135111134, -1.9233344525691516, 2.545130558564813, -2.7051232044651883, 2.92775543182208, -1.6332782452539856},
    {3.11955602037832, 2.090240633672397, 2.2613173843333283, 2.645646713810506, 2.5358912112939294, 1.949747153187582, 0.1468029500955541, -1.2562501942063897, 0.9321146680403423, -1.9820712097176116, -1.875921561584535, -2.4797581137659632, 2.7727415271962106, 1.8904947246352433, 2.57395275035642, 1.9816912400073439, -1.5099384598665015, 2.512856440752968, -2.322238589578958, 1.5909565415754001, 0.3535660784943873, -1.4608144296109935, -1.5432248226553948, -0.6103423640859417, -1.240869790481329, 1.322435305583326, 3.1095447391984687, -1.829455669675477, 2.6333868956994393, -2.9515895235608407, 2.5805811560611556, -1.8039352138269422},
    {2.9611751392130112, 2.398297761397394, 2.4728843684280983, 2.666001285065547, 3.011321931402402, 2.278949902331998, 0.8299340718902829, -1.4122407961975534, 1.4950658633237282, -2.2120525397739947, -1.955862914982489, -2.9867040767294557, 2.59233259994651, 1.9154433648577773, 2.7470077050057182, 1.951689437175852, -1.6096020742373183, 2.5967405749704957, -2.2831314786132553, 1.6821906442078924, 0.4991167922755243, -1.7327704882340977, -1.4894564110970396, -1.0955544018919066, -1.3563158339602839, 1.6561312121651937, 2.878535061792376, -2.0609296979626786, 2.80210780645124, -3.1648369908402865, 2.62348720832601, -1.6809371540871239},
    {2.9100491248318807, 2.734640228250724, 2.6711611683175343, 2.8897057024526176, 3.135789343248809, 2.378575631356906, 0.32526653572596476, -1.653600517188015, 1.1674228135021336, -2.5968537841508175, -2.663627983627785, -2.9829936593598534, 2.7108420918947784, 1.9772576601050775, 2.839453296546604, 2.315546120581462, -1.9518596441063885, 2.863364257287176, -2.571978548877284, 2.348112928283703, 0.4092227331353652, -1.713011730292519, -1.4000288445158637, -1.7513759905454112, -1.8102636951897941, 1.7159378547655377, 2.8601609885455037, -2.314926942483526, 2.645733191199978, -3.3433487681090632, 2.660124520302392, -1.8012990345096858},
    {2.8986721154956405, 2.7236496838850663, 2.740559597730414, 2.7157192914090795, 2.954166084514888, 1.891387474284211, 0.06254299885182099, -1.233553343600649, 1.4267607633153068, -2.3493010214690444, -2.2064776176153003, -2.489027807212993, 2.6391498284122696, 2.035113985836384, 2.919815092670243, 2.3123436884071396, -1.7004012553959087, 2.4939816546860403, -2.202413778604263, 1.979127822368646, 0.8858439469781532, -1.5244071183353678, -1.0481004780526135, -1.7238177071095817, -1.733852284518346, 1.4248101791325902, 2.763039636730215, -1.751848528440373, 2.8036883974380307, -2.7512220129557172, 2.839983279472813, -1.5480038079618355},
    {2.1113619816055893, 2.079615896113892, 2.673531933618593, 2.8961037565725682, 2.8231736649955494, 1.5203016021844409, -0.24429458559952286, -1.2096322724079587, 1.4338050097959911, -2.1396303996233454, -2.2625418957536105, -2.5939902811228195, 2.2865421715764116, 1.9294757361184107, 2.6052803373833293, 1.7463771166109403, -1.999342687303726, 2.5602778558410773, -2.5757328189537914, 2.123730396912347, 0.8270345636358979, -1.3105860277822259, -0.9941946086736483, -1.6970840295591734, -2.212362497162157, 1.2912033538780272, 2.433766574596563, -2.219090911745978, 2.8000230860552664, -2.590352653174187, 2.7467379686326865, -2.086045979934973},
    {2.486675164820483, 2.345789987554446, 2.3876200316153677, 2.647873685629736, 3.067741126869721, 1.865103421147719, 0.0608569209204225, -1.7611750453832504, 1.0827958152803616, -2.289070856163401, -2.6632656018805982, -3.08748121214766, 2.795291861375638, 1.8058139763882881, 2.4924315259489727, 1.7797138379150375, -2.134747972215406, 2.6270495540661507, -2.5547441433063445, 1.7950303923792428, 0.38187741768178785, -1.7494911839624658, -1.764214163606302, -1.94817562492584, -2.0628302337922864, 1.498148405357866, 2.8719483310424754, -2.2737771083753557, 2.4712651937610195, -2.5881294996547286, 2.6797876532898135, -2.181118240619393},
    {3.104985750480972, 2.383978020807894, 2.4798637805868067, 2.400688491821774, 3.1393135648053296, 2.4943934790756965, 0.1396418916898476, -1.6098129794771956, 0.7038824143163392, -1.706369717622597, -2.5340903366036733, -3.2108874033891777, 3.1111920066566867, 2.188416788924796, 2.920569713581986, 2.0585542903349068, -1.9961506702110563, 2.8432021298892027, -2.496781311111163, 2.183042595269295, 0.10770693264667801, -2.0247191495226216, -2.212802249787023, -1.3182943962072744, -1.9575705507256334, 1.8489740203578842, 2.879858390825323, -1.965155780836939, 2.961929991621358, -2.7349565733344936, 2.9564774390666044, -2.028801272422434},
    {3.2543373550162613, 3.0902680222540257, 3.1761454813590584, 2.738574596997532, 3.182795295637884, 2.5009177651229444, 0.05282182798912096, -1.7026385669511006, 1.1954575034663182, -1.6767803937711434, -2.472679811806472, -2.856708499943535, 3.234264112857469, 2.7247625989732476, 2.9399084111238585, 1.8398757427859558, -1.7762534148958533, 3.0507019140766634, -2.3706669510860086, 2.5312464257782974, 0.47282009385789686, -1.672269720952299, -2.0380744338986188, -1.206769965621778, -1.8420079134289897, 1.615130732977688, 3.244152167461587, -1.9188555967229524, 3.3019257980632486, -2.629357832700974, 2.992549260148234, -1.9909577301205483},
    {2.887230083110773, 2.578144594783798, 3.019729255764423, 2.672611817481456, 3.176410187368385, 2.079884522062447, 0.044956718151040194, -1.473277833503566, 1.2332565025378837, -2.2239901918026828, -2.472352024989759, -2.933928598980799, 2.8090369980247387, 2.166434509909253, 3.0052899206872468, 1.719205882634026, -1.5267117910194454, 2.802160211047118, -2.301272214672163, 2.2077149621722065, 0.41688499876802615, -1.788370444652902, -1.5631903068200286, -1.4749170054644212, -2.0842635236722944, 1.568527616354655, 2.6906148962685656, -2.266675065425337, 3.143486219636726, -2.6814100487973622, 2.916574429719156, -2.121488625714855},
    {2.730467341423727, 2.8473189778738814, 2.9340002009826973, 2.825673724001815, 3.13805579562392, 2.412967482213473, 0.4963731405597976, -1.3213921240798474, 1.353172710558846, -2.3944155106048326, -1.8917871850664356, -2.5122689898124633, 3.083540862206021, 2.7034470384390246, 2.975642499092213, 2.4338657738032525, -1.881189464940204, 2.920783177826901, -2.7326726106278993, 2.193192304631934, 0.7470659765716484, -1.5609588922233848, -1.4948835191280443, -1.5026837703293947, -1.9484780561220518, 1.8874456555846284, 3.3025037995678996, -2.18526100645978, 2.927916270761226, -2.5781405679462774, 3.061899002197868, -2.2793670854317756},
    {2.8138123964946775, 2.6426138564306294, 3.0345988869609486, 2.6043486528945388, 3.3628318559011086, 2.486575456440058, 0.5734515186262485, -1.4243299974722108, 0.8003190859976319, -2.2935274518809825, -2.2218771546555405, -2.797284025279484, 3.345610101773479, 2.6062383004080973, 3.125959070913122, 2.2741424797615406, -1.8521779510038883, 2.776786066335695, -2.7600139252551887, 2.2262946622293662, 1.0768472800266125, -1.5931751635009046, -1.1088874461215381, -1.9687687398748608, -2.142881134812283, 2.0403427131519947, 3.1846042551939933, -2.2282867008650085, 2.9738187278318864, -3.01493869683646, 2.834713508703381, -1.8240942319024043},
    {2.995418999828397, 2.804562892417839, 3.211883979590869, 2.7932333919920698, 3.1987894948253484, 2.485630408923367, 0.5748548170959349, -1.8219285887496828, 0.8069376296396766, -2.267139366789738, -2.492443203296198, -3.1741088155384842, 3.3407233768472837, 2.8502845663523626, 3.246603414840401, 1.8693718470658918, -1.9813344376518747, 3.0428637809094674, -2.550639129542197, 2.202354668144012, 0.9662013066130607, -1.8953531044477374, -1.8932024989017464, -2.13791163951553, -2.3919610697374396, 2.218614374804595, 3.2331608552445297, -2.5434647086010878, 3.3200491540120267, -2.737745057500731, 3.1243308755645103, -2.499427801540154},
    {2.9451426081732723, 3.1380701644099105, 3.0796131948677945, 2.9690500430425733, 3.3607105972563467, 2.429788374019035, -0.034166060073564, -1.9094687821782454, 1.25932682471425, -2.5311519816213384, -2.4005599724599618, -3.0902378942578945, 3.2800512638357016, 2.9247848225553694, 3.1655531439571276, 2.07453626879913, -2.3794931057216244, 3.0337293262976797, -3.4666850325251524, 2.3678455896462753, 0.7037015518398226, -1.4965132264576515, -1.407631472771032, -2.4587459781681296, -2.9460185049802776, 1.8496122742186587, 3.0605279206641285, -3.0235297185604266, 3.5251210079064594, -2.6573620564336693, 3.321101256297233, -2.879947218846091},
    {2.784406373240076, 3.2794473260192256, 3.2141697724846017, 3.280415029252506, 3.355563508772537, 2.662277786886747, 0.442812968407569, -2.0250957262538822, 0.6949487409303391, -2.583905443393499, -2.528165837917423, -3.2074608991410085, 3.390753090468835, 2.926669932454874, 3.2742496928298195, 2.573726913960032, -2.123468846318634, 3.285762441225221, -3.3719902071155174, 2.4771743081474646, 0.8099292501680185, -1.9439467019593408, -1.8957006804757128, -2.394923234063192, -2.8229085407430556, 1.7679272001186086, 3.0189158174094883, -3.303261625026907, 3.5684766760920197, -2.9165849441143155, 3.058730715232331, -2.430293061538031},
    {3.1162501015907584, 2.8179666633781317, 2.934651678580927, 2.907410059853463, 3.3484428367131693, 2.7732411536046278, 0.8696169711800339, -1.7538030659043176, 0.9424230755969057, -2.2061867525862433, -2.6680305387220624, -3.0275271068548837, 3.322021124686723, 2.6653121937186244, 2.9799376020146813, 2.5640508806524682, -1.8549895010437465, 2.8872427676728964, -2.6625791849634206, 2.6642019601759026, 0.5749767354399624, -1.5271715468350608, -1.8768092417813964, -1.853452231972252, -1.971317029294214, 2.080403164741758, 3.517565830866678, -2.757362616722512, 3.1257725560436707, -3.2046954888283072, 3.2281768333021055, -1.945235233884162},
    {2.8848880264225087, 3.195209229537171, 3.071106663311876, 3.0292232301376822, 3.499352727069524, 2.712084585589531, 0.3648973873603861, -2.158296223339436, 0.9507316927401367, -2.6341369199565516, -2.56978116279545, -3.269800858835939, 3.3788989724028897, 2.746909632352766, 3.179496835130349, 2.3904814292094447, -2.2367183681872276, 3.3649041148497427, -2.9995249146142533, 2.535168796894176, 0.6594329356176865, -2.0576968047049093, -1.76442873868968, -2.341967026250803, -2.5466540955889583, 2.1595502040541064, 3.0981651096637783, -3.2834493547822357, 3.5810615525836584, -2.9558732874587075, 3.035508120650879, -2.6001621043421483},
    {3.3394549688909025, 3.0529798859775523, 3.08308053476078, 3.423341939355293, 3.304681934617339, 2.3600146042433723, 0.13880397467012326, -2.0880621209070456, 0.923807280506289, -3.023818480728827, -2.56675404209041, -3.453671386963755, 3.269989531824814, 2.676672763456526, 3.2641480325614407, 2.3011390466284043, -2.180200101382064, 3.2917990318279986, -2.8177627899935316, 2.7840787696804643, 0.8000020001136491, -2.112278578415753, -2.117464769284949, -2.4813842437240257, -2.5369055332797315, 2.1533354590028186, 3.0938209695874437, -2.8991931350990563, 3.471739610873694, -3.1033124062100343, 3.0988629795656846, -2.5046227759098945},
    {3.2720538805905637, 2.7106938195758516, 2.840261899024767, 3.0488083810769804, 3.067761427030058, 2.538695459441342, -0.21229274739076237, -2.444136257645707, 0.8633203774257602, -2.70381881134276, -3.122425143960825, -3.2533756663371642, 3.075220040315105, 2.434037567320265, 3.245899021579712, 2.1379960568907297, -2.4299496280458066, 2.68570146818742, -3.1998844816816785, 2.2533392931557823, -0.07144886004779881, -2.34455667570912, -2.4377530037718502, -2.2053496782710265, -2.6663720395291097, 1.8285462632932903, 3.167147707313275, -2.947837578024883, 3.1377801925326847, -3.1437174521120976, 3.190691402910466, -2.8747137706537464},
    {3.3991527857818684, 2.8622810944690036, 3.106446444834251, 3.109783296894686, 3.3201215521724743, 2.6737998380855226, -0.2324177232303395, -2.374649033998905, 0.4897510345064471, -2.6948621027664386, -2.824597038377772, -3.326657464678657, 3.1478858604398, 2.5726275916760786, 3.2395078954177485, 2.0237406360689354, -2.6986920106668557, 3.310161507879765, -3.2219228520119327, 2.677434080619615, 0.309142558646471, -2.430619202321181, -2.0318623691207844, -1.842851429300501, -2.564244249190849, 1.8957840280110279, 3.201062686301373, -2.9273755277767317, 3.5740090665060347, -3.073305566401674, 3.2967825023291, -2.6125794049018203},
    {2.9187150610722616, 2.9492555493271686, 2.9024371164262694, 3.0628970919652905, 3.3822483318104255, 2.3526986968866184, 0.15319816832232513, -2.4155289935200095, 0.6632683736566238, -2.6633682892492594, -2.7819416744510965, -3.377085621186999, 3.075748251131362, 2.8800048967096052, 2.949845523307454, 2.0283858457028185, -2.4521292999255944, 3.0010562045408715, -2.9967700230347583, 2.2718355404278774, 0.2431356985890243, -2.117597407384413, -2.0601068028571436, -2.2971146154106146, -2.78291661968594, 1.896906039977927, 3.184723634643925, -3.2964006620718265, 3.2547060004674675, -2.9735398592724436, 2.876590923881691, -2.894975983119344},
    {-0.49144049746312435, -0.975908047025779, -0.5569826183075675, 0.6073053375774087, -1.472473293829053, -2.620568510558825, -2.423807350979265, -0.8007005357801142, 1.7145788426538429, -1.4214103995381295, 0.430467032232271, -0.26445496403194835, -1.7317548897235586, -0.6329571010038235, 0.3049791727205351, 0.7548561033747858, -1.6485917055935997, -0.32613278334497586, -1.7880805767096872, -0.16503844054241112, 0.17237772240791246, -0.7535829780774368, 0.7370333508875961, -2.140033780790277, -2.5182837191987035, -2.863107974613781, -1.721452869190964, -1.721307510735728, -0.261691807780863, 1.9074794294711606, 0.14807060712776743, -1.999810551467007},
    {-0.39670888022141765, -1.2156290727788837, -0.7932015621354161, -0.13022859415817303, -0.3275000781740411, -0.5236323944823201, -1.0490968992940035, -1.3711155504103132, 0.4969427914345931, 0.36871086459088637, -0.19948026605101146, -0.4337841418113548, -0.4609696465106004, -1.3956621751814362, -0.2910865318725067, -0.7419025758392095, -1.0370047113410725, -0.7834338047974029, -0.6402362603794234, -1.0713022389239226, -1.1095608595631212, -0.5964899554172793, -0.8093580552111598, 0.15654019233979932, -0.7768523549783075, -0.7972849211583006, -0.25007619940572157, -1.0705414293196953, -0.7135681128197463, 1.2497357937696478, -0.7161563175758741, -0.8820963460570188},
    {-0.8366286698945763, -2.69978243096877, -2.2670835288550504, -1.4252621452098795, -2.305273679921268, -2.811182511839376, -2.769989175645833, -2.541012304833357, -0.7348249261584503, 0.03388998062750889, -1.0477418316610876, -1.3785366286827585, -1.4619079995811692, -2.6557500472552875, -1.999305164907078, -2.006187588361765, -2.59879332972618, -2.4924701354947274, -2.0882470235090245, -2.39228616254968, -1.843237911274615, -2.3325194958316287, -1.8812067461086157, -0.5247457235729266, -2.20483751292036, -2.7393640341838466, -0.9962236337833051, -1.8848071791665022, -2.370873923584981, 1.3474499767181825, -1.9784383179467686, -2.4396254681598313},
    {-1.0477181913325337, -2.2354129282341697, -2.170778180186577, -1.0104706184461578, -1.8886615197000025, -2.305172158950752, -2.273614435443482, -2.0357691467865475, -0.9673910664082204, -1.0888996108136406, -0.846801632289209, -0.8783677761521639, -1.4180111009926324, -2.2815587627176788, -1.8396088786220126, -1.471468936256696, -2.6119631116499575, -2.1196610841461156, -2.5802349568587992, -1.6694252753469347, -1.2126060848595952, -2.087807879066754, -1.2216080504848132, -1.0521057505765754, -2.2443727193777696, -2.3323162210280914, -0.9089534247067488, -1.8626858750442326, -1.8592734998420481, 0.015046755003755366, -1.7296434751903165, -2.6191771418848324},
    {0.4630102366497027, -2.0017665896150065, -2.3591599554883063, -1.4558061083435112, -1.5572800930720163, -1.2148634605321322, -1.901906927614195, -2.471474099268977, -1.3107456562386763, 0.6368801340797685, -0.9594442826844217, -1.018297803490057, 0.058494352408735115, -2.585561206996984, -1.6045902849435925, -2.0152273061987, -2.58184324134763, -2.1753462175548153, -1.7767313625393226, -2.3528648715520806, -2.4688311895793813, -2.1001006216382163, -1.67206140005762, 0.3394700570208429, -0.9569342715609286, -1.4993739956589989, 0.313258966491002, -2.204539390239456, -1.547409561478402, 0.9089770969028301, -2.0378147843631487, -1.8820562697774619},
    {-0.12607896468845753, -2.0625612846503536, -1.978777526988761, -1.6291880989601546, -1.5959264475655355, -1.185271500844467, -1.6554335352176555, -1.8461009292209498, -1.8620664594374396, 0.09813640862340281, -1.3437474528230926, -1.5270392853331303, -0.8477588171995795, -2.104417910940862, -1.5189763053162044, -1.9595619943136566, -1.6628549189843116, -2.1771772729150407, -1.5959061934098095, -2.396972756373153, -1.911824477928856, -1.850618276722803, -1.3368702333860891, 0.09540747536901664, -1.0512390536054017, -1.0775478494137696, -0.3031879504541502, -1.7883220762592946, -1.4924106411974811, 0.9396975695824439, -1.714051087930478, -1.743061848374868},
    {-0.5486213982959738, -1.7596286660016762, -2.1688078289749173, -1.9239300681149116, -1.5061967900327469, -1.5495658507619026, -2.1921254118813143, -2.0806019101494027, -1.6381499242779343, -0.09952156019433588, -1.9165092132533683, -2.072106516665434, -1.184081494689719, -2.2291795596342214, -1.6345710442724224, -1.5257950774344766, -2.4430101624705705, -1.7357658636963664, -2.1449948282496463, -2.0066179312694494, -1.6067445073267637, -2.1946603943344423, -1.576028566183663, -0.31349612711322955, -1.4349785139138687, -1.7853814041405398, -0.7606553003895085, -2.3479949852800415, -1.3717166566860135, 0.16669378950435992, -1.8253860354705223, -2.354633767362735},
    {-0.7265328962065793, -1.9063907692223137, -2.0727286854917537, -1.4563984335869566, -1.3369836516080382, -1.5298426664720342, -2.3144762113618786, -1.583839887508133, -1.2028538017161572, 0.03803118269481023, -1.5364076439969854, -1.3184569293251511, -1.3454559296999926, -1.829613891714895, -1.5632916788071534, -1.4488383146143644, -2.352526138437634, -1.362011777467081, -1.5135144002238294, -1.6118045916248638, -1.9161333919178278, -1.599948999340278, -1.3132957401737482, -0.22092017574391196, -0.5757615615698747, -1.2795465951223408, -0.8349203970472562, -2.1877080799107915, -0.9207737234958218, 0.5049707061232667, -1.8272984519557864, -2.4003480167118925},
    {-0.6949299420458598, -2.1409925150588633, -2.1700724995906002, -1.8547624742156792, -1.378409944784028, -1.3430590682064634, -2.0843703698162668, -2.441067831650708, -1.5377493376854967, -0.14550985255096585, -1.239879151348509, -1.7669878898200946, -1.0291909333960014, -2.4159480903183743, -1.9756493603745409, -1.7580081154073282, -2.3152467184156986, -1.9101681393893755, -1.7854004404378832, -2.3273507706313095, -2.1614973648303963, -1.9230584800086417, -2.0274105863099345, 0.1892477210584156, -1.1937089184669314, -1.807222381440597, -0.11046314393235074, -2.4337522837119523, -1.5603998338143668, 0.22444276348167466, -2.2694572921752907, -2.437251334173642},
    {1.0526577231848382, -1.5793468427112882, -1.6257969969080042, -1.5110673689532088, -1.2829166439233117, -1.135229657721431, -2.1816240044554442, -2.471694622234472, -0.9452112282186944, 0.9079972440743738, -0.9338958815965367, -1.5841960514707618, 0.08742970116719855, -1.7829739507488096, -1.6558588060534578, -1.6636325448139087, -2.151119774097115, -1.7224424468033182, -1.3006618883763161, -1.71040761004807, -1.7793321243042182, -2.5155861514203823, -2.022622476239003, 0.7184419177837101, -1.313314542329475, -1.5601152439592607, 0.5445151781274219, -1.6937026876359984, -1.7278225411507266, 1.1653564897369777, -1.5026508132165053, -2.309978462255455},
    {-0.6268078587456747, -2.0133486996581462, -1.476646053220611, -1.0713952501945556, -1.8469084500744084, -1.8055361379199169, -2.264909944554135, -2.2785512178261973, -0.8857935009575472, -0.6950118629844756, -1.312457957623643, -1.2105300390430618, -0.878676790921344, -1.6336105572935113, -1.4394424743459509, -1.3239964737975047, -2.5152406860372603, -1.8534667590912206, -2.0112824981628084, -1.7354228213550653, -1.1163514419631364, -2.2285419542379197, -1.585426362076124, -0.5101082782199639, -2.253233634062518, -1.8575659813564112, -0.5159305646783857, -1.968086436084232, -1.2602745547065575, 0.7408995963081056, -0.9766215266367104, -2.7776517398734675},
    {-0.3588702706774156, -2.076494953405696, -1.578115650987857, -1.5106606495492136, -2.110915038765016, -2.1551483216437775, -2.3738964914790075, -2.7301911713886864, -1.1369111776358736, -0.5122028971664092, -1.8520564786080838, -1.8203810545845642, -0.8588132126706242, -1.963131267929415, -1.3922727587557848, -1.7052868770965128, -2.6144361913853507, -1.807458811192834, -2.092867466533528, -1.6890654538831409, -1.8881700097886065, -2.5781342347719844, -2.394798689971298, -0.4891029549557623, -1.607331669891882, -2.038907805406787, -0.12699594857871732, -2.213929917176768, -1.8468659700167052, 1.247600994435298, -1.369334983347513, -2.8341831981661043},
    {-0.877442105669716, -1.7743683146399907, -1.7073888383622435, -1.2017634317919472, -1.7711915355470886, -2.2522946203636947, -2.886459702291538, -2.6609097439337623, -1.5479850826426105, -0.34845222247119334, -1.7984646333194243, -1.9298137285781858, -1.6524530305034417, -1.8805064377172795, -1.1617377270644604, -1.567626196940973, -2.470270908771552, -1.386563755530241, -2.3118697120079, -1.5920078946497673, -1.6454851141257036, -2.0878650938502945, -1.803438577998342, -0.5315291492445506, -1.9325438811522848, -2.3701309659095595, -0.677441776988181, -2.616977580410567, -1.6752770408735782, 1.1094835631889786, -1.543961523649835, -2.7945607001621893},
    {-0.5238412649518065, -2.3232676554266134, -2.3298507703398763, -1.190318947171463, -2.2982536045960047, -2.1064236046245957, -2.8562232157705454, -2.2070322869593166, -1.1455940171800625, 0.04223790772552153, -1.5562996661879298, -1.6390112073133494, -1.544104372071451, -2.014243290724288, -1.3994869683701372, -1.844078027247355, -2.2469250808559065, -2.3571204412823556, -2.179611034163277, -1.8612320903407027, -2.019881379961097, -2.227446039967846, -1.709344875925785, -0.5412007564148004, -1.703243865422339, -2.341046629863498, -0.6569055159990458, -2.4167290887681574, -1.778848159706647, 1.6150221285372928, -1.6463105167089744, -2.5867946027615987},
    {0.5368453131234813, -2.4442164378085858, -2.0910331233336166, -1.4854362329358675, -1.696755426008173, -2.214335415444871, -2.9233474880166272, -2.488944151961692, -0.8617547899591431, 0.5813402807053724, -1.1886999317223306, -1.543638149924801, -0.5951222214976934, -2.2520821033350242, -1.44232824927209, -2.1692977541309024, -2.8562785766986587, -2.4457713779447774, -1.9527392417083784, -2.4111448082171756, -2.4207968322393265, -2.49544975489558, -1.8707766225820217, -0.018425745879507568, -1.4128664253440566, -2.4493141018539144, -0.001646424483732091, -2.174295899675801, -2.0045754676555214, 2.0015174416215267, -1.5560475921790213, -2.526418961107},
    {0.4517243838487553, -1.9457856416433128, -1.5462830574196558, -0.5960727511909241, -1.5952384908904484, -2.100002291082265, -2.82691434176828, -2.5171474587368685, 0.05430522491972329, -0.4231746089159631, -0.8672060643359116, -1.252444888146134, -0.41477050104616386, -1.8149904097146514, -0.8333837672929749, -1.5884026992434288, -2.6940300503027483, -1.884698078242804, -2.319972955189449, -1.6830890383348827, -1.585882439993177, -2.29568525002445, -1.5313606716561212, -0.42470715474826015, -1.5496933866090135, -2.7577232542642593, 0.3114014764090365, -2.3716237358740955, -1.299467485000393, 1.6452597808795404, -0.9491693868402186, -2.5284077498778217},
    {0.07677387514727323, -2.1231750848261273, -1.8638423162082034, -0.4832774216892031, -1.811155958205365, -2.6671371061911144, -2.91896296476349, -2.0636804689320662, 0.6547358762279636, -0.4600830188567134, -0.04554401874440691, -0.40592972497150315, -0.9842174889556979, -1.39383760811733, -1.0310696207564338, -1.2980579717268084, -2.3369575460428473, -2.08842989809702, -1.8956838078397387, -1.544402668067041, -0.9811233611571535, -1.5662038424787632, -0.5525552526232209, -0.8149911460131524, -1.6517404006562546, -2.804899172254253, -0.040120481298195836, -1.8551886842560716, -1.6405057961807474, 1.9704898517403777, -1.1198367399716522, -2.36427600800325},
    {0.95509946246164, -2.186505393728808, -1.7822973704225886, -0.026435012255529827, -1.7616134915583375, -2.0812377305092546, -3.1914645589787565, -1.9245169928129433, 0.921621671265687, 0.536171124809762, 0.1941010911004378, -0.5189330425376741, -0.13285579163481415, -1.5493759306644042, -0.4193996110171846, -1.461046310014511, -2.6421000956448473, -1.7162903689144737, -1.8932977967543203, -1.3071540494662124, -1.2842133357132084, -1.977639994885138, -0.9821276669184407, 0.3710565620682902, -1.382981255024888, -2.3833621224621524, 0.6713299706087125, -2.258092271519251, -1.4347252825391148, 2.3576486746611587, -0.6265906144642647, -2.3670591068706903},
    {-0.03159720937452268, -2.4324168261121706, -1.7606483101559927, -0.5316453913072002, -1.763300725790839, -2.451609076081354, -3.0991681510337763, -2.5803186006140444, 0.5223985571208806, -0.11376112865477175, -0.24613500985314332, -0.9560529288111674, -0.7712244671700899, -1.9794642178849517, -0.6043442977423152, -1.4397283021160179, -2.5813933548527106, -1.7739452134907039, -2.3198438695887376, -1.9330886103262406, -1.9914408597814302, -2.363833061905225, -1.2275209609516475, -0.6903876234231175, -1.7540115438085648, -2.854564605049005, -0.1595527692480819, -2.55724116656271, -1.5806005765246731, 1.9066479649514243, -1.1465066067579208, -3.0425263095622803},
    {-0.46053935048611633, -2.8006915485703847, -2.2906969899832412, -1.2215623676614147, -2.5852269364176035, -2.9330757563990515, -3.4077255063087355, -2.818422954853883, -0.3754761466462929, -0.3970326023041139, -1.0023947333663907, -1.7608191965829312, -1.751263829701037, -2.5916946032184445, -1.6925197557623077, -2.3111457946162632, -3.293098997444376, -2.5763200482938764, -2.6512106074206803, -2.5482600364735464, -2.226297636331366, -2.8607982204027045, -1.7651130233414258, -1.0455655939201138, -2.1203118304504636, -3.0880592836059355, -0.7475118327940189, -2.896879524466411, -2.1700392808127567, 1.7037443135067825, -1.6701432565000125, -3.270973309672255},
    {0.6410500038071184, -2.9364421559263785, -2.6847708774940107, -0.5107332016722954, -2.319654469990621, -2.9954441296650507, -3.7119741317380255, -3.0526843929545877, 0.6208504911684152, 0.1052846767632943, -0.3047731131574967, -1.3505361013131345, -0.8193063785660765, -2.651700889823948, -1.4944192604852544, -1.782385076971528, -3.1451443796924274, -2.535389330744607, -2.455049134672712, -2.4368443086073714, -1.9792653852813429, -2.6544274348393855, -1.5714173547650316, -0.4679027054957248, -2.115390432997326, -3.3681365264652374, -0.041951455322879035, -2.957541572181981, -1.955807436504026, 2.6239773286112413, -1.2846571537540274, -2.961293553018727},
    {2.1776454837648376, -2.4787597634250322, -1.847929213621151, 0.4961692494546742, -1.9651630719403426, -3.185727976032998, -3.9635846378264716, -2.570726271180803, 2.3371404483170384, 1.6657667635551276, 1.203868287751435, 0.27819255321794195, 0.376007293428142, -1.6555154637542535, -0.32856116897084514, -1.4291657184597173, -2.8342601831662906, -1.7679808811295454, -1.8217836787215322, -1.892462186488334, -1.4993555612236669, -2.4013785738569693, -0.868266813014997, 0.625911137113038, -1.435687636276339, -3.6294642106351165, 1.2875080521874507, -2.3548334919222356, -1.2798882585192553, 3.790893513644506, -0.06941510462027052, -2.7120276654049955},
    {2.1439084006823066, -1.506250386629112, -1.2096521764308694, 1.5161677507967428, -1.8141358864686832, -3.528066747280897, -4.181495172225125, -1.9485882860419825, 3.2176060268926108, 1.3487442351889616, 2.251637938883481, 1.3188752080453163, 0.11085066714591156, -0.7335466626469702, 0.7680934175212989, -0.42380988530085845, -3.113286208393934, -1.4368547962336335, -1.9283841329017337, -0.7539948518377869, -0.4032891622411965, -1.2148202366551029, 0.4538897702646854, -0.02529286901911194, -1.6194228530259112, -4.110363859869174, 0.7326820265042439, -2.3783572322738755, -0.48612657490312555, 4.108538554629019, 0.856178851707214, -2.645623435603293},
    {0.951344843508009, -2.6618048826063485, -1.982386842787057, 0.3553009936539429, -2.257519099252405, -3.5614450333762147, -4.093118990615762, -2.3161383369564796, 2.199799405444039, 0.3419018323634649, 1.2287424900696227, 0.24407762505519556, -0.8474586350354889, -1.760065786686065, -0.3802896030994042, -1.1342945862483078, -3.4768676428122576, -2.222680465800482, -2.455692041215628, -1.8731459158634989, -1.0633410631909999, -2.2976569771910484, -0.7371863914313143, -0.43706884067621754, -2.327322590711474, -4.080287552177826, -0.1819480808745144, -2.636546799859621, -1.7072463277864955, 3.4516745907585134, -0.5347871258541054, -3.1691218319237184},
    {0.5206600715119357, -2.6394689134309335, -2.5096528838400602, -0.9427324357651133, -2.4678899284759197, -3.4208840039246593, -3.938559207522372, -3.1476928038306613, 0.21458886353233003, -0.1379292571382116, -0.9843496652191887, -1.3046022196941773, -1.3976251275465918, -2.6560579712616676, -1.3469858206157812, -1.8322962403946639, -3.6564392806981063, -2.7533325220381615, -2.623209351271295, -2.664405026312243, -2.145369709888682, -2.7518147713038505, -1.6643416080946751, -0.9890605702833656, -2.3619525634122134, -3.5686858660378986, -0.6638841130120012, -2.8431457413872243, -1.97429202703249, 2.24459636065284, -1.5049102963142487, -3.4618465986553493},
    {1.4228629206818764, -2.083045466842712, -1.528920483850916, 0.7572758480435524, -1.6679249399464442, -3.447206113198121, -4.080903970654675, -2.3126668413753144, 2.093102242742735, 0.13438758032265494, 0.8816924525440615, -0.1488451408364294, -0.7313815505723669, -1.3034579613958646, -0.23081844999900272, -1.0585846792871034, -3.5125158032525676, -1.7727605158752016, -2.6791647222941575, -1.2540911562597428, -1.0901376910002272, -2.037427986623205, -0.5023259052166053, -0.8743315010750533, -2.395715595279284, -3.7061905762169762, 0.14389983203593396, -2.8136365455574057, -0.9405972489895577, 3.4884824034250035, -0.3692691346333967, -3.3984137625214426},
    {1.1843017775502955, -2.313065606911698, -1.7495938265081188, 0.2778262073998203, -2.4598388390650667, -3.46812239225806, -4.3836480619302645, -2.7754441088845954, 2.470338528482372, 0.3565153948852109, 0.7225082269556002, -0.42601122473598413, -1.3623424564156998, -1.7982970204510675, -0.06854907070041176, -1.2458030753223335, -3.5454671254494556, -1.8988957561509427, -2.819152839540947, -1.5269810271759516, -1.3264317620222361, -2.6397662134693527, -0.9644311869392539, -0.5502744903589564, -2.586893283465142, -3.9671177897546097, -0.2912114954246927, -2.81252553558592, -1.1230855204072654, 3.464125940778524, -0.4068451002303152, -3.41825750708963},
    {1.4333037202513519, -2.513320217183044, -2.247138891843381, 0.30216622254311276, -2.590169416972988, -3.657510716219709, -4.414618461244754, -2.8806790130773345, 1.7755511469212273, 0.06477499598945255, 0.5725096216268329, -0.13179786917241615, -1.1890409593763491, -2.0136519121228953, -0.6256407063968713, -1.3776904821583709, -3.5825964257208365, -2.1514270091548937, -2.888105708569622, -1.6895732950624027, -1.5357663030032247, -2.8010169678578287, -1.0372388075863919, -0.6532498970271934, -2.5500283858656556, -3.962427947115668, -0.08388925672556573, -2.9170706653576643, -1.3771120601119433, 3.41639799617782, -0.4518031706566294, -3.6639622650159906},
    {1.3823388202035385, -2.1698316831714592, -1.937746731233984, 0.6462864187005428, -2.189383638173824, -3.5099510762041817, -4.432743249583766, -2.649224926779973, 2.707151305018128, 0.14629872375385145, 1.1002160307552182, 0.1611241992835765, -1.2977845456462789, -2.0576011111973624, -0.18129330561343837, -0.8177897408806231, -3.478094840735303, -2.081329585538289, -2.6087342075458664, -1.5205699986141517, -1.4405408213659887, -2.2563263763788517, -0.6065838978279771, -0.368024951635053, -2.5066299778899, -4.1480320493924205, -0.14800669332072508, -3.1750197985225452, -1.3315978102041788, 3.5883576918480515, -0.4040045419308946, -3.5417340443921064},
    {1.8733188661893094, -1.7909266433323878, -1.10180562056202, 1.0105169929467934, -2.198239329787784, -3.713897200587678, -4.475753056675834, -2.0319365161912732, 2.8711271546707455, 0.5450143395249332, 1.841721860326764, 0.6724457719815438, -0.7254807363319384, -1.1118013928359736, 0.5444041183635476, -0.1116843297253388, -3.2251446031051936, -1.549877005660908, -2.1402199770319643, -0.8200569157980242, -0.4478196480311675, -1.4218403107584143, 0.17281177160719047, -0.3417995058797719, -2.4273849465718724, -4.159158357130671, 0.01765151436349649, -2.428555955035866, -0.589822323190343, 3.7628244448184023, 0.659272547896961, -3.2457023864884276}
};

static const float b1[32] = {5.5765606887465395, 5.4371809398951845, 5.443859977894071, 5.38220055875325, 5.3196902659664715, 5.347181763830367, 5.278003160965203, 5.519293056975265, 5.521388777644346, 5.651167842930136, 5.354268090158344, 5.334289942876923, 5.53129771607203, 5.549941296895354, 5.234934454629091, 5.421349981497326, 5.444881537871158, 5.461626755721948, 5.593634010455942, 5.39558770783742, 5.401258742770127, 5.5161374676972725, 5.376651312243426, 5.566002995585801, 5.34965164608119, 5.2702945157101135, 5.505112502769886, 5.465275343477919, 5.430424284302023, 5.733127102940242, 5.382954230037555, 5.580676850649339};

static const float w2[32][16] = {
    {4.506632464113044, 5.092052281505551, 5.002165577844733, 5.050964463739839, 4.772044491696251, 4.977353227277186, 4.535729069990138, 4.5341321060416755, 4.622862244784478, 4.944899598273386, 3.8277389390671392, 4.86920299944323, 4.4339808248914165, 4.675668739960324, 4.816511967459648, 4.461995452671405},
    {4.442621965875167, 4.56235696891307, 4.391950159916242, 4.240218228021828, 4.733976272224779, 4.619673275072823, 4.421446172896129, 4.343395836334873, 4.287598129025865, 4.515634549884271, 4.07568772551954, 4.547166283629327, 4.816228211713325, 4.522708838135228, 4.514957291271964, 4.7845512838365645},
    {4.445542974605666, 4.361371715066947, 4.257820849712116, 4.581815374567739, 4.880044580540961, 4.895676701081461, 4.414232286494855, 4.269241450262288, 4.252386226286789, 4.345405764884014, 4.074902620322498, 4.5184703561449515, 4.459357908912506, 4.847521087903064, 4.096358704032295, 4.255866390323685},
    {4.680062645298633, 4.454497299486876, 4.767162895811018, 4.3385418708872665, 4.76096146790783, 5.012631729604566, 4.736710654517092, 4.48397693098144, 4.76058451859936, 4.90449635286481, 4.448111134527234, 4.455190930925801, 4.411336333444181, 4.695181936176927, 4.61090681645517, 4.682633244541879},
    {4.690933812256824, 4.771477474186328, 4.869844597270156, 5.111430006963073, 4.8247275720891185, 4.96564557478348, 4.9071385257061975, 5.070816569061585, 4.63753848733845, 5.00415291277895, 4.603248450558645, 4.43221233752702, 4.585229965390964, 4.416702563730679, 4.251467525166767, 4.954006644351137},
    {4.6587459905346265, 4.572109590024329, 4.765583898190723, 5.032092962727267, 4.963228562857389, 4.667552885818797, 4.548549799286703, 4.644479016860321, 4.808995382071166, 5.138524273598086, 3.9241098016535965, 5.11654393560143, 4.732598992674992, 4.5529884701786845, 4.665416961488921, 4.705915168427691},
    {4.721013923696557, 5.208312424156013, 4.609444298826382, 5.048604849313837, 4.739561450507676, 4.5246863330211236, 4.974816300337371, 5.191402361571468, 5.021327524955134, 4.994875696274254, 4.242347118664711, 5.179737008383623, 4.923774937496641, 5.001217529212987, 4.358488024249471, 4.519641567704073},
    {4.644281071461327, 4.519712701332509, 4.8153380563008765, 4.600249215677204, 4.509291604136928, 4.244495017473421, 4.213799041934037, 4.17424836946268, 4.48987184264252, 4.345903272441712, 3.883170710999061, 4.557179768604233, 4.467292883552884, 4.615689772415152, 4.1627351540653015, 4.336810277517176},
    {4.229616064479601, 4.918224502356937, 5.05521786121576, 4.95180384116304, 4.53795676862373, 4.557461905890879, 4.360060128910294, 4.506032865846089, 4.974271676394914, 4.811114098834171, 3.7776677170485273, 4.831103689652138, 4.433796958009879, 4.999275385821212, 4.234062763324601, 5.003299908763517},
    {4.561894934169344, 4.723525314576266, 4.8640008563725035, 4.596672643640155, 4.418353241632003, 4.021017170835645, 4.198133812460719, 4.291066633142712, 4.684633232814343, 4.970579585990071, 3.933095529295739, 4.849571627657584, 5.000526630579733, 4.55189956479208, 4.200032779923874, 4.175407420013794},
    {4.639230828018247, 4.774915408328329, 4.6027714740825925, 4.531099531308314, 4.635259775847694, 4.5344157012976405, 4.4117126573239265, 4.828203708408097, 4.839381115133371, 5.048724568314823, 4.386928536182111, 4.7533640970655675, 5.047719371365739, 4.780960031116209, 4.457353740395812, 4.742316601986728},
    {4.459477693061084, 4.690404301643116, 4.828699412006981, 5.020174929902071, 4.5758702957207245, 4.495548610082942, 4.476034937238607, 4.985610847601636, 4.816340435481523, 4.774463964665806, 4.196614093173668, 4.6917476956345805, 4.485826205517686, 4.500314575659419, 4.122151847128656, 4.856973216507358},
    {4.222944059712652, 4.710211145513326, 4.946423277750125, 4.724952380722857, 4.601945712889778, 4.364853854750311, 5.0443248659795525, 4.952409932619166, 4.7389762475431345, 4.939613226952226, 4.235629267991384, 4.55380463670746, 4.7034768590798395, 4.727676910888173, 4.666703181604442, 4.717721274398114},
    {4.103032154712957, 4.3168509430906195, 4.533681211885463, 4.157883341109067, 4.523157548248452, 4.61520738842643, 4.6285400749134, 4.181356000899032, 4.2786557303711925, 4.337200943512065, 3.794923562241513, 4.340619145021752, 4.68831722013173, 4.274200671195726, 4.230083140269209, 4.476744618813017},
    {4.6100077897809815, 4.70557264143904, 4.4760363710728805, 4.682504526814263, 4.679343966648301, 4.568511946715068, 4.7405182581063245, 4.614155367101518, 4.898982163143787, 4.530702746385711, 4.295044997647634, 4.433378804234674, 4.4026479482974805, 4.3589430411298276, 4.494801470658923, 4.764857817830059},
    {4.125552764984834, 4.642615402670584, 4.299737618599355, 4.233750769625689, 4.755400011738402, 4.551984894741163, 4.506289911410912, 4.796545736892748, 4.39208230492187, 4.405088137367496, 3.8679171207056244, 4.6564001658133725, 4.63898634139611, 4.852226631032496, 4.494056012170903, 4.548631381133682},
    {4.660516650339156, 4.83484803808575, 4.9254858420481105, 5.072074792283318, 4.909283448746951, 4.489335674616326, 4.994640158848069, 4.979292880613208, 4.613964764757605, 5.0904257925933685, 4.375450535583405, 5.134553429168011, 5.1327573146359615, 5.089407921265155, 4.470009510925559, 4.445728113133734},
    {4.002175669641049, 4.3429668717299545, 4.751807910996659, 4.42749755491044, 4.772890259069894, 4.719653598036846, 4.504328201462694, 4.65898682407839, 4.487896670912829, 4.355657069204346, 4.0400158258420955, 4.298815638440075, 4.139579624926277, 4.130826673835516, 4.350648292078386, 4.27273997007575},
    {4.775955607539838, 4.737825339113754, 5.243158833088368, 4.693314032946503, 4.970718228767666, 4.863314712241373, 4.809438253968527, 5.006826740878259, 5.045161407063984, 4.9068786093002945, 4.351620877472339, 5.200737809155456, 4.903942243736571, 4.398986123594176, 4.513117067793979, 5.011433724038634},
    {4.393677632296068, 4.1997396685511985, 4.667347256365751, 4.75049591680251, 4.7830909414856055, 4.591461780101017, 4.558281064595047, 4.665608326162633, 4.656893725890398, 4.3134880525205475, 4.196925843047588, 4.317983406883653, 4.253830443454244, 4.781949684540229, 3.856044644252032, 4.45605453475135},
    {4.5863445352599905, 4.4378426083894436, 4.294986843279087, 4.400812699126562, 4.71208878331394, 4.712608333089822, 4.238133442417729, 4.736312991945298, 4.592221285784951, 4.30475130880642, 4.204036103043553, 4.776282574982574, 4.562314658254554, 4.372909238741278, 4.226585024022949, 4.650750974054294},
    {4.25671447878476, 4.27579800084855, 4.321483802014858, 4.502483201655357, 4.782400398984885, 4.659128282074638, 4.128467576270382, 4.866879136221278, 4.233176239598493, 4.881852850174143, 4.196609411981288, 4.546643451898667, 4.267397565863741, 4.42842415540648, 4.552495860743117, 4.858376788554433},
    {4.792134207326402, 4.337381493461879, 4.35849549583321, 4.9266312621199155, 5.046837400916921, 4.899075387319555, 4.819280128581762, 4.926151301668492, 4.82522302257517, 4.873958408026154, 3.9747306643738716, 4.621119319682373, 4.504724947837801, 4.3835703050260815, 4.314499339671041, 4.409185783668718},
    {4.590971367224483, 4.5672103015733, 4.866192180996396, 4.576795068519379, 4.935090072206404, 4.655816362077532, 4.949100719148069, 4.661936932326548, 4.647221654980461, 5.249308654628431, 3.740413700607943, 4.596225103750651, 5.166916654509575, 4.492124699960162, 4.6727660230383785, 4.501778284181036},
    {4.92824633865643, 5.0565457415489385, 4.7910507160014095, 4.871657394091107, 4.756157568477938, 4.493513877519689, 5.109435470193285, 4.9391393646880095, 5.174524190933942, 5.197098791222977, 4.418146232036602, 5.094966957663405, 5.340236341294864, 4.719490191282638, 4.904239836611496, 4.999019644590071},
    {4.396848948757514, 4.998043770895672, 4.8417150654317185, 4.600242444036323, 4.683219026187999, 5.030656612994098, 4.951501788296432, 4.942846763622027, 4.872432693407843, 5.31556045862006, 4.1413326310407745, 4.523608362243625, 4.693550116480216, 4.78691149021947, 4.72871573873638, 4.960245366483517},
    {4.485191475209431, 4.534189633137486, 4.76548793879784, 4.618366315549787, 4.932775994960967, 4.398488750672222, 4.637369065332547, 5.017554810203058, 4.824521398130686, 4.623922362136536, 4.125384244671702, 4.531221386687158, 4.857277332708187, 4.50471839752512, 4.495749775119139, 4.475526811304296},
    {4.413109919881808, 5.395870764024777, 4.656065019472285, 5.0514098886298395, 4.989369627640636, 4.883972239241338, 4.723668008050334, 5.001280144611037, 5.157734183022311, 5.238220713123064, 4.544959136110344, 4.993621995111155, 5.182848837873738, 4.797238894546452, 4.280606468011139, 4.734273111240334},
    {3.990369103862329, 4.411511292924742, 4.335799767364939, 4.732965931224641, 4.680449085372725, 4.566252499186999, 4.361058078308826, 4.4324256672789115, 4.387782751175818, 4.391714998302441, 4.350305549368303, 4.567638087845911, 4.450176330268902, 4.875650322600511, 4.1530770769728536, 4.358630572895558},
    {3.7760350580434046, 4.597532819583356, 4.368891541466405, 4.703963573375711, 4.597067738391546, 4.2708172170814915, 4.635945004857657, 4.082445546783088, 4.615562490880997, 4.618191941586564, 3.7198318975286044, 4.663661327686125, 4.374906592573811, 4.058157278680228, 4.175519321884018, 4.00119354431431},
    {4.544406800190121, 4.451050359188338, 4.289359051275726, 4.2205885900152555, 4.852476682734408, 4.510128668599245, 4.6024657616749645, 4.649962164161999, 4.741815324852217, 4.480237635314265, 3.9800234574615336, 4.668076533809248, 4.711268531331795, 4.564482859543225, 4.010208592057192, 4.513011000045869},
    {4.46412981366373, 4.779055936453738, 4.958154781053329, 4.923939354833568, 4.82593405705218, 4.8480684720015015, 4.420966943927726, 4.865897944622161, 4.981986639337394, 4.999391283430761, 4.436536176657876, 4.67640565443081, 4.890344532919815, 4.506504462831261, 4.28656028390374, 4.42171512658372}
};

static const float b2[16] = {4.560549697518557, 4.261042733491755, 4.131647940018348, 4.271632043525979, 4.182744397003046, 4.454300725968174, 4.349919474681299, 4.383157796055269, 4.436128884363624, 4.3565106327920855, 4.64379682339358, 4.207654528233273, 4.317662854457092, 4.392215277429588, 4.630211325007198, 4.416614646198696};

static const float w3[16][12] = {
    {-2.9886762317765245, -3.23462810802974, -2.695421236612034, -2.857610986266896, -3.2216440172669616, -2.722803168997585, -3.5305645785011897, -2.8978290953413657, -3.443133433334367, -3.1771490842588275, -3.3891169608500378, -3.044383109233901},
    {-3.478064568631328, -3.5870353479556076, -3.458401828861425, -3.906622473496787, -3.8929686226277145, -3.344951146232362, -3.044873124773724, -3.2858120539671876, -3.540869030175651, -3.13247022692782, -3.2706300472279586, -3.81695672617095},
    {-3.324351987291765, -3.07878730219703, -3.8416306494866084, -3.3017580866450627, -3.5591687296898162, -3.8137751622254474, -3.374758650776784, -3.6013335094662584, -3.47833025953506, -3.027276717355561, -3.765181293788706, -3.5947206506834974},
    {-3.2141292261405, -3.5516061323676014, -3.2235585366783805, -3.541091316038242, -3.2431448330293327, -3.1185059844271685, -3.7277361228031545, -3.5588414251648186, -3.1823947246070423, -3.3344108997790936, -3.2371139262890853, -3.059607898620788},
    {-3.3263572729170163, -3.3313235825548273, -3.281794983348137, -3.8342005475585115, -3.1642704652099116, -3.393951833342213, -3.276469645813534, -3.5520694403878372, -3.7839522029030723, -3.7673680216988314, -3.4405233687527854, -3.0985439576032645},
    {-3.2328900532697022, -3.511701662215028, -2.9624649447629676, -2.958276104622367, -3.086078461061806, -3.17784975621053, -3.8502436026507167, -3.05591243801548, -3.3958318646308268, -3.6793948656626565, -3.222958121336419, -3.8704141673286636},
    {-3.8717359649159957, -3.3362440815027496, -3.371774258987983, -3.7881061371810247, -3.2172667020325245, -3.098871689916721, -2.9601532578842438, -3.6782566555978393, -2.899821611533154, -3.042200804986106, -3.038653651624972, -3.309843372730973},
    {-3.0938172884270343, -3.485534456170448, -3.3175457042987713, -3.0470627350509876, -3.8273586027347393, -3.6800937788653, -3.385864153403816, -2.8444003065533927, -3.188147048929979, -3.1646296213569287, -3.3153315103780376, -3.2336473504453034},
    {-3.8805197753487657, -3.139983590070534, -3.656332835398807, -3.1022112866727043, -3.5793712431470057, -3.7842043448428693, -3.632844989362811, -3.5064214943399077, -2.961450221579574, -3.8161946233784865, -2.9905345790161304, -3.1008117928379737},
    {-3.6045993488887014, -3.031476796914377, -3.1329458775411894, -3.9532902561562864, -3.2739373094195554, -3.4201313991260722, -2.952798221484777, -3.131362931671527, -3.7400436434327835, -3.4924298878173827, -3.5621439211808514, -3.4496024548773376},
    {-2.6914700536410407, -3.023308282075789, -3.1134205352833626, -2.7358782042183436, -2.8842306637749444, -2.649699798676148, -2.664547592260046, -3.2396380145287162, -2.990182999013291, -2.5760132808710545, -2.8395755166875793, -3.295654207323564},
    {-3.1093144121047462, -3.7257952253725453, -3.633589955993835, -3.326305325446981, -3.4196636264070217, -3.8885234070310815, -3.530160837316331, -3.826197298624169, -3.87775227424809, -3.5589212266134744, -3.0186074253497126, -3.702607138227264},
    {-3.880164147701551, -3.3954772918652796, -3.439735138337043, -3.4130065151006193, -3.3375449325572677, -3.2887541482554683, -2.877251447322666, -2.9602942985175122, -3.2051367848773102, -3.4596298864124964, -3.556806387836624, -2.9744963020543373},
    {-2.91838690086392, -3.4218380848090546, -3.512074205464652, -3.053474934306357, -3.2307718777460814, -3.1044518534029355, -3.494743022333979, -3.5265255848510497, -3.186100893034, -3.567487609797412, -3.3320067530966333, -3.334958098053371},
    {-3.1264911561391755, -3.0234617136389055, -3.186754807650212, -3.04281449784771, -2.9194047561805556, -3.0954471534378274, -3.332607054125041, -3.041913331663808, -2.6370779469890007, -3.260790688389667, -3.7008978660334146, -2.680295924435946},
    {-3.271651851166091, -2.919653166819357, -3.2062509956080376, -3.137224307363667, -3.154177821188785, -3.3945180618204347, -3.5060513145978196, -3.5493403807595945, -3.535994757721346, -3.07995727438745, -3.4339191099653363, -3.5276005830230437}
};

static const float b3[12] = {-1.5385723499101596, -1.2630040105164084, -1.6650468184193343, -1.7201717743711753, -1.6050794228239067, -1.673995390183583, -1.599041916993167, -1.6351321174180469, -1.4014185342996965, -1.4788143658937551, -1.3408148630587151, -1.7553181770029513};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
