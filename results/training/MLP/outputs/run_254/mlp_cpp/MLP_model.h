#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-3.0121855044550974, -2.6464080484164754, -3.974608635931322, -1.8148830521625596, -1.6648597823285143, -2.4998646795132458, -1.5572923951043554, -2.375570096413823, 0.8631863021383122, 4.60280504694355, -3.9861367183063825, 0.1610473321307211, -1.889392940698534, 0.4700278357162529, -1.8471036449778961, -1.3957488564190683},
    {-4.377235844245527, -4.066273463302704, -4.200554597500205, -3.8851761804333536, -3.0918362253224334, -3.9463969093278557, -0.9048049272011849, -1.7401641830837997, -0.6706966877161198, 3.4856678278206443, -4.72774414843851, -1.9919893668373252, -3.9285245642167723, -2.9925513885072883, -4.497452287184527, -4.203986331170389},
    {-6.587110936362631, -6.137954491511576, -5.4518387303178875, -6.040137465971785, -5.5926813729840745, -5.8400154810724985, -3.7719251002491876, -5.405018897505598, -4.593825539577386, 4.7494411031547585, -6.351023509846413, -5.2263087645510815, -6.113529287214817, -5.5367647177659105, -5.925143285418126, -5.571465040025625},
    {-5.977071326227692, -6.100235028812693, -6.87987285772935, -5.8204198968230925, -6.198082287819545, -5.081623265790905, -4.4507372352111165, -3.7580282372192766, -3.836168156014893, 4.218808302055518, -6.869910216361379, -3.8642936595679864, -5.5274932239127725, -3.712546034814759, -5.5258392090105115, -5.406234167988901},
    {-7.030612308177148, -6.83292958409883, -7.378270650692377, -6.633290456494035, -6.9704418404634385, -6.097425428534868, -5.973577659163167, -5.000260728741869, -5.739953219640626, 3.938321314973635, -7.110370901542867, -5.622116431973147, -6.743278207212269, -5.039352991004575, -6.714689159000121, -6.639038499506269},
    {-7.2904884271087935, -6.636425429878902, -6.8834397190984395, -6.717542836071137, -6.910877337163738, -6.550874565565037, -6.272163431035666, -5.202951072655374, -5.794791462223987, 3.492540856738726, -6.998238328991827, -5.822509624700285, -6.803879617379685, -5.702131413555134, -6.859513746617315, -6.7074278961931775},
    {-6.808680700594445, -6.662574492507192, -6.43677529647956, -6.138309678858416, -6.875343225602309, -6.21972138898534, -5.8869143798385934, -4.678356439090107, -5.3076836683377175, 3.598516990090713, -6.62073932744065, -5.573279036487685, -6.497774349182858, -5.612736241620772, -6.574681236901311, -6.745665596271828},
    {-6.613487953061038, -6.287305433444531, -6.8551742700766445, -5.769702973684919, -6.359892697076806, -5.8571871415236485, -6.018947655587233, -4.411391608957932, -4.636905529237399, 3.1204693802889887, -6.593507346038029, -5.510605805500983, -6.101513006720558, -5.163270381631401, -5.8930397293926315, -6.112914901053769},
    {-5.831719014234562, -5.777460473682896, -7.193849303350973, -5.398897211293781, -6.660303274164244, -4.8830054708942185, -5.43317380645476, -3.703083828211878, -3.7451154167620007, 2.236950093079979, -6.799065573089525, -4.199026806098516, -5.583688295949897, -3.9535663648803205, -4.868244727895498, -5.0311574873507965},
    {-5.730939259026027, -5.619366792550368, -6.848779968314962, -5.3264393046651035, -6.331880425303835, -5.079598467019616, -5.1836924618862446, -3.6024072410610835, -3.5213204043518305, 3.1635099878084425, -6.500949545386571, -4.258385278315062, -5.722268669552085, -4.199904136334289, -5.332945905371721, -5.422190456791386},
    {-5.633304926828298, -5.483666983865312, -6.164781273524843, -4.895653267516107, -5.818828835721434, -5.456940258112935, -3.9936415642251006, -3.1544112953934436, -3.6002967923802096, 2.473329402056847, -6.4967766345111775, -3.368457620974209, -5.424734660544946, -3.9636065435957937, -4.762177295082021, -5.591406435549337},
    {-5.480595789677035, -5.803973732558087, -6.683660951389764, -5.227091896349356, -6.043307654914645, -5.259715298908925, -4.615270836135811, -3.919031372651326, -4.55864285197286, 2.1612462689564444, -6.091656315867264, -4.274421783344514, -5.5328434816952345, -4.634055808192229, -4.665313689709013, -5.758654051424498},
    {-5.9238186201581735, -6.354725300718908, -6.7089666122289815, -6.221390491913535, -6.320205890658857, -5.6732295006556255, -4.659248926370208, -4.549342089997265, -5.002192755927993, 3.1190603930132847, -6.671283981882137, -5.274485669214327, -6.030830290378419, -5.894036093844843, -5.146675135692323, -5.879753337150641},
    {-6.378039538264147, -6.523216953981079, -6.5686757798850595, -6.203921714562084, -6.360913089867647, -6.008212998007291, -5.398802212482318, -4.841246493672458, -5.143349329622263, 2.931569420376039, -6.4296817406156315, -5.820035817322586, -6.494151948105282, -5.944653240102838, -5.708859164287796, -6.0461590685599305},
    {-5.967847783549301, -6.324259310786184, -6.233380496100817, -5.985725515967894, -6.199661117174192, -5.650983037752607, -4.9249949467618155, -4.673876724049382, -4.431188260321934, 4.134675890535182, -6.244024386566905, -5.648277245775256, -6.076795623004183, -5.650270008685376, -5.685298860597184, -5.762795933383463},
    {-6.516756482671028, -6.384736944871632, -6.846019586821084, -6.319804836308204, -6.808044980058225, -6.093972743339486, -5.629581736812466, -4.702342063075206, -4.736809873215307, 3.4260200952379187, -6.764031063609764, -5.905939460987426, -6.338589950576072, -6.068266349401336, -5.694992264447869, -6.440132320742706},
    {-6.462240402970095, -6.131984566940707, -6.648517899431642, -6.042587309236475, -6.638663155520055, -5.5235151687738036, -5.215365813397593, -4.5162965016897445, -4.512693816744895, 4.642658103513114, -6.537305932283776, -5.563939071779126, -5.889333925262692, -5.392023373832225, -6.00414301905553, -5.653738674585199},
    {-5.766346353323628, -5.908033776046588, -6.042920938008514, -5.772431177719815, -6.003743778971126, -5.066338745278846, -4.728786560183918, -5.036240520351875, -4.831310445606272, 5.490840332202392, -5.950183775556265, -5.262446753632799, -5.793774792609587, -5.737325890431286, -5.267648351023194, -5.079727072104925},
    {-6.058501282446391, -6.1239258659581095, -6.18779575786634, -6.035131869887673, -6.235995254423581, -5.687779149209703, -5.157045041023255, -5.345525971517583, -5.090446495586667, 4.920415882683473, -6.171349882228468, -5.364121340156006, -5.795341654818226, -5.415386883014828, -5.519575820590583, -5.086504085836238},
    {-6.358664265020407, -6.190347878985057, -6.956693362422313, -5.772699924335822, -6.410836190757408, -5.684640857930348, -5.776458905003555, -5.308500818271064, -5.114694420243436, 3.8534769345068405, -6.856233440902195, -5.6170262285871635, -6.363341611566131, -5.110165582005883, -5.307859599724571, -6.053379800923926},
    {-6.1632583095581035, -6.203755173770952, -6.871252009612615, -5.724756904724608, -6.590388447845457, -5.809232361350926, -5.294012398218702, -4.710344958101477, -5.138600458085148, 4.10811160932435, -6.8411953971470165, -5.566893538369157, -6.087788775274061, -5.256034991733719, -5.572512896172013, -5.79743179068393},
    {-5.4570004668395296, -5.726900046745488, -6.164133870410899, -5.247034436190536, -5.272654754086915, -5.061405362889004, -4.0763934984108126, -4.765782158078523, -4.453511758031281, 6.215747683025484, -6.15200659510507, -4.845913462166129, -5.582954888413357, -4.52662173836231, -4.946278957923586, -4.916110119445049},
    {-4.978033314448205, -4.995651553540123, -5.3139176812010485, -4.758189172853847, -4.837577282671944, -4.821374047214866, -3.8344929093575315, -4.979761794644107, -3.619503641185179, 6.23489389971281, -5.612542367503092, -4.114368840159114, -4.861154169333517, -4.106737964720598, -4.670015652487902, -4.332630694214134},
    {-5.395919662822039, -5.620945598944368, -5.875843749975129, -5.278727755156509, -5.835253855306929, -5.049635850647055, -3.9593937882122425, -4.063604281176036, -3.7631262066163464, 5.508872934060852, -5.971860390480747, -4.685756274225533, -5.412621749833424, -4.559307439776015, -4.942890893673491, -4.768637281375501},
    {-5.694737609806439, -6.194823639447806, -6.2771137932077545, -5.430008476417813, -5.514558558114086, -5.267243797368929, -3.8789201024761186, -3.586493470269493, -4.001747052203191, 4.104836396667246, -6.671083975580698, -4.632615936424857, -5.699742172149491, -4.532082209559941, -4.612400399224488, -4.933569698876685},
    {-5.1701073685668275, -5.3851710695171695, -5.779113738303779, -5.147412761832767, -5.445302029777399, -4.938299240524854, -3.578268534276624, -3.834668858775541, -4.099972366640858, 5.467502246583024, -5.703561061520384, -4.1846975684222905, -5.542666291060562, -4.486665999921397, -4.606727289961108, -4.482101691065472},
    {-5.560478416819122, -5.471226782533608, -6.046971887489555, -5.618641891568985, -5.5842944016920395, -5.053145181764821, -4.20227229570043, -4.3590687766482175, -4.1313787620490166, 5.659745428144613, -6.163264265881723, -4.60681378071809, -5.576319546479616, -4.759457340778884, -4.953102164980779, -4.616328645320077},
    {-6.145305810641602, -5.8622615121581, -6.376963600807178, -5.67722980880066, -5.751851193285369, -5.476574526118497, -4.529696070181486, -4.841052065954347, -4.4085036082066695, 5.22922795828141, -6.564533532150338, -4.9027199510535056, -5.953965176594449, -5.106572053103592, -5.287387444292613, -5.222281553839757},
    {-5.622569439131476, -5.878264583010701, -6.088681381782121, -5.400951249209915, -6.134542512950934, -5.56750572919501, -4.741229282494894, -4.621175824900963, -4.362418891731929, 4.581561052544802, -6.350428530744313, -4.816042524046385, -5.8946900122490655, -5.082175748100584, -5.429179397450877, -5.294958579166539},
    {-5.206919543728931, -5.52407990993136, -6.3999851317555505, -5.253799464174267, -6.254267162542323, -5.261849441696791, -4.446144627619555, -4.2747684722595976, -3.846389361652689, 4.196772509505056, -6.180961817701889, -4.6331839449887555, -5.797349846303945, -4.8047867192080105, -5.0350248253844105, -4.9885425564220425},
    {0.3312598681303987, -0.5260897769269639, 1.7639711771054174, -1.0755524272489119, 0.6164041198476973, -0.061885912080597835, -0.6098452367036251, -0.8466668342992147, 0.17352277364223131, 0.07157355695809059, -0.38596124521791053, -0.1876166128307983, 0.02948421641792969, -0.72867071422097, 0.7246972756976418, -1.6759666512260414},
    {-3.1129535520799503, -1.541290650634271, -2.0342302522712084, -0.840025027154089, -1.210050398934088, -0.9109996036832175, -1.4605529529114243, -2.3315402693534253, 0.5252486200897403, 1.030385438933764, -2.457110448042382, 0.5538553387434515, -1.8905827738341017, -0.8484121834516432, -1.2227486356923434, -1.6144396368823366},
    {-3.3794870426380323, -3.5238104041708422, -3.3901879755552025, -3.376230899325925, -3.424117950405855, -3.2305950360150004, -4.404361338776561, -3.8223219340206276, -3.6202947966431567, 0.1261504091371702, -3.095308587858948, -3.5227315580287217, -3.360517965880661, -3.316426046034864, -2.853118928099162, -3.290063442708018},
    {-0.770459241632249, -1.2691600983161602, -3.6693720064931283, -0.7965129474278062, -3.123123767060023, -1.4987818061301696, -3.333759649672423, -1.416331064453798, -0.6849982214030982, -2.055464707071603, -1.5301701281200404, -1.0155995123732977, -1.3417124911648288, -1.0987826119537267, -0.5772325200800962, -1.49483430720345},
    {-3.1973368776844313, -3.3739588246851464, -4.363559606475369, -3.2161831825401435, -4.065375704223019, -2.6387176678813575, -3.8277024967602498, -3.0755346081716723, -2.2208225498871346, -0.5416418585522519, -3.475680795520156, -2.3554922540679644, -3.756800274930801, -2.6594750482124114, -2.790729228805983, -3.316472149310971},
    {-3.1315957322376184, -3.0096983481526833, -3.8531598351233933, -2.5487608882386876, -3.6944545387867658, -2.448190064029871, -4.205502676221426, -3.130357231116276, -1.3157113469131854, -0.4236104659660921, -3.174395941912706, -2.2005561557507227, -3.216465027224429, -2.092065018076589, -2.438323837950442, -2.909276792756447},
    {-3.1204403395715743, -3.3245524395588353, -2.82926775342735, -3.5094971908643915, -2.883118532115567, -2.9411152008665944, -3.3349759548443005, -3.2708294811265834, -2.0814424052595117, 0.6920462326477619, -3.239945681245388, -2.72416052608484, -3.2109288634745417, -2.727488178939002, -3.1259358879070582, -3.930714499106645},
    {-3.104765743372765, -3.7448396526349703, -3.0645492124047267, -3.0075298237186807, -3.132721186519688, -2.6182109766255715, -3.686548926678578, -4.168243153553613, -1.9982145399328506, -0.20075529851208002, -2.652759877923409, -2.7307702762669583, -3.2709989900812357, -2.913025820391594, -2.673584803282808, -3.208881138597636},
    {-3.5328336596656533, -3.5731904169432536, -3.8009375002955723, -2.834205460103943, -3.6222408826882773, -3.045242889014361, -4.164350442955689, -3.724186957703673, -2.103649851963234, -0.04626723807052249, -3.8116396173509273, -2.303438222847873, -3.256306343432, -2.3466516852938346, -2.5731783774199806, -3.624257752825292},
    {-4.682932294136182, -4.656765123835757, -4.836222702028069, -4.486571823607021, -4.820039249963548, -4.278104962766732, -5.12932442645561, -4.472994676291177, -3.1326560871131375, 0.4425927205468242, -4.7653955317567815, -4.024471141115558, -4.268855905565217, -3.9628813080112497, -3.9792489503224155, -4.8467050090806385},
    {-2.697905533111719, -2.8814781878646496, -3.238090037343578, -2.5621856854229184, -3.0681136324131466, -2.191243455609787, -3.035096588699103, -2.2856515990579944, -1.8311233145438695, -0.8862864224599878, -2.6501359020361797, -1.5604594954124853, -2.5601635448088382, -1.8837473230664796, -2.1421165495306003, -3.4580356493753532},
    {-4.167722067122708, -3.988864731450524, -4.173652681442893, -3.9398663159655776, -4.0073451419061925, -3.9030278508348215, -4.367805102034339, -4.18050069023617, -3.1433410427675477, -0.23224669423099992, -4.655578983880752, -3.873406218277373, -4.174291999415665, -3.538408408623242, -3.5707794223277625, -4.415648637482232},
    {-4.293028361794082, -4.438895756756996, -4.148990653874625, -4.840670791661384, -4.257491088740491, -3.7212788587569348, -4.444175818654469, -4.509560222571875, -3.666185575091764, 0.1862627666215269, -4.3535845186441, -3.9684081291240156, -4.258778138299666, -4.338431477200363, -3.8439274226102444, -4.65540632381531},
    {-4.7072899891544715, -5.3413065869047935, -5.740647651247122, -4.537462881774264, -5.335502545934734, -4.4819524393164265, -5.790614547700305, -4.920659468781152, -3.6636842230598092, -0.9853025759948842, -5.11751285291509, -4.224627984183143, -4.895205434135239, -4.054447480045597, -3.963186969875265, -5.061038885962922},
    {-4.880758360035869, -4.9331710664905355, -5.073173907944126, -4.823974896155564, -4.52731217502161, -4.722709283106029, -5.555392261955851, -5.1596483931730175, -3.792309495229602, 0.9806166317458858, -4.862220266852499, -4.248724493609248, -4.861237125236011, -4.229000271274033, -4.333103684722312, -4.859889603418102},
    {-4.9181464455748065, -5.132224883787843, -5.590184228766011, -4.264600708314164, -5.2075705968339445, -4.4444652336439985, -5.942587289995235, -5.388464569041559, -3.6190702505919594, -1.2203995327350488, -4.925280422112029, -4.439341511445607, -4.651793327573744, -4.301882109739542, -4.306382307515681, -4.934691633571333},
    {-4.468870211110314, -4.457260264879492, -5.335021785124334, -3.9963101377432944, -4.983691935936965, -4.010620485443121, -5.613404059682929, -4.789982805687097, -3.085028906339424, -0.6332633098366608, -4.586081424453216, -4.0305664059821, -4.245455740519802, -3.7887595709288275, -3.9457606141155583, -4.126645091402504},
    {-4.302374596778395, -4.307536824585562, -5.005527493618743, -4.227501766992865, -4.82060875884264, -3.8524770765111627, -5.473219376642572, -5.20561723823412, -3.292322631353738, -0.3152206659431584, -4.006515813357841, -4.6288586417567545, -4.167235410626986, -4.400145218977175, -3.7125265608750566, -3.5143774208055794},
    {-4.165380818646784, -4.654727057177805, -4.243936589037409, -4.937651543280183, -4.481564487949835, -4.411260260478518, -5.046778657103608, -5.4319045365161225, -3.8931454248283703, -0.29214615532134114, -3.705200466727689, -4.743780928074762, -4.709224341636523, -4.447549396994446, -3.9768838299224765, -4.293011503848524},
    {-4.915826444663815, -5.0513221173931395, -5.446444418194525, -4.621789792664621, -5.234756634716342, -4.366042172749699, -5.962092476210145, -5.337756070674483, -3.1265192660871213, -0.5558005346298196, -4.870422865866427, -3.980761714494697, -4.7638258217622065, -3.9883165507175873, -3.788569487223593, -5.363534589646417},
    {-5.491870798703808, -5.660125197026028, -6.151458939617366, -5.3218918855230175, -6.021885662492886, -5.501978784538664, -6.229652048043336, -5.132671634138719, -4.4592336258965615, -0.8021192482273075, -5.944786735920608, -4.805406761187913, -5.527398216083604, -4.571193871163144, -4.922321214761962, -6.210042210857092},
    {-5.6989922593293985, -6.059616422098288, -5.500022255663478, -5.32359110624256, -5.268128410944817, -5.478695734626851, -5.793991747426986, -5.5221141631583714, -4.606346522891464, 2.102209888832907, -5.580487581813179, -4.630311871575001, -5.598912424677269, -4.568836099746401, -5.0549729293508046, -5.652016607061458},
    {-5.495809288487367, -5.5328124715049025, -4.209625806754492, -5.076217802193573, -3.7103943710926606, -5.346036160263739, -5.092254921913057, -5.466766393468316, -4.307916219355359, 3.670484902521754, -4.6201879358714555, -4.354360939083555, -4.771291924478852, -4.59866175811402, -4.877848552411298, -5.007465536330392},
    {-5.231980221611005, -5.19490940113186, -4.419112462523491, -5.350887177170536, -4.1749257533507, -5.238683230486198, -5.374065443558761, -5.114920663004195, -4.136855782390175, 2.3996550083397508, -4.147350802138576, -4.629980669963236, -5.305441186226689, -4.612159561324395, -4.604564448073698, -5.010149219330285},
    {-5.632263036841897, -5.583073751745643, -4.817947305326244, -5.291887720611432, -4.918191205007718, -5.139136331888309, -5.286839672352686, -5.590676806968273, -4.115524289217623, 0.6736520701202057, -4.407673967656389, -4.8621066967153626, -5.410181202409115, -5.181096477414786, -4.521814864010872, -5.21392701000379},
    {-4.186896970222854, -4.288196828653815, -4.223681833918618, -4.557784150613546, -3.830492637604772, -4.057509409125432, -5.113947271321769, -4.555648510380063, -3.3400303840270977, 1.9413948453083094, -3.394018167342838, -3.291446587430679, -4.088056131728069, -3.563028012082936, -3.3215750302627662, -4.27750196180804},
    {-5.201509815098384, -5.2488698967498255, -4.707591722924913, -4.816482065655222, -4.2831202006063975, -4.931364155136451, -5.6934736543203615, -5.1479778234351965, -3.3607696177420032, 2.144883287356926, -4.372969597539882, -4.122441225771427, -5.027570919763984, -4.315227144779425, -4.156059891100398, -5.086043065411226},
    {-5.887332800901358, -5.721852843521035, -4.114012019558254, -5.240083554561929, -4.313825483710081, -4.901397029866886, -5.3770301161741685, -5.584043952204456, -3.8204645049108548, 1.2591765824065158, -5.0617942120951005, -4.493074324475421, -5.650644054787423, -4.387677951345468, -3.9787156522145413, -4.449345299153444},
    {-5.152059120897567, -5.228040179735565, -4.903965171201114, -4.72470163103922, -4.856986479551986, -4.843814407663985, -5.614169537574644, -5.073621943784471, -3.6838729506996457, 1.5931780909031867, -4.409262399282425, -4.220856646675557, -5.205754255051406, -4.32560824694597, -3.840006784675924, -4.4543987937979},
    {-4.785306704805333, -5.015023352592312, -4.944206929423351, -4.34198016519592, -4.722456010332801, -4.525618074638657, -5.679067792942308, -4.916775279931081, -3.0161568486478907, 1.2297092892945463, -4.543305766534634, -4.227520266476291, -4.457092507679972, -3.604055723187878, -3.587262757148177, -4.425350415651071},
    {2.9762904749762327, 2.803412023929759, -1.38299269798191, 3.9591808413968517, -1.7260941358849793, 3.2362159637782084, -0.09882318639904525, 3.7777199170554714, 3.410383495479183, -2.8863565340582547, 1.4303701036741938, 3.6356397880073468, 3.0152822101303456, 3.518690887882268, 3.042461066451874, 2.789907397228875},
    {2.02806043721828, 1.9743048885840822, -2.7285808576979136, 3.715424746384138, -2.7236551913532345, 2.85184099690204, -1.3521484491014313, 3.265323806323757, 3.1835027918790977, -3.139241861161789, 0.6865823051344546, 3.7628566030607384, 2.454428731403659, 3.04466292149195, 2.8907802998692835, 1.73568107077896},
    {2.9868019153022, 3.389443871461822, -1.846657887496038, 4.674347753830062, -2.225447994392798, 3.8557629902807213, -1.040851044193315, 4.369169560432437, 4.277529538622136, -3.5581257729117675, 1.8142278586530018, 5.039296330186527, 3.9075848976866565, 4.455187756413056, 4.027937009508735, 3.313625095825796},
    {2.496910035738115, 3.4273729441938205, -1.9823093700590084, 4.384959071996684, -1.8526160358558583, 3.578997802321247, -0.7673067743814578, 4.177618274187787, 4.054067752349806, -3.2922502828677653, 1.5459811257956368, 4.3944110217073975, 3.6750044831897273, 4.234432289103022, 3.5938722579191147, 3.555749879929081},
    {2.4678882588098094, 2.9250014709194425, -2.7354755538091733, 3.9007270489608374, -2.332992259429588, 3.2860736959711794, -0.9719786693326448, 3.778338386839875, 3.394957760517378, -2.846776785983211, 1.1759015429772537, 3.973864687930356, 2.9383295979100423, 3.534824098441825, 3.283715038418449, 2.931088971575082},
    {2.5756497033873735, 2.948694503912228, -2.534663094556611, 4.147205534241108, -2.454282709393046, 3.728120814655029, -1.2839442904902503, 4.270241896297179, 4.126957648567378, -2.894999833644611, 1.0185227247128188, 4.333263134204793, 3.1204623936583196, 4.076006462802533, 3.636295265377917, 3.0264706437026643},
    {2.492376799522391, 3.2558096700993064, -3.0646852853146127, 4.296186671603989, -2.890048850549084, 3.945614461825693, -2.136662665167753, 4.598162663681899, 4.403273317584135, -3.5162425965175585, 1.2591726955489588, 4.627501661974834, 3.268784346705392, 4.342969995599637, 3.8705294952065024, 3.104002443142682},
    {3.1666577483290324, 3.66568606773044, -2.250926489516465, 4.4475250003724645, -2.0880164099821585, 3.9090772772034494, -0.8885182038184877, 4.637408456943346, 4.455649264957314, -3.415094135441366, 2.110285999659754, 4.604640780507037, 3.7093423456933503, 4.497600830798728, 4.062524414254854, 3.3200738682229214},
    {3.146976205831681, 3.9244581912408183, -2.2051581841582664, 4.272241234715458, -2.2187844228541387, 4.084465155180875, -0.7113561536812587, 4.429678679268851, 4.2263176874214565, -4.225543379364333, 2.3891072908146525, 4.450307739976065, 3.5824861177303227, 4.355909955071481, 4.122932921690509, 3.3345772414876347},
    {3.136691581200692, 3.0087941242529057, -2.630504179420386, 4.163355058516188, -2.351714287160439, 3.8941619211692826, -1.7081798014125498, 3.9617551880712503, 4.002133640890052, -3.958184067616972, 1.9912894053084282, 4.316406943283365, 3.339015415852031, 4.262565404130017, 3.9973650005101313, 2.7546351045185475},
    {2.981746754663876, 3.024101076786149, -2.5471017010762456, 4.464854274151534, -2.322043518810386, 3.703983760262348, -1.471650105910007, 4.142436739991929, 4.033549985266965, -2.813396839216914, 1.7872356796420146, 4.391459845310644, 3.4614286946543706, 3.9087183336658637, 3.5459804834461894, 3.0146038446268624},
    {3.439660260423379, 3.9510747121583, -2.4720639396271773, 4.585440693912677, -2.407283294227768, 4.077681022523757, -1.0478181098677604, 4.540919101906919, 4.565219117727306, -3.3383366786045614, 2.281997634309057, 4.819423636872193, 3.69376304169708, 4.622683881666821, 4.266231321262172, 3.7222821742854824},
    {3.4715341817050134, 4.014550505021075, -1.9646636003138929, 4.532326605251442, -2.3073219029982304, 4.21104859267568, -1.2887216691056966, 4.454049243580629, 4.225934079143228, -3.80134224348943, 2.202332157175159, 4.71374814484602, 4.310726316321603, 4.558392284993609, 4.123917182949593, 3.6997042743764146},
    {2.5962353564984504, 3.565045612060022, -2.2749054507347353, 4.1021092009660505, -2.211522030328018, 3.71472052966459, -1.517587602061374, 3.7619150105494796, 3.7968825528379075, -3.271510994583231, 1.7933359019086226, 3.9544928745929635, 3.9032451478760177, 4.179604646384324, 3.3504839505607866, 3.2581370495590867},
    {2.845755795695378, 3.3962673164052037, -2.6844769647048463, 4.411890041715162, -2.537301712802779, 3.629543204191432, -1.600150436901123, 3.874265980726917, 4.06491564318553, -3.432926539982198, 1.7988477745402902, 4.554434704602839, 3.2630899459570957, 4.212983286733651, 3.509138195883677, 3.252392358181697},
    {3.346955962877878, 3.882785005554142, -2.988514385862552, 4.67875068993031, -2.6161572527084327, 4.248595806954025, -1.1777545016959037, 4.549384351407011, 4.395091111107862, -3.9377544573463426, 2.444445412535745, 4.766249313035223, 3.8056928419894875, 4.453006077459452, 3.9084078934039894, 3.844387560912011},
    {3.406318141461809, 4.00283685855884, -3.2432305374797963, 4.60775595375578, -2.742975738076323, 3.9606524365728366, -1.2442671355403514, 4.2323614202814, 4.303957762970405, -3.269698900984047, 2.65499102485965, 4.493914156008304, 3.757291214325659, 4.322881937903008, 4.391039586917518, 3.7598742552445543},
    {2.7486172358507335, 3.196345075714991, -3.409592322716884, 4.074391761447325, -3.014617558546024, 3.2096085628064244, -1.9069853980416143, 3.895475122304722, 4.253652339481792, -3.839258685879186, 1.9355696491309875, 4.204890460265699, 2.908561316337203, 4.205963116376645, 3.7355082138887, 3.1232057274528193},
    {2.680859893633306, 3.8191743988270686, -3.585377819865762, 4.560859513719788, -3.7008468811796678, 3.581400186627716, -2.1433572608676066, 4.187979851380301, 4.147839094557676, -4.255810423457137, 1.3652355871665611, 4.702203389872905, 3.6324779515386516, 4.289727401778971, 3.850805838025658, 3.414615763341087},
    {3.604593028110449, 4.016906261370722, -2.144709447150995, 4.893288077044726, -2.4245021464163896, 4.082652516891806, -1.0541132222686787, 4.755120067950157, 4.610607982770318, -3.6279788595791866, 2.729970745088907, 5.042520235694123, 4.200418325568942, 4.765922824329613, 4.54318514369805, 3.7340601766493395},
    {3.146522902919278, 3.653579356217435, -3.1123356914093945, 4.370127203217985, -2.849152920674301, 3.5423076996768104, -1.3048604562262007, 4.205378761735546, 4.278773400720919, -4.499021663431472, 2.3671027690515225, 4.792379809860988, 3.442853680862667, 4.347580064926213, 4.258600097840516, 3.1864539968877077},
    {2.7299872958545683, 3.5092268474027755, -3.1228126638125246, 4.817092244477385, -2.9563220720940797, 3.9504878534568952, -1.7579895398374088, 4.236184416194194, 4.341125931456862, -4.018279436012082, 1.7058661273822826, 4.9264270179016, 3.454917959737213, 4.447106204224003, 3.917118544086059, 3.220112368779417},
    {3.4867041778976624, 3.890844503959482, -2.9176264724812455, 4.802574694607149, -2.6089714241121063, 4.46340444750674, -1.5498306070948686, 4.598159551338847, 4.357178443387875, -4.2961882344998, 2.5134701977253306, 5.060539848194888, 3.8562289555932407, 4.554848019263249, 4.530723126254238, 3.6302007306175184},
    {3.313576870377567, 4.034479308652118, -3.414194870836712, 5.137740501345763, -3.1618348956470275, 4.241593520686708, -1.5337143206530288, 4.726956244250167, 4.767770884262452, -4.566868573865678, 1.8214651752296553, 5.367660203559576, 4.073628898253313, 4.860094686116087, 4.441903639104835, 3.530009029663671},
    {2.8579175276524618, 3.6792420883396018, -3.797658468400011, 4.7561732502477865, -3.7904863344594784, 3.8385956184940397, -1.7699856973280372, 4.842042772729748, 4.934767692644799, -4.3741555177411096, 1.3361383423411313, 5.1528316490775445, 3.840098781358181, 4.904481168295934, 4.220506842658309, 3.229415290090728},
    {3.190419574926681, 4.106674881077117, -3.8569704471223076, 5.020035142211558, -3.622291192750274, 4.2463596723524, -2.3665336852561967, 4.786063792433494, 4.67468755981605, -4.750531602971631, 1.565171629593656, 5.179215813975484, 4.280241600728776, 4.853247987350036, 4.323606649306532, 3.7994346072084904},
    {3.187277695506746, 3.9774753303007078, -3.95881962969099, 5.082278942128715, -3.7857777524276313, 4.344346065649699, -2.491298654838769, 4.654141256415022, 4.605040057246135, -4.0178571347560155, 1.3421594369330005, 5.107829928503871, 4.02121221514329, 4.774888006438143, 4.433009140324256, 3.541337507765216},
    {2.8897342028930812, 3.6112429932986445, -3.7466512573698223, 5.082006807463078, -3.367168984886275, 3.7920301842913116, -2.853500199744507, 4.514427314414584, 4.461896972448897, -3.9023245560659063, 1.2428630704195707, 5.033197538967027, 3.71930230474785, 4.491657189171481, 4.106120938184268, 3.7196435731258246},
    {2.604012988461535, 3.231525288916745, -3.9813570011887136, 4.326020642563611, -3.714356154706686, 3.690481658228797, -2.7686663715309687, 4.200259721414513, 4.305481723872767, -4.488463838887522, 1.0741073681017146, 5.040692924945065, 3.4787016880911774, 4.294356855135539, 3.952624580856659, 2.964559560407601},
    {2.9010756363055545, 3.6486890001910135, -3.09688654824037, 4.894007522566192, -2.815332039784587, 4.265897663075259, -1.8914529445971515, 4.5089394446044055, 4.6202647217739035, -3.382004141698961, 1.7111202370000245, 4.964942966714096, 3.6591000454098985, 4.731431358539086, 4.168711502109216, 3.5047903269303218},
    {3.174397456959124, 2.3767772710692943, 3.111912531992878, 1.7381423548633606, 2.9995738242805188, 2.6069293333867956, 1.2600889945649816, 2.4977329613121513, 1.9140582773122945, -0.033130385548200844, 2.5560026118579646, 2.290970832545037, 3.4265713662289854, 2.620583236371657, 3.4108208280068877, 2.083108905435694},
    {-1.5128405663035278, -0.38755279986509167, 0.8246055313647709, -1.9256775830645532, -0.5195176360326595, -1.5583976075214285, -0.8808285738801719, -2.5558283932638233, -3.2566523346304628, 2.3992651268724945, 0.12694674355011296, -1.658047543099103, -2.0440785636334313, -2.617172668405277, -1.6492392435447332, -0.6439919870042505},
    {-3.109820667951307, -2.945191117708883, -2.876897132334233, -3.3135305427173893, -1.9823879662212898, -3.058713477834938, -3.122550627214671, -3.2862618681563927, -2.3434411742607737, 1.2110346110810806, -3.3451537110168315, -2.8112623681485878, -2.9334811301376535, -2.780179518106419, -2.080808839400316, -3.104921117429401},
    {-0.9062634904839441, -0.8936632489210565, -2.003742811234132, -0.39820751102342467, -1.0218498426189333, -0.8293783942334466, -2.3787015923580084, -0.8689719886332371, 0.03294310652199221, -0.43705915079955815, -0.7191808922543604, -0.5666098012073468, -0.4972851823011244, -0.2850338731142949, 0.5004098015563845, -0.8232119376268432},
    {-2.794648948898459, -2.9330547707388104, -3.8985593183226523, -2.7589201754829467, -3.786158402889272, -2.357199902027757, -3.647943040828633, -2.2714519420276775, -1.2998879355291368, -0.2643053608143362, -3.267558944843113, -1.7720624360484327, -3.016764877692801, -1.7423001394638034, -2.244998328703675, -2.761025852861716},
    {-2.0819906077197308, -2.1421905527632723, -2.4339783113942253, -2.0170691608497227, -2.8991115302676986, -1.976870667599434, -2.6874483463967747, -2.070707633419435, -1.0312831003180407, 0.0025972227133331163, -2.1217811941728013, -1.5988259840897692, -2.11652552913973, -1.2476227154480146, -1.434955078977907, -1.7198929207586608},
    {-1.2572657889537102, -1.6377599843783952, -1.3652991478310716, -1.6973502025753846, -1.320931339382834, -1.1795789848064222, -1.4796639020253373, -1.7023352404309184, -0.9026498324961801, 0.725867888918863, -1.1823687942821666, -1.190484836658358, -1.311118843466933, -1.229841784563864, -1.2450488112609328, -2.236120922715488},
    {-2.0192146337447654, -2.265706618580685, -2.044334896518196, -2.3453351410261787, -1.6665266253338888, -1.858754059513768, -2.8987935320168403, -2.97165533524627, -1.7801265067102607, 0.09465643036525012, -1.5893007431673682, -2.2584277470045593, -2.356939353961482, -2.144417292663503, -2.011578637617651, -2.123774057698649},
    {-2.5980100215080357, -2.7491804638941164, -2.618539012697676, -2.2124988406702624, -2.4885571834339477, -2.2087096408230256, -3.2990991829080274, -2.781683513384196, -1.4897602838162336, 0.08323733074987036, -2.933501819992258, -1.592988860324712, -2.3934274738230465, -1.8373318313061164, -1.896369218854601, -2.859867768768191},
    {-4.138564020517597, -3.929263011305856, -3.271339642229242, -4.010620433378657, -3.3321619994235974, -3.670771584044754, -4.32726046540278, -3.5673920330898903, -2.7445899201051884, 0.9405114503592694, -4.296584583491, -3.146140445703773, -4.080695010633179, -3.0671140456849546, -3.0796252340294834, -3.9439411482673314},
    {-1.3198770945436502, -1.6611717072006005, -1.2725058556337638, -1.037363544118944, -1.530896054356292, -0.8658049597099647, -2.147596775608066, -1.2364278206146642, -0.4640815409776409, -0.5931193516958111, -1.4136040601413766, -0.8539102160454394, -1.000826470033354, -1.0878047713019159, -0.4615123158652162, -2.2804516361916103},
    {-3.185357045721343, -3.604023557688208, -3.678297541674411, -3.2609776058301527, -3.0762624054099583, -2.991624550141349, -4.100377527223102, -3.746056670955409, -2.867970189116955, -0.23999948439243998, -3.2427569677826726, -3.204023289702964, -3.674580041417007, -3.183788070944726, -2.7651243447530693, -3.7473880962254915},
    {-3.0973250910380132, -3.4787868881596555, -2.710558437148183, -3.6267539039761996, -2.32080483941457, -3.214805014494853, -3.591973182104099, -3.2987269093363447, -2.6296447296348715, 0.6990135205115323, -3.0102618598855435, -3.2642715819644637, -2.9862544254898475, -2.9052725931850913, -3.21555548542629, -3.793755023005123},
    {-3.975832934683769, -4.689038035868973, -4.038134190078891, -3.985593671895474, -3.719030065770695, -3.9655417771127333, -4.937218989765086, -4.31288537577463, -3.3783268026978996, 0.5039759284909828, -3.631743490607367, -3.9837321411646474, -4.416612563208809, -3.742210174186064, -3.7874903414119845, -4.6200193210183365},
    {-3.96323696493152, -4.4914666424766265, -2.7240278344853524, -4.505719060053986, -2.774721656801637, -4.193971423525405, -4.102357249170741, -4.351390520990229, -3.7280543192942535, 2.2499561989654953, -3.5262670191936962, -4.127330440617211, -3.9256253687125766, -3.9518938069373926, -3.700656046505845, -4.301966926874449},
    {-3.1142821567871266, -3.2375570240450138, -3.6716734974566405, -2.676957354188017, -3.7803413984209633, -2.431497895132074, -4.950847301893141, -3.4544282683541554, -1.9678698331213171, -1.1868911264663065, -3.4517915901862692, -2.5935085549117454, -2.788032396868751, -2.1704183930759253, -2.475777718283065, -3.091457313832653},
    {-3.029838233545001, -3.216911132124486, -4.475861932832793, -2.8498340945535814, -3.5988795326346437, -3.0527518079728826, -5.034479878648994, -3.225169598867359, -2.0138719185319243, -0.4048273973641305, -3.1364812542876406, -2.8010966310622525, -2.557172160796118, -2.2562409261494034, -2.7791549361068286, -3.473657128088606},
    {-3.3204098747340485, -3.7162803734763195, -4.701888587476281, -3.6630393286226024, -4.3625054880190195, -3.6674910357725534, -5.110590504880059, -4.213876432092611, -3.1154384840649545, 1.2106003261914609, -3.3071468076765185, -3.639195096254763, -3.229939734992985, -3.375305820137375, -3.58398161716386, -3.3005765367148436},
    {-3.2367372672080923, -3.429621064396386, -2.487625691165793, -3.567671735490636, -2.5780013124514634, -3.3511401497488222, -3.9607592645458536, -3.7916326542860044, -2.9488647176218428, 1.3796241002725707, -2.998439091793218, -3.191583108810398, -3.0067868299685734, -2.9690280419350636, -2.940260989743141, -3.614086281302255},
    {-2.896544164308685, -3.2462581752963096, -3.3402578163386853, -2.8078950872812554, -3.4371777566789805, -2.6531382211236005, -4.670108899917054, -3.1428923231923527, -1.6487766234303294, 0.09086305120323482, -2.412438089449516, -2.2415137509861602, -2.6204072199701884, -1.699170117193515, -2.0642690031327353, -3.704025139806025},
    {-3.8414448877571523, -4.2611584249738526, -4.0917874638832075, -3.7754758949851657, -4.110655182916437, -4.0770587677866805, -5.173297159077488, -3.9952056059192285, -2.5902890010122754, 1.341950244406679, -3.9766907091565193, -3.4059222337823356, -3.593160252148355, -3.046446084585132, -3.5013625859395923, -4.708196431563938},
    {-4.489494875202097, -4.812490834637248, -4.038012320733249, -4.6264434169765805, -3.721238105483215, -4.788742160447542, -5.398575110735778, -5.186717455598661, -3.974918788369904, 2.1229621900722053, -3.7595815080566437, -4.528097408565233, -4.45756399285186, -3.805835586573548, -4.202073694330218, -4.5676399774496454},
    {-3.3833646460046873, -3.9846868953860053, -2.637722292746456, -4.239889456598962, -2.341444808886618, -4.618704089270993, -4.731630608966052, -4.472781493081686, -3.97006161512511, 2.9965445838809135, -2.7984231100997956, -4.3006709628482485, -2.7353171375212146, -3.4481950642875256, -3.743236835708242, -3.7795354473016674},
    {-4.247035624591367, -4.3109146850280124, -3.5506090690014624, -4.727639084061862, -3.070726509263875, -4.630130002739659, -4.755727313713556, -4.676685384391517, -3.9461910311861548, 2.090898512680976, -3.3027138720812586, -4.55020872667603, -3.3585525871030004, -4.176644172061445, -3.808006733605597, -4.177239033087173},
    {-4.191848356761474, -4.352191985761368, -3.652572561476559, -4.269554987294482, -3.368674747241413, -4.248168002800981, -4.956390751904502, -4.513046269003509, -3.300472038095877, 1.3372542907329628, -3.6468606686543774, -3.9358974731244816, -3.698068878387726, -3.757203344970761, -3.3715562743056666, -4.602515222399218},
    {-3.3014195281353556, -3.716178162549317, -2.9815898053335217, -3.4063073646273203, -2.3121232801299523, -3.875490672820484, -4.60166948927523, -3.8232394076135314, -2.912177903472597, 2.5886777879057576, -2.6894010981049368, -2.783152831659226, -2.910803039983702, -2.535860201066402, -2.6196757587721256, -3.3979956150534805},
    {-4.3850218129510665, -4.75503718925308, -2.5778100350934294, -4.436953154302114, -2.69976307680457, -4.642190084853587, -4.802419994958602, -4.790679215681519, -3.7377680901081036, 3.3294069261754173, -3.0862327829710705, -4.097297463846657, -3.8833476857583316, -4.0076207034769835, -3.7327721787780215, -4.483473344936789},
    {-4.917358880580935, -5.233687811661572, -3.3419284440505375, -5.052978929276041, -3.073044044475555, -5.042825770215364, -5.288863001637344, -5.236017157382232, -4.0403639430436495, 2.200954540855501, -4.023533095633532, -4.545957631650502, -4.60718154713772, -4.31505605584927, -3.856650239908784, -4.481372725687397},
    {-4.756280022097272, -5.009208719994429, -3.3889929229530544, -4.906582127848906, -3.566908333863552, -5.0660022797119035, -5.315459455493079, -5.095035319305038, -4.307027507839727, 2.2777028553636876, -3.624473069787023, -4.670855633736145, -4.269706016427118, -4.266010598781804, -3.76380006307361, -4.801678556986631},
    {-3.8390499567306535, -4.284758080314114, -3.5850161532228695, -3.7928281627288682, -3.1036739532480606, -4.584943345186807, -5.422706690281947, -4.152238753710612, -3.3904172618224457, 1.4425177765568045, -3.415363030358352, -4.366827431796072, -3.338798793250618, -3.009915228644644, -3.769186947852235, -4.163151634200708}
};

static const float b1[16] = {7.647286943034968, 7.677899728275669, 8.235085257187974, 7.544367085028117, 8.248817773005221, 7.528554151103923, 8.265895515116684, 7.735705835495973, 7.138632473308917, 8.877450586656188, 7.825780148499772, 7.572662835752324, 7.645143315913834, 7.319742470468195, 7.638903823604123, 7.684733474280074};

static const float w2[16][12] = {
    {-4.5439270994728505, -3.9966690425769533, -4.187065137309656, -4.268974022272443, -3.8376841467716485, -3.8198434095073748, -4.604620089543983, -4.796001988627895, -4.197097523619292, -3.3948271432126362, -3.8321238907045587, -4.933808686177577},
    {-4.096772719520158, -4.370500526354712, -4.232439908555174, -3.450944412182672, -4.187619945520864, -4.117514353170441, -4.016533114237671, -4.097763822564817, -5.075972918749107, -3.9978688492025163, -4.293596925123622, -3.5885072939094154},
    {-4.390324232056744, -4.495973946397882, -4.139284832318564, -4.0452945083914855, -4.4769108211944815, -4.664156164969025, -4.769388686508717, -4.588056506446316, -4.277686272457949, -4.8480651038231, -4.199998692275015, -4.887021217418904},
    {-3.4787553639667737, -4.288481809805949, -4.2908382425551475, -3.6485599391241847, -4.947142492840777, -4.1613698995335175, -3.934986410550905, -4.360873660066816, -4.630288155439402, -4.142665110741224, -4.340173708359127, -4.0984970527078275},
    {-4.471215318760227, -4.517807782505205, -5.596937095155095, -4.9744931109771775, -4.5553445408834286, -4.398422535555501, -4.81429653593345, -4.652320912216184, -4.972031272789398, -4.550331582735955, -4.873919128631099, -4.561879384775942},
    {-4.421651477551647, -4.865105310728702, -3.935074265330408, -4.442218343864067, -4.112348312638645, -4.810160170961985, -4.087124155676364, -3.3724235219890955, -4.38499525237872, -4.411974553863313, -4.555703567215814, -4.040778721521378},
    {-4.698096842207595, -4.683476628890686, -4.171213658976707, -4.774938862071597, -4.667897035897252, -4.689856312606868, -4.118028453470744, -4.603116852599368, -5.003188293034336, -4.109885472038458, -4.685844142475931, -4.232594244978896},
    {-4.120111752506224, -4.593678812350825, -4.541309381139721, -3.773613338250966, -4.101925394719969, -4.221047839879023, -4.761125345804948, -3.3388227864884796, -4.4554475298010585, -4.611323252210249, -4.069901332657958, -4.545014868644876},
    {-4.538619269308492, -4.47098705422033, -4.214626717105036, -3.859185388337197, -3.8023199661559253, -4.187319639568599, -2.943612270438692, -4.565597887498079, -4.954845089926148, -4.355247068174604, -4.627637723208583, -4.091544116760026},
    {-6.177663568985397, -5.840676313748493, -5.765717030472107, -5.979474406560823, -6.0804775035282255, -5.774327228752324, -5.707776019813134, -5.731620056132249, -5.670175276335559, -5.773819739916819, -5.777911143481942, -5.7188362948853095},
    {-4.1586474768061725, -4.21995982508023, -4.07035729356831, -3.7947145881965345, -4.052130144723025, -4.2009410707996455, -4.45949078400709, -3.9083418311433187, -4.127940774347546, -4.850780864043115, -4.683564530394343, -3.885913783115519},
    {-4.302369844920519, -3.4397006954231735, -4.499062003880919, -4.227991044563898, -3.195198553637005, -4.3038532791974955, -4.600965800305609, -4.588689621908769, -3.9626304598773268, -4.034483961309353, -4.400542629961912, -3.6360628326619153},
    {-4.806683989345552, -4.223619482021157, -4.025148403582856, -4.833644330417542, -4.201903715549927, -4.068692277081084, -4.330693662537426, -3.9370140679113454, -4.378685370724513, -4.256572470587077, -3.687145177875975, -4.0937575631935745},
    {-4.04581105823237, -4.331954219670444, -4.569910802217994, -4.739594850748076, -5.042282839662184, -3.546911435152184, -4.7150817170028905, -4.466967922937432, -2.669136764886435, -3.641975597875601, -4.591500377632345, -4.075066048538827},
    {-3.9016392554490724, -3.686431383046183, -4.1299223731163, -4.876301851902284, -4.641713555317674, -4.571958096776242, -4.213057600588862, -4.533523250417641, -4.154537283368836, -4.373580664831399, -3.0892425104947905, -4.888642432221427},
    {-4.130638017378621, -3.9833546576176406, -3.6506975657830893, -4.489140496382127, -4.216328467210565, -4.367052589264874, -3.9184328649385836, -4.57575110229699, -3.45547277075622, -4.555321420352394, -4.312536786491763, -4.647134683993877}
};

static const float b2[12] = {-5.311456649794405, -4.0629214229377935, -3.845640218498779, -4.597936317786765, -4.520330595553484, -3.5705887646914847, -4.739599827765909, -4.670428876859868, -4.04143337749371, -4.697305721724759, -3.997075810731653, -4.905653692995197};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
