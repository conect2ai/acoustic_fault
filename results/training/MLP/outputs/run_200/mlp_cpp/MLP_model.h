#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.1854972307782314, 4.452677141539415, 1.6571195778976675, 1.7856277727984442, -0.5483542281984888, 5.027900242304143, 2.7676463722258102, -0.421996760633729, 3.0133016917883566, 0.7115823540312658, 2.120429976637321, 0.9344758429058118, 0.2030367665682819, -1.1180890214309065, -0.9147513525561293, -1.607146215232287, 2.7859380058406855, 2.2430363398972997, 3.146659678368763, 3.8147494020197747, 3.0574963573521816, -0.3884741129577926, 1.3128623327399154, 3.5967781455038184, 1.1663528837658321, 1.9537282895434882, 0.065607156932569, 1.6961871892949765, 0.9905446491470042, 0.1595915689173162, 2.5215899900952903, 1.2564611645485888},
    {-1.3567796282370959, 2.010760995494801, 1.2860896034179812, 3.1714518441495314, -1.7581081826798626, 3.0152871172139353, 3.6802670032003926, 1.2670770718095012, 1.4971383743384183, 2.693211297247355, 0.9162830489231305, -1.8280414053534573, -2.161436807312631, -2.0688504815861943, 3.2464278591218987, -0.5397895325766913, -0.24086540787162244, 2.6274907786272985, 0.7300164575203801, 2.000606384503684, 3.1263389748362376, -0.08406872796314542, 2.623694008675973, 1.2352922880990542, 2.8503176804268033, 0.8438361929502166, -3.176472098134628, 2.919425532073396, 1.924797699317124, 0.5160426716091877, 3.6569287534411776, -2.72128596605221},
    {-2.6500614026044307, 2.0553208563757566, 0.436117072005854, 3.6001760372826483, -0.2702030064512032, 2.2733719405417157, 2.0152044193404746, 0.10383445210343903, 2.7813323178364118, 2.427809758622391, 3.903064353801699, -2.3207938970775124, -0.733738066083484, -1.4289739840979794, 3.3977959253264984, -3.428200250687889, 0.718082885737022, 2.1277755905166646, 1.2685761809729643, 2.537224421729066, -0.4126988561663902, 1.374367589867633, 0.4981471465285564, 1.0393589800270993, 1.854224178873078, 3.5159802728719716, -3.0368026494975626, 1.0014830359302505, 1.2488119162090283, -2.451382879544516, 0.5775854414340639, -3.0128019844356997},
    {-4.310248632145986, 0.09916379752548948, 1.4237877270463646, 0.27172350941691853, -2.697515073028218, 1.7762056567061828, 0.909121965537582, -2.067997480473114, 2.97117882438722, 0.7095155445086112, 1.023176444440976, -3.6239068163601083, -1.5157259513781598, -4.775165539225947, -0.10263761040011683, -3.4652624765295683, 0.9799939931303979, 2.956782911915694, 3.107014053621796, 4.123265793221594, 0.09388578440498456, 0.6044220208686745, 0.6053102835246751, 0.8129544186703109, -2.5139709901970124, 2.38233737330836, -3.9703077729747647, 1.5789921436134298, 0.9801049301850138, -2.146605920199387, 3.5269986612070747, -2.0276093885311073},
    {-5.7829766792795345, 0.014400707231823259, -0.456919858223245, 0.9168296042344914, -5.880328224486705, 0.3711865016401979, -1.3693757793290118, -3.007382175153193, 1.262789599226561, -1.8183726038905308, 2.1088243108109492, -4.724670766048351, -2.9342486039348907, -6.032815806893783, 1.1061115297244652, -4.693727564526893, 1.4537152110012665, 1.0375531894102998, 2.2232894921225106, 2.536164337865777, -1.057685629254988, 0.9520147469676119, -1.802904800062573, -1.0176547943823495, -2.3119302339796137, -0.8198804507737664, -4.6323384177377145, -1.361293215479898, -0.08380643125261829, -2.248126632843581, 2.334100334297202, -3.6993448308748094},
    {-3.5915970423272254, -2.6514713492781277, -0.024035760336348123, -0.5132311195281418, -5.260561519105529, 0.9919936740041946, 1.103784911120556, -5.049812112315923, -0.12150013247030045, -0.6647101897891295, 1.007249030662248, -4.87005800060949, -4.29376912168762, -4.658722775104822, -0.9291910701890866, -4.372901366928964, 2.2428013747397153, 1.8011154885539984, 1.244135149019481, 0.6464657361494063, -2.0329085710207293, 0.9419757006248843, -0.1354080032954998, 1.1692441327715621, -4.197131755983681, -0.6018681170986928, -3.71270212285408, -2.2389594485874693, -1.5145311147283813, -3.200890881382193, -0.7509275059547431, -1.8470891312531645},
    {-1.2515197197823098, -0.03528662328990504, -0.10820015779715078, -0.1488205585239119, -4.304361573793224, 1.74546442349807, -0.0452884649806057, -1.9630751538425115, 0.8222195500955379, 0.8561791061923046, 0.2599635991145566, -4.644305531006499, -2.698893552193056, -2.684242807419578, -0.0793793782310489, -2.6393532480458446, 2.0448945506243708, 1.043507505859225, -0.22443134632059958, 1.8218143197445058, -0.20293691331015495, -0.6188618632166573, 0.8388426752068258, -0.753049745185815, -3.1742388874760508, 0.29914896093024945, -4.326177694179992, -2.6087936203779436, 3.158357156047525, -3.540554127965696, 0.2075595832593386, -2.8035897824149947},
    {-5.517549517339495, 0.34948403221774715, 1.5481111982487572, -1.2979268119755456, -5.384879794297623, 0.34637557923058343, 0.10683371395630709, -4.1335109623986535, 1.120891951577512, -0.2598001310142215, 1.2192288617974716, -4.28558844998909, -2.7407623613672873, -4.898770395762784, 0.20118744491085805, -4.032209571500592, 2.5241926678408606, -0.35827700888702624, 1.5249555077284305, 2.747188153194273, -0.7418127228557029, -0.13293163175531278, 0.554116662899467, 0.4523297824920343, -3.602341579414055, -1.331937773247555, -5.543876361027793, -1.0380368518926282, 0.9848824316431299, -3.502205311861079, -1.7777499023032477, -3.506183640116591},
    {-1.8682064235022993, -0.18603298586924713, 0.28758306261187694, -2.1696226343707323, -2.400191057416375, 0.2819952321825563, 0.1493681280439187, -3.8470332325656553, 1.8926364429752578, 0.07758636453124891, 2.4554366970618817, -4.994216242857677, -3.8028825824222285, -4.211716654326259, 1.3643890310193716, -6.100815355785906, 0.0650132729884505, 1.6716940794878852, 0.8791540834008112, 1.178716273970269, -2.1859097820819073, -1.1593208528519865, -0.48528862128144634, 0.24779017646476592, -1.1463043717296812, -0.9099956018139095, -5.260841109527531, -0.5751920254311041, 0.11277823214310145, -3.548162064860619, 0.5936023123766627, -5.4920867892800835},
    {-2.7078040608459504, 0.5041475444790967, 0.2675621318227297, 0.4238465385031073, -2.7655853743095906, 2.7651711745757632, 0.5537070226387452, -4.212765739690286, 2.4660953247556963, 0.1775020612226745, 1.8934932621636555, -3.824984064922725, -2.2194616487003636, -3.7590060084395955, 1.7339725563104014, -3.72287351436852, 0.4106211042246694, 3.1441046095368987, 1.1593126511691698, 1.215199891557506, -0.3722179202180258, 0.4975302759039877, -1.014018623117832, 0.5314123391284284, -0.8871151540209847, 0.08389916627070622, -4.102786169039319, 0.7677337376370752, 0.7269982542602298, -1.1897815364094873, 2.065599610669522, -2.8147464326617526},
    {-2.720286591316474, 1.868919022312491, 0.10199302319747394, 1.2041493691046004, -1.3170268003300643, 1.7198828942637665, -1.9223313228835426, -2.3769344013066913, 4.110718179528674, -0.15373531800765536, 1.3026727354696241, -1.6269347628811917, -3.3648606770366594, -2.9064565649238476, 3.367607333024175, -1.491838806340836, 1.6927151519747154, 3.1295135164589007, 0.26321027641093586, 2.065460338311301, -2.2698828945452276, 0.8885227791172582, -0.7095230290858687, 0.5543993497394103, 1.2079988330559681, 0.7480975823884305, -2.736046804875063, 1.4267816686376609, 0.4772207564763917, -2.1738561895934785, 1.9960331834672744, -2.7078858285862872},
    {-2.736001317917543, -0.05682636761935096, 1.6310012437966954, -2.046697638786155, -1.0320629469288365, 0.1319918708957923, 0.6890513101652909, -2.690292630234834, 0.10870489257757186, 1.8001931185368578, 2.1103132522867485, -3.5152126750187365, -2.9594498064440997, -2.426827961231896, 0.4316202204575577, -3.0706173566330985, 0.3859560625380109, 2.435021993752028, 0.8832888720871542, 2.0404230310740608, -2.4647682178325554, -0.8665050805333292, -1.190125288093325, 1.3938115011210184, 1.2338964143893578, 1.602317005013986, -2.1656353369563437, 0.3175431495262585, 0.9411259280848966, -0.3634326801230869, 0.08485518908646471, -1.6069694971766049},
    {-3.5186875008813687, -0.452336186309164, 1.614555277174004, -0.3243509938890161, -1.7416066034764721, 1.3284883597898456, 0.7565193598441384, -3.4819870869705367, 1.3735959087273806, 0.152531196048844, 2.5362581824657906, -2.2947066813473382, -1.8907344036371638, -4.176263431519451, 2.968039741480144, -3.7886780971499805, 0.02290208413024622, 1.73707933830341, 0.9207913697739777, 1.9787474368866707, -1.0383085844741975, 0.6107639778733913, -2.1381780390655964, 1.0484377553307271, -1.3389386036943651, 1.2330369935315182, -4.892865498562799, 0.2750261014973308, 0.9127758825604723, -0.5993973629893835, 2.24105794261282, -4.5549776650778355},
    {-3.0040055751886685, -0.24050855921385253, 2.7629658389268785, -0.6655967880501292, -1.26371334860108, 1.4896768868644539, -0.3840161195117507, -2.024019439870354, 1.0486819689764655, 0.13115749729551618, 1.0385642225700462, -2.4442551097412193, -2.366383748543116, -3.249502363392865, 0.49597750340967023, -3.065301313155235, 0.4975846142811895, 2.5271733358189743, 0.07068176753854774, 2.8666773044689315, -2.7513095656512125, -0.8109182061692327, -0.1056633898680316, 0.2467240158479053, -0.469519162911657, 0.8830076354122937, -2.8978878942016038, -0.9368712504967303, 0.8772614009091461, -1.077749312090001, 0.9148104584458566, -3.2523542156034266},
    {-1.9729851814826864, 0.5778228734974549, 0.5775480591746189, 0.22231895501287646, -0.3341783575016553, 2.888975952292285, 1.0531941605585173, -2.4653338102819613, 1.6029508290964039, 0.6091474385324422, 2.7814469744006045, -2.2836145191770845, -4.534615805999218, -1.8376685798487165, 1.861633678712817, -3.666958608370296, 2.444876723572533, 2.6599676662856946, 2.6394078600177613, 3.1188981656143446, -2.0369267780937164, -0.6807130325035784, -0.20506770120386286, 1.520218761163958, 0.14617897484653788, 1.0508714789188958, -2.4592600131692346, -0.8921714338374493, 0.9071392830214391, -0.7216342036814773, 1.4606025860762295, -3.1002304603083988},
    {-2.605134813991003, -0.32723467186186245, 2.5383186579301618, 0.6589384548426342, -2.161323598109464, 1.058495903806377, -0.008438588112849687, -1.5190924774882284, 1.793319565618892, 2.5385755380714845, 2.1881549952903763, -3.899640905444075, -2.271061243421803, -2.431980015316108, 1.6985362818905636, -4.125067020659988, 1.7927669093376446, 3.139061926927686, 1.0819250877706326, 0.47896673818040914, -2.9527785144534437, 0.4174749258683578, 0.7755251078249082, -0.7680999402353134, -1.290437813286903, 0.0029458001016380965, -2.720674287816875, 0.3533787348872744, -0.15033573960679278, -2.443904219148249, 2.517944631606445, -3.7963858730030426},
    {-4.021830643459141, 1.3545093109534905, 3.810133415894874, -0.9176141119759057, -3.7632724799880957, 1.5574610107049511, 2.7585728101624363, -0.7367828903700535, 2.8669515194966855, 2.2793940050470223, 5.205061504039981, -1.8138908817389234, -2.1200967785481275, -3.2737090827674376, 1.9188937909100807, -3.1542072270553474, 2.2899426163314685, 2.2407140467827524, 2.1287809310325647, 4.036288398018116, -2.7728962105166124, 1.2879007489580059, -0.2566407585915685, -0.07415351593988506, -0.4589840064837317, 1.1008260708299302, -2.0081865187102457, 1.6348296601551047, -0.9234643536022175, -2.035247077776282, 3.2415294193138324, -4.320346444576181},
    {-1.2776834207046877, -0.3893587392842175, -0.03978355302618797, 3.81256130169128, -1.4257786384994162, 4.161951802065615, 1.055453759715221, -0.4990738216969611, 4.599119481947694, 1.023177391229771, 0.48762764761054384, -1.0434603047728719, -2.1838956215365815, -2.0719161177487435, 3.315299058544633, -2.9509053206087104, -0.2412856006453616, 2.4550811406446016, 1.8084338121177306, 3.276509962241966, -2.4067266198529027, 0.5706022863664246, -2.170264205909327, 1.1433500085892672, -0.23449754492425967, 1.1583627501892635, -1.9012683124540197, 0.9600873525436011, 1.420509830995927, 0.21427300125357784, 2.3686595472386713, -0.8983498389940957},
    {-2.9511373451961656, 0.307258203635078, 2.1663978443410072, -2.0421258753862097, -1.6888850210014832, 2.5960834723727473, 3.098721522219426, -0.9938949422875042, 3.277434179713891, 1.7612558978453414, 1.5237550617266147, -3.7508028552312176, -2.023783163450773, -2.204588311429732, 1.3936915253518283, -5.723142941080498, 0.3357736063107212, 1.079110807752096, 2.7435767360304903, 3.2181255480054647, -2.948131415080316, 0.14228370902674017, -1.547765563454835, 0.18276844683258575, -0.698840793016727, 1.073859668528621, -3.250221145232984, 1.2785799156830506, -0.01854774896078818, -1.467275711389055, 2.062459596515933, -3.621889641498286},
    {-1.2330682567411069, 1.0680502860571504, -0.45297453942367544, -1.2031493386877152, -2.3637833219713715, 1.5885928260624438, 0.5463831615639734, -3.7727616875708745, 3.5312618820015427, -0.13841777684082096, 2.572037138735623, -3.2850005823348942, -3.1588650558543487, -2.648867242038843, 2.2818548169694535, -3.9890119958674877, 1.3759339380809024, 2.0629946756939366, 2.0789943801443407, 1.6160616923863844, -0.9826726559897062, 0.8428766007373475, -3.2092707029047927, 0.7522859077058995, 0.14024645165764454, 2.207620608307129, -4.980143782989134, -0.3153216342195791, 0.6221464876558894, 0.01442581421378414, 0.6139442089703997, -3.8327339235185685},
    {-2.271561903525779, -0.4304704693697648, 3.6653211459049757, 1.4500553914480836, -1.574565354157418, 3.916047955998462, 3.215410525790944, -1.586998812848997, 1.1221484414819476, 1.3164758679053468, 2.5256291960586377, -3.481253054973074, -3.1987261471589656, -3.492732992572768, 2.5799300461854355, -5.098885979843546, 3.205495419022229, 2.7575890290666405, 0.4019551964840416, 2.331972000555941, -1.163922303165337, 1.8497993171917342, 1.1269936269850984, 1.101947750569645, 1.6836870987857862, 3.392445697603944, -3.3586481235223036, 0.968469297615848, 1.9228269164579355, -1.899372994066026, 2.8409005432660073, -4.006573347262682},
    {-3.479783180434348, 2.75048946837059, 4.951838996283267, 2.204420848651526, 1.4980317025347754, 3.7545567935130912, 1.837802044767556, -0.692509862605778, 1.4594390585887622, 1.2193412946317774, 2.769129847383555, -2.594573051254198, -1.8455193247453985, -1.2073679075001005, 2.802438840671658, -2.0936404185883526, 1.3486191251735162, 3.0127473952830033, 2.006577429727219, 1.6887723582193421, 0.2413047371499159, -1.3132517990338581, -0.5644292243980582, 2.4098262906217913, -0.34804048125700277, 1.4636053887981684, -2.6047426373358338, 2.4718546556619403, 0.08823176265667006, 0.11314546111410703, 1.7219370577864144, -2.8867794267814455},
    {-3.493325034893201, 2.235070679362163, 2.1691344091478273, 3.0700842225110834, 1.9799962205689836, 2.696426498421716, 1.2630002392306352, -1.0309005734172416, 2.173185481228542, 3.3856615905092946, 3.3957263511767204, -1.2985305380599337, -2.5388953419002958, -1.6212324987547675, 2.304939736393629, -4.8179780106467405, -0.7105343006992674, 1.1925311691466849, 2.6927149471355465, 3.6728046593381634, 0.2470246820387495, 1.6641522890974614, 0.14380998201466644, 0.41798157489494947, 0.6081946634401706, 3.1473705791128794, -1.6399389637337212, 1.5117509222506544, -0.0536069964955351, -0.6610039608004433, 2.4056395576954173, 0.19890190739734845},
    {-3.4927406158205097, 0.9044652511555134, 3.185738307021958, 1.1903459075282743, 0.23254320110390006, 4.7684495768742, 2.791187469700549, -0.12019819508800252, 1.7716556143294067, 4.253716544430291, 2.2617759465150624, -1.3310391853980865, -0.9401850925195543, -0.5396923149653633, 3.5156758170064357, -3.468500864626872, 2.441619198978667, 2.6236940655648437, 3.4131567580766307, 2.6767463968948455, -0.575167277493438, 0.5017884243632195, 0.5439175599068826, -0.033185578465597235, 0.32372998867607317, 2.4955055175348133, -3.0321820187945767, 2.1268360608748385, -0.30112727170433207, 0.29621840033552416, 3.1735428692317225, -1.21271231375339},
    {-1.5821703638465272, 1.3328702157513226, 2.4342707023689245, 0.7941854486707555, -0.1474363850649231, 2.886721202144584, 0.9866251721052635, -0.7896931561251674, 2.294294488529144, 1.4843339159566078, 2.7998749983442046, -1.3959674046602684, -2.2885682433729677, -1.4335961677015776, 1.1345880259265833, -5.1196773229450185, 0.4033509892147195, 2.3608004713848314, 2.0735983243792258, 3.4215633812785637, -1.1484483272389185, 0.6359334691575316, 2.0571211586101694, 1.2993664790151542, 0.7216018915361794, 0.7657207375173828, -2.696202513846059, 2.0445286833260026, -1.1647444644673794, -0.20186210287184833, 2.6936455850491123, -1.4311972660989347},
    {-1.526623419552671, 0.9709648719095135, 1.2312330568708547, 0.7208421302929716, -0.16463307432535054, 2.665056178940654, 2.297133338868164, -1.606095871329131, 2.9075841775893116, 1.5493618587663232, 1.3759023308008886, -3.914116701726838, -1.250591204051832, -1.508738298004519, 2.6837117991369475, -5.191771629867532, 0.9259626427889973, 3.888923196273229, 2.0984342550572976, 4.523362493222402, -2.6572405869655777, 0.6712240823153688, 0.8717061314881293, -0.19166987216425746, 1.9060766485913487, 0.9878777803794729, -3.8313566155855336, 1.769134934025283, -0.6477635444689009, 0.33815720418040307, 1.962111145349454, -2.2788684879172245},
    {-2.648480644138338, 1.9201390156971734, 1.5125652477089209, 2.184424340275766, -0.21020929075215217, 5.423099718327513, 0.6012836341156496, 0.5261464356748858, 4.0565520697623905, 2.857977604263, 4.28008906745037, -0.9229354942021755, -3.749590123548697, -2.13843458180707, 3.6718598154529936, -4.709203299283801, 1.9752450896290958, 3.1105420007297546, 3.0328597130799895, 2.5870293477739983, -3.457037802634377, 0.1034140305586659, 1.0395763050065492, 2.016953693588307, 1.4049221117344, 1.318289840094001, -3.369078126656311, 1.7713614899168897, 2.4693568352768023, -1.0801617947740836, 3.2141702043250886, -2.568622360581954},
    {-1.309317011876005, 2.2619828225842213, 1.4449406989862006, 1.7970741699308899, -0.6279657623588805, 2.912885974885349, 3.3774662569146185, -0.34229616482537517, 3.2808505523276716, 2.1242012120474874, 2.8478220498153215, -3.394662040481984, -0.7121771084518074, -3.0874535246866683, 3.32589258455512, -2.1159256778180318, 1.6459544799455523, 3.296571224293592, 4.862433701483673, 2.4302139106119247, 0.8463117642162835, 0.5561696684450793, -0.7090654587429371, 1.7144720053324214, 1.349024918835707, 1.1862955471863774, -3.3139971241595174, 2.3102694137879585, 1.1269756715248955, 0.21407504830695762, -0.026111163035635345, -5.267648744893397},
    {-4.125252001592565, 2.13877498808492, 2.797210029495878, 1.6679685960463426, -1.7139367204084877, 2.333931783434205, 1.8023005383030624, -0.6072524583009541, 0.8113170766420766, 0.7135154093724476, 4.277267012276543, -1.9637749774422155, -1.652007963733112, -2.333120876223812, 3.3305033598024223, -5.452889230576763, 2.1920150205025473, 2.729976910811303, 4.965285058513233, 3.883856612443569, 1.4752866988606828, 1.5529046333998897, 0.6565379421843965, 2.0635691260237863, 1.3351923545359945, 1.6394075049524321, -4.064503476804723, 0.7293361315486295, 0.8023754628578322, -0.7997467287498484, 0.8128930687132694, -2.1432078233641545},
    {-3.6122097344107504, 1.0741103884170713, 1.1095655643446627, 2.1753035695716214, 1.7248877410571133, 2.0666824059108038, 2.1509312768812423, 0.5746633613495867, 1.2076020521964046, 3.5260653882148465, 3.9872806935057237, -3.0065522066237453, -2.2399420735737374, -0.29662435548477983, 2.1642286448286483, -1.3093715379031035, 4.409111395691168, 4.978941092514494, 0.2153572525329083, 3.069026931949964, 0.454063596546668, 1.6330821480764504, -1.5198881776365842, 2.9611097925070857, 2.1911174129947857, 1.5053322985188222, -2.374521287110802, 2.533739952176187, 0.1695568999635724, 0.5060306254699136, 4.173900259748749, -2.9623796614313007},
    {0.40218201083143046, -2.048535020370596, -2.287509870929806, 0.7242702429929828, 0.5778646821833922, -0.1330301412166296, -1.3202789467444542, -0.2008353802227, -2.5782299600915315, -2.082369333976145, -1.372985237278249, -0.6786438625639, -0.13245439811146337, -1.3540335619307216, 0.32035116443980044, 0.6140380936169041, -0.8236760641353855, 0.22563787797043885, -0.7022311322232002, -1.8089554928624763, -2.5116046438003896, -2.702873486441518, -3.21233254409932, 0.11846723008137251, -0.6385224345507475, -1.068468691346504, -1.3098783951173532, -0.329262700473057, -0.4585202349049442, -0.6720828493303351, -1.6914454315736855, -3.109145979792999},
    {-2.1746035276356057, 2.0424953694168426, -1.5513330560156522, -1.0016035321290557, -3.654443056859263, -0.5062372450525644, 2.1979045205462397, -1.5172322235987588, 3.092599364480544, -1.58180532234062, 2.007046240038693, -0.8257700844181006, -2.6694680893669647, -1.6808960204350312, 1.271360889738902, 0.13436160326476293, -1.5221476109354537, 1.9022386963474918, 1.8515492925146166, 1.4533325573282259, 1.2336198198020527, -1.5238296701871636, 1.607569081210734, 1.7431841432274302, -0.3575983849228732, -0.9939375810884208, -1.4365044963186233, 1.3531579581978936, 0.3260267067135029, -1.248282680026721, 0.8063407861631322, 1.1827433010887916},
    {-1.4742183043048, -1.0584679790811478, -1.0300970862322147, 0.2696086758369598, -1.2185012808826874, -1.3287050596260521, -0.8449716474120567, -3.179257211639922, -2.196328522938326, -2.3698895444624757, -0.8840523075480149, -1.2928233866154808, -1.5402623399179431, -2.4209935230479673, -1.1584496526548078, -0.1215678306319589, -1.0087105674835564, -3.39760957971751, 0.7608290527894497, -3.5866431570792683, -1.6008087553931358, -2.0308553109351397, -0.8343073234547047, -1.8321226827504722, -2.525250621142285, -1.4682518704849292, -0.04191971988295663, -2.1498585996662154, -1.1749383176154131, -2.2213784101834797, -1.497211486462397, -3.59819324295292},
    {-1.2569758747491115, 2.184928144549119, -1.083290476569949, -0.892325223899011, 0.03905213443971009, -2.2178761373791476, -0.32744213765360647, -1.6675312732062224, 0.2521858662140129, -0.7709074071952248, 0.49051147386578375, -0.8688030917349652, 0.08611203041109158, 0.23717155632889353, 0.2741549538462059, 2.8792746493493606, 0.07087923683045586, 0.5405832938627223, 0.8873699372053095, -0.4691336207777345, -1.5598932231513944, -4.44461604727912, -1.0567022755693778, 0.6534917645676843, -2.6185454399531345, -1.115909052265486, 1.3425855347047841, -0.23559783492818845, -3.482023296562216, -0.3246313064617949, 0.47981395324857584, -0.004003363404145498},
    {-1.803567444015564, -0.36728776422744036, 0.36148132517428005, -0.5850636134184342, -2.9277325386824717, -0.8795471991299808, -0.3941624315937893, -1.005443975505021, 2.0172963929939294, -1.6779292499571659, -1.9304143814744077, -2.538649573124252, -2.5514865106947693, -1.7244474534435268, 0.45143996438292583, -2.942105958981056, -1.441097716396035, -0.5510583419287072, 0.6386304536555688, 0.6899135358082825, -1.296121724297123, -2.1399307066096322, -0.028214777939696956, -0.014273801175497139, -2.67707077372977, -0.6221706457070335, 1.8291211084093586, -2.2681753518854166, 0.5354852366858385, 0.5356721757727211, 1.1050821380576181, -1.2446024682759436},
    {-2.0452251676944537, -1.1363083700355863, 2.078402857628686, -2.357407780067975, -0.8185125439883897, -1.598191521292015, -0.06345641560023604, -2.3477227551184954, -0.8302443800312487, -1.9431413169385081, -1.5109355650197434, -1.97001659398866, -2.6315836434133657, -3.6052298456559977, -2.2356382636443275, -1.7515641481380364, -0.04675069604568116, -0.8911901448626588, -0.3770440828313754, -1.2041093779018377, -2.7164422456376465, -2.3520761896854854, 0.8885640658487283, 1.7049003295560106, -0.7466308900791273, -0.5329299534370341, -2.658556945723999, -1.711709254189984, 0.535362989187075, -1.0574116815995727, -1.3591522650329426, -1.5940309036948304},
    {-0.539522265027382, -1.451949179860455, 0.48254164958524165, -1.9946126292427393, -1.5292565117255719, 0.8055428919986561, -1.2179464494552388, -2.641606727445183, -0.14393552415053498, -1.0499370743886631, 1.025194061552515, -0.9653113456969171, -3.4262546471062936, -1.8694411814777152, -0.6523521342085247, -1.0059236313096047, 1.3308304802968696, -2.48139090721096, 1.8706297539632, 0.7814501675583444, -2.781954139428437, -0.6608814041503788, -0.9183668686211486, 0.6074851982715117, -0.8042346619337083, 0.8646861554203054, -1.624736716301004, -1.2950285120476346, 0.2928113732552113, -1.9840680394761883, -2.212010822973405, -0.32976487920891145},
    {-2.3674280983894564, -1.3377176278545206, 1.0757799162688748, -2.875862899795719, -1.079660793899275, 0.06523704198274097, -0.2112696572510328, -0.5166682355390623, 0.8093464753568457, -2.1596379530430685, -0.7137098644477275, -2.128971389198447, -1.773500551016532, 0.29041086772355423, -1.3782782787863577, -2.0247976612932366, -0.47317223372195016, -1.6463950001205316, 0.6890878697759822, -1.033229794156095, -2.67212293606333, -0.8914928490451213, -1.9437581360117435, -0.4830061406756898, -3.0870877592521673, -1.7194282252830186, -2.03085122302513, -0.2680198063944782, -1.5356276559660027, -2.3473384813224762, -1.6050683759734126, -1.3057632930328076},
    {-3.0448673662020753, -0.7921408096472852, 1.1630071062192606, -1.3105877077258177, -1.8725281454167169, 0.39928748549912146, 0.12706706501255535, -2.416299224616928, 0.5173230598883743, 0.21831502964853775, -1.5588609732089196, -2.407227904881796, -4.6046971717771905, -2.65544109538896, 0.30169259433631423, -3.961390808262692, -1.73814085903535, -0.9098386670235492, 1.6040254537038487, -0.9823629962599716, -0.17901668579380245, -0.42211692242981275, -4.270379533895705, 0.49918894239629485, -3.2482799242691205, -0.44561095531482314, -0.625073885970781, -1.0563502510532892, 0.07339219159427221, -2.4198324248183964, -0.892474593922359, -1.620395700931921},
    {-0.1627369242153187, -0.30028504221703334, -0.4132581246650173, -0.3466465078905619, -3.2499356940987827, 0.1467641365809218, 0.32035207952392536, -1.9654156866296846, 0.13929793743403412, -2.593677677034422, 1.0005396667224655, -3.2324199242413583, -1.2759067205663521, 0.6986093124559071, -0.9416484397394153, -1.1978076473969292, -0.7376264787436038, -0.5910568772926844, -3.6292368411335727, -1.4069382381208322, -1.1536750133177038, -2.91353548088674, -3.7134539139411573, 1.2297626499780048, -1.2681389705242043, 1.8615406791733144, -2.343769943649183, -0.03982114201569384, 0.8403688287988355, -2.407899891550886, -2.61506370582084, -0.5383254470186218},
    {-0.36904695451933583, -0.25275221779429985, 0.6340223859065265, -1.3415086440274295, -0.8943048190016804, -0.8444095839172522, -0.04990978440541205, -0.17131953845093237, 0.48173455777959184, -0.7863869048735561, -2.3288836261773205, -3.5668319590524815, -1.7696522870850209, -3.779694638549063, -0.5953111621197292, -2.5691118036641933, -0.3526412625159336, -2.756957668161445, -0.9158376891341047, 1.1054634718267533, 0.524956232627979, -2.53911646654381, -0.7875476017912073, -0.027989582752756557, -3.0578271503686394, -1.909507135550565, -2.7380487771700395, 0.1186636627585045, 0.8347730718865103, -1.8249070783991654, -1.573445558352546, -1.443463550322566},
    {-0.46098696440690773, -0.9050029646228324, -1.421155922886269, -3.612152096207118, -1.4354948778894794, -1.0542101837576079, -1.5331903942841756, -2.805395874425045, 0.1640043153841057, -3.0637905490696142, -0.40590014896709564, -1.4020622078525207, -0.8860264305812448, -0.606548221840777, -1.2401628857098819, -0.5075884677671096, -0.20376366963289708, -2.9518730950606153, 0.3609509181525583, 0.0836499635373812, -1.5166727514367904, -3.6264083700838095, -2.6979125914876496, 1.819808298452869, -2.1353355711415847, 1.5382184176062186, -0.026691238740026907, -1.2692833552211384, 1.2015280480805588, -2.8452335663949158, -2.732845224528909, -1.057427746764253},
    {-1.9394167770585347, -0.2542746361285086, 1.5745898081928644, -3.1670713900890006, -2.0101460980226387, 1.5934765889709517, 1.2399369899627772, -1.380631436536217, 1.1590791227944963, -2.461353813700218, -0.5501364908965768, -0.7881714714849937, -3.599940724666041, -3.6827700390395317, -0.5446706153141002, -1.3302466428451678, -2.3010748466402, 0.5161855022916518, 0.09368199697913383, -1.5322354276915404, -2.8663667066486664, -4.138004039449633, -1.469552073498951, -0.727419886545138, -1.9981953436363185, -0.19362068441542302, -1.6692612641265336, -1.2970076885667423, -0.557640977324351, -2.482825521146523, -0.8618833860329369, -2.208942395065935},
    {-3.3759259650513433, -0.18821668985882525, -0.32433244366575287, -1.2361502597694627, -1.5699035666864736, -0.42358278292574947, 0.7857698605906211, -4.33152662930482, -0.9587013476126298, -1.875468944525149, -0.9152933124589515, -0.49904204671971664, -4.842316430648868, -2.7542525550145616, -1.0729767774636645, -2.3548804810414476, 0.7581114743200774, -3.1604027594287216, -0.5116521090164832, -1.5194174345620495, -2.223286151902589, -2.8138061285348743, -2.69764889102352, 0.0900227872141557, -1.2029833376401657, -0.11183912169034013, -1.3858767017408313, -2.95166402531745, -2.974470365783403, -2.6967788516679994, -1.2518840223534289, 0.16587468681086484},
    {-2.2632156514490265, 0.26320124962119174, -0.08051860784133733, -3.000651812576676, -0.9347842473711758, -1.2019303486579587, -2.1248710649097693, -4.301926093599687, -1.7183305081246445, -2.6347603797174006, -2.1206024501093013, -0.7726830702739621, -2.5954190453972665, -1.326195845633786, -1.0780315962964477, 0.33292949940127287, -1.529075692335128, -0.23262315387293422, -0.37209162827477765, -0.9447311375491648, -1.4687367400110467, -1.0589860023498325, -0.8950487618611458, 0.5761388921133804, -2.81849383614447, -0.5191059160589836, -0.766677696842642, -1.9257643024111968, -0.3780600575961616, -0.8637752707402596, -2.968843855976594, -1.842790045226327},
    {0.2862521509730089, -0.09527246087649675, 1.6876563975851222, -1.519994649704512, -3.1210954035982925, -2.6639346447908814, 0.34562156597234533, -2.3419845338673055, -1.7119297264264315, -0.8970280228206209, -3.3365088353797527, -0.8392121797871278, -2.1492222135253303, -1.4927977889757733, -2.504526599068459, -2.1769672746971462, -1.614904338164063, -2.2610584660513777, 0.40219311797275736, -0.250136746155203, -0.990753461016, -2.6406397381372324, -3.1468347976814175, 0.23461570587587277, -3.212834442274018, -0.5849923576776366, -2.463995377684033, -0.9955728847149438, -1.6335272978814888, -1.6149216107183113, -1.7352417120734747, -3.6444693993751685},
    {-1.5844227419942576, 1.7761148784827334, -0.9038457862287708, -1.4230758562840495, -0.058624703187228226, 0.8734519643410339, 0.24290851831364463, -2.053258840434922, 0.6981892176669913, -2.532610361346396, -0.9396741512894159, 0.87323651663545, 0.45347210442070857, -0.7547808644803545, -1.0656209108854549, 0.27747657311605367, 0.2807146159036044, -2.4490196225992524, 0.18434765733806324, -0.0402601111550688, -0.46247854650693276, -1.9239242564613928, -1.2238007172529854, 0.7385545816088759, -0.006742547535723452, 0.24122823861330187, 0.522442667194832, -2.793518678370035, -0.9824080725446799, -1.6690602979708775, -0.28608855116619947, -0.9794104675306927},
    {-1.9535789654821232, 0.808418922723304, -0.0181917464023253, -1.726617825727459, -0.9798185131971812, -0.8621174758130125, 0.86475986550618, -2.513101723020853, 1.6972107751996235, -1.644331745960861, 0.8402353828323876, -0.19112039905906575, -0.3274138070500536, -0.7703453669695809, -0.09070457346254361, -2.039398592685051, 1.0233556205417036, -0.4636748427457473, -0.041222747623676136, 0.5277684123252414, -2.8776500622686547, -3.425770090780073, -2.752448779345374, -0.7404181082149361, -2.6319127769485853, -0.44741572828615417, -1.2539685745780578, -0.27544451365094275, -0.5038825684091338, 0.26005856934334126, 0.3094186850554917, -2.5879329670694027},
    {-0.860818128312875, -0.7371374807639662, 1.752167665728116, -1.4805123908311157, -3.2485898616863356, -1.704008403556507, -0.8784960440349178, -1.4997090950061862, -0.6836263020376147, -2.953350668533119, -1.4591179654585433, 0.5609145083454027, -1.1832877482765056, -3.2327604409000785, -2.101152380031437, -3.188826780682416, -0.21461907690487045, -2.585680874083772, 0.3929815051621629, -1.3582479997696648, -2.518066169551427, -2.7906000977264105, -3.2634764253891864, -2.096258434831776, -3.2981538201526117, -1.5879795809038129, -2.3973609947461694, -2.3973255456627816, -0.8006506971209829, -1.9375622752710158, -3.3212791798102366, -1.3165660455999944},
    {-2.792979479323341, -2.3694346624027562, -0.45479836088303305, -2.670050235226043, -3.990232016697332, -2.5197305798378347, 0.8578085539323721, -2.960604279428754, -0.6795257742147788, -2.9790977571819086, -2.290686643674632, 0.40894104437809015, -3.0736006318329063, -4.558660333893489, -2.8332132527536222, -3.162614663903771, -1.052588026041653, -3.3548110383653524, -0.6492999548379298, -2.5533335757653592, -2.956676703176015, -3.571403186981339, -3.9845004022319235, -1.4661453353049223, -3.439855259408137, 1.8107106967308682, -2.7844675927968554, -2.164714071697239, -1.1454267788517811, -2.080648622509543, -0.5692849436384139, -1.7860725976014953},
    {-2.325398936257179, -1.6785677858674606, 2.3026148827209263, -3.838481555262645, -2.026617600512495, -1.468475452394782, 1.0719917602814588, -2.8292355594072047, -0.04183962230106811, -3.2257992074158057, 0.13103933059821174, -0.31854780644620084, -4.652855936082035, -2.8140274549978495, -0.8012784328988876, -3.429588180794916, -2.030322532649218, -3.194794389946389, 0.22288335307446494, -0.05099201983371515, -3.4239540791089693, -1.7238788318248315, -2.8640308607988074, -1.4127673406929417, -1.7698261284472532, -1.5810375963423435, -0.4023664040716596, -0.3313532677540054, -1.41061583370728, -3.39803970277152, -2.145652416009312, -2.532034482780558},
    {-3.7054064245816014, 1.111517787358759, -0.7166249520440294, -2.6483364474805406, -2.8547603576810183, 1.7151407652608197, 0.5278628989622113, -1.4906115984119415, -0.2341082260209008, -3.014593829592802, -1.2826282397294035, 1.1735592300700453, -4.894132530339204, -3.8456670875293937, -0.9232684258039615, -1.3699045666219567, 0.028718840346865004, -1.6461807803396886, 1.5809375076127754, 0.5162873536586386, -1.66312221770505, -3.1181985097073883, -2.31038897632288, -0.3353964837457737, -1.326020655573411, -0.03912330421068164, -2.2811114051557495, -2.1284528912415777, 1.159302178939677, -0.4996754504579165, -1.2733688876779852, -1.1149329956566048},
    {-1.1276204032080015, -0.3283935782534457, 0.43113482672383935, -3.518674878538834, -4.359058417459736, -2.3240013464457725, 2.0558302169471614, -0.1585930369414315, -1.538009846568444, -1.9407639743255591, -2.5172832637729563, 0.3735704609536189, -1.7239315294004263, -1.0219917769021554, 0.26151974019840146, -0.6531962519175417, -1.8200650764915678, -0.8781808420124912, 0.8070516846502601, -0.7850163603371403, -0.5037424559389705, -2.0842990066864195, -0.9539192986795662, 0.62704554410458, -4.420915468359214, -2.3847776717018747, -2.3497747732626535, -3.0341260083104595, 0.8379688590598231, -1.0894663486889853, 0.0944455659412362, 1.9468440933215696},
    {-0.8107839845453019, -0.5396361202852079, 0.542905301358885, -3.6211842319268226, -4.313056542577424, -3.48369494687869, -1.4194669659655204, -1.3474772167623896, -1.1716532815291638, -4.611302119567232, -1.6187539650946972, -1.2550761158790635, -3.225773883791413, -3.2231459824583886, -1.125612013472851, -1.9049115682893183, -0.24972651668213122, -2.5885353593417832, -0.5399422290620802, -2.9159820290687724, -2.6400442503989443, -3.279766490809337, -2.331972932619335, 0.6961593484501215, -4.381965510933288, -1.0852467861975694, -0.9603583990898519, -1.1665360295897933, -2.565816042314952, -1.0265941258808613, -1.127349946099873, -1.0095352542955163},
    {-2.1483179000057566, -1.4843189970371042, 1.1887487231112184, -3.360174417823135, -3.3256443485173146, 0.07776008657535985, -1.7903587901164688, -1.7261857860029879, 0.1589143638854353, -3.845244737691551, -1.7427678102196926, -0.2075280529754094, -3.7378491392560313, -1.6888240102027177, -2.5534863518822988, -1.2458163020694237, -2.162515219531598, -2.2900289090915082, -0.7636178298448754, -1.0488265267550398, -1.8145435948143611, -2.9392071954014347, -1.869340497300673, 0.42622488035931994, -4.377758764897433, -1.2941619828743818, -3.123937198686786, -3.124335628094599, -1.676025487187677, -3.718268439838469, -1.3507230561369439, -1.7869425296044257},
    {-0.38972181641368, -0.3414456597468404, -0.3733745835709863, -3.056760968768719, -2.3310652196973938, -0.5040921489394432, -0.41249456064602774, -2.4356536217967304, -0.8369981250944343, -3.822529233668885, -1.680477863388088, 0.3759706791779466, -1.1107778814029459, -0.6094511230378099, -1.0675133221893438, -1.3139989668962262, -2.400223923577411, -2.0994252165298604, -0.9636330791989959, -0.9407274954833873, -0.13520180606670054, -3.6207684369852835, -3.7728065598617917, 0.5361867992247565, -2.5251282566356874, 1.128725061278168, -2.6525392818472966, -2.432541677958501, -0.15178622715453371, -1.6600848605447718, -3.342026783773504, 0.5019862124326452},
    {-0.9982419910296294, 0.5795441616098229, -0.5188747970360297, -1.1198080631054614, -2.802495620750976, -2.220666769977655, -1.6022548607664813, 0.3902165926946745, -2.596877347744551, -3.088568452591162, -2.2144393033233416, 0.2912771211504717, -2.7365238146658335, -3.354107110435851, -1.3465823848079364, -0.26048570311545866, -0.49227884025639607, -1.5682589300537546, -0.7673355871763696, -1.6467171312066866, -0.2895560178096691, -3.024943662007801, -4.054756225732391, -1.6900795244479905, -2.045782137224775, -0.6230472040365413, -0.9855450915411271, -2.3449675553686746, -2.610832698313868, -2.449345952766691, -0.006701478491165651, 0.1494953686640708},
    {-2.390447670226821, 1.0488411399120905, -0.8672334773139394, -3.9633384199640638, -2.7082991175352165, -1.3091517130418906, 1.1031671126471512, -0.4878802855133483, -0.9663283092651717, -4.170666907099367, -2.6396519236818077, -2.6467928553925386, -2.6990068341182254, -2.4342769478665303, 0.20567980394765956, -0.5128731283017542, -3.078610870973535, -1.8117424381112863, 0.025453038218271083, -1.135590758833331, -2.4095269882474186, -3.433869519727838, -4.090843789757957, -0.1796263070108419, -2.0786280407083364, -0.07048511152838546, -1.3624230554038734, -2.191493774223101, 0.013590863446499903, -4.609752806759735, -2.4985795402860536, -0.06366960157176421},
    {-3.2529539294107837, 0.9915892033316414, -1.2290339309966918, -2.7372008663134166, -3.948570419939479, -3.031374990646107, -0.3749378610594254, -3.0913196361836874, -0.3009581902995453, -4.653518814421574, -2.5958694238838245, -0.9340964632284834, -1.6673246638827506, -0.6920454022120706, -1.1211861520335882, -2.7963536226094208, -1.7092263379411607, -2.7728800878485047, 0.9257120823025833, -3.333015390438355, -1.121994556576311, -4.9733225396419956, -3.3498259317037506, -0.3862212479876615, -3.792168030230618, -2.302159771689473, -0.6916712488574547, -2.486681560451211, 0.14088764412558777, -2.5940921188782, -1.0061314993517976, -2.9942251841039482},
    {-1.6248119925348345, 0.5521013246498571, -1.8605773434334565, -3.313742675247881, -1.1263635383020028, -1.1217833204489986, -0.15336927642378873, -1.4181879260677142, 0.2327011275814167, -2.8586490121810226, -2.60402317172949, 0.5082655160573302, -1.9974952167474016, 0.1800534459821766, -1.0356643196441848, 0.49227248191012596, -0.8828535615508216, -3.7004336118154035, -0.11326169372451095, -1.4548297746964705, 0.2238156346056076, -3.0021680031523195, -0.43258146398181146, -1.0785585508110829, -1.2229352953557875, -1.2716690990573931, -2.2325685369012933, -2.503988124372157, 0.07393052282571506, -3.1510862217158304, -2.7272054612814007, -0.20669047076285163},
    {-1.5040974708882544, 0.7025162916405389, 1.4642780580520212, 1.0446044726429797, -0.46227917498976984, 0.9547888583899247, 0.21614163820842067, -4.056419504485117, 1.42303903303924, -0.44688499449990843, -1.5798847178139626, -0.7775603256108786, -1.1381763385589827, 0.701311957611353, 1.1252689065396928, -2.462015443308063, 1.5306455150996399, -0.0592682593139537, 0.20208067711331845, -2.184881410699626, 0.002499690960692853, -1.0556388363478133, 2.2389135736728805, 1.6956198314109134, 0.24111683722910598, -0.6839925956854906, 1.1553801377153579, 0.6416700765238494, -0.04957767063862938, -2.592498769731466, -3.549164846899197, 0.4225084118751464},
    {-1.8039653835866014, 1.738246477765426, 3.0452635767972684, 0.4974125920055304, -1.3855563891530747, -0.8102493351614993, -1.6496216372487322, -0.4463488213780007, 0.813015468153022, 0.6018382882962051, 0.5398999412101345, 0.30036430057821256, -1.0995799115143812, -0.16471675782696013, -0.1115199442515661, -1.098118636025546, -0.6533873230927112, 0.7594470512842, 0.04120506997596118, -2.3827276424872466, 1.1165301327239288, -0.774998709196865, 0.06550479412984156, 4.030585597252518, -0.3986669794249876, -1.696120298256471, 2.3864465041543577, -0.2274761525420432, 0.6318580198538684, -2.0925655624770703, 1.493489209097329, -1.4695925099313654},
    {-1.2963045006282363, 0.9788597942341426, 0.45294249818212196, -1.0686484053717644, -3.1788161479268866, -0.7644430719633313, -0.05842848575595583, -0.5615001014649563, -1.1696389524827155, 1.690043571406714, -1.2320929460136811, 0.3218185252025711, -2.3140760609135533, 2.6417226634281117, 0.3026117763202608, 2.7259939222502694, 2.3516812498630535, 1.3769001424744869, 0.6576724327233595, -0.5585454464084196, 1.5341553154248608, -2.5946260266123997, 0.37901525464820385, 2.465972707526693, -0.6368698294668879, -1.7521735636485236, 0.4494535488391455, 0.08541176013914503, -0.14966778770735742, -0.32214045229398725, -3.7872002531900817, -0.8861828480998634},
    {-2.0882694527951977, -0.22690475926650866, 0.880540236979958, 1.8515013871928252, -2.111670681567412, -0.4509394803604993, 0.5971672086581991, -1.3590643340336532, 0.4757648521102788, 0.6681680467197689, 0.265862933660394, 0.0026963322671217983, -0.7561653284118283, -0.5763559597913069, 0.7021455519691564, 0.4971866066354575, -1.2394166795546684, -0.9327597892915624, -0.43266541331774727, 0.20332389156585873, -0.75757565998732, -2.6752685848382787, 0.7018161920850889, 0.5059139518181139, -0.0959692128349916, -1.1647020960670462, 1.0842443872393275, -1.166397013851609, 0.49763566623597677, -1.6011423313279671, -1.3061236849734228, -1.8498396955472152},
    {-1.630221926934453, 2.982017715679594, 0.7889081956550089, 0.3733168161775597, -1.8457954066036262, -0.6138879178011167, -0.4526923037748354, 0.22484201621345734, 0.28597692751683906, 3.063486837139613, -0.33794163113915804, -0.7869116277032921, -1.2906223544968638, -0.7715311422053208, 0.1853164349560138, 2.383976272907129, 1.591849342573491, 1.4721458194907313, 1.2348152098774472, 1.7245965837920014, 1.0104418542421314, -0.692181645618626, 0.7006724720823904, 0.6422102504342597, -0.5552405301745914, -1.8677230040506554, 1.509645354979301, 0.9402352085194153, -0.47537818086091704, 2.286256752758999, -0.3873024621439077, -1.3463536294833318},
    {-0.4046356691851913, 1.001556267575544, -0.8649312085496541, -0.27313848178044575, -1.7023558623052375, -0.5359384368136256, -0.7611592059848382, 0.08992773233177925, -0.806499971124364, -0.6132343797499759, -0.11610352342205543, 1.6530598777321934, -1.0724800140771709, 1.4597772061887044, -0.22718155444713786, 1.1076605194098121, 1.0079633505731098, -0.404239049940546, 1.072594330757084, 1.3022484637851843, 3.599830043999752, -0.23245539418572625, -0.8737728391092462, 3.100742115654548, 0.09562138925957145, -3.967425395286933, 0.24355215012858597, 1.1842246020990645, -0.3817885688855116, -1.1794218250485868, -0.8819992346040493, -0.7439606703751654},
    {-1.5466047794864006, -0.06609479385591595, -0.07257578328855431, -0.678723805973593, -1.0738835478602866, 0.3057175520944919, 0.6560498762512245, 0.3347070551432504, -1.4988079142266901, -0.6309909843096871, 0.08352919425474872, 0.3211613248236305, -2.167961899061216, -0.939824030271699, 1.195476064820068, -0.13839335158198868, 0.8533606616836379, -0.6385676910241257, -0.7263198432285121, 1.309191017056461, -0.19473179724003903, -0.14653208823140576, 1.5945634284955894, 1.123324819487556, 0.5854635150133135, -1.9323087247148076, 2.9905146338774293, -3.2530650261125142, -0.026092855232143823, -2.7093912787179897, -1.8706340952752383, -0.0077903614658434905},
    {-1.7085776936531611, -0.3495884564314074, -2.97592636626137, -0.26108432653873964, -0.4292338113262902, -1.1795467977083507, 0.7404129773484657, -0.11476013483713046, 1.5358981256723687, 0.5636879740893709, -0.3392931717555492, 0.3031849013596265, -0.9350865575782364, 0.28882192840480353, -0.7387213425401992, 1.3438082775365856, -0.8981910099257738, 2.4490546096074186, 2.0243153744811546, 0.051330652478955664, 1.0340061001394116, -1.6769559578820994, 1.3997614940392493, 0.42780413998215777, -1.055871725688861, -1.977830145082834, 1.3053768070227922, -0.4972143849896479, -1.5207534984984383, -1.1799000895435643, -1.1041449667232335, -1.9752266675966224},
    {-1.6661536040950629, 3.9562969651125814, -1.9540201494998846, -0.642860572822623, -1.3468654273452303, 2.0383226548549933, 0.3115762902819787, 1.9708171785309392, -0.8751432397788798, 0.05968354104591404, 0.20695917175900846, -0.20266128310812762, -1.312162922474298, 0.9508615082823889, 2.8685843415467507, -0.2729313089077039, -0.4791429272382506, 1.1184992017225681, 0.037186104562572514, -2.6995124689965757, 4.03167185797195, -1.8472581348952448, 2.568107547639255, 0.3102325062991757, -0.3842795167986973, 0.17584420237548667, 0.5793400247393553, 1.050489962698517, 0.7212038976262968, -3.2285726384471904, -0.7901053759747996, -1.6333090966679966},
    {-2.3372847665763703, 2.878166265352264, -1.6621193901113784, 0.44301138489878383, -0.6635690886311224, 0.10271087519086684, 0.17643571108882478, -2.042506445946048, 0.086418125720193, 2.04310472932745, 1.3425178423065387, 0.10676885131860414, -1.3056492351078968, -0.011495993435722366, 0.8023190661320989, 2.1507689024493555, -1.9713534486561852, -0.6720547816570024, -0.7589925351294519, -3.534536634161499, 4.005633643828154, -2.471924796423676, 2.2274536900793596, 5.036132975760589, -0.8799361213790331, -0.2044397082247726, 3.157690564558608, -1.32669515196671, 2.578553182609833, -2.428538136420799, -3.0398366639698136, -0.9895039839842138},
    {-1.2489804231457922, 0.33369749193786985, -1.9773967185068206, -1.2811836411346325, -0.16690944816266662, -0.8446216721857375, 1.7183971625071468, -0.16597481683522036, 0.9487843527032377, 0.34607708346068783, -0.7367140992618488, 0.08069345828140512, -1.1844911948558305, 0.14290775396815691, 0.8093754522177735, 0.07631842642432593, -1.286172658173636, -0.5476997080112619, -0.101282908069895, -2.064393216412297, 1.850081017629627, -1.5058735671763164, 0.04261055804058366, 2.7104190433769673, -0.3932572641640074, -1.3432091227543135, 0.3703077330037983, -1.7195966175084982, -0.8034108628283642, -1.1442426958968026, -1.4284750879727022, -2.6834074529197323},
    {-0.983874645131364, 2.306776919082024, -1.7868772501091923, -1.0795606231054047, 1.9464956801916726, -0.5562141150699583, 0.8203365688037401, 1.133989542171896, -0.7812032052906884, -0.38174761226923676, -0.16108830710929217, 1.263173110487476, -2.541415782952686, -0.18329124764266416, 1.4598337335029095, 1.0712165976157333, 0.9615053785365079, -0.6491550377466749, 0.08457177372724455, -1.1675226381727781, 2.0811599405304686, -0.5606986975024157, 1.3569770934799086, 1.077286264061633, 1.3391419253435446, -2.0712419155946544, -0.5417917997433443, -1.4110533545874808, -0.7958503959988541, -1.098333074623599, -2.242810244747597, -2.2023469664555417},
    {-2.226119591180783, 2.020706861527712, -0.7294044925324804, -1.3442280205082568, 1.668643218987718, 0.912492477049187, 1.5465588713874263, -1.567083834992568, 0.11085766499475824, 3.5108002841743975, 0.0458317665060902, 2.816544862424374, -1.5319134694761998, 0.12917041110596114, 1.2039384057934113, 2.5460063574554055, 1.464496993923138, 1.1712670436112, -0.25609810096321733, -2.027880422634942, 3.15589307973629, -1.080894230086673, 0.027744284926516927, 1.5864917639390828, 1.7128615682455528, -0.9044856962229672, 1.2935773627652196, 0.9647743017704177, -0.6649536806616007, -0.3976239582008164, -0.6137074066098743, -0.7316518219358451},
    {-0.3742057797674361, 1.7297159477921318, -1.0568292082936959, -0.9272459552430197, -2.250939635475901, 0.6268384475396047, 1.3450494193697764, 0.12759768155911763, -0.7514089111893121, 0.9955296861222419, 1.476712300740634, 1.3300423464174147, -0.6438974600720573, -0.002576550531710091, 0.9765654961685719, 1.8669782296041753, -0.04481701901642501, 0.7036521346596509, 2.18654836830515, -0.08558053917687383, 0.11976227904007393, 1.396665861487854, 1.1890121931891129, 3.8785559065313646, 1.272865054875729, -0.7389806087663779, 1.0337291691086423, -0.814897321398199, -0.7693716892556233, -1.182390368402375, -1.7414095166171317, -2.1835201611059802},
    {0.009112882695388777, 1.7144643783511724, 1.4011151254499037, -0.22003173474393178, -2.7907929750897513, -0.33127664258319944, 2.0358119228676395, -1.605696523909305, 1.5222023399216356, 1.1135916013443983, -0.2522265948484525, 2.316412954920863, -2.9153252553813633, 0.23427778780309272, 1.88535882715182, 1.3806383733339578, -1.277555176252932, 1.4330123032285798, 0.5862394618651121, 0.10845167844065377, 1.7803125195202785, -1.723281643332658, 1.462107077512862, 3.2473725749706954, 1.40980284077593, -1.313881150744743, 1.5614254567915358, -0.04128035384932271, -0.47632334139715, -1.6525755677206098, -1.8223066625070437, -0.3637079275536937},
    {-3.264070313181398, 1.8338410008235075, -3.604769962641216, -0.7843456495743653, -2.582172494380157, -0.3339841942092777, -0.5613316165391248, 0.13930390061439168, 1.2367586801197994, 0.027862162110451817, -2.6137762053723033, -0.6141999292117221, -0.18876417099745202, 0.3677791253404446, 0.05253269214013115, 0.479766428189181, -0.1848769129628231, -1.7863094492140636, 2.8113034401158505, 0.5666358561640208, -0.04015178482359916, -1.6497930024579655, -0.030024197016154726, 0.6692013379780611, -1.7354058112898516, 0.2042788275715545, 1.1530212484664446, 0.9523388009989744, 1.8477513811341681, -3.6686020455471455, -2.5756603159353424, -0.2299072341679311},
    {-0.8648041334927421, 1.5365210090633503, -1.4833788944999604, -0.14905278903651203, -0.3742876657828436, 1.4277532779419904, 1.4621209390296837, 0.9479381442698259, 0.9813801481125628, 0.9879679856004281, 1.70739298256878, -0.6218793267426408, 0.2415807430585243, -0.7150223681839253, 1.7280115184361529, 2.2976037618574283, -2.697411914386965, 1.775286906230718, 0.3286852058245026, -2.8292634296179244, 2.1148278027292005, -0.018254563594149058, 2.048432752874757, 0.8123963673353559, -0.022256930014928532, -3.9600138905048143, 2.377139729330609, -0.16872295110183014, -1.2373016538325186, -2.7424061338122567, -1.7954523165689327, -0.8040262802338789},
    {0.11254920912814549, 1.3997716552787676, 0.8887853045156523, 1.2699227618674747, -2.9376986105841905, -0.2195481431300224, -0.3295165193754325, -0.21633318650272526, 1.5514581199837751, 0.7729341570303802, 0.9491251459871469, 0.7931677949750187, -1.7684485781320196, 0.5187757769148239, 2.827098907459117, 1.8476598588017294, -1.5421619785122818, -0.18823638429793715, 1.9885375000760603, 0.5880539760896454, 1.7795960595010818, 0.41524140510233615, 1.2740635873346695, 0.7022920536231065, -0.48647231913802, -2.4318829234398183, -1.3547326138760967, 0.21488950986559152, -2.449104263621155, -2.2781921414618993, -0.933082047897091, 0.5328218822654022},
    {-2.0480297614771272, 1.3903088920123408, -2.5646686774082985, 0.24153155723667352, 0.2582793894969627, -0.9483247819516564, -0.0420698190590451, 0.09998327899732676, 0.8632310166265972, 0.42507077047309844, 1.0189031882458743, 1.6731928300540972, -2.425026558507062, -1.143638193205325, 1.127058917742562, -0.310974574908316, 0.2901962959253787, 0.7169129537350997, 0.8611412365843358, -1.0638521781292545, 2.103716891345444, -0.9373300668699203, -0.6472419224003285, 1.246643350838938, -0.44538892062663327, -0.5995791407774308, 1.175765525272275, -0.4632882262626691, 0.08592230654146721, -3.1280872971222715, -1.1946765294977146, 0.23897389225471607},
    {-0.6021587665010092, 3.2026676537442373, -0.7688589596915212, 1.8217550622363043, 0.9623819172755284, -1.3212896461471269, 1.0758569738178148, 0.7801906610142523, 2.1532019518046464, 2.190542568775945, -0.560460351757438, 3.792330343697712, 0.3070511778047149, -0.19985315117227678, 1.2455253318206125, 0.8082295484262337, -1.8252067424885827, 0.6060688612779297, 1.4721171913100903, 0.999477398845215, 1.4728868836160804, 1.2895943757311146, 1.4610691060287293, 2.7113827597327127, -2.0501189333678465, -0.670565142409434, 0.4259188360679373, -0.13518429880732186, -1.336864214197764, -4.325877672046796, -3.025309114824303, -0.4026526324329545},
    {-2.027251373452572, 2.004163570979587, 0.6964818681356828, -0.40747725156539777, -2.4592652246502813, -1.9530663762994378, 1.3635841855911854, -1.0680164693423617, 0.8849504559586239, 2.341704942173031, -0.8542438829468789, 0.5562915113237485, -1.359821971801074, 0.9995137758819026, 3.2108453902672056, 1.9414039560039573, -0.8840205162838186, 0.8264642020450012, 2.1252527762349884, -1.131000834876098, 3.4489672272550496, 0.955530656209496, 2.4743985024965163, 0.6180315847010234, -0.7780145259380047, -1.9426939309178684, 2.6178479923012277, 0.5059322357373596, -1.0492930985001436, -3.4721497727267, -2.318260086237587, 0.07497922161010638},
    {-1.9474084355781687, 1.8854300448153842, 3.1308830848141636, -0.004728380905287395, -2.7930549107927387, -1.5075224222207695, 0.9512862695569237, -2.74045465227863, -0.7135455397265235, -1.047293200500319, 0.29732425832776616, 1.8061836339439608, -1.3831873493931, 2.9761233927778483, 2.4913144743245335, -1.0429654543844646, -0.7154102718474532, -2.847904912621545, 0.7788263028959362, -1.1760061853354977, 1.2090237160341426, 0.3914103986869373, 0.06968059259413677, 0.568328429395511, -0.5035885036580601, -1.018336598757535, 3.889497434005483, 2.698067130600608, 0.18420344465570226, -2.332346540566933, -4.86934161154704, 0.8744247832191078},
    {0.3502426494156341, 1.314204143873039, -1.959871873517656, -0.972401308863086, 0.40987575335647797, -0.8348368048514585, 0.6094319109555156, -0.9255329204021407, 1.30988235822451, -0.19339208582151568, -0.02762078272234704, 1.5053271481669315, -1.244724605178961, -1.1367515424662948, 1.5081343625075623, 1.246256244483752, -2.0795955819907226, -2.01728392487809, 0.7876124656072002, -0.30875745098385016, 1.9661333627032773, -0.7639031453456658, 1.58846308353106, 1.7061842653837893, -1.3824284394939885, -0.2863989286690024, 1.4301142372701028, 0.1774184458814841, -2.5293120257409054, -2.165648059568747, -3.244275766492281, 0.5250082447752363},
    {-2.2614208560736784, 3.0086774513977113, 0.08487414472147235, -0.06292776704531203, -2.3256265063426524, -1.0640052410285123, 0.24439074884565543, 0.11901169657558909, -0.610118699738354, 1.8783314430457438, 0.42968388366823695, -0.2696729294697705, -1.3547107643668896, 0.8415108233907442, 3.110722124369524, 2.7256523939759902, -4.4941247099025, 2.0180835107647987, 1.783967734450915, -0.7208508014540024, 3.670253936717358, -0.8617597410380176, 0.7992270630092926, 2.23055808158861, -0.2009548019447652, -1.5540145915004873, 2.5915396828646307, 0.6133542099827944, -1.120844800807306, -1.221676417831839, -0.8138127828585013, 0.278735615795383},
    {0.9432612430064693, 2.730647076927428, -0.4810217624607221, 0.18312142031130044, -1.5744630576562089, -0.6899652322815074, 1.1956496766772997, -0.17460783696546514, 0.835358984865166, 0.4214508945215881, 2.3921446399612623, 0.5354621411333461, -0.6346908198690857, -0.22088985593194765, 2.696266433786718, -1.587189792089415, -0.259158859825922, 2.0727746908721936, 1.62004712284465, 0.42649760105777784, 1.9339545331777064, -0.23230167324093434, 1.157748642529534, 1.391425618505395, 0.3532274724118865, -0.555450604736985, 2.372605492891317, -1.1654317108025114, -1.167422597670945, -3.174395082995081, -1.9384696158102686, -0.17758756132054623},
    {-0.5494623487439338, 3.239286280566632, -0.8353243512458977, -0.27657584981633315, -1.396260484236632, -0.7188093047748879, 0.8896432201702776, -1.0603330637212758, 1.7368627196154733, 0.47377263419635346, -0.5933115801614316, 1.6590501744908115, -0.7023450389358407, -0.11776264192980933, 1.5297949931731243, 0.5810756970988706, -1.7217901167594027, 1.2173649807852438, 1.3221565574138217, 0.7817781742900202, 1.0657059051485431, -1.5071562647261998, 2.64902050882141, 2.5095729864744794, -2.0226571276896657, -0.9687973530194671, 2.0807034375296736, 0.748979429316921, -2.2071044847408205, 0.3843151601490389, -1.6025226591478388, 0.11306641469444251},
    {-1.177470354016872, 4.674442538123527, -2.2985649688368115, -1.0041175483214844, -0.8377527072427603, 0.41235461601014806, 2.0490415790580916, -3.843627707287831, -0.15827219976743917, -1.208018173830065, -1.509901209028643, 1.3747047003494564, -1.942002714791761, 0.7771493514927877, 1.1326809279790209, 1.5756880811582819, -1.700891788810065, -0.5015276406367147, 1.8799238573158294, 0.36434099917370055, 2.526106980426613, -1.0023174522329164, 3.682923883810066, 3.7386340519240018, -2.020744762585083, -2.3396237382985596, 3.4556077917252686, -0.6018540650190011, -0.5639329110237132, -2.4012985957745863, -4.720172367840517, -2.123015306797092},
    {-0.2320608559945843, 5.2653378504986295, -1.7407061978113738, -0.8145846920735155, -1.1972953607888035, 0.7155582941754763, 1.3122872898187146, -1.4042103693151966, 0.9253452711562499, 0.11498997725144566, -0.46217675166581695, 1.1010631576257988, -0.9372571865020739, 1.7861080230518451, 2.3523467952456003, 2.6467376960194997, -2.185145550539115, -0.4128753813346837, 0.852854976702334, 0.8175333042687087, 3.915552187365925, -0.4908100956759608, 4.886694456148268, 2.055055153604603, -1.4363274463323343, 0.4266047012469741, 2.2588196334877777, -1.3945714735886074, -0.480543289910654, -1.0609442620964304, -1.0026310890453998, 1.9174194913740197},
    {-0.4341097900876744, 3.6734703198288425, 2.3899247566950823, -1.7581572658049713, -3.354281468583606, -0.5268895127770077, 1.6550586474490343, -1.5395385342992483, 1.7637451931144192, 0.9577219327538008, -0.22758406637446207, 1.399776457597104, -1.9501393143897001, -0.31562422081452585, 0.8827481373746912, 1.9130714187694187, -0.8278855458421601, 0.25901682564319145, 2.1930561699791764, -1.475262147862532, 2.920436847628693, -1.9898048286505248, 1.6315988004864934, 0.7895221694602131, -0.31282380756863604, -1.313260557764117, 4.781380305294349, 1.195085095419925, -1.467601637234714, -2.5504810717495636, -0.9719766174106532, 1.9745587992781526},
    {-0.9925024314575572, 1.8045406412325247, -2.1454412225235773, 0.053418567998861195, -0.5169215174317389, 0.3015084466374357, 1.0935410040747977, -0.3916902265979332, -0.05908141391639034, -1.6304659692870198, -0.9785368740483704, 0.8440979995534702, -0.9678475767561917, 1.1419966571070208, 0.7248229265044612, 1.155687266830509, -3.445493321458656, 0.2542619553805503, 0.9552215541025975, -1.620310215301868, 2.5408726360403047, -0.22936108445854048, 1.1698378870672794, 3.1962592387361126, -1.9679793148130633, -1.1914149455565883, 2.144889278887112, 0.22962981858831547, -1.4241179163714213, -1.117780307731537, -2.7739739699081496, 0.514297158708738},
    {-0.5629983064068612, -4.203957905850759, -0.7710895141916114, -2.017098782733366, -0.7325368761284959, -4.699569588402583, -2.2184281018899856, -0.9170048976043551, -1.0738877402235911, -2.815018865185296, -2.3983359260994654, 0.7178877253781716, -1.5833420294061056, -0.13877912734845335, -0.2478214182184455, -1.269005894723922, -1.803447930067428, -2.105505012388012, -2.020098479564599, -3.583450201972948, -3.092967147340352, -2.7220215261895957, -1.7341810101938224, 0.8417213627578242, -2.8190546278971182, -0.25428389885443126, -1.099803643727836, -1.6784206924820804, -0.9924142334224618, -2.6278095091874656, -3.4780931115920155, -1.6194431367612052},
    {-0.32186305993476855, -0.8133158085019407, -1.519554336277483, -1.270307782789652, -1.4136859689273102, -0.7342250868998039, -2.371917086012802, -0.3393627129432903, -2.1400625814749494, -0.7667734179458414, -1.8252052511564725, -0.15885704474697437, -1.3140146081359678, -2.23309568912184, -0.24273205447849497, 0.8013786011632449, -2.2767652728902426, 0.3079612812970687, -2.1774174146795353, -0.6455569486777935, -0.2254128466883254, -0.14558068827843879, -2.440730541023547, -1.6804387825122662, -0.5603004148026335, 0.5683556380470293, -1.618973163658178, -2.830068253010618, -3.8398495102346684, -0.31154817601394047, 0.5437752787173398, 1.2427355053147948},
    {1.883313351516844, -3.549540853587878, 0.8824713938793417, -2.56471424868836, -0.14263270059933816, -2.2668581263442307, -1.8389409889799164, -1.9038089653542924, 0.16597261760163803, -2.1567838128988415, -0.9745796386766955, -0.8178453569165639, -0.6185177032220363, -2.2357613025499643, -2.7021006694440786, 0.9612142673039558, -0.1623858712537232, 0.49793930056590663, 0.42218338727933646, -2.4871788056256237, -2.1850664550112127, -4.06768489971352, -2.0814851779004155, -0.14851617080665894, -0.5485954630957587, -0.7354720573570424, -1.0828783789326457, -0.9605805631054795, -1.010971429791034, -2.2973551537690664, -0.9710661164170267, 0.4904361054020556},
    {-1.1494959179128397, 1.2312710590440406, -1.7451644439172984, -1.9374546384200264, -0.3871322923065724, -1.2389993729280897, -1.4393309437564465, -0.22718375577215327, -1.2171894768696827, -2.2268947577943505, -1.7783001761914208, -2.1330374420775895, 0.8373562001208412, 0.4772853267966473, 0.01013505586418967, 0.6624284837998361, -2.016125910863524, 1.1505980926202577, -0.19248549061053555, -1.454316091281496, -0.4936056134232665, -2.55556468962591, -0.7004394577254333, -2.3874822944693137, -0.3417226939625891, 0.953716348896071, 0.950218134313371, -0.38235521724012483, 0.32607313110770786, 0.38901698805042884, 0.04046909169421738, -0.26846102870238386},
    {-1.596110582265009, -1.6362954427774603, 2.670538404419607, 1.077646441994419, -2.090369818451028, 0.03404116428650693, 0.4825675392723223, 0.8740285248554411, -0.33109947135980927, 0.275107150906875, -0.6455741318529038, -2.862836389573766, -0.891674692847732, -0.6696112899337621, 0.20243606638534123, -1.3431017019724816, 1.323166923013876, -1.664701825974405, 0.4307852139951761, 1.230453655325021, 0.10866421661043482, -2.7418116850509184, -0.014366174196545413, -0.2213340109232771, -1.5467394596566868, -1.1625685285713796, -0.11891987093420707, -1.5567216880653951, -0.8502042897669844, 1.355902564075557, -0.14864816082478516, -0.6818206344345715},
    {-1.9957463133568427, -0.25185515668523034, 1.2399987265075372, -1.7219012582263773, -1.88076330171146, -0.238511160823576, 0.4336370890413294, -0.7133172375636712, 1.4718226215941352, -0.3162912315277977, -0.656239263115808, -0.6404967987908569, -2.79034977649372, 0.27321899471116534, -1.8033054871980476, -1.0547317488129233, -0.6912618335751441, -1.2736542934158868, 0.5058337593191972, 1.2389747437789085, -1.8850655547375033, -0.7143637168109118, -2.3473620295090774, 0.7981848114789161, -0.5698650813167331, 0.604513050280943, -1.0843040324027091, -1.041999450573553, -0.6451893734355097, -0.22927667285016368, -2.0394166268068648, -0.30426082634544005},
    {-0.49756425898858714, -1.4000729316308111, 0.8265963660109332, -0.41295216343844177, -1.0195507914390232, -0.03866269987801309, -0.44870567611026574, -1.4907076943390334, -1.0645812947198279, 0.027600884468566667, -0.7531432868772358, 0.10503638579841224, -0.5659607600643172, 1.3434608882605765, -3.008287483898637, -0.5616052392973635, 0.3939329935220019, -3.2123177239664176, 1.3159093472941785, -0.4818073811587509, -1.001672294678149, -0.9633830114034666, -1.3419822394870997, 1.8362047552208272, -2.607845512335711, 1.1751353552534383, 0.20895338387609483, -1.8351850969871375, 0.6017845108113845, 0.24369523611813898, 1.5664436639980646, -2.1373824681143274},
    {-1.0537753365953382, -0.29767270100787907, -0.39660159943115453, -0.42223694260171285, -1.8510644174257704, -0.17023790275612288, -0.4472109754881482, -0.08330010464309882, -1.0626733776072985, -0.7187482584843599, -0.3444399203051643, 0.7622012603766827, -1.1377346950153955, -1.2528686336515826, -3.2663648581744367, -1.8241021717602672, 0.853350453565284, -1.936095620479972, -0.0874194882206718, -0.14624116420869582, -0.9048004219025448, -1.0732145928087364, -1.7346904460224286, -0.0067110571830193075, -3.918859203240803, -0.5728930805096428, 0.9009632859904694, -1.9433160052543574, 0.6462133597808889, 0.011426021985470873, 0.18403057713007653, -0.49990891380446806},
    {0.2544019278733326, 0.3263821893824025, -2.5172670634297662, -0.82011213459614, -0.3304889981416449, -1.8445193801436661, 0.8210916504664346, -2.342258786352499, 0.4999814292728192, -1.695561463469132, -1.922996010416314, -1.9358273433125135, -1.164707263927824, -0.99240848516572, -1.8983280506618418, -1.8797007394180913, -1.7958084971650625, -2.3002439962202272, 0.9352748368200964, -0.8600874516860958, -2.3246533387783783, -1.543200871075006, -1.6606660987255997, 0.08420428681342582, -0.37033070875607393, -0.018058595755442993, -0.9039997620786603, -1.7557161861251234, -2.984512778005693, -0.765335556134414, 0.06470076847785573, 0.2518003723220663},
    {-0.0881042629128648, -0.5585464559834675, -1.3639545779164832, -2.3964985890473027, -2.0872864835117713, 0.43795640883761117, -0.3379083481963723, -1.5758648334120935, 2.055764783602947, -1.781296048866291, -1.1465980700286909, -1.5051092495069986, -0.12312114994273736, 0.26617679089429414, -0.47334419409926454, -1.571995451336082, -0.1921771657370946, -2.7842848500195316, -1.9266965985397835, -0.8114670043762466, -0.44008046981518484, -2.0006905641679316, -2.2398711632193185, -2.818488587975847, -1.1139769196205673, 0.18101086050286727, -0.25304515105428255, -1.410956927128186, -1.0077057530775622, 0.724639588732002, 0.21344562762869182, -2.2465013984167497},
    {-0.22585889689276276, -0.12085427432388567, -0.17090234199563586, -1.3631116643857708, -3.1790880915891586, -1.2919275986964012, 0.24719424586612143, -0.19796093649862628, 1.6918407203437238, -1.667580312047435, 1.515494583769151, -0.4414099269921262, 0.898621743799911, -1.4792494767492528, 0.46840973808324526, -1.2219290968000793, -0.3467696905368853, -2.2659547852428656, -1.7674788692036842, 0.8894136564340817, -0.938913774305571, -2.478210279517675, -1.2620657513421711, -1.426305690527553, -2.4198578717302364, -1.8063949869966858, -1.5167237521249985, -0.34551724609029894, -1.6150983634650793, 0.2692647363858248, -2.4134355116679114, 1.7257629565793655},
    {0.37705047889695675, -0.26309716227819857, 1.7888769835900429, -1.5579295842000231, -0.6702019126442313, -1.477795693061368, -0.20773361549991765, -0.9360757068032899, 0.5796656517045888, -2.7175082112231603, -1.743329275104909, -1.3953773592952323, -2.8209675383295445, -0.5385224207534123, -1.1558687593630907, -2.1901212642661334, -0.29586761992043537, -2.632746574220404, 0.643494867242651, 1.2012249702602236, -0.7005548994428995, -3.364388143103919, -3.1740665438976348, -0.14746276437568087, -0.1394858593400049, -1.797445281068645, -0.2598661737235582, 0.7590321029768117, -0.08153415456098122, -2.5602156696263445, 1.446229321887958, -1.5033327440943762},
    {-0.9476217705845759, 0.18925555719593243, 0.950443351118127, -1.4306003724416938, -2.904058263775435, 0.43944480498139493, -1.0671279900162867, -1.6976348059788922, -0.056735699572119304, -3.774159871861267, -2.027865988973671, -0.3216758427109813, -4.974483512363568, -3.3164935270226263, -0.7236733255443412, -1.5095881389039683, -1.2644358234433473, 1.2341971414315602, 1.0130546851574846, 0.8303786815434642, -0.18397317227673046, -1.7379613484201468, -2.1911862417538948, 0.3712927267161599, -1.0622214356868191, -1.2061871684935215, 1.5848474722267545, -2.325276076329381, -1.2020190738334158, -2.7094421620471696, -0.979327639103464, -2.6191238423507364},
    {1.6527950426509372, 0.3914507342929943, 0.6988365757591252, -2.2716867092463753, -2.334416992612532, -2.177406704050414, -1.1007033620468276, -2.2210911681400223, -3.5318414992324976, -1.9306909713935834, -1.2165623031353363, 0.6282578588835186, -2.7687737110862582, -1.6229365645383251, -1.4758900889113424, -0.551965239410704, 1.7671715526849325, -1.752798014267896, -1.5568018728798667, -0.8053080388094843, -0.9791049006172942, -4.657459396856272, -1.9797297301659114, -0.18154621018452738, -0.35719627905997264, -0.6829631055976929, 0.4106980039814174, 0.40874244762811957, -2.4988921406285716, -3.602624017762785, -0.6359304235001118, -0.26405935792007085},
    {0.68881745379888, -0.4281548719477328, -2.436467350993802, -1.3067259708238286, -1.81487577122894, -2.29124965698754, -2.4097006657690456, -2.2525329302448305, -2.487468146712801, -3.698590968981377, -1.9269886723713878, -2.593686077955978, -1.819674070664595, 0.6521490289848154, -0.8725931445267449, -0.5163075093041656, 1.633862305245872, -2.3912079438712226, -0.7511390123083821, -1.290995701958017, -2.993192099469938, -2.36255677968306, -1.9168895070421155, 0.6830413812745155, -4.408136064947956, -0.8661681465069738, 0.005212391075142117, -1.6027556847019089, -1.4911448282903728, -0.5539439658267472, -2.437442298195695, -0.6319734292682411},
    {-0.9419713416644142, -0.8548623698492426, 1.0756859540957235, -2.7698248449888307, -0.7133385562490673, 0.3910147645083916, 0.39174016007137535, -0.8235652512351693, 0.19618367657513064, -0.8735798851648857, -1.8761005643621111, -0.7523901188469402, -1.4879788216832301, -1.2970289055208826, -1.180013601565619, -0.7749377336038454, -1.1709747133009925, 0.13067399464733143, 0.6091225100213602, -1.7134650639616276, -2.05037702520849, -2.8288863693211024, -1.4042933290699626, 1.2012671700966933, -2.1617730648819156, 0.13592373408514075, -0.4228291105491788, -2.5509557452568594, -1.2500367416399183, -1.6777215658700555, -1.7249906157457948, -0.8641992800947171},
    {-0.7665742280665432, 0.6128561074668634, -0.3006443316370649, -1.4185479846768219, -1.5719130830380041, -1.2913992790348807, -3.8107066931605273, -1.3495075029706032, -1.5430342958344525, -3.2412224680390085, -1.3331982459405725, 0.995538448023133, -1.3494930069325104, 0.021517447456120817, -1.1262179665914445, 0.09929757209626318, -2.811667439975941, -3.000424287937991, -1.48468567456141, 0.2572341995955645, -0.20066128484181833, -3.591708498573214, -0.5569997819441834, 0.43228477089920275, -1.7270409616942428, -1.9840911592716473, 0.7187116548575697, -2.1523891460124664, -2.6569765483582763, -2.5709812469316224, 1.342659854175109, -0.2436721654575951},
    {-2.398137409899145, 0.34102012934108394, -0.40501418790066174, -1.1038209440459934, -1.4205294612740584, 0.14848570799292993, 0.021933128382173518, -3.422373416312355, -0.32379090398820426, -1.9190571068254028, -0.1427987907684861, -0.29479488489757955, 0.47896225445170804, 0.9225464226285399, -2.191213086809553, -0.2356655395541617, 0.7854902057278439, -0.7488011003678394, -0.9994795991194063, -2.2050705491404488, -1.5436001894091378, -2.420238930880064, -2.916167691863815, -1.7419446241686622, -2.080258668128674, -1.6362356211402591, -0.7354247757966426, -3.683773184011747, -0.4488688063509966, 0.15068282303576397, -2.1911417028513784, -1.1505225553920773},
    {-0.6042915260142159, -0.16744334078908332, 0.3938539223253112, -0.4620438284990644, -1.6553818834184897, -2.7284245469111887, -0.05069072999563746, -0.10926467724338074, -0.4970272995272017, -1.8431517987251596, -1.8859513770585916, 0.012326498094672449, -1.5928960831460408, -1.2553980505856182, -0.6670927374244672, -0.027962294865108366, 0.3707949655039464, -2.1887904480961606, -2.117757019666438, -0.3198530510248242, -2.057670654596321, -2.724846057995787, -1.5593106167339263, -0.9963446146486257, -0.8161571202340047, -1.432996689818406, -1.6636140799345138, -2.8472250746836236, -3.618860957442145, -2.051325813361838, -1.2407801746766525, 0.15365625651081147},
    {-1.3349396920795744, 1.8180422675898595, 0.9191601903934312, -1.8696051572098529, -5.063947520623514, 0.24581797220377677, 1.251554963715882, -2.8511783052630593, 1.4110710130879374, -3.087759867748047, -1.5301748658490353, -0.9425702562297313, -1.7262219957324654, -1.1435028553267577, -4.536647499902132, -1.525171459641475, -1.0989617666190603, -1.5310282583742143, -1.0227176750962896, -1.3686730853897888, -2.752553583564882, -2.4295309268571446, 0.17916506822476788, 0.42023633978466474, -4.041868978042774, -0.9006858761368423, -0.12684534237715725, -1.3950106457002298, 0.1601688659949119, -3.4052589310731776, -1.7811904986502982, -1.825483469779331},
    {-1.8410209983402395, 0.8280497147220334, 1.1268696596553258, -2.9091092284447937, -3.929343857047329, -1.4693324989333412, -0.2177143280623431, 0.004547328554875346, -0.656660947646721, -3.5678564592698847, -2.447523995084669, 0.6952854905021258, -0.0070345100624958565, -1.8551300155833392, -2.157270790530406, -0.8312051695650418, -2.5041516927664955, -3.9573312647372063, -2.55989578703747, -0.9255366949732491, 0.5222551822818392, -2.1465826143335716, 0.12817699592075213, -0.5630668585514855, -3.212731297647093, -1.4938908106395736, -0.813860037523149, -1.4620493892659907, -1.7328967792061207, -1.14253807950825, -1.8562630849448913, -0.6723396038056512},
    {-3.4218342994351456, -0.05562140748753586, 1.0231095778815096, -1.6753356505293255, -1.309552316857743, -3.475867182925065, 0.4526617791427825, -2.7213458425357415, -0.25142212338067577, -3.071454887054566, -0.2793849501903602, 0.054627802455972915, -3.0500691700710525, 0.0412960744314593, -0.2159871388568575, 1.6068626334567677, -2.0505244949940797, -2.878743878233734, 0.802354038345942, -2.663770791434321, -0.9800804589064195, -3.9049508172948055, -2.543679109229092, 2.343531054222054, -0.9512320636601203, -2.465906896974075, 0.5343682511677266, -2.198709752907709, 0.37582016615113173, -2.3708464357913406, -3.1976801153009884, 0.18004153443311127},
    {0.14381679409315717, 2.0719338901980877, -1.1921550420506866, -1.4122001954852614, -4.537529455158477, -4.487895329609649, 0.9950728050326385, 0.7468523130054644, -2.739485981758527, -4.320292798498941, -3.2070232298177177, 0.7241528107174847, -0.7405913955181701, 0.43291291963575906, -0.6588629148820025, 1.5533030507553962, -4.714612807524286, -4.355822546540251, -0.5627838921947642, -4.006606148887597, 0.38952965040837, -2.867500668488789, -0.7155677483393937, 1.8790230415260678, -4.787840559240239, -2.8475197629620266, 1.1127526525380003, -6.081956337749108, -0.8908192076657223, -0.44213311320330306, -0.9646249586595373, 1.5894185482014054},
    {-1.8158519692952522, 0.1139222688243625, -1.0924746790661533, -2.1607212277869037, -3.962930852738021, -3.381241332713946, -1.0557017844153604, 0.1986425822147305, -2.0196213292492646, -2.300843915583454, -2.684989735500518, 0.16197644331639108, -1.860770078120295, 0.32775404740616504, -2.0602044261056536, 1.591543051909029, -2.544835180868469, -2.489544728576205, -0.985615960285725, -3.3916451280585087, -1.574238937247999, -4.8112662714709895, -1.0285955694846702, -0.8336871761212639, -3.9669215129890665, -0.95194826629672, -1.2483701014769555, -4.062942278401612, -0.9614192878489138, -1.886618669022232, -2.649328870799803, 0.09193045577208081},
    {-0.7859394180251588, -2.608078887335554, 1.3127494433077913, -3.818352494303194, -3.072637371740952, -0.9364065181924767, -0.2674471265201203, -0.46337317637748177, -1.5926213343364632, -4.34825614073401, -1.4546790893076764, -1.692506566366207, -2.68257124826521, -1.842832325283067, -1.8417401501219544, -0.024111850798611716, -0.8527043548741049, -3.380659261696213, 1.00012695954765, -2.6706290026142243, -0.7337377233452854, -4.272273963696891, -0.4523701338079351, 1.2391004979791884, -3.6193210629188055, -1.825918230881196, -0.8276811729711098, -4.0703626852838655, -0.4422242960854875, -2.1847480798152796, -2.0807552229825563, -0.7368213354312547},
    {1.6080126279907023, -0.22238764743038014, -1.3723011347934937, -3.6927210262840733, -3.198097378965621, -3.312945864753193, -0.2607249349660589, -0.7975777046452542, -1.4773590828711074, -4.263807896849652, -2.1681894981810257, 0.6442065306554939, -1.5799830892582931, -0.2834753545008274, -0.284753634520572, 0.13527128500271066, 0.5701991787828624, -4.928741273281025, -0.57127512459221, -2.2920403086408245, -0.2835760748304555, -2.8904017060093414, -2.586106586481993, 1.135240803342022, -3.169831020030461, 0.28865952363182984, 0.2444104341479181, -6.193914064759723, -0.8867050920506048, 0.08303386203903053, -3.343388454248319, 0.45488125127787554},
    {-0.8143386260114505, -0.3814302493781368, -1.407900354451953, -3.080254853817046, -4.623734596491855, -3.0163114606859027, 0.2579085825387454, -1.3759790871820998, -1.6753836762837335, -4.425516889280095, -5.401186936252974, 0.34360735834100903, -1.4754188748642612, 1.0125553546020405, -1.9649219770668034, 1.7024668244518573, -1.7445907177151534, -5.661156109661825, -2.682562403984673, -1.5684460948703953, -1.6611333376841497, -1.9647948649690632, -2.1437836089603532, -0.6787980373561505, -3.644718555859123, -0.8730067350767167, 0.5420124089733579, -3.648376953753733, -1.5578514917811097, 0.5965883782900369, -3.5880897692062725, 1.6372002502867014},
    {-1.532963996903129, -1.9850460724036587, -0.1264687613380322, -4.547762910803002, -3.156852949927955, -2.6360546829974467, 0.3604518956595286, -1.753463412410675, -2.70026724947519, -5.245810274356995, -2.918383464636157, 1.5737298932810257, -2.7688979715097415, 0.6404376247817689, -2.572705562946796, -0.7844931902774835, -2.714965307543281, -3.88960583345455, -2.3093255820039866, -0.5606829336788629, -1.7275466686471677, -3.6689220762161656, -0.24945656022123075, -0.5623730094292121, -3.1599884626494124, -1.7277665655560501, -0.07521485528300652, -2.382198558171661, -1.4976548631424573, -1.551972032673064, -3.097237763053919, -0.02041444246489399},
    {1.118140383194318, -1.2110724970464533, -1.0265995013405784, -4.1196410557331085, -4.0363457009278445, -2.886849578262687, -0.17232742703228607, -1.3415697272813771, -0.897040738924338, -4.296553182874672, -4.833492871028344, 0.07903475789678012, -2.726656342881227, 0.7303439910191125, -0.48573701682014137, 1.7158660443404101, -1.1527149094393485, -5.217668480362976, -1.3207678429755454, -0.9800676109824835, -2.005268592820594, -2.9922182628324214, -2.3064367526034086, 1.2932263582823937, -3.0514332610221335, -0.7006937142282169, 0.3015814445555957, -3.6440234475056896, -1.8770919180701036, -2.257052886604384, -2.6183623156525266, 0.9219243127424389},
    {-0.7028118060987022, -0.42575231995932616, -0.8061917591963175, -2.7846133845375833, -4.43546063719277, -2.7093337024727426, 1.009602683785894, -1.6200638348893681, -1.086348402690658, -6.143886499043946, -3.682121293584594, 2.961487016590347, -2.1338890694978927, 1.0609316454116136, -1.1687942425429485, 0.6013942858318223, -0.809217358135227, -3.6146928315268365, -2.644893325084287, -2.929724796774807, -0.4416287780862303, -4.401796043388319, 0.4624743451620196, 1.0109232385158435, -3.4392321233600875, -1.639787925907908, -0.8639817999744707, -4.799780990075365, -1.4728555814385376, -1.8529810104735844, -3.468258966824731, 0.024847219468563064}
};

static const float b1[32] = {5.350848489900936, 5.616438344094237, 4.450863888337014, 5.074238047941963, 5.880086776923223, 4.970671422439934, 3.0791712342016613, 5.938026018353952, 4.078686536199179, 6.300639241744297, 4.448739715570718, 4.8259242093543175, 6.291020977955883, 5.322261483620117, 5.068739425543309, 5.401650254268164, 5.143169455402895, 5.775557358281981, 3.6493452446755845, 4.981829820569369, 5.30839827437656, 6.0351079617170225, 5.290205099471916, 4.578569441308896, 5.910871487239133, 3.815193746994253, 5.693798193068038, 5.247834746741788, 2.878001104400538, 5.665923949842203, 5.444318949530083, 5.660570835803807};

static const float w2[32][16] = {
    {1.062607966669345, 3.6391438220902117, 3.4470590807125405, 4.8468649527120755, 0.17709170676565775, 5.574455627270123, 3.9753389836503437, -1.2915925429632789, 0.2566218687569493, 5.589895401630129, 0.1813781151809998, 1.567230387651396, 5.169439219586327, 2.7362015844861696, 2.178999684260794, 4.8951657635305885},
    {0.7625241220612696, 2.583384064332025, 4.655565089550258, 2.2929013261979923, 1.2132652739955505, 2.9027991856574857, 3.3375799085170756, -0.5248648122566556, -0.46088694203786384, 5.679833529851384, -1.4038835187861642, 5.022568263481043, 4.643134840807697, 0.5995766112667242, 2.078292793530076, 4.7776906434455375},
    {0.6017177595464729, 3.103335915607973, 3.1515481131706435, 2.2210630533939275, 1.2293782092171068, 5.568844498620989, 2.8820932770183028, 0.2871585979953978, 0.02032766857139269, 2.7371191728968656, -1.3593290567162934, 3.825430562165317, 4.033149175201839, 2.7097241513307377, 1.6155851982800502, 2.3848614411449005},
    {-0.03855541868564506, 3.2255180987141348, 6.066744868866616, 5.140470788454367, 1.3161865020416605, 6.177923357992574, 4.148792049237413, -0.7923210521281009, -0.18972426181589166, 6.152147511411292, 0.2489966825674241, 3.7545350324524844, 5.328161107873669, 1.6967911854884465, 1.11784157714214, 3.3976382427630734},
    {-1.2606938522993176, 3.5170082957144335, 4.655412609956725, 4.319241382092672, 2.0025691453424166, 5.731757333676447, 2.504102477732268, -0.9026257230515161, -1.012689783027565, 3.9014044395566643, 0.6801630323223012, 1.8277112130473012, 4.779785742339325, 2.345168718646162, 2.0235700303960127, 6.350937364840143},
    {-0.7807331697840595, 3.613294219430797, 4.434155123130369, 5.339314538165771, -0.00948039821730172, 3.8077679902716692, 4.579643018714435, 1.5221309517182122, -0.05362321688868622, 4.249900025515759, -1.7068736493142105, 4.088189647793854, 5.2198731397796365, 0.930675945016259, 2.257575605522672, 4.2876323844338335},
    {0.4250530216097884, 2.2022228265884656, 2.447402682119021, 3.5480671614419674, 0.15173261434932633, 1.3384366153563463, 2.9814420883855237, 1.5479004934878244, 1.410639987189883, 1.9904344429669187, -0.4955141540403956, 4.374882352822749, 2.612888081655222, 0.09554103697248888, 1.6264847318820808, 4.484322923416569},
    {0.8915523361509893, 3.5054580947129073, 2.5915644026744906, 4.14820003204912, 0.5715469104760448, 6.255991907014115, 3.7699971461839157, 0.14665133268678504, 0.2219485701336637, 4.769800592281993, -1.2939975164189246, 3.839018556236972, 6.035461731316372, 1.6986196185663496, 3.9173377510244776, 4.694628217680683},
    {0.17593239403188413, 1.2193680859534537, 2.4364667349871096, 2.4754293292770733, -1.3851287272731314, 5.068033713965525, 0.7319411061955771, -0.9892284606151084, -0.5158554084025511, 3.0701158355834877, -0.035297128373272736, 2.8580001330730167, 1.9877975665540797, 2.4160639303215445, 1.9150724544659243, 3.5698172626886717},
    {-1.2234116235545411, 1.7525720866379673, 5.591070128967379, 3.7687957020345784, 0.7380540335311397, 3.769516141161791, 2.260481085641883, -1.9963007150007663, 0.4726651138911864, 4.015204996420393, -1.3109722285318792, 4.880877318323826, 5.058884227204069, 1.2702807869288915, 2.2518630024979074, 6.27624039831217},
    {-0.3276619370699602, 2.6264531066376793, 5.005494376451415, 3.7014899789335036, -0.13233882259246882, 3.564783126303622, 2.8154329243180674, -0.2342591296285146, -1.4650565366708037, 3.855298248476654, 0.9061343227832537, 4.104626269624263, 5.111261769586436, 1.5928435347907004, 0.9379338543970707, 3.654527379583157},
    {-1.8427379122893286, 4.464347122461583, 3.136910508330842, 4.877396613326458, -0.3834657866607889, 4.66731546687078, 3.8121263754750303, 0.30754713410546125, -0.07504142357512092, 4.8064955669995575, 0.7538870523007127, 4.572268660415171, 5.804795472814102, 2.9491754790185567, 2.4524068467328246, 3.82896767272714},
    {-0.01010474099395823, 2.97527839291374, 3.740159732857784, 4.845438869063767, -0.28890293046110277, 4.391624435820686, 2.7831063858643077, -1.5231835257828354, -0.7565663029665844, 4.272257026691616, -0.2651390960511231, 2.951236140572933, 4.312688836246282, 1.8682898140204747, 2.5065204127515712, 5.073056119272964},
    {-0.9412432979740855, 3.968229690247575, 5.145411953505101, 4.557867641508349, 1.2739922247848487, 5.711068532025286, 3.243795605418447, 1.1863568512596143, 0.5318951289626034, 3.3461839161249594, -0.08050581593526224, 3.4919343015218285, 6.041787695454704, 3.6356147408096153, 3.1910040316038137, 6.352741653389349},
    {0.6357927926031409, 2.757436840310748, 3.9897830709085773, 3.179836098846178, -0.5491414833107426, 5.8811357692301565, 2.167282521775867, -1.3475612905148913, 0.14743965491349365, 3.0768150180629434, -0.9554647380351862, 3.3562733478538505, 4.888668651012635, 0.32377887472804806, 2.2281895040756012, 2.970683932760959},
    {0.08152996607195882, 2.1059335886083836, 1.3523191810013626, 3.395944642961101, 0.25077748297165686, 4.916459791281202, 3.041288371193559, -0.21797682112195046, -0.17684906905337255, 3.421763212420092, -2.7068042113585324, 3.4898725155231802, 3.9870459598459345, 1.9283979993606823, 2.7452359588809268, 4.050389698184165},
    {-1.0369120132590077, 3.061871130244195, 3.461790158331704, 5.708252199581053, 2.7519862625299036, 4.548663069620257, 2.985907497555891, 1.2766847588857673, 0.29593138507172445, 3.6118309823880415, -0.6691730354211208, 4.478691783173914, 5.341887261008416, 1.8307818222698333, 2.782467725936716, 4.314036616107125},
    {-0.9514440020426623, 3.0350845143616065, 4.099188708770615, 4.771984130006991, 0.014501016844522251, 3.7671872000046727, 3.301673694658162, -1.0521176292903742, -0.3777004421858015, 2.447408363102708, -0.923168411704542, 2.3357273841721944, 5.31330707342876, 1.4733628616144034, 2.4757770390434044, 6.062124364940674},
    {-1.745098562527682, 2.7996845775256096, 3.685676941187902, 3.4501227181781213, 2.427233268899653, 3.5102593081666322, 1.4862733843151066, -0.3015663462650297, 1.036436058527516, 2.8378212442573525, -0.9343500776422571, 4.106537473348753, 2.659127678853381, 1.6725638719610156, 0.9837673367417239, 3.034338835198158},
    {0.6196200355128898, 4.175056104692588, 3.497397076622702, 4.70451655270945, 0.3155535852970269, 3.942220671106449, 1.8700562124309488, -1.7971192062120376, 0.7773439992854778, 5.844105178789863, 0.6055200671862939, 3.894732919899463, 4.47936477025298, 0.49262006682991644, 1.7769036883415605, 4.329831034911753},
    {-0.7222326769169893, 3.2577766053009944, 4.109941149348283, 4.9398707582629235, 0.4161741038226613, 5.595002855875528, 3.6672310477804784, -0.5126707640113138, 0.7413299029742559, 4.2910756881315955, 1.281545251300922, 3.637611938255086, 5.973669883849485, 2.897450287358648, 2.2435434718579503, 5.074214062262357},
    {-0.7927280112856155, 2.114636222784311, 4.0245414987382, 3.8623907894671956, 1.6140782478382283, 5.273665606861594, 2.2852418816914053, -0.03843055507300218, 0.5924410123790271, 4.7952077782455085, 0.4170279284071505, 3.950060038430337, 6.019742162931732, 2.2516742424149356, 1.1535695674013997, 4.8247200957966685},
    {0.33898933158035754, 4.259550070468727, 3.238824639138739, 4.802675322016514, 1.1434796080028955, 4.384809309174222, 2.7984589846417296, -1.4812318746862765, -1.2382654601614307, 5.485828860606954, -0.6145692785383102, 4.458177014914142, 5.136649754913102, 3.9594035341205602, 1.7323847861523192, 4.760751873635946},
    {0.964349485949884, 2.7205900810726984, 4.695995866858421, 3.774498774648723, 0.9418576910917937, 4.67368128796773, 1.9850426132378913, -0.37835846521418753, 1.7009604251365935, 2.54729582668513, 1.4030968458844526, 4.463926158993262, 5.105324059798935, 1.5335626729042127, 2.569620336753833, 3.724845926174193},
    {-0.7819887450618918, 1.8055947532477183, 4.320722300807922, 3.813989953137303, -1.3223448657577639, 5.42448368350543, 2.963837339264486, 0.18722902498413616, 0.1147800089011303, 5.327785331354243, -1.100042556109359, 2.728272888596215, 5.869966866600846, 2.8892105847924343, 2.1099468957057224, 5.56318547449616},
    {1.3492980120749454, 3.37823539478362, 2.382047002620568, 4.270388806145201, -0.29855076105990397, 4.320748138160905, 2.7617127236237544, 0.44056038804055264, 1.2151630815913257, 2.351926817699097, -0.7839924876624847, 3.624779870178639, 5.234071017333937, 1.7778932016534206, 1.8838325909437397, 2.554733233257237},
    {0.6035596812911104, 2.6120042266723726, 2.684926173280686, 4.746550635106994, 0.00307994764158087, 3.335058753240531, 1.5940289402337673, -0.8688881933317203, -0.21329635045738632, 4.779533180580935, 0.2834932430152119, 2.211959479045984, 4.900698919174034, 1.835890222973453, 2.980384532778057, 5.518413088514369},
    {-1.6398122698531425, 4.266509907672122, 3.9128319499694184, 6.561107576004909, 0.9625986815952247, 6.280812954621147, 4.194610266807504, 0.3830172773548247, 0.14832838338049942, 4.482171692579373, 0.40807609922460164, 3.466953076818155, 5.453369776884467, 2.770436978315687, 1.4251891884834518, 5.633153009047987},
    {-0.10029581919185492, 2.7151739938307298, 2.6539688238303536, 2.2016289278299865, 0.23112767888150487, 2.152063226716459, 3.5445698254226894, 0.03460640519616118, 0.5900420552974879, 3.699961123524396, 0.7211064270865418, 3.3020748918973606, 0.577915240631012, 0.9372351153482299, 2.518844897166266, 4.811072092457041},
    {-2.5929072148247916, 2.314018739823943, 4.890143149156223, 2.4224719051487047, 2.0547275406318244, 4.213623697874681, 2.744648616907803, -1.6539976859664913, 1.889044374971271, 5.663721440098754, 0.49027637586365286, 4.632480270993586, 4.351432623988536, 0.9343636279668335, 3.2235274618556553, 5.19490802052128},
    {-1.907218298800516, 2.1590021746818002, 3.245203705123046, 3.5043719343162505, 0.2659009676367544, 4.936394143054707, 2.5430463785404944, 0.2032593312511644, -0.6040524204255365, 3.2345846930247135, 0.09896373453609522, 3.865772849247754, 3.993344480035546, 2.3557977224267157, 2.874658862285162, 4.85254448778477},
    {-0.04588549709451237, 3.664030784601526, 3.765352233670148, 4.074991039873139, 2.4962383266693644, 4.116199708684571, 2.251705149476839, 0.9090619177771831, -0.8755959278233081, 5.1131477346461525, -1.0256060073645223, 5.382452519230621, 4.79946422131474, 2.227508448750874, 1.5949082533268943, 4.75486775257866}
};

static const float b2[16] = {0.2266276273965476, 3.1937995795060417, 4.622615390395483, 4.540768053625537, 1.6148029196261036, 5.37172475978591, 3.629218314765628, 0.13589903388277225, 0.06837938248920611, 4.9070517578048, -0.6578647759774285, 4.505318573497283, 5.644062418011029, 1.9781848751332438, 2.813965184302711, 6.079347492558456};

static const float w3[16][12] = {
    {-0.19719514782248795, -0.2768278334827822, -0.23780356085574644, 0.6195384794996104, -0.8887884057558442, -0.23514816679045072, -1.1145599152240617, -0.5146110290752235, 0.8410760254872378, -1.6250886747070783, 0.33791966016698427, -0.2278922120934432},
    {0.1298586014615533, -2.280892645014605, -3.804698015911431, -2.081124492868132, -4.331783767382888, -2.0982249480432023, -1.0632381527043984, -2.410073010861597, -2.7397425865545473, -3.116640579058728, -1.8731060586843915, -3.262793961347819},
    {-1.524955739745288, -4.2307549314881285, -3.095328819902353, -3.246430522123353, -2.4721738552244052, -2.935614411776146, -3.90037309150008, -2.793536302859935, -3.419225311112695, -3.1265400110535566, -5.2364210426471, -2.950401821388973},
    {-4.174648124877459, -2.9349219386467094, -3.3447512695982193, -2.7620935273886476, -2.951046828523509, -3.8079255279426625, -2.324901104753332, -3.2447373558115227, -3.341425688911044, -4.036453691311873, -1.7907227375787855, -2.8798457345547313},
    {-1.1434646254396053, -0.3312889343759088, -2.141401094655589, -1.2572918002404396, -1.926952264866264, -0.7253282200123808, -1.1817128069069136, -1.9230101124325603, 0.30092529113176375, -0.8830012338153634, -1.183969567746835, -0.43179071830566584},
    {-4.336205363920473, -3.529204193079527, -3.4365135480872344, -3.8327938064407485, -4.175833783550291, -3.5010412646325255, -4.758734549115272, -2.3244496482115076, -3.609730945914996, -3.3603161746411505, -2.6324247809460966, -3.4705667711390524},
    {-2.723176120865562, -2.1645519601875085, -3.300899149329238, -3.808372991872029, -2.0862304873095523, -2.550942851224102, -2.0041196867654647, -2.6394819192439627, -2.625351349529704, -2.4233352552376126, -1.416996550933532, -1.506109064978116},
    {-0.39026576551132497, -0.04152526049717705, -0.8245328324048082, -1.335391144746185, 0.7084025948940523, 0.7007192276424352, 0.7759643548644608, -0.5399364764521661, 2.140825340607295, -2.306479327266787, -0.17397402090929237, 0.1996917756211286},
    {0.4534370308814061, -0.9285879263111628, -0.6887701406043581, 1.4351720167689777, -0.5103577847564906, -2.5381579003186028, -0.8764574847287945, -0.6502500703251141, 0.1050240706486151, -0.8630448260718955, -1.7146274071055272, -0.3673797308302533},
    {-3.7036047905844263, -3.6479011788659235, -2.823447187078533, -2.5092770735760626, -1.2273457242565944, -4.432347851355587, -3.715774616596859, -5.501690818592508, -3.9603830335991033, -3.3292994556130826, -5.250064016033237, -2.650208862692762},
    {-0.4852099819543833, 1.2076423223955204, 1.3849818202982687, -0.8907572487236362, 0.43591128742559515, 1.3478873808446068, -1.350860632280252, -0.5650535500196988, -0.07009052121041975, -0.6158728852784261, 0.24619465517343636, -1.2033331992460097},
    {-3.963317436976259, -3.0150537375643416, -3.7765274626422562, -3.7107619996812953, -3.2802014120046166, -2.8481212944797183, -3.603611626023034, -2.702210120954063, -1.5664627149983132, -2.4968838100848862, -2.2884534244166423, -3.2622208471856897},
    {-4.016231226912712, -2.9544287593339167, -1.53023769946961, -4.250696178040919, -3.682741957739308, -3.5591291269913743, -3.0831400297055267, -3.3717982928665253, -4.4899030782352884, -3.678886003015531, -3.0926046065653465, -3.9279670029401643},
    {-0.8972122503020611, -3.2582869804593897, -2.617844165381553, -0.9408032904517196, -0.36108409091628096, -2.525027473312468, -3.35524273084808, -0.5679999446651414, -1.2742516191914075, -1.9610897415229538, -4.038398407243665, -1.4322148854480226},
    {-1.693129521785442, -1.9611171738376956, -1.5793065526396939, -3.562634325655739, -1.530387570721393, 0.008121094808087304, -3.298103928721288, -2.673113733410634, -1.6501913814097968, -2.3016616869243234, -0.9594988503491325, -3.5355562041654918},
    {-4.222052599438512, -3.582073927981159, -4.414331125477472, -2.6106787382728367, -5.525294817824163, -3.6989247866050365, -2.6801202631789645, -4.071875256688177, -3.6387457719049503, -3.262185084051566, -4.450313713583469, -4.246446346782403}
};

static const float b3[12] = {-2.701143038441755, -2.3516635806906305, -2.300386155352001, -2.384753460083007, -2.7783680618197026, -2.576349967479014, -2.736574375398175, -2.8901150643307063, -2.2025901750167907, -2.6110547610953505, -2.579533304800659, -2.5852140020503214};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
