#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.5220640611673186, 1.3203238132556072, -1.3546786696125703, -0.31437366899606933, 0.3419667581186968, -0.7501798178451459, -2.19475507003214, 0.9175056567703674, 0.06890675792419206, 2.6133267439851675, -1.5621087947623142, 1.000508025171318, -0.3600777507900234, 1.9427506932175955, 1.1559484532240982, 1.3548940485664347},
    {-0.7648118944576697, -0.18423744313456156, 1.6421352592389353, 0.96014232695005, -0.10638525474487374, -0.3650960417376011, 0.7671501286263258, -0.13818551009103722, 0.8504479268570031, -0.717922616337993, 1.0390281464619444, -0.4249009185511098, -0.5859773774208707, -0.8678245910323669, -1.0527491417953783, -0.027464109550256643},
    {-2.0427204668502412, -1.5595700931026508, 0.9799641415423206, -0.9428727476048099, -0.8426934659567069, -0.6163894397084232, 1.2808619795345932, -1.1606514437387963, -1.4156928834534557, -1.7947601375933528, -0.29963757111487177, -0.37579055544270434, 0.7274500652275303, -0.17418718297507332, -1.3885253813260496, 0.986610164204308},
    {-0.698733718816827, -1.6230180145934945, 0.3147576312971977, 0.17042319255603977, -1.5114341480278999, -0.29648554940909394, -1.4994416930795806, -1.5171216684904039, -1.988092008332827, -1.319411378853599, 0.6952709919262842, -0.2845856437164855, 0.634471789987719, 0.11357425639455196, -0.7593513251781367, 1.2811775618286751},
    {-1.9999148375905513, -1.9255847609302295, -1.371464515771087, 0.31722697529379895, -1.5490964966233471, -0.6835717851038102, 0.6484376882264812, -0.6749120558347588, -0.2130998153088848, -1.9722716944917953, 0.1520644666310827, -1.3838452055570423, 0.41611865472537474, -0.037509162756343306, -1.282704545897251, 0.09502387612453767},
    {-0.5435042253443267, -1.8254324209253918, -0.05836003149885422, 0.5523249979116438, -0.26847255048145835, 0.34757331428121024, 1.352454820873267, 0.7377856785620098, -0.8967968330593334, -0.3805554664218873, 0.5139013769114364, -1.4601119468501293, 1.0826524424608939, -0.4573263658769474, -0.721155463765214, 1.2312222171802107},
    {-0.6158478309332471, -1.9625413692210505, 0.4310184238784241, 1.0043927392237177, -0.5791992611097024, -0.0643048961495033, 0.2958263929463668, 0.06697679302862965, -0.9107926733130202, -0.10684040743774374, 0.660091751889534, -1.2707132527266076, 0.8779051845297626, 0.32571962431567986, -1.745197738814196, 1.5998862112134882},
    {-0.8389178011042874, -1.1169446309356499, 0.13469527214207833, 0.1546650087612152, -1.4960852682814354, -0.875061858598009, 0.019099167486419363, 0.01862206397907453, -0.5608281907009468, -1.752557624881956, 0.009612079015206066, -0.6117786483757405, -0.797760265903975, 0.12645969716035874, -1.1395271696194482, -0.022155592912988114},
    {-1.85278230979193, -1.4478014945194135, 0.878103490521059, 0.3634393851936936, -1.5780631636948066, -0.9512074322659696, -0.495377244737864, -0.6320820319262215, -1.2994091292886927, -2.041583209297783, 0.7906849164700834, -0.6886147526037886, -0.8891268118943441, -0.04504027689950858, -1.7846049352580355, 1.7420123212486545},
    {0.15097921031857686, -0.5641527656728141, 1.3929532998123273, 1.0386811436664838, -0.34653890619470956, 0.002703331788722261, -0.15157764921026737, 0.2309412261930949, 0.43313762936035644, -0.47522433607075865, 0.8832562598177235, -0.7367488300301992, -0.18206250210435038, -0.9655383504111956, -0.8961105213540288, -0.800285085554813},
    {-0.73434847730224, -1.5848781511450742, -0.7230643181864393, 1.1903865687317294, -0.9890955463141544, -0.6724176523955517, -0.21818153475594798, -0.75476035701064, -0.8211111234187352, -0.6107336390077256, 0.46932117791862266, -0.9564101241494971, 0.5355219538278122, -0.8333466118700763, -1.649054751390719, -0.8517552518871614},
    {-2.1836093335367655, -1.7316072922487917, 1.0191349844898585, -0.05012143929398613, -1.117379961430202, 0.09080333182082453, -0.1385581802354128, -1.2601858582061005, -1.535360565584796, -0.7602699668308802, -0.20155432832709846, -1.0938067339481417, 0.8714666433590261, -0.8522295033370181, -1.3021033916572426, 0.3599396192737447},
    {-0.37591464753092235, 0.48386367841732025, 0.3809083173293568, 0.5674917633880353, 0.5769553927792005, 0.6325530761645594, 1.473294182208039, -0.3243199683245896, 0.4538194807371625, 0.5677269713299893, 0.456846533404643, 0.17874077624867962, 0.12387057686093654, -0.8609909325472133, -1.312899712794313, 0.5939851585501505},
    {0.38545931659627136, -1.6525941961469843, 0.7154483429268096, 0.8974956355020403, -0.1700479473450325, -0.16482610525891453, -0.5520172867857022, -0.49158039381281793, -1.8999500481563931, 0.5935990086275864, 1.1364042321490964, -0.6336656623842708, 0.7816678264412011, -0.2044115209541112, -0.8219591647462972, -0.04632770403820229},
    {-0.36174585850979496, -0.9245775584739673, -1.2020158436329378, -0.5580651846915603, -0.5925723128478053, 1.5746365275773158, 0.16480818296355518, 0.7618442849003807, -2.510139884087332, 0.8688589506475699, 0.12324102675413375, 0.13762522606519426, 0.7208336265765531, 0.16701280097806975, -0.36264616576445063, 1.0375994674470974},
    {0.9922190145147523, 1.1993577167556946, 0.6910742576505995, 0.3563135901087601, 1.331676653934932, 1.432552274054557, 0.9802473371840219, 0.8594888616546051, -0.9535431167593097, 1.195090184296057, 0.6666100640941734, 0.6281356815262459, -0.48415929502574967, -0.10872517255165497, -0.7291446396787465, 0.8317956062482252},
    {0.279255499402945, -1.7980615658257604, -0.04780031607651058, 0.8214456247271741, -0.027431379974357663, 0.5835610449457782, -0.26441250897228574, 0.11284896760371466, -1.3563141731912671, 0.3406329925127802, 1.2504621924180284, -0.07946085643716506, 0.5887372446494643, -0.05108145015653655, -0.49574194301209773, 0.7263751357015243},
    {-0.214324908595019, -1.6352985361562826, 0.3400560057028941, 1.0056463024620101, -0.6727656679680837, 0.3269024869981929, -0.17220978879504598, -0.5177837709058943, -1.2860226646465247, -0.25565171005826065, 0.3734082821615783, -1.2765180183388491, 0.6156879274381176, -0.4979808451424297, -0.7495752785975299, 0.38988657394901827},
    {-0.560005245062945, -0.5481846870726422, -0.06158713371189683, -0.5511800064226458, -0.1284901065861058, -0.12384356674501308, -0.09942729708531545, -0.5653023367107799, -0.14647180254959413, -0.013528161726458026, -0.03752818643551257, 0.1201248569988372, -0.6930011698688316, 0.45876959517193255, 0.12059152068817468, 0.21126586483580895},
    {-0.34008542426064037, -0.7660370507973725, -0.2840708701876712, -0.19058999514431663, -0.051239412871909654, -0.5635019296252307, -0.712084099623337, -0.3325093366815372, 0.1278581725048776, 0.5176054148161002, 0.41968766482059117, 0.6784622722697412, 0.09812840729836567, 0.07038611967043687, 0.3654493389305359, 0.08802906761406988},
    {-0.327809478504007, -1.1711468184501053, -0.7273366519740291, -0.3682919782126554, -0.4071527646659796, -0.5578945185589065, -0.2624661159205401, -0.33586965991644635, -0.841319295131299, -0.1958022318062472, -0.08334359417336679, 0.3362043220489672, -0.4260189926053138, 0.2864547689659453, -0.018764277879486157, 0.03990136869693978},
    {1.1745023593653594, -0.2268773638032089, -1.1139802420273044, 0.4578973652498716, 0.46709848176277047, -0.4813741608790986, -0.35169317738214795, 0.8228691985680409, -0.08718777802279697, 1.378674045344822, 1.058739864754895, 0.8033802168892668, 0.2762087556894208, 0.2713076276300685, 0.9284944737443407, -0.8783069290654801},
    {0.6876352863859103, 0.4657130771434363, -0.19861319736767777, -0.31682341651028295, 1.0490826883205047, 0.817250835174906, 0.17791958097566782, -0.2128629991324693, -0.7331878629127844, 1.1862459921033301, -0.09305236383709303, 1.3930451448758103, 0.2857723241322311, 0.6190769208570429, 0.3204643559408013, -0.4205404921871114},
    {0.920746017547683, 0.43022926373923664, -0.2938486016931469, -0.3951096542899432, 0.49989844903085845, -0.3783476097028193, -0.07762586869368111, 0.19059119012454018, 1.429300720643796, 0.7418834260836253, 0.5121068142368636, 0.7564000045610133, -0.2252388847711145, 0.10432309038027641, 1.0388190095113523, -1.5269946255010485},
    {0.7491987971971246, -0.08332712598545741, -0.5195541105161103, -0.34633794739892, 0.5843463491111142, -1.1705384937372834, -0.2699899958214358, 0.40711738811305104, 0.7387420413524258, 1.6783615068946354, -0.6511116295767266, 0.3776344171072272, 0.10635624567693941, 0.8385595746163442, 1.4667236399385786, -0.3238793042761869},
    {0.6722831842444478, 0.5813112148381845, 0.1323849523792034, -1.139097487885955, 0.4900679439202396, -0.7538848575819592, -0.5988163936833298, -0.2855495670600283, 1.1985727079992263, 0.832998752950646, -0.6871916387627646, 1.2868010205997165, -0.4508904875087182, 0.5316819621117881, 1.4552319474290418, -0.5022933780063453},
    {0.2025365777063368, -0.09159055227437547, -1.1507907180543744, -0.07581570321682829, -0.8209646317723924, -0.04634315128395011, -1.0644350221294625, -0.7023239311157649, -0.05986072543570375, -0.1560131529804002, 0.02624191392785496, 0.5014209972801863, -0.053235175626044184, -0.7480747145794182, 0.12519413113189676, -1.5931802859468425},
    {-0.20482248748602247, 0.3370582815313164, -0.5546414803329578, -0.9775028950139456, 0.3759563458147433, -0.5414944411427983, 0.522229766043004, -0.4025038448854037, 0.9930366077252578, 0.19005292701473578, -0.30727061896957836, 0.3298818497074899, -0.039646662655890716, -0.11540400570382531, 0.040707106734663885, -0.3223887445816919},
    {-0.22969545275438177, -1.9112467368955235, -0.058479984969645786, -0.09343490136937042, -1.022121958089008, -0.15189171174030927, -0.5507221297825913, -1.0636691746349882, -1.2438114825070008, -0.6141516346476306, 0.028041884846104266, -0.5109358060785669, 1.0658344966735658, -1.0149028549589587, 0.011617569232671092, -1.1297255360152623},
    {-1.38473973935307, -1.6863571592560973, -0.7523861706666592, 0.06918465217421235, -1.355877258892603, 0.21894492802604568, 0.26095477339475487, -0.8915732239794374, -1.3877352338853677, -1.345204565474079, 0.05804765745259168, -1.3376662234907704, 0.7156052668656447, -0.7362898343745766, -1.0542569394782935, -0.3162514281400468},
    {1.594470849249886, 1.6229967284462705, -0.1741961128952448, -0.8326968636692471, 1.5776941144019505, -0.8626060433773236, -0.6716930439340688, 1.5070438617095614, 1.4146859182149587, 2.2236191457612873, -1.0621181484734428, 1.3724494249326378, -0.7834288692003045, 1.0503649788933362, 2.038940132716693, -0.21702864082278836},
    {1.0282284193664675, 1.5867417772080714, 0.3810882859728198, -0.39036604267103325, 1.2062477714671829, -1.2760208294687834, -0.9662206187564203, 1.0463482003529396, 1.1708955488955293, 1.6044092051825471, -0.41200370150023197, 1.3192500667727993, -0.7039401610086744, 1.0310585629420836, 1.3097961302503174, 0.05174399252555308},
    {1.872616793094489, 2.219298841782081, 0.21782282065063668, -0.4753946029350063, 1.946215651394459, -0.7014233323350046, 0.01022023803693238, 1.0890863330337888, 1.1405361994157617, 2.1053432641385106, -0.42693017652377724, 1.4608860700209083, -0.22710891722602417, 1.190832062645459, 1.761212318874088, -0.2395289517553177},
    {1.5525438798043822, 1.7937317303494256, 0.24869514469982087, -0.5256603466727391, 1.948360795327829, -0.19452140719840885, -0.45665599976042565, 1.4075409936872088, 1.2247716309114216, 2.071063218378257, -0.7424672716255277, 1.4752746247340478, -0.780555348960616, 0.8780722901385599, 1.7744499512233762, -0.3170437091140779},
    {1.6718778432311152, 1.5928904744129955, -0.14341800032564792, -0.34959734137487736, 1.831033753072397, -0.20972500886572687, -0.3984935369015562, 1.373057479251337, 1.4682840268870203, 1.7812109661750373, -0.3634040014440399, 1.310102282327902, -0.6632215746094816, 0.9695631175037593, 1.4425591568419738, -0.17603586549182665},
    {1.0622610857349233, 0.9482931272960152, -0.020177272602200747, 0.06986823846936761, 0.7160380879709397, 0.17100592349262897, -0.14046369798505512, 0.8190647680882712, 0.885595467814615, 1.1648754378053494, -0.5006163621933623, 0.557454689887523, -0.1500511129710906, 0.33034332430908653, 1.1389984881672979, 0.22084107537889316},
    {0.910036843839603, 0.9463437679462562, 0.05010129876306014, -0.40369237763300075, 0.9519800505514702, 0.17642155887289945, -0.2874058562760851, 0.6241576621670935, 0.4357227747938336, 1.033229498662078, -0.43059017062592636, 0.530350443453999, 0.058893851617027905, 0.38981956935344053, 0.681357476357079, -0.15253615087337732},
    {0.5544023550938691, 0.5104684319551065, -0.3749206808006255, -0.5669364052502869, 0.7609335904792128, -0.15470699609951855, 0.04541318011123652, 0.1833438345535737, -0.18482551834027172, 0.7550405427746069, -0.33839246781848437, 0.22425026155149783, 0.4537631276209689, 0.14736322140936128, 0.3733401760392745, 0.06486449521943202},
    {0.7119573038412422, 1.2458048160769981, -0.15561538093377733, -0.006189845533611978, 1.27672038738297, 0.03755685689359518, -0.10687454069240815, 0.9154841431349329, 0.70121224999074, 0.8173228629214214, -0.2611478440142855, 0.749016948678532, -0.16747497807812925, 0.9050119604760968, 0.8181417732952676, 0.22063640107937504},
    {-0.4952565264316161, -0.28481791342542745, 0.12367438930406029, -0.44915711772484956, -0.07656163476408474, -0.0019211351678560813, -0.041413075811204174, -0.49010700250457817, -0.3382310416181617, -0.3265208508468544, 0.11593583875941436, -0.10007938916370834, -0.21720761510298597, -0.05301755095898135, 0.26068989751141614, -0.05344240572321417},
    {-0.4897530123588948, -0.2031671593928887, 0.2932841413931923, 0.04397470790013932, -0.17560454149947463, -0.24667105547670345, -0.02936891943220051, -0.3853058827129473, -0.3001035685231604, 0.14316163591767328, 0.13827454028953212, -0.4664813202806573, 0.25834485633023024, -0.4452203685693907, -0.1664417372535598, 0.2770470792984714},
    {0.6941289372481464, 1.2353077010970819, -0.0017093541211018507, -0.03595824554951598, 1.1431324110462289, 0.20235525611129992, 0.2210563098940549, 0.7834386836476558, 0.6815395007974329, 0.9292529417519683, 0.0342120931930205, 0.7546467881504728, -0.16825463494096282, 0.3649076836160796, 1.0025181669672654, 0.14423056575917623},
    {0.18890770161415227, -0.18010115603238117, -0.005629117083234726, 0.21602147983080558, 0.13864938206855998, -0.3626295377444546, 0.04673420159639987, 0.013145121810622593, -0.28935032838439445, 0.4968541455844106, -0.11860185415085775, 0.2580405120960645, -0.024488698376752834, 0.08210317421989949, 0.39734148683420417, -0.11550302603581519},
    {-0.4811667992802632, -0.3320769790270813, -0.06087983926770561, -0.37045709886210093, -0.23114739547861465, -0.46532059449065394, -0.11691640222508613, -0.6881352616397736, -0.8247592123150685, -0.22631137635477058, 0.10670787312909841, -0.6319731337032818, -0.25328093799972023, -0.3237353940594823, -0.41228205195408246, -0.17030536439731037},
    {0.17729934535150765, 0.010997430313169144, 0.1713820598398983, -0.1500644416634316, 0.10440018296523473, -0.10160906035450769, -0.27588395512961855, -0.017179446870173556, 0.331378317410145, 0.10785666915286467, 0.2623799430619068, -0.17575358275858546, -0.21417980812722537, 0.27465880377958013, -0.003920704127454323, 0.4391500647952338},
    {0.3836299000472478, 0.37935888606852197, 0.26735249388884436, -0.38433649383514124, 0.12920617062555403, -0.20066959858823552, -0.13843272140250532, 0.4333954342343634, 0.24735122253869113, 0.2330505669788433, 0.22198519217859575, 0.7145483791275391, 0.22644667556032394, 0.37259072039315516, 0.4591458161164622, -0.20935122313350868},
    {-0.5614005693976096, -0.522747342657484, 0.09385121848782917, -0.19398979646142986, -0.959860174994055, -0.06174078519765238, 0.11698249788234383, -0.6954865578011027, -0.5913282350253163, -1.0657553637591384, 0.03871712836413887, -0.6682430990038319, 0.2488892756060499, -0.1991915866459781, -0.4081619831133306, 0.018491733486461128},
    {-0.8261320349006976, -0.6599260517270618, -0.2906403437175017, 0.08389621286845562, -0.30309066821113934, -0.4551112755472753, 0.039517865636021804, -0.899676633255838, -0.7327694161063988, -0.8486174238600553, -0.4961959959618449, -0.754599879561612, -0.2155533707437426, -0.38114604173478434, -0.6835196454401491, -0.26350577930439967},
    {0.07284798320954598, 0.5553758113075545, 0.4603568771850422, -0.2103024604025542, 0.27030454715692864, -0.5868278052632304, 0.29544645789350055, -0.19683771790198668, 0.3036368879795971, 0.27241088616900616, -0.06442393430570012, 0.27815818814638127, 0.05699021890549164, 0.11972875725669248, 0.5673252149795005, 0.19749188310624075},
    {-0.6026287694981769, -0.015000614968505589, 0.30089884743982176, 0.25147551363214415, -0.515993038104227, -0.1341298598423404, 0.640618909705684, -0.2460835751110892, -0.6468806345489764, -0.4152039427723494, -0.38189229728113216, -0.32443722533002933, -0.07333991763825928, 0.013294228972190942, -0.6047261552795216, -0.05147915269305722},
    {-0.15362394182396696, -0.13263378059469633, 0.4068929116904597, 0.04984586039208792, -0.17060459766318722, -0.23454915746691324, 0.21247046374935247, -0.31842132324940453, -0.7365678507428668, -0.018871063479367123, -0.4631127043827035, -0.16346219530135314, -0.14064193007257547, -0.19659947616257495, -0.5209538180734535, 0.073464350014003},
    {0.814030539780618, 0.7750745394435448, 0.30282651369510516, 0.0817454480337143, 0.9388067670733418, 0.5937034361946911, 0.04828276294353034, 0.8404678452473895, 0.5118390714235348, 0.8318923618001257, -0.14434007110756386, 0.4676498862226419, -0.03529604584576985, 0.4654328888972886, 0.1796462490841399, 0.19209847597733098},
    {0.470466022415089, 0.36512517600774275, 0.08786759494979604, 0.21087110650237895, 0.24322969714024292, 0.14445736907151122, -0.021302719069990154, 0.19810151073237492, 0.23318567314495472, 0.2943195258766731, -0.12977736828752376, 0.33538422482975805, 0.126753254416298, 0.2056444045071028, 0.010638980952282762, 0.1260879688552328},
    {-0.16342468338212887, -0.5794658343427785, 0.43249126794574716, 0.3667736688030768, -0.5241814448975234, 0.41287102496189904, -0.051494754330703496, -0.4078724259099778, -0.08585729650330666, -0.5881419615323897, -0.08981923165604087, -0.4482467369602743, 0.07583391507704357, -0.367279917961936, -0.3351481989737421, 0.17971590217945324},
    {-0.8034811209446455, -0.6871597087538763, -0.25319293539496107, -0.2511461334873684, -0.5105012954913868, -0.03200731319774803, -0.014585490776609795, -0.46930060242425503, -0.6521533379560344, -0.9601161361959784, -0.014346639767651638, -0.10953629370706827, 0.011454746233253136, 0.09646350627087198, -0.42010387475321975, -0.0016019403189934203},
    {-0.32750090995230474, -0.10811185986421347, -0.17491599406500777, 0.03323969964372479, -0.5594867276320934, -0.3776735150542774, -0.00029761426465018135, -0.3144227147252677, -0.3012067382394745, -0.3633727060217511, 0.49913172206039014, -0.20025536890849352, 0.16182594264257194, -0.2757211376937874, -0.33240073887688903, -0.005055548960553573},
    {0.48001387722629835, 0.20859788433727589, -0.010822931880202034, -0.5258418655117236, 0.5731452755900778, 0.019095268928730407, -0.09719586637034107, -0.06134039134575834, 0.07815620636345821, 0.48918004763648315, 0.19779959225811597, -0.033209361287031544, 0.20754032718571425, -0.048543255088209995, 0.4530478885511726, -0.304933287162726},
    {-1.2446512525421418, -1.0065259267484514, -0.026742093515694464, -0.13099247601242184, -1.259113395161473, -0.0015309961019449243, 0.09517078605243294, -1.0732890843169165, -0.7895923112403945, -0.932673201859399, 0.24478469756668084, -0.8774225066740399, 0.6726042085767219, -0.8314213085926653, -0.9199475685688423, -0.03300518530038934},
    {0.13405115282925698, 0.22009853158843815, 0.3674511478507611, 0.03563483582394876, -0.21034734723485762, 0.18174806682707617, -0.22620399783405187, 0.3549901069578558, 0.3879788506368458, 0.11221769148898181, 0.139438573028844, 0.29228246863982216, 0.5607040933586939, -0.11032250702168583, 0.1877348011469181, 0.22096383581095855},
    {-0.8835347161957843, -0.63790909443618, 0.09199809451904323, 0.22464831779211508, -0.7777953401300632, 0.06218582023887623, 0.04546578201205913, -0.343974313300756, -0.5326267850609183, -0.7043597603737891, 0.3491956973104444, -0.34511423808689556, 0.28142778742252367, -0.26093363860640817, -0.6066882206184955, 0.05091763142816696},
    {-1.1736223746008225, -1.5313751511790878, 0.10752862977271248, -0.00808951762850195, -1.1708261060428273, -0.004241013312784361, -0.3233372651328077, -1.1748554972839127, -1.053148279249432, -1.1818455161625432, 0.013308065156864137, -0.9009071924325354, 0.2893411680057518, -1.0061864482405096, -1.3865264424431392, -0.16176020149790718},
    {-0.05457118574774188, 0.16317253763150283, -0.18357248779562668, -0.3108336021177114, 0.06771078361919179, -0.20353655529489803, 0.16108944044003531, 0.31534778235788113, 0.3443867544011854, -0.30884249967108696, 0.12969241968207582, -0.08805918993350792, 0.14257579953421787, 0.13870306972743993, 0.18878214116386577, 0.32321028587229866},
    {0.8233123219682625, 1.1423347821976415, 0.265590414232968, 0.2533537403039903, 0.8137139731153994, 0.015594502103079277, 0.5146188981646782, 0.9214901177013787, 0.974874363019011, 1.0060657387522391, -0.0731693577900047, 0.6730842319083652, 0.2839901656001873, 0.5261510921536932, 1.0321361332421126, 0.1504656930786205},
    {1.0959345381415575, 1.1988351300955922, 0.33323565631246654, 0.004356014159859899, 0.830648447062223, 0.06099483965395043, -0.016863515464820917, 1.0250551344964105, 0.6161020609200967, 1.1971083950492785, 0.32455532180704516, 0.6920350044332072, 0.5011179939426125, 0.8446212277865751, 0.7578497955089124, 0.10326688032328467},
    {0.3795431173406648, 0.2494434018636666, 0.07314331543149366, -0.15767707153645505, 0.35077618902018065, 0.19544549160533894, 0.08663229072249895, 0.7652111940021711, 0.4160954507010693, 0.2243131889690068, -0.060122004922927345, 0.31090264945396623, 0.06553264745339729, 0.3164191847587824, 0.13812254264978296, 0.15412299095726234},
    {0.383627781649035, 0.41519255092532686, 0.15807433837061843, 0.14854705113129613, 0.15414952202562712, -0.122704418946212, 0.26880958328424875, 0.12123186735203427, 0.50941078043233, -0.0046857646135149145, -0.052919279999195136, 0.24962385582615315, 0.30371890688563125, 0.1620571952131958, 0.6276095802093036, -0.01615226397429412},
    {0.8931829390376617, 1.211042793057807, 0.19845309094899363, -0.0372701137402045, 0.9444983290756047, -0.08895171283538494, 0.05185910708106123, 0.5683543342721805, 0.574010106153961, 0.8648882787602385, 0.07351912784556484, 0.6104126946909844, 0.2360247351268795, 0.20432801587116067, 1.0085600149103602, 0.33471043640171094},
    {0.5598930079595406, 0.6901512937353125, -0.23053980703740465, -0.2001535707371095, 0.5999789385938121, 0.14913113984720433, -0.33870679250597224, 0.5458255108132187, 0.22661716985573693, 0.6573795617958541, 0.0507593888852308, 0.34514722894306676, -0.02307656812266094, 0.3984354892254408, 0.42626525125953374, -0.1256628082561036},
    {0.3739811799734186, 0.24519950710292862, 0.11985016683794594, -0.20745396803150176, 0.565670546194765, 0.03694944125036396, -0.12084197213548202, 0.1866491523800639, 0.6707022273086475, 0.5237767291764241, -0.2324183587118601, 0.31427619629372733, -0.2956008848405435, 0.5770386287343415, 0.5310151851191569, 0.08782870375409373},
    {0.3577983684373092, 0.6041135330635399, -0.16794632109187804, 0.05996287667486978, 0.5600124056966514, 0.15320876265620562, -0.016503286479671378, 0.6254383020375062, 0.4596788551541717, 0.6409030275337162, -0.14087637664986444, 0.5818434576424971, -0.4167277304381977, 0.5763889491139966, 0.4528977629594994, -0.055445049434646725},
    {1.04648626066422, 0.8375873249667393, 0.011627290662219321, -0.10916006958591196, 1.0278719064573292, 0.038644291469205526, 0.017430352841930057, 0.8268656521758808, 0.7531404932248894, 0.7412390190122993, 0.2304267280936488, 0.755829828998131, 0.10989481878007445, 0.504736533238406, 0.7894417566944658, 0.065542681174697},
    {0.7131479385018216, 1.0565834874417852, 0.2123074037045224, -0.024732487563141052, 0.8336884860016913, -0.05468326168101556, 0.01644870328480537, 0.7587040579422872, 1.0258396532311802, 0.9202731276510684, -0.2947799947147682, 1.1530128836311722, 0.37714273294869194, 0.7108638108211451, 0.7004763663267463, 0.057527626637394226},
    {0.026781652807998987, 0.5926665221279451, -0.15589843057479932, 0.2400134754035096, 0.6063479143463248, -0.07868996548505364, 0.11620029228961848, 0.6654908382011167, 0.4809170080299269, 0.33754367310575395, -0.21374413879483328, 0.3903390948926894, -0.2662404082372803, 0.3416826052036492, 0.3025112055739804, 0.07114590148014785},
    {0.06137628238065105, 0.27705368626977056, -0.020710344586435562, -0.023271477540199564, 0.14037715183328608, -0.045802490542632704, -0.21322439532316273, 0.2456800018610422, 0.25519034356822007, -0.06492781968284503, -0.14693537281327385, 0.014337425152869744, -0.03942612489503484, 0.0189641857638331, -0.0019380393904645478, -0.12174012975307517},
    {-0.0007236442777425688, 0.11168079129753473, -0.010092942425511085, 0.04623783183791113, -0.23563755428214045, -0.19619373857180034, -0.2987609120313821, -0.1030985806250285, -0.19506573549922665, -0.03875328154774647, -0.06573903492758548, 0.2680797102077032, -0.21073315531529394, 0.11838745249160412, 0.4183846945700006, -0.07203434978335807},
    {-0.030419497429001324, 0.06969158443288251, 0.2983945552249517, -0.2033020507576547, -0.3406915664682335, -0.17535230663199763, -0.15827027022275045, -0.16727082869488966, -0.46002588341815814, -0.3573920652133325, 0.0974646254378041, -0.20499727272102256, -0.0391764665999648, 0.20763934422178107, -0.40700285663610253, -0.20390248655604717},
    {-0.3499266146686471, -0.6730412216403999, 0.06632678931246166, -0.21689072530305148, -0.11963249202460789, -0.02009321457843027, -0.16337416043142172, 0.05178836523818293, 0.2054059980556035, -0.2662602616064451, -0.31328545167340477, 0.030580973116607072, 0.06336775072223548, 0.054422737920323074, -0.10555993964316879, -0.037946597420330824},
    {0.8429116972112293, 0.5027768079036283, -0.026070523954661726, 0.03298514537292287, 0.6330813287294698, -0.005234960245523229, -0.0508740057638754, 0.5445516836328341, 0.9325457291021585, 1.0224378350245233, -0.016397409470947852, 0.4583537965933384, -0.05748461788793, 0.4106611979379317, 0.6276863749240631, -0.1281072132900954},
    {0.06747558798134688, -0.15830664753948534, -0.0693272801851481, -0.32792403645463336, 0.3229747282330447, 0.4096332437237762, -0.20525009765608646, -0.12007103290854569, 0.056101694082642255, -0.06872748700281556, -0.17933225727380994, -0.08760980564438839, -0.5147492279137853, 0.18990294373490493, -0.14135858389429107, -0.22007199181169199},
    {0.5279528452225236, 0.38293902502248567, -0.1828330500151379, -0.11635452577604032, 0.9483556799473449, 0.2775381732869324, -0.15202136084047585, 0.3151020894321547, 0.2032164993707087, 0.3729563655008031, -0.37019597318399244, 0.834599547859894, -0.4067563701688359, 0.46039897064892354, 0.45556177541611864, 0.03984810674933899},
    {-0.357662475792063, 0.07135983306338216, -0.026123080160436758, -0.4794719997814831, 0.011930786237058372, -0.10072616440694014, 0.23430153821642977, -0.2184449542445106, -0.35181523054285496, -0.33641887945760635, -0.21883822702274325, -0.32532174563559757, -0.3061615172687575, -0.29007088847107343, -0.29501148459753457, -0.10879286907631726},
    {-0.5812851904529854, -0.9262786985146279, -0.39377120704600865, 0.13636286427558944, -0.4814051160473449, 0.24015371722196627, -0.15904461891677793, -0.5023869158776263, -0.6261461955196375, -0.4097889963856319, 0.22783963491333106, -0.7366013707705198, -0.02739434118532325, -0.38095928375296817, -0.5696734669679849, 0.2400276329097611},
    {0.07430562504392209, 0.11937879172033102, 0.23622447824154008, 0.12142472008462296, 0.004650027436140331, 0.43109495007624465, 0.16835202513140168, 0.4764504517430186, 0.24350071042230362, -0.13788657371495958, 0.20150080388787575, 0.5056753057482811, 0.24195191350040388, 0.34731150132446786, -0.15250967129424228, 0.013345657069098864},
    {0.7770792360509348, 0.9445759498470221, -0.15176995660765366, -0.25960935464878016, 0.6870513344090832, -0.08027184151300536, -0.08425157569280223, 0.4707876572478091, 0.3876298869058089, 0.5988434985894182, -0.44426208110956455, 0.7153241903779484, 0.11195205746932721, 0.4289817199322538, 0.4278542413557159, -0.2332732894399597},
    {0.6727688661306808, 0.6948261915952396, -0.0598229483928661, 0.07189746146692977, 0.7687979405602992, -0.2554339284908959, 0.20210835514210312, 0.7429218207688619, 0.19470926570811628, 0.5255409554991785, -0.015297565188383004, 0.5293677934313489, -0.12912737733351964, 0.05064052658272115, 0.66311700530795, -0.022018794060261023},
    {0.1183844107876372, 0.1066415982557624, -0.08486886787666581, -0.0014820169934746227, 0.2438458840626127, -0.019057383456033482, -0.11012047224035618, 0.4655865157338749, 0.40914714187395324, 0.24881335747736236, -0.47087336987538386, 0.15182472461770755, -0.26017731875981226, 0.051358984939920624, -0.016021256399840516, -0.21968120377679354},
    {0.3036515664907759, 0.08724479875302088, -0.0041411204148013095, -0.20674525005813915, -0.2609462332067056, -0.15886630980336816, -0.01944292382533424, 0.07084087307719915, 0.030067318598752536, -0.0699298723162447, 0.2100942785783651, -0.27038461198814867, -0.014564196159247369, 0.12153485868067315, -0.09370376531760084, -0.2449775692579072},
    {-0.6705834131955676, -0.47233326414304155, 0.28398648351564065, 0.247259928103694, -0.2862130914470856, 0.11295655877371483, 0.3180245086192236, -0.2359655299994632, -0.7315654906552674, -0.3129095052987093, 0.04529820875090518, -0.5344392704952861, 0.18750598378182656, -0.08853515483280712, -0.7275178601321048, 0.18271543934203313},
    {-0.9095152211010641, -1.0007401223257686, -0.20239292664073297, -0.004220394729000679, -1.042722237477941, -0.1211927365716455, 0.037998049080523365, -0.8745273486972172, -0.7710453947467821, -1.0124771565049482, 0.19128987155565602, -0.4930080959608283, 0.28300773535971546, -0.42200119508187267, -0.9927541032195791, 0.04207929594706144},
    {0.6571002361720479, 0.7354888139840045, -0.20283296768640716, -0.1956712855552292, 0.4042948830553612, -0.2562690925791912, 0.12299774031558067, 0.5826043540271159, 0.26445239474763305, 0.6073005995245268, -0.1705178187257218, 0.25692694056298376, -0.2285884143392566, 0.1763128193944814, 0.48251783029675827, -0.2949766859178643},
    {1.6557379213490464, 1.8247393915264356, -0.27059288074000165, -1.161655504300467, 1.4325211598346796, -0.9553543899714592, -0.6363033884546133, 2.146839194617566, 2.1738010159298415, 2.136963543771499, 0.6035488252944738, 1.5186739136848095, -1.1730611715222181, 0.4963524674636595, 1.7871998137950427, 0.1795677652035835},
    {1.277735008760859, 1.222007569766582, 0.36657431035089416, -1.0891571641354956, 0.7175491407749064, -0.9599487305040958, -1.24725989875256, 1.7632854305343786, 1.6095587497255508, 1.5910327029872244, 0.7640366365326884, 1.5863857151003262, -1.3510235930018835, 0.02783911349472359, 1.4048348497109893, -0.40033862729460656},
    {1.8796671709225035, 2.007515153575427, -0.0010765899040732058, -0.48811079578762734, 1.6562892989573403, -0.24429029484768325, 0.016467153180946107, 1.1624462931425252, 1.3785886094233124, 2.0290822409175004, 0.059500269969938804, 1.3785265710054981, -0.7204375067936137, 0.9636866312578389, 1.6049836948245302, -0.29624319814040523},
    {1.3947531489443772, 1.7658175254188953, 0.2373498223367489, -0.2649498087706586, 1.6412628894609855, -0.4269002161026066, -0.22106947704245178, 1.4781591508499803, 1.416134991090966, 1.7359476968974021, -0.20325784073816275, 1.220257820371956, -0.4324691133592617, 0.9586239936623037, 1.4714871384793964, -0.21890512191474182},
    {1.4111078024817325, 1.4947863544600917, 0.17871224468817082, -0.28814042705723136, 1.6484648579434156, 0.041315400435143, -0.23826671468231922, 1.0162858045686807, 0.8881514652841893, 1.6567224127960993, -0.13719024617292466, 1.2374682803812698, -0.912287193938277, 0.6315988896075589, 1.2846179339667325, -0.11688127889457424},
    {1.0207526787374803, 0.5840501556323167, -0.2090664247878488, -0.06899339129712265, 0.552477856829688, 0.0456844498100048, 0.16323736160546853, 1.1873772881997844, 0.7510503595377089, 0.8636680612261184, -0.12450036736488203, 0.592588696903964, -0.26571226339289417, 0.4686779413092798, 0.4544706682919285, -0.32667281682719035},
    {0.8108931448564433, 0.7766891585521024, 0.01959445507902025, 0.08915775736280065, 0.49708894541332177, 0.010622074569782184, -0.04046844508823115, 0.5838514853620018, 0.3237198203238097, 0.7849435429427704, 0.19093060038036688, 0.6295817870112879, -0.28276134734135555, 0.3911608007582033, 0.7022763467320311, 0.0366183333937345},
    {0.2548883480184081, 0.2777413522313981, 0.0746304851530998, -0.38797682422071056, 0.33267279666936167, -0.4150178934015618, -0.03494547085255032, 0.25480785666894806, -0.083488908159987, 0.3105804608144709, -0.11142714124458711, 0.27649741342750994, -0.5909699043986231, 0.2089689169512843, 0.5757114953497614, -0.177631390604146},
    {0.5930352340888975, 0.5058261756326602, 0.09511202355932129, -0.27047463522604626, 0.2508039486709365, 0.01225096971493727, -0.29242046124956794, 0.7552998142725444, 0.4174144818860787, 0.47292940965188485, -0.1274852706340236, 0.6363044138485509, -0.329016487932763, 0.06424599708281142, 0.5183496383719263, 0.05507309771445678},
    {-0.09013259079877348, -0.09789350794145876, -0.03651743512236707, 0.2157790724241998, -0.05455237911496658, 0.02057462009390343, -0.0876344851148037, 0.08711164721326833, 0.03454679997904788, -0.008010970175256104, 0.015819337938940574, -0.03672232060811732, -0.13274001651133627, -0.020890639221587785, -0.029346632171105454, 0.1303386323049738},
    {-0.4575997752842089, -0.7080198034601999, -0.4777047103161887, -0.4267119999566193, -0.47392239631007976, -0.28314865321759336, -0.574134596002199, -0.4542232977263058, -0.2522081196620725, -0.3773022140886095, -0.09122324968430393, -0.433857682938316, -0.1769684634549338, -0.37368037250836467, -0.18413027460953943, -0.35861303538670475},
    {1.043583468354274, 1.0659574917890826, -0.010635387630465372, -0.14849246639403335, 0.9597916949961833, 0.4614325483017603, -0.3217988758631535, 0.6227817391535968, 0.9615946852297674, 1.036289772021369, -0.2870254447328244, 0.9998944952864308, -0.3099797786458331, 0.658099950484718, 0.9163554830502161, -0.292935815900381},
    {0.5115518020009189, 0.6556746391912658, -0.12381868322006116, -0.12002893725901358, 0.4768110114932502, -0.03678536880268732, -0.09908896945644113, 0.68465234027313, 0.6182220797714839, 0.9246815595116712, 0.0028425520900317706, 0.2007009555332942, -0.23254517573191028, 0.2517078600889158, 0.7176421127015352, 0.19574575017820048},
    {0.4732754607247298, 0.6588388124718947, -0.08950194431284492, -0.22153678136617744, 0.46940940668631825, -0.13052830137114813, -0.07485650186265146, -0.001045524893894869, -0.10032493943013862, 0.36709503109536973, 0.14906067372799825, 0.2072911892929411, 0.07949717947284975, 0.3858415856570447, 0.14424415465931914, -0.17128133451569438},
    {0.1705362890673436, -0.18058832560706653, 0.20929307219752114, -0.2602499078928648, 0.10307782871838515, -0.13053594462503584, 0.012879935572148336, -0.18810415914963216, -0.06059609835280295, -0.07206837329293664, 0.322822354833894, 0.21986172326322057, 0.2483220516766709, -0.08291726363869906, -0.09592915236527066, -0.08411109872235445},
    {0.4405964823360983, 0.260703851049596, -0.17028260901300835, 0.10868663394687304, 0.38349710730254294, 0.08505594662854792, -0.12024005210746001, 0.8279971540196137, 0.25198899259825086, 0.7214079263503663, 0.2954302644057705, 0.6841833547146504, -0.21453650391138815, 0.3337217141074983, 0.37944990037344406, -0.3427209394980293},
    {-0.5357875404399284, -0.6359564304383248, 0.02564324774371691, 0.27757507830222267, -1.0149079335715068, -0.39049230410203933, -0.13888267122690995, -0.2045432814905919, -0.42337824661642287, -0.8451638248375902, 0.2909036146228133, -0.47353928401877327, 0.17203629055879918, -0.703034656582449, -0.865621382579425, 0.08485758993836919},
    {-0.13739912156435788, -0.2734020709080084, -0.2129462333971637, -0.3679661277846973, 0.40013140195005414, -0.25154391350987515, -0.5966786150952348, -0.2882464676821563, 0.033877383192876205, -0.2022626084756885, -0.24506123653534803, -0.26241214211694763, -0.40996932177248374, -0.07930021544720378, 0.27687730109425746, -0.2795064620261042},
    {0.22917867437594858, 0.04029263964545918, 0.00832453258154651, 0.26123315105581263, -0.09818101158267648, -0.433641874288018, -0.02092202042671507, 0.32974371425699117, 0.14000866028966763, 0.039033438604612995, 0.19389108374470518, 0.11867789146748275, 0.014080073435964596, 0.0036193147747205254, 0.37632259582157823, 0.14423918564304167},
    {0.3084998479660675, -0.24900665071994804, -0.007509574678227504, -0.3915908103978877, -0.37888275874979077, -0.07760787605529453, -0.2486213812073601, 0.41924598636486793, 0.04672284594805796, -0.2976998446225001, 0.08812138812937567, 0.13834918841337493, -0.25368801244554195, -0.02144104286438662, -0.04178902238391757, -0.21716943647257564},
    {0.7457881291977656, 0.8911087026290241, -0.1015370967799441, -0.05036309153656488, 0.277502633037778, -0.12050519033199165, -0.09874876366682427, 0.36885464615242697, 0.5661165725038653, 0.554118537561263, -0.3719114614712009, 0.47862405466758584, -0.39480575666296525, 0.12047872832935107, 0.16456202066232017, 0.09279280739796861},
    {0.5069244019663789, 0.5769286901016745, -0.020470453230636655, -0.09601909196324461, 0.24583968012007126, -0.24267589745184914, -0.09389092184185392, 0.6005585094907655, 0.5587817386913356, 0.5358030827036723, -0.027773247167697968, 0.16509737741861544, -0.21039617214803963, 0.40876373626199836, 0.5170525028524819, 0.14522733421448997},
    {0.020473746004669138, -0.010742939935926031, 0.05867488999066108, -0.16280930035319033, -0.24064639487803485, 0.2787573477409302, 0.0692516453205333, 0.07014148875658514, 0.03318239342769595, -0.1296508797443804, 0.027400026383413833, 0.13865540283630742, 0.226237262231262, 0.2413344284560718, -0.10077984369356596, 0.30195949996386806},
    {0.4821219406953029, 0.5232075086611404, 0.033730754199020496, 0.1928106827832735, 0.4390886010347306, -0.16049427768286176, -0.13752918042540785, 0.7297840242566357, 0.8058136753726778, 0.018055241172769895, -0.24425579481453794, 0.8462615287506561, -0.05268199096203906, 0.45681398100701, 0.666759035346867, -0.1367997047971552},
    {-0.23303451343309597, -0.3939045038703696, -0.06736300104794499, 0.004130866458367028, -0.3254927400279603, -0.09267474521233705, -0.4693686537900201, -0.2904315520638375, -0.11405559016916365, -0.17329229285412245, 0.14509426746601112, -0.2932272750270883, -0.05886528422626517, -0.2970673403678005, 0.09243325227498946, -0.3774855547543397},
    {-0.6907583369622923, -0.41372007024047336, 0.1262788407700806, 0.3230788551471941, -0.6810754100411508, 0.13606956642619228, -0.3734325994045125, -0.3011397526866591, -0.45737774977886103, -0.6754041931667893, -0.12865369152095477, -0.3756844230852926, 0.12278999442658552, -0.6492357514200385, -0.6126552772374441, -0.01980216732989314},
    {-0.023937489796246162, -0.1734406899574634, -0.13813729684888046, -0.2790874954596244, -0.09966537826657182, -0.1416789922845097, -0.5526782507207358, -0.029779432383454416, -0.00136054293211191, 0.323102278588351, 0.17760456596371843, -0.017260820596555555, -0.35493812363504146, 0.146460050456725, -0.12342324480191284, -0.05172318318480249},
    {-0.6706134784673082, -0.11991015627553062, 0.0793674793559389, -0.25912787349957384, -0.5424634638571695, -0.09345027750442698, -0.24397823970145643, -0.3810121629451432, -0.291811729038663, -0.7343684691527592, -0.30826563708345034, -0.41458450253432255, 0.21524510481484832, -0.21664839581660958, -0.5370833170060815, -0.21774660779921706},
    {-0.7276304174897343, -0.8834380767164572, -0.0779304904602587, 0.09197162757308566, -0.9665927289631636, 0.022760895774363906, -0.028657608473680898, -0.6044515096536417, -0.5606446762825246, -0.8740391733792123, 0.2111841711036839, -0.5450083968065045, 0.33747385830062065, -0.7061257765656115, -0.4821493043002689, -0.0380320371066817},
    {-0.24191506862753606, -0.02650515764395179, 0.09796490389956913, 0.013241120435875369, 0.005941146308847953, 0.1414197746694831, -0.030363508612456236, 0.04896080500011395, 0.09704914182437022, -0.4242252654737977, 0.2477028108751598, 0.13175354553791838, 0.15774498212985358, -0.029936681380658352, -0.1645251619913667, 0.07847343895090635}
};

static const float b1[16] = {2.436809725775889, 2.3237139463627634, 1.8045574357138183, 1.1442285438478565, 2.2404682816888215, 1.1667240894762545, 1.1510332912045576, 2.756117089071274, 2.7503284213846664, 2.6504312726134183, 1.494312128607003, 1.4440787722521873, 1.287506098324807, 1.858004709056756, 2.339559516475325, 1.8256803815242715};

static const float w2[16][12] = {
    {-0.20993367928846896, -1.3722013793637897, -0.6952583573059343, -1.9468538335120475, -2.0317024542840576, -1.7062094578546563, -1.4794629720082815, -2.318591028914919, -1.149971215223886, -2.345334964350568, -1.1722901302834619, -2.076947625442032},
    {-1.9504963834394053, -2.0580194476212497, -2.553303094221661, -1.2667682225725652, -2.1364949899658754, -2.4209479064682298, -1.8513202677939473, -0.8756265265453904, -2.1208623025734004, -1.3942991454182747, -1.8022967663826666, -1.7383748910152683},
    {-0.30928183993285735, -1.764019243793233, -1.6987301006692452, -0.3979414368378616, -0.46940118616837406, -0.14137440039309776, -1.895061651697855, -0.849297413542624, -1.3120094601824526, -1.9522703261983947, -1.5706520791553813, 0.6496040207385425},
    {-0.2757714291796984, 0.03525910158366448, -1.5872623900196525, -0.5434038214774212, -1.8606876917303745, -1.3640535643658669, -0.5785897028327611, -1.2854524113243595, -1.0529720242294094, -1.6575596592538755, -0.7735516789793386, -1.1735363953126623},
    {-0.7709562190143487, -2.415802362064307, -1.5258077134005872, -1.474930583831846, -0.9225928407211277, -1.3888654967177514, -1.8451119908838218, -1.8229571797515445, -2.789165502511059, -1.2787656083787695, -1.96992574390692, -1.295567988296961},
    {-0.7333931633736221, -1.4694700332104125, -0.6524789568637865, -1.8417588397953548, -0.5346674631501961, -0.9798682147380084, -1.4771770894425549, 0.1532763856307833, -1.0055880015015357, -0.6951405166102795, -0.999551951648631, -1.2555247398155958},
    {-0.7954629835755173, -1.4119562024693453, -1.92841081246383, 0.15684755511968906, 0.6849301575332294, -1.1240761265108516, -1.521483892204409, -0.6918309703961125, -0.5829682973259074, -0.22136000232368508, -1.3664811604763438, -1.171767082199024},
    {-1.6843686080308558, -0.7616786101918654, -1.6123552868399191, -2.295757946559705, -1.07612318552071, -0.8089311526957013, -1.909960549451692, -1.4850102093123472, -1.8271015473089862, -1.031100552360152, -1.8701252758823343, -2.461042709237722},
    {-2.1665374197211777, -2.10164178447645, -2.4120248897949654, -0.4191033133444309, -1.5281488588304604, -1.6135950396047807, -1.6363546677542093, -1.7142158905587972, -1.6402027920457358, -2.185955715325428, -0.05400954739983026, -1.1886286971132156},
    {-2.143639172839115, -0.6022132432484103, -2.225715165456087, -1.9405913631210674, -2.2044722969250468, -1.3909284049166544, -2.2487979841403773, -1.7360351767586957, -1.630425858516107, -0.7548258494838378, -2.5289281958153484, -1.8810055799503331},
    {-0.3655966859708249, -0.21655318668994172, -0.8666576815803522, -0.446509276800615, -0.6733239747303279, -0.25029580614133046, -1.0577547150531843, -1.039457307863434, -0.13422207818470025, -1.6707304568441723, -0.6943661469149787, -2.061711147342548},
    {-1.918772520018737, -1.7102754484971083, -1.4701011130024721, -1.264623842046011, -0.9250971890440849, -1.1536102287638252, -1.1103278466065343, -1.1231499945215913, 0.3550291228967775, -1.8533153767547372, -1.2974323880883092, -1.6684772245259596},
    {-0.9794406875741879, -0.6661548278600518, 0.33356976920526726, -0.9765501828802948, -0.8857515289291985, -1.1543887813551663, -0.7525184282245445, -1.4226432386952017, -1.1210496077666168, -0.06603515751045125, -0.5062822693379623, -0.3746709313079155},
    {-1.9527846412873286, -1.365124311017255, -0.6418346539333472, -1.2165972061548125, -1.685637707030793, -2.1413722644088846, 0.4863785173409573, -2.342526388615707, -2.111499754976622, -0.799787864335736, -2.3855699048748824, -0.5607583796875237},
    {-1.998576483676963, -1.765788150736827, -0.5861476081232786, -2.1272285895306116, -1.344239574852875, -1.5879155454599432, -1.51663239708488, -1.1199553353032863, -1.2206904682735322, -2.4797933958572367, -1.1164998942688482, -1.0475521305691768},
    {-1.6523031395144039, -1.1851984794773527, -1.5867960811046888, -2.776548519056227, -1.2541462932410299, -0.07062095666325793, 0.2560774832186055, -0.6462965036772901, -1.0063224075602075, -0.3747827703112105, -0.9243113510154204, -0.6485066701967118}
};

static const float b2[12] = {-1.2815915763906638, -0.5228448951243763, -0.821587108192497, -1.023187673967693, -0.8876076403313585, -0.8523370550156681, -0.6839368008560069, -0.8986767234897245, -0.8994014224205757, -0.7821161965614919, -0.03767240830145215, -0.8188334649519964};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
