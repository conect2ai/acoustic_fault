#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {1.1140631746891718, -1.1654120820188991, -2.0205890278281537, -1.0591803878435342, 0.3445196106075828, 0.2864925601067365, 0.1941342091818005, -1.3620139531513116, -0.58596800191056, -0.9898266998976535, -1.4261571066049923, -3.367881056733426, 0.6863399502932531, -0.08308526913262257, -0.10204824694478101, -0.22900972662464222, 0.05462681496870578, -1.8608383345400281, -1.4766944232683352, 1.8652663623000951, -0.05576505730745675, -0.5136054163803861, -2.241942484103213, 0.06181270988430841, 0.4360382753289449, -1.2242711847925645, -0.3505659195924479, 0.1187331049284301, -0.12036867442435692, 1.1304158144881458, -0.9377046169729616, -0.14619292045447382, 0.15965500201357835, -0.21542883799500445, 1.0694707434789874, -0.5808836212075779, 1.5457905018554765, 0.19244097079705366, 0.8359712061811592, 1.992135917589604, 0.6511758559546347, 0.08350317007825199, 0.3886712115313299, -0.6273578986580304, 0.15785043452737318, 0.8720146472742754, 1.5811643184668622, 0.7124813525865166, -0.6783952484903011, -2.3515561962711944, 0.9286884141565115, -1.557640266669369, -0.8321233895229687, 1.215513732403969, -0.3984517601685362, -2.3462291252066216, -0.4547308715420906, -2.539002487267771, -1.4011446402890702, -0.4644097097831578, 0.06511665701506791, -0.9229476681112163, 0.9240730589346605, -2.783724900988135},
    {-1.7940074678771156, 1.3005999510954502, -0.5681019583794452, 0.14760839073985213, -0.8496638395001146, -0.11267258313252115, -1.8507412184203687, 0.9588008114032428, 0.5217529073391531, -0.6683467337429946, -0.11188651090282518, 0.3169976968589791, 0.2778794580152198, -1.2193138083895805, -1.055034457014833, -0.51874612553044, 1.3257048175843382, 1.3237716759564686, -0.954674456622171, -1.5517709064233232, -0.9321996034245656, -1.0089617223971767, 0.6917671457769742, -0.18434219654870554, -0.4670492835348427, 0.3631456653097433, 0.33846032443543655, 1.8860833771603196, 1.5913031924648828, -1.4445636382139029, 0.47197951039917585, -0.32233090119009733, 0.5691895030718815, -2.2902023758687626, -0.011150371465894227, -1.0244105727215962, -0.9211897194653365, 1.1844770729281153, -0.08451949280293283, -1.1844879678837843, -0.923161441331781, 0.528178421689814, 1.352685933449337, 1.1850124649541027, 0.4931647299081296, -1.1870926379443214, 0.7171885616987529, -0.2825126845341195, -0.15513922964872445, -1.4367449785188748, -0.821316895486156, 1.6699846076416476, 0.11596979681255278, -0.6910519143476034, -0.18210379211729624, 0.4896766215775452, 1.2522693233968873, -0.30776458538758444, 1.4729392029279584, -0.3198024323014331, 1.5440520295268765, 0.2981461684470367, -0.45064124915783504, 0.22288350107519694},
    {-0.5793362260004219, -0.8685430572647228, -0.626332238472763, -0.20613119345163905, 1.2970737306816846, 0.034015564457165436, 0.7741514901604386, -1.86186200589016, 1.1242167893290582, 0.1921244370357875, 0.9514499181699245, 0.7888203158958483, 0.8205760330903991, 0.9997627040502307, 0.03445917054738891, 0.012337763580508478, -1.454984071268663, 1.1126582805830407, 1.2000672157811754, 0.20324590753625774, 0.904602938801456, 1.8366148210402966, 0.20452461183875717, -1.1908753888157688, -0.67376458199562, 1.3500654477216354, 2.0400812721830275, 0.6629687905830333, 1.5102258765582468, 0.6752430803985668, -0.13975030384463805, 0.15712678725447823, 0.8358217505105301, 1.6401578825966967, 2.9704757406018127, -0.6599247415172091, 0.4227257647517107, -0.617439951870956, -0.32779459257590915, 0.43286189207955056, 0.400877630154742, -0.29949707607893505, 1.101910323084559, 0.008823625137485027, 0.20275430231454572, -0.25413833430172345, -1.6753704588862186, -1.1554002815761104, 0.4355887847206125, -0.280662166423689, 0.8090906096201579, 1.6087865523990286, 0.5810102713492489, 1.4332375486977709, -0.39545961663328616, 0.2072944177891801, -0.27331805367346923, -0.19606982288403646, 1.9076135882996499, 1.7723159696103747, 2.259926698491519, -0.7796003201822994, 1.0591894607331716, -1.2562887195840093},
    {-0.8198765525709264, -1.2137867330221765, -0.15948182636835034, 1.2835229146396079, 0.18489586592465504, 1.102018407384641, 1.0467086211036933, -0.17189672883485674, 0.07389218378517019, -0.23701600997716815, -0.3507914311606901, 0.048632717391810396, -0.035940537623144087, 1.7375893197194865, -0.3455420974504468, 0.7095862615348978, 0.11120008535515312, 1.0862611834897171, -0.23058310942822968, 0.9805282911353959, -0.24248229142534453, 1.71955526818398, 2.1256842530711397, 1.4686196064067856, -0.9370532997424694, 0.21710751462125566, 0.8525434091849016, 0.30417256088833744, 1.3245089163358363, -1.817284451036554, -0.4429361295779829, 1.3906915269764601, -1.5821153584876901, 0.8170729211859211, 0.4084778776255168, -1.0269222423613387, -1.8856376156143524, 0.359826871757211, 0.49551130951605327, 1.002142870076441, -1.68490386326847, 1.7379112758442936, -0.9843561968337812, 1.7754603251997498, -0.3375524802216041, -0.6252483765157056, 2.713455016641035, -2.649516540616395, 0.55090112107405, -1.0122915873372293, 0.634104665472514, -0.8224446959689561, 1.0216955491818085, 1.338953742817189, -0.2224667134210916, -0.5266771441502099, -0.9755231197450974, 1.5118972055078694, 0.8364506534687056, -1.308869556742857, -0.4244546787520063, 0.32837214287182476, 1.5018501644058977, -1.6719131986292641},
    {0.44260157511072, 0.5660120007271716, 0.11982408603679916, 1.6008380173614496, -1.1926328237410724, 1.6144511996835142, 1.757048710962114, -2.1009837076431293, 1.442427633347076, 1.4801925191427736, -0.8927312102168087, -0.1741221372810596, -0.6036639162744516, 0.2811208945999985, -0.647411873207064, 1.771889175646151, 0.5825642523473754, 2.7681185044047063, 1.4690670545249385, 0.5050325712345582, 0.4696385905047807, -2.109099670292336, 1.2617059753765811, -0.4119317709148454, -0.398520676048044, 0.8786109888064908, -1.4261829650922138, 0.6051791619151331, 1.12996301960494, 2.0270182580398703, 1.2450193828593024, 0.9953723321588942, -0.14420585239183709, 2.484835459834238, -0.061893861982868455, -0.35122829604545347, 0.21881264926560764, 0.7756740963571406, 1.169502486642273, -0.6788461601519518, 0.17082597549684456, -1.3279886096681954, 1.8615603869835202, 0.9598332447647395, 1.2994853552490673, 1.9191126700644758, 1.20046358789301, 2.162353500140329, -1.1775364469352858, 1.2311298388489655, -2.219851825493506, 2.9874716148917946, -0.38557573962349256, 2.2667125625748494, -0.7361939228370172, -0.9841652475591823, 2.2151964842464107, -0.5621089541024056, -0.47961236627116066, -0.5090118131030279, 0.8910994677740303, 0.925753238396837, -1.3665903419214833, 1.067104378729439},
    {2.1674568780333567, 1.8870611840716425, -0.2303464731749089, -0.5449795176018903, 1.979934800114233, -1.0323116998342754, 1.735177072888359, 0.5481372752971907, -0.3296224640434149, 1.9046336761495926, 0.9233259101655377, -0.14760010703909687, 2.1894590688460425, 0.14965957002200314, 0.08928826872892778, 2.0436511254834557, -0.863004307620607, 1.1452717290536434, 1.0004063104961651, 2.4310837023244645, 0.8518835705234662, 1.114362025761478, 0.4893052446114195, 1.5193411579051739, -1.545281274149463, 0.39077910580358927, 2.0553654750436614, -0.15809999976421024, 0.41539875512939, -3.1951136543185523, -0.6600968699536652, -1.3911021142679802, 1.0028570274554378, 2.234967822680759, 0.2232785466808689, -1.0280072331922352, -3.4901720157464977, 0.8832403610407848, 0.5100617717622113, 1.887144368859509, -1.5988898659281578, -0.17186081436675268, -0.610379328310743, 0.3672150156803811, 1.1035299794565412, -0.37293363395167334, 0.07642392222116615, 0.01860059488306693, -0.4284754872736577, 0.20690261352125072, -3.814244347793496, 0.653153470472702, -1.1745420096002257, 0.4276087999634263, -1.563797295672811, -0.8299989890929418, 0.5080063258076667, -0.6722495404028085, 0.900407345056345, 3.993814729026908, 0.14022353210680635, 0.2599822224867099, -0.11487292245431424, 0.03097494458003781},
    {-0.7129914340769152, 0.8202256560851529, 3.028655718389159, 0.3433963078182352, 1.3496972634024205, 0.15127629879053203, 1.7882827679676827, 0.4049825231990236, 0.002979514521632556, 1.0994350833002458, 1.3618820208353288, 1.821216224263618, 1.0206743844989727, 1.7335811156336718, 0.7654288785619455, -0.3138453441860867, 0.3686784646690327, 2.4448551087982815, -0.557586798767773, 0.5243798220445095, -0.7478358344921912, 0.4839181953578076, -0.31454159830274725, -0.4032205769046922, -0.28209567720092976, 2.0615814562307597, 0.48724786367883005, -0.017228915907378524, 2.6388863993785687, 0.5845743541258551, -0.6385645436556748, -0.9021802102111501, -0.09003628446956852, 0.8098694920307544, 0.5581803127554196, 0.19495441743994535, -2.133286775267261, 0.3906139037861425, -0.4453877941209872, -1.599300015268016, -1.1387101150320298, -1.0771327825401213, -0.2738600787333245, -2.613503947882514, 0.20216403604067099, -2.4463962574892624, 0.885217890658431, -0.12259373158871976, -1.2853170407320733, -0.055779239744391154, -2.3185939386275773, 0.7271720480510869, -0.9640687324028082, -0.883330504565086, -2.037508788083369, 0.6653057603497592, -1.4072968201278568, -1.0061092660723558, 1.335138007112628, 1.185983787333397, 0.04207589962979813, -1.587371770029206, 0.3382243328288556, 0.757428341631777},
    {-1.6050637461313544, -0.05884782528745614, 2.56255401355639, 1.2691709535773172, -0.5763926637580594, 0.047052942586940885, 0.7714578800612726, 0.2339004758652187, 1.7654441628165738, -0.5548886780585385, -1.0098925783983195, -1.8253206962549604, 0.37638749753032197, -0.8329309580405104, -1.1678879567458005, -1.0562018190871805, -1.1638227220657955, -0.016729566170341017, -0.2873996791181052, 0.6685576006857732, -2.3721143304440653, 1.0260628595679604, 1.4470373073374916, -1.0485344695804006, 0.4549849687714437, 0.24737331830183834, -0.32698743609833814, 0.15208799328703188, 0.6908363047371139, 0.012711382302767483, -1.6443299592965794, -0.711072880279692, -0.3804732938051416, -0.2715017883443687, 1.4415282436835875, 1.0830329819546447, -0.383997776114191, 0.7076097894748081, 1.212386403392688, -0.8107580719196988, -0.3500473060105081, 1.8280892669933042, 2.2203196530035467, 0.11995406480854563, 0.040902386255116545, -0.1985110881620668, 0.6450783720236184, 3.005662151529995, -0.5104792077677421, 0.9264665501654842, -0.3290324870456501, -1.2826612236738621, -2.0927325659456186, -0.3177368164270482, -0.5901206523310821, 0.1651412936604089, 1.1002672382449572, -0.9250905857816432, 0.42372330355022153, -0.3703116743197909, -1.5636621472270387, 0.3637878759362256, 1.5289598425597313, -0.5594808806294617},
    {-0.20914040100671835, 0.7868144093586026, 0.5808065698007441, 0.43072207220528674, 0.21662347655037378, 0.7263511631618258, -0.8707449213031101, 0.8408473217904551, 0.4113931206163844, 0.3298753764400184, 0.5384297090202951, 0.22513333930726895, -0.010904848448700787, 1.93658829855859, 2.2101296126759657, -0.08505593252042455, 0.5832820092843833, 0.4592751018161257, 0.8921729531824967, -0.48274321299048495, -1.1059566720413618, -0.5560146368789891, 0.24393959088357428, -0.39491523905691533, 1.548664021899077, 1.259412953267194, 0.7150868180805454, -2.2109515130699835, 0.8256253005542453, -0.8336971180452406, -0.6716979152954237, -1.3734963960643554, 0.33009868280516613, 0.42833265996310416, 1.444358607509019, 0.8827117118142708, -0.6096376998130049, -0.41908283295660265, 0.13403402760392208, 2.3191019975230165, 0.4064606861138873, -3.1231594313732827, 1.4137708791411294, 1.0214418183380483, -0.8407420672966316, -0.40038374359085704, -0.2836699544229071, -0.29435224401153737, 1.456009589175901, -0.47476938826302917, -1.9979861548274755, 0.6882376489561585, -1.9204303079450906, 1.4315960113193633, -2.7246986058865996, -0.684630942236712, 0.28468988368252995, -1.1118689949370946, 0.3502771971247057, -1.4434561985669911, 0.21190074367172154, -1.6647105932738977, 1.2158300279691638, -2.7268097120842003},
    {0.20340188511460602, 1.4446836718493306, 0.6657201025024069, -0.0943900852106595, 0.5051428496169702, 0.10147274602056232, -0.5664756523823108, 0.1494645434184911, 0.726717234890102, 0.16174763327309977, 0.8337478103551177, -0.6460286660284549, -0.8268553607240278, -1.1846999189866505, -0.8489051653624098, 0.6943692299212365, 0.525841691540359, -0.8036958634320979, -0.03501377044970822, 0.20679040510477786, 0.5892025490527927, -0.2646040337618652, -0.6328115645715748, 0.5760260488845694, -0.9595625880511195, 0.5075575251537148, -0.24440521911038296, 0.1845698977794851, 0.4286105786594708, -0.6774995852105681, -0.6258053744574482, -1.8457611908480593, -1.125087014775056, -0.9389620866838362, 0.8233615695977116, 2.1337255072150203, -1.600605871882279, 0.3785057886868431, -2.7697238968908957, 1.9939973601576755, 0.7376634131034908, -0.878735955905198, -0.33115167617684166, 2.3620998472729595, 0.2877355546461063, 0.766967134010495, 0.5837807659202535, 1.474677774209833, 0.555416559821799, -1.0876838013773258, 1.755551528814867, -0.8767391418811002, 0.7168268228640482, 0.6931403769969879, -0.4346478559259168, -0.09174926808319478, -0.06636750526378535, -0.28384702513246807, -0.5880286059825388, 0.10084198412676441, 1.0424252979201998, -1.968244660384934, 1.714275633473916, 0.448325200130088},
    {-0.35873712483977965, -0.5861523698500289, 0.44164636009171526, -1.8304918974265423, -0.5860376456931069, 1.6680840381996955, 0.9190154962004148, -0.7181187698017176, 2.942725329415214, 0.23823836833922002, 2.086479902540673, 0.726678603493413, 0.8509434207446535, 1.359482521870167, -0.8549592362363597, -1.0453987436529295, -1.48875185683976, 0.6094136001701911, 1.2378224003740708, 1.6538135574344557, -1.7363636679516863, 0.7207210725370106, 0.25366693784182087, 0.08093101061473938, 0.6290343504486096, 1.3570570299748448, 0.1485264840232963, 0.2566583154247136, -0.7961418014899421, -0.032577265961232366, 2.21008427755196, -0.12490457919280872, -0.7356117697844217, -2.320912419553862, 1.015572250739997, -1.454615138785056, 0.7965746120837691, -0.20958885299234345, -0.5846167680935456, -1.711193111563735, -0.5017063449089265, -3.611128011230052, 0.5285364417754331, 1.1674507104691876, -0.022891033183461536, 0.534570354749199, -0.9000021244123763, -1.7688416876167006, 0.003501562410476532, -0.6174377305549932, 2.2056112220816386, 1.700972695594006, 0.543244769357746, 0.08333919575643685, -0.5330808975968506, 0.9421760932223532, 1.0455957896594794, -1.3111548703522424, -1.0155200451192388, 0.2141703838947643, -0.5484188671247769, 0.19209425097637278, 0.05715914876047931, 0.215144787526617},
    {-0.41782113545073857, 2.1231673852075454, 0.5831709195083752, 0.3461063129531319, -1.1701877154165523, 0.8814025748505677, -0.16416053704961114, -0.888279319770322, -0.15707667964153418, -0.5553711324174305, -0.2607617641524238, -1.6486889142874033, 1.1331562722863096, -1.0105278547316752, -0.11710724642112831, -0.8514846147669016, 0.06439852027200578, 0.1926181184412119, -0.5077561449644079, -0.6565074171433336, 0.29746201837242275, 0.5710762989081812, -1.6268259812633337, 0.8106896445773634, 0.29203839393607706, -0.2509009159237971, 0.553919828780707, 0.21546473576935235, 1.0244044207142342, 1.2030335698424994, 0.2407719086443285, -0.8812150775022574, -0.7949355305031127, -0.507104335320085, 0.08017932542131653, 0.36228917490336904, 0.07595201905858931, -0.13925921283105955, 0.6310720794683885, -1.5196156782766486, -0.05158150625111802, -0.9362656812532567, 0.2721803206863303, -1.237405100347534, -0.54807485062022, -1.3567157390179232, -0.02433949906386822, 2.784394465112678, -1.5288667422542253, 1.2458467470330272, 0.15624938323153767, -1.422536512612826, -2.153313198810242, 0.2095284907126522, -2.3205646011140892, -1.1971882276889105, 0.4836392905950968, -1.204808567395483, 0.9131487174599385, -1.121538976851166, 1.389927998728302, -1.4017108868809847, 0.11544970603747841, 0.23579373710993073},
    {0.14006238452431113, 1.9068273235684474, -1.1704504503260658, -0.49782192594100094, 1.1017404653105862, 0.29221453588923074, -2.168862470777233, 0.3390237189058733, 0.5438089902074843, -0.39119863346236433, -0.281468178813514, 1.151866365894959, -0.010752399273771827, -0.30561888001032417, -0.44221978063784306, 0.7371574864430153, 0.12379568964854407, -0.005127861803730511, -2.211200871661707, -0.6541157366092415, -0.18961834018237153, -1.4073565888546766, 0.6024700990888764, 0.6553655903681955, 0.9959908735694866, -0.16574983251203762, 1.9506615271694052, 0.36412978267373114, -1.2988157945597596, 1.8107290026269747, 2.648677023258315, -0.04395361229794288, 0.33677596720416014, 0.768672500766349, 0.34467290455360416, -1.4563077163177363, -0.5397849222406197, -2.1204376915655105, -0.18770559055550956, 0.7976501827541171, 0.22405467921619487, -2.5906721664466037, -0.5229103840769078, 0.9278546267063893, -1.6597006338587987, -1.1107138232145883, -1.3734754535590434, 1.1120599180041026, 2.20525909474656, 1.4223219315271853, -0.6703592691472753, 0.1437493695941167, -0.46555159745505553, -0.7393423898267478, 0.5308717575255902, 0.7716910408599168, 1.1507986368860885, 0.9605621812278252, 3.2922513407570553, -0.5847708267785644, 1.15644744768883, 1.613120450023566, 1.7209205787526296, 0.5158051865648892},
    {-2.506454703657012, -0.8929179371463413, -0.3730691111173395, -1.2611422430589507, -2.228455549685196, -1.554153948797759, -0.15351658247267222, 1.1351575818848403, -1.1739392054932707, 2.5891225356576792, 0.9662238049084589, -0.9415615797835462, 0.9068865609470831, 2.0381443397331798, 1.4793434491839117, 0.9493483453215411, -1.6153239646749424, 1.2528949631033537, -2.3592660921474873, 2.7550270317541155, -0.9465466371413637, 1.8037131395752457, -2.0071682764304755, -0.3431663541682371, -1.081074161517265, -0.9317026941269245, -1.3692073113935432, 0.06113218812888062, 2.100249253292923, -2.026650014578811, -0.5676997279310423, -1.6905869231452486, -0.5690633591586874, -0.5602820773026357, 0.7453809458527052, 0.6798569437565961, 0.09466366359815284, 1.0501885879728863, -0.7373534470883071, -2.074490797779668, -0.8706405417106593, 1.4753652632674596, -1.2618629720667556, -0.4259198244389701, -0.37039119800556536, 0.20242772225433192, 2.00080501603074, 0.1495187243319556, -1.0409324984478254, -1.991301069237509, 0.7481129709777385, -1.351498442078738, 0.48842904422734273, 0.611100748332679, -2.0697125520132142, 1.6859943518669893, 0.2608918623158248, -0.05892525674986248, -0.1636653804438495, -0.39972170384230143, -1.2735750670444725, -0.08565911107857131, -1.1714879205503836, 2.378002598883173},
    {1.1566337665718391, -1.7806961105409627, -0.12292744758255925, 0.5811708401467033, -0.1706239027667348, -1.0502753491554422, 0.8538744902872729, 1.9666032879767519, -0.028063184692280616, -0.9271360837311154, -0.39123488219523483, -0.35202407338754244, 2.1221421804899694, 0.5103536607851777, 1.5411931785516695, 0.9281979881109564, 2.082989630503242, 1.3796212211035628, -0.11536236505733456, 0.9093655914760492, -1.2961005209339644, -0.7804752125985126, 1.057676152853492, 0.1574452500871982, -1.2165848270924777, -0.7014797421761316, -1.1176888442914397, -0.9946847327403228, -1.1712990829514374, 0.4047429612259145, -1.320320548325464, -1.8484885361903625, 2.3513201862931523, 1.181096607849031, 0.9503550465667772, -0.3852771649386397, -0.038798065496585696, -0.60044953315107, -1.260337561166578, 1.7522904409163766, -0.2878212157044569, 1.1570408605286433, -1.3210770908709788, -1.2449379245941057, -0.9715491229160736, -0.4038237994622153, -2.0523197394008825, 0.20578739130416507, 0.6857188435936186, 0.9047099019754915, -0.8957613381276875, -2.059031048403315, 0.9642801666213464, -0.27543126412447816, 0.9985100230864509, -0.14803675534100116, -0.31852753083238383, 0.8334900414564808, 0.9565733696656467, -0.006041466131122565, -2.4256207638569856, 0.2806644350913307, -1.2932913396811678, -0.3888883210287294},
    {0.20778308085264627, 1.7704716784071894, 0.3839179610372303, 0.4297381335780178, 1.3327324853136646, 0.9601806989582192, -4.323514688626542, 1.1874916945378684, 1.3996066479320015, 1.2699090011548322, 0.6262791771955698, -0.499253398747462, -2.2524965039304874, -1.9702134502414796, 0.655707261591922, -0.5415631715612236, 0.251388692134862, -0.33574740849251467, 1.1909181762583565, 0.6704746825633826, -0.9535502677461257, 0.16910246275486523, -0.8733797976291215, -0.6793956334313701, -0.17497761276601392, 0.2379687926946799, 0.30428064392451926, 1.23788209039555, 0.44624154205520433, 0.6483967908499129, 0.1471507730360601, -1.03632388719191, 2.0110722549031936, -0.3043579153717879, -0.3996089785694039, -1.4372182122843042, -0.47487110755277756, -0.7269287941433064, 1.1000886675486223, -0.3032244957363514, -0.5258392482701384, -0.9698410776919772, -1.903956820836317, 1.2941128636146084, -0.6764551863732008, 0.544251353778244, 1.1170488266717424, -0.9355834997363671, 1.5893862913287606, 1.9554873600119593, 2.082169148649091, -2.8390326624912987, 1.4260139656840598, -1.41990899082459, -2.0940987277507577, 1.6191194031799314, 1.3957841646422857, -1.7884020619570278, 1.0799219898510428, -1.7713079300916656, -1.0875393396986528, -1.4401221403287996, 0.09670929001082519, -2.342139556759172},
    {0.5159000514724468, -0.814806893971486, 1.4679604574563272, -1.4971100520881675, -0.3389185626415954, 0.70589846033094, -0.9104651018180121, -0.1089748662357649, 0.4870512884829452, -0.717100988480035, -1.7818155114451417, -1.8745844688578301, 1.0756811568058375, 2.1294007517901967, -0.07363141790424069, -0.17529133986693443, 2.115270806071126, -0.03211916017302797, -0.6291920932933657, -0.06748820407818469, -1.1485923580972084, 0.012862136318752826, -1.8443601965292542, -0.4860922131036625, -2.2797684641801625, 0.004455770431888106, 0.03844208233539402, 1.9057170213072805, 0.3290670371198038, -1.8839936352582862, 1.3330091072576635, 1.3477288006678494, -0.24951490499691042, -0.2530590646180465, 0.9761712233872212, 0.7594068121015339, 0.3988579845622296, 1.6768511025200954, -1.3690134494160995, 0.058482474208942606, -1.2823975106541845, 0.4613619341207928, -2.745854159640733, -0.9329075822325642, 0.49255771145843835, 0.12308412779706657, 0.216247842847685, -0.7406140977262481, -0.1134332508437093, -0.29825706919405826, -0.3863152591786076, -1.3512748806568629, -0.704363344429784, 0.9208509298681082, -0.7414640057746991, 3.2724093874760705, 0.07900213892841833, -2.770624740641579, 1.792397598259536, -0.40712763683725783, -0.6838561502766612, -0.13086624268709376, -2.1438163937301606, 0.47097838462941033},
    {0.04901506257480706, -0.6769307627237423, 0.7532178645936058, -0.02615187698160634, -0.9643392302654433, -0.14538586252952065, 1.2179825775661084, 2.8551826853393703, 1.652162516586916, 1.558559205635467, 3.1676696850253014, 1.5255092421836323, 2.0713817173274247, 0.42811784101271094, 0.5550636085760082, 1.0053004475771528, 0.707516528816793, -1.8222281599700094, 0.46759031457993244, 0.6819177894843491, -0.3279195936731298, 0.9787067362023222, -1.3766994697020265, -0.18861974395051792, -1.4136114415998104, 0.2976195936199185, 0.7448738218590883, -1.8798963675511748, -0.810308412698349, -1.925861827941211, 0.05308933084817556, -2.291928170795213, -0.28123517213247057, -1.557748377544379, -0.006525622670855997, -0.5172792097747959, -1.2887217983595038, 0.47225974136155224, -0.12086321267787341, 0.6600800088169569, 0.42113440648170425, -0.49181421119535285, -2.966901635859247, -1.3766697833300197, -0.9193366287679504, 0.5084606369167365, 1.2610720817753978, 0.05806095913013297, -1.1113067695844678, -1.1172589028295554, -1.8500763399303803, -1.1369494305999623, 0.998017924283529, 0.47095495020725864, -0.6868122196526742, -0.11717829028305854, -0.37056269090068017, 1.6877007101190458, 0.805183187091139, -0.10461360304917316, -0.9031307781944551, -2.367516135073624, -0.9979412039641328, 1.4139631549426044},
    {0.1829060663312832, 0.5116266803657462, -3.4650064089630566, -0.6176321235802453, -0.8248472847775921, -2.320768467111956, -0.17000404538160815, -0.14331401003578934, 2.6124556671930446, -0.9757840165042562, 1.0605013878441627, 1.159165887284044, -0.012422521221810033, 0.1332865046514462, -0.6814838942080724, -1.084355374281476, 1.1960115173170704, -0.32601508387202394, -0.5416938523867078, 0.4371737507195081, -1.132009906688068, 0.15036164967994867, 1.7433494089927057, 0.20535899553154272, -1.9571979058574709, -0.23015744312238298, -0.8818607788622429, -2.304863432585426, 1.725584226704552, -1.2860100311096305, -1.5251774084710927, 2.451710850364689, -1.165376823095495, 0.7854414340390709, -1.188582850501772, -1.203328001880039, 0.4423374557065218, -0.39462293865821196, 0.23115711144508075, 0.484057754141252, 0.6399231849078768, 0.5032096168881989, -1.8680211918713232, 0.6944065495192442, -1.2459816025473578, 1.4003937719119066, -0.8880547269529265, -1.8693026749890596, -0.0763311223085655, 0.24950216115218293, -1.6950261300473095, 0.36690229114069467, 0.5593645635001075, 0.09600536274728257, 0.16444747941638402, -0.4695676728952195, 1.586185712563006, -0.38268903826006034, -1.2791730003192383, -1.6076480409141958, -0.7597539392576335, -0.3957463512238596, -0.39879611891081196, -0.513777699567238},
    {-0.2377738124485405, -2.118049615829509, -1.4132265426077055, -1.3623972831402844, -2.6405067394931847, -1.5568782273701314, 1.2257801116133202, -0.02000266045860288, 2.7003153672139213, -0.31940523108396934, 0.6443726960828081, 0.7505758649494843, 2.2279414589506197, 0.19602290548558557, -0.2066151939597864, -1.4008086823550177, -0.37040197348443255, -2.37444939131306, -0.7681016401709612, 1.315984114457569, -0.4797398593827421, 1.4790681151940082, -0.5163840755860325, -1.5477355027660136, 0.538124661316662, -0.9564465423482816, -0.8877726181866263, -2.5348711592127695, -0.9280570238799228, -1.441954497880384, -0.11280554016472676, 0.17511008332667324, -0.7709773398001396, -0.6023851214142208, 0.9452532766465606, -0.40455818717896674, -1.5399469032940856, -0.28227577634174417, -0.5688840213032295, -0.2965324093013483, 0.7580831554481486, 1.4209510537596146, -0.22160897990414496, -1.7454623791778867, -0.10373347852441588, 0.08654141755228742, -0.4477814391131735, 0.8864027111559583, -0.04240412366303938, 0.8927200111173241, -0.4632278544920497, 0.8291386808107666, -0.5334981456311985, -1.1080212986187927, -0.5974430037015396, 1.0032508569255463, -0.41106638694687664, 0.0398580242793641, 0.44718429451531244, 2.819866301335027, 1.2742901234821453, 0.5095115507981652, -1.6917952260077669, 2.3563757305619224},
    {-0.9308185058731319, -1.03869048237954, 0.11355626325665129, 0.6946037080585299, 1.3277615869112072, -1.3092278767436385, -0.9545559401756923, -0.670972356062689, 0.20008691665856587, -0.6044462119476873, 1.0906634277110214, 0.9586644099231174, -0.8093659621066669, 2.0402678259739155, 0.6559706405186496, -0.19558409038051655, 1.254504420901869, -0.08566151022252383, 0.016533406063183827, 0.007024666287834402, -0.27460758870530155, 0.8403235939138732, 0.8252996760697121, -1.0910065911327604, 1.3391089742373197, -0.3704807061867026, -0.6530586946906732, -0.5336296119365245, -0.9271355093310591, -2.1771214652629696, -2.2235281296643974, 0.040716831034351364, 0.08054933101592023, 1.50856135973861, 2.5347238423790173, 0.4377749273202591, -1.344504485495959, 0.8540398483260222, 0.8866260242676303, 0.15927943394369623, 1.2692772585287746, -1.1419192536451164, 1.8540304847618252, -0.4323064055495527, -1.4756772540839396, 0.5839990287991926, 2.256402023516742, -0.10349387134262486, 1.637532038249649, 1.1410041769826416, -0.8157931426963709, 0.5647774542783072, -1.1460124545321415, 0.11840911321071514, 1.5639390301045135, 0.13781769767292068, -1.3439871577131017, -0.35285988017732767, 1.255955173602843, 0.8852626898269162, 0.8115092670691033, 1.3526151919206373, 1.7105684351215478, 1.2774813653125212},
    {2.1060376709757187, 0.03724217603339125, 1.9366143977862678, -0.8968795612922734, 0.23227029718732, -0.27835579248025133, 0.6843321660428652, -0.018868497919197095, 0.8197315787160335, 0.31849452787230437, -2.1834304016939434, 1.8551002139618784, -2.026435345731594, 0.6024550416173009, 0.8878567717805376, 0.35429920325446046, 0.20060455760352458, -1.2577618916114766, -0.04861135969490507, 0.5841896769012218, -0.37643907509532437, 1.3990739130486811, -0.4143250025262545, 0.9709743915443877, -0.3926669412748456, -0.5775026873558311, -2.4217852899809444, 2.117992012572194, -0.05953310142349646, -0.9849054204747647, -0.29591361643691283, -0.009833728541308958, -1.4842534118344712, -1.1618655003520924, 1.5023072112923235, 0.33366221401724727, -1.328515561189253, 0.21072842543827142, -0.7262187995356234, -0.7119650985278788, -2.277872651810372, -0.43969098809697177, -0.503182010776348, 0.8261353650150043, 1.942429734613122, 0.2195299776204281, 0.739391513036688, -0.16700340381287082, 0.8088017482650994, -1.4172339435709713, 0.20350083345792272, -1.04931989807906, -3.3048152737859895, 1.9915660201529808, 1.2457240416143454, 1.6344094268701639, -2.0286558493061313, -0.6638249995403214, -0.8986636441034695, -0.9088523252157986, -0.5447280078001931, -0.9217124619255926, -1.2037721536070047, -0.29277570469088315},
    {-0.2564561429183391, 0.816761284918534, -0.029057166818481774, -1.3120736241438493, 2.0997491094647205, -1.0744463624899399, 0.9326620736721931, 0.1196688390847735, -1.6701196539624819, 0.6111211665425035, -0.6468477264152629, -1.1882156253470608, -0.7142113845698177, -1.316097992779073, 0.38043088197703695, 0.8011038828080067, 0.45814024082449095, -0.030435097336295895, -1.6916422965565177, 0.3145476214335317, -1.766303973116722, 1.5692431727952105, -0.13237032308918262, -0.11850839881278631, 1.5944284604629377, 0.09888385261550056, 2.156964827778868, -2.8688930583161256, 2.5349286277343124, -1.378376942713463, -0.24773012602039862, -0.9278259996237052, -0.974862459954099, 1.2008682373086625, 0.036323325186272605, 1.1493494164719942, 1.4912597899555766, 0.6940993390505901, -0.8078555137705761, -1.8711170351838349, -0.44536037399141176, -0.5523164332480293, -0.6999606345853278, -0.5315283901954369, -1.2162798397138226, -0.6321792639217413, -0.16121043274778796, 1.0797710905983577, -0.13402819558534057, -0.5916007027977986, -0.053606017052753474, -1.0347283406165042, 0.18814198257515902, -0.8724286274840104, 2.60238510307215, 3.009527675938928, -0.7826731428069716, 0.6813102699528237, -1.2183851470083091, -1.5657949701362366, -1.5094083644093035, 1.2365286862407763, -0.35821952153304026, -0.13012552034068617},
    {-2.455593656973875, -0.6908723738662698, -1.0510367613594775, -1.9656994348746393, 0.3100525056079451, -0.7606938368242092, 0.5257020767763858, -1.0586840500356502, 0.2800388271863046, 0.7967963115448403, 0.1474652619990141, 1.6812616455119187, -0.8843049319511782, -0.7647365531957431, -2.1254335329410066, -0.14785175161880157, -1.6435802122460548, 0.5364375821190764, -2.024234596146337, -1.2194687818517445, 2.5388292495553793, 1.359323029053676, 0.32921648325709224, 0.9623536192614222, 0.8619457169937926, -1.7372070665219037, -0.05651867037042842, -1.2596444510179237, 0.2590255569355121, 0.40332260059696917, -0.12309895615293018, 0.14704023989587933, -3.3262911105301503, -0.10693343194091527, 0.041077565835309124, -0.7040951812193672, -0.44458037110132265, 0.185428839913837, 0.22446532687497625, -2.3662315346188127, -0.29385024226046463, -1.2142232352760696, -0.30230653746451314, -2.586470949437161, 0.7213572563847722, -2.08827873879702, -1.767879511696674, 0.5177411161431723, -1.3069798833390642, -2.1206032672531423, 0.15397097080187808, -2.4969694943489267, 0.5714211315828018, 0.8576621560806186, -1.1873899084840207, -0.493572257593992, -2.699883472175691, 1.034695929525844, 0.36898421092598993, -0.9469005369906779, 0.141348920613469, 0.13368159495765441, -0.5619899555021096, 0.8089159220558179},
    {-0.4780583158936914, -0.6135686893226303, 2.1993998501954066, -1.0849404188210228, -0.7181510938489808, -1.6339293414800435, -0.1293343463799828, -0.5700238115738163, 0.7794240358208745, 0.7663310512008698, 1.8484679400374808, 1.2900511201865263, -0.1686637721940549, 0.9071211764709165, 0.874470899645446, -0.1472833113473227, 0.5684128393368861, 0.19934763759195773, 0.5965115791002856, -1.4794983597092257, -0.6635863878479831, 1.8189679054882033, -0.6940334725598094, -0.4286057280286135, -1.7433827171051228, -1.6370390664499035, -2.0974006420012676, 0.15980566725125753, -0.6189258884166638, -0.7349129303879829, 1.225724146465207, 1.0955722611857603, -1.1054230121297481, 1.3487961047608863, 0.21513228054629227, -0.21570729834489294, 2.3608614840314903, -0.1000495446679208, 0.003695826821356693, -0.31810386326257023, -1.9355195026642873, 1.3233363626617065, 0.0120816263489651, -0.8041608514520989, -0.8761639252228737, 0.9186106749685926, 0.3882073543114792, 0.42879438960321503, -3.0557055127569583, -0.4225401041787543, 1.9956562275289116, -1.4767121478622178, 0.9484378858483445, 2.1307296120240955, 1.0824366912154006, -1.1923594582112345, -1.4660448789199678, -3.0715947202207246, -0.4431193311220955, 0.3700468866399517, -3.4483617406116736, 0.21248494029130163, -0.1543643080850032, 1.7260506711621808},
    {-0.8905474961795113, -0.6864701286697077, -0.022770502005708966, -1.2319601951298185, -1.870953634435316, -0.7438673815569947, 0.7477657600202334, -1.43223797669845, 0.9379359558808574, 0.3421278076763778, -1.5332142252934997, -0.6014478172585019, -1.4192854832571897, 0.11152260303720674, -2.520372938467474, -0.4892031712433788, -1.9657271058956074, -1.1247810493899986, -0.6762295442449434, 0.13898830564194825, 0.2080322189981693, 0.6731962538965156, 0.5276133473676119, -0.724070732711103, 0.6376591237148933, -1.772564496570505, -0.9821184494857569, 0.0669314850618399, 0.8387057379494921, 0.8006491049602333, -2.377711217359536, 1.1919067779791601, -1.9280357456069683, -1.1794849682453938, 0.9158418119484437, 1.1745749240421661, 1.2315954379795244, 1.3221918441445082, 1.2938838222182203, -2.4296786598473195, 1.4170279351080182, 0.6562021846301166, -1.755798994053041, -0.17463524508275072, -1.7288670993800812, 0.30064159057411, 0.925585627875888, -0.4613910453263003, -0.0018022466039492677, 1.3016613806755624, 0.8899954598608258, -0.5270251089524373, -0.4897614478307505, 0.9894182232758287, 1.0886730461665775, 0.9279593633847493, -1.1899246352368058, -3.327026691259719, 0.14741858088663004, -1.4409452108912713, -1.5700782759599816, 0.0818963038041528, 0.5123289302397147, 0.15498116992029753},
    {-0.3997262810623045, -1.0111215659920103, -0.006583122986109986, -0.3011979632213301, 0.742355280098147, 0.39108022353956995, 2.717585496815563, 0.8349496628607693, -0.21614316349081106, -1.364113188526329, -1.0087164926753729, 0.5518458201316823, 0.4538285098677625, 0.7619124803888392, 0.38288452909164156, 1.9386388274354454, 1.1697179484922198, -0.9745823978408511, -1.8417059874178392, -0.12732069439590413, -1.8222013925602982, -0.5838614004712638, -1.9938950965278845, -0.44672115734440737, -0.6163288365407712, 0.20059732864388238, -2.1765728712933967, -1.3017587108775897, -1.421497602691434, -1.0755105708693464, 0.3283630320056906, -1.08998425727243, -0.3903612917629706, 1.767552751483302, -0.06220389923176244, 0.9935234421185821, -1.758276218551044, 0.6034070619593579, 1.0684367292004378, -2.6704479698788015, -1.5441960144213087, 1.5372748857757736, -0.8833949440658727, 0.28433305412814047, 0.30033699686429033, 0.32316405123113584, -1.895551991017702, -0.7210226408903344, -1.9012619938227402, -0.8235995318359949, 1.4899171176595476, -2.267819121895384, -0.15043593652110723, 0.6987692449080148, 0.32964218869126677, 1.6960626484364445, 1.010327879085788, -0.18290693971679542, -1.8456109029491792, -0.1377821275259793, -2.781194000547992, -1.5398444867928844, 0.2088914734559513, 1.4781103136279785},
    {-0.47449044266242607, -1.2059526636586888, -1.623797845946627, -1.5203614668051844, -0.7991106513303221, -0.2087312787063394, 1.346697299159901, -0.8250826652600369, -2.183413960439412, -0.8304099158208188, 2.1278160863353883, 1.452001249152935, -2.321578006840067, 1.2842944677782049, -0.3617747944792392, -0.08716467875883245, -1.7468605761888878, 0.18960081262169143, -0.5215325849995818, -1.556142537192589, 0.4794143264049057, -0.4551923976535242, -0.37350911896482397, -0.13639812349232716, -0.18819008965394685, -0.09141405323990548, 1.1059390401158442, -0.03130261592797855, 0.19687031803538527, 0.243532164365553, -0.4885571839072608, -1.5267696305915253, 0.6317715976758146, 0.2119784402054353, 0.8743523429471505, 0.03374772447953703, -0.12543276519327562, -0.1983676306001925, 0.9131111678891762, -2.3925630622580973, -1.8020403384591501, 1.6004360543103533, -0.5071664693625436, -2.49796322510249, 0.7288019655850144, 0.6835475356913537, 1.486220167111223, 0.3871146185522163, 1.5160259639657432, -0.7036267016844155, -2.5936551642018157, 0.2548400619821622, -1.2147401068676487, -0.33373783529041157, 0.3422952847785549, 0.5218482951719341, -1.9630642556829805, 0.8916198662220182, -1.6448071403476572, -1.473841264655656, -2.2708856612395474, -1.4237304222493339, -0.9244819046943282, 1.4448005943597397},
    {-0.9062669219850849, -0.48740305545716645, 1.7038470027808446, 0.12997517051248222, -1.508931032600204, -2.7796302055811455, 1.9770483730060526, 2.428955691554563, 0.43216226191923185, -0.4883605002611589, -0.9743475371374919, 1.394796905613084, 0.07000989295282048, 1.333314198163336, -0.45257340150018166, 2.396382612380673, 0.08267830149393099, -1.0845656173991014, -1.9422944374400017, 0.7492477542462369, 0.4116080777608278, 1.4571121508077596, 1.4018744611027005, -0.5170050027585029, -1.4475882449179878, -1.9367732183220403, -0.36537697223620597, -0.12311247140981678, 0.9683250795795042, 1.6027435998017963, 0.24107585817773503, 0.8846974399103624, -0.8254198769997594, 0.3439487991711534, -0.2777339099548908, -1.2934568158110573, -0.6709543301567976, 1.557641285328532, 0.1332990364723557, -0.5551720651518439, 1.0397702371456097, 1.5590318231838933, 0.7566256620563627, -1.3282124356369074, 0.5756039515287968, -0.28922993156760424, 0.4618448199975245, -0.16256239721081672, -0.32817768979296574, 0.42500673095486335, 1.024280505336554, -1.853859888030729, -0.6462035876244016, 1.2377035896485917, 1.2369748885996166, 1.2266910980981351, -2.0501315341455366, 0.223488195818373, 0.5848288038894528, 0.9926305116719407, -2.1514013293109433, 0.45420855895090384, 2.099452823100737, 1.648397258729184},
    {-0.14336608364941641, -1.2251538322858904, -1.794201873178676, 0.10177658188869478, -1.4175050476259017, -1.456447403105869, 0.7934819269704949, 1.9499373757154954, -1.1509884875250576, -2.308010081847568, 1.1896123638469565, 0.25919742402481916, 1.175039608409887, 2.2193519485208353, 0.7623462580141377, 1.6118863179352063, -0.9683221608476364, -0.7124536164267303, -0.841827315133787, -0.5208273921635707, 1.7041296736200742, -0.9479939489725493, -0.8604986144281283, -1.4536963708069406, -0.6847177273424248, -2.905519843198171, -0.3362390396539812, -0.4774465803879556, 0.7810865257385919, -0.4326474974747687, -1.324288711934132, 2.9368530314840844, 1.9396281596585065, 1.327096900994964, -0.5075433542733699, -0.7096784118349277, 0.9913310503702484, -0.21952893975318669, -0.18286559142853448, -0.7374115131640167, 1.0756768520314053, 2.062143106580632, -0.26969651664939237, -0.418385548794389, -2.710489075842048, -0.3054427194678392, -0.6624741615355444, 0.2136852428330297, 0.031044322076538584, -1.109183148946694, 0.11879607691287862, -0.6578511637366349, 0.7017956073953792, 2.001737365442099, 0.9093167248156739, 1.8012817275306747, -0.2796034146509532, -0.030264241593099234, -3.014416597495254, -1.2332556634423557, -0.3196541659322889, -0.8266666824821775, 0.9968664668464207, 0.8415411127913099},
    {-0.6418892735280611, -1.3742983154558102, 1.3879176414090286, -1.6940174581690777, -1.457258389293173, 0.2510044911355519, 0.658118004634825, -1.6308561990847559, -0.9957983584072587, -0.06296497748058778, -1.0581236853703966, 0.6585198534973857, -0.2148635900172737, 1.4880469577185875, -0.2956386423781542, 1.118996190776265, 0.9613845232347075, -0.9804655747132264, -1.2254586739064333, -0.4863537864286079, -0.6431719799722463, -0.8103893138930941, -1.0887709643754766, 0.649584514807352, -0.38684590499477084, 0.16542783702905864, -3.2105267910616684, 0.9990292583206835, -0.7223326675802324, 0.17605057970005605, 0.12820533206692641, 2.0258961686250387, -1.7271874068319333, 0.977518359215246, -2.138696445673463, -0.6190571830543289, -0.848920192095084, 0.9126550149344533, -1.203869320548175, -1.166451168479572, -0.029386174464774154, -0.7158412340004903, 0.15192683373864146, 0.80872290155194, -0.30803221549598225, 0.1724559365457644, -0.6563525427971515, -1.2114804330916606, -0.8389924932933517, -0.3068901684053329, -1.3409728009521136, -0.679758293082846, -1.4771562009468684, 0.11690268156097344, -2.262855850600979, -0.18517075849215928, -1.8095587325275708, -1.4430329833795474, 0.9457449913300123, -0.565283025746337, -2.537678149897396, 0.8202619725086632, -0.8844962137751848, -2.7403272368452787},
    {-0.22516963896724837, 0.5258219596805707, -0.2870025704725908, -0.9382400724250166, -2.0510286784114538, 0.09594358526102911, -0.40437293314904393, 0.16889590305134325, -1.289763657313976, 1.2809132845977353, -0.3416802037427211, 0.7210873248127613, -0.002388156854086057, 0.20326023673261961, -1.0070497265788914, 0.79522184486104, 0.56426695797516, -0.7969896482027957, -1.1346437571202117, -0.13040838276969854, 0.14979986901342102, 1.1477477210158404, -0.5108587822106085, 0.7999672164633481, -1.168469253809309, -0.4534745342051773, 1.0892460691657435, 0.5176836025040126, -0.2866861408104185, 0.8231367266860208, -0.4354583312938757, -0.42282978698385715, -1.379233328231457, -0.6765269484656935, -1.737396892281345, 0.7788389280703671, 0.3185238236572252, 0.2769192151753655, -2.3925366361276237, 0.1487067827311803, -3.131219195282191, -1.2095052704288727, -3.3720374937083943, -0.32000359487950053, -0.2745003272934718, 0.7433893397434158, -0.8929238626745605, -3.134747027528562, 0.3810551996512471, -1.7311574425126126, 0.8312080904641244, -1.9281782378635526, -0.10597646440506905, 1.920663660377069, -1.924182356564835, -1.481767884025896, -0.4808521736978481, -1.4849052135390068, -1.8768938144048706, -0.45240078060578615, -1.7219773269777563, 0.19563309657622227, -1.6948258533923992, -0.3150972245001582},
    {0.7621908211338299, 0.14738171358140395, -0.042981813248527685, 1.4508236716570768, -0.6533504532458156, 0.43669359343588626, 0.02195333204457905, -1.5519994075650192, -0.3155618225466761, 0.713687162090891, 0.26262789436995565, -0.17813390824294775, -0.9165404001398584, -0.308207832737503, -2.2462135223819275, -0.34104208679464204, 1.0043206609097715, -0.5559963443243544, -0.25063513057657344, 2.019362975125402, 0.9659904206033525, 0.02755338263937083, -0.24583908809287622, 0.0793577558074993, -2.4859908545656295, 2.3523632782798765, 1.4423230592272922, 0.5755404708825324, -1.9359189497039582, -0.30300168388628373, -1.8303147678984506, -0.14639458996601337, -1.3881372723972307, 0.01943472544962574, -1.0442294886919075, -0.5612334906113859, 1.075577732465164, 1.4336498607720185, -0.775893644089884, -0.4377774696067677, -0.6035279381801878, 0.5586860324987127, -0.16488545933381515, 1.1514224718074606, 0.5213745046550738, -0.27736011443148206, -2.399956892906597, -0.36192558840169803, -0.69458568268135, -0.10537960607852555, -0.4743822587577736, -0.07081438871830432, 0.09071460415918609, 0.05441479444706228, 1.184092239483848, -1.2103971740752113, -1.4446197573631452, -1.5400734196318757, 0.2606799980820397, -2.219952675992939, -1.6948637637949793, -0.9670139880307171, 1.3951199559637422, 0.30283160949758764},
    {0.565873760342464, 0.20972545092920478, -0.6011584151758343, -1.3736662483513047, -1.3894378656763222, -0.0705707757016369, 0.9753818545815311, -0.17487771334998722, -0.48004962516153654, 0.6305606679309911, -3.405072112550243, -3.231613630511329, 0.029659046035615536, 0.5077246336078021, -1.897865799517407, -2.421081588742243, -0.20793199810724428, 0.6687895292040447, -0.9428023705359743, -0.8481833751249577, -0.6110464243499037, 0.5327269573245613, -2.309169994388975, 1.259564791103256, -1.7304346006982352, -1.4522194133038704, 1.32531990546863, 0.5787396681290716, -1.576484927091442, 0.7696902501628985, -1.3386663331066917, -0.5417083382039405, -0.7520405638758064, -0.05708820798893472, -0.0022090317057501165, 1.9346867342794387, 1.4985106447749776, 0.5878471723781422, -1.894219214708381, 0.5554759066134308, -0.5301980587767657, 0.1893157978578784, -0.5389763205101759, -1.3921212162708982, -0.39028194208441747, 0.5314830781873804, -2.459208974830227, 0.9243604837007809, -1.8265108987301817, 0.2795473947335931, -0.0032032596719456232, 1.4545769860485611, -0.16488319677837426, 0.8379105355737887, 0.6220527386448347, 0.9005692952846237, -0.7151346131991967, 1.269835625295258, -1.6270576513757296, 0.44034226247678543, 0.6672882925590635, -1.3337760488131853, -0.9466428059634754, -0.3382008213788358},
    {0.20053211884791383, 0.4427383370779128, -0.21599809888164542, -1.6501108899224268, 2.4584821968644386, -1.9697600743943218, -0.31685368987276297, -0.2682576998925297, -1.5856880958822626, -0.3970778691939703, -1.0306292685865708, 0.12439478168268055, -2.232462874070596, -0.5188404871226793, -1.295239825419957, 1.9079642559332761, -0.14959140136292612, -1.1307652317512367, -1.191323791393186, 0.008765627021946677, -0.47431027896507455, -0.5817603167023415, 0.21596910509603223, 1.4525207876743353, -0.33723720304518795, 0.4776793912455815, 0.2619611512103236, 0.7111318318112557, 0.90176460798277, 2.946883340438436, -0.5044669035217223, 0.783695057616318, 0.42690749446454035, -0.05541568944176073, 2.3247859495431364, -0.03091414818813071, -0.35835523826309046, 0.7283766540020872, 0.04445424966720353, 0.1856676240923259, -0.9108076846496643, 1.9682620396217634, -1.8555957934320055, -0.31430991207149994, -1.172761403318679, 0.42821290927339395, 2.485515150265423, -2.8226316170967496, -0.7838738078826755, -0.6356015591712663, -0.8587971169499502, 1.704062532483595, -0.3546623118571473, -0.03229375408681816, 0.8300894308465802, -0.6163933334822109, 1.5310678441637293, 0.8972484450531012, -0.02565564303931064, 1.0248984621817812, -1.2545945736373205, 0.007964919272114237, 1.2975606089188398, -0.6110331269680696},
    {1.103680467956912, -0.2984292916622373, -0.526746933844362, -0.04301214448242852, -0.5457776672250582, 0.27136534595331313, 0.9116522746047385, 2.876060866995651, 0.10459093566775386, -1.7852165335221704, 2.499830206508597, -1.2369508467899748, 2.041160415827389, -1.1615325506553884, -0.6308249908035458, 2.1109444365457066, -0.6491097576176315, -1.6529808585999102, 3.02968553122604, -0.46831075651696197, -0.9488161639343865, -0.1544875003121773, 1.6300406082732035, -0.2636348489588284, -0.48024417843012734, 3.1007618671201453, 0.24731578878572696, 0.0800204047966621, -0.08478311120024547, 0.13905447869073045, 1.075362413949648, 0.9804075308494957, -0.3872264442466897, -0.8392476416149879, -2.090699498287422, -0.24582597685877353, -1.6064467014665234, 0.39199447153878386, -0.1536151461749938, 0.9945986721535132, 1.3955069731777774, -0.8296672359779075, -0.5840325426022708, -1.0637820977875037, 1.3610692466781225, -0.038833343713663704, -1.0391941660958117, -0.6022784449126519, -0.3741800553815105, -1.990215666958497, -0.4592546262931941, 0.6912968638999816, 2.4167884754123796, -0.5234829016915782, 0.29011096686282317, -0.462085157863565, 1.560516825744961, 1.1375556810536276, 0.19518033570500007, 1.794241337894684, -2.2372335450595098, 0.8597151837441733, -1.4517560447804108, 0.7366442024803072},
    {0.007395456330093148, 0.24482479981630434, 0.4807135558744867, -1.9548088997749153, 0.8265261376623969, -0.9332610043698402, 1.2846948365635884, 1.5561622611608772, -0.47948858527090743, -0.31677215033513906, -0.9131236621522308, 0.6392325911115964, 1.3874431528883437, 0.46106021486202864, -1.963183307891747, -1.246859378986793, 1.1764091891235637, 1.5095064875425357, -0.002820524118221291, 1.9729888367916273, -1.0241242113190794, -0.9329691700518562, 1.2260761198438799, 0.08785683826867137, -1.9331053216522254, 0.2451674060710916, -0.8520803898808089, 0.3660132068458139, -0.8153660374616178, 0.05483703050914993, -1.6010624993620821, 0.629701436324169, -0.19768000156541674, 1.220344972260813, 1.0479760466981194, 0.8651197915932828, 0.5661224437608722, 1.1085284100729385, 1.0724665466732084, 1.786929931876539, -0.37830901525709043, 0.13075569590272626, 0.12296457020936245, 0.5957426381809225, 1.88038692833928, -0.647066917112958, 0.1553577473985257, 1.444051605978252, 0.4819038376971888, 0.39212629497763146, 0.8753130433249737, 2.2107525900091693, -0.8171305972884882, 1.860564467418176, -0.07692691670422927, 1.3124082351976676, -0.18652390824293935, 0.6744289142503312, -0.8177800093785239, 0.11296457000232664, -1.9571837610552072, -1.4355009916104344, 1.0866588560592005, 1.509926741325547},
    {2.489247737682602, -2.008027428754319, 2.0360682820191154, 0.11810411015782038, 1.2815497583713387, 0.1688231803316236, -2.7311126460662694, -0.1822879304532407, -0.982106163405197, 3.3146960931002405, -1.24303981897828, -0.6279402558811041, -0.8033497777494645, 0.8662314364083131, -0.444095982865866, 0.6964289426049921, 1.8198084436354949, 0.4665004741514658, -1.0855133117725329, -2.3520519322795392, 0.2538656387608056, -0.4251441561273572, 2.0025048926046796, 2.459006899322561, -1.2328619474165075, -0.6985988605396519, -0.16516236532656392, -0.4685901762743825, -3.228338944821947, 0.8474102326474577, 0.7711076540915003, 0.11876213174413608, 1.345772696676176, 0.41590562944662013, 0.015026440604997263, 1.1080221941462611, 0.3548215917122682, 0.8532163115906762, -0.13658966476867135, -1.0876826875084045, -0.03545745087971045, 0.6213360500188664, 1.0379134983704965, -0.20112580196880003, 0.8456268351281361, 0.4342612528261287, -1.1627893260176698, 0.7445239284821487, -0.0437197292818358, -0.37812667632335784, 0.5332081002986998, 1.264000325608992, 0.020008069578474792, -0.16542228316968935, 1.7567428322971477, 0.09554676629709463, 0.029728353946988535, 0.8000041571913813, -1.3708405972226656, 0.6917235178985383, -0.8285590365081426, -1.0494339529479737, 1.0121096399996732, -0.1817279253834873},
    {-2.078336857571246, 1.0506324982043491, -0.6384045854829544, 1.0846173014535232, 0.6598219023925839, 0.974392124529211, -2.281535931838746, -0.6414256878672946, -1.403321798086703, 1.8612599145191604, -1.4312145429033374, 0.3431257734127081, 0.4115542604716691, 1.689215980475939, 0.5759328323710234, 1.8356677894247517, 1.647684432990311, 0.1514542638103774, -0.3561331962196863, -0.2540912879080715, -2.2754142354443343, 0.35497576731731434, 0.9184437225649534, -0.6302530143558192, -0.7095367384720803, 0.6058665527076792, -0.3885255250240858, -1.5671040616374334, -1.7925780170481487, -0.2890529566983721, 1.152405534934498, 1.621150597254077, -0.6449925991094371, 0.7866124908848364, 0.664705534038703, -1.3555575058332499, 1.2423628704156562, -0.9006883939302456, 0.04031413089927661, -2.4146567687271, -1.2689493422592824, -1.6654365900955612, -0.39699100796228437, 0.22769921843453148, -1.552321514713394, -0.6744636219683365, -0.2515076368584389, -0.5010749294571645, -1.083635052330694, -1.293374856966473, 0.5577390602690242, 0.5980233341883298, -1.4940268082660657, 0.03835937001021952, -1.0733051824419586, 0.7749958729239252, 0.6105218522651936, 0.8432166928804993, -1.2101573624539073, -0.32392845556135486, -2.5253855942185095, -2.1106243297815466, -0.2537929882277668, -2.004985030934007},
    {0.9384200946306844, 1.7859482790973935, -0.8102933040601394, -0.7931651275112122, 0.4314883092493098, -0.5230204920619836, -2.5082238185937396, 0.7097348614097663, -1.2067193560323204, 1.0591103132183202, -0.7262551607257038, -2.0138250986230464, -0.6689491872307319, -0.37040747255363876, -2.6748940514024673, 1.2426671780703298, 0.16720352934819152, 0.16492307933412012, 0.36946859785553327, -0.449952747085738, -1.1317058014743782, -0.35593187152719913, 0.5891718763605293, 2.6053901052998785, -0.02132158056986916, 0.3892497118909095, 0.40689276949303077, -0.15126307635202138, -1.136073394710314, 3.1910775433432463, 1.9029495633900875, 0.6409385893021938, -1.210028055621957, -1.9703957835848738, 0.8122340301817784, -0.2242158537506878, 0.518213347992558, -1.4354657206045172, 0.24135351642179123, -0.21840395517507208, -0.5999950316060044, -0.18366561087662767, -0.6562666030737662, -1.9211399327669731, -1.4509542996974103, -1.858010783854043, -1.2831145197316394, -1.1061629391770094, 0.590330062681137, -0.22601980955941914, -0.6148215152501542, 0.7471459448423194, -0.3951244020797891, -0.7016824569445181, 1.5444434016117745, 1.4378232612806634, 0.14609261734124449, -1.2912995979388509, 1.837012009726683, 1.1865889602648096, -0.15150582462847434, -0.9800794276164476, 0.02498382992137652, -0.3762993550060607},
    {2.7440598162877587, 0.3271076516386626, 0.9455070771294589, -0.9800738248286247, 0.6773323002506657, 0.31138215237920824, 1.0978769529022183, -0.3692628692381487, 1.3718793060421268, -0.35437620444387297, -1.161942090287288, -1.180002291210799, -0.59652543861196, -1.1425191317541086, 0.78939817557455, 0.604121039903661, -0.8470086059558196, 0.19002548158481608, -1.392937527880483, -1.8271330315094403, 0.29528409548106543, 0.4736663048082658, -1.4117608431630866, 0.6132529564832505, 2.2217270962406346, -1.1354053443218353, -1.1517253435005586, -0.16288491665955454, 0.6830665530232521, 2.9430595560714004, 0.08052902478175007, 1.147542782004579, -0.24909546013082814, -0.12478145433358924, 0.5357092392954391, 0.35683697599305597, -1.5375471995974501, -3.1581091922801994, -0.7281702680531178, -0.012150050839793418, 0.5371878034511244, 0.8675019798652185, -0.07211835712904126, -0.0684753229600616, 1.4048855124985071, 0.9819266216073811, 0.04735845295788685, 0.2977167933819637, 2.4788974924132896, 0.8241240313540322, 1.5290644913898999, -0.48052897539389733, -0.5953174549411393, -0.1003428312644502, 1.4860151801114116, 1.4184978237709358, 0.7283683695290709, -0.21229518234009254, -2.4332624468234205, -2.145124892568565, 1.66084103689994, -0.7519359355983349, 2.1322354422803116, 1.1626815747006092},
    {0.8451676925072708, -1.5004772872344574, -0.5543295082963466, -1.3520816027002531, -0.5017217744093795, -0.06834572993953769, -1.008409200637574, -1.5497078890418816, -0.9905801994835876, -0.24508675012492104, -1.8443529542198605, 1.3803580511863323, 0.391041247538788, -1.2492414018598506, -0.43981756025355534, -1.0633300592784634, -0.3672481293684813, 0.41747147046791666, 1.06636412302529, -0.6194718914443547, -1.6830255227794226, -1.1222090072787112, 0.9130965915406636, 0.5449670710829434, 2.614316510502543, -0.6297902972219291, 1.7002051581990663, -0.00969476322475895, 0.8734200264560422, -0.3262706314410635, -1.466058228520788, -0.15700049945402478, -2.692805342432513, -0.4153470935821533, 0.6630052686037892, -1.5387175193111207, -0.24912660996297611, -2.0398850635731156, 1.5181196988703147, 0.74620000906436, 0.5769843147778766, 2.2771297735399703, 1.2306902981815924, 1.4508774756271197, -0.8229283006897523, -0.6275015394972345, -1.268731050786779, -0.8055038392463593, -0.8250713685172812, 1.0542776640056437, -0.43251255787651044, -0.42915652176834895, 0.7325438266332178, -1.1719131043537592, -0.5487823671843277, -0.486486450876067, -1.1410724657670956, 0.485265722776828, -0.5822544851802343, -0.7355998992583197, -0.6581074737790142, 1.3616487254817309, 1.0850645447533454, -0.46662538053112623},
    {-0.8372165993748002, -0.6936255445356081, 2.7331673911190952, 1.0564936017999758, -0.6400891644492429, -1.1137471653672808, 0.15160565532800185, 1.3640350531546028, -0.20147990422875078, -0.3623831643026494, -0.23638727511572882, 1.1099373035764697, 1.4979728852864296, 0.21046547250473088, -1.0440104675958817, -0.48903489118353616, 0.10907621063730776, 0.012809830112605506, -0.8442491095266423, -2.012932953212161, 0.3603777674557935, 1.4191267288293128, 0.051810819445021104, -0.7751871739317533, -0.17938027945778917, -0.8534247916329772, 0.8020192498295368, 0.5759443801550563, 0.13112830519224197, 0.276138957991706, 0.8400006349782332, 0.6037028374937657, 0.8710976240754537, 0.02884980324676995, 1.496848279058935, 1.711770284811186, -0.9588366436169407, 0.31455126279098256, -1.2484944288420086, -0.5495668134236439, -1.2949889493073778, -0.6341295527023499, -2.4955575189469, 1.4511251883908063, -1.7846516848972058, 0.4683690823551863, -0.6729769912714637, 0.34634546339571465, 0.4196081014305778, 0.8493457711696472, 0.08432861356230777, -1.671637039378562, 1.1176210274173113, -1.0229486633896234, 2.4320544495556735, 0.5518897892281784, 0.27589439795481296, 0.27767373098223846, -2.2779330783539775, -1.2812334489349322, 0.48669136805451074, 0.16520128729321232, -0.4054885300477907, 0.18305852241935777},
    {0.26520479056328816, -0.48312071682121954, 1.614842944436243, -0.627713600472179, 1.4729325463316831, 0.7177105828989524, 0.4653984037851831, 0.89687478612126, -0.2772007007073456, -0.3669456903480214, -2.657471785325193, -0.5455036194012565, -0.5255764849618226, -0.7072713137440315, 0.4069350528217977, 0.26338279487793076, 1.2996251903636182, 0.18923608491802033, -0.40990764497952364, 0.9875881201026653, 1.9873463795785837, -0.7717030260142802, 0.7530901917308106, 1.6782867737998286, -0.39034530945120793, 0.6339377694182347, -1.9970058657682717, 1.5257502867365886, -0.20077357336999546, 0.4209223208912133, 0.9012268448849093, -2.0675586164944963, 0.50544652444841, 1.0090539054878886, 0.4930325954523482, 0.4134292812014879, 1.2592983538862002, -1.5380679184906523, -0.6624951608790397, 1.1295061411081788, 0.020733628609283888, 1.007151519442428, -0.8780655633156608, -0.14480672577402678, 1.0018603810715174, -0.24818403344986478, 1.4105537061604159, 0.8728135587491511, -0.5999978003666618, -2.481128888476533, -1.3167218660483206, -0.24801119339554997, -0.8594224619665849, 0.7134298311787884, 0.308885797198192, 0.07826722640198908, 0.9748026810379679, -1.2081692737743994, -1.6344605234567984, 0.733191024509949, 0.900529623918559, -0.9442557021616427, -0.34030744808730873, -0.9509282574321433},
    {-0.9244514194714922, -0.5005225539507105, 0.44624924641409414, -0.4082686282124153, -0.47156789231127433, 0.6497470739347228, 1.7697898829550642, -1.727998938121929, -0.9695992184416955, -0.6118073981039844, 1.0817823164705975, 0.13430349051211693, -0.4384107968050135, -0.7133055033307709, -0.17611998148571095, 1.4914373972532546, -0.34589962415127906, -0.7053314363148577, 0.5841137002128644, 1.6128627680859895, -0.2985100494064193, -0.4661276897787784, -1.5203221920919199, -1.1694551401194877, 1.622924004564753, 0.7627248602866661, -0.6177653563758149, -0.8559578083057021, 1.1281748121776092, 0.7778364103464267, -0.6938746170372708, -1.670259594244796, 0.16982283698211587, -1.480260976146931, -1.3086182352489233, -0.10009951441885599, 0.7143311336083448, 1.8772324975522363, -0.5739838232715196, -0.07080902503504374, -0.6841611711019059, 2.073676968582851, 0.6417379709308296, -0.2711387040815468, -0.3365272071016674, -0.46771893812445103, -1.2624933028100078, 0.11123821866820194, 0.5969271373550559, -1.3404610785508058, 0.4513593062103362, 0.9047751092395733, -0.21965233761535174, 0.1492746287383451, 2.3449393376269, -1.1341336393288273, 0.4558133417044855, 0.23842039656510475, -2.8257192089512344, -2.398401930227553, -0.2516773580153921, -0.16049497035746405, 0.7203285626304411, 0.20630760845062351},
    {-0.5661014389292621, -0.5029632178350386, -1.11888080064235, -2.1314300132463555, 0.1636872416058799, -0.17424520839041735, -0.18680311913565342, -0.8618764303627287, -0.8137345667321576, -0.9303812705724939, -0.8888850503891984, -0.2953871727927704, 2.671224261385729, 0.9246132793069827, 0.4107748808628998, -0.23326882112709488, 0.09434904012373724, 0.6540186474604059, -1.2817172080220134, 1.6603831898778947, -0.970336943571188, 0.5303843571692619, 0.12077298444563818, -0.32735863885397465, 1.2439894239918832, 0.41905303301053587, 1.8330507507435274, -0.8770718910092109, -0.2549355887159055, 0.19698538263844934, -0.8634612421937328, -0.18337679541885685, -1.201411941195559, 0.5183216319553196, -1.2165652866654855, -0.8500009851676161, 0.32975171462923686, 0.708814749723103, -0.6432856747257645, 0.31265270724555544, -0.9529891448431494, -0.4936791595510884, 1.239784755859838, 0.021308697715912525, -1.2423865888709231, 0.07206112015844388, 1.1635388651989078, -0.3956175242552666, -1.9030923365152532, -1.3539126725631039, -1.57905181451902, 0.7369832207257536, -0.6588479008390294, 2.172398756671966, 0.6380773829947165, 0.14330888982114362, -1.126182031035047, -0.9235466279337832, 0.09314293915539888, 0.7850941205593056, 0.7983396363324199, -0.9961685795557581, -0.38556783415851903, 1.2831573677104096},
    {-0.214461789826945, -2.6415309167161682, 0.7363032247414139, 1.8197587737066676, -0.7941827552317136, 0.19399895341150333, 0.15676320980972092, -0.2113350811670217, 0.30201807956569665, 0.5406973571148592, 0.5816573894856734, 0.14880245218576063, -1.092262921725877, -0.6933346536336851, -1.7209748062962398, 0.822350390711177, 1.1721350925959046, 0.3570849984126379, -1.2847782948827282, 0.6175408329299065, 1.3291575848163777, 0.18419276194614317, 0.033367587688927405, -0.45840925190826043, -0.5682959805234316, 0.24170526926539182, -1.082357775371056, 1.145393259177635, -1.88060971513763, -0.49691415642434583, 0.6361408750576034, 0.27658299722351193, 1.474554809781828, 0.8149672541334305, 0.6262044478202371, -1.7343963688775241, -1.1370241787285797, -1.9696867252444925, 0.6932147178072491, -0.006996603321965672, 3.866832338826642e-05, 1.6682760971116264, 0.5847858046376254, 0.4770640721655918, -0.07232351060583884, 1.4520592272426318, -0.48284430323740485, 0.7317699292283718, 1.0317262267443235, 1.3472053826990338, -0.12847762826039322, 0.18618966257384897, 1.1452026876859833, -0.31668215539420486, -0.6253088714985658, -0.9782559490201833, -1.0471561687079167, 0.6361877710255319, 0.9414408132367569, -1.4048369471693665, -0.06584730902960312, 1.3238813112983963, 0.026240988062637603, -2.6270650361222954},
    {0.506353081646833, -0.7410393273171512, -0.2589082385445434, 1.6428922318536228, -0.9477074703461659, 0.19813878780251995, -1.794562565046553, -0.3490538498205966, -1.8573470301289017, -0.6318669715998594, 1.6212975778941472, 1.0107737212985692, 0.21504744440521578, -0.4648928553230671, -2.2180443624731323, -2.9180622498371274, 0.08325515721902542, 0.3500514253083765, -0.397499734813045, 0.34958438313255924, -0.14896804908118746, 0.008188751581429397, -1.2305358294219744, 1.516090239009995, -1.6572255064719943, -0.34350851298760715, 0.4775795915933066, 1.3359721055791403, -1.2126696783801956, -1.756740391321422, 0.719152284197898, -2.8614567670886717, -1.0542040697686135, -0.25883046894355255, 0.30907756460057345, -0.5191001827993018, -1.242190554349869, -2.088479570611115, -1.630372011412269, -1.1745905111535693, -0.8297857150109225, -0.34190560554741484, -1.2247527577274635, -0.9649914174650129, 0.4915145897978901, -2.44830477178422, -0.5376237351383223, 1.2491558337687299, 2.578425579192078, 0.8671047130512187, 0.45550054719745975, 1.4020539438593809, 0.36560713862379923, 0.14862938620508645, -2.0424890943618874, 0.204446080369065, 0.35155513770463076, 0.2362612998331131, -0.5172090279851017, -1.2525965169920368, -0.7657019986641527, -1.9879002079617163, 0.04327403221114949, -2.202464811386267},
    {-0.5467449638236223, -0.041897895097145664, -0.7001132630497998, -0.3846471302783118, -2.7032173320908517, -0.6415632233933452, -1.781379189801005, -1.5906792733711697, 0.11383328024503911, 0.4546570345449215, -0.34660063969922855, -0.7778289784923879, 0.7974838038470685, 0.38526379388417953, 0.5008778519553353, -0.08355260115869793, -1.5147994572770622, -1.2348765973227267, -0.564114025996898, 1.8155430657102298, 0.38615268884671067, -1.9737039677619916, 0.9327641552618947, 1.3929315096560728, 2.3898391983964267, -0.03693320724982383, -0.46291973845443135, 0.9828165790281329, -2.386837573647137, -0.2112383745929959, 2.1833331094876507, 0.7408629747443942, -1.9048297065421689, 1.7929522031732843, 1.0130051687681099, -0.2069686728138433, -0.300634776407898, -0.7302784955497001, -0.5825477743832963, 0.4536500094182136, -1.5092855082640448, 0.5572438017231685, -0.037074361408029353, -0.7401251334028129, -0.9974730615828398, 0.24711620634125528, -2.461901404999105, -0.28236660741426794, 1.7805316789648156, 0.4068185368345951, -0.29834192716191515, -0.6454403160023582, -0.7444229861842608, -0.04796223633647081, 0.21394364789811432, 0.12458930840845976, 0.38554306404798894, -0.6038425924221156, -0.9167652681772427, -1.1183938538275118, -0.5063319179055342, -0.44336410896932327, 0.46948653513314015, -0.03190525894528375},
    {-0.97411453536319, -0.17032826438451434, 0.14747046868939898, 0.46303562607925913, -0.8504372851768606, 0.657270667741003, -0.06461202186938465, 0.12126662097891427, -0.09715886696239069, 0.2650272194684172, 0.35885498369117247, -2.059770802240047, 0.7933665835915809, -2.6225883420784037, -0.5578444927671536, 0.5767751616068154, -0.5764110040028801, -0.7750887117325246, -0.8316094090833683, -0.07417382380011302, -0.8073047997172346, -0.3917866911968891, 0.2785303749898592, -1.1452087108179696, 1.544249828268792, -2.041137913991436, 3.7368135266913396, 1.194600227929263, -0.1447684603261316, -0.8381112147616264, -2.18045481414667, 1.2151911175785561, 0.8983822449989297, 1.4559223171838838, -0.37177347953879375, -0.2612896428986705, 0.8456460209105595, -0.6586877313131172, 0.23668986139246975, 2.194963731943844, -1.8741724370920243, -1.3321909659290565, -1.1134163791157743, -1.4695943118793462, 0.5658956004627577, 0.03905829985839531, 1.0431121861609962, 1.1352476470844797, 0.4513653730925233, 2.54658166216121, 0.16392608345227966, -0.3325777838662898, 1.1251247491301626, 1.4372685352806693, 0.0782475099242327, -0.29600797670174056, 2.5505425788276965, -0.8149812409410732, -0.790854802208332, -0.8241627589619872, -0.4956941055206065, 0.7191921144532919, -0.03233102380461592, 0.7613590468882762},
    {1.8901291755201002, -1.3205885576688858, -0.7494710760745567, -0.28297445274209015, -0.4926803552773998, -1.9183170350740824, -0.4064758101476709, -0.7375075542280204, -0.7903563472617032, -0.7646840672536822, 0.294895333472998, -2.382660736750207, 0.5364467197335678, 0.65115315762469, 0.9133471725237965, -0.22999849222265273, -0.7255770520282936, 0.8400555803072205, -0.08390141731166764, 0.7033059698848846, 0.4928618968680656, -2.2815604903601185, 1.181454976777708, 0.023559504460141736, -0.594181518783025, -0.218652535588643, 0.6206077197017092, -0.14155727652289699, 2.2320656383108637, -0.1272710113382254, 0.39685811034937124, 0.21264395295712074, -0.40135582208944626, 0.14228243004603788, -0.5608051180618061, -0.20495252242784245, -1.454908916387443, -0.7515193583023051, 1.7049289207399436, -0.9528679210418992, 1.0642371365962129, 0.6023631407927093, 1.2191658036463284, -2.6457104420702002, -0.16444203535285126, -1.4685746400091206, 1.0849087957681718, -1.488138680577795, -0.014348927521870137, -0.10528111096046634, 0.7441401946524178, -0.709443541254811, 2.7553848193343042, 1.0953353352137134, 0.3526424517301609, 2.100968711540606, 1.7423899298428835, -1.0645172640071716, 1.5418499540975783, 1.2966895532409919, -1.483920226181814, -1.4127510378340802, -0.0007827950296655599, -1.5062213776633842},
    {1.9849903898196184, -0.2572501487543569, -2.3887128112148415, -0.0998029096872775, 0.21008148237436355, -1.2440388452665225, -1.0653424950362471, -0.8577960808378853, 1.311284671164898, -0.6287074578409763, 0.8205578171455106, -0.23742990425410013, 0.42303091990228314, -1.2113287942355848, 1.1852138259870157, -0.6427451645827885, -1.1146859364442876, 0.6015320098885125, -0.09050316674137121, -0.26689711193748455, -0.5007362702834585, 0.6148097020784813, -0.13821617087596652, 0.708307740821401, -0.2581126887567854, 0.00508345022104992, 0.20715481382979434, 1.2849284312731237, 0.9902837735312221, 0.3064405871606302, 0.3840780284433742, -1.7034390773187509, -0.05270139083430495, -2.6028025440178486, 0.2914474499045912, -0.46888114488666444, 1.558106992097993, -1.64528850516811, -0.020452997097895633, 1.1566846887401117, -2.5901920002585723, 0.8141511035523673, 0.60675114079465, 0.5789209943458534, 1.1703642312263187, 2.1461130193449054, -0.6290552629631928, 0.17242751833111422, -1.7746882529070798, -1.2201345789931362, -0.6611563672704911, 0.3302700910375036, 0.7075062804191853, -0.904533277430515, 1.107131305641663, -0.16282195409645955, 0.1606501138494068, 0.5074187948128629, -0.3543488695428173, 0.8206022663368234, -0.6243907229817762, -1.7194712646470751, -1.186251795549211, -1.8049948127524218},
    {-1.5909428969335124, 1.5271669573959865, 1.400597250932465, 0.37222322214612663, -0.8938315664741712, 0.5097696469269477, -1.1521136564143972, 0.11067351616177903, 0.4372602168287743, 0.2676705051787586, -0.39277877877103495, 0.3416444961695128, -1.8023343863316146, -0.0791481545745464, 0.25073528402963013, -0.47605652098032236, 0.9665431569482865, 1.1372969545571092, -1.1269998709389775, 0.3268940189224976, 0.0024930059635426636, 0.6715062374027881, -0.38721360610824834, -0.16077374419719986, 0.99086727334363, 0.09356437752239129, 0.6739497991404392, -1.2669686476821485, -0.922201767758088, -0.5340114147772396, -0.9012438637590083, -1.3089605738464882, -0.9644243125897869, 0.8454675052899059, -0.7501273388415493, 0.18500591682685327, -0.36694594428207494, -1.4094359949111557, 0.705772484032308, -1.5038153219213781, -0.4897995957752014, -1.0433582023295374, 1.1168466925198666, -0.949014778420653, -0.7019840016899919, 1.33821452785954, 0.10560112013315073, -1.1622925285681314, -0.6021656723282147, -0.4156914371907462, -0.7609400738728725, 0.6161133754292265, -1.4635715215588523, -0.4711519063284006, -0.34103590622442975, 0.46405591916496575, -0.6169438674492768, 0.5593172558939488, -0.06529830911286269, 0.39000979124008833, -0.975931827496537, 2.2985923423813204, -0.7521160091960417, 0.5496374524478291},
    {2.065766460602329, 0.8170659746416058, 1.2864612057450073, 0.955416522944642, -0.06888276224722094, -1.9282513998167163, 0.19196550247494498, 1.7141662364854473, -0.2052261851617002, 0.4656559393231896, 0.032185725170620426, -0.6814260852882172, 1.5801907203222436, 0.45635524148313367, -0.417988245636393, 0.08758682053055362, -1.1829113496255195, -0.5582549904234833, 1.525316054898764, 1.0824767800053137, -0.389443611107373, 0.8843047221627613, -1.033929215720741, 0.24498548332998177, 1.3316200125972257, -0.36830970949163233, 0.08582909750684688, 0.24765792391517757, -0.6742935011782539, -1.002675643510804, -0.02408091506478714, 0.7805084923272386, -2.2308690584038326, 0.9193258325605328, -1.110035790302462, -0.6423851905219171, -0.2990526759204422, 0.8314258843746156, -0.34663496910368613, -0.6413385483318225, -1.2266946856208598, 1.65754031867527, -2.5209761708778466, -0.5626907142728625, -1.1771800877102798, -0.6584139861164598, 0.4769559502649833, 0.5850856168709582, -0.4509576128894731, 1.7916241992534057, -0.904797573551879, 0.12917258770991955, 0.4098389343937749, -0.5428019938912424, 0.1252039890114472, 1.3047753334782095, -1.2643711641241553, 0.6734737798408444, 1.2093453202609612, 2.1787310328268226, -0.05023326830282186, 0.04671583825003954, 1.8079177742748302, 1.7084364151174158},
    {-0.3141459942163306, -1.891542017977362, 1.7194360506388402, 0.1421725993768413, -0.8496546781958373, 0.6973841976177071, -0.15827650611833122, -0.4141380494141549, -0.5761149519129721, 0.5218122039934702, 0.36839034398263343, -1.40931571863552, 0.3352274046108248, -0.4231948777891003, 0.3195900254750729, -0.6001622513244751, 0.1256205828573057, -0.7130292135342906, 0.6171581302084947, 0.08415519782443592, 0.6043663231113763, 0.3608617426999964, 0.022194557765510277, 1.4274689213912328, -0.41523451763044283, 0.6051656632032036, 0.49953892598283206, -0.6343463027820735, 0.048239549449499555, -0.04578948632522004, 0.7677900941524789, -0.09143541709359106, 1.4338560408808083, 0.7600771423324221, -1.2446021296083456, -0.33239802771484006, 0.18081048194830138, 0.757788981414701, 0.7833113425636173, -0.11089216697269973, -1.3667505603129264, -2.0357171108916923, 1.158971917715135, -0.8731471772753804, -0.4331197875895336, -1.3516908926734144, 0.14610746303177077, 0.29161136478010397, 0.9624628323987914, 0.8504847109580208, 0.5463255062782508, -0.7264527642425054, -0.9883866946601612, -1.0629875563578735, -2.0140229439218027, 0.10104029457806431, -0.8473480707232978, -1.4519645994162573, 1.2978692057244237, -0.5280156129825032, 1.0112909103136936, 1.1964678254415633, -1.8720973979458615, -0.7093958560264824},
    {0.9535525478271523, 0.8712566146416524, 0.597540093411649, 1.1386076562443719, -1.0881080265871272, -1.7211658478353489, 2.20570803551282, 1.799947347359677, -0.30820975716759097, 0.6692306932745067, 0.33494430014618354, 0.9710693549310079, 1.0102863294859492, -0.9467712331901353, -1.4446082072184052, 0.19331157701388993, -0.903520229114039, 2.058236527328691, 0.08486019465878711, 0.7845120878599184, -0.4412631660426076, 0.28185839697653065, -0.7872276509796535, -2.7052737980688493, 1.828441451740329, -0.05785546197899088, 0.711681101363343, 0.002562773896323053, -0.7391353123433493, -2.3331841179427566, -1.1520937564078633, 0.554452905752672, -0.5773083070612939, 0.5543217496489612, 0.7291038031508624, -1.1430586879545013, -0.8514168825411343, -0.7164761735270982, -1.1558226657537942, -0.006417128908414971, 0.6880112886730495, 0.7240069829954262, -0.5693226826457263, 1.1359109477540685, -1.4313586238675797, -0.537026652122946, 0.39699183697556273, 1.1749013004395594, 0.29335690834839145, 0.08671454329946864, 0.31757019977157097, 1.3525005698835502, 0.5206320788625498, 0.1383079697562787, 0.0287302140160894, 2.852664779532386, -0.16060694512929757, -1.2353215630863528, -0.5189967091469101, 2.1573236269603395, 1.3673464717064916, -0.7977839763670866, -0.0010001842257478068, 2.5818227434372663},
    {-1.9308811491919038, 1.161711288345904, -1.2411956554582484, -1.7249341723135343, 1.05363182687424, 1.6906299094919328, 0.4692644837556761, 1.8978541429313474, -1.326481292961552, 0.0010057682206725245, -0.23209956390032407, 0.6365131426145298, 0.9171384633246703, -0.3132511025081881, -0.8970804768553667, 0.8725462016589101, -1.134046301683431, 0.011134750477130423, -1.4415576245786477, -0.24507722187206926, 0.8358381331573761, -1.5191986808887261, 0.5343821938943761, 0.03328664145942875, -3.064855815294009, -1.17084167063057, -1.0588145469038241, 1.3834965550098206, 2.4329977434596533, 0.1182142555867016, -3.0332671053561517, 0.7789862692007806, 0.21396189583135056, -1.538869054621995, 0.46929641863304183, -0.2942427578994468, -0.5166242098771228, -1.4463971647557348, 0.9720221287631886, -0.5172200015001777, -1.9064491685143414, -0.6151728288053541, -0.7219608198374535, 0.033824767610630066, 0.03174985259290437, -0.2754146878340206, -0.5606337437602431, -0.5693021396101967, 0.18462535792345333, 1.0257685651210546, 1.1345709775628854, -1.066024332716117, 1.1217518108869404, -0.9347745726476765, 1.5932060703249045, 0.3984307721627098, -0.21738466196145736, -0.8341241531879298, -2.161097119455224, -0.15615900141159317, -0.8760309286933476, -0.7949700801643835, -0.623825712955958, 0.5430290497767063},
    {0.22720025603986307, -0.666875818477109, -3.0499745063224597, 0.6317251884501563, -2.4173675914290564, 1.2224514006297087, -1.6028649856637733, -0.5476236136774724, 1.5288814916984144, -0.2840085639190108, 0.4077194025088362, -0.11800032971361259, 0.3422612622230188, 0.3914639483270827, -0.623430484996084, 0.027574074963537414, -1.0297558038385657, 1.7899635156461717, 1.129760095493547, -0.571851574631091, 0.7015963337338054, 1.5524374556160538, -0.7723701440171596, 1.1827176943818232, 0.4077481964814435, 0.7656716870861558, 0.22285172044272727, 1.0266739665543316, 1.8866580533726673, -0.7956258221820629, -0.37199725705265574, -0.8448335605430076, 0.12912452347841277, -0.9699140700645545, -2.3605562212475317, -0.15738473990301297, 0.7209197699887878, 0.08384926132029666, 1.2540125326310072, 0.4562378274311524, -0.16168618422798692, -1.3750557310651421, -0.7918386939654021, 0.18250779900904332, -0.07705641762046138, 1.2335236016106674, -0.43710732626482124, -0.3981627430996549, 0.9361806937365375, -0.4389286514702893, -1.443389965255816, 2.2733630620785785, 1.7495867896129484, 0.8539626052214654, -0.06620400009877919, -1.097097040428147, 2.170451703958256, 1.271147380458632, 1.0704295785658062, 1.0324069446429833, -1.239453687511882, -0.09122164837645093, 0.14732065598063826, -1.1168222705898048},
    {1.097547527977635, -0.41953524411019827, 0.2305114949515805, -0.12840057629112886, 1.7784180455454246, -0.6521594357635877, 0.4410674710573016, -2.2339325259033322, 0.9122644420610798, -0.29493443756810034, 0.7580772442887475, -0.22783788268655394, 1.539472120784276, -0.29252243511636117, -0.188711318849813, -0.8769816743199167, 0.3510545063655336, 1.5188411499275665, 0.23855151647349263, -1.1887176200230565, 1.4142478248301977, -0.1493465244847243, 0.1580922044737168, 0.7084180184317557, 0.3648175308389624, -0.1268013346868517, -2.4412923191554565, -2.279992299767844, 1.8237023931339609, -0.9359617389220447, -0.3023862488030644, 0.15801491785640204, -0.3637901310776795, 0.7590823390513726, 0.3816247440047814, -0.83505561079289, -0.23329701625259489, 1.0272270897352413, -0.46980641131392886, -0.31760047377865236, 2.2408072845054585, -0.580220550384727, -1.0943974240616041, 1.4935362541731085, 1.8046090228859921, 0.6194677842325248, -0.6266142318541187, -1.5503179386963064, -0.3379579801796584, 1.030231333237382, 0.37145311603634945, -0.18216681747674263, -0.1385105752812785, -1.0494182097319724, -1.2976638003025347, 0.015733236528778418, 1.3890574038443042, -0.32508546895107016, 0.6069094949512196, 1.0595352786858394, -0.4015234542773538, -0.1048303587864167, -0.21021797921000984, -0.009413745368359415},
    {-1.6942128637358855, 0.02913413526103096, -0.4351396785390703, 1.0518855926645332, -0.0709574990105313, 1.6763619446153877, -0.3336605917540288, -1.099851649307025, -1.0825580687467982, 0.3640868473914308, 0.1820886361004901, 2.418679889528363, -0.3195843475914967, -0.6493249574466979, 2.405323053326868, -1.0788178735093374, -0.7266652188753033, 0.8663808468590348, 1.3256910677794052, -1.2601735310506037, -0.5503450556255987, -0.27643751403244204, 2.2202549548973995, -3.4940248372508322, 0.770187473017657, 1.4594425586916462, 2.278867495086747, -2.1116915661865376, 1.1179123208372321, -0.06741627580618471, -0.38748508351003264, -0.1324499760691313, -1.32232720097851, -0.5868097188298189, 2.0271761051694135, -1.7355533301079207, 0.3045662199896949, 1.1519420678643935, -0.01720120003270185, -0.8718865141343701, 0.6129314964846058, -0.9243264619251993, -0.4809277343355082, -1.9420807946846868, -0.03311522983135122, 0.476618984649607, -0.461384720878619, -3.215433141416888, -1.55624830395983, 1.5523883176126179, -0.8822206422414034, 0.16748956912420493, -0.31895129560530877, 2.140106871188758, 2.1252760181937105, 1.1844104654883392, 2.1252097949941184, -0.5863324935978488, -0.8697270176543352, -1.210883057403112, -1.173672970933448, 1.984892301304349, 1.0795897431951447, -0.05530379440490305},
    {2.2217549312270397, 0.34105187829397804, 1.4455283771412955, 1.1538800840386119, 1.5014511865068132, -0.5034929614573657, -2.097537041699866, -0.23134313826517477, 1.4037847763720939, -2.3223908323600515, 0.0005887809054487784, -0.5221973831709228, 0.8819179205418242, 0.3223655539344537, -0.15689429483591918, -0.1732966166581227, -1.636428266501172, 0.4348279514180768, 0.9182108049832705, 1.0818056385189156, 0.18124768212555378, 1.074144200149752, 0.6484637841912705, -0.20439757749089496, -1.1258989168870568, 0.23867817184490214, -0.33872216437464303, 0.41822140132829183, -0.1398935125503067, -2.125396693442353, -0.18811721073101692, -2.1372028096882483, -1.267071923956431, 0.6784796079674935, -0.7349464584396647, 0.38900504587626056, -0.3605588493527132, 1.4454453547006534, 2.013884708410065, -0.9775844118211044, 0.497941260740621, 0.6288868303428529, -0.41412871394389045, -1.0596991085641145, -0.20141779308971722, 0.6120714632711299, 0.6673738768314433, 0.29103169451457434, -2.5936621371893427, 0.9416330098988115, 0.7694741104699455, -0.036551656370590095, 1.6331784671873482, 0.9698169661506805, 0.6720068304951358, 0.17207197684524933, -0.5367137220555448, -1.7894420894771883, -1.57063258475591, -1.4712679801294295, -0.027576948563902554, -0.2800248437312166, -1.9162382520459758, -0.8501303452719282},
    {-0.5158806869787432, 0.8521491839238133, -1.3686063119505931, 1.2083417509273706, -0.24214545136828883, -2.409617226870247, 0.13356419043917833, -1.217382731422933, -0.8928301676639223, -1.464203116591735, -0.04565476780341971, 0.00691234825044277, 1.894166977125567, -1.5516661826970621, 0.2737374606046213, 1.1304650788756128, -1.0568365756940867, -0.7337636959774869, -0.11529217927595713, -0.5598959863362809, -1.563866066736217, 1.6368964253150673, -0.9186837204585137, 0.5762881330053974, 0.7765472813171896, 0.0866678179850073, -0.9157218712848206, 0.4003391767007659, -1.4730115016502117, -0.14816238061369885, -0.06780847380017689, 2.3219317928815544, 0.936290528574579, 0.9586575198768716, -0.4157937461534142, 0.9852498842551367, 1.014122773299797, 0.8990860631591225, 0.43004443501856904, -0.020466377728815068, 1.445126272562435, -0.01008294194790168, -1.3167344888936023, 2.023914251796686, 0.09888529226532024, 1.880558309972742, -0.7576463604591595, 0.009337377653345379, -0.34385155235024817, -0.24720167952710276, 0.19935882885942263, -0.9012969841054691, -1.7617628629057582, -0.6915630200248948, 0.6248041370737063, 0.188457595945892, 0.7180590232581257, 2.2787560012612063, 1.094351059325687, -0.7610298683005874, -2.1308723348853458, -0.17269570102252216, -0.6332860805912744, -0.3941298674839354},
    {2.286386693901915, 0.5622775454759579, -0.7675815591767327, -0.47008089796926583, 1.142939174864408, -1.4970615531596099, -1.4868051775012947, 0.34937302855052277, -0.955695062264899, 0.3961220452411804, 0.15919258429599398, 1.4121753133438257, -0.674927559466618, -1.605355666102767, 0.6570842997959262, -1.341289946661189, 0.7858772841531824, 0.9594643654247662, -1.0623095033761705, 0.16468956729059347, -2.1624710061176473, -1.502492008708985, 0.6670056457527939, 1.098134461405213, 0.3914399476325067, -1.1727512347261284, 0.5082588052397562, -0.2610219523779855, -0.26387860783579087, 1.1220763359105432, -0.5857858936585381, -0.15095172951214988, 1.268256503176375, -0.31262847241557973, -0.5139414628918163, 0.6195462011501575, -1.5683769769293407, -0.1517116553781542, -1.9571051808678943, -1.1061668604337005, -0.2605034613038267, -0.7044175492546663, 1.3075596911288103, 0.2351434397126723, 0.3657202182285606, 0.021613492054365788, 0.4350533236641718, -1.2783243851036672, -0.38742821600389865, -1.4824780146606038, 0.8933090689144975, -0.7961521240197781, -3.427542730256751, -1.0317335194057395, -0.9281867510630966, -0.16802786497078853, 2.114270310008061, 1.174845985626598, 0.062406139282909286, -2.1445226149061867, -0.8821660707187402, -1.950078958314408, 0.8652686781838673, 0.4637202730302696},
    {0.8320463708364259, 3.0437718471372897, 0.5962127834386055, 0.4200060621800335, 2.109915337938462, -1.6301320806253314, -0.9401876864699759, 0.3870629216166455, 1.2807974483191393, 0.4878169670018398, 2.163485497040949, 0.6378005398244669, 0.9037378114764472, -1.0580975300769229, 2.2577542836134605, -0.5494240663080571, 1.5847279336760247, -0.1364852231185556, -0.03567143678765081, -1.5323914443579976, 0.003047956007504163, 0.4641003240693069, 1.5290010430398824, 1.5455804770446215, -1.8604361977303527, 1.438527056728066, 0.23660004476830265, 1.1623095647379733, -0.2841441260669015, 0.12540403657062152, -0.3822699992422184, -0.2887348443687837, -0.7305106737384968, -1.1228930757528188, 0.5715714021060947, -0.013559538766223527, 1.3549470894481708, -0.796899223522376, 0.498608877534103, -1.4237855482849286, 1.7670935876822942, 1.0175609386796864, 0.17476450470578708, 0.47143780180327455, 2.3122719403191807, -0.31848850433288, 0.2687287436609323, -2.416207233895578, 1.7303071035866753, -0.16752880890320054, 0.783877497682869, -1.2164836238800298, -0.20739893942523646, 1.1105486071950947, 0.8153110087968582, 0.07546390148725615, -0.848935249898427, 0.1369764631437318, -0.46991528141683636, 1.2634518789130007, 1.073069744260619, -0.09709589362002329, 1.1898330499363048, -0.1392931708922842},
    {0.7942129659607284, 0.404586653382322, 0.6138349339380946, -0.8267046092169341, 1.6314393683282915, -0.321849191455876, 0.8815561794384827, -1.1383123780173912, -0.293602859725535, 0.6084779713227279, -0.15440340587850124, -0.5724047741724496, 1.0396300759620773, 2.9022754040738623, -0.7078309745617142, 0.1846744396190777, 2.8575118420693966, -0.6141195158392143, -0.3752028163503455, 0.13695890137159927, 1.8091507489143273, -0.5697905426103238, 1.3358093400168023, 2.2830389013113517, 1.2108107014515888, 0.6077440960468921, 0.3256748067454023, 1.0679704797299636, -0.43005507094319917, 0.480295140601911, 1.25711120483598, -2.083035647905764, -0.4283745826040241, -0.30661901710070866, 1.0686681907193991, -2.2931851702095303, 0.07183381594569621, -0.9595237545483793, -0.762066595388914, -0.2950793497002876, -0.09612732540908066, -0.7263431968542338, -0.6277189968053656, -2.2572617464233398, 1.9082642831073682, -0.23025241127634227, 1.278910288760094, -0.8641818003886477, 1.5416038553747355, -0.4236605139146074, -0.227228364678527, 0.7811592229490412, 1.634299367878792, 0.8244139855993826, -0.7679497777791552, -1.0680259110106427, -1.5594986088707827, -0.5781974696490133, -1.3404433651035617, 0.06474734663856592, -0.4510599332649978, 0.7064731512026335, -0.9414157855792274, 0.16387962526945746},
    {0.8170645786211952, -1.0799601298146413, -1.357109413682734, -0.9444886778469749, -1.7636461278556002, -1.743966568714168, 0.7312486709457483, -1.1205504799916286, 0.9572057665870701, -0.5334479813303246, -1.7507165578706452, -0.18144873240784165, 1.9639064304636806, 1.996894926488866, -0.11641864479187694, 0.9941839373005469, 1.1542153186725703, 0.9935941102421691, -0.4383432878592395, 2.073743008589992, 1.5405462236800551, 1.5947345869027412, 0.7956915910482332, 0.5300465380174202, -0.10461487489787692, -1.589996599866343, -0.6056509917210036, 0.5447488157909302, -0.25678959679046787, 0.7618548369581096, 0.8432697156771537, -0.40274384191312385, -1.1095566301125204, -0.9471534793908292, 0.5928886615104263, 0.5205684429360011, 0.6209103524217005, -0.6882881295004322, -0.28570500006921107, 0.8249035611260616, -0.2636903838426116, -1.2577049074924538, 0.04691192909834923, 0.34194938917598955, 0.747913913195665, 0.2246434790442534, -0.7338556718725316, 0.9604584438985178, 0.17794844894144232, -0.502610691698798, -0.9291469313387705, -0.4126650323520562, 0.983425861127756, 2.500374042030409, 1.262185618127562, 0.5995263297401576, -1.0329862004274755, -2.8069476889442466, 0.11381092255959971, -1.1476878726948714, -1.7064786983295168, 0.5570371226725936, -0.5655316407533456, 1.5040273506239965},
    {0.6439207548765951, -0.6398737494159459, 0.58533694792007, -0.8613603596712471, -0.17329229770752583, -0.6579473398775976, -0.37186642300544076, 0.5729254478712532, 0.852561715787437, -0.0437767948242964, -1.0070439313094748, -2.261213129756304, 0.5853649606579072, 1.038461443148613, -0.3600223502821325, 1.0064092683742583, 0.6311793886318567, -0.26817859664519283, 0.2961398585701294, 0.9081059622432683, 0.6464307348591106, -2.235411419417192, 0.24076673598201756, 0.23158550799696148, 0.5660973704068848, 0.8642554125911002, -0.791789961169058, 3.3776594674896048, 1.7733541327639801, 0.6533882811792002, -0.4777232491092392, -0.536549399154898, -2.092941973082722, 0.23375641777597264, 2.9459629413195296, 0.08907528709509945, -0.2392494872007875, 1.0039416614320738, -0.5627738261335078, -0.3756504544029855, -1.0548771278043472, 0.25408205928233746, -1.396397863163618, 0.27443001648976884, 0.9705938032386265, 0.737766943239198, 0.8978307402704732, 0.2863572404044872, -0.42844504184002646, 0.43946662084836247, -0.03846149085937757, -1.370680922995274, 1.2919782338563353, -0.7194328697005039, -1.1199570370845138, 1.5216138346472252, -2.7084997252256757, -1.9784772842299823, -1.2172891323034707, 0.9801544777222408, -1.4713140170615302, -1.1699230688806848, 0.11767329660741856, -0.18818105651408054},
    {0.5251087623660458, 1.329483344371041, 2.114799863920889, -2.100973254997119, 0.17351825916079347, 1.4211520426500697, 1.368101619159144, -0.9390157315222402, -0.5327459486548892, 2.006424389555291, -0.1430282994113631, -0.8155137910614992, 0.01275808441551973, 0.6508976159191673, -0.0014248883501936454, 0.5193990650249649, -0.45059318290482125, 0.06017887267819857, -1.553084228759946, -0.7818354342400528, 1.0976394443642081, -1.0989478214701702, 0.4600294966589903, 0.8260769626541086, -2.3735078586160503, 0.19308175686462847, -0.03779306160061338, 0.7188252940447047, -0.025558315094479776, -2.254647464020063, -0.20919614055605787, -0.4370155984858776, 1.2989059361974884, 1.2192001384341578, 1.3339657253397785, -1.7218479518923342, -1.1564254075749538, 1.14732233059119, -0.9607962804533848, 0.7979159484123476, -0.0895442579683444, -1.3114937987790738, -3.045713492257448, -0.6143210423542044, 0.4159583065430245, 0.3965778999990628, 0.7422123656067218, 0.7355037917424326, -1.3289716411288155, -0.3178814035515872, -0.47944005355860086, -1.0972210890914638, -0.19780007598911645, 1.2460879246642154, -1.704268158499908, 0.3439885158015548, 0.8543428341463122, -0.1428601070001166, -0.5121583227721387, 0.19197141059358058, -0.8727756113267426, 1.0396850510616429, 2.372540931200319, 1.2014692625411774},
    {0.16661154726636945, 0.3252124050056634, -0.03194172642439577, -0.193700653535184, 0.5394027886238114, -2.1464326297445937, -0.4549740727652254, 0.3352939219885727, -2.0024744032146327, -0.4040588753750695, 0.47748310951631756, -0.15608954099696756, 1.952548461315408, -0.07569291231383896, 0.23750773590834032, 0.20298122757055195, -1.9847353064387272, -1.5372545318199362, 1.991226116859505, -2.1699801935569694, 1.756388771096194, 1.077378762855351, 0.007146882445655591, -1.085489129579416, -0.49817393001773863, -1.363176311533682, 0.5734412443539053, -0.9822993151539342, 0.3797077669277897, -1.4345529578373684, -0.10042127951711471, 0.9536920250687595, -2.6689978441943776, 1.4659636030862078, 0.8517916069170316, -0.34286579094613945, -0.7078119145264875, -0.3165612581110556, -0.16263371088117232, 0.02641587873836322, 2.8525469750116423, -0.10356842022101881, 0.8586748551086979, 0.14004685187622276, 0.10701349868663548, 1.0797276917388177, 0.4486043276196581, -0.6853030407481934, 1.9187989426323968, -1.8934895516858206, -0.36754660835984365, -1.1446846378786963, 0.32583170848300697, 0.6764436104022407, -3.263071305488588, -0.7225817702863565, -0.7039851553435991, 0.3439925064123556, -0.6790183688891915, 0.5785270583792914, 1.4126459593694591, 1.4983019668493212, -0.07666894963944285, -0.29024145508758864},
    {-0.12437528796262931, -1.0593979313981752, -0.9190949823094531, 0.0410761876580231, -1.2907468179259864, -0.4012974161667568, 1.0335935255602182, -0.6333745923749272, -0.20860440225012092, 0.9399701261576373, 2.2168685453384396, -1.59447104926897, 0.967248302118157, 0.4735419723525912, -1.0647067565322565, -0.025077291428014247, 0.4890345287158364, -0.23798330477967256, -0.2791944910871037, -0.15725364754643084, 2.0063009285669637, 2.5825873771800034, 0.18094014218824006, 0.019383427222569975, -0.30904358811903043, 1.2101871424780615, 0.976461208827886, -1.1121786348825748, 0.137319379383875, -0.4521962194320474, -1.4036796377736958, -1.2585463875192153, -1.7810784159044577, 0.6915134758106951, -1.8287983187910817, -0.2708490569885636, -1.1982909433943698, -1.6767059616367002, -0.15233728244858094, -0.5039764393112639, 0.18628149208504927, -0.4014594139540725, 2.19821053141489, 0.5239018346141676, -1.2151981546876978, 0.49002889704301883, 0.8196426750563979, 0.029304947419748872, 0.322059894981323, -1.8242094504457922, 0.1334821582676626, 0.26483551760553614, -0.6613322594465583, -0.6460013507900799, 0.13266934966002697, -0.4944097531883081, 0.026046592768547136, -1.7185270375542072, -0.9224793484457517, 2.046686514462051, 0.7632179800337263, -1.6444813019479947, -0.7704747894192753, 1.7113987529029264},
    {0.14494206543847651, 0.49015714949605327, 0.2863050353720939, -0.018069772920521456, -1.418153513929174, 0.5958796966715796, -0.17349453338313967, 0.9554995598664242, 1.5733259384054283, -0.9254598833026602, 0.11027155643492184, -1.50209234941182, -0.20313283421242795, 0.004730936249821475, -0.9341856939466683, -1.0514228116395716, -0.49704390376333996, -0.2468899235022232, -0.5351190141916855, -1.223290956950294, -1.4246580978761194, -0.7583440423919003, 0.23779127778525608, 0.10908171220277561, 0.21804101984070412, 1.765789739930167, 0.5915408121101429, 0.9852681535695168, 1.3608355567848647, -1.153390423525318, 1.7975432559210944, 0.5006396535247135, 0.38523917072261804, -0.7506758437608585, 0.9176079257704615, 0.7172124013349055, 1.3801646499348594, -1.3464200205357955, -0.8148077692021956, 1.792795345260563, -1.1119316386342208, 0.0368223124510801, -0.28900049852925963, 0.6240216110987833, -1.925994466092218, -0.04000130107247665, -2.492256905402402, -1.5172879981161655, 2.20564124607335, -1.6623581003685848, 1.2977152874684406, 1.2608421975900639, -0.9226423254604285, -0.9349127032142321, 0.1606768581855039, 0.4379826870418062, 0.34367131036879606, -0.7182402638666462, 0.49620839046423826, -0.689930747432807, 0.4253639449881923, -2.3053125849979383, -0.014033854993580381, 0.47092518930214433},
    {2.4191422366191446, -0.06610148255525479, 0.20384470820259268, 0.6819459939354028, 1.4669183071479655, 1.9594515984933676, -0.9587273252193302, 0.2365436634869968, 0.4797185256015465, 0.17395681766688087, 0.44027508758163664, 1.9844172926577222, 2.3225168992812293, 0.7361257764692404, 1.3778224546559483, 0.09751533484415748, 1.1521807860135118, -1.362533364262612, -1.4955989216392473, -0.11957132528722747, -0.5724824882818877, 0.7846142348874936, -0.1489746391887229, -2.241387238104228, 1.5431322309576498, 0.6775939510970304, -0.4937232621920215, -0.04675420004110604, -0.17643466533562877, 2.325565347776163, 1.7348598580075096, -0.11555480590916185, -0.1455850472392309, -1.9226774097490384, -0.32326278566203065, -2.208957056397322, 0.1413640703917523, 1.5998073714493404, 0.5807415251138245, 0.4333808438358098, -0.06591809861780473, 0.028658682067136357, -0.01695352236673145, -0.4953415915390242, -1.035991614489401, -0.4933318281439024, -1.537401959240999, 0.6802340838583713, -0.9431437092456966, 0.5529688408787544, 1.3006071629913, -0.7155394955776285, 0.6640381203790604, 0.15181798284552633, -0.7483444914512261, 0.5063207117217912, -0.20917839763799964, 0.6593001026403474, -1.5106564354250458, 2.266726449816701, -1.0788974727318894, 2.494682892426154, 0.7018038374135421, -1.5712861702216148},
    {-0.02499373162036105, 0.1283001586780616, 0.16686324884937062, 2.245643266646785, -0.2306515778321656, -0.1663815646296961, -1.0491691839849875, -2.135150198170803, -0.7887032962138052, 0.10168864008101866, -0.8223928121008409, 1.6017766677697403, 0.26099516978607823, -1.8072435826874824, 0.5568820205720649, 0.19035623982481928, -0.4147255894351829, 0.6124185912486881, 1.2568188342570938, 0.8307893138443354, 1.2712849208970873, -0.3137001401408566, 0.24010735824453508, -0.3894283494360765, -0.9231415376145681, 0.9498161388039672, -0.5748119208661842, -0.0650795414958252, -0.32305580064588924, -0.8985308905807818, 1.2516846154855703, 1.2529242965780365, -0.6681503022541138, -0.19418227166710617, -0.8616156631607216, -0.5399299574807296, -0.14271113168557403, 0.7112008350109623, 0.5094468465786056, 1.564356407617133, 0.28566365857541226, -0.9658878965548988, 1.0938322094937019, 0.5338475426321696, 0.5896343934527267, -0.4535616278077439, -0.23143300176308987, 0.2024199371593821, -0.07951616881793522, -0.05124903403505738, -0.061493050643982305, 0.9064719485296947, -0.6933629876999545, 2.4736278422584452, -1.2745234536344072, 3.2198822751227896, -1.2415111177375113, -1.4659442811375503, 1.4137891242832739, 1.228021625333208, -0.875195408089935, -0.482254235702022, -0.3301795441899466, -0.6539600396244147},
    {-0.18740584665154014, 3.2697713635068135, -0.3556089326537799, 1.626799285696591, -1.2105835799967908, -1.0651637756087107, 2.3879402851449605, -0.10925015817821428, -0.26844854349856717, -0.843125354066394, 0.9259547010692248, -0.007046233705674405, -0.9427424102923828, 0.9141041581956582, -0.4182691648471204, 1.2257877528336554, 0.40794630141545146, 0.5970232475508661, -0.7849895599900972, -0.839194994112765, 0.8454905619282466, -1.0423763099834396, 0.8162331564346756, 3.4771980028056824, -0.3110720420511241, -0.6441228756433198, -1.6666023832277321, -0.2095810460974875, 0.11660610366833273, 0.3247111000853187, -1.5427910648008942, -2.0802693730247115, 0.8551184067859764, 1.2041517972484328, 1.5912527581393585, 1.8358102152013587, 0.7419964695487381, -0.09721010037914497, -0.4327367053740261, -1.4492213075020381, 0.5671868508950579, -0.4639488247904996, 2.4772163380345678, -0.3486103116852385, -0.5430379683226152, -1.0700628677107331, 1.2427122773299093, 2.094702622810066, -0.0496552394335648, 1.6941199096648571, 0.655477155081814, 0.050575997638008276, 0.31368934948594646, 0.8348432865552753, 2.9104726270445096, 0.3397081335516982, -1.312257444808071, -1.3004357687932029, 1.4913185989890818, -1.7364104406469218, 0.49006388401332435, -2.51699721974563, 0.4563977095493866, -0.9787323878608211},
    {-1.375303447819712, -0.9005771446953634, 0.9247513162375972, 1.2976361451124976, -1.1657909813127127, 1.6809960105147423, -3.491072188545958, -1.5198594250726412, -0.08244163551823484, -0.1407516573101704, 1.0189480347988384, 0.5874914540187005, 1.572478062166662, 2.4606242264750064, -1.0134138973638624, -0.9530262642113637, -0.034346369921979744, 1.0834469375140154, -2.215742412602197, -1.2637136609172015, 1.6405946502746847, 1.5231668166064058, -0.18149777665547742, -0.44132513136492757, 0.8222330183908235, 0.07192117722799671, 0.06721007277431189, 2.0058590468802886, -0.8209482224153671, -0.04642152860037732, 3.379537932561835, 0.15784113436295805, 0.5180030158903247, 0.1347696542801972, 2.4016326524605223, 0.6451618738637265, 1.555507465793, 1.603972479172061, 1.3921501875759754, -0.9589993425373996, -1.669836842281714, -0.6742624312326861, -0.048997938482776573, -2.7685866548966476, -0.04273772448103657, 2.0147732364708184, -0.2288616284576098, -1.5691865696270315, -0.6583434876294241, 0.3911705272783649, 0.527412671553787, 1.1160997356881313, 2.1167173411229077, 0.3734033714889268, -0.8999690179245184, 0.19119022366987384, 0.7343977648840635, -1.219618170950882, -0.5007611092773109, 1.3466416345350585, -1.3062342008666652, 1.4105878796674982, -0.07035323563420731, -0.9574193862447447},
    {1.1172795656413856, -0.7246302718108595, 0.776561673697651, -0.46988643296978405, -1.3056085563390156, 0.7832618212081452, -0.1363229636236835, 0.1450108590189504, -0.4431716992573351, -0.5327873599514048, 0.8888996717956756, -0.30602298645445913, -0.2907626037359702, 0.03151477019421564, -0.8871255112064476, -1.589772450342701, -0.48486328026026704, -0.7410751498201835, 0.2709171463423222, 1.0011013143539953, -1.0738125524719173, -0.5285636478364428, -0.794780884218742, 1.9894474381121665, 2.070863758275136, 0.3841744863073803, 2.015484486612654, 0.5840262879880406, 0.27429898952976434, -3.133241507840247, 0.7340438660347114, 0.24599770016972125, 0.10425850040044815, 1.9549175298610233, -1.8350362304289582, -0.05810699552745157, -1.75869656579426, -1.0168024078230251, 0.12177220694448006, -0.1773323205649885, 0.7319845286720413, -0.06877939773208329, -0.9315441448987445, -1.4194558491910005, 2.472324847781549, 0.9483591494139368, 1.3385185838849858, -0.6259200138545219, 1.7907096341769626, 0.17998630673067206, -0.05408057573253284, -0.334348206710748, -3.386969366462381, 0.34420426701272044, -1.0406434633642707, 2.474932630318063, 0.08335609330080253, 0.7099638913739879, -2.0102795438019108, -1.316278954361059, -0.5865429979776404, -1.745713232049183, -0.9120253221333867, 1.554615673121082},
    {-0.09490332066863276, 0.9074653973415081, 1.3734089281470179, -2.719264402654724, 1.635214170050174, -1.6410696792150707, 0.6293849442996605, 1.6040600916246075, -0.35472198596845445, 1.3362144207393496, -0.022124631991797317, -2.05064162983983, 0.33340155710867464, 1.2112527450019992, 0.22445224270073877, -0.8422681970958004, 0.16075884100117685, 0.34333664822635435, -0.28531951514896414, 1.4410580857675441, -0.1621019423289524, -0.350130908061751, -1.1851782912660056, 0.5951891479140524, 1.2120255957944879, -1.3862060137921177, 0.3371621242838196, 0.2520907659007798, 1.5116363433093045, -0.846427352471705, 2.1994092851484566, -1.691754487955753, 0.1769044305753447, 1.5087264230092357, -1.1013020869879468, -0.6668784892352716, 2.0875593483209327, -1.2315505856383178, 1.6502706297524814, -0.03522719877039378, 0.7824924524773094, 0.2816251057287908, -0.7777219262185647, 1.1371357859351596, 2.523597277204889, -0.3428484779171506, 0.708536750996966, -0.9587344722029635, 0.39145419763668954, 1.8233350627477212, -1.26449480786924, 1.135214629306654, 0.4212069527586095, -1.3964529774765666, 0.3885218429191731, -1.8380522749475148, 0.2900514533329953, 1.4392173395449972, 1.2152285934644866, 0.1677255903210166, -1.5544720782450014, -1.1938827319898218, 0.7173270536411173, 0.48762160203468313},
    {-0.6744252075756827, -1.4953801901271928, -0.20502590674771576, 0.7811003828519363, -0.3984142495122873, -0.8695254808210673, 2.3030882692389287, 0.002360204484677979, -2.750443402005759, -0.3369585122613153, 0.8977185026186371, -0.11448003384832202, 2.145986265743084, -0.3516654710546357, -0.576780258340174, -0.367987494347885, -0.5678358795933821, -0.9859267852334127, 0.8037293338902953, -2.368100733110198, -2.369391694590226, -1.580081291192717, -0.5723953805510598, -0.8965280097709943, -1.766499712682189, 1.1608655293164591, -1.0828066995049457, 0.711296196400999, -0.24501842407298777, 0.5485101524821971, 1.1915536142139926, 1.3834595096940263, -2.3360744109850575, -0.8341591540209488, -1.1500375983493394, 0.24540579195578666, 0.9092721688086489, 0.5906350615186325, -0.7822936280218961, 0.927011256789623, -0.749080139080498, -0.3974546325341234, 0.5822306966206513, 1.884490456975363, -1.4644254409655006, -0.6503334138894182, -1.5708410840651066, 1.1528552784579564, 0.4199988737584741, 0.6312267499632427, -1.3851230278291273, 1.294626480648103, 0.2283859719080284, -1.6163994132411217, -0.02101458799691119, 0.9403498753990613, 0.4996247009083562, 1.3541102940477496, 0.6565191702605921, 0.696671424739224, -0.652059446957207, 1.7217557388994433, 1.7473343017971767, -0.9740247812262345},
    {0.7684461916877608, 2.2301894520969396, -2.6907658270024934, 0.012141899554150943, 0.6339244180992258, 0.09225349627437035, 2.126324959036023, -0.21449435285465332, -0.18837217437979387, -0.48682222643177187, 0.389612530865332, -0.9397824528787918, -0.10149449895977074, -0.8490139706951156, -1.8211822389594114, 0.1370023321265507, 0.5591557877498473, -1.8633859657498106, -0.6842762502883657, 0.13681609391071814, 0.5206068781835688, 0.05987590006973752, 0.8778798565419187, -1.6376615252197877, 0.08402719597725918, -1.0232486056615961, 0.011266592707455229, 2.1254680722314476, -0.03986546672471449, 1.4247454892615263, 0.38682504500782583, 1.3133391680652386, -0.02696033449725157, -0.825863581773592, -0.5509449693450503, -0.06846473851825917, -0.442726633064409, -1.873882533539413, 0.8826868078175051, -2.9061421387025748, 0.3104499549650951, -1.3876086915697459, -0.6932143464456358, 0.5533619495555108, 0.8366400062570643, 1.8942306993250027, -0.8913971446724768, 0.32040469936424154, 0.34815856193431943, -1.185556586234033, 1.9202320016990349, -1.8162153717239973, 0.8623299565827509, -1.3134450039394086, 1.0017009807512023, 0.5580701776706176, 1.0534809238681757, -1.567140227250584, -1.2299797735017457, 0.4938241168293884, -1.6495829531469361, -0.9882075407764018, -0.5056037469974035, -2.12576145659803},
    {0.5568310728982285, -0.14403337511002148, -1.2795940811561084, -1.6173411221006677, -3.2466244641927524, -0.18951321775790667, -0.7214197559538097, 1.9533124936975594, 0.7632336604291475, -1.2625356920078714, -1.863475276833529, 0.2830248442359632, 0.4110015939482635, -2.1721515199156514, 0.883473945415646, 0.24508898416012553, 0.31879746303992457, 1.5765856623084609, -1.2118644069176803, -0.8465754781175351, 0.03499473525348259, 0.8210317780009279, -0.4628784523933903, -0.013417689454069464, -0.32867317934951523, -0.4895500315094159, 0.6040208879552762, -0.25278056808858973, -1.3116988196583654, 0.8917137269601999, 1.335850041153535, 1.3071678642367601, 0.5455127751535339, 2.217753348407703, 1.4484646947888125, 0.5241466587145615, 0.09231900129183791, 0.9731285461152996, -0.7647870545923643, -0.013357942612147828, 0.5793985008502295, 0.5835429495782386, -1.297448638022739, 0.16017156241224323, 0.9954306214505602, 1.5061004686522836, 0.6708319159387527, 0.32196142700351954, 0.9965539342863996, -0.06485127860531413, 0.14757712795650216, 0.164068339549003, 0.2528296471599582, -1.7232661023592515, 1.4228272545734815, -1.0410774648943404, 1.0560924043553392, -0.21198697807081393, 0.38553036036973587, -0.8008920622383854, 0.03828370443255412, -1.446711995237602, 1.3933473477245273, 0.7092604865717119},
    {-0.3720330268403469, -0.503175198723489, 0.9851929291697112, 2.1672820291242316, -0.7415014808829651, -0.5396479148365603, 0.6282204303385367, 0.266390234131782, -0.3418868580159437, -0.14437227809611158, 1.1418622962588658, 0.94328763301008, -0.7592878610432651, -1.4739269789314073, 1.059370734237299, 0.7425441877912662, 0.06699318807477742, -0.05398175779696054, -0.4017063602010702, 0.7704366419673913, 2.5662898099185236, -1.292806685856199, 0.3261353642656356, 1.096180640562607, 1.231439963068202, -0.02139564724922325, -0.2241200812508829, -2.119980764469274, -1.0028022682520183, -0.09553939432563306, -0.6260517200825518, -0.4473703022621676, 1.2074284338221863, 0.15654549806216003, -1.7667972787825945, 0.4389918938221806, 0.5476427192113901, -0.31087534274304546, -0.495436453497783, 0.9364675666293883, 0.7624381866851495, -0.12755430730251954, -0.018443905097955144, 1.7261671219569923, -0.2896709347680903, 0.9280474857255253, -1.5020837258423567, 0.8764060426330832, 0.5559042545644488, -0.4858160396240831, 0.4681022970288112, -0.8165970407949856, 1.2384768458001607, -0.4557594168292017, -0.8251932763332517, 1.0136643050917216, 0.07959450952050302, -0.1783748600367726, -1.113404874729135, 0.4185293112052641, -1.2029515981829162, -1.5608647819141617, -1.9973842788207472, -1.486209869072643},
    {0.5494222145157565, 0.8653281536250842, 1.1390827875666947, -0.09290402156501126, -0.03213124152627636, 0.9840221951959324, -1.690942790544173, -0.7186700862557274, -0.5836529728189779, 0.9787966502968619, 1.650274047214354, -0.6957616626180982, -1.7386061150850152, 2.170803481859126, 1.531471437653067, -0.13226620937787373, 0.6946013060501423, -1.1424964183601614, 1.274187735826055, 0.46908317159864305, -0.00047224107688533174, 0.36994691562372817, -0.9637040706419676, 0.6394376342310735, -1.988720660032566, 1.0131847106901128, -0.6096005277661283, -1.5291258141929536, -0.6154721274474246, -0.06795193254626611, 0.9146270247604688, -0.754440196387252, -1.5387797532301406, 0.12490443293877454, 1.8902708887894368, -2.3417320779449784, 0.6956850595776891, 0.20392444459241957, -0.04751256940892657, -1.1756103481925186, 0.031476643456030975, 0.8842834334570953, -0.3396477993354709, 0.12316237835964408, 0.5365449120660041, -0.4559602490316853, -0.3428822728274593, -1.4132821791271228, -0.8825264460745139, 0.5253502611014336, -2.053609461586937, 0.29353247831398893, -0.5582375894325472, 0.9629806721446872, -1.3684061019706033, 0.16435784373146542, -0.1943012439907776, -0.22496067000329878, 0.0760971397053243, 0.9352362561509271, -1.222571974292499, -0.0317547503566124, -1.2339468243960003, 0.9900261050098718},
    {-0.4185702059950698, 0.33855509380507903, 0.6271634224319718, 0.5897265699034722, -0.6517921989167724, -0.014427981783039733, -1.8237081503263468, -2.0064600067509035, -1.5430779214014927, -2.1808400206119045, 0.05964561213716839, 1.546601360585569, 1.021933477986387, 1.0256824477473134, -0.933004365762056, -1.4602000719274908, 1.9943036448809737, 1.1080549510086262, 1.9464734205924756, 2.4827283487645175, -0.4014481566912497, -0.48197311248353325, -0.42653793366683584, 0.45163714415248407, -0.9113586207652041, 1.405507725029671, -0.24724354808769583, 0.0050565536384441865, 1.1794064045905808, 0.1900504764329044, -0.7430039685449027, -0.44618163027683416, 0.6561140430535408, -0.5046071618814401, 1.9262125595541304, 1.27421183536595, -0.006415136884647255, -0.4406456006764791, 0.419852333921574, -0.4403298871092182, 2.2707874445257543, -0.2601952682257594, 0.4660228972753604, 0.014700206176779716, -0.8138530179441172, -0.35498272486701987, -2.5125521674340567, 0.9069857430941296, -0.05876453400192719, -0.1348452671656359, 0.416562423515247, 0.49671020944280114, -0.18461359790480888, -0.12122481355213216, 1.4255321760805548, -0.00720241061192022, -1.4807568246994203, 0.19532391583135175, -1.85619351396369, 0.595883536515236, -0.6903777736057114, 0.7610554339554177, 0.5879144782577082, 0.048609394167741515},
    {-2.031781351197327, -0.8550487367072036, 1.4349489661062271, 1.2154931023909574, -0.9557335547505409, -0.8889581101431053, 0.4019996178107735, -2.322521766289352, 0.913288061230775, -0.8504274062740304, 1.1273272823684493, 3.5111970879163774, 1.3455486859417523, -0.9005259501210577, 2.47659897209689, 1.3843284906141113, -0.059060800090031444, 0.6714742134211694, -0.43428383724727915, -2.71756989133686, -3.337505603378081, -0.04672946377171164, 2.8793354388324532, -0.27851828610200446, 0.6229653876818595, 0.22796422805698968, -0.3229226808073406, -1.2699692771126994, -0.6792541817157882, 2.0118416870566747, 0.49544088532322794, -0.7804291991952852, -0.33125808325485956, 0.019504915512202237, 1.3306113452323438, 0.56549588749113, -0.812342358595073, -1.0914716513655476, 1.166491690029072, -0.5350769068104465, 1.5494426568377888, -0.1485849140345844, 1.4059740990296459, -0.826997983381627, -0.6584966609833969, -0.701589804695502, 0.1887340556552061, -0.14267587542925642, -1.4918954827701896, 0.5320462432140823, -0.3070970109771163, -0.6745594564227314, 0.6627502040065402, 1.2418535221291738, -0.11502072709883748, 1.433767426943217, 1.4154736671594499, 1.6954212410139133, -0.3747751430112704, 0.7943714924357274, 1.8347140608211838, 1.3018596129654942, 3.5645801145267235, -0.797154423192845},
    {-0.17900331287638732, 2.074528812209039, -0.444830273138574, -0.7698974681771705, 0.6527933395398636, -1.0284095328902134, 1.6703389754396505, 2.247045118913157, -0.569709798949039, 0.7254299813288078, -0.6245031775822792, -0.10852343147737951, 0.4513850407575396, 2.227372462352418, 1.672326676032806, 1.3289802877156434, -0.9394107497897555, 1.5108805179175089, 0.5161497082359964, 1.6372198411351544, 0.8572427338815574, -2.6429532389970687, -0.565698849972134, -1.1767444482088536, 1.6188284853265145, 1.2152294684534637, -1.0176631795703224, -0.3439991781573527, -0.4127259442923507, -0.020827460627984015, 1.164613386453617, 1.4563740019817095, 0.6661871368452832, -0.5574269444163177, 1.687686103100252, 1.4948235097607272, 1.0836771829726028, 0.3120422875028609, 0.855031905302964, -1.344560725468819, 0.32761261641205364, 0.8190485207020022, -0.5382190623667636, -0.6907385135945125, -1.2375816103764674, -1.0859449325150705, -0.5280887958164505, -0.04928497082240489, -0.7285494076531132, 0.3092560198048123, -0.6136874676851732, -1.4375620988856317, 0.38157200815027614, -0.7501810148331809, 0.2197899468035738, -0.5864115552920172, 1.7337116373547918, 1.3357049281876516, -0.7414966124519179, -0.4283179636012936, 0.4105853849419331, 0.24569780397419894, -0.3417757016118921, 1.3004141635895254},
    {1.2334953459126758, 0.09665882965197944, -0.6127465858665042, 0.31500529709300196, 1.5843134173710782, 1.5125834557094529, -0.9717767263185889, -0.4909676172215032, -0.3132608511955375, -2.109813680462464, 0.6504227021114095, 0.3818468463688267, -0.4602595906680487, -0.09432251634476012, -2.2621182375611406, 0.09556656117764112, -1.4430594952310098, 0.7163168328433255, 2.373330062228416, 1.421766572907892, -0.6329549272221735, 1.8720839082495022, -0.046666842966538745, 0.22866937167902499, -0.38366416245402996, 0.5192892523481598, -0.7697267369629055, 0.676065795904308, -0.16710547453148306, 0.35218132193414736, -1.710723691148718, -2.0857799939687474, 0.299309479856139, -1.726165049857639, 0.5116894567357037, 0.03914739790400904, 0.01655109368667999, -0.014867939224045347, -1.9324394181653852, -0.19188322704245764, 0.8652129423860024, -0.8046436683667757, -1.6146451507999402, -0.1767317301723827, 0.6799514051961649, -1.5152294159743427, 1.2789829839428342, 0.8849661070574247, -0.06580952006752847, -1.4340831938925094, -0.6618963165446269, 0.07444037970622927, 0.5122852415688388, -0.6798271459508342, 1.875590363108125, -1.6987934453177338, -0.10847475817236717, 0.7626335912113559, -1.0148301547711391, -0.2754117204215964, 1.338481827887328, -0.0391618398347313, -0.007186028804596232, -1.7947216363389076},
    {1.3790286148971966, -1.38222277894985, -1.5077270810248833, -1.3382681202081057, -0.09064858585669834, -0.9444581973778278, 0.09079097373359478, 0.6830351909705776, 0.7806208876069839, -1.7958589281690287, 0.06800659066393845, 0.226853640431899, 0.24642133263827412, -1.6985446247283356, -1.1396177457729217, -1.9228883750996513, 0.6602909441049571, -0.22478994056300472, 2.7307576079453697, 0.6532089955911334, 0.24083772964321237, 1.3045358587655902, 0.4043775077415193, 0.6171865625032968, -0.6727342862918605, -0.6464364964861525, 2.121763975450994, -0.06073060560005472, 2.266332917094031, 0.7384874261055137, -0.5021508406364696, 1.1259073173454195, -0.6582518456794443, 0.6302121219205611, -0.6756222232862912, 0.5957159657781611, -0.38337818960568526, -1.9450424244379032, -2.106952677028756, 1.78768387012136, -1.0754543830076404, 0.3915018597134478, 1.124552780732275, 1.5772469984184723, 0.2775474716165048, -0.17093554543918565, 1.4099271259954191, -0.5645001657318792, 0.9201459116163698, -2.5928605469446393, 0.9702024777465191, -0.35559809557224226, 1.209066216518477, -0.8478695052323004, 1.8784963374810022, -0.817775925734022, -0.2731637432131147, 0.08629416676218254, 0.7853804171315629, -1.247487773159508, -0.1429825502303898, -0.5105833616024484, -0.610458917292007, 1.1322029883527631},
    {1.9395054789805155, 0.1729836225143818, 0.20273003051812688, -0.0926611710964833, -1.2972837237400348, -2.2927454623579435, 0.3930968172560654, 0.033058195923266726, -0.19705950676102807, 1.2856266548618531, -1.8294535052238314, 1.7744150307411286, 2.1210138953657425, -0.9298664970310538, 0.6095452266432069, -1.4663090834798893, 0.7310425451985681, 0.7558297868152678, -0.04842658876630575, -0.7013395900176048, 0.9099492616027097, 1.1598878642140167, -0.007689744460940282, -1.5038972270335045, 0.05568892799380173, 1.8576473078065836, -0.7582641834533154, -0.08834226160258865, -1.6049365346486286, -0.6707044801004792, -1.436421871302807, 0.22137285760834335, -0.4730161554648841, -1.2228355527670973, 1.0991450047977775, 2.4014337126946654, -1.5049051409504839, 0.2823182615395778, -1.3765707188292824, 0.7361545694452529, -0.1524869353561081, 0.7417281301120011, -1.7304035827182593, -0.9986867357504723, 0.4456346012693145, 0.8284922225609723, -0.591945139147021, 0.051804559368246614, 0.21950065599938412, -1.3403634625575362, 0.9674288191642683, 0.22126127234879903, 0.8263130427061546, -0.47712131550274905, -0.5289338121751835, -0.5956070879324724, 0.7365567465111708, 3.1082810938633116, -0.16249227727792617, -0.08072830354697194, 2.8734376842482323, -0.12314309703720736, 1.7208321985296393, -0.8936603355109208},
    {-0.15311656262804518, 0.8263661065789156, 0.7027578918663667, -0.3197479977214059, 0.5047513805189657, -0.4807879314179063, -1.9525021203342376, -2.5922235302013323, 1.8358225020817436, 0.418757913291288, -0.920079760905492, -1.0871754349819058, 1.163967538911006, 1.0703795902128197, 0.6943314818250815, 1.1399470594978536, 0.8360146693731836, -2.179052167425833, 1.2189060364967639, -0.20885820360140403, 0.26958407224457553, -2.333760553751334, -0.16051732439174346, -1.128712919679211, -1.4369947309886835, 0.7858500655949598, -2.091479200181891, 0.32422369264996126, -0.8368030224429965, 0.16371263292654245, 0.26683592266022976, -1.87193206958149, -1.190969816357805, 0.07890782651742706, 1.0801270709659347, -0.011249421545199223, -0.8315977972954072, -0.04694587431741069, 0.3158322972395277, -0.63774161827503, -1.14055859023479, 0.5399277794782902, 1.6508857570987814, -1.1449265886841826, -2.71962295424974, -0.5162411687421602, -0.8183858432963885, 0.8716487703201365, -0.9431333540950434, 1.241521439641675, -1.8651287816266917, -0.6395240667201215, 1.6604158707036345, -0.8003721185309531, 0.2758075068401542, 1.5042461240092804, 0.23259773745412016, 1.6432207131633827, -2.914358239425244, 1.3989818649111327, 0.4101965645342836, 2.7503715410941254, -0.1408984097099341, -0.08757479585601172},
    {-1.07749962633065, 0.7631652256944096, -2.273587030711631, 0.1166600966255533, 1.0485978881970939, 0.45589373010540446, 1.013395715082218, -1.0731737129518768, 1.0033074388129293, -1.2811128589107343, -1.0013311786487211, -0.6916962558717086, -1.9041998284307196, -0.9390851714020855, 1.0838286369949899, -2.3914036891173884, -0.013646580273534829, -1.1584468937177261, -2.5792745057888653, 0.8306593813405498, -0.5334874907308944, 0.34604304545963116, -1.638660529692387, 0.08977743838914996, -1.2291832277579682, 0.43868988746617416, 2.419075707279107, 0.03328153164034186, -0.04554707798639962, -0.6080580737996969, -0.7308639468342847, -1.1009360185180332, -0.5588421476228487, -0.07756670365722503, -0.8830989223586355, -2.0670283555308466, -1.432496172896655, -0.8599033461435215, 0.6908835355033054, 0.5430675407446804, 0.06502920799199884, -1.318273419858107, -0.3386594106558622, -1.6222024987566306, 4.230122797809653, 1.643644314189847, -2.129198079720414, -0.6406780713798373, 0.24115196899736058, -0.7237597340243711, -0.26244975829534295, 0.9674943750882121, -0.06479128970178051, 0.31404876765843237, -0.8907587500247997, -1.9506358285343772, 0.716101831617299, -0.5919370580802776, -1.192430204389026, -0.8366271436215613, 2.5423242975489737, 0.8311697703562395, 1.0035546046319685, 1.0625612132737945},
    {-0.42272716404479693, -1.1962872352929983, -1.4913458767704297, -1.2055241049758323, -0.4182704079385761, -1.1200660175917982, -0.016861433355323686, -3.236147589844093, -0.40608301456653884, 0.16255600540401285, -1.9894023498124631, 2.02262612749687, -0.29852405541858057, -0.6256068649893847, 1.0105419827710211, -0.33648248754676063, 0.169637498455466, -0.04595387296856822, -1.6065116572938838, -2.5096172252323226, -0.2835310842755199, -0.10315604770068083, -2.6099049752174044, -0.3330597212660382, -0.2726735556747988, 0.9954514353800177, -1.1005972006177083, 0.21732448171607574, -0.9878795123206249, -0.34948840087762517, 0.5355393243180576, -1.6453721483484633, -0.8311932994443924, -1.2936520307671198, -1.5718730308375326, 0.3867752572777975, 1.0029676970436334, 0.7709884960907234, -0.7660552972263308, 0.8028849330052354, 0.3415173580125707, -1.2443059076581124, -0.5646436811784799, -0.0910375525692673, 1.1145435692985506, -0.05365202808637545, -1.063108060240424, -0.8281609944627848, -0.5494525670732793, -1.3356501922143993, 0.02578177810465896, 0.4647419508612992, -2.30649035732248, -0.6360479251589853, -2.0571209580847847, -2.141497090694691, -1.6619069824009167, -0.461486136691698, 0.09948437224673676, -1.8161366987944507, 0.4629343106994706, -0.7424280561088443, -2.0255205424004394, -1.0539538633169605},
    {-1.299972400525596, 0.2604931852546065, -1.3964025925800758, -2.590680460815779, -0.7020068878354662, -1.0288921872826318, 0.3544771209626896, 0.5344107759036879, 1.360166150456743, -0.6304856477276708, -0.9281621375441906, 0.7725977515707804, 0.04288260614577206, 2.684588784317749, 1.3108815945939314, 0.10144224552153308, 1.6384200170245913, -1.0931935032505729, -2.3460058068723746, -3.39354247999377, -1.6812111105208287, 0.3636595091479528, 0.6936009737219468, -1.7000486080752792, -2.5718894020201195, 0.29102882821756304, -1.8188580154540552, 0.5236430682309673, -2.050099044923556, -0.5345615326822939, -1.3779404818042298, 1.8823441580118006, 1.4040624808042876, -0.3683800463518169, 0.3310601520346683, -0.26607538294520927, -0.6443246168500978, -0.8466739070600073, -3.1995945317892907, 2.521684059095323, -0.8912216949052952, -1.300950200815173, 0.659353362399232, 1.2237799241458094, 1.194360458676995, -1.2662256871612094, -0.18088865435928198, 0.4660881643394167, 0.09326189328829243, -2.2957091513370442, -1.4798081032202954, -1.441600907249912, 0.0443137431150431, 1.245896967297849, -0.12809009007426464, 1.6069038092682901, -1.4029469792368296, -1.4215439903111928, -0.96482713201646, -1.1514248961740645, -2.1874609249787857, 0.2826759226016476, -1.1764985721382681, 0.47793199938136005},
    {0.2054763097286476, -1.2187395858453542, -0.08528069063115884, 1.4480366114345968, -1.302203560999765, -0.9956060845854027, 1.8552421500030436, 1.6115714882905545, 1.837692035753667, -1.268234019545217, 2.1687953686069776, -1.0770044626760182, -0.7428013825526377, 1.6697851720701435, 1.1421151859268717, 1.4292358383061337, -0.33543599711776784, -0.13861372399034305, 0.7472075522179275, 0.38621031610344725, -0.7286594040357427, 0.04396957255740934, -0.9621337755675605, -0.26363506984274765, -1.1806295132081523, 1.0530162721502119, -0.4064798815029601, -1.8285059610350152, 0.45296044596250556, -0.39883516508822436, -1.287048661080681, -0.29364288675503875, -0.5532029737980481, 0.1682620425557181, 0.7285950584050858, 0.22988042023763036, -0.7995122852457549, 0.23723236698665384, -0.2699531572365599, 1.1829518066717466, -1.8830690726136181, -0.4387248501536257, 0.3183704297915586, 0.05090460049622745, -1.4941664070930718, -0.9014881056480069, -0.7609768262626627, 0.16822778049797973, -1.4654623609648219, 1.0859555173984519, 0.062224650448041915, -1.4342713851137716, 1.4688025592455873, 0.30923821565030335, -1.3145978590927607, -0.15186426300141284, -0.8348225462708478, -0.5130539104670477, -0.4030802120259207, 0.8920525256992846, -1.2993902606712333, 0.14300821805234767, -1.1316134802319033, -2.647464521158346},
    {-0.9146911454462274, -1.900797857628236, 0.5687020555836192, 0.010287552131739165, 1.4677664015386171, 0.8780331199331725, 0.2604325501837638, -1.8702982385383617, -0.785233323141521, 0.010954549600481053, -2.009893651079088, -3.3797447538971626, -0.5689787420742082, 1.2188834859142448, -0.07815616779059308, 0.2157932741504727, -1.0897823754570182, -1.5290775657495586, -2.3507616890606187, -0.7938647813724167, 2.649774232547073, -0.03953292470460657, -1.6389029572965441, 0.1956162947516449, 0.8969218929599555, 1.1978599007908843, 1.7484221523429107, -2.0156745293308638, -0.13942561424971373, -0.3376337577500685, -0.2422298813116479, -0.355584780756763, 0.9873153707025636, -0.2167187170882063, -0.25523418397942726, 1.3653758048689064, -0.09034363287164583, 0.7139386168510501, -0.5327268472924221, 0.6621472464550445, -1.8582851311720632, 1.4293884739105351, -1.9516500256711462, 1.7794855315928049, -0.9343303446431376, -1.159429622694612, -3.110010342493669, 1.177451305583404, 0.04650055129994236, 0.7801651222079488, 0.9440710487845829, 1.7812614335468906, 0.6722377617768344, 0.20918905055809553, 1.028833652100879, -1.769662747123529, 0.02559073431567177, 0.3535536517424094, 1.0063040386244575, -0.2011095559752737, 1.1168423313341256, -0.5689559245659133, -1.2610125109659256, -0.7282096333827422},
    {-0.5541113698889673, -0.12586274999032881, 1.2332708195746604, 0.7956784141838822, -1.1187712279249895, -0.329788912157026, -1.1292001717323499, -0.7074696535758783, 0.20910039671657876, -2.8466917547751773, -1.1210196334739928, -0.5880821139184998, -1.511944200846071, 0.12286211539916796, -0.6854488275032142, -0.9813635418221454, -2.198604258723471, 0.04138159733615978, -0.7525636311830936, -0.8862300034971728, -0.5685901924373042, 0.47438882001538574, -0.4152638524288694, -0.19615067308224188, 1.5160420003893167, 1.1069428594827497, -0.5813204137474237, 0.41676851707794704, -0.7197964718965322, 0.05097101931972663, -0.5174208451887061, 0.9588544190288915, -0.21784290188102695, 1.1154872685938038, 2.3496793349458263, -0.8711124940517461, -0.8511756956392325, -0.3481701324739845, -0.9555731574262848, -0.2490097330277008, 0.3952308069877601, -0.01655164814633656, -0.3457583823527588, 0.8800938519165351, -1.2393188292899289, -0.01626083423674657, 1.0047376851207297, 0.07603983282793016, 1.1101431845773373, 0.15736103830473727, -0.2928723084273671, -1.1454171536658868, 1.2077606682050113, -1.897826588425257, -0.3968311477889689, 0.14538079776641966, 0.494639165969518, 1.6492374094123463, -2.502891847130128, -0.7945850486396353, -3.330547753081027, -1.2684738304837933, 1.738386650108306, 0.49846391558923664},
    {1.6248666373353575, -1.4869476519585572, -0.09795304853068651, 0.7744341656322788, -0.40532709277199375, 1.1256727950481302, -1.8072813280260227, 0.09351726390774878, 0.8376946945355289, -1.8534163199393774, 0.3187500489747133, -1.3789682095173388, -0.4813991853695628, 1.0597860985279288, -0.4535400807573846, -1.6168985386026244, -1.5807429467645446, -0.9156229753212154, 1.9671688346966107, 0.7699012837645557, -0.005989596423853045, 0.2472529563019421, -0.6577767957320172, -1.6381017772852433, -0.9487206448948272, -0.06655176156151109, -0.5330926193138971, -0.6165968712626736, -0.7041200199768944, -0.11021652662649446, 2.585192839126315, -1.9449888470047465, -0.5063585053336981, -1.919065158672122, -0.8611694236265465, -0.9547337945257451, -1.6771974567965875, 0.2507747367963405, 1.0479476532434182, -1.128670374857539, -0.2614509296885159, -0.5213400826826653, -2.057468340004023, 0.5892276996058259, -0.7444646888014204, -0.20656983204611, 0.6704761330716379, -0.09150674694042768, 0.6992650715523536, 1.3048477420937226, 0.9008088131060233, -0.6146470585989682, 0.22796554028929386, 0.9055262818224903, -1.7132052094616552, 0.353450160427891, -0.601316256339655, 0.5429910689697303, 0.9466681111408631, -0.5911814520375797, -1.6674036092402984, -0.5717981694242092, 0.8880697559679861, 0.7141175025123654},
    {-0.32443633539564454, -0.3857149305967797, -0.17741343585148628, 1.4327033018770874, 0.15386138181564682, -2.1755208098269088, -1.3220605687330758, 2.199911488778056, -1.4617057305675696, 0.08095719672531719, 1.0072443947661065, -0.34676969853003453, 2.106756235179564, -0.491072792482801, 2.5521585616239446, -0.09232421367460884, 0.4764582994470203, 2.618351729131226, 0.04059899660162335, -0.7840754478748543, 1.1467934167880418, -0.8077487138993219, 1.6376242112964916, 0.07815295137231724, 0.23704230552632666, -2.861524078462779, 0.37878228437018974, -0.4950081522255337, -1.4742963637123518, -0.7711742206578043, 0.8332548613128767, -0.33623656673008545, -0.5441769558257613, 0.7259386167322864, 1.030199066064177, 0.7274414405740931, 0.9710971770328393, 2.2453023774680565, -0.29255818551186874, -0.3278530087820973, -0.5770023447920002, -2.4877596802204445, -0.2748276003012136, 0.9719504034628708, -0.6677911307340064, 0.4364984252439901, -2.0245117830685273, 1.6284657471682975, 0.4967276826477518, -1.2712020465018992, 0.530207104939224, -0.35339286655256436, -0.008958888900137404, -1.799117137052229, -0.590560594924418, 1.4546701573012664, 0.05593937505600973, 1.9430005929086216, -0.21354102430693836, -0.46808690128239117, -0.239096698346853, -0.3552711845737712, 0.4096998745568778, 0.5680384853455797},
    {0.8005231122782721, -0.8161876428406575, -0.10842490910900558, -0.7265291573266693, -1.129286478784686, -0.29479887598845755, -1.5237957979897812, 1.6415966855140618, -0.23815986548529175, 0.9407343051956547, -0.14098661211384572, -0.2193324615816452, 1.218206995261222, 0.15933895447817997, -0.5293988258738987, 4.029332925829329, -0.23687452036635195, -0.4797840538005951, 0.8591182536061939, 0.7372347441721048, -1.0242638720803516, 3.040322802527472, 0.8077611643892638, 1.7023570086338453, 0.28825787827211163, 1.0178850421467431, 0.23959260913506766, 0.14851878509665714, -1.306656596074797, -0.9978532104578595, -0.4113830776230166, -0.22961790548682603, -3.819806116376577, 0.5087570007727487, 0.42687129483168573, -0.04070726084393882, -1.2502939673102411, 0.18796142196990856, 2.853942484987042, 0.4723787374924015, 0.3215398815226676, -0.4336501898009307, -0.44919299091350834, 1.2756376586170795, -1.9404506022447026, 0.1760681207046873, 1.8396068040258133, 0.9507495510973036, -1.8604011713829824, -1.4795808585279921, 0.401395818719468, 0.9522982444244434, 0.9995335773436331, 1.1903715893845324, 0.6658848857224084, 0.35922749747831934, -0.41922217970463593, -1.5512186835059323, 0.6597388035500463, 1.4762147661761447, 0.09089802032570404, -0.4692025377070752, 1.9986936998044358, -0.2860798881732332},
    {-0.9742170399564088, -0.2417692681346963, 2.597016904345471, 0.11737449742933581, -0.3682448771039239, 1.2618363437498188, -0.18396620634557645, 0.6095899312042642, -0.6319126518676561, -0.8356704400787882, -1.3929516648782116, -0.2040189302734535, 1.5971167448899417, -0.031076307175717185, 1.2403813893089175, -1.224905784983886, -0.6601131297089737, -1.2588214585457358, -0.8265228537460871, -0.6638742874640494, -1.2867522789762653, -0.23969374277566508, -0.11789223202661615, -1.8048490536356143, -0.38820319624722804, 1.9080222010374681, -0.021688901538618785, 0.7933849123763254, -0.5205674747021085, -0.03379424737680273, -1.2669141486686977, -0.6990606283540803, -0.47296665319835035, -0.7260084612377252, -0.3478478262709678, -1.3494319239696158, 0.1773941367746904, -0.29565916285852034, 0.5150533996193417, -1.4733045947057055, -0.30752625493997104, 0.7809977120857262, -0.1568207486126832, -0.7397682077457923, -0.5125591230770227, -0.00418273048240853, -0.22079917477839345, 0.5556159503395912, -0.3085743164718416, -0.6597254047202699, 1.1061906420667147, -0.5998515322107382, -1.8955312121592003, -1.216603648315442, -0.8897077118953995, 0.6175895489858176, 0.26315870785742373, -1.9725154029280687, -1.270229982264179, 0.18973381028853445, -1.6034012013508752, 1.4751287684525067, -0.7619197423437257, -0.12039563875838252},
    {-0.5567913705451003, 0.4080016327212535, -0.22708598215647144, -0.6280611462820154, -1.180183159943845, 0.5128340653042864, 0.4416255143693122, -1.0551730238720651, -2.9821228091236995, -1.251800566570561, -2.89563959596129, 0.6137912766631309, -0.33531781322802756, -0.9605483690685342, -0.1577143693317898, 0.6127654076912773, 0.3523889429416156, -1.1208596076573303, -0.8271180327061963, 0.037582649158391906, -2.0063778035320143, 1.4700015997246687, 1.5195844114572707, -0.6308190675631778, 0.6003547527911409, -0.2634625780730277, 1.8625860846573548, 1.6525363525571637, -0.8550066154832985, 0.31645414637628055, 1.2659794574153673, -0.011631188981971324, -1.517163236987072, -0.9773759337916087, -1.0406286049106865, 2.1284182833486693, 0.4988558950919527, -0.6075991252989925, -1.063009693907923, 0.13261229076337733, 0.524846875697563, 2.2730651656244336, -1.3686894398124745, -1.0684239111842102, -1.416632117542951, 0.24171917499904036, 0.31662919732766115, -0.7738309100201187, -0.8847372489869069, 0.9937066169323787, -1.2180245047153533, 0.9818721528146355, 2.0676004679384574, 1.0472480635029453, 1.1654139502622036, 2.1297994599075514, -0.8210988517672067, -1.1181693957052548, 0.7296157500965439, -0.6439481043335797, 0.9608657066852446, -2.926274944811152, 0.2897169937894424, -2.338981903744393},
    {1.4013568964877572, 0.5256899176274059, -0.523235349406932, 0.9794764065607168, 2.799873661689242, -1.6102185325920524, 0.8528599274436365, 0.477171720668029, 0.781590858258665, -0.26798094679088325, 0.5472442499660061, -1.2623719305597496, 0.7641780500196118, -1.5977595616056137, -1.86079531163239, 2.3778816708851687, -0.5962103666957101, 0.5022030395542482, -0.4668868779001166, -0.6432462718758516, -0.3411604789104605, 0.7740811257993089, -0.6841821480504635, -0.8931754178482938, -1.0359415982758287, 0.874201866932596, -0.03799714343814917, 0.2681097527974499, 0.08475466232602007, 0.7245161802197623, -0.5574167579782696, -0.5560645363392622, 0.2572803023202854, 1.1560801679101345, -1.4296326625036102, 1.7731995433097023, 0.044063642331178064, -1.187733031708759, 0.13090727775556013, 1.4745085614185456, 0.4070495894793621, 0.5200412540574773, -0.5909062687516589, -0.630968697914234, -0.03957603576027508, 0.14338183615474767, 1.6756343851816244, 0.5488519622445703, 0.15706103736354263, -0.2481988169993942, 0.2579171885222363, -0.34639132595888117, -1.6994635088414975, -0.7811681901631183, 0.38931715234175196, -1.0391325059910472, -0.6751303831499664, 1.2410143566474165, 0.5625887911266694, 0.013410853505244234, 1.0573176925331278, -0.12455065011482128, 0.34647087455739084, -0.16550364779462778},
    {-0.9660793454158086, -0.9030318162703767, 1.9693623600766015, -1.93294055143297, -0.4352955091648038, -0.41314852196400775, -0.3545883941085564, -1.2636537466989926, -2.000493483541221, 1.7900214688357623, -0.4947036423264821, -1.7432305343049033, -0.260172104238341, 0.6377237492682492, -0.7241054244408379, -1.2321324687600013, 1.0165057992547444, 1.8411376902815546, 0.40237812781846855, -1.020601859236131, -1.1936419428556355, 0.00985008232552441, 1.1528716232559622, 0.6074056928318878, 0.33102931007237385, 0.49068245012755507, -0.7972538138409928, -1.2872186852901442, 1.6550276186639092, -1.7762989345507214, -1.0178992711356782, 0.7757805165066062, -0.06053591278388812, 1.039618025622797, 0.41255029539604343, 0.4421111990142233, -0.0172551500570012, -1.1581667651071987, 2.521015464142565, 0.7616727465106804, -0.9965464060934928, -2.2137236225333243, 0.679044796877496, -1.1559252315846271, 0.24961976473701483, -0.28528480484714513, -1.2818254911242783, -1.3532828092042053, -1.5657086288067585, 0.09838487807520477, -0.5929074501912501, -1.1363126117716496, -0.9383616407292465, 0.005785569111790279, -0.04993662046649818, -0.6713933168714106, -0.7720078333457292, 1.2768321171813728, -0.7209660782007654, 0.5104656237573723, 1.4489931157268603, -0.22975708918881696, 0.9167173084905907, 0.2860648668301926},
    {-0.36165587068046295, 1.690909006077898, -0.13562215758668528, 0.8498795707178176, -1.9925985178932595, -0.5618794828963903, -2.018954329984843, 0.8862193334377917, 0.020622067866358194, 0.6908850482735037, -1.6967295542594516, -0.8597084119074757, -2.548392085883521, -0.8666475015297975, -0.30594065477647464, -1.3693713561825704, 1.295468518322892, -2.146703527277196, -3.0752140008101123, -1.0573058034548561, 0.7421869835252954, -0.6387831882923356, 0.1760862265345898, -1.4183404036491931, 1.403629444973139, 0.06474292893675485, 0.5212639131387045, -0.052192214439001815, 0.6067703134620194, 0.298051813430901, 0.49381999462583887, 0.1910400558201071, -2.6070914478500105, -0.4775632617033705, -0.1062936401772538, -0.852392800555565, -0.5666391764793467, 0.8584114478045662, -0.10295045256601967, -0.8520043621615341, -0.6998201318299249, -0.6322162986228455, -2.047978017942548, 0.3515285312801963, -0.18576186133146125, -1.4929621125012895, -1.250354114477404, -0.11908277663452968, -1.4850411815382802, 1.7247104025699893, 0.7731168427010687, 0.7915808787636521, 0.3262549138819502, -1.9881211130311656, -0.40364496615641043, 0.6449683341883125, -0.4274914726501354, 0.18954047340456243, -2.8549866355933102, 0.06226859022090986, -0.004817248036447484, -0.2591100318884945, 0.4604380251642809, -0.4947078584760814},
    {-1.464247865457334, 0.9993623161394415, -0.6256754110118935, -0.0854799672294153, 1.5038892190043502, 1.6769401871885838, -0.8650745963686279, 0.14807718167731956, -1.1979388201303638, 0.14736457984298465, -0.029566039788805898, -0.455292915821697, 0.9228824273308819, -0.731595054095837, -0.6036488922224286, -0.13471416632783242, 1.535480735172587, 0.699762285694965, -1.862031378710328, -0.10986877235314717, 0.11341629499910481, -0.297293809789448, 0.041618126642634035, -0.7671238546901319, -1.5072203414241239, 1.0901393679861042, -0.5859758112930205, -1.784265544471052, -1.3091696312427938, -0.7978052396109272, -0.9771134011310265, 0.5798591183480827, 0.3897975615380666, -0.7256930507923092, -0.5561782407454029, -0.014129805894623386, -1.7215055082772865, -1.4687785160564077, 0.7379234643812268, 1.5862645902208905, 0.24220560858584816, -0.7691520638587508, -2.239238830877019, -0.1321624593602484, 1.6460117521718496, 1.5271918859230598, -0.42934351028270606, -0.5406780771405717, 0.6091535985478819, -0.0652423875948704, -2.088955880227543, -0.3530800056759305, -0.367853330957249, 0.3053325509654914, -0.9012586605556583, -2.0169012897445673, 0.5157780642400684, -0.33737606563754735, -0.27985703905528986, 0.46533865982831096, 0.252255093563198, 0.24556291209847647, 0.3295062398669344, -3.1837044365370173},
    {-0.9672742681682571, 1.971680442657794, -0.3834596015658482, -1.6242765108979815, 0.32030008320517617, -0.4611760446667798, -1.3610826467845838, -0.3679985049370891, 0.3416623440745838, -0.34173634550769594, 0.04034496370275804, -1.2124261256719395, 2.0772077671001257, 0.33973339663168595, 0.2635740198976204, 0.35556333906830606, -1.212583144952583, 0.6489371273379873, 1.1675366738455915, -0.6890100237469148, 0.5544530439578016, 0.7681458118466423, 0.5994422189091002, 1.0531484545275203, 1.6437048289886982, 0.04488223783380308, -2.230965668909906, 0.09891111665802227, 0.3423776270842142, -0.7262706247399427, -1.272938706661366, -1.7600306488673116, -1.052075157218336, -0.31406793955164225, 0.2987371569681961, -0.0844451931716108, -1.525262363631018, 2.095629900055146, -0.7796092868580189, 2.2131502594430135, -1.2680752029031124, 0.0616008083393319, -1.1201443023876043, -0.7015852746259954, -1.2819891044940042, -0.779440962665998, 0.6043767161741165, 3.0257631137796364, 1.3096204004285141, -0.2832171958270759, -1.0969310620128492, -0.8647816648555843, 0.586188591676198, -1.0392724882810007, -1.3099387761386825, -0.922086533165656, 0.48625516996385265, -0.5132382394750974, 0.8464587264421224, -0.6540075578694678, -0.49211090093411763, -0.4740958741186965, 0.936961988430509, 1.72686651614223},
    {-0.05215212647055443, -0.5211384019794728, 1.3613016828869287, -0.986044932139424, 1.5310815434067535, -2.093054108141558, -1.6368966964904939, -0.2564539918003907, -2.0626128682039817, 0.16938888040790842, -2.726954955464475, 1.1089328433604844, 1.163502070238924, -0.8221771943961553, -0.7651305129144034, -2.269630009843665, 0.906871511864831, 0.776736205442177, -0.5390872372688434, -2.3486096518541313, 0.9843994640665694, 2.065573186812797, 0.15421241865511862, 0.014070416566536112, 0.4028745193152926, 1.4024320081258241, -0.6202341797587755, -1.3309400445304842, 0.6187895021376767, 1.7486365137042694, -0.3596661879092878, -0.9354103900981345, -0.8372046450090574, 0.6954595096949269, 0.8135736439366218, 0.45767656263674017, 0.6040217133989666, 1.158091904420296, 0.5790929816561117, 1.894892828140984, -0.41909220490475774, 0.1951141823967937, 0.2809762549891564, 0.2941101046697162, -1.2183819617083078, -0.7890216231315529, 0.337205713288203, 1.0262330418750976, -0.22163818161900212, -0.5560297490952791, 0.5676136369899523, 1.2808575086467282, -0.8223939816661201, -1.4870966447330776, -0.060692439969501064, 1.8403732766391938, -0.26320210025287855, -0.9836613560457905, -0.44510484669169414, -0.9266601783644435, -1.6354798601492089, -1.7516609266354206, -0.5283879812738804, -0.4246944890135634},
    {-0.162951434311999, -0.07752267304332984, 1.1160855001676833, -0.41281098042066133, -0.570433717266712, 0.3038476701966022, 1.0908225464723305, -1.3786443825637555, 0.5018948521898909, -0.6288768506066887, -0.8362402840379142, -0.9185298945177002, 0.16434671541217136, -1.9320689579495538, -0.6786566090180804, 0.3320192390960319, -1.221577690862496, -1.0528689680578087, -1.282518321063687, 2.0001922557280944, 1.222729986322861, 0.887968778125133, 1.1903785218066008, -2.532233592061342, -1.6142337027227223, -0.07847996895856975, -1.425788426724742, 0.6398481160814528, -2.3142681976831714, -1.1592270835118494, 1.3058429092367838, 0.2857768318908783, 1.8287599942439823, 0.025807538974304604, -0.5352460963300242, 0.3965923897504817, 0.8524368841812362, -2.611187163156156, 2.2418207342173972, -0.3632978703007412, -0.39549123870928427, -0.44518624563859943, -1.9080823303122851, 1.1683645625326238, 1.0507183831215134, -0.46428249961323204, -0.2503620457148251, -0.909990611724226, 2.1034362515602907, -0.2588331871015978, 0.5170287424977523, -1.7171109657822778, 0.5466774836155397, -0.5798311987469393, -2.0944916716523405, -0.15843951221750238, -2.4735125642516493, -0.530235402134719, -1.1100287419867079, 1.2284608374410637, -0.4781895546129216, -0.41455583419729597, 0.39963996968427384, 0.398379704861526},
    {1.6222246137733984, -0.3691191780759021, 0.7688551368370209, 0.5808871588086423, 2.6797819504211784, -0.9531641041280642, 2.2004500003970633, 0.886998528904527, -0.16908014680914674, -0.5917846698885596, -1.7944964619863621, -1.5988491314119504, -1.662512421018247, -0.5250657631832881, -0.21402822904647803, 0.46433545063782555, -0.39981381990366005, 0.5306662855361172, 0.032047762147128456, 1.4514031463671697, 0.5346680632738596, -1.154638397430457, 0.6732657229821079, -0.9155539777700995, -2.034873284095348, 0.7489461526443804, -1.1398420433177514, 1.368573463455188, -1.329317179923191, 0.8276478677943702, -0.3040963813321015, -1.0171594981624004, -0.09774046296748128, -0.7620380418793201, 2.464486610848877, 0.5874044888597562, -0.22843768559223795, 0.9866385389052261, -1.4597427653374881, -0.3629434036074274, -2.1905838206816957, 1.5571991672469327, -1.5521559487277192, 0.3270572509470905, 0.8266789137184025, -0.6473869561927147, -1.07087790434876, 0.11563663686873354, 0.020714484427051545, 1.9406526955647165, -1.0951371849600469, -0.10876258936491283, 0.5103089618077056, -0.6931577997254073, -1.535526947018988, -1.4936496739652578, 1.0070509853595133, 0.16768742546124335, 0.16853506842238036, -0.2868526913365138, -0.7548050581943808, 0.5122944337707939, 0.8727223004414275, 0.9544987601200996},
    {0.21203015750363977, -1.5243833270467597, -1.5841423925767253, 0.7868794549554186, -0.6832909737289354, -2.0476659235020875, 0.5794762248475271, -1.4956177452832753, -1.6198879563272675, 0.055753428909981466, -0.740803139948109, -0.9814292371604401, -0.4541379664177867, 0.5418204235550726, 0.6043845264798849, -1.168725853861818, 1.3049321615297713, 0.3947824687561608, -0.5047396717254043, 0.4691770464028938, -0.6977980096592691, 1.1361968054344196, 2.510876587852885, -1.45328335080068, -0.984245499942867, 0.1373019362616371, -0.35395950623380673, -0.7449948960247723, -1.8160767140562226, 0.9136867534235105, -0.5543054007060628, -0.5083174485092201, -1.0167954869465472, -0.13141942817004562, 0.7688487785213011, -0.18762544124272357, -0.8313623960297294, 0.1506004199053998, -0.5180754008774872, 1.1853213660954802, 0.3463743235334628, -0.9007131185935197, -1.1548157414294384, -0.35364601443891575, 0.18680699907133663, 0.42386412700279164, -0.17592545225212694, 1.6096862024468594, 0.1463887886869234, 0.1229649463873454, -1.142125169447699, -1.263293066454979, 1.0880268283520198, -0.11452633727199747, 2.011106890736799, -2.5081357136140308, 0.293191573323728, 0.818609369081044, -1.7899111996975037, -2.0055182680124943, 1.109256291627587, 0.05637921157470528, -1.1406000668240894, 0.050975788826511714},
    {-1.4861944708731634, -0.23066862542711147, -0.39053615891876153, -1.091900560653676, -0.08529617985534958, 0.6620949150793067, -1.1821205205661527, 0.1509896993141245, -2.3794897548173592, 0.5852974704790288, 0.7825147681751157, -2.0870433812860893, -2.059595311810166, -1.4282778373247786, 0.22952702842628833, -0.05775442056771203, -0.8557396084701958, -0.01660264142479986, -0.7106979141238401, -2.0446214279488837, -0.08607874593289942, 0.3442040451148436, 0.6111223742416285, -0.13034433909489962, -0.7411516484542136, 0.2536071831915372, 3.3074265320324474, -0.6977174849483079, -0.9928942896133375, 0.07135427915467964, 1.8145847958012085, -0.611690133000164, -0.24928162197635323, -0.12466525289931868, -0.3842131967291598, 1.4693423532720176, -0.28535589835871344, -2.3187037805697064, 1.5474291451696196, 0.34158992755294265, -1.068815423999278, 0.5720611346941562, -0.9348558761950236, -1.104663753692407, -0.2187101337851336, -1.16214057712374, -0.9817812833556662, -0.041757485578973005, 0.07702151909405726, -0.4726982067476842, 2.165592785148573, 0.41846720980843144, -0.7270017577817073, 0.5929430022312325, -0.7821608260413121, 0.29834493578204146, 2.553996658805641, -3.423376431033245, -1.3183231861247802, 0.08372372645890352, -1.8237321512540026, 0.8341997529204181, -3.312296539564721, -0.6983102189083381},
    {0.4133978579334357, -1.526592609247584, -1.425713865372033, 0.41781033521846656, 1.3362456015985125, -1.2521955754512, 1.7495130979503217, -0.5442995989194567, -1.0566921083677812, -2.0188367697748775, -1.3780848014321794, -0.7700387203860776, -0.8509760190519656, 0.38146152171966086, 2.9510366875851797, -2.21211353683326, -0.019336058443866093, -0.8571404076170221, 1.183431364698407, 0.3023684065312016, 1.4178959767916395, 0.17853758268258532, 0.5970057926966177, 1.8659899613175903, 0.644059825532778, 1.3607800056198698, -0.7376032202445713, -0.936474511333098, -1.3291885999055562, -0.6182032790482056, 0.7737407870971639, -1.7171194121442483, -1.4173614806459656, -0.5110840608683077, -1.2252898069300315, -1.0116845068737412, -1.7386972300959342, 0.4118125071782431, 1.4927913007512268, -0.1919864910916274, -0.24363137869607487, -0.9316291138673127, -0.6029249758959072, -0.6035852410289044, 1.003316061029841, -0.8967080985980779, -0.36551059508626743, 1.2470205502091143, 0.4107819795153146, -0.6361859974688923, 0.23616890206010602, 0.34524433565290114, 0.7472811366230508, 2.1838967573941983, 0.4792246256672361, -1.4359522019564388, -0.7380535374247734, -1.9778451657232479, 0.5643797765178293, 0.2650822966030983, -0.9082268370054611, 1.8153289144611644, -1.7645731643611382, -2.3683934028953413},
    {0.7846584860131482, 0.3377659813221487, -1.1873943871468533, -0.04835215910448714, 0.6153541685003349, -3.277541369486716, 0.5087711973342844, -0.9502794811452067, -0.7091189016588355, -0.0033255323150961596, 0.059973796187668536, -0.1517406637820179, 1.7088256142419787, -1.7814511045358523, -0.6933112472709269, 0.08194414766656641, -0.9491435681552265, -0.9393730193711731, 1.0866054491804549, -0.026846523572339364, 0.08073212732469853, -1.608470962461695, 0.7808597500655274, 2.8046906566214336, -0.8140407945451549, 0.6520332072910116, 0.297682840084989, -1.0883510941607644, -0.5667649621513065, -0.11244458982729692, -1.3869988923665517, -1.1163353928317645, 0.2730287297851451, 2.5819287937859032, 0.8096395882701078, -0.04824796866867569, 0.3188967146342077, 2.2257145897113864, 1.5557659554964023, -1.9222690806494631, -0.8540289707534974, -0.842957690527607, 0.876438792907606, 0.14532043030594616, 0.8408777619417228, 0.02546363887533073, -0.8407672725009135, 0.26775148270274335, -0.6148742191155865, -0.014041566646451347, 0.8343011484254385, 0.8731330732006459, 3.304024010007385, 0.29321041139076914, 0.020500221938263057, 0.18708746290301037, 1.619964341386134, 2.2849543768211715, 1.044709431983744, -1.9151484417484814, 0.4904082050872847, 2.3525423905788507, 0.7245437649148644, -1.8915541923716161},
    {-0.16156844828101236, -1.5656114365667817, 1.5209899193866145, -0.5256623811845562, 0.39697029721583776, -0.8665719394084238, 0.3190517786724546, 1.3273502960377712, -1.1698385296974856, -0.6929538407941679, 0.7324163225030734, 1.2052353147258235, -0.22387411684298192, 1.247391697025425, 0.5860658862168643, -2.03430927981167, 1.1716737600743197, -1.2354405807507134, -2.676438497020706, -1.2915859040462783, 0.20702758843319924, 1.5239869642054225, -2.068848886728851, -1.0392448114291857, 1.0321646958563957, -0.7214857321741964, 0.9898141918106103, 0.8682121689756647, 0.05676558685721771, 1.133375377551015, 3.0452992054192443, -0.5198865185975265, 0.806400493074632, -1.0798998831842224, 0.18921640106140733, 0.5556670380020804, 0.11149081290753145, 1.1173146919848103, 0.2774236759692455, 2.9199979642579295, 0.7648898367202964, -0.3759962898257101, 0.7394419982911875, 3.5396412598719573, -2.4789768420778375, -0.0013572218834136975, -1.3075945073722557, -3.329844901823309, 0.7988295308199819, 0.7243461537656203, 1.3248544454722204, -0.6746631879830417, -1.3279152962405296, -1.6209925186749419, -2.015686961977084, -0.4537415811445008, -0.744265094488427, 1.2025045198741249, 1.874600705210684, -1.4084921674854909, -0.5550006329969338, 0.266641308304282, 1.0721552037059723, 0.8279494114345111},
    {1.7250815772843098, -0.6909518892366111, -0.19393708897638373, 0.8657988065806264, -0.0032678317950035015, 0.06339124834528324, 0.8676370205810238, 0.30076512207400113, 0.5126749162389934, 0.9078438539854532, -1.9495434163636036, -0.4141179212743906, 2.040777175753852, -1.8835302878662694, 0.8902032741453272, -2.4210932550300726, -1.4948265509702265, -1.2369774268585496, -2.5308902286961046, 1.3338060722337364, 1.2223567834833893, 0.24722870236556477, -0.06879741401741397, -1.3667781219705544, 0.8990189732577941, -1.3035377597881674, -0.6540258849242128, 1.4575627077214546, -0.15344934160342602, -3.7089204440419294, -0.3648313893147917, 0.14446681553323668, -1.0636023457934594, -1.101608967516276, 0.4066250002755569, 0.019620892943767863, -0.9134350556911087, -1.5611307463334045, -0.10413864911438042, 1.1693046237915137, 0.2702489544412361, -1.4182889549964364, -1.0770262974651132, -1.7466141694603692, -0.8924684600035017, -0.16379416464032567, 0.3218506684676266, -0.463308260324685, -1.4302610555597812, -0.024410904370675085, -1.4950845023726476, -0.12580028703411228, 1.1301103936604964, -1.9957538962613233, -1.478007114150309, 2.168352368202843, -0.3229849298825364, 1.3273397734259147, 1.7173395795642548, -0.6017066022945761, 0.8547034276988299, -0.7847865505779117, 0.9443643389143073, 0.37842331288375586},
    {-2.9152835682735256, -0.721250240323458, -0.11295721699769841, 2.190434311824414, -0.17292701864968968, 0.6465358592785907, -1.2704544842824141, 0.3196295076379757, -1.4060163810429154, 1.9100463682786224, -0.573326011325832, -0.6255757001601575, -0.9682481461840262, 1.55074586004762, 0.15909955281711968, -0.413572912086398, -0.008820709219710036, 0.833363360930557, -2.5273297942284256, -0.18144319166612094, 0.8254697435866645, -0.9834064807734636, 1.7731827760579055, 0.13519609646081623, 0.0017502710739173899, -0.029453235269026167, 0.994200005001819, 0.3193120609934662, 0.6255655991807564, 1.977398165078401, 3.3483101743068766, -0.34338134924148817, -3.4233163854303332, 1.16632766899892, -0.04711517875486798, -1.7002981041631307, -0.5587147246699429, 1.4069004818372535, 1.0340807558256537, -1.821046058116581, -3.8633762587131053, 0.3310113641581821, 0.23207913077928652, 0.8087259969783404, -0.22895825499450279, 0.4019141661031784, -0.598368179597605, 0.9890133715693097, 0.3983605532204825, 1.0965456556202982, -1.040873764821944, -0.7019064013377434, 0.8289823602260625, 0.37383296831842383, -2.5280023354355023, -2.2160742791485477, -2.2258550858859687, 0.07372170256456187, 1.626040862820718, -0.9589799227589931, -2.096977834350514, 0.28259794098933577, 1.2352226177372774, -0.24354924568483713},
    {0.7147934859763218, -0.11832663297896638, 0.019553611322179417, -0.20025958901724583, -1.589676581409389, -1.0932754056034022, -0.6714446153226747, 1.5712737052651986, 1.7064081034381335, 0.32087916514277587, -0.9843704291866253, -0.4885243736084089, -1.5198311254970385, 0.64633298219268, 1.652735893421246, 0.23103873299051356, -2.010861935165788, 1.318600664403869, 0.1591129805448866, 0.9848256383565147, -0.23354454641180908, 0.6502839332996996, -0.8038713270447041, 0.582109332169664, 3.894345383559034, -1.3311106980914147, 0.8248600321936304, 0.2258741124059424, -0.14628550063879492, -0.8497193510809237, -0.038266016595006704, -0.902348109162348, -0.5804155279919397, -0.5956469918481654, -0.4808198543216569, -0.21204926702752047, 0.36117564273054686, 0.1558071060043342, 0.09577113541053088, 0.7710384244952092, -2.1785289019999277, 0.5580830922715097, -2.236986653521821, -1.3566028841061253, -1.2438697801779068, -0.508184501192633, 1.098005486202005, 1.8865838896609142, 0.5991401201820455, 0.8310916025661907, 0.32887628803113006, -0.3198424217645294, 2.125331463974755, 0.7476108092875071, -0.3970754459471892, 0.8022953449481113, -0.32983323631323547, -1.3619755750945828, 0.7263817517867401, 0.8885981770373464, 0.6413146027452782, 0.9281699971932187, 0.8722719160172934, 0.7333952675668434},
    {-1.3869596365586687, -0.5709434806850175, 0.06182913210844952, 0.7861495289432097, 1.3006882270507358, -0.8049448291718753, 1.3465321350659525, 2.907322043526322, -0.7398328947545667, 1.5277723532022047, 0.35000621723405956, 1.4685458801635063, 2.7169652885860835, 0.4236282311513319, 0.9047957876601359, -0.5111918883151768, 0.5057067020548216, -0.41084556381727716, 0.3084933800463431, 0.7822050362769465, 1.1667685348558967, 0.7180704530718486, -0.790727436337759, -0.6469272634888084, 0.11280073771505235, 0.5477406875567197, 1.1742200226158592, -2.303598763193227, 2.0377806638270424, 1.196699660202844, -1.8276993659361058, 1.2755370868364375, -0.1294419971580077, -0.4640089722140547, -1.44528815344804, -0.12966280125572768, 0.29631695162229976, -1.451143069209301, -2.660141574111712, -1.4593089923439053, -0.5914292599071057, 0.04698662769418818, 1.4145568434626432, 1.169660133261798, -0.5116552867823378, -0.8061711564235075, -2.2090206248678523, -0.3256035262448565, -0.6622765669682327, -1.9415847150880632, 1.0992799667235806, -1.3238020543026043, 1.490097057622496, -0.4892618181754442, 1.208148491284757, 0.6654957632079535, 0.2767399891204101, -0.9094286243676636, -2.2967062026748506, 1.2133364550660874, 0.8982836287419246, -1.4118516406312749, 1.03827411830604, -0.1779705907401757},
    {-0.26974648727479505, -0.8038446456904833, -1.993530289095277, 0.3668722635387433, -1.4236110231294263, -1.491954317942764, -0.167823036211433, -0.6257157267227257, 0.15951383695213048, -1.9142085620643994, 0.07224271189868356, -0.32716550153610324, -2.8537846449965363, 0.08945379658113205, 1.137220796938363, 1.037754535166694, 0.9391489336328014, -1.2342334866085334, -1.1285360299399476, 0.5971345536516195, 1.9394667661371872, 0.2931982518636367, 0.6141384942242127, -1.9163216962304246, -0.30036473244464984, 0.052618904525833926, 0.5586093235183234, 0.33267843819612447, -0.6121948282872239, -0.6831863472458519, 0.9147868373891826, 0.7746126754695093, -0.37138043360962986, 0.6713014563368452, -3.337806986350236, -0.6609372903536401, -0.08777377378335964, -1.0717353464555253, 0.08797682222439925, 1.86494823674936, 0.5750155996803781, -3.2041980609158642, 4.497798785971216, 0.35659366782787083, 0.9577712839237769, 0.8701128943721014, -0.8651775905227482, 1.576159369454532, -0.7158525404276499, 0.06965268013209278, -0.4543496170643874, 1.7700934997831168, 1.0401803486557162, -0.3914195771460997, -0.5747790550664607, -0.09772316450743025, 0.5772726602274951, -1.6262977724520489, 0.9294951620318491, 0.7976734047819575, 1.7885642183540627, -1.5424084188946083, 1.6676417570288948, 1.7525561576329682},
    {-1.5259355005041486, -0.6512966999317974, 0.7143229308205097, -1.2783836273394955, 1.763426882592775, 1.5517991910242703, 1.303289788964607, 0.41060901409273715, 0.06854835976909958, -0.6369514915616316, 2.440902269107091, 1.2077064557665542, -0.9117609638038786, 0.24723550585338247, -0.8371176406120938, 0.09594336463661671, 3.4186581001606813, -0.720010934322196, -0.23642610983178416, 1.067169080706261, 0.07516419921468237, 0.2993127871438047, -0.06635798901061955, -0.02992717143174121, -0.13659168743976452, -0.47369575357396804, 0.049810701360018944, 1.130443304288973, 2.1335160611472093, 0.1708466053336675, -1.0303915165668334, -1.0987872483470367, -0.9034117311597658, -0.19052505871365658, 0.41195760097721645, -0.7153368200683919, 0.12708533295569344, 0.9570907384252355, -1.6253674214060576, 0.4672584083187455, -0.02811098423637215, 0.8478773876166573, -1.3975734951008332, -0.27510994739535755, -0.754435531826069, 0.8995843634568774, 0.6782964870268549, 1.0595464425041072, -0.06019033313703161, 1.533017666603254, -1.6215037444457325, 2.8453713812110766, 1.4482572190828396, 0.0791296576190002, -2.2123182298495188, -1.1992676470464758, 0.6932036371384228, -1.4384497312050095, -0.377625106915342, -0.5481770486129818, 1.1263129689073321, -1.4954531074078126, 0.9251266985347119, -1.8901499949658924},
    {1.071483821135348, 2.0520395364230435, -0.7796928836638634, -1.3664723528572649, 0.8066868403418742, 1.3096731388793204, -0.9038829982988202, 0.6122148073255861, -0.7461750258930957, 1.142179243918068, -0.2676926989422774, -0.09329303054049973, 0.7550309229737662, -2.5306119409842722, 2.6776174265733412, -0.699063631147967, -1.2972772854291683, 1.499840805448513, 2.041743550080611, -0.38068207073322186, -0.5204101186383115, -1.1477961957538545, -1.9193773847055156, -0.2889601499269375, 0.17966457085248524, -1.141684308650594, -0.903009910431394, -0.4065074282074369, -0.6750791211300213, -1.4238363694308669, -0.21141674670545746, 0.742601609262408, 2.8710654903808575, 1.295780502851725, 1.5399878806097445, 1.236263787059757, -0.2886789035097752, -1.7926169995598378, -1.3288424013874434, -1.5629306402461958, -0.37201940853587057, 1.2926210675148326, -1.173726326352117, -1.6579441975905302, -0.8799163947153789, 1.7730088583419215, 0.06826648581403964, -1.575709739446347, -0.21929388487588006, 1.2661261099081855, 0.19127296786500297, -1.5961167095584774, 2.985696636198237, -0.19331174706804996, -1.6374271662571978, 1.004406124918445, -0.0766734311884219, -1.7840987187143686, 1.0749424919242985, 1.9059928946206681, 1.2742033306941893, -0.6825642614555439, 1.2957282185238266, 0.8551900670709482}
};

static const float b1[64] = {2.167696809026892, 2.830492652215074, 1.8802800571140492, 2.283098452727412, 2.6669759646103763, 2.6946941201032972, 2.4584151024595124, 2.092747623009911, 1.7190866590019758, 2.025365334137817, 2.860910465485995, 3.0923239064480197, 1.74471278850033, 2.217117360189348, 2.3004675978167435, 2.405361371223891, 2.1208333943172573, 2.178084405396223, 3.0633839211895566, 2.426364618927496, 2.3078014928777875, 2.049499847594976, 1.6258542132634222, 1.8781382851777215, 2.4537375492195626, 2.07589276709149, 3.0632675921230628, 0.8510663682937686, 2.7615951044459592, 2.7846741330651574, 1.7463774310881686, 2.7779401959952956, 1.797902916866918, 1.424264534541938, 2.0434474464045342, 2.0075197146208965, 0.8717520539613349, 2.257703885175585, 2.4715262395281425, 2.7765165364883195, 2.7227924405933237, 2.5431905356854956, 2.432065635753148, 2.898098315934989, 2.6532736305587985, 0.45773062359481764, 1.9156252357966437, 2.8572128994053823, 1.9788054309642888, 1.4081059628195176, 2.3267570766500816, 2.1504643981502354, 2.8367853462253088, 2.1391461747439893, 2.2063903268833096, 2.3121346167429904, 2.750377329158175, 2.6447780395098226, 2.707185869121523, 2.901826134515803, 2.684032271351745, 1.7967358432104346, 2.226338333295373, 2.46050101551209};

static const float w2[64][32] = {
    {0.9566132785010901, 2.793173520281564, 1.2824542847471503, 1.6377104080503535, -1.3066876590102312, -1.7093833191404053, -0.4367952043590388, 1.3401052411628165, 1.6987382501067052, 0.2994602977270853, 0.15409756184214776, 1.4369603074869246, 3.7247481025251963, -0.5056540431357294, 0.9042597601043103, 2.675552149137196, 1.0316612031220354, 3.964360705567553, 2.784238779675308, 0.5614776333484331, 0.8748008185854598, 2.31419366592291, 0.10654493730148477, 2.317177876834675, 2.0322791852946342, 1.4290405273203746, 0.49568250955950016, 1.7873923230842166, 3.318180049760894, -0.03305400050053284, 1.883857994534413, -0.21209116747777695},
    {1.551020531243379, 3.1595714817263847, 1.3616829528028418, 0.3362520587734545, -1.5444174547200122, 0.8290995711315312, -0.24426015877141707, 1.7534871345890821, 3.670737452916849, 0.43403576481298695, -0.2416037775932856, 1.524583030175834, 2.91960005431295, -1.8529676177948442, 0.3420356080765095, 1.886463423221705, 1.2463768530688208, 1.3897214566739888, 1.8438444430699912, 1.846011220070314, 0.5530918363132903, 1.0358123137408777, -0.7080200755258114, 0.9863711943907982, -0.21902722071726635, 3.461417749963794, 1.13962745839708, -0.7681423400868922, 0.72166509780583, 0.7046866488815703, 1.4388787271785508, 0.4784056092520716},
    {2.087734037973702, 0.016811381461126252, -0.091914627606073, -0.1576098380743767, -2.014045888938323, 1.1390290504032912, 0.5659758412055166, 2.4732564335973444, 1.7062153591487774, 0.8659461020480601, 0.22152718771845814, 0.5684811439317208, 0.6819710587302441, 0.7983730714622843, 0.7463890519113255, 1.68784267568678, 0.5721917114979432, 0.8967218394168023, 3.0222154669271086, 1.835141306863671, 0.6216598028679031, 0.1709231111642446, -2.7138426553133685, 2.47506261254639, 1.2681173493273954, 1.6805681296983934, 0.4372791569224699, 2.177701840126782, -0.23623022117264686, 1.3887065666234066, -0.5444482178678386, 0.15040060437587593},
    {1.527834545652521, -0.043174081530079594, 1.9355426737927506, 0.617511375808491, -0.2484326251491594, 0.4225707507033437, -1.8712385950491937, -0.06842873361023606, 1.5930301834272036, 1.6278789444711825, 1.0116370716689622, 0.5233032956110577, 1.5541808176738334, 0.8792747341490834, 0.16910856575976563, 1.3073792753671278, 1.2775237576863865, 1.6393723182484652, 2.109829539326663, 2.3007089728995447, -1.0984074843070442, 2.356559517043777, 0.39607790770537693, 4.001894244241205, 0.08823155759995, 2.7079495720595737, 1.3833520504821635, -0.5102589225064375, 3.457731619096467, 0.4282025575813495, 3.7954240567346615, 0.5619052918657143},
    {2.425836702300879, 1.3279648282382224, 0.9073240993888186, 0.7369757777476222, -0.1999978442820589, 0.6137076791560435, -1.261484190505888, 1.954549981242126, 2.6563605375720685, -0.35657461742079427, 1.980600870765352, 1.1857767944835478, 2.281399049345944, -0.5066354295192605, 1.38176807613456, 1.50571986085987, 1.9317308282213634, 0.9982631947016032, 4.337970732110155, 2.229674376356316, 2.498817751661809, 1.4048302175369551, 1.7856286478667514, 2.8100063898115732, 0.45610109380043384, 0.41314389877878877, 1.4707570305765052, -0.6296795223354315, 1.842846642714874, -0.5011287910112473, -0.01624966427441277, 0.9793327386473281},
    {2.1444534049080466, -0.15528674808881657, 2.1317170732020334, 0.9893747409881141, 1.3914569322325157, -0.17962788988102615, -0.6074218776691415, 0.6674420910768732, 3.419534663780158, -0.7615930814323127, 2.4701542617668477, 2.11822956686457, 0.747663499358011, 0.6966863923703838, 0.8142240317198527, 0.7892174148821159, 0.7338274640609164, 0.9655050947236328, 1.8376547305994113, 1.3111604419104932, 0.13371822922234364, 0.28584827136322594, -0.9303011392652691, 3.791681923929806, 1.4484609209697932, 2.2664227015803404, -0.3460422786545345, 1.6213223825167546, 2.2341107471234802, -0.5887422822111197, 1.990609740223276, 0.385691869739789},
    {3.5280632290371643, 2.8632842990396963, 2.3917295189699033, 2.5773945685064885, -0.5182909243063406, -1.8444735642624506, -2.4085758071634227, 3.098988162091576, 3.5922539027818443, 1.8397534557054305, 1.130520272844443, 1.6532357693167206, 2.452766151851007, 1.0955741648352324, 0.4941524495104907, 1.0447480326783274, 1.3941340271370644, 1.7687219983265865, 2.1813313078783203, 1.627966316205623, 0.02027457960924482, 1.973493869311048, -0.8245778426793623, 2.3131073155983626, 0.9423678832249452, 2.2994098187907155, 1.6907957913797282, 0.9926537084120645, 2.52295030228838, -0.9089936660957424, 2.24362056083131, 1.398931871449355},
    {1.3999584126830873, 1.6636013081443977, 0.384515400477115, 0.8040752767346324, 0.41651375311071664, 1.3435427479037283, 0.14600807328345844, 3.2116925370903258, 2.405334419468033, -1.263844185792838, 0.561461407298537, 1.2326231002321821, 0.23779366365660767, 0.35318601025788354, 2.4809673375448984, 0.8109599691215272, 2.6377632041155423, 2.7012700662860407, 2.428197413242137, 2.9496670391526827, -0.7201912153246885, 2.5018629473429224, -0.3984874845818023, 1.4552322290980204, 1.1981068595930795, 2.9056443596001778, 1.281394647726172, 1.8609785544610828, 2.026564272742392, -1.5041110734985488, 2.5280476933800977, 0.8001109252480129},
    {0.835897319265002, 0.6607801507430214, 1.8662892209165998, 2.962770579812727, 1.907166991212248, 1.0441400561465644, -0.27245424889068015, 1.2398663540497143, 0.8204288908833962, 0.12489000102537508, 0.13115760084183253, 2.585799848980213, 1.7174978027415337, 0.5538143690417939, 2.0359737965690368, 2.801451540950344, 2.11593185626178, 0.6340459942521199, 2.5147818515956506, 2.7249819016096164, -0.1920608139793084, 2.1351697096746363, 0.32343287093925993, 2.255433175453102, 1.4735781352573938, 3.1993215538526303, 0.4037586058095023, 0.9054250401432905, 0.6899194747296061, -0.9434404096286746, 3.475906630561658, 0.9838612379069025},
    {0.713999566347488, 1.8088892321228618, 1.021480143565784, 1.6451261866403994, -0.8192883304958657, 0.11857550214075653, 0.39713029772189323, 2.5098408848310516, 1.9133025664860446, -0.7231851275721347, 0.765689692016609, 1.6780157603924146, 1.9820409171292659, -0.24869750792991016, 1.7784660859725356, 1.9800629819954072, 0.4594309573568267, 3.461246124655502, 0.5624627802892131, 1.192420565690085, 0.7023469659765831, 0.8996846539879242, -0.3577906180345916, 3.037833103917789, -1.155966178613569, 0.17148610129897726, -0.32187259830584514, -0.2635458843537495, 2.470656463446229, 1.057585784496582, 2.922296227711194, 0.7621583625929529},
    {1.45578541707088, 0.26314146751910406, 2.9983915057891752, 0.6211420777771729, -1.0575022205503628, 0.1731132316158337, -0.24915697934216074, 2.576294155913826, 3.5940367806125058, -1.691218680875252, 0.38646801734678365, 1.8528261698913555, 1.7455120802659878, -1.4933777563283221, 0.4815773112332939, 0.9415046455345231, 1.8309065173407935, 2.0874771307990434, 1.7855838998100968, 0.7854385818701767, 2.4616168497692867, 1.7452795799078975, -0.7913807604046903, 2.531130154372032, 1.954839203801341, 2.4382728942682945, 0.52946981476828, 2.2085429064128848, 1.9624392746693728, -1.3529261330194768, 2.735648010368772, 1.036645521108443},
    {1.4368189497907236, 0.7968148307645246, 1.1426016485638009, 1.1269759448260512, -0.7002525752540554, 1.035755042878583, -0.7399307095461152, 0.27387430622822756, 4.512789498760623, -1.289054849630477, 1.0208233897141514, 1.2035692067363317, 1.4368637846720254, -0.9409417386535132, -0.25923425097409614, 1.7411411369516823, -0.02806101002914312, 0.5181100974157808, 0.593071453664074, 2.8396694280785155, 0.8876704665447408, 2.4274443595442663, -0.057359548757470874, 1.8771711262295265, -0.4338911349196824, 1.2552579106769337, 2.673142178016447, 0.3353161262569278, 2.3995729706543045, -0.1939929235121994, 2.0986474330455067, -0.5115742092756973},
    {-2.263936199674468, 2.946382600906394, 1.9673202509166852, 1.064883359520146, -0.27167777763105033, 1.556459925367711, -0.6382979431890984, 0.1906749835065645, 2.910275008853006, 0.7329265593182188, 1.3069030883103883, 1.9303300924944926, 2.5928508259514746, 0.4592266720252051, 0.2375877290709125, 1.6554843919182347, 2.3893026198737894, -0.7011478272008934, 1.4762437597031373, 1.1113942332271403, 0.2047731624734648, 1.7284012125885357, -3.346399496250328, 1.0782202180187905, -0.29161768084718326, 1.7565062484851879, -0.20798016454275206, -0.417319262755851, 1.2016665158105082, -2.388969288928901, 1.3926446733209485, 1.7676151132992535},
    {3.179937689129653, 1.5555488687822245, 2.09523133023341, 0.6413321075592476, -0.6828464175580949, 1.8875920200350875, 0.2835820876789419, 0.575282478513556, 1.46430858459505, 0.31457725766821176, 1.862532233924192, -0.2604207605214021, 1.4734115676795143, -1.043350690539773, 2.6276173694977607, 1.2256756570819378, -0.13786076790371105, 1.9163027035800881, 0.689116081122901, 2.798425027180935, -0.7027453668536716, 2.7232611221799874, -2.1767012391830374, 2.866124528863635, 0.3560360710676071, 2.7724200851723766, 1.293643020805238, 2.9681530964032885, 0.5057754072754488, -0.580623765375691, 2.129242559925129, 2.231305033079798},
    {2.4711436970913483, 1.1201585070689801, 1.4883634546985682, 1.1503749552146294, -1.1761619095707525, 1.718483934828753, -0.4769084577732903, 1.1783072202781049, 1.1111903632441016, -0.21158530364942277, 1.517127659284641, 0.7661684276000741, 0.882003981559369, -1.4664912220819815, -0.25939460855929813, 0.727651774782657, 1.3233751691378433, 0.09583283428932919, 2.275976343954965, 3.345875608402418, -0.38712024690036556, 0.8116862502478815, -1.0269993472167271, 1.9828772735307363, -0.38483487048451137, 1.971699259926045, 0.3551009052757914, 0.0026296361045595293, 1.379261814690553, -1.0453706184482912, 1.0230269546069408, -0.021389385002502297},
    {3.3794684535957704, 2.0665180996221304, 4.688345964616171, 1.2947193980701588, 0.3876715959081543, 0.0634978916486377, 0.05982273170914856, 2.790494382988353, 2.235355089074527, -0.6327179325180896, 1.9472116717781591, 1.1431637075059706, 2.12374070823879, -1.0838274172389837, 1.5451974907039905, 2.634621658046849, 2.8212975992587137, 0.6674057335714816, 1.3385536001088336, 1.5602175006917598, 1.7666720893362977, 3.316850761409251, -0.46608853831689834, 0.5125805323395979, 0.9182098926402312, 0.6104454507024678, 0.2588637497787157, -0.18838630218744257, -0.45955547018914855, -0.3204311831505629, 1.194981835377194, 2.194623195404715},
    {3.3552465626078445, 1.161180175256404, 2.137650814364866, 0.8425062853915347, -0.5132971726783143, 0.9340469838603899, -1.6437289149448302, 2.063890180921427, 0.6045081931601074, -0.20318799460183437, 1.210200792002673, 1.767474641818554, 2.0130164552772825, -0.7177560592237795, 0.013387191738469785, 2.7211140408405194, 0.18851692264865, 1.2760008452396852, 2.036204870302483, 1.220472687029912, 1.0147233391570205, 2.018354247602529, -0.008573938698453555, 2.372412058166504, 2.3322167514981467, 2.3786096005474304, 0.8008735530571847, 1.5917519384113556, 0.7397416760396524, -1.2646617813554863, 1.416984798456661, 0.9894921557642499},
    {2.7934032854543958, -0.5919796750630006, 0.4133756145907466, 0.3736951274162932, 0.08265553969023196, -0.13509165052667882, 0.013311106981205571, 2.7542536871134686, 1.6378834477340647, 0.9100646629106758, 0.5098097920056426, 1.5783156380336625, 3.2769412764272765, -0.8393494049446193, 1.166111465456154, 1.893710848459945, 0.9550140306459415, 3.146298483649682, 1.3778453514236735, 1.6345469092417755, 2.4262469539666394, 1.5887928315743625, -1.34852676565393, 0.7063519257691806, 0.7040136185592935, 1.1769610307430598, 2.1671611029151845, 1.4106501080053637, 3.486566886764146, 0.16823829820104746, 0.7027751935623407, 1.4349443943983322},
    {1.431377504828705, 0.7151594416617684, 3.43031885829282, 0.4443414386243566, -0.5397975769143784, -0.540098150378159, 0.26163034200815827, 1.8680739969370843, 2.8169318927804556, 0.42426605879219953, 1.2550865028429559, 1.7063897553846332, 1.2139478174681255, -0.7384504104534227, -0.6137440187553416, 1.4446483090953688, 1.0980655234869798, 1.2957133891037538, 3.521919469957348, 3.1342087094495663, -0.0539781108847547, 1.5943907161512654, -0.5656427585454039, 2.2673288581460054, 0.5312290328257833, 1.8542294451241361, 0.41593055848856464, 0.8058112941951471, 2.2042337665186604, -0.45743534081365866, -0.44470632045454556, 0.011715067890950042},
    {1.8492641258446758, 1.9498188826772465, 2.101997766128886, 1.8954821287341956, -1.6602354311929444, 1.414532844130765, 0.17530086806411188, 2.907114993682842, 2.2781561364037093, 1.109986428471948, 1.5225616685024468, 2.4415272357641613, 1.47741623800867, -1.9556992476540307, 1.2537760380004221, 3.1185162268177535, -0.5025641479223376, 0.47868375017574893, 2.712092370782847, 2.5450414079771932, -0.7996856395129429, 0.8779328921079058, 0.5629327472265957, 2.0923331198076975, 1.2781164746384264, 0.18336588200554982, -0.2596572976189419, 0.6802581408141196, 2.0333036125930186, 0.5312124049058017, 0.8382642527886341, 0.7458104035404897},
    {2.8057430550949967, 1.9939273089158593, 1.875786401037918, -1.038728996767373, -1.0043700161539473, 1.1156867017220051, 1.1696550965641062, 0.4296572477833391, 1.4505179688213794, -1.1954735501271698, 0.2714552643702441, 1.6034348355761308, 3.076304485950881, 0.8967688969483467, 0.8019666704860646, 2.7548315907247374, -0.5336810204514767, 2.4995709495399048, 2.113515029234122, 3.627416066713552, 0.5059049427898459, 1.0532760118861815, 0.5285900200753171, 0.8956813665221884, 0.4502023580630136, -0.8844586407711328, -0.5532566676176083, 0.9650419930687717, 1.04884423811458, -0.295422273669482, 2.7578891872279, 1.4722114363268974},
    {2.2699029822396026, 1.663437387164652, -0.26225737193881477, 1.3359379810075953, -0.4092462279351252, 0.22476124481128007, 0.9670882771969983, 1.6826357025939158, 1.796535036255213, -0.6540556813861433, 2.2134086252573044, 3.5637500914394296, 2.980242134245736, -1.1465153369174779, 1.7007155608806006, 3.645200923777268, 0.9406700783167048, 0.6091989107487221, 1.4893403006191033, 1.2327463910622212, 0.5302686986039596, 1.3201056247796714, 0.7575779400130092, 2.1253906386443715, 1.652941638622322, 0.9890189355963909, 0.6872391733679859, 1.3486652407370225, 2.699896921603383, -0.23005799462338383, 2.2968373649098695, 0.3108416515878481},
    {1.964956571457504, 0.7127417445806995, 1.719480769455249, 1.8393692069632472, -0.6041373028143575, 1.2208344952806058, -2.051181355304874, -1.252851834270518, 0.7032805228832971, -2.3741765224822458, -0.3693972717658785, 1.1918207363954332, 3.0808135324903008, -0.4428748208704919, 0.4809718886126961, 2.401258902674901, 1.0637949584138349, 0.4762353961721745, 0.8292391670416297, 3.299130605807827, 0.07593955470309785, 2.588819711221903, 0.19982458805905648, -0.23666153215127067, 1.6496718124875762, 1.1628757384237707, 1.2427663980839319, 0.8252469055719307, 1.629957727248019, 0.4743269668055956, 1.715073503317641, 1.5683652009325186},
    {1.8072111081080982, 2.115990066041606, 1.9535444160092705, 1.548726559664498, -0.6103810543286137, -0.006297514949991874, 1.2342557692552416, 1.4171251215653284, 1.7587179922502938, -1.0296373666863536, 1.4351037876133133, 1.3152157931302044, 0.46859553821439753, 1.7185112567698984, -0.791816556492642, 1.2832284134243037, 1.162066170715261, -0.6573653044862604, 1.673473896853623, 1.1711700366566216, -0.2948783997390962, 1.8836739897275852, -1.1779505553958733, 2.1003896382645935, -1.022586617001049, 0.5761724181064659, 1.6257311871512488, 2.4845412786228542, 0.7169200884503718, -2.024441923217977, 1.4582453043606176, 0.8185814875428208},
    {0.2921610536250321, 2.4723048450298832, 2.487836329261374, 0.31012119662304494, -0.9494385717388971, 1.770580824853094, -1.367923800104278, 1.9446330474406124, 2.7435826740242377, -0.08088330457954009, -0.44744253248087873, 0.9916324799933953, -0.30791998905226964, -2.2609553772217956, 1.3424566527828328, 1.6691020604620486, 0.4006129588605145, 1.2464388583715376, 1.7083419274291978, 0.8202834566747973, -0.26924385968966347, 2.4140454815190235, -1.1029077397287466, 2.1950523100284687, 1.0084949752480932, 1.7601126502098463, 0.673626004874581, 0.52613739025407, 2.91042755169954, 0.4153785586016359, 3.5008896747397436, -0.9154739158697808},
    {0.8719664897157103, 1.6357012675733433, 1.3530053281382872, 0.7265684371857245, -0.2558770718778612, 1.097728428125524, 0.442278034702606, 2.0121454473505445, 2.8538611523639226, 0.35024217711228567, 2.952342657258776, 1.360459998764868, 0.9361994489347812, 1.5445506627788108, 3.0647096779876937, 2.0678464384806663, 0.5353366310329468, -0.7088996393183264, 3.3443432414862118, 0.2537503804237406, 0.5474413384994983, 2.788423707027804, 0.07778849137398125, 0.6923563035543061, 1.6568831099749466, 0.7905505001865641, 1.0757846346663942, 0.3380680172955746, 1.61215606020354, -1.159451828824107, 0.970111002361491, -0.984120595525812},
    {1.9745436343542853, 1.6572702742897074, 3.8982806333953572, 0.6346135613419716, -0.5914358576342228, 0.15307539290458191, -0.24167538193225527, 1.4070404536234944, 3.0646070967190786, 0.5484425724630083, 0.9695605211262477, 1.8704246491189418, 1.81272682688342, -1.4691405763520295, 1.0908564210889948, 2.3275974274683424, 2.2071501242677174, -0.36642128918054334, 1.6007914056000252, 1.537125613579167, 0.4752947564287254, 0.6143279781056683, -1.12696046882436, 2.7972362647503126, 0.4498394853815324, 1.5008978808754758, 0.3777162097047082, 0.6437247203626631, 1.3794720817353467, -1.722514782909082, 1.399177649596797, -0.7657803062961829},
    {1.9589058158617563, 0.7923033004934749, 1.0282794866497802, 0.7720391957505389, -0.02388391893383992, 1.6559681322945792, 0.498522399322918, 1.2420393691959049, 0.525308946878274, 0.6487072694478258, 1.674197247230038, 1.6684604348341705, 1.5774378193778935, -0.6528256231389783, 0.8406809465851972, 0.41663821840147697, 1.1137839646422067, 0.05513727383889832, 0.9558386455709728, 1.0879958558130653, 0.7738197531605927, 0.8326370404381175, -0.5122591310917471, 1.1822579665522794, -0.5770352026919146, 0.9463572071814682, -0.4475560400005049, 0.809174127221699, 1.7357459255103351, -0.6870421950520413, 1.0273192940367275, -0.18942603279060552},
    {0.22106194928903108, 2.384443297744101, 1.8873742727988785, 0.9668658138548948, -0.98481211457848, 1.9147517896309703, -1.593865990514654, -0.03724151858194463, 3.0642883788540907, 0.024971222012890905, 0.958918859056148, 1.562403144198221, 2.1525164998581436, 0.869680874325959, -0.720632500996263, 1.5925769248489903, 0.2556138443093003, 0.45277511553590977, 2.8652577371523638, 1.092147705370477, 0.7764163774584139, 1.637638740072721, -1.1250308805281641, 1.676200100252274, 1.424847891501646, 1.5371624067900316, 0.8384113303764404, 1.163630022383183, 2.7816297669603474, -0.02048547488923295, 2.220341953742345, 0.38745213776556625},
    {1.3889913808430994, 2.7662265446906633, 2.697834303095544, -0.047604698482796325, -1.1336150764897988, 0.5293669430971275, -0.9073277209326208, 2.1789106619112584, 2.7584753727076374, -0.9708515036533432, 1.8464225927239664, 2.3244100925884736, 1.7165032813004222, 0.05931026072140107, 0.6241339008099321, 2.0747147640562296, -0.02825835605383542, 0.690452933456395, 1.349066203515447, 1.732177058866912, -0.790375487647694, 0.8484866722444843, -0.575716564486672, 3.775055348195928, 0.21777171583927402, 1.635139245931689, 0.6775952095694467, -0.051373061748352614, 2.7991418830302304, 0.10539553731383301, 2.6258196228216097, -1.2231247824507274},
    {2.051066522555879, 2.7018601731443006, 1.2417470812432356, 2.7557716100548295, 0.04778731176038762, 1.0379006304449638, -0.41540539184214453, 1.6714686966876722, 1.9366550782546887, 0.36707818700405626, 1.1003530242239201, 1.2766704055606655, 1.845566413192033, -0.6954529342022605, 1.3908769716791862, 1.4555606560070669, 0.49957713478169763, 0.41741314731467655, 1.114167317994729, -0.04467322023462348, 1.6572902770647506, 1.9933556616001142, 0.5578360390003192, -0.337933157387174, 0.8280490319449564, 1.8861157185477309, 1.2527004945167466, 0.6990279781665859, 1.7325724710934554, 1.099869385591934, -0.043744877437905796, 0.777502018758584},
    {2.054511706164071, 0.9393699728816755, 2.1026969972171035, 1.8789232371854014, -0.26019280867299244, 1.4030715190471523, -0.9039044608949971, 1.878132879940275, 4.638073614979773, 0.7636953894302114, 0.42063838535411996, 0.830858505834857, 1.5374509886241536, -0.29105838389584837, 2.4373624172446164, 1.7942895907605105, 1.3955899319676919, -0.0626302160982771, 2.5671856143971215, 2.3617704105489636, 0.37013465925845584, 1.869103480870858, -0.36051313288836956, 3.1868493165147616, 0.6046057160110131, 2.3495305498198804, 1.97661857488329, 0.6710940662965386, 1.750324941766985, 0.4519932647864041, 2.6270444826790205, -0.45885786702843584},
    {2.2734736383913257, 0.5147003007420654, 0.9421203078065417, 2.6381874660411837, 0.30688476002450005, 1.1827468878706384, -1.122414970830819, 3.1180604033112083, 0.7122163320718813, 0.038044224489946175, 1.2789613589642232, 0.8704961197671072, 2.0933398052435064, -0.0646703518312543, 1.060824142264142, 2.22200619533104, 0.9426754290324456, 1.1482470094269217, 0.6773376865824956, 1.9738953775206602, 0.38876907109643555, 1.9449338207361884, -0.4372121882704096, 1.3415046071727674, -0.8918587542097121, 2.78375361723334, 2.169275451241182, -0.7359612457336144, 2.3478799485064243, 1.9637120516649906, 2.0092178045534075, 1.3882236978855778},
    {0.6018988986568589, 0.4720269205584357, 2.5428146974695354, 0.5076954670939461, -0.35460796090712465, -1.2131719082167893, 0.7872563903924666, 2.8539348885150644, 0.13728392470520187, 1.2755671737299796, 2.2636572081167072, 1.5365009908654645, 2.142781935717888, -0.574104489424021, 1.6952503856082286, 2.004277745072008, 0.8725544285773934, 0.9671372571942415, 1.5092385490232154, 2.62080776903667, -1.3800109843024593, 2.4333609588493608, 0.10470338652886478, 0.4890332867297941, 0.9071117618721873, 1.109417287484, 2.0810760830206405, 1.174989389229031, 1.7018915395178498, -1.7890244032678504, -0.5369174886647722, 1.1437740199111897},
    {2.332476744006811, 1.3088242033943955, 2.4988979650546086, 0.4332857382147998, -0.07499463745920361, 1.186548864501158, -0.8688437953960118, 0.6026346816921331, 1.6637169811671455, -0.1917840640757016, 1.1474962162685545, 1.4654431917953048, 0.7484920617412482, -1.3214669066405742, -0.6793743120572662, 1.74484694436493, 0.2065977113524989, 1.2625166746727798, -0.33762644735902225, 1.9063171824577578, 1.6469658518845238, 1.819890301758459, 0.3394824474581214, 3.58633944374271, 2.2326017576700266, 1.4949702255256452, 0.554974300123122, 0.794825170713492, 0.45905939963005876, 0.16667466806072337, 0.5289421445843496, -1.3400371435550336},
    {3.328308985465846, 0.5729983412112485, 2.5867839629231497, 2.4456441485416285, 1.0244664631252522, 1.0993848210085921, 1.3662873701964053, 1.8436503140618001, 1.185362838217193, 0.2894682956598222, 2.280896571769819, 0.6054199014345004, 1.5628515630534108, -1.5422626371274633, 0.06984693440485142, 1.3811986770778744, 0.29200428296208214, -0.6596696634946952, -0.04741438982458752, 1.3870831493590767, 0.369357268090736, 0.9091249372003422, -1.2853633616550733, 2.987233347657552, 2.6847252955596983, 0.9783170060845706, 1.585342081583319, 1.2040790363988771, 2.20380370641452, -0.5190111211034746, 0.7895464974228694, 1.9313209603370443},
    {1.7151773241239494, 1.0008893874670726, 1.6286266894600676, 0.9045360488490388, -0.5713355497687473, -0.9198484231874506, 0.27620278650028013, 2.4728720435393323, -0.6072451297153701, 0.5998504223515273, 0.7998902402937208, 0.3980100965390566, -0.42217897163633206, 0.08939510643902848, 0.04727351594128655, 2.4270693539746304, 0.5369001708915886, 1.7304858378734342, 1.103579631891446, 2.958323521183967, 1.4816919484326152, -0.10598959600449935, -1.3955835207956178, 1.1900998363137334, 0.35881378927281704, 1.2924788902917603, 1.8696375358386599, 0.5574059592057212, 1.741892976297347, 0.271417925783682, -0.291433702782864, 1.4287070501753403},
    {2.9934514558611425, 2.444138800694188, 2.2056048001618747, 1.1323428578921528, 1.0415867164019739, 0.3616521893455189, 0.2994003741394227, 3.0375795313988805, 2.7107318430479683, 0.3203229747326534, 1.288687541231221, 1.9435271039486044, 1.6137690348572273, 0.052079500127996226, 2.5178159764858195, 1.491234322779504, 1.1760037037485653, 1.787846128905402, 2.9914370490820517, 3.227650872064995, -2.1832766600734863, 2.269772826815515, -0.99242609795883, 0.9219798050386668, 1.244065753975352, 1.0129433122547307, -0.8989840404715795, 2.0644318556226002, 0.8052506847034617, 1.0391709144157792, 1.0704153924979904, 1.588828367653283},
    {1.3568085607324032, 0.9705075771267726, 0.9379127241473878, 2.235608454390153, -0.8689420369709508, 0.03249657785588475, -0.433219372501864, 1.0326474786106863, 2.3786206046550884, -1.6485201266062357, 0.6371024995741963, 1.866697853962104, 2.5381975469991214, 0.6643897902860308, -0.7806082479000529, 2.154863363562362, 1.2375023104965313, 1.6754663603037516, 2.4688565752308906, 1.632803504670507, 0.48401214851389746, 1.0676203805147861, -1.0427271900792126, 1.3994488092867847, 0.2555007732275993, 3.2747067940054206, 3.476511959918079, -0.6021119230798349, 2.721292226188672, 1.0831092246142717, 1.4590955117121585, 0.8992396165662144},
    {2.7813229754533926, 1.9938107166082275, 1.705540456913537, 0.5215858956244523, -0.43590369915739624, 0.8141932825356525, -1.1444800036708722, 0.8186759615982884, 3.02408336253707, -0.790052272304967, 1.909558809750406, 0.3948885407584618, 0.9751711723264606, -0.6522854982158683, 1.6780353701645407, 1.5196180713769476, 0.9464207098685883, 1.1564396342322216, 2.6041199100862746, 1.3841503792379533, 0.7310305453727804, 1.4642552841352672, -0.3166907253641614, 2.9066914120003453, 1.4202630284924145, 1.6589989229512017, 2.3100948889668187, 1.135676390200365, 1.1104525058427785, -0.3196240907170498, 2.3103081840174635, 1.8788904056160518},
    {1.4915772919455026, 0.3666648808126786, 3.592951941663662, 1.3073253942432304, -0.7295050251710691, -0.36219906058413326, 0.16313647961911218, 3.2030264433580333, 3.851291121951965, 0.019874854330139777, 1.134802863736035, 1.5105288535197838, 1.400612776686081, -0.5468176183189483, 0.9492345795541868, 0.594959049008081, 1.7699177550790581, 2.9853219939574904, 0.9147558196262964, 2.2597759447956918, 2.224955461856578, 0.7115124848495399, -1.303080075632916, 2.1188237103002074, 0.03653556252146448, -0.085016389883743, 2.1649877348929327, 1.4897493684884542, 0.8608764717325399, -1.257906642376227, 1.6396857107705058, 1.0080887038652797},
    {3.0701986892685746, 0.7707650967285529, 1.7527250835336499, 2.4330551634547524, -2.4150728530164627, 2.2069601453563745, -0.28207636634312316, 2.255120832427492, 2.8019481022201784, 0.7356985021681289, 2.772462890459196, 0.9392632522331341, 2.210844329371943, 0.6242757563396784, 0.7978399832572058, 1.5922756431131235, 2.0123125020530854, 1.0700647732519455, 1.0945332540702364, 1.2294591783131021, 0.15892078896963618, 0.8318292557278549, -0.9090101034896488, 3.7253801970397484, -1.3337142324286981, 2.401055558274515, 1.3268253374549002, 0.5713352501484417, 2.0261872147970488, -0.34857048668821466, 2.9238433950661427, 0.7530827376880797},
    {1.522837187754525, 2.863406772977861, 2.7014165411330624, 2.4471373557339393, 1.0073977989293152, -0.7969021794157188, 0.1615836335828693, 2.135784803773089, 3.804231861323949, -1.3819709159138012, 1.980899446955562, 2.194992942177494, 0.9664525772295012, 0.7270425065128899, -0.427662380392969, 0.5681878630047881, 1.7826015621491, -0.8606295627761005, 2.856510962670257, 0.8549403800985189, 1.5395342259022151, 1.827927068309067, 1.3386629652918527, 2.4475390458548825, 1.3655473303413608, 0.8265259157634159, 0.26904196612482206, 1.2983122676997352, 0.06366409946843822, -1.1338899474176691, -0.12131327776182685, -1.2140707748563555},
    {2.1006874543465086, 1.0645318757429982, 2.966578464064463, 1.259101451450123, -0.8196348975579536, 2.2198678372950895, 0.8149931493172996, 1.3581470765642618, 5.143027266389029, 0.5755790063982159, 0.7772992157556199, 1.929357004137458, 1.443543665117625, -1.1905103532838532, 0.4389932455364381, 3.0118556521950577, 1.9520568646972762, 2.7743636111241354, 2.188973265930846, 2.3643645260679214, -0.6726332639192801, 1.3045256215035521, -0.958010874789291, 0.049985434759738594, 1.893613759531111, 0.6796662303563228, 1.790881197756521, 1.980452204044188, 3.265078276508492, -0.44539621852119243, 1.146070503188677, 1.2210959160845047},
    {1.211423717097556, 2.3239229756035984, 3.356639113897131, -0.7914703163422112, -1.267248787608291, 0.9660043163131442, -1.0238237163929795, 2.190978140866894, 1.6775512292054806, 0.027867106354565237, 0.5224995841231275, 0.1636858822614731, 3.4806155067372977, -0.2041582868902384, 0.5211031722139453, 2.8755937120859474, 0.362436397658933, -0.32073025153088036, 3.5795305013981835, 1.5035747786105795, -0.18304065212190607, -0.5483167279697746, 0.34492189816035623, 0.7340057597810233, 0.8196072282177883, 2.5411818861901354, 1.7240912592465212, 2.571477199486006, 2.136446806538199, 1.0732772945289688, 1.2297117038392662, 0.021251430423739025},
    {0.7090218036125648, -1.0597268229945043, 1.1801819229458759, 1.7604547156036046, -1.0235646608682458, -0.2950347859829025, 0.6106169851359976, 0.066561758101493, 2.466893527332476, 1.566241685919498, 1.0995138623201208, -0.8482204729321243, -0.5551300478039964, -1.470876762956322, -0.32814489571430594, 1.7799670814728636, 1.1607757538844767, 0.34008209673534473, 0.9846919799432441, 0.8236078797625498, -0.12864297881348413, 0.3749839881537868, 0.0868193492112886, 0.009849987397978417, 1.7588592244082026, 1.1393624856890656, 1.573553394934104, 0.7534875451858449, 0.8347878135623515, 0.08847997292431888, -0.22759738473588986, 0.1372123796219717},
    {1.1844099941744721, 1.1487410602963, 0.6348069319999367, -0.2646554256058601, 0.9747584010056096, 1.7131671614901656, -0.7415199788176227, 2.2801492232141256, 1.3870729563398196, -0.6724824980629183, 1.620510509665099, 1.847951658789617, 0.6401987486635464, 0.1998772367330624, 2.1473690019434404, 2.7211816898036925, 2.739116726207946, 0.4812606897915311, 1.2435823193071547, 3.682048928788584, 0.6784506054948127, 1.3347231055440132, -0.10030598806511686, 3.7095384806645155, 1.5070892996312186, 2.2159167841188117, 1.919495145542805, -1.3059279978344425, 1.987571421763257, 0.18939472522920198, 4.4445278333181815, 3.482655278679935},
    {2.5829116980925773, 1.47171677013338, 2.77743061296918, 0.6234541910623919, 0.5372693474624468, -0.4050449206949491, -0.433693653221731, 0.30272567841839576, 4.843564625734567, -0.6197834222931874, 0.865716913696845, 2.2784677060041862, 2.2901552978316047, -1.4043539374154161, 0.33066637467411675, 4.128023977343283, 1.4425795957600458, 0.05242739675546557, 2.227248606410381, 1.0301218006997592, -0.8226684369044118, 2.622745345341467, -0.31956516649587213, -0.3306741036860694, -0.4869401738237437, 2.001134578437318, 0.8074265277708438, -0.40293363873705546, 0.19439390492029776, 0.25138603917704544, 3.3453195821357187, -0.1347038335115512},
    {1.128310478138644, 1.9118019107455466, 0.9064196467584847, 0.43439526830544933, -1.1992933495488647, 0.7926516247768449, -0.7708956029403987, 2.0574308261401058, 2.1736210931359072, 0.46250693759988176, 0.9563467608282565, 2.359678496911509, 1.1282120835038094, 1.2807889465483226, 1.4162193262172798, 1.4767478356129078, 1.7896869959171926, 0.35492435709027714, 0.8470411008407971, 1.0302777319944736, -0.06485601949656725, 0.9453821987313294, -0.9283225083686801, 1.6592817783181333, 1.581010634392752, 2.1616397846161544, 1.3520664213657498, 2.7640798760085907, 2.432838085944036, 0.17857178879992766, 1.701871431843061, 0.38647485435693796},
    {0.6589573867583972, -0.49941308624937364, 0.5963468313738748, 1.0579148858448821, 1.4135441036013257, 0.31393495712579234, -1.1534994198091628, 3.0324127642793925, 2.2629747927131776, -0.8752482940534685, 1.673142743995387, 2.009749883747923, 0.516300538688421, -0.1467904490138844, 0.7384792815332107, 1.5097401429701685, 1.7801170797460897, -0.3077557485025673, 1.7895967645068735, 0.1865360362430219, -0.7585827514701833, 1.2904776295929352, 0.8151155343031807, 1.816205405738116, 1.3034023753919106, -0.6730085875950201, 0.7381267324241452, 2.9290308694036127, 2.5785013096896416, -0.07811863309918275, 2.761171612980199, 0.42307564204971576},
    {1.4331549558225845, -1.0908296593261202, 2.6402655629178278, 0.9114542920499732, 1.197597699587413, 1.1924960086751657, -1.2059807787851768, 1.482307673759813, 3.574679150604273, 0.16072803234452654, 0.355635585947564, 0.7219856727366246, 0.13581512453795935, 0.637443496342342, -0.07743845327941484, 2.7134633064582134, 0.44874782168032734, -0.035530026231460884, 3.2310856909576717, 2.004559096761848, 0.9849206262947741, 2.883539435524527, 1.4770151705136911, 1.7647605557738497, 2.1558462722316714, 0.8799671702062711, 0.9617436936987167, 2.644148225029572, 1.1350950260824744, 0.8439998354940673, 1.6141898903718213, 0.9538578936744},
    {2.8673166693196444, 1.7107960490091294, 3.66372994370361, 1.6418402203871167, -1.6062583892465625, 0.5112452199835013, 0.06416203392977753, 2.545408914167413, 0.11861128105101408, 0.12614254890468815, 1.0471370938236246, 1.0477033049896718, 3.5140444453887056, 0.9067735193891951, 1.3056010506827862, 1.6724650113807484, 0.6775969769101418, 2.045159053082617, 2.814170802605588, 0.4495888413543353, 1.4263494385085624, 2.3091357221203053, 1.4285457298418376, -0.8567879252565264, 0.9647909310896007, 1.8323150803370578, 2.906993824311264, -0.9997073699874574, -0.18714423398190805, -0.06970069139673, 3.47075529723376, 1.642360355337518},
    {2.1691709882830588, 0.9753994735086582, 2.068562261399113, 1.717243716691626, -0.4138490969434856, 1.9775235899630812, -0.8312186528303142, -0.13853449421222902, 3.1826191071554675, 0.28644627368328573, 3.2318271581607108, 0.16110266811093707, 2.6996748517089046, -0.6190380620264507, 1.8720375048673565, 0.0626106150275827, 0.6072479224215392, 0.9517387324536755, 2.240270971083034, 1.375347563942069, -0.225283616591508, 0.30454469773016046, -0.8842285915318123, 1.025098726867752, 0.5302892586858851, 1.4593207424415864, 0.7774250959501664, 1.4018980927768339, 1.8301040989527348, -0.14922984954346322, 1.6203748902029134, 0.5858474271035253},
    {0.708499555499893, 1.3069779237953043, 2.6296156316771544, -0.07998517025411124, -0.3324070351300843, 2.080363777514937, 1.265743466675106, 0.5731828933475629, 2.730544204456079, 0.6615874455601681, 2.581464560339204, 1.5528578810789768, 0.8546877115318017, 0.31646327832562676, 0.8174764946183347, 1.2569694333249666, 0.7746085310102172, 0.6418825804037427, 0.35863477144684, 0.8522585013681021, 1.7681322302015197, 1.3237477690120396, -0.6089218426507835, 2.858783886356336, 2.0985639711708486, 0.9064562355851564, 1.530163422920288, 0.731617900879735, 3.4729534175055226, 0.06405923804837195, 1.9473018263816297, 1.3202564405948205},
    {1.4498011752011226, 0.875819120105166, 2.917821983526319, 1.1102934490971836, 0.3871851647476319, 2.0040213901567205, 0.010294523730460017, 3.148012363377239, 1.8502678235586338, -1.1879451162569064, -1.1355134195599748, 3.88385186883052, 2.3325644839953283, -0.743774432625688, 2.411991799547063, 2.682249492484984, 2.3722855367228197, 2.239258420183912, 1.902409961985227, 2.442280543841631, 0.3034468566523081, 1.5088605122261074, 0.3930778841125924, 1.4724995343643708, 2.6294618768992337, 2.3082428162441953, 1.9141036795322426, 1.9889146661739343, 1.617341266359097, -1.0194068299614703, 3.2018931604455036, -1.4634061258583924},
    {2.8335725575357094, 1.6455855630474763, 0.8138377298968636, 0.12314053698333847, 0.5068704139084714, -0.9526860150024524, -0.5876976908521934, 3.3245692990552382, 2.3418030575767927, -0.6867838132393531, 1.575341929289554, 0.6669348705288257, 1.6271908875858228, -0.6969745011351962, 1.449539868105679, 1.710710060021491, 1.6137421115607833, 3.1213214388170325, 2.271801353597782, 1.284177404034428, -0.7817311521462257, -0.9121355747895509, -1.0443473519098552, 2.9077266166741307, 1.5615219947376853, 0.39400803991675304, 2.0592785174495063, 0.9405814580579831, 3.222156501260138, -0.5401455344695518, 2.9400239775990396, -0.15046122914714719},
    {1.531012304987539, 2.0734674053926105, 2.806024914976, 0.7538060560093927, 0.36329114670384643, 1.635803298584688, 0.34835196308923577, 2.0500369672726735, 4.144588970467271, 0.32634861915963326, 0.7171632844846517, 1.929279095133254, 0.8414552852667984, -0.6368984844934547, 2.079437804423956, 2.8358075607027255, 1.2949901070842507, 2.0948452580143857, 2.0076525576655757, 2.4667938366453614, 1.059785896713408, 2.3727395817391423, -0.06444691286391581, 1.544360098827418, 1.9032604193329379, 1.9788268755916247, 0.6902826479157436, 0.8300981042581171, 2.1272243358646796, -0.9627464321077844, 0.5413984440075787, -0.7806769020439842},
    {1.173096564215302, -0.067943861390168, 3.260447395588596, -0.9678961103915756, 2.079340313796817, 0.2793750048558061, 0.4375274194051387, 0.7973220694058307, 3.1592984497618133, 0.6867849163850125, 0.5738032566159594, 2.39175662687262, 2.0210199379990033, -0.8304663941601456, 1.6187326484861742, 0.7384452483909707, 0.5092801682059703, 0.21213867199290254, 1.3398543088266288, 2.6648233705686266, -0.2521674702958205, 0.9031696952964486, 0.5039039165774949, 1.3731422017980792, -0.09232075777136632, 2.0360047624965976, 1.6404959888600061, 0.6417965946862717, 3.4428715022511915, -2.236926274396068, 0.3729282411582543, 0.40779467410608133},
    {2.7099201381508506, 1.650682248587701, 2.40770576373162, -0.5303285346858974, 0.7360699459885077, 0.8835226482914508, -1.0166757238161082, 0.056626776187588886, 3.5840592341960016, -1.1546541012894307, 1.295013056808412, 0.4457301542800758, 3.202137577667027, -0.08167274624015769, -1.5442375659919587, 2.519640722880044, 1.125773661722898, 2.4571405951212264, 1.9516378808837176, 2.04079448482825, -0.25461836168161833, 0.9221811641397698, -0.9835535947998484, 1.4897165327608803, 1.4891644202948333, 2.6431442064645605, -0.6598937004323372, 1.9309160870036202, -0.009006061298418975, 0.8183334194153941, 3.5444361658596613, 0.39157816894209113},
    {0.1523229685216384, 1.2291764934750489, 2.997179634210439, 0.18639791545665127, -0.7762851055292731, 0.0583490240987534, -0.5413705037028839, 2.1410183444361124, 4.090506663874029, -0.5200786918456826, 2.937979243221722, 1.12318692971804, 2.739266842654857, 0.0909430435384778, 3.125461945623638, 0.9716382992715012, 2.6563172710792706, 0.804203232602523, 3.8097487321196044, 0.8694098895900139, 0.562243640134209, 2.214037166712578, -0.478810943364957, 2.4702878754273305, 0.03982690802465004, 2.645448170992994, 1.4612361152808324, 1.643843395572311, 1.111820993997213, -0.3432979317725841, 0.9405547950836854, 1.7728883531862496},
    {1.5096386902992325, 0.20584941152772068, 3.0455935970913806, 1.0306241755714252, -1.9836304945059784, 0.3785398097401053, 0.6789864968767815, 0.3049250801045499, 2.3626157426125065, 0.16160627612687017, -0.6911438013791689, 0.32664956930897, 2.6762358973885867, -1.1211865550672993, -0.07473317994321177, 1.545059642379166, 2.2203257095770583, 1.3796614988310647, 1.5614415833043513, 1.960376107600679, -0.6932135413068823, 1.950438077568815, -1.5624797404897344, 3.3845382200286527, 0.5877587343795871, 1.1195581970349835, 0.36452607768355555, 1.664253372581439, 1.8100383991984998, -0.5741999821102158, 1.8809132275159397, 0.09386746472595453},
    {1.0761414426426401, 1.5940926473278714, 0.8953480595961891, 0.8138057477674127, -1.274763066712651, 1.0571714007352613, -1.2279969619114606, 2.761178856902416, 1.7147613123070773, -0.761513451426074, 1.8799336319790088, 1.411040460464955, 1.1307265155158908, 0.5026828472014009, -0.13921189325994135, 1.8810551146669574, 1.2634306136552194, 1.02754568941936, 2.147504256944733, -0.05256577367569506, -1.7009719465275297, 2.573026484193436, 0.42820484217771304, 1.0092459209625544, 1.626238714174174, 2.189939276066617, 0.2355669765260147, 0.7077426155589535, 0.43666453851648596, -0.7900027088650123, 0.9721582594024756, 0.3557189166603567},
    {3.211339426498255, 1.8568322344901844, 2.3527299898926413, -0.36812142287745075, -0.06074609567944112, 0.9139413659442392, -1.7129470354482554, 0.34467618407729683, 2.583827860648982, 1.5065353350609185, -0.28862346485207546, 0.8464504039350188, 1.0714737047684064, 0.23980712405739596, 1.0100164049258813, 1.26685552231215, 0.5816309142137378, 2.2319491676021372, 2.9347984409095123, 0.547369877413916, 0.14501949634420963, 2.2665172989684366, 1.3787368204012889, -0.8496420206834031, 0.17840447767887818, 2.2170652188015723, 1.6065864150692737, 1.6453343729073515, 1.3709922773813135, 0.31814404418319236, 0.9667648888817189, 0.9705444289612196},
    {1.3065499203859614, 2.3666443499059424, 2.6944414187467576, 2.794042969569579, 0.020139318409602803, 0.16642676234906778, -0.3047379547667667, 0.32083307327499566, 2.648345911762007, 0.6875485441961947, 1.7749394415935849, 0.6937347837180905, 2.992900997158502, 0.8366908403808473, 1.0012063045552835, 0.8116345725762015, -1.045643060784559, 1.5971688812424913, 2.6039341177214923, 1.2236439884791368, 3.212262546836791, 3.007992450956048, -0.420332132562612, 2.5328636406277476, -0.2051125664125668, 1.179734184362579, 0.7412549461257373, 1.8453415148511585, 2.018815319941325, -0.9985850446429727, 2.58203104297652, -0.7747777491861112}
};

static const float b2[32] = {2.617743158442881, 1.8792739905942022, 2.924443549511513, 1.4810577297231857, -0.7452783002591292, 1.0858782222997156, -0.45508083459258275, 2.452248310893112, 3.4661584774053105, -0.2450099761601679, 2.0558019881881826, 1.9610845018748255, 2.843386427894789, -0.36206598929459227, 1.4789179022498915, 2.64845831210093, 1.3041724252737674, 1.600566060138054, 3.1510466854180126, 2.5129077054062208, 1.0517595545661775, 2.0442128480928794, -0.3911132241121883, 2.614902109936824, 1.0640728033975173, 2.422250601943174, 2.030719243031082, 1.4955567586620702, 2.4395931863862317, -0.38596271638593044, 2.4387031690975403, 1.1757866983511516};

static const float w3[32][16] = {
    {1.4007023121373545, 3.9147201761352894, -0.11806501809958057, -0.1503008660493934, -1.703186229948312, -0.04285246653514179, -0.7375286297656493, 4.721663128280376, -0.919958728339339, -0.36097499244086745, 0.002146397459524036, -0.4517370157145367, -1.8832118392201493, 1.7002867426318238, 1.348188622714724, 4.583755309086951},
    {0.35648363880866163, 3.5117199656404545, 0.854864947560794, -0.15134367604970866, 0.8523377773510952, 1.844719672347387, 0.9571544327000814, 2.9231421494237777, -0.3625880443556194, -1.302426521729831, -0.4341284533801221, -0.3095108187688798, 0.36294461631878144, 1.1575436451288998, 0.8285638394928343, 3.362035930548304},
    {-0.18691553941699093, 3.08033387858639, -0.18963539545071612, -0.5758057649504598, -1.277577491374624, -0.12006165519742674, -0.7368420406834713, 1.9279179633951673, -1.5294328296994866, -0.005406020450781921, -1.3563271406533446, -0.5938258772811597, 0.6377325199476667, 1.412814697679111, 3.4183889223160007, 3.35152216477128},
    {0.949311874351648, 1.3871410286034642, -1.008173879811638, -0.17107528888213544, 0.0531033013391634, 0.5357505512063513, -0.06989103275087795, 3.968172281858556, 1.3906072776967437, 0.25561937716147515, 0.9433653454933758, 2.2636643110741583, -1.4846864864615745, 2.0641268187214044, 2.2000396322686315, 0.9830277980583542},
    {0.4610325359321973, -0.446611516070053, -0.32215250625057934, -0.47861939606155807, -0.010470523651178952, -0.285353281570339, 0.510650029442359, -1.046633015673563, -1.8859788630761158, -0.10062111339878874, 0.7293146005463571, -0.4904510870781499, 1.0919427133452566, -1.0995001287625976, -0.2024271289615141, 0.9315341425708218},
    {0.5557105464148119, 2.7522099766076678, -0.581344907617516, 1.1856067520782718, 0.840087677124144, 0.044345854964562385, 1.7181295721776466, 1.4489524589362672, 0.048675375802091025, -0.6419394676534275, 0.9018946332877862, -0.4790297048025851, 1.8093802029517452, 1.2945677374957947, 0.6157837700061751, 1.2356898756969785},
    {1.434868641783185, -0.9388907268964074, -0.5993320809413429, -1.2275043876454188, -0.7736477948373393, -0.4021961205465112, 1.3264420070608853, 1.5263548987052808, -0.21696135760918137, 0.19482034540963422, 0.7503436484360483, -1.911814637125382, 0.7367628209486214, 0.11234132901768089, -1.113675654775747, -0.08705226066128054},
    {1.2357054214546992, 2.390211712830938, 1.4388113456389322, -0.1609454215806292, -0.1648214106547311, 0.3428239013873268, 0.4515234762912168, 3.1229498681866676, 0.46603919527531557, 1.1611280033051818, -0.5539789271367445, -0.0524640239600424, 0.5296462485959845, 2.127907881150248, 3.3322178564117424, 4.550055512767581},
    {-1.2418424544821005, 2.927339480469744, 0.004699938027369274, -1.7335887265901164, -1.059200463885983, -0.31509860958480157, -0.8369403402700913, 3.460517650113848, -0.29165796199229727, -1.517509193535539, -0.10083767690812866, -0.5885177816570756, -1.4326908953875699, 1.3687081533712269, 3.093281171890926, 5.312348391101619},
    {-2.3825246960978363, -0.9020596927926795, -1.2103662431685074, 0.5337279111737496, 0.3925977723960607, -0.737623030487899, -1.2151533769110263, -1.545591518313397, 1.944605068139223, -2.149614529481658, 0.6160655341589211, 0.9145907941206971, 0.29671608987223425, 0.7450815865238959, 1.7915423985136147, 2.0631924884595056},
    {0.4435279169665262, 4.482430891518185, 0.7405303107156147, -0.4905227357909708, -0.9743935856668229, 2.3275837799319956, 1.6060479089082733, 4.2787295483398635, -0.5499383053380478, 0.6633400432271451, 0.1835844650074012, -1.3576241241432494, 0.5589250469954334, 1.858739534473046, 2.311075003976342, 2.465895089423957},
    {0.19563295170638098, 1.5891816224677153, -0.30176308107173855, 0.5200292861001085, 0.6730504095040964, 0.6717170745008533, -0.25486715616928013, 3.5193818090758264, -2.0382382275690505, 0.5542923568342757, 1.580544734613799, -1.6444754288531627, 2.179191981306847, 0.9817940271983948, 1.7664643875564658, 2.857810742450457},
    {-0.6478601257491144, 2.1151104312121176, -1.2635857664741783, -0.0015735556666862467, -1.377566463060257, -2.5750790743313194, -1.4245097343586242, 4.120905756454423, 1.1361582108952388, 0.09200158335770484, -1.3873361096089265, -0.26922001695504366, -1.1128731345617706, 0.19931910087333554, 2.3946001353461766, 4.328207465783339},
    {1.3291018522780136, -1.1099193999957344, 0.6229286990353815, -2.1461171611553786, -0.5975406832219454, 1.1473918961441631, -1.1150766288491136, -0.563409550257445, -1.4819802784514504, -0.5764604642046824, -0.2985980275148696, -0.005219702578966979, 0.2426284824884179, 0.24929380273423038, 0.7148973699033072, 0.5015522433690792},
    {0.7198592539508631, 0.19236990005293392, 0.6277707766181541, 1.2522907895615272, 1.5795937411658434, 1.7835516058237797, -0.25896160306143007, 1.0734790462546513, 1.1588623929833748, 1.5503998271876782, -1.0482941492201177, -0.02964718479076076, 1.6139836365915288, 1.9014098712645424, 2.3383734741584288, 4.8384544628293416},
    {0.6121919421443303, 3.9854875084614902, -0.8094824480863337, 0.030663892164726172, 0.2214064891171129, 0.27744479605786354, -0.6409509944827869, 1.8085338876857586, 0.0020438394672005348, -0.15909651628836693, 1.165041774271184, -0.49710005034061755, -1.7686475982015655, 2.9644844651907496, 2.9508670644907746, 3.666443042590048},
    {0.7919750550638665, 1.7133875275550836, -1.425640107396237, 0.86324695970059, -0.21992320566107443, 2.165328686161274, -0.07385010939109289, 2.5721407361959336, -1.0433097143112502, -0.4803086027662543, 0.29122348897484895, 0.5717388550768194, -0.3383456831448532, 1.4720756499373215, 1.0114205485044694, 1.6014612601552463},
    {-1.1686165909509407, 1.6650080585452038, -0.8929341818439237, 0.7192786440572261, 1.3561147764851822, -0.07899329372670276, 2.6238883394147035, 1.4884184063259756, -0.7532958728319971, -0.7310023210174076, -0.24953605360429446, 0.3076496258387188, -0.1338832243591593, 0.39633658009299577, 2.633904489644407, 2.0480764618932517},
    {-1.4526641990383664, 2.64865043171364, -2.4468342359449946, 0.2319845883286723, -1.2058491165775997, 0.6867434187608337, 0.3456232885524212, 3.3560787530244633, -0.4696576719119269, 0.21604991687994904, 0.11962215223714054, -0.5973317855704952, -0.27546767297443253, 1.8489167304110632, 2.227458582561687, 3.8223923871198457},
    {0.6858932799402606, 1.9303722871214322, -0.8659008443695269, -0.41266728640678674, 0.3864849063194888, 1.2379158206941843, 0.19950304698347646, 3.79152589717556, 0.9878834404384053, 0.04449604145416031, -1.414821909298029, -1.2222943536779545, 0.7564611815587822, 0.01226992853699541, 1.779725088130255, 4.1882965430862535},
    {-0.24749942737394676, 2.3088742243303204, -0.2918426572303861, 2.230922776909762, 0.28583400128441433, 1.1041200679858876, 1.0511791494924387, 1.2423530559590639, 1.4395756530546535, -0.9800054322568746, -2.122672696145624, -1.867446393511914, -0.24798239627353, 1.6115989455432225, 2.937286405938451, 0.04507325154888194},
    {0.4491189036182984, 1.448417551571541, 1.3928569508888824, -0.8836856412719483, -0.3057987515155255, 2.059278426939698, -0.5789877437696351, 2.8057272016262744, 0.4606067242810173, -0.9564692809457149, 0.23394223876889833, 0.2583498598677105, -0.7067765843931044, 1.918152227200052, 3.6635693331429344, 3.6833574161735854},
    {-0.48012206241116473, -1.175628058928095, -1.1408808667884085, 0.9057708574920369, 1.9845601458476856, -0.5785892712370458, 0.7305170061476083, -1.1173066659464095, -0.78168093945226, -0.7563616858737292, 0.8603807266860853, -0.31758416238217363, 1.9766894767795202, -0.5394383757315758, -0.6612010879227728, 0.2839308648300986},
    {-0.15488716937785277, 2.930138739604616, 0.08136530724406853, -1.0475979225478944, 0.9460556268015372, -0.0925172480376681, -0.622188157733994, 2.441730928916086, -0.11782553465495978, -1.033145069013448, 0.6660463483205498, -0.886237144463175, 0.5554778005171673, 2.427992518995756, 3.2827546436133117, 2.856570679067769},
    {-1.0059475793447885, 1.2591952002208833, 0.2585842937600938, 0.26451288172066234, 0.6380386842384175, 0.1566438813214527, -0.7007828168551852, 2.024208308260203, 1.815063603187963, 1.136399851237582, -0.7309195435034083, 0.6143947239653865, -0.6684663655042155, 0.23504615630779707, 0.43991965176389225, 2.2354097037950167},
    {-1.6770998148523717, 4.8605293729885926, -0.6675884621871233, 0.2307682830378719, -1.696682168508981, -0.09759382245546752, 0.11613295619215495, 3.0582985985413544, -1.1583208960703955, 2.2847790357174134, 0.5578276176730242, -0.06098480788602657, -1.3532135190452894, 0.8504021077421061, 2.455155103285115, 3.4039170551649702},
    {-0.5044505724018894, 2.1045858211684867, 1.2255977632387358, -0.5345101204686515, -0.05411710479825376, -0.39804710750717304, 0.5472086287653207, 2.6168003771684005, -1.026832600024336, -1.408182611143864, 0.6015216930569456, -1.1221010017208621, -0.5193135356499683, 2.5106488296408482, 0.7890285414856435, 3.12731326692584},
    {-1.8503710459805394, 1.3995377288342168, -1.6216993832089899, 0.7530614977421514, 0.2869160886025402, 1.9593496969716628, 1.3032867559715209, 2.485303840444342, -0.4382985812834194, 1.2557018767946888, -0.24992639149555604, 0.4769198129244138, -0.8022555409307157, 0.7547754306965944, 2.1001239394977427, 0.9674485388580034},
    {-1.2246312478089965, 3.236259126857367, 0.7653974921374757, -0.3047912263140899, 0.5212864108018906, 2.6897634602576095, 0.10769500639754569, 3.9593850180795296, 1.2546541686966342, -0.4084867845239803, -0.8994703067060024, -1.3785372639075806, -0.1569414755221082, 1.3832582488251661, 1.8846681360432138, 2.8709810345738327},
    {0.3631613967137285, 0.18632024972812403, -0.17371145833814158, 0.5827286212536098, -3.732626591369786, -0.38192800364631996, 0.3078900688749524, -2.4867080168379196, -0.49035755134087383, -0.2532637045229297, -0.3095777738901195, -1.704332089619963, 0.17962677720000758, 0.3888149478891385, 1.1085056419404047, 0.8300308814697522},
    {1.1750332596731132, 3.4250481144653806, -1.1603592797142055, 0.8191014349625234, 0.8245596755884774, -0.07889663736776657, -0.9113457651181562, 1.5148741531600969, -0.9364841753492603, 0.3532512985242718, -1.1819111547550427, -0.21966038387696626, 0.560874491777824, 2.395585182430042, 2.183580276485642, 3.7067515014420778},
    {0.9637274630658882, 3.3076781790689096, 0.7863460603391697, -2.001802610098331, 0.1348527084196502, 2.7311333763504106, 0.4262810634829899, 0.5357969389537578, -0.17343617815190704, -1.079809907363371, -0.9322462527099407, -0.053734858811589736, 1.1269534606886615, 1.6480694878015105, 0.5671583974713855, 1.8337684919492028}
};

static const float b3[16] = {-0.7239661621407876, 1.8168633162275807, -0.48131679235227376, -0.24553101623960302, 0.04906251730042391, 0.306390032753088, -0.4800953453031373, 2.3688872020047, -0.34150464175643075, -0.22659311388993403, -0.4157962155449502, -0.2568198240409999, -0.2557926236855469, 1.4287383984344793, 1.6004149669449126, 2.5088262400633865};

static const float w4[16][12] = {
    {0.7648302713816355, -0.9485222195168574, 0.6915819964404232, 0.001801224922284361, -0.39889772411791913, 0.8992176880272732, 0.15749110226116592, -0.13784772784640065, 0.18120694525315412, 0.03873667457084299, -0.8413918515756351, 0.0374706679471859},
    {-2.7324147816265216, -1.6501443820691262, -2.858014870419445, -0.878019716853211, -2.7897265609677215, -2.7695913574102273, -1.8449736010667406, -1.5678571261099334, 0.6932236998942044, -2.468938502113997, -3.577914843642981, -1.9920514863179153},
    {-0.46364329243593605, -1.269722079595598, 1.543401902237139, -0.22289324815171258, 0.13873122356450315, 1.3932919482980013, 0.05749597685520277, -1.1912473535283425, 1.8315964632035635, -0.22692168547823593, -0.3018174155642524, 0.3879397074864034},
    {-0.9005535664577511, -0.2572745770148757, -1.7382224668126633, 0.5140068597879516, 0.4027775283151671, 1.726165077994263, -0.9263385537144585, -0.0825960129468785, 2.686634097532737, -0.27719703135381746, -0.011671629285697377, -0.20313468517122885},
    {-1.45560296766112, -0.21561357395064878, 0.3698895538553453, -0.37715923934596074, -1.5354618887687403, 0.09077401978335894, 0.7032126490373873, -0.5382792602724573, -0.04914952777037046, -0.3318580170747158, -1.6582925894246057, -0.7084849708796628},
    {-3.819091614810463, 0.16204449437233245, -0.6969761535929446, -1.2742179346809774, -0.33810292775829304, -0.6997166397970473, -0.6283658936272201, 0.9143246023974385, -1.0019316466900414, -1.7627664291467355, -2.3866822722294834, 0.15391760368903354},
    {1.15054196976069, -0.006087454752389497, 0.8016903852079668, -0.6082722632851453, -1.3577453107736603, 0.9957208414534596, 1.3444897668154867, 0.7158606059253694, -0.7607297271297886, 0.04960178273647959, -0.08673060726092591, -0.333010189203641},
    {-1.3715380641772652, -2.0482057674941956, -1.5467449916662912, -3.1858752198146796, -1.840878158200213, -1.9940339382515528, -3.038840634172394, -1.5744184154044216, -1.5962629184332233, -3.243205227923039, -1.8153284993011218, -0.4294162515042613},
    {0.7430734297711119, 0.4785474653019142, -0.18298228149629375, -1.1085177100667798, -0.1699311272251914, -2.2094726206589863, 2.140965282426785, -1.1384306240325373, -0.8018201254639709, -0.3773715645123122, -0.33204560151305546, -0.3529442638776405},
    {-0.01565083731410875, 0.17981336477291887, -1.1126632450375102, 0.2908117579390415, -0.3354049991939895, -0.891582904950494, 0.9903316769121854, -0.6299159370168088, 0.37472740773906205, 0.18119724291579914, 0.5454214830312909, 0.2622329385399092},
    {-1.4976274894104191, 2.0177246068479473, 0.01942038867272485, -0.37744165965159954, -1.8306367382510047, -0.0007047260903099367, -1.3357037812558552, 0.6566576763306479, 0.685843626446503, -0.1632208367981951, 0.19786031606216506, 0.8468133268399378},
    {-0.9887000014950925, 0.7303236436598857, -0.774996581152689, 0.36434810448590066, 0.0037221093608432168, 1.0113564106676243, -0.00902591961787661, -0.019635464837718906, 0.08711437345561256, 1.0450322253903135, -0.8252343170947538, 1.4528249770759265},
    {1.7197254600310852, 0.3974105288106966, -0.185376303270177, -0.30817261311206434, 1.0508348266486798, -0.3187079340244917, -1.1651889599047927, -0.6089227185333268, 0.4531233610376884, 0.1160320262002173, -1.4868124226412258, -0.44425281988915966},
    {-2.7379065938152944, -2.4924731314128152, -1.5967173306935034, -1.861869752893368, 0.7411132624550426, -1.5673427300987626, -1.0543073110660433, -1.5843135714408094, -2.3220114764696946, -0.9048103950454355, -0.6084862308797513, -2.9544368929844262},
    {-1.3483160752551946, -1.5282603832491413, -0.8190815859546593, -0.7818242166805095, -1.7122046128553101, -1.3744851524042911, -1.6622630912505136, -3.794713174496484, -4.447137848555589, -2.4523683561192984, -1.084502747569046, -2.247090821147647},
    {-1.2868356984513067, -2.129143787868494, -2.3882871881509833, -2.3271056545702797, -2.6457068556427963, -1.6487682502610301, -1.5322549398570209, -1.5239716655764213, -2.3423763584915664, -0.23665907818623946, -1.5205271910607414, -2.5747662744775495}
};

static const float b4[12] = {-1.410697787032249, -1.4770440681553798, -1.6363555666851184, -1.4471643413611772, -1.2986374877866942, -1.3693709812207888, -1.1773359881119634, -1.1923887509645665, -1.4741215231019122, -1.183241922254328, -1.4310163860082312, -1.2901011871987658};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
