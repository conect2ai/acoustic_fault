#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.7009290271409381, 1.1957304171472372, 0.16265633066774654, -0.7016234385489611, 0.9403416474590068, -0.20480368092259563, 0.434472012953556, -0.22533604931288914, 0.014398299169346165, 1.0821761650966597, -0.020029494094999278, 0.18220479081063604, -0.4856086557068105, 0.24752198794447652, 0.6826767243902117, 1.6870660337582404, 1.6783976059175285, -0.10868335433104591, 0.34238235645004067, 0.1664817790489022, -0.7798692985834019, 0.40734003439519834, 0.5676699613997651, -0.6536014627654486, 0.19707779216654606, 0.2975457440839774, 1.6935246010190053, 1.0814039233190618, 0.41989590648577113, 0.012594082044365787, 0.7331253128028082, -0.013161234808938988, 0.17933802252345676, -0.7873761979656987, -0.001878662134160811, 0.02874334304182692, 0.42821803071834647, 0.4624112116349613, 0.8562369825616514, -0.3452515937158519, -0.09550876842092587, 0.6480852807366647, 0.06706753910522331, 0.6106093277833289, 0.03186400698008994, -1.096273030107369, 1.706016326847421, 1.635573795962099, -0.7435841171351605, 1.525011909111188, 0.3493778482623493, 0.11943286775634797, -0.017347208095158554, 0.9764763862168646, 0.2333364686805222, -0.5773448372000494, 1.3755038749732889, -0.39845034423045633, 0.42551868989157754, 0.5424524642005126, -0.2800159638128478, 0.8291289428443697, -0.7435038012778873, 0.19318482320679792},
    {-0.5291985610001689, 1.497846514951159, -0.20382766433518926, 0.10036297749236082, 0.7164389493961341, 0.8352694734611515, -0.8311262385695053, 0.10264574612136614, -0.42466283801901744, -1.276027799258556, -1.2008413937145277, 1.1628221450115337, -1.879297047276583, -1.157749135806063, -0.6677868848167036, 0.9654535618136085, 0.31516593625721634, -0.7116923681985494, 0.8821612562085455, 0.08496042416751756, -1.4889634903926494, 1.0179726365168826, 0.07424102308197753, 0.8170543974388129, -0.796146299647494, 0.451041653169463, 0.5710611623133259, 0.7396715599072632, -0.3380935388464789, 0.7266635683389817, -0.67244615085958, 0.5388102897091287, -1.213294341282753, 0.43947087254947126, 0.5942612220636002, 0.1253439335231989, 0.6232860566071857, -0.5553227390315776, -1.0765937487606592, -0.8291286389850353, 1.010705235788898, -0.538276684788242, 0.5280329754322928, -1.7985929420132516, -1.6116649163234507, -1.202702682843495, 0.07506300960303468, 0.8892580837933017, -1.4474461201043023, -0.08570887480167813, 0.5538636481438634, 0.5683058461412016, -0.39352582020075516, 0.4263777710740356, -0.2295707739721928, -0.023381876631081405, 0.8519600057809819, 0.8679126245403471, 0.23640495148649138, 0.34615891718670005, -0.6070325396977048, -0.2801898613738014, -0.05978890281685125, -0.07155202406231025},
    {0.7071615215476051, 1.0168848163053752, -1.451096413513701, -1.4458814762438363, 1.015222312036074, -0.4320189148365682, 0.6918103605023314, 0.3327236868187099, -0.31644980093876746, -0.5683800103949409, -0.3503690488367814, 0.08691572134982113, -1.0124783944628861, -0.4890777897448272, 1.1487680527504704, 1.4678868558404428, 1.1673683147941423, 0.4448166204931017, -0.318361127262528, -0.09056320993621135, -1.0509290410503602, -0.829815734639027, 0.09200377154673763, 1.0386817642706723, -0.15029790720971975, 1.026143253417799, 1.6120465678208982, -0.1143110911179768, 0.6725922586922769, 0.2986286160795042, 0.11273613247238708, 1.2563454038634856, 0.40809265991132687, -0.5004507910719459, -0.8110547853858879, 0.20749440924408377, 1.0507952797515665, -0.037495845599015025, -0.6201497190961077, 0.45344700863668785, 0.973007486244207, 0.32509647188512886, 1.6149117368689203, -0.540862038482566, -1.4834841157094005, -0.9880879539327789, 0.19074151445353058, 0.4638864466752789, -0.6815297827623528, 1.3704802249068542, 1.184158759352279, -1.3461488684554612, 0.647244237293822, -0.6292033511442177, -0.7313431280186393, -1.5830035924258268, 0.39927067258247173, 1.5935348133137546, -0.6835033247816401, 0.2549957321363619, -1.7212788237560783, -0.37149665717254643, -1.5212367462425058, 0.45455848746949956},
    {0.5314913587225321, -0.03239200529222342, -1.9721593831615911, -1.900153028506572, 1.4556994057965713, 0.11556354523215791, -0.9556600559596555, -0.2068128889055474, -1.6809850557132924, -1.2193945111450177, -0.516498789092803, -0.05237342517103771, -1.7531112321259836, -0.8620355347477612, -1.1495863951653702, -0.04893904585500982, 0.014917577639310193, -1.8328227183740342, -0.24722422985931586, 1.2951708854669652, -1.659310300327776, -0.7802837137261559, 0.21347817884533885, 0.36535646544302025, 0.16994682077227272, -0.8509328542036152, 0.7141641506028659, 0.698212328621624, -0.869438999583138, -1.6004750128948249, -0.6914183821737854, 1.0700503229213585, -1.3058396715084053, -0.906974859628976, -1.927779700412166, -0.5851001960093328, 0.16854762585842842, -0.8949879345359393, 0.29038285639379363, -1.4986778047099905, 0.3257419898889819, 0.512098836708873, -0.18746569596509594, -0.2471284033568518, -0.5995775967350789, -0.15886144648889863, 0.9152587339134376, -0.5716634335446603, -0.530305539250715, 0.3459233728376364, 1.1210021127985872, -0.5893894333638386, -0.3829891905847421, -0.0006806215421900308, -0.8801296104131164, -1.8738002903795514, 1.2819183794702897, -0.6759536955732675, -0.29899314128653653, -0.5379713501066173, -0.731868081892809, -0.2516505691896687, -0.4473692151833694, 0.04041682526077611},
    {-0.005149331460302095, -0.5788454212354214, -2.1870076296352696, -1.0754733976113384, 1.102298385887043, -0.09207010839939414, -0.5492347224868008, 0.97731778418434, -1.1633831447252367, 0.2247913343476003, -0.1681802700570229, -0.5263290905567541, -1.25800971097235, -0.9743094669965542, 0.5413053415316027, 0.47423357539995054, 1.1837359400939769, -1.7656901157213436, -0.5689192805048315, 0.08369783980121354, -0.686788447332329, -0.7739445586060949, -1.3099138385532998, -1.3462659706103348, 0.5493595926186905, 0.6051937175470073, -0.776412212011244, 0.3636207459505471, 0.6983233145492249, -1.725698715648028, 0.9303639992217678, -0.40883540629423554, -0.27895523202794054, -1.4000057117932987, -0.8106117138429777, -1.6597327475473542, -0.2605298126205353, -1.0655298598450327, -0.4817228829053165, -0.8178415138628055, 1.2528381865322524, 0.12055569696410869, -0.6636822431273585, -0.5657458833784803, -0.5048847179786986, 0.03415939609375977, 1.143808665103981, 0.07060701231902944, -1.152414996960512, 0.2611022019759039, 0.808840705868063, -0.15653857063478838, -0.14409009344768675, -0.4850732887748156, -1.586622717473753, -1.2152892297151796, 1.1305806793328257, 0.1710779536735124, 0.923073725302929, 0.14420659773052685, -1.2770910287109314, -0.541199172278369, -1.1344313106641835, 0.9405256503894364},
    {-0.5906368067855897, -0.6683085662713308, -0.3354453332005, -0.8113909710034823, 1.236953948516802, -1.5574956623831746, -0.030082676254375964, 0.4710574682501298, -1.0736171295892232, -0.43429324692967547, -0.6127648627117085, 0.5693886134855387, -1.2718911745836863, -0.9221148832206918, 0.4609831647125556, 0.6951581223163004, -0.877470892347744, -1.6792356242022028, -1.6705869488818943, 1.3001467352532905, -0.9578576141616898, -0.5778428348987033, -0.40728849887436325, -0.5989393597313479, 0.3324744967073459, -0.374229612234934, -0.7578029463793089, -0.7921775514338087, -0.6995820935776721, -1.8178931691048454, -0.6345389229213906, 0.7340987869777399, -1.088446547401143, -0.4617891470271977, -0.11792753306837361, -1.2332642735805506, -1.4222413644962162, 0.14535676764026853, -1.27908119804275, -0.8939752097446304, -0.24069968592338728, 0.051478395324602876, 1.280701514051898, -0.5138417492403315, -0.27670934962102695, -0.9996899618440993, 1.176552009268178, 0.6275212722332264, -0.5652467154679628, -0.07345072187160327, 1.2431562698187404, -0.3458185397023745, 0.32636679588801726, -0.6340574878981606, -0.8300497804142186, -1.4262186380269104, 0.27350438541069294, 1.232954867327156, 0.9174327917042243, -0.7508211750752594, -0.7796603820712872, 0.08955399810586237, -0.5582262882644522, -0.7473173871390066},
    {-1.3040674991974965, -0.04958392761767457, -1.1072196995764785, -1.1460610149044497, 1.0920170014436172, -0.03060428257055116, -0.4877190381814968, -0.08777007025015955, 0.30980248229709556, -0.36762066841873564, -1.7411380826164047, -0.9091744392823179, -0.9261525153646029, 0.29367206812260566, -0.3124784591766558, -1.1431011729063127, 0.1914295366142896, -0.6575100068885394, -0.49434092366720606, 1.1034629330790233, -0.4570453062212733, -0.23652342965165501, -0.7690894011778974, -1.4113222487434502, -1.492810571449301, 0.8162537590946021, 0.3491291741581957, -0.9181621401413549, 0.0777630617844179, -1.9570580529217594, -0.9366189893232509, 1.1947494901508027, -1.4347855551851865, -1.096724230777681, -0.30906357490862724, -1.7164023744332124, 0.22665029957463098, -0.8650260155437621, -1.0014265743133735, -0.9122493813065955, 0.6998518826187778, -0.314576756849709, 0.37574878768685555, -1.642293557914493, -1.011154800909024, -1.3698559487727677, 0.12840102558801894, 1.0780855214625542, -1.9116591276305368, 0.9796707339120292, -0.8157562026202699, -0.7037354421231682, -0.02798874358282074, 0.42535774132083204, -1.3569448596640932, -1.0876803492276865, 1.2522371480169456, 0.07777891657881777, -0.558360887228113, -1.8747473952043086, -1.9049693099397158, -0.19564930539670408, -2.1638591086020993, -0.3523341691873002},
    {-0.41281925209732534, 0.38643289170222517, -0.7165423669767105, -1.5928591300132298, -0.3276728895638539, -0.0317193968889584, -0.9767965788301997, -0.1625106243330583, 0.16360463318505014, -1.3670343427345377, -1.931266586740629, -0.8929311654503377, -0.2156383680823437, 0.0022310123450452212, 0.36401028579150313, -0.9225786704139954, 0.29434987725307166, -1.254513845449246, -0.10439165986658128, -0.6862158543173621, -1.0395127162028228, -0.5546793469577108, -0.5479533110478245, -1.2546548514487874, 0.40637565548406673, -0.3642793230100642, -1.1544878673320487, -1.1309213097047697, -0.2632270847018642, -1.8215676160562528, -0.27833249773576874, 0.033723662293673476, -1.3459854831915536, -1.3691120423386582, -0.7066271828385658, -0.5631458552173069, -0.1744699341711746, -0.3404662930355829, -1.5577807575885776, 0.14210497370056935, 0.9759384730006218, -0.3105560255989101, 1.1931711121209936, -2.0666997716255713, -0.7919007112851028, -1.2053715903510676, 0.004903571478630222, 0.8987284639044436, -1.8651778078148677, -0.4209136140981443, -0.29146543839793104, 0.7212810181428718, 0.12166739712632765, 0.6471904035578937, -0.9000789164516532, -0.7245338926286256, 1.1691271867211772, -0.0926244686796745, 0.42894386306212523, -1.6230250933212413, -2.1119434921467786, -0.43633984406268245, -1.0855271653777052, 0.16050790013759195},
    {-0.6034279627891392, 0.6155652636344155, -0.934012031003044, -1.1775963339933706, 1.1261471641643395, 0.19794007269157562, -0.602222832694322, 0.5002055501501046, -1.0794280562410539, -0.9623908119063738, -1.5599993759273518, -0.47869321060281816, -1.790596277645979, -0.395917964274171, -0.04027148618839042, -0.8246927812200019, -0.5240309452185272, -0.9101717247438433, -0.5103404279713465, 0.9649554504563791, -0.6852433093380581, -1.1516789854466971, -1.1329600386042213, -0.5898846725083013, -0.5647704532180141, -0.06370660948668058, -0.6104422740295752, -0.09354051998149253, 0.12560727539123187, -1.6816626689735679, -0.08046178129301554, -0.4677892137171997, -1.512316032728704, -0.09847793412175962, -0.7997297687676187, -0.714878994033149, -0.3870141886986388, -1.5053895740258327, -1.7662495524451312, -1.1330698251978388, 0.4110739550279254, 0.928582850563831, 0.030577508071551383, -0.2375774553425332, -2.2519178354878817, -1.4543182558117858, 0.2735675282970305, -0.5728443156375462, -1.9794222816471707, 0.17826770169552056, -0.0052993606541169615, 0.41199958462814595, -0.8559280690597485, 0.5637105760856539, -2.035298844505644, -0.8837620685629889, 0.6125476301433854, -0.10487908241739222, -0.1023167574564744, -1.882249965753395, -0.3305005604444686, -1.3114706812297374, -0.8060211457327333, -0.24413271549089166},
    {0.09671909542369134, -0.6990255624284794, -2.125569685031938, -1.1017704651242866, 0.007841810685971598, -0.07825928893334218, -0.9577662518642438, 0.45708798698924097, -0.9200684475707971, -1.1280284176278184, -0.41693969061414593, 0.710058876766537, -1.493559402445181, -0.3815679365458414, -0.1763577477880532, -1.0077684499304405, -0.029331821591624337, -1.146222137191576, -0.028211172881797572, 0.8286226600385941, -0.41519122949674264, 0.13795491918867928, 0.191377368893704, 0.4282350153147411, -0.9870790789255044, 0.5037252610328324, 0.7305639651254311, -0.14171425673398919, 0.5688492561490679, -1.0231151172977055, 0.19058436095224796, 1.0240436860269577, -0.906730133135096, -0.22935828441328415, -0.5720923947120566, -0.8554887252925162, 0.09098824178093597, -0.2173506672828024, -1.775064763378012, -1.391646563392696, -0.29736522099343793, -0.08129900593847496, 1.1158610351478604, -0.8730055233602657, -1.8415439649305048, -0.8988282719735723, -0.2114363246159627, 0.12781918036895434, -1.4422091238701793, 1.1244794411488679, 1.0655907833137968, 0.06464783530477791, -1.3369899312697873, -0.34405245717326566, -0.48742788787192676, -1.628404533292824, 0.7776091252911451, -0.38715055211976, 0.06398529351489493, -0.33906494798555276, -1.8488364837274305, -1.8523066704121074, -1.8659053831643662, -0.5864861374193446},
    {-1.5084485772932756, 0.2583300764328028, -1.72470220619076, -1.8289082936833703, -0.45318637486409413, 0.30675410558235755, -0.314821073452439, -0.11390747310358997, -1.7010483345426077, -0.6857613215639249, -1.4591584040694345, -0.9578641676090369, -1.9501782470776667, -0.8575711399098304, -0.5122078285462415, -1.0834019000643553, -0.5687038178569097, -0.33456927865406977, -1.103262243254661, -0.49324877455036337, -1.6904686991695004, -0.5217471281589262, -1.1752637922320095, -0.06234449560107864, -0.0946914851566761, -0.4269600311936399, 0.4890809144351125, 0.3929682141617676, 0.7438682629138764, -0.9327642667320277, 0.223279399208173, 1.1673239986351085, -1.9575995381350089, -1.3403597642522291, 0.026877917451456373, -1.5285601933156328, 0.09499071606718427, 0.010058749505128837, -0.8075103653735395, -1.3907078007953297, 1.0356484798443817, 0.8572147878847323, 0.808244304898177, -2.053835654917887, -1.2152106465670822, -1.3986484884065593, 0.11740297814563098, -0.5448199688374041, -0.4993759854193676, -0.7723370160739588, 0.22998196479240157, -1.1391175471803643, -1.2049788837059257, -0.5962794498414614, -0.7171771909644288, -2.0458922575468956, 0.9407194803239427, 0.5803946791868394, -0.15492292207817923, 0.0941781979743013, -1.3313859500419658, -0.4096896487452417, -1.924496213044068, 0.01966815244312159},
    {-0.7129488667128182, 0.6095349939297197, -1.7467453539146136, -0.05876740485512359, 0.12466071038478596, -0.6480378369019307, -0.2777464678692267, -0.6800497765264027, -0.8790304411058629, 0.06285294067466446, -0.09411474253577354, -0.8762507272529455, -1.6486617952047997, -0.8599388965063658, 0.3851192862236012, 0.6549359665362734, 0.41491005579694845, -1.860444845212541, -0.7565119423767369, 0.012564997249177753, -0.210335331138241, 0.26169208528251875, 0.3295524791657998, -0.006194392957058771, -1.5213064186100895, -1.3400999457864127, -0.4131279940826866, 0.6535752930257155, 0.9150200846221208, 0.3225326778597352, -0.6165485698853288, 0.008021174718736927, -1.8469855402629407, -0.2048648636629479, -1.2499080463785188, -0.9998976098348634, -1.068192243534124, 0.4647514500357761, -0.728152583662673, -1.6740530731372947, -0.6336891197226672, 0.30139407320950456, -0.8525581982373657, -0.9281774763450881, -1.6402551812604627, -0.23162193880580076, 0.26796182643638455, 0.13921409259613357, -0.5486746990517062, -0.5842886232389672, 0.415650292333947, 0.0862353635076559, -0.6879316216560425, 0.256961843516634, -0.12392109683590674, -0.6527787665656768, 0.06480476398663963, 0.9269465945157406, 0.6957608704360307, -0.038528012266715435, -1.433764416537218, -1.950696525248478, -0.15264930714487313, 0.05047805428284113},
    {0.38814890717825173, -0.5494644636564983, -1.8216244181329604, -1.5143673083092244, -1.1579711160258785, -1.0241410278713234, -1.2173926312921275, -0.760911218045805, -1.5606756653541027, 0.10518495867183858, -0.7498123761230696, 0.1467208538927575, -0.885525729886694, 0.17899915551925186, 0.13222794699246418, -0.6516879534582002, -0.5107648995049819, -0.7987744651842674, 0.11133740680355336, -0.023820271789159502, 0.004249586537024933, -0.6797663820342367, -1.1554938987874919, -0.4172739197119258, -0.6623927787826092, 0.6387089819858282, -0.8659805886667069, 0.5190781813222535, -0.7821390218404307, -1.2664485927304616, -0.3524346528777671, 0.5870636814076231, -1.34247017113493, -0.20401360668942417, -1.6920488379357812, -0.5898752958045296, 0.5400542654266934, 0.40694833048036416, -1.7340037269009587, -1.5473377984450376, 0.018910140729324447, 0.7563690343702822, 1.0112783212910643, -1.7686933760115153, -1.7527416902649793, -1.2409681784846212, 0.7588171275173444, 0.5396221452565442, -0.023959602431789948, 0.5956541851593478, 1.0652508483309506, 0.16613153316958099, -0.22363929076765088, 0.6328387093981703, -1.6286446131940837, -1.5321226909348076, 0.38887086352207473, 0.31590361395475197, -0.9469595155224794, -0.2993619235644428, -0.7678228589563875, -1.9809525095588405, -1.797384795277191, 0.5021302840040608},
    {-0.8789601551087319, -1.1813282147618813, -0.908730306808836, -1.0142632775960048, -1.126154460028103, -0.5197232915895292, -0.9136891363310902, 0.18296554274378987, -1.478576396235182, 0.19149377145428373, -1.0156888928858725, -0.020754324798508333, -1.0299496016806284, -1.0913559045197092, -1.0687117996306097, -0.5873464678889584, -0.05172527660255739, -0.5047109885973763, 0.42596499897891005, 0.987306281612174, -1.4366999771134397, -0.6331475287860643, -0.11807315258160189, 0.059303126813083085, -0.6577668352609444, -1.0489219791754614, 0.5716175135350804, -0.005708091891366467, 0.44013600800675134, 0.1232839229293978, -0.5258330664459345, 0.558047222579698, -1.913612260531144, -0.4924111113273038, -1.1279029238864215, -1.884864678374913, 0.5018683827506188, -1.11780189980165, -1.623859066531332, -1.4361989937947144, -0.3602509187088353, 0.5860923286629237, 0.0959516349098397, -1.957921105445686, -0.7809060073400962, -0.12572758853762095, -1.073394106967636, 0.2833074685120862, 0.007952065405325826, 0.941858768070418, -0.5925892828408805, -1.1093596125093301, -0.5969584615480334, 0.7485973007127058, -0.4231913076338437, -0.44963397303355934, 0.28866162902034886, -0.4233027844391273, 0.23609709634993262, -0.5448724667610136, -1.5240691835387496, -0.4738620382355928, -1.053005649574115, 0.35920792805198964},
    {-1.2487113758795632, -0.3631042890569309, -1.4518928919655885, -0.7828599000309642, 0.44974790944522003, -0.016523129745729004, 0.3045966447458149, 0.4375711084031227, 0.1649092749906113, 0.4708947933858284, -1.2846149915964333, 0.7453729239402277, -0.9994737348363356, -0.6563663097931619, 0.6319541397082906, 0.14025730403609965, 0.9072753908114929, -0.2251743320598716, -0.155856452130862, 0.33316913755571326, -1.1627939909685114, 0.4596084921737782, -1.0762927149185268, 0.4450680085626896, -0.7191152778057225, 0.32423145262943937, 0.4128428121091328, 0.696292846939702, 0.22548461529365665, -0.1259551573198705, 0.39781005302667233, 0.3164438942992203, -0.4370255508373065, 0.0906415287739818, -0.6846516073917157, -1.8771972915948174, -0.8175868305425099, -0.9214378830026166, -1.4528602671616744, -1.2534408300877249, -0.2395476394349463, 0.19377465882226452, 1.0917994626094831, -1.658855415217636, -2.187972550311979, -1.1164710100397521, 0.6066687728642539, -1.0182914112824595, -0.9512192375445391, -0.49929708294429404, -0.009752177254812488, -0.5713050846117697, -0.8453714504602701, 0.5030783344963693, -1.374810183944151, -0.27106036620101953, 1.1018376737533806, 0.7297498891867165, 0.8880538540562389, 0.035077201369183256, -2.0543821065176027, -1.7676142214529866, -1.8367964894965352, 0.6816853846861877},
    {-1.2167020381427236, 0.6506947312786242, -2.0652163288509535, -1.532951103658882, -0.18102640019010188, -0.3978351650621985, -1.27255868615146, 0.6976225053962369, -0.5925001002649011, -0.2980731947538941, -0.5833418185821309, -0.7903498021458614, -1.2654737772522973, -0.8936337183956811, 0.8700910507050738, 0.6614076275798066, -0.2057373421834419, -0.8869640576738935, -0.3626152822812035, 0.13408005458900013, -0.28832966307266905, -0.9684481303504411, 0.2997615552442469, -0.719054468257389, -1.2654054562941397, 0.2769005570018122, 0.11365681582053748, 0.34506867489496285, 0.226263705933557, 0.23232246421928335, 0.20487140844772914, 1.6770558521889765, -1.2116855848006456, -0.9906717491526111, -1.50383699448554, -0.12938336827316613, -0.8902985498399009, -0.679205993501786, -1.4837281995738691, -1.2392004168126751, 0.785488993055353, 0.012632114316480413, 0.8641903273547652, -1.2137618797473049, -1.7255970159410066, -1.596275440602636, -0.1464883297706004, -0.3257977133266031, -1.5543463391617578, 0.001270848796330835, -0.300587509714172, -0.6524561465762505, -0.3654048725913358, -0.9508905812752065, -1.7280412872193165, -0.3992308505936088, 0.13507148034604535, -0.4133775289022888, 0.7948590146464043, -0.0481079153860126, -1.652080698736549, -1.1923461357678473, -0.4729105935813866, -0.3277136709522343},
    {-1.1638897888602406, -0.4820554848123707, -0.9087591091934014, -0.7200636349565631, 0.6595205210626469, -0.11974486675818173, 0.6894637205660484, -0.4394070936233837, 0.2458198252576688, -0.3654505414999394, -0.9313547238100649, 0.8217844550664113, -0.23742863255306015, -0.8170184322610249, 0.3727162911056627, 0.16857173903231398, 1.0291105311488316, -0.8750296345665561, -0.1496464944900241, 1.0715432837875838, -0.42996057468202814, -1.3679378330284997, 0.7839307480927701, 0.6896788424596901, -0.07739424411623125, 0.45442255554245836, 0.09787048786605622, 0.3132600135688847, 0.7809160215776357, -0.6887450800445903, -0.2155263697498914, 1.870942515909476, -1.010500561755788, 0.0187419211690366, -1.3620299214266969, -1.8194664257128037, -1.2150082338835217, 0.6240633074759865, -0.2945792693283543, -1.1292278169256356, -0.39372021497387216, 1.0975751343321192, 0.37335496891323855, -0.08453523607730663, -1.8816557314617042, -1.8198431801838268, 0.04096151691228638, -0.4111146495934132, -1.6213812885427275, 1.06826018007754, 1.5705196526353293, 0.32536923466527096, -1.3172954508229238, -0.7452914339634539, -1.3585250164370681, -1.463246894961688, 0.5475697257221801, 0.9948691656525105, 0.012904239081311114, -0.6237924448567491, -1.3027757438580292, -1.779837333698838, -1.330270377672986, 0.01066023748684471},
    {-0.35175132565402917, 0.6676705727252766, -0.5353785031305162, -1.6803645395658828, -0.03425332283635179, 0.0520651842235077, 0.16755106343696755, 0.27675751211329097, -0.11095076532516895, -0.8324369745887061, 0.3767221451768991, 1.0832877708906383, -1.485656520040417, -0.3357358842666678, -0.4944745878880948, 0.06761616194150231, 0.8608937680241494, -1.1517086486472017, -0.5320275891022076, 1.0917844178134641, -0.5140533055076828, -0.8309675523141601, -0.6477810493845303, -0.4719865225583199, -0.032863043868064504, 1.196929036387599, 1.5775471654912627, -0.3498689915426398, 0.9220349731162469, -0.8726692087073852, -0.017434245813826094, 0.6193377234931422, -0.023965629800011608, -0.31328309889721767, -0.6115553871166338, -1.244097562555033, 0.2588383841595147, -0.3647967864599715, -0.6304580204297153, -0.4722266479562492, 1.7320002263031444, 0.5019653717542281, 0.07299119868952648, 0.12418821454814236, -1.874137170906257, -0.14712768797066017, 0.5202405229154007, 1.4289102721016205, -0.2920178078026867, 1.6179137984983123, 1.6120933457210331, -0.5820198842998529, -0.8856132038351777, 0.7986984954543634, -0.5493538050684154, 0.1339071969239018, 0.9044229544610238, 1.1873471393177635, 0.8708175773916579, -0.3142848809375409, -0.33795335291386036, -0.15762207915034934, 0.18351523927999064, 1.7993583024329414},
    {-0.41731442216523973, -0.6572996682809481, -1.2337640340314062, -0.18479946131787384, 0.1457084501448312, -0.8219361440931182, 1.1161423451535242, 0.12458309559427513, -0.704597554460955, 0.026029948142823726, -1.215739915820062, 1.1486010350086615, -1.3472491106113345, -1.4651420574391574, 0.6764079982094475, 0.3771931276615004, 1.8509355555501976, -0.4090600849918479, -1.1471822973041315, 0.3624753823130214, 0.08242547414031334, 0.29549036128951806, -0.011166123154780605, -0.07940684219413005, -0.3452555582371341, -0.3656893250405741, -0.02301978704263899, 0.7607140030791903, 0.9093959844715496, -1.2788681039806788, 1.2094767827719624, 1.8280648858795079, -1.1686360417601998, -1.296483704382679, -0.887044657314762, -1.4668507688276538, -0.4607770215733524, 0.8594097274089307, -0.9072248737268414, -0.08213773965812923, 0.6476615405896136, 1.1571764309340973, -0.45496134517176384, -0.02573290122349707, -1.21019719889719, -0.2754995109349977, -0.06384944010145721, -0.4720070822583996, -0.6129511717693112, 0.9649467571552072, 1.748984489845513, 0.4239017871990304, -1.019760405920889, -0.9272040537579597, -1.3932129134003635, -0.9079527927987604, 0.6167260283178974, 0.9214931955169183, 0.034379775456292776, -0.06891529966656475, 0.16301617610678673, -0.956957193957539, -1.3622918753623288, 1.925018613446274},
    {0.49924824993220157, 0.3834932707889051, -0.6111717664060311, -1.1817050087297423, -0.336617216139094, -1.0346299917301192, -0.08081214817609511, 1.3278823376562603, -1.1880676332280995, 0.11483949397984702, -1.6402299196677927, -0.5702097469122143, -0.31717341551335515, 0.11982965070018466, 0.7630341577809336, 0.024698284885031528, 0.4059146718213115, -0.2826732012328413, -0.3396122649879926, 0.9327190186455976, -0.1833946570802022, -1.2096458000262815, 0.18572505899570455, 0.6551356102832744, -0.14103709297151282, 0.6076660012919767, -0.27407807622433344, 0.6913460825728849, 0.5177403392422513, -0.7292135474821991, 0.510670477614401, 1.8120208197573286, -1.052055668597455, -0.8699721213211125, 0.0066780314078011965, -1.1715424543659445, -0.02201910532783338, 0.662907828938166, -0.7895404535509876, -1.3471067492596605, 0.7192359689795946, 0.8398502239588437, 1.0814672586422005, -1.2117768172425907, -1.6465921860435426, -0.0916759320236311, 1.0613381698760653, -0.735055231316785, -0.8175272551542366, 1.0015354767531595, 0.5582150619794695, -0.2669146519346976, -1.5802437099017947, -0.46463753674435176, -0.9837612599234375, -0.4334958872108369, 0.36639856636539647, -0.1075723478188941, 0.2029132561928982, -1.0655253698461744, -1.7403356625713708, 0.035846051908096754, -1.387464051385435, 0.584000759474961},
    {0.5243087949121311, 0.677153755051144, -0.7089174036392295, -0.667084447166674, 0.9966687462198182, 0.52714847098833, 0.42815606728358796, 1.20989032557499, -1.4695643837578205, -1.3481810708329716, -0.48375199167384664, -0.609625918906375, -0.21138747065965857, -1.5477323270593975, -0.4931352510024323, 0.9998260364760715, 0.9311512962955197, -0.26428969352770804, -0.39103814843441675, 1.251355090136298, -0.8576406109323662, -0.6448301449993775, 0.1825833323756861, 0.32117376214736365, -0.10428176017844845, 0.3752839055830672, 0.7594647158409081, 0.7909725602509854, 0.48286758267675595, 0.21548053885450377, -0.2384257644690206, 0.45859713551096976, -0.7010931877337064, 0.11507553301176193, -1.5345819097157527, -0.13756723890749087, -0.301180497294442, -0.29451805171543854, -0.6802148250779678, 0.1927942010580487, -0.40262676947598913, -0.7358642582301903, 1.2339549705548525, -1.033295134449342, -0.988024645806097, 0.005237164265793844, 0.5677211390181072, -0.03405805850187552, -1.0774633546363048, 0.20339060607708845, 0.38198650407391577, -1.0182871703237955, -1.29999048644926, 0.2653913707417818, -1.6012168787254126, -1.5561139999415863, 0.8719719941339282, 0.7259330367968997, 0.51736617478935, -1.346182975409261, -0.28314264449412657, -0.19069873186687084, -1.9410755118668683, 1.5988157513805057},
    {-0.3085118818705638, 0.5798618533871174, -1.564416767267901, -0.4395513310073363, 1.212865347690515, -1.2015651979847404, -0.3934984881801076, -0.43273448252096114, -0.8281692570170763, -0.19017215643446347, -0.05154015122807536, 0.4111959599942968, -1.5493302989824336, -0.6291554836149271, 0.1523021880543152, -0.008540600668967042, 1.407402778039261, -1.20144397672932, -1.1600209442484632, 1.6124451704353273, -0.9558560067733597, -1.0227281254766136, 1.0545068515731661, 1.014111877645944, -0.8139431045595662, 0.6871541658065905, 0.6636828144784479, 0.5896252947271452, 1.3925593137301466, 0.45484196283576134, 0.25570774561900467, 1.4996900571247445, -0.9814314199415826, -0.4023497476635478, -1.804093767736019, -0.8621516145248936, 0.10118121315741005, 0.8139309992341627, -0.9754259123141689, -0.7051746011057479, 1.6271587835234578, 0.6369835357606574, -0.3122994453833354, -1.3710378087131805, -1.1704390330352292, -0.9996653570185433, 0.667563554230083, 1.197993401374087, -1.5288886307047276, 1.6813803170505737, 1.4071164871282644, 0.09283736319519975, -1.4000935248346518, 0.7970747555638719, 0.37956087294382607, -0.5586644698545916, 1.591892216772062, -0.3723048072135099, -0.4359099420282161, 0.5204280414283894, 0.10365900136535999, -0.3903827939640376, -0.4689848391281249, 2.0298718149236255},
    {0.3922727249828399, 0.040211180165655315, 0.22740197524291908, -0.3137597928660479, 0.18850890998137557, -0.9529777742341289, 0.15613884152973426, 1.618035488694513, -1.0738632293655397, -0.2355902103599639, 0.2455975262471508, 0.6446079224379601, -1.3908251282924526, -1.389438532428148, -0.23344038063464037, 1.507998173739363, 1.307747916066253, -0.25653357055419973, 0.7012810452069068, 1.5317669482402771, -0.03680607956002649, 0.4770842590571276, -0.5263605521162743, 0.2500205408582658, -0.8747332036713005, 0.7326738333729491, 0.3707510212675206, -0.3165816155981428, 1.4357694934562502, 0.6324766198329098, 0.7778608748942079, 1.3826507504649947, -1.6171034406782423, -0.39409398786557764, -0.6448933314378443, 0.3175168093603099, -0.633896257587595, -0.27880321204261144, -0.06723319145369638, -0.3909697630050944, 1.2006213343073648, 0.9803466565389074, 0.3741784765096677, -1.7496935393925686, -0.47475789738145774, -1.4247350419916744, 1.1606460988212108, 0.29145094368439495, 0.5038641128613385, 1.4764219331979804, 1.6699902358196876, -0.6077725548779338, 0.33531587373467003, 0.14250234219631133, -0.5128719102586932, -1.5250856140230986, 0.5855738140543434, -0.3075491343459, 0.7733182355760397, -0.5573985398234769, -0.29299127644131695, -0.8405870636856329, -0.4103657341446684, 1.8787586421808764},
    {0.26453426560407767, 0.44628490558319606, -1.1657924749213178, -0.31826947528459154, -0.3761907180575777, -0.904437152320416, 0.3555584344079708, 0.6302494016314764, -0.9669375237032758, -1.0612736751913718, -0.29886581926407574, -0.014450378726587889, -1.7582751896937476, 0.04051230926822932, 0.052551329202890226, 0.7428311374211656, 1.8576099272908124, -0.6496555257037833, -1.0745156144467662, 0.8332299458918396, 0.11340643157838919, -1.0697179125380132, -0.5749213098189763, 0.6244387842137246, -0.4935524296309822, -0.16910824135890665, 1.4913286321114696, 0.14945236232309297, 1.062578575466157, -0.8226895805825203, 1.2593899002199203, 1.2698433213169646, -0.5969519299391719, -0.14491388684439374, -1.7966748328820608, 0.011513107191546374, 0.9602353510473095, -0.8873318056043633, -0.05102681393539443, 0.16124903811406213, 1.541960793699956, -0.10422030846202764, 1.2040290605280966, -1.8222190528710998, -1.398700748024653, -1.4216049713537728, 0.07203307086102126, 0.9006805054420032, 0.11137838207887077, 0.2760550609837935, 1.5239716693299015, 0.4661704239557876, -1.100565056660638, -0.8957635619144859, -1.3586434277955455, -0.08980419280643244, 1.5244795708995424, 1.0650074399329963, -0.08164282054726986, -0.4977031282578199, -1.3791251919635443, 0.38111325206105134, 0.042062517777011595, 1.3110814634229018},
    {0.40827960756377263, -0.12492885924203438, -1.071562707758886, -0.7140238216367438, 0.35258661663491897, -0.17094836792601187, -0.2454878442094543, 1.4016425604683473, -1.4238569561659054, 0.3759338229638624, -1.36762554654759, 0.1774660196549022, -1.3721429825430513, -0.5905931103562286, -0.9456298855892911, -0.36608947251547425, 1.4342960967991698, -1.4782259749594284, -0.4541751138673227, 1.1907396889960773, -1.0924237397729843, 0.02935858583170113, 0.13712822019978474, 1.0717082625991496, -0.06384034969245847, 0.6889099124280512, 1.150005661337237, -0.5090875692966954, 1.1210722619219002, -0.30036608522762964, 1.2633575229602325, 0.37433712653898504, -1.3787204736315306, -0.7140854973711424, -1.9144240981410683, -1.325306788400063, -0.08598911155209214, -1.1512558077152288, -0.618165140043676, -0.16367301410148627, 0.37324795836257446, -0.20038979510563518, 0.7882267368110022, -1.772777071485028, -0.23508192381254944, -1.178824685314032, 0.46702243364243806, -0.7726828717766903, -1.6958044780716466, 1.434236767073932, 0.040646455155288405, -0.9945834614308325, -0.6113846727676507, 0.6162312521271299, -1.1697275232554014, -1.1843453732796527, -0.36633535351638424, 0.5760573071922912, 0.26319132512384924, -1.138164213522247, -0.1814512013739506, 0.09597021329862872, -1.201416184434412, 1.5617510029114552},
    {-0.8036329245092553, 0.5007639403815375, -1.004993352667978, -1.3813395649902005, 0.6847895263265676, -0.09706758846689911, 0.07878476007478204, 0.5701207885610903, -1.049980230694677, 0.6762107802194428, -1.6892614676014484, 0.9215972071622016, -0.8243355856764881, -0.9877968789399346, 0.33109533528541557, -0.20975573718274815, 0.058319316697263444, -0.6589270026196895, -0.2702566782048194, 1.4434967415266666, -0.8588121543898172, 0.3104890389852991, -0.18946053587149853, -0.43309384045004873, 0.6060359122574023, 0.6339188268016746, 0.8152139591515277, -0.772871917945489, 0.1327445830837922, -0.2797072433873468, -0.23905329066698217, 1.7570211310818615, -1.5448506896470062, -0.07095651772956475, -0.6888174030938826, -1.7466907910668186, 0.24173981413394954, 0.23686601035741045, -0.24879448317177438, -1.3143516017826087, 1.4717333584112802, 0.980708751467205, 0.7486641672050813, -1.254928551512016, -0.2344774580308735, -1.1356559680378728, -0.1255449387462945, 0.09951302504912037, -1.4821253431614434, -0.2459322557409835, 0.3476857446485197, -0.7469615634723079, 0.2012395711838686, -0.20605107216520702, -1.7804150338293119, -1.4468279059961044, 0.28244333444256714, -0.2969279437664873, -0.6311016093754231, 0.4536359023701181, -1.7323301624371419, -1.6052640831957012, -0.6748170394596008, 1.3101083903729585},
    {0.5066954895477931, 0.303843957011876, -1.3079673231692042, -1.4869597394139353, -0.05748247518490461, -1.1878005303864818, 0.46087316764535263, 0.5551097878982717, -0.5137884850413664, 0.41050220492380135, -0.7024381881181377, 1.306073431027112, -0.8899367009243009, -0.5909437695737151, 0.4373049077973154, 0.6985399604199592, 1.2286075746834817, -1.1651082322274762, 0.5112570205602063, -0.10976770436846071, -0.4807084470172042, 0.3495266284544127, 0.5070578762154587, 0.4274145955882541, -0.269666623524847, 0.9439390219059792, 0.6655324885092271, 1.0450953763085022, 0.4750752427192816, -0.2618242222516997, 0.802487792759785, 0.4885788030957902, -0.7791543186462944, -1.5252071128325069, -0.8521535389748386, -1.3518721176854345, 0.6545123632772942, -0.43375982231875954, -0.14631586622023868, -1.1394161441828983, 1.3151988687102327, 1.0018658198576451, 1.2651678912121556, -0.15978207771063546, -1.9970148163953607, -1.0841927812910195, 1.1957666316050923, 0.8402007971996381, 0.3060100550460833, 0.12535127713627778, 1.5540586130685687, -1.2722474624589142, -1.3114082269273388, -1.0864148805775693, -0.058218791852396236, -1.2233418090490884, 0.031266871472260975, 0.7068078644120851, 0.2813697444677821, 0.6501128837013517, -0.8383233676709816, -0.31068259182790875, -0.6299922620539448, 1.0309754995465101},
    {0.5110498505824415, 0.9357042839927402, -1.2467234815415293, -1.2438381239361416, -0.19398997296128925, -0.11651958469693542, 0.5741706695689843, -0.12883263336615108, -0.9306849692194105, 0.6173575355685975, -0.5629795554525133, 1.3308888226894007, -1.3559204955861002, -0.7264627171754349, 0.2934791204356491, 1.478288491483376, 1.21432319392822, -0.45860637927443715, 0.5324189272364759, 1.5055515191094955, -1.0171157066621739, 0.08059748095865689, -0.5384588618160983, 0.914276948061668, -0.785362301891347, 0.06000003054125259, 1.0698628156541141, 0.5058591070653904, 0.28453494847530114, 0.5304997555480617, 1.0549867416884908, 0.38553022746873206, -0.2627864604325115, -1.421294491998187, -0.1453768542111954, -1.315059487354915, -0.4313412933954893, -1.1873075709655339, -0.9069496595855149, -0.45446491975673436, 0.7346153555486369, 1.0897903410884853, 0.5973904532595673, -0.5331440390842157, -1.8122632872562654, -1.3095356831808735, 1.010776822806301, 1.2457451169810763, -0.10297761300490418, 1.4880526469362585, -0.18615769781082508, -1.180629680709501, -1.2116744866562237, 0.4403026105333946, -1.202204840633522, -1.638512765641612, 1.4525834692956734, -0.23090300579855116, 0.0228118465058895, 0.27199162618085254, -1.2629533986682036, -1.3332175490115075, 0.02982668815782989, 1.42156398284391},
    {0.30846491360733197, -0.8366551684797187, -1.6363859563617638, -0.08176099808136053, 0.3727744046318129, 0.207644435610285, -0.4487951767286662, 0.8810380002779004, -1.4070196556088206, -0.7018004084300876, -0.47566421356742755, 0.1554961780740559, -0.19683619953052392, -1.3170485480632996, -0.6494157610122421, 0.8865813801356116, 1.3415749116779578, -0.09760144146810279, -1.1650305654124518, 0.6043264642170955, -0.3508350793268036, -1.2820866515239804, 0.5704591598621648, 0.8734660906760441, -0.21784391275059561, -0.06792820910719098, 0.7982021198485071, 0.48342435650963017, 0.863230266296575, 0.09173289012905646, 0.3755358729534415, 0.849499270481449, -1.1735294628907689, -0.220219503909532, -0.5447919306347409, -1.7222583439456196, 0.8923755421618258, 0.6756190386329191, -1.2188840434485126, -1.1583385804236164, 0.09483179188408436, -0.4832784486219437, -0.46790930784976514, -1.96571049726715, -0.2310413176796004, -1.0548641462325161, 0.48712021551413826, 0.6533870957901673, -0.6655084522705037, 1.2075614162564259, 0.09160294825175659, -1.2559141810859062, -1.1792170080081261, 0.8682970690263899, -1.3063602493187174, -1.8526968405592352, -0.3964320139815154, 0.8484151511286993, -0.40617327871586606, -0.7042886065928494, -0.4685896440544859, 0.007791481702930148, -1.4893092155767, 1.5595621236633386},
    {-0.0010375550179556351, -0.6105545451191065, -1.5530633193841756, -0.24694308272597734, -0.09865362667384311, -1.0181126941997805, -0.9550439047352027, 0.9185448297380361, 0.2894884002379314, 0.012993362715370407, -0.3693180729099486, -0.35829815816900984, -1.539224621405331, -0.6065679932162596, -0.8707452683510589, -0.4132685785278494, -0.24682229232722483, -1.5120480632824678, 0.16336771208000922, 0.2562338160951927, -0.1430057209086184, 0.2899429314036215, 0.8740199990503127, -0.6372128629272674, -1.1808609048141825, -0.41919137380901933, 0.16026144448727564, -0.874456051896149, 0.8792146907252817, 0.03878667479939665, 0.8766174397241006, 1.7654685987144876, -1.5025872102598734, -0.4323928291434033, -0.8045556969883997, -1.1433835514446413, -0.021270513946448025, 0.3849534010323254, -0.14029394110760665, 0.19356600095298418, 1.3646409420907966, -0.19966576459321395, 1.3901712602581742, -1.0661317646406157, -0.6133011597438789, -1.8548915651902942, 0.5991829107898762, 0.17399725631628868, -1.4385682171013956, 0.8434973523462872, 0.3801254006114742, -0.4198342727890872, -1.5416998224922018, 0.2598086193102378, -0.5437586065824067, -0.29938254307921486, -0.07889827762470317, -0.6890096726548111, -0.14856219186360436, -1.0723154804788213, -0.8151890478594805, -0.6035550633632675, -1.7521212160538724, 0.862935900783102},
    {1.0522444978798198, 0.7873981053353957, 1.0007268920523869, -0.3120451109253281, -1.261816421284948, -0.5761079864285661, 0.9621940709246102, 0.5478235970347756, 0.5125056596884142, 1.333067026648561, 0.12161756847148077, -0.9681821035908154, 1.0927746274637382, 0.5144593035264633, 1.4103271534489934, -0.4668592831051465, -0.3345553151544566, 0.5624786248087686, 0.2795573039545819, 0.11721150815090374, 1.3400161487234963, -0.8068539115517185, 0.7974913736361074, -0.24547658714485493, 0.11224023249078476, 0.0988983920803205, -0.6710333591185552, 0.301216859228773, 0.7884614154736866, -0.31826229945426215, 0.1748360235996361, -0.20846143587415164, -0.6190121539302118, -0.9196970319427359, 1.0521890838349743, 0.20324591685172783, 1.0874875561219535, 0.36084260921941064, -0.3073359022469304, 1.1140743769010248, -0.6011759294342949, 1.022460388842985, -0.9036401297854806, 1.3507876160151846, 0.035067765435898346, -0.19649227981705628, 0.9528761840442831, 0.8636297998370864, -0.8926236208457496, 0.36676939054317353, -0.05310017975083768, 0.1143057259617337, -0.47856824935629055, -0.47419736063737006, 0.23080684176646651, -0.41001097380327733, -0.6060499741616787, -0.159393560503043, 1.03984078620078, -0.17741531731107252, -0.7847064625330187, 0.004158267990545319, -0.7319383290498587, -0.4320615314209732},
    {-0.3384197605282848, 1.0440541682943045, -0.04203608267505719, 0.30168104062228257, 1.0008271997590044, -0.18425345655991154, -0.5562216597728109, 0.6208741122900178, -0.4263199816682494, 0.7575633109992651, -1.4060423657966725, 0.5530607060217894, -0.9544850520645074, -1.2090376171121782, 0.29345874353209506, 1.1384808796834969, 0.3540197336203209, 0.7206534522367078, -0.015003035074100151, -0.6649384651794491, -1.3524131149138139, 0.25385144407167715, -0.8624391158461725, -0.300824169085996, 0.11523283474699174, 0.5676751061955565, -0.06629329862731134, 0.7509725501363718, -1.1006543503967672, -0.8107325370969832, -0.7767317827128415, 0.7204159474226381, 0.14600628353424142, -1.1660691136121897, 0.0021999058382028633, -1.351247468581996, 0.7725392173560778, -0.8044725470287634, 0.40680720789455016, -1.387975221543222, -0.6395069644741387, -0.6801858359157931, -0.23288767204618196, -1.5408831377575163, -1.068670819070804, -0.5903439494454222, 1.5019517625493068, -0.10458754111757407, -0.9641692547597448, 0.909491656023228, -0.06910936859950649, -0.27184950390169305, 0.25257059082955957, 1.005798918595679, 0.2715818991187828, -0.3584987433898911, 1.01763601377699, 0.5943370492100275, -0.627883862490599, 0.47653037808525933, 0.6068397662292928, -0.71832671922442, -1.1835366895700687, -0.7551318229184607},
    {-0.6611812480191812, -0.9337852797573601, -0.4498253476158114, -0.2792181414733356, 0.18852253430896979, 0.22097778619484834, 0.17769640467420067, 0.6673057859727441, 0.5420624431971075, 0.21467027795705276, -1.412158071125337, -0.4746456726031796, -0.08383969725661637, -0.8833549557085593, -0.028815421843510606, -1.059963942168678, 0.7192191066756043, -0.3378392592624215, -1.288644131505967, -0.8115278344031023, -0.3384111473966486, 0.07681004655043508, -0.11743427618745755, -1.035191309181481, 0.256349602320061, 0.5594898269697477, 0.3340316984961626, 0.5021412362597901, -0.957685621789895, -1.6527930291189497, -0.8042029579975473, -0.8294655725399467, -0.03713119591369761, 0.9800988491613206, -0.3061793292866039, -1.0154554605186983, 0.1708592352038782, -0.09064849584830471, -0.9401186978019739, -1.2314034811577943, -1.163545301616141, 1.012561748675364, 0.07340980198377438, -0.38459907930268805, -1.2648398954105655, -0.22194088599213896, -0.65214599929686, 0.6429098216045882, 0.46354711627838896, -0.4886949419050816, 0.6755064993226476, 0.5279054411870452, -0.25211494638764176, 0.4466171531543873, -1.2668678192427179, -0.4231091514430285, -0.2540459260426546, -0.0899821353593188, 0.42280752176578484, 0.44760813394111154, 0.8701143643482838, -0.9711294991776395, 0.42530284039811134, 0.0678587042186136},
    {-0.4774653164726344, -0.9400331659625164, 0.18635628506558996, 0.5871801861400895, 0.3750151105656057, -0.6797516204685782, -0.45822685171494953, 0.8615392906137348, -0.5896934914597967, -0.6349212745216694, -1.3584001112790387, 0.19831797120669953, -0.4633754030895779, -0.7555058340747501, 0.22906415562718993, 0.10048857027204908, 0.8254697844755029, -1.3222622871173435, 0.3941741989146511, 0.4385856651504224, -1.1592899879535146, -0.7416562097178385, -0.6522543231010481, 0.6164581624384207, -0.0005038958549652106, -1.114480304283719, -0.04149979285037956, 0.9498005062534811, -0.6963426865343699, -0.5946251766743103, 0.19217747935486443, 0.06215577281320446, -0.020597386485472838, -0.9499189725627503, 0.7179665176643658, -1.1621750143461231, -0.23289024753446624, 0.9015768704592741, -1.1422422403445784, -0.2445102763760486, -1.3049798485448176, -0.935477098563514, -0.3073348542096374, -0.07407049461689423, -0.3634335829914408, -0.6236728102988971, -1.2878756991258034, -0.6386569696837084, 1.0437791680991588, -0.4459336053699753, -1.1681371387854211, 0.46881937828327963, -1.2418489554046028, 0.08099099018354074, 0.03948708488407803, -0.18161384690207336, -1.1758031566618883, -0.5515574578743105, -0.20485278276163482, 0.07896496076093604, 0.14642336650566262, -0.5557324087293878, -0.018305941175411816, -0.002575433608590188},
    {-1.38218637751095, -1.5526710624207476, -1.6566532423793041, -1.2848221406817217, 0.7532016878067764, -0.786076169422418, -1.4168008646539236, 1.2046950628203428, -0.1876652170378834, 0.07860174457415305, -0.3725569291729073, 0.16127751400801804, -1.233290145385213, 0.2526392511902132, 0.06546375074425448, 0.5672152963325604, -0.9482151360063222, 0.11517765986582883, -1.1893613142544077, -0.3820247182786572, -1.4483716696082478, -1.0287366978387562, -0.4070684146557525, 0.3562975188494177, 0.007536920325175044, -0.07844646502486319, -0.4673287525022579, -0.43260093632634405, -0.5527357708983016, 0.0758182261725114, 0.8691641809064871, -0.24078424430958012, -1.4272778027597655, -1.0949987181225886, 0.4178311860240186, -0.7217081943772566, -1.408320964665657, 0.3444576821447211, -0.09165252718902113, -0.5395015185489042, -0.6712386111903665, 0.9675770045689367, 0.9125924757484759, -0.3967255609563864, -1.5474145855784245, -0.8490428287807281, 0.6515784956856316, 1.1824630205527766, -0.19016994307859414, -0.38751170747072655, -0.25632530077013993, -0.7796897075490294, -0.6099545708526103, 0.2273347911104781, -0.033714143627860856, -0.5557801412392941, 0.33205742439606645, -0.557449599052918, 0.7631544485199466, -1.2743957714269942, 0.5109492831443033, -1.260332542665257, -1.4152946043345347, -0.3656167883581977},
    {0.3940547549552259, -0.848192744583632, 0.2829507797811111, 0.06451917054869427, 0.7935779456380188, -0.4759088088372495, -0.6513366342631811, 0.39859440856999884, -1.1276166779634058, -0.7784504609117752, -0.2861529382969603, 0.6471299091786843, -0.02838598036702412, -0.29672932828762055, 0.5466553701810373, -0.05280055291498242, 1.106881084771936, -1.0566234256126812, -1.2862439411773035, -0.253829143955324, -1.347308372151574, 0.2268857200625566, -1.1803679378826673, -0.9317351130825382, -0.9316671870332277, -0.549061624928444, -1.152410731000276, -0.13678814440469014, 0.6563851829010093, 0.5977586324696588, -0.5816340094418593, 1.0381095609019915, -1.5136397968902604, -0.06196731381076653, -0.38188439643877964, -0.30488378904597746, -0.43343819243352205, -0.03660290762267801, -0.752361425212982, -0.06670577412422053, 0.43284002631379487, 1.1215681982424381, 0.26862356623129724, -1.0536219652336822, 0.26720345371563103, -0.011891459917030774, 0.08103356159584738, 0.7384097424992349, -0.9583696326512775, -0.3886364155508833, 0.3001549880246431, -0.2947040687077801, 0.46157254456704494, 0.4315090103266684, 0.6429334139484905, 0.08141232523912892, -0.7609122699916435, -0.33941748599352906, -0.9009877593809305, -0.5666590122444921, 0.5385675011918056, -0.39131162926380136, -1.453634039091916, -0.9564112873873963},
    {-0.8534015816250884, -0.5023847624823896, -0.15403093101471949, 0.5499431989580583, -0.5556390268993028, 0.33546738152294214, -0.8389898834396894, -0.6418480349619085, 0.21583952582631688, -1.0885870188230005, -1.7835586756555426, 0.7255954800254317, -1.307430708389756, -1.054574900159285, -0.633920299311271, -0.25974968634248646, -0.5494591628747167, -0.105895508504422, -0.6174240145217493, -0.44928914656670815, -0.6829776144886696, -0.18229120552855235, -0.4912268319127357, 0.5539862547849967, -1.2885450618245775, -0.6457452499641226, -1.0435626940390463, -0.5482948618457678, -0.32417388861127255, -0.866606027945808, -0.836151526557289, 0.22602499816240246, -1.3511515004383754, 0.8247025210121344, -1.2438404726766037, -0.41628795891215864, -0.9382939410002008, -0.7267386063417105, -1.5552125310582006, -0.28320627548150706, 0.7390029386919611, -0.382950253582493, -0.6850367504453065, -0.01127511432936713, 0.252516344886683, 0.8333303365585496, 0.4121002651239144, -0.02054932970986538, -0.4030030234063081, -0.505443454437472, -0.9877386879760273, 0.20726791741997252, -1.289172775803431, 0.128686988624201, -0.7367033734251797, 0.7480285757534885, 0.5191058723409415, -0.31965039286501795, 0.8713632328371366, -1.0441152299492797, 0.044952809474478723, -0.7144930046857363, 0.4441163697016484, -1.2556353451185183},
    {-1.0526510877707376, -0.7309400539402606, 0.5721705612157065, -0.6873731719706342, 0.8306578942130519, -0.5692789964633593, 0.29106848090950477, 0.6886139664343702, 0.5279788605470914, -0.8004901801233866, -0.5738754746592283, 1.063187606062405, 0.13765742208576526, 0.4268334821283365, 0.5327586608703523, -0.035013445699677154, 0.08582458011486904, -0.7114452763121609, -0.8154375295133043, -0.10424498498018382, -0.40935016243526495, -0.579776389319274, -1.533490013035014, -0.47578451518865505, -0.4458602536837622, 0.07527358195843209, -0.09355074778485999, 0.9832338545183187, 0.3950105227120348, 0.3312828187618023, 0.8070239957318659, -0.3034144007903299, -1.0606641520932782, -0.22990635686725103, 0.3804102523541797, -1.1848024003143394, 0.9341758190401459, -0.4512694464409965, 0.02360954314116976, 0.6721524902102023, -0.2112987192506845, 0.05507174071329566, -0.42887654097367295, 0.5643413577270224, -1.3971685005491206, -0.8298158687681918, 0.08889183852497398, -0.8723433310129705, -0.7512771922049478, 0.9898413871114252, -0.059300305780551524, 0.1431416101684999, 0.25830328588118884, 0.56041567765279, 0.5437733152703433, 0.5226751903183097, -0.12633261540473284, -0.6444741086574264, 0.9624585527273042, -0.5223263229689683, -0.3761006943709661, -1.3826733172113164, -1.2042348315597473, -0.6977152397900888},
    {-1.61030692906782, -0.9731828765818125, -1.3676829106327595, -0.6941323605906821, -0.649018243229415, -0.30905108370527845, -1.624240051372592, 0.32404473043080456, 0.3428814195818207, 0.3994240163901378, -1.312887431539165, 0.758564314698705, -0.4715480368535155, -0.7972236834555823, 0.8450256067703446, -0.9906059447421894, 0.5911006887568434, -0.27120147642954434, -1.391165876732593, -0.03401715466368285, 0.438194160740982, -1.2157051402376406, -0.32184858692936325, -0.255518085999867, -1.2568588512502432, 0.6768011925336376, 0.04985163628384045, 0.33726008446397976, -0.26040985469516226, -1.2710306152698598, -0.5498474230097342, -0.41574446939543364, 0.42439721901359384, -0.7130683399032586, -0.022527658821008677, 0.43388371495357314, 0.19492422052305328, -1.0185574287866845, -0.36279874394352235, -0.9766132869788778, 0.31203599688052175, -0.13021919155499, -0.9727493285834853, 0.7318284727950607, -1.0186539379883883, -1.0761388914513743, -0.09535241578090363, 0.7650836049026452, -0.12031122034342688, -0.27803999798852297, -0.40815822289147946, -0.24892769581023094, 0.2647655611659752, -0.9418541718519753, -0.2532541161132338, -0.8689652578914425, -0.29996635690175705, 0.19068554959116513, 0.9851210271675447, -1.2116321986142389, -1.4321570048083274, -0.408453193151911, 0.10543085620965417, -0.5480265202099363},
    {-0.49427356848065146, -1.4315281698013838, -0.6420283201943316, 0.6234542070042796, 0.7389791026692787, -1.0091115308034475, -0.7818249229425868, 0.3574838423221907, 0.6734133927825319, -0.7794847316157583, -0.3216150674889521, 0.013833115808623817, -1.358125417340024, 0.7832623130992211, -0.4918252755519829, -0.42408984684206413, -0.5206433326141638, -0.3910502070073971, -1.7655740044624963, 0.13574126404950973, -0.8015243983722359, -1.077188652819331, -0.166016884131179, -1.066740012066457, -0.7813261824183824, -1.1127991532052819, 0.737705045363931, -0.8362705457759534, 0.5238592224473769, -1.5411796017940433, 0.7937212467165919, -0.3342760193311172, -0.3150208868223007, -0.22195693349619278, 0.027312377078109434, -1.1161772008625985, -0.25409778231185765, -1.0476262651889974, 0.4845821602321832, 0.4601563674840257, 0.5069663120001167, 0.6744298343992113, 0.8865288362152999, -0.7357256315945612, -0.0014397042329520977, 0.4303759189732575, -0.4729520704515377, 0.9010418607809801, -1.2896592568185652, -0.003687069364440257, -0.6651652900284588, -0.9734294626545423, -0.5858833669401283, 0.24920832631474896, -1.2337067867844234, 0.46751883335629935, 0.35903397664579967, 0.20271016511207038, -0.0873243981534808, -1.615022369081018, 0.5976829927516732, 0.20368684163398076, -1.561409519375909, -0.5714608713550752},
    {0.49206390899371805, 0.2703206189572518, 0.10733574173265126, -0.5366178911109861, -0.15491164011469577, -0.5306989169611516, -0.5455148865432607, 0.9121985416091245, 0.7685977274827648, -0.4641923327216547, -0.7872675233664508, -1.08788736050613, -0.6328853547062491, -0.6550674849779199, -0.9363118666470924, -0.370603709942351, -0.434667772797101, -1.4802490362848155, -0.19882212288352882, 0.8969275615976348, -0.18107511806478654, -1.4704156138533546, -1.128441473375773, -1.3224669783857201, -0.1505833445673547, -0.6812766160656134, -1.1117420818568204, 0.9160535834192243, -0.1193975411546252, -1.4407943361364257, 0.06876343815527151, 0.15760570861787718, -1.1354635929271766, -0.3079929786996237, -0.0911458652562581, -0.25959218420719515, -1.4042235185844927, -1.1223838059115376, -1.2711482841194734, -1.0334512219034566, -0.5462498446075658, 0.7618144780038102, 0.7734977486066322, -0.25625605003240653, 0.6778166722971097, 0.5504481059245528, 0.0930309029127341, 0.2605942361401907, 0.26816956964277316, -0.5589439245727855, -0.25081574889223174, -0.6763949167113903, -0.8209160338557624, -0.8233485670563683, 0.3526806254250685, 0.7893082820026693, -0.4356494914020959, 0.6350758229151043, -0.8166170026299626, -0.9129899833865218, 0.4000408226763819, -0.09155346199844136, -1.392112997244712, -1.440242703030332},
    {-0.4960532854991731, 0.24956549241541448, 0.17932719986352538, 0.6068060942138828, -0.5777561452004022, -0.5675166148456542, -0.6166194148443411, 0.7246523398028945, -0.37336053621039333, -0.643949211797994, -1.4308820819040318, -0.07439997400806643, -0.9468348422926506, -0.9314625453733058, -0.7158572493293216, -1.0329805268472014, -0.6477011171995457, 0.09655406102450355, -0.12538131483311332, 0.7046540280818193, -0.015285137688511353, -0.35451886694197043, -1.5563896548877627, 0.08201591769095222, -0.7704076360212668, -0.6253810441777047, 0.23417020489928905, -0.07072894898393711, 0.15573213063755434, -1.104756645685112, -0.47901813385083936, 0.3879780930618576, -1.5907270566573564, 0.7641698046363644, -1.108028588770424, -0.9980783828355344, -0.9499315128147073, 0.44854658272845266, -1.4185918585880033, -0.4357824136358172, -0.8692370413284227, -0.07735782002574632, 0.6663313744117939, 0.00401057578858293, -0.8371685540856344, -0.4355783206527701, -1.0940364078129459, 0.46175599334820583, -0.0385840217905256, 0.4556675303788274, 0.9055654561414154, 0.16863569676730836, 0.25962701409634736, 0.7539862697694978, 0.1219812204632174, -1.1355936774898554, 1.0905793120548424, -0.9370038273095672, -1.006412364548909, -1.0335090400242313, -1.3042834413500752, -0.6898930917034198, -0.9164097738742756, -0.6997402855908629},
    {-0.9447563767584995, 0.4857907235153811, -1.2831575911186792, -1.1449592188701114, 0.2768766816248408, -0.4744224892145935, 0.33399289017969636, 0.3432363937441965, -1.1936250069101053, -0.05911596744644505, -1.5373950738196722, 0.9861751508207283, -0.9452688511530422, -0.47173662201976296, 0.2938165498755245, -0.975961686976122, -0.8658307638952298, -0.6174000032912585, -0.8989804325725703, -0.7379573933359193, -0.20243057164503364, 0.38441597273371936, -1.4663303515997672, -0.7981027654730295, 0.02695321508426496, 0.7441914508902617, -0.7968929475345015, -0.2076297498247837, -0.5701168949220907, -1.253343585126714, 0.91726777266966, 0.5102033206309594, 0.02152195045422435, 0.2867078789883788, 0.06319674330113474, -1.3623722324692722, -1.0537018757542984, -0.4734323227240428, -0.0808376606384453, -1.1595533953860235, 0.31045078847896745, 0.8586764203693177, 1.0884928097464979, -1.236592801142564, 0.2413575946980636, -0.9742391068052264, -1.0616894763478415, 0.5586823584778754, -0.9107373878843975, -0.5540187394246843, -0.9066649351694989, 0.6406385225929524, -0.818005180111531, 0.9729769491468397, 0.4646393395473239, -0.34109586291666777, 0.2575192353705844, 0.5457187107935874, -1.086461253600541, -0.44775226148443376, -0.18255675535687593, 0.280689878218952, -0.7273806178865604, 0.13873110048847595},
    {-0.4490045601411396, -0.20116614816999953, -0.7036294461051247, -1.4496019836770406, -0.18239242659569185, 0.05627967467071492, -1.431070237585491, 0.7989631305013533, 0.022450863419198167, -1.2059522669029694, -1.402472602244713, 0.9209204611979759, -0.43168015937184157, -0.11701277133664763, 0.08027381578587896, -1.4669624585548922, -0.9372963358118186, -0.043760866356100034, -1.2510334798995346, -0.27997859890653826, -0.3478957427780898, -1.1625733157106162, -0.47528659120610817, -0.2059766474113658, -0.40805629341606947, 0.3961136412253625, -0.31585185721228015, -1.1201394206639321, 0.6776203015826491, -1.8365573933930368, -0.3685815930610402, 0.44917214749791934, -0.9098177901296646, -0.07287820090709286, -0.8677798891919415, -0.9226647472466348, -1.0523163636059911, -1.5483695641136208, 0.1724587537893084, -0.8867580116914581, -0.0871669820075985, 0.6434221159973996, -0.08847692613423257, -0.5007065221628749, 0.19684021088278833, -1.1888398227437138, 0.7558684039543139, -0.5721218736222503, -1.3975888779113808, -0.00545859818917469, 0.5426051200769058, -0.7612306553399065, -1.1450156445368367, -0.9111711678677732, -1.4886103025526678, 0.10551549992845376, 1.092935852357101, 0.8019992109172979, 0.3469303235605895, 0.2623807513603292, 0.5083851892685982, 0.2921400432049184, -0.6651953942445504, -1.3368608543411575},
    {-0.3320372115355495, -1.4443424183928628, -1.4774433880836628, -0.4353482443271236, 0.4369930495154872, -1.4725132365537856, -0.23132839447337492, -0.09173759419527704, -1.2489022545586503, 0.584296127841784, -0.5995100655785097, -0.7907835818427601, -1.2369915353401346, -0.914158841250899, 0.9371294077290958, -1.1223482930553856, -0.20155113852573817, -0.3396539530974743, -1.5530753673228004, -0.9974946125347328, -1.0112216678841113, 0.10410149664395454, -1.5707728369903031, -1.229635742669054, -0.08544719095388226, 0.662569295551396, -0.39882176488939636, -0.23942483360987232, 0.7093140920146965, -1.1892485916900755, -0.5089467623035999, -0.389906248381633, -0.43766131401050634, -0.1450848190684899, -1.2959099109880274, -1.1371761567576093, -0.4011101254476869, 0.3161410166438589, -0.9814851346391571, 0.02498989041025872, 0.12286967952420037, 1.1234389773418232, 0.78099749954454, -0.6272644929665715, 0.10574472856471977, 0.7189725972907522, -0.7664132568049604, 0.00021419864799377978, 0.30759068333945033, 0.4484044324829082, 0.16652180502336866, 0.6406225261424223, -0.2648274572173689, 0.4240702215982567, 0.3395972223972338, 0.4394582307455172, 0.25404070414368124, 1.1772171097509412, -0.24938731358206315, -1.0721631316494624, -1.394942726664632, 0.4769228875285773, -0.16814320230755878, -0.81412094124179},
    {-1.0592912637449852, -0.49025575793632387, -0.6948554237422125, -0.2516774505485197, -0.25806523559449346, -1.2597506504111897, 0.25031938584692387, -0.38622777768183103, -0.021542691394765674, -0.8869995141679707, -0.7993488699493875, 0.5743363390488295, -0.7020003252614945, -0.3420037291831606, -0.20967001850233935, 0.3116614791159829, 0.5474582911263076, -0.29628169379024305, -0.8962958810103077, 0.6530117094892616, 0.5573030401064012, -0.09540631454699809, 0.10056892885446525, 0.16237232009248467, 0.25393773644425066, 0.3294142031764328, 0.7485303951168302, -0.6653863086176097, -1.2183574503827364, -0.8018857058719594, 0.08067722014485541, 0.11157303089873118, -1.3521196468523429, -0.05244622703098197, -0.2920296077296715, 0.024424273083923153, 0.21257155727093877, 0.01085968389174758, 0.09329272565444852, 0.6282692814592961, -1.1041358692552967, -0.04098522203200978, -0.1717685921800723, 0.3594431650066866, 0.3306924612564591, -0.0032813972304983445, 0.11645905298611688, -0.8579945287799989, 0.27874488297331385, -0.8217277015362915, 0.010623982514218968, 0.7652787970089494, 0.5339363755335118, 0.6046325222870219, 0.2023668504067603, 0.10285232784544462, 0.4907407826607777, 0.4237892872372449, 0.015119762889795161, -1.5225300599307707, 0.1007986557572801, -0.8590325592651965, 0.017195266162292663, -0.8238091659407203},
    {-1.4066821975306159, 0.07731384376981464, 0.2920319562690138, -1.1338062616464428, 0.0748431791703655, 0.4578974474643115, -1.2074310781624433, -0.021473241072655927, -0.8822075925788627, -0.8286664494765005, -0.23901447192792633, 0.3942951437120366, 0.008034731089506916, -0.46206779986452384, -0.12022899188832657, -0.19529632400403724, 0.05891092187337146, -1.3582822434433603, -1.4588209356482986, 0.8943662677081221, -0.7324117957720465, -1.2348163284784275, -0.8481490295769335, -1.3797966268219632, -0.8035849974646395, -0.6568606254579634, 0.936269879296182, 1.0021621640081453, -1.011831032585561, -1.4803607562981986, -0.38273068444102026, 0.7158200094681163, 0.16148547504261276, -1.005815211528208, -1.5673218631589005, -0.4212752222588877, -0.4084544646567643, -0.18499699343080248, -0.23517844419038045, -0.0566453544043901, -0.2953974149729242, 0.37518740227617475, -0.26773878659725503, -1.2174614166464266, -0.8629692632517282, -0.38796511264927325, -0.20623223396096615, -0.09100119953607559, -0.7030432315344047, -0.7056550235149867, 0.78627149310455, 0.49313556246173906, -0.689022433398027, 0.478781523273394, 0.28499900427678226, -0.199136974603929, 0.3091142886292782, 0.7042418699721399, 0.3422554658475529, -0.13960470513836384, -1.0745096706788522, -0.29199670015231516, -1.3886410046457238, -0.9356559909519048},
    {0.5809440123821473, -1.018116524583794, -0.6503281161666944, -0.15189542425772143, 0.9575463939951678, -0.6415421164702726, -0.10637877860680268, 1.1346798210043927, -1.2400811119076283, -0.9509782672970577, -1.3225523485914934, -0.37560662541519657, 0.13042125642063646, -0.220786718443591, 0.9479465835422121, -0.6894509860149152, 0.5332800592651129, 0.3121978119940847, 0.42566015959113623, 0.16055228841692562, 0.628456873231965, -0.8231085788946079, -0.09613221377492179, -1.0078475269605844, 0.6340153165393764, 0.6352643076709031, 0.14772483188113242, 0.6560502557562101, 1.1055185792085498, -0.958566355664049, -0.13195475798422773, 0.577923328730259, -0.07313069766275881, -0.37566867763343853, 0.24203310580030216, 0.3028011244783864, -0.04136270150425619, -0.9883464555672024, -1.080363656168779, -1.150720953836783, -0.3058792759337256, -0.09492577808534192, -0.6487641089808663, 0.29543551859339995, -0.426717483158746, -0.17333794163748492, -0.6995181783555419, 0.08441363065609822, 0.45552181344843545, -0.5572137733520129, 1.1139505327538703, -1.0463277488952032, -0.6025649830682667, -0.2999385879527267, -0.3229694136848999, 0.23381432585777978, -0.25520324866849603, -0.4899768686063395, 0.42244939430655076, 0.37783996148100363, 0.07958388702642019, 0.6951640629358121, 0.7445211681243629, -0.4168222799638446},
    {-1.3522746498023956, -1.1191526685843414, -0.9070764404861669, -1.3584387808556284, -0.09846012847761787, -0.9598605453057437, -1.3374649635925, 0.2276915227671037, 0.6074651992664395, -0.9872827106674581, 0.0050658365229565416, 0.4913293539313654, 0.6799747388444286, -0.024546577837038404, 0.5411024973729911, -0.7256904782478912, -0.5946258582113492, -1.1103429503778237, 0.015973830037839278, -0.19014175206274228, -0.06380575988180219, 0.17521849238363685, -1.7201262905559958, -0.6612763575726449, -0.22492326239977067, -0.4742697243549973, -0.5066472898178933, 0.2931905481076451, 0.861793488886358, 0.34386867200003424, 0.7911564083073771, 0.7435575459203634, -0.17316217002370335, -0.19712733990760425, -0.7313992309227686, -0.5734597699755367, -0.5532638166040045, -0.6601011457273627, 0.853237023753641, -0.08910337271845394, 0.6536282975770462, -0.11845963709232384, -0.8087373922532617, -1.004017904189671, -0.7317220016587147, -0.3628850056967549, -0.1222257711009571, 0.2894701792932415, -0.02245329376895369, -0.788501171781011, 1.0157129988972098, 0.03708264342063145, -0.26976736638397997, 0.40193274757814135, -0.6841407021451984, 0.2189514684730486, 0.6526678194681044, 0.362558181816944, 0.7774836701442162, -1.4265210182687078, 0.4666371136242802, -0.5316969238613083, -0.1835211303595217, -1.0627044616535437},
    {-1.3716477607096194, -1.3107861035246025, -1.317368845434398, 0.43228801817543727, -0.29073617512385763, 0.2342884712106314, -0.8050759538870385, 0.8738411030179492, -1.3298494669690402, 0.2129072374673985, -0.6142060986299941, -0.9521043543193314, -0.916369790450354, 0.214776665309833, 0.6290219379586932, -1.5273757249744786, 0.18085293659504845, -0.9120294518097309, -1.8129546938251746, 0.20605778618917112, -1.2165618587787084, -0.447961278716531, -0.5544629115549823, -0.5716373426206162, -0.7925231858279427, 0.43024859485399464, -0.9954679692651585, 0.6606595860025736, 0.8090118567720508, -0.02742190287835959, 0.09408538933638293, 0.9002894259186999, -1.1675239855845347, -0.133997608359805, -0.7482256806992786, -1.4001939189663617, -0.2810296926902385, -1.3061160453896545, 0.2797546396052132, -0.8924261970677669, 0.5795000825893404, -0.0730333960061419, -0.4615820066110524, 0.8137650959669173, -0.07479946403085186, 0.3698794406502078, -0.1560299788375634, 0.29927224350794573, -1.4885646980593517, 0.7031958626964457, 0.05691709584325595, -1.0438325838606601, 0.13991343872092826, 1.1274622988656584, -0.08720101705718479, 0.27751455314865164, -0.37250458563555183, 1.2047784326269666, 0.6395797537965532, -0.1462196329528205, -0.18462320175270752, -1.6905017602065318, -0.9834316740811891, -0.8313932165718972},
    {-0.5486881184029089, -1.527544315060716, -1.813575756651191, -0.26064023607738107, 0.5802358361999294, 0.059585658055443594, -1.618381486341516, -0.1440892614592898, -0.06831250111316872, 0.10483489033887393, -1.8638907553206088, -0.23865248805034037, -0.627247249549331, 0.5163042879259767, -0.8825910751672471, -1.195579016218842, -0.9178954443521512, -0.7858138162823178, -1.369419621242888, 0.4077375572823175, -0.996443268087027, -1.064934517631427, -0.12188864902629519, -0.13962598012117558, 0.045977227773781784, 0.4846381390335458, -0.15042858720759494, 0.4063807617789835, -0.7373901118239089, 0.10498771328374248, 0.39298842556490715, -1.1665823853265855, -0.023595836335620873, -0.2152134528365056, -0.27165196449914425, -1.5064525029577367, -1.822805756274081, 0.10862405566482991, 0.05252550472990519, -1.3785265577622157, 0.6429974499289218, 0.6189605530843131, 0.380517911534058, 0.05259461745919929, -1.5752762070660142, 0.46999709642977305, 0.4994251855843011, 0.7891566492535709, -1.5888595005724644, -0.5983993140322955, 0.32354778411051277, 0.2823094250398087, -0.44915486390023407, -0.764091962563513, -1.7615547416286028, 0.038265290436595205, -0.5251050833376767, 1.0575669838888782, -0.39244418004753084, -1.4219608925092766, 0.154055727141018, -1.3754767369225986, -0.9073077135936028, -0.7884935695872092},
    {-1.5823361295826381, -0.9181550975376646, -0.5579585297537807, -0.8401276051856977, 1.204454395858417, -0.8747130719828723, 0.7037316347963568, 1.1412658586469948, -0.05536883678237417, -0.26610253428254727, -1.4434414573240446, -0.4905649727421469, -0.87395788833893, 0.03160121636002257, -0.3804494415114171, -0.03394873073960932, 0.7790304042754161, -0.38529427866047095, -1.0167366880736777, 0.8019350735400869, 0.6682463111275262, -0.18364977077763583, -1.598065850849332, -1.020016512145167, -0.3315084665243776, -0.2005355104528933, 0.23131777029562142, 0.15032871070340761, -0.43281911014003166, -0.5383276882285635, 0.38437806616300974, -0.2555042333891688, 0.6170960111398917, 0.7462642531207319, -1.4151459861008473, -0.12950273107678362, -1.3132632085022848, 0.6696375951063427, -0.8385531379525556, 0.26440410053870855, -0.536417691299932, 0.2810358530623138, 1.410694524559235, 0.5757220025495715, 0.18882961457594824, -0.6903933791490243, -0.1055572352249706, 1.2603032498927818, 0.341037260821424, 0.8735405171264917, 1.4555066895150497, 0.29276682393598735, -1.0206395958611099, 0.17926987780799478, 0.4194963421983017, -0.539336378516882, 0.3216261578089515, -0.45414421741197203, -0.3991126269314661, 0.2793655332523023, -1.3336475683562854, 0.03679834970451501, 0.33595277754799313, 0.7794814291417604},
    {-1.627111682517913, -0.5004296458148538, -0.01021810198735705, -1.0858422133861092, 0.8463985160381006, -0.9279784152839597, 0.6642661737891608, -0.493188623357449, 0.06880772151255532, 1.2156067984415027, -1.0185684545929663, 0.5347962618823908, 0.530620829831319, -0.06330266958136156, 1.352141773221865, -0.0015464337778892752, -0.17536986871273091, 0.5723877867885845, -1.118341075452426, 0.7020470402567002, 1.1515985949575533, -0.25475827972101733, -0.5167134378746053, -1.6658441610660217, 0.30852858247132675, -0.7009612064050907, 0.7415865462610604, 1.062328046600655, 0.1551406233079464, -1.1430426368647295, -0.8197135315117746, 1.0523995147503689, 0.983766081571916, 0.2841551113657274, -0.3706031837740643, -1.080644120043173, -0.7644948843959685, 0.7479323969026576, 0.6760991068621797, -0.5142200295462057, -0.1675467777413075, 1.4295967857928376, 1.0929240338757662, -0.20363468589877115, -0.4544941376267936, -0.6162844894608726, -0.1872591140226757, 1.5404122628225037, -1.3266256749587235, -0.027961107073579006, 0.9099918979693454, 0.05673866862218483, -0.4980774319253577, -0.2158936645013744, 0.04756615526786561, 0.3685158560010513, 1.0226931252659084, 0.5278934422289105, 0.7566275886590108, 0.3850937366777297, -0.20549172851556577, 1.0211017696696034, -0.7793274017713416, 0.7844449173343453},
    {-0.33363511761955283, -1.2839720697447592, -0.05414375154667089, -0.15326422727083053, -0.657417665236511, -1.499668316097152, -0.9606530851693271, -0.6950264318912803, 0.49167970307684233, -1.1006488100851362, -0.6115907477364312, -0.21559970170216927, -1.2713244562948252, -0.30914185065009814, 0.8171906154790943, -1.1034259361197614, 1.2279901557402086, -1.2085550567191328, -1.2603107024629716, -0.02159882805269463, -0.062395944887642066, 0.0055204530799043226, -1.7170990836028321, -0.3790958478415488, -0.21841963296177408, 0.6263639815828936, -1.3255062954947217, -0.45005423707790854, -0.022520308878360016, -1.2230648804300372, 0.4986949535650402, 0.31856090931789216, 0.43724094965100685, 0.5376019400445282, -1.062306951198272, -1.4183417517309551, -0.013983024009733839, 0.7927760886691717, -0.11016982989448715, 0.46740982626406163, 0.5837512146309288, 0.8710690773136871, 0.4580937562581976, 1.1434743002797587, -0.5531179927352537, 0.5771859384493446, 0.8110218666660122, 0.9430238291352078, -0.9563847769385154, 0.44624787196925253, 0.598284931323431, -0.10787319582417804, -0.44134613714059195, -0.7541916852330649, -1.1328694677115263, 0.16797411538420756, 1.0642886014654613, 1.1697328155160476, -0.7579390967928287, -0.9347137824509826, -0.453097647145335, -1.2480040942053683, -1.098698996061722, -0.6881424638025815},
    {-1.2447925130078874, -0.5853466230260114, 0.29997576223063294, -1.153919145344829, 0.04253850033837522, -1.2279490560211932, -1.427013379994844, 1.0227060919575155, -0.6207940183262359, 0.11180341112418161, -0.07287396875924686, 0.22141272411500348, -1.2144474906091614, -0.38395409129489483, -0.2962150457410086, -0.1600890810484769, 0.14946842082891537, -1.2535568238214416, -1.8616308837147688, 0.1958031614471584, -0.9856914071523617, -1.0708529115851908, -1.3618281563973185, -1.437034178953659, 0.7519952334519737, 0.6917880988784768, -0.6196410992413822, -0.9761358624390347, 0.194109130354, -0.23924731804960012, -0.6144747350531885, 0.4137535281970638, -1.2886454056501437, -0.685474469535028, -0.8930328423524082, 0.25502075417669623, -1.2856461480508952, 0.02675694029320188, -0.09193685498799359, -0.3742848476665499, -0.10279766323421465, 0.047303690027186415, 0.5568435007558261, 0.07812868077558008, -0.5808991648560539, 0.3822090501633717, -1.0937916394625227, -0.5172195867084265, -0.03544160480067321, 0.42889791758590506, 0.1597127082907816, -1.1967295050066844, -0.5644101286537294, -0.407004159668049, -0.5656148293075629, 0.37486937504569284, 1.0935770800362254, 0.624858278758096, 0.48118328696813284, -1.482663822784546, 0.06927488051366287, -1.0528705797743723, 0.08648162914170276, -1.1756366616950817},
    {-0.6622423001681067, -1.4741972703954174, 0.5859559047814448, -0.5634089192426888, -0.7426555782001607, -1.614271461094098, 0.9389880983859218, 0.176732663558623, -0.6923352285748249, -0.16428274343683316, -0.7147073534927278, -0.18617737820826324, -0.67424598549567, 0.13944332351268937, 0.3864282981955097, -0.258643626988543, 1.1669027877339226, -1.0532670706891736, -0.07145098893498565, 0.33021169346806495, -0.180895976914647, -1.6198675186410003, -1.3946395050096696, -0.6561463334752062, 0.858757437691984, -0.013015537293927142, 0.35847828132293325, -0.23334684952847343, 0.5290996470130684, -0.24793830606085945, -0.5663373977926373, 0.22680623758254506, 0.20307851578336636, 1.109377925616448, 0.6278624338172532, 0.20311569608029498, 0.41874182121100245, -0.9622982973443329, -0.7777105078711419, -0.6270689127044853, 0.13776616701966773, -0.180252278000737, -0.7916580710631858, 0.10896354977203333, -0.8314703503209663, 0.9385031742428007, 1.1720237230524824, 0.857105193469812, 0.6397711936547602, 1.0564524007790348, 0.15011093322099875, 0.338651338368492, 0.9123210832273648, 0.2980218282882882, 0.12035393202330512, -0.17451283043595156, 1.1204587223382831, -0.47692599553643006, -0.11630452292709409, 0.17589720404033135, -0.8601772344953387, -0.5395873888993639, 0.12055173066804249, -0.09337580508965126},
    {-0.567061433408632, -1.6830965235135003, -0.2355624164188229, -0.17037174147813494, 0.2870615920382465, -0.3155884574313231, -0.5915556054888476, 0.4477116440848377, -0.7644649573529386, 0.7622237303075668, -0.8989063722790851, 1.0509291009519317, 0.01708127190707189, -1.2236567351486354, 0.7355678218294691, -0.4746748246405586, 0.4083345425816564, -0.923314681296602, -1.4276783058006237, 0.5009000756277628, -0.5883290675818736, 0.023460633447171718, -0.3829653401310373, -1.1749521712544118, -0.3516953267198274, 0.5855075019501472, -0.4617258600876777, 0.023981989757625926, 0.02112440040592881, -1.5179268362868377, 0.8661486670656421, 0.7169985703508622, -0.6399194734931644, -0.5628902451331443, -0.37785497094770676, -1.5342918177187816, -0.28013126839420627, -1.1503435206212207, 0.48822470637907883, 0.08556526694094964, 0.4936576059002978, 1.2881387116229412, 0.49392463898739647, 0.7709960820703373, -0.3637242856961227, -0.7733002304038089, -0.07396946567882474, -0.05016165872474856, -0.6796065404663656, -0.7704196783291546, 0.4248577472185654, -0.9513938121856337, -0.38783257301935437, -0.23662238803877994, -1.692171545032409, 0.5687717844604219, 0.3125728026904946, 0.11451036087321714, 1.2314878987928632, -1.5804044091881082, -0.8681706846738072, -0.6788984331692797, -1.4562771405347932, -0.7155414928318535},
    {-1.6636601864303435, 0.04340910660067097, -0.9454228927112732, 0.3994186201606604, -0.4395641939875666, 0.04023970349909951, -1.1358000797174082, 0.49418408784019174, -0.7752351270616671, -0.699812198306188, -0.6043336966491666, -0.23679517263622019, -0.11735504981945546, -1.116390067720837, 0.9154892455730003, 0.49756639143364867, 0.2642699464814397, 0.13909200668617863, -1.7007360078358593, 0.4216680621275818, 0.3311967858729898, -1.4621447718627718, -1.769862113629299, -0.09683618674764334, -0.4816787703994456, 0.5380647307264232, -0.24254235487244538, 0.9919527572223553, 0.2046827403410006, -0.7703904969252436, 1.0836097132256102, 0.1914791760636139, -0.7125511642606612, 0.4802249402248805, -0.6839750317668132, -0.19088408636934717, -0.9488457039660099, -0.26198745660160605, 0.5305525797871778, -1.0248220055706927, 0.21133821826597685, 0.5115807710065381, 0.9287735335797441, -0.4688062777806622, -0.02511281667750752, 0.8678609411554017, 0.35250125888878403, 1.1055382754255145, -1.1437528653440443, 0.39093328367313845, -0.622258320348704, 0.7975905718663151, -0.8584400447094694, -0.38601757522895025, -1.542600597318127, 0.7381151484022689, -0.48774541330153504, 0.8119711251122979, 0.301211156769372, -1.741377781846969, -0.1522232812564287, -0.15622215421828597, -1.1165400098803178, 0.3956140471895807},
    {-0.7971532504295025, -1.8245355233906169, -1.0455242407840264, -1.0277426449031617, 1.1085188523217586, -0.5140383429010681, 0.8694768604597811, 0.8794738501206955, -0.2961489053579507, -0.05217982959103289, -0.13559033965289108, 0.8317819132515968, -0.34392847031545465, 0.759234995978288, 0.9467219334771643, 0.4487490205244502, 0.06122602298749334, 0.2921999669045492, -1.883490264605777, 0.8857685509817208, -0.2281170416799076, 0.026068481218602006, -0.9924503654793687, -0.1939211568998418, 0.5121317187539152, -0.07707620699461624, 0.06826557325869781, -0.703636746551266, 0.3983737108667195, -1.6443056177936446, -0.2992082171150439, -0.03573055940652361, 0.2609493425669504, 0.8194780653151769, 0.21215429534023325, -0.2768459204296866, -0.9236862959953211, -0.48552472774109995, 0.41494453971888284, 0.46661594475761603, -0.5883604092693502, 0.6203900078186771, 0.07044974188783763, -0.3931881834619969, -0.0896061859179811, 0.544232866073303, 0.525518943078014, 0.8264045572020299, -0.8168663117515379, 0.939396486312628, -0.29153056417642687, -1.0018232989150029, 0.467372707677385, 0.5906507582431507, -1.6454799633866894, -0.18330629709869645, 0.17965633618409113, 0.12392032802468811, 0.35219469211725873, -1.1772807266414376, -0.4491531385989151, -1.0172951295759622, -1.4079292025302064, 0.4768116346241891},
    {-0.9164833732698311, -0.5570515453610848, -0.6453868041759618, -1.2988919498839997, 1.230951678222708, -1.524629831296199, 0.48098885538278047, 0.8572229263497676, 0.2074759087869052, -0.7204608865051442, 0.4812307631892754, -0.15290884292875317, -0.5283739100234571, -0.7631150434349082, -0.3200130354165824, 0.294523201593398, 0.4878093957367462, 0.1355716792146267, -1.699710611730653, -0.039023117159118444, 0.04618846319406114, -1.189448141126914, -1.4183431476701964, -1.026845805315849, 0.762288983915978, 0.5853184304382694, 0.031080816897734835, 0.05824452400542514, 0.5160751426596569, -1.3580199051155026, 0.06136774346554505, 0.7235795153497534, 1.0273605021866552, 0.6867253502651085, -0.7598853812503156, -0.4709889404956764, -0.98519258351792, 0.03508310086963599, 0.0006825761896551897, -0.09354199316901865, 0.17314041901346947, 1.2705049426625414, 0.7627847053650977, -0.2864130219166182, -1.1765340433701648, 1.1289538521993407, 0.9325693340560719, 0.616416691897071, -1.194725884765882, 0.000666524580319461, -0.5353340152021143, 0.6169547206242043, 0.10078093331230287, -0.5796113618599295, -1.0425234146251519, -0.8377042844443718, 0.689818929181287, 0.5594379259338776, 0.005434838687749609, 0.17077715855585676, -1.1268171904920414, 0.04485343968739731, -0.27371553004596794, -0.4397805062901089},
    {-0.6717303734309539, 0.6657007979474548, -0.045534121191739926, 1.3496448800050767, -0.746221200845158, 0.02830108910643258, -0.901527494397225, 0.5386601867512972, -0.9362228725270832, 0.3877982488856975, 1.0714209543761843, -0.6746325835721707, 0.5811084978448686, 0.7458271524970779, -0.4389998972341927, 0.692833848812859, -1.2024797183239362, -0.30503920832757664, 0.931772817941948, -0.9637522624142261, -0.8288855127504837, -0.6877136338703023, 0.994412686790998, -0.1554850965719195, 0.02868774286270392, -0.1376495977042161, -0.5190571989854453, 1.5135111013300921, 0.4529418231909888, 0.4685803741888146, -0.42538619886302204, 0.8210485748031717, -0.4558832253016275, 1.0358723033500115, -0.8328230748897576, 0.9043590477355696, -0.5423793343246912, 0.3966841995421656, -0.9144258724137543, 0.5701788898891099, 0.5569058167457281, -0.5874499064090074, 1.0108722711921756, 0.13099989895438977, 0.2288056340786997, -0.9054348906904252, -1.363909800767744, -0.011789345972716997, -0.5238657536510936, -1.1411494319628408, -1.2689632638897477, -0.5989902466763424, 0.46872077438905, -0.7451001639510245, 1.0129509647145964, -0.026002298396418943, -0.261705593991318, 0.5444516469299553, 0.28419718447848236, -0.927459178125382, 0.6245285998732255, -0.1577325719730374, 0.2836476356720049, -1.1354500974742903},
    {-0.9862944857449831, -0.8875373589152358, 0.43214134960040596, 0.0026577388374286193, -0.16174739207073768, 0.7682279147920307, 0.7428718491118768, 0.2788242122413076, -0.28600607129293626, -0.6010738313173345, 1.2520170582700267, -0.025910468501070785, -0.3494809060476786, 0.7497944184393812, -0.4300476783667247, -0.6435222082222061, -1.0775956632648704, 0.16963860403016506, -0.7473221675054001, 0.5812122621315492, 0.3646153673997308, 0.9745909877869895, -0.8932916257963628, 1.2460473627516047, -0.36317976805657737, -1.3738901931405683, 0.4183739635937766, 0.9101821450012323, 0.2334128361018116, -0.060206154566731465, 0.07093386038777227, -0.2628316151042819, -0.14734042232854153, 0.3983613068706298, -1.4053379257763232, -0.3921827636739637, -0.8208529749154088, 1.0179087467464822, -0.05384994510637946, 0.37853166352655837, -0.029348950896827097, 0.9000403794729495, 0.2997412070576048, 0.10764955302668937, 0.40699041752794857, 0.5256429849801658, 0.4575976054100891, 0.2446271019393034, 0.36344905504614633, -0.5466455562782563, -0.876816033045228, 0.18465893632030933, 0.28124924409958857, -0.3963764972470651, 1.089895184277404, 0.4843755423289796, -0.5015113944307446, -1.1627654113448977, -0.17960424024534075, 1.1823838399988895, 0.5260871625805754, -0.6273160358560758, 0.031183194959240643, -0.2793009917311828},
    {-1.0536645481569933, -0.902571770268748, -0.18867907658565405, -0.5576681024789115, -0.40053190796976507, -0.6771109174536477, -1.1685327344172494, 0.9951367659009915, -0.07101310337846846, 1.1059421094169253, -0.6798205348025552, 1.1418653560406644, 0.4490378857489851, 1.086511737680742, 0.489947706525501, -0.7377821097021593, -1.2120156888578357, -1.1315020280386288, 0.08306146349043046, -0.6513321338302677, -0.9298809042553811, 1.4681361399921489, -0.268022411468542, 0.9810176926876232, 0.16264413935909455, -0.6246576067869161, -0.9105405517747166, -0.4625652304034243, 0.6113828173860695, -1.1515438608411641, -0.9681289723889469, 0.08342323738566898, 0.07662967900155807, 0.5988735450992566, -1.5189497294445107, -0.02951191360940242, 0.7824404473442252, 0.5235001721275717, 0.7106917593323482, 1.0282121374015847, -0.9225845499624358, 0.649860883983778, 1.2072322769484045, 0.8795287456830856, 0.24050848673426278, 0.39562831540348925, 0.3522128255252899, -1.0914241789314927, 0.997869250560775, 0.06856468304249257, -1.1218356519585184, 0.1191098454233965, -0.36167005208413505, -0.29070006358370315, -0.7196715184801475, 1.0142136772348394, -0.5270249983155161, -0.209184030601876, -0.5371650827445726, 1.1662936143383233, 0.3500199240973372, -1.406663990010545, 0.5173359375091872, 0.06115655364425681},
    {0.414457824996372, -1.3895346618617925, -0.5555117458698458, 1.1427734577110995, 0.3454555945002363, 1.2343435687647961, 0.3775301043980369, 0.9480699918998468, 0.7067356631182797, -0.48219897600438694, 0.4060806334457712, 1.0125499818403942, -0.6531072165888754, 0.9441930754494287, -0.6198841175592809, 0.8903261339647138, -0.003025350427040515, 0.19785217258404653, 1.0295756950069777, -1.0880618103793331, -0.4758138209640602, 0.32906673106491635, -0.8483358056729009, -0.2006819700624812, 1.1003791209434186, -1.0376655325034425, 0.3899180144789877, 0.27789110130061884, 0.8273480970557089, 0.7035786946509236, 0.4237363250846869, -0.09245532538105677, 0.5024709990499368, 0.4780130167489546, -0.4833264997951042, -0.4504518464898219, 0.5663779891760753, -0.3678363063261749, 0.46931063803112016, 0.6459654214907059, -0.9409283903948003, 0.029673371759121117, 0.7610441692534917, -0.36169997177118823, 0.9224498855803476, 0.5259356122278374, -0.6954250486274579, -0.10312426107503282, 0.8866869489394371, -1.0438292954025286, 0.15414860459793275, -0.16057043613114125, -0.42606430513154697, 0.3903280779203066, 0.10755102043215627, -0.46723531709716615, -1.0544906830408034, -0.3668245302008884, -0.0548045515949062, 0.4832759873939826, 0.7164548952951701, -1.67339277290361, 0.22085794052651486, -0.17766707865848663},
    {-0.9724515684091778, 0.4701062146747518, -0.3992377787239823, 0.5658943501250391, 0.02110223920554601, -0.5209965484954784, -0.3575435855549289, -0.26908565683099767, 0.9603937917615174, 0.5845205484973464, 1.3116788253564349, 0.9951995914631904, -0.8623576606100989, 0.9778637657777954, -0.8280739391595173, 0.4389675899227009, 0.7554754787549139, -1.4559328337578137, 0.8200771512099202, 0.9123449060715135, 0.03213331000086581, 1.2463430766755257, 0.06854271726168874, 0.19998693134108894, -0.06100102452165699, -1.5312415169850937, -0.979841639964874, 0.7391048530078855, 0.9328631027642448, -1.2365098702616062, -1.2340073884695337, 1.02934130765889, 1.0330807084905602, 0.193700375110487, -1.2691266211509817, -0.38217916516722916, -0.23425049811143442, -0.22758446882081163, -1.0248049052779538, -0.012012194954496423, 0.55553858010674, 0.6523043967275581, 0.18695821934154014, 0.12904759582613176, -0.374179679021945, 0.8755434003195507, 0.1947537055035697, 0.279972793139548, -0.12494025728128699, -0.6514531755746144, -0.5631485111466861, 0.8330811544948967, -0.6589498211691026, -0.3464818931607807, -0.6832493641055107, 0.8091466189532868, 0.8358008259648132, -0.12368414084218315, -0.66879258635903, -0.07631913275471428, 0.7598537249045832, -0.9485885198079232, 1.277676758568631, -0.3619253190218399},
    {-1.0262509315878017, -0.8257616504861909, -0.26205150431497515, 0.20043193261570288, 0.3431423072639591, 0.7575544287707243, 0.803367606476713, 0.6564566493605182, 0.06261216887125731, -0.3676772373124757, 0.7715588460847441, 0.7292826524087159, 0.5793037328693459, 0.3585671616697577, -0.23465864837418762, 0.9178600038286587, 0.4616137805085013, -1.1125247074642466, -1.0867840863723792, 0.6086449968297066, -1.061277731493399, 0.5282391740249359, 1.1163580711397632, 0.5064068230853862, 0.33148092290876485, -0.8146202410781445, -0.948096477592816, -0.3379030496267859, 0.8619337163121478, -1.2877828026965261, -0.9474862619686497, 0.4992247484284741, 0.6622402588584849, -1.0962840061813364, 0.055996746054031495, -0.1928074980875383, 0.843325002831311, 1.0751311789165825, 0.6023965384740171, 0.480806105276387, -0.24348970391202127, -0.6757216521067152, 0.7423386781701019, 0.7913861421545624, 0.4044548218862047, 1.0254718672724028, 0.28133837218944857, -0.7688166204593885, 1.3483440484213642, -0.3488880037939315, 0.1771507589819161, -0.7124853987335829, 1.152773550793697, 0.8158977516653103, 0.383258074825138, -0.025245061495252314, -0.29462318446550023, -0.21260004875650143, -0.39251139764219256, 0.4597955560011472, -0.21302383795759966, 0.05421547416264313, 0.04778875290491678, -0.294300483689782},
    {-0.0355120518407757, -0.4748293103373459, 0.25474338796046153, 1.105508945350515, -0.9205339400387528, 0.4242978409031555, 0.1699547522737722, -0.4177476945609289, 0.6707713509577459, 1.2999548413136757, -0.5359860493992841, 1.3059642316242173, -0.7290111101776976, 0.38921677821996564, 1.031619437245319, -0.7131743749125082, -0.1405998513945625, -0.1276348498140759, -0.4014348069961068, -0.5837503516964058, 0.4312545975679669, 1.2411094517800452, 0.42971951776591505, -0.020320923657170628, 0.007335454196395836, -1.6342596059148757, 0.6527830698676468, 1.0989678221334802, 0.5876224633857071, -1.162869655923058, -1.2098051078229008, -0.5566332537650421, 0.9646705956503239, -1.086100607543419, -0.15826581003395743, -1.1241116309476302, 0.4160982630414222, 0.4686199871330157, 0.03336194917143364, -0.2251223861938598, -0.9312282504044809, 0.23497180920294633, -0.9997962196178012, 0.4938484167461796, -0.023785342763489644, 0.4079325870100932, -0.32629997517121956, -0.8860388349899498, 1.2535604613661748, -1.5326553424970604, -0.12386992247928451, 0.09550385474926922, 1.3579873726213425, -0.7767226992807372, 1.0682381063448965, -0.852216400452459, -0.5468517597061604, 0.6061474259992713, 0.9611833286851745, -0.7569087868859131, -0.9617677108185839, 0.03655623532911028, 0.1194858685096134, 0.3847134815008123},
    {-0.36437645536407615, -0.6269652549735657, -0.980941797827066, -0.7056682741045457, -0.7990762126134741, -0.7949043824102899, -0.1087075252361426, 0.413198159901989, -0.4358941536762115, 1.0940981356837083, -0.8283474910941472, -0.15802166626413797, 1.1517994181823497, 0.6605399353080443, -0.6332383572172634, 0.47490877051973535, -0.6436179954200377, -0.6284914072140285, 0.6944971182000269, 0.35290477706242535, 0.7329523804521081, 0.8820071767800833, 0.8878285851912531, -0.7672870833802876, -0.7867149267208848, -1.3328465639764517, -0.9267687233115328, 0.26493357552960284, 0.7780298297663129, -0.2470690458447231, -1.1789283954663208, -1.0119612669696936, -1.0316812337409222, 0.21569101782874567, -0.7653609309572301, 0.13896027047395554, -0.0047087990656193264, 1.249484977740222, -0.7852574260230433, 0.7882136369910555, 0.5332129956960633, -0.19590808104393342, 0.29257874398561656, -0.3436161628632568, 1.0598421234699167, 0.46890278666058804, -0.6694951560382618, 0.353990404907082, -0.5495244150872629, -1.4053124516128273, -0.18674954444751848, 0.21230532713610872, 0.8553799437153818, -0.48505773532332314, 0.8128312468089692, 0.9528428422335476, 0.4368457729806823, -1.0782971974521112, 1.035995352176465, -0.8419567725175153, -0.27060907988010013, -0.2933922215678951, -0.5613133308136821, -0.9761208102075605},
    {0.4303320039600782, -0.2777546095855965, 0.9168185151770392, -0.08326113628700171, 0.23451509376714758, -0.625796839444726, 0.17105286697317898, 0.6406270071675426, 0.6639335901819301, 0.46651594258447626, 1.0283977362776577, -0.060976034165541544, -0.21252841509625645, 1.2508577712572566, 0.6250668436360359, -0.5849805810600862, -0.8350584167469386, -1.5897034137622443, -0.3748588132817305, -0.54873775804603, -0.6361919817097694, 0.7441492457331125, 1.1509876091853555, 0.1386308634301921, 0.7729346641431525, -1.0090040592036538, -0.16114015537460993, -0.16787708033333687, 0.9113455331576946, 0.28309486059808936, -0.4203573954864256, 0.21431177702271637, 0.31434915633268, 0.01603610257954964, -0.9412929271003454, -1.1295249745337363, 0.09984033929809383, 1.6766533406663173, -0.07550069215647781, -0.7017180859865912, -0.10890152462908544, -0.7484713917867418, 0.3835643236568177, -1.1311977547139724, 0.7601271133497796, 0.6588302571154148, -0.9702533616760309, -0.6810707269975592, 0.8133000945680889, 0.3464297691042058, -0.06435420517124545, -0.15423655107104378, -0.12146464515424626, -0.0452971162108924, 0.6201089895634424, 0.4867321814397222, 0.1310015640928917, -0.7445711314896383, -0.1435018520972528, 0.5567055111648923, -0.9175450872510564, -1.6665350306626947, 1.3424820151334314, -0.143593046975481},
    {0.07693253960402249, -0.5956375511982304, -0.29908866351386076, 0.6533979225320344, -1.4009935806267093, 1.392354437616329, -0.18845611823334732, 0.9418953608090904, -1.1852980336618506, 0.5447184536278471, 0.5514997018804538, 0.519516863115785, 1.206185370328452, 1.2626941539144014, 0.5708803402269201, -0.5444858890591029, -0.5868965408177795, -1.473447419070384, 1.0981341612798505, -0.9397827850635551, -0.7806461301696914, -0.21547310177175116, 1.0136447943472957, 1.1997019553671548, 1.1863710391603062, -0.11501039166887903, -0.7847781793739356, 1.254397438035028, 1.218358597321223, 0.8279521803212677, 0.6971942948644624, 0.6754802608743207, 0.4953750959064826, -0.7410003362419676, -0.15915267863596985, 0.852273222892552, 0.7504145733928075, 1.3536832816448976, -0.538507430743723, -0.674852538657926, -0.9127189350238536, 0.05000852698366071, -0.4179116262130882, -0.36537172235966847, 1.225788848501414, -0.2533851860977751, -0.5437606293765689, -0.5542196557388268, 1.23300352249443, -0.5971047873865345, -0.376448070642655, 0.17300063657733222, 0.7759313558792258, -0.41583670174963666, 1.0066168454605633, 0.40903119195167725, -0.7342861730216192, -0.5781218453584985, 0.8847256802147997, -0.31633400905985937, -0.36228250977994625, -0.9919596497368676, 0.7382109522027717, -0.5401443040138535},
    {-0.8194075376816345, -0.8299925845330067, -0.5389233084378637, -0.4324739091573182, -1.3493601195904916, 0.24856976612353543, 0.22498894366193958, 0.7447159900362597, -0.7112361170389396, 0.688098076487604, -0.22505823328219993, -0.5312524007053335, -0.2565701875604388, 0.8359104761944333, 0.01636684130671753, 0.5479065384194451, 0.5826719818567397, -0.6008657880841467, -0.7715715420479655, 0.05539082559738037, -0.8459613375826321, 0.12140988624137666, 0.9201162053929166, 0.926697547889347, 0.3874355595688549, -0.916733821312037, 0.4570112181294323, 1.4146729758779975, 0.9515692683304616, -0.5612056130474471, 0.04319471966719417, -0.044623425623924504, -0.18296159144315402, -0.029660935840100548, -0.6390571163776789, -0.26387109716141316, 0.8781967171362841, 0.840041789061994, 0.5312114166909471, -0.16314072047354244, 0.6975337385211059, -0.02198491447282866, -0.8805878453102839, 0.5426802007181695, 0.5431050611339158, -0.7537986043592484, -0.3981914580744296, -0.430127576303253, 1.1677302693764247, -1.0996145237981019, 0.4480015456490369, -0.23453129570966533, -0.7718159790386816, 0.47308722517010354, 1.251422897823693, -0.8207648645845831, -0.3770106853684941, 0.8709152640403637, 1.4068396724611836, 0.9172526205696074, -0.46243185915883317, -1.373221946699173, 0.5554599902141047, -0.09823915729411067},
    {0.43098280722378673, -0.6365066399637184, -0.7623656070894682, 0.9968530523709173, -0.6494321473748759, -0.3688641293422754, 0.40041353402861407, -0.2701622290692114, -0.9796826049565561, 0.8771512640935696, 0.6182785920849041, -0.10304063018422818, 1.0447730893781761, -0.27967740413356534, -0.5764700130964936, 0.8425517195677107, -1.4258183131819908, -1.3960473720841464, -0.4705044118353242, 0.6300534342987896, 0.9608326669596183, 1.1852376909937126, 0.8187908886246177, 1.4771912296289709, 0.4930204039760335, 0.4001276438933432, -0.15823758607244232, -0.01595083467240263, -0.2691619725493419, -0.7285942105425014, -0.3507710756867736, 0.7387527168897634, 0.884937781827938, -0.9109455677052426, -1.0422428819895302, 0.2941676575979346, 0.8682436377707283, 1.3297475163377543, -0.4347793192759296, -0.21073508628573376, -0.03387704018148681, 0.0502498866249087, 1.1100465738684735, 0.27852089622716114, 0.7912465730749255, -0.7907469087657735, 0.7842303101290357, -1.3766526287070375, -0.43159674168284823, -0.5061217907983843, -1.3331489047428715, -0.4768221748713945, -0.6700759186107855, -0.7901309711448672, -0.49765403045152135, -0.763525135154165, 0.10785074429574389, -0.5754366275461751, 1.4107237243309596, 0.55390282493637, 0.07689622094009144, -0.1470089252228886, -0.4471644776345768, -0.4314645349034163},
    {-0.5891948995327916, -0.6333783046051119, 0.12295785643015515, -0.39209494696778885, 0.5632690360486848, -0.20785573004890492, -0.8852513232861947, 0.12610474927945522, -1.181138075712401, 1.0307246989421122, -1.0364525766469397, 0.9017745290161606, 0.22443151053416402, -0.8706848433326444, 0.9091158251402943, 0.45256266464994943, -1.5345227681320945, -1.429364176461912, 0.033597706003798175, -0.906156565918542, 0.08761908595533145, 0.4677537143834292, 0.6951832384474537, 0.9502731642017915, 0.3065285088560442, -0.8774988636697201, 0.7311590684115621, 1.3687197707519627, 0.9982486905131209, -0.5397194628324488, -1.0488335075561568, -0.8434655259386102, -0.19111981892655788, -1.1099898470270573, 0.6919277666900109, 0.8822657426106775, 1.043225897907555, 0.9080896209188521, -1.0092214331891551, 1.2045929528239416, -1.2384080761503675, 0.30180505696626214, -0.23871432713823407, -0.894284795416379, -0.12852944513640505, 0.3361940617771409, 0.1670625240085464, -0.16112593687268878, -0.28432360043597654, -0.9638628357048493, -0.8599214323078798, -0.19041456092932435, 1.0532759774855371, -0.25205385869535585, -0.26254497320909637, 1.031176892730551, -0.20647127176074292, -0.6445265402319169, 1.0724638581772798, -0.08102759627722776, -0.9191877788968977, -1.5650632557450148, 1.1223350634244813, 0.48428250264972217},
    {-0.5974251146837207, -0.5693017348868161, 0.7471005491036438, 1.2825760080934283, -1.381479652304973, -0.3486654247033137, -0.688454490921414, 0.9861156443717971, -1.3795263962147355, 0.773163941758155, -0.37035954873220917, 0.7208765126267688, 0.9552047427191129, 0.8586086122911372, 0.4059144077044096, -0.4225518655249272, 0.4163381402675651, -1.4785146042263102, 0.9279305395844702, 0.19352130191701203, 0.7087085632329654, 1.2801548143320327, 0.8186748384029395, 0.28532082150488597, 0.7461957995119194, -1.600318016653342, 0.3177085189456335, 0.8536890165319877, 1.223557989289265, 0.21533434419052794, -0.9129118389584154, -0.17651850388660006, 0.715694035244607, -0.2535144319389651, 0.5835002165216657, -0.8394933302371964, 1.0697660475816229, 1.8428957757684854, 0.05851230836672547, 0.7359354098597837, 0.5863561022738296, 0.5305528743902318, 0.980413587294111, -1.0116921982290927, 0.6729943157752151, 0.9606576374849719, -0.21220794464305232, -1.1589849476124405, 0.9577445154839974, 0.38511597258456587, -1.5740212150063773, -0.16637536831834784, -0.6823402202151995, 0.2450494210104205, 0.17741917203913618, 0.1309946113890201, 0.27198913317244877, -0.24034737500763834, -0.43853763374653437, 0.32732270073157327, -0.6466814166728508, -0.968359475829667, 0.8410975056758417, 0.4042117027751332},
    {-1.1346222737187115, -0.7851246042792196, 0.7224901638899471, 0.31084851858991264, 0.4227422948315578, 0.9892106748031173, -0.12895428734847397, 0.6101717938267474, -0.25716961098180424, 1.1092930461056567, 0.6817283126136379, 0.5839379248875715, 1.025643006752207, 0.935741867879019, -0.38673869000487904, -0.115433642131227, 0.024811061526321586, -1.4019417041207294, -0.7096380619172846, -0.33831957207008845, 0.7283319715960509, 1.182286036319787, -0.826408278656584, 0.8876818449236481, -0.629124533143915, -1.0372480418090844, 0.7029212456715929, 1.5024753237793627, -0.18205478580404602, -0.9400117922366683, 0.5915172389210861, 0.6279575820953526, -0.8139202585742883, -0.559360656894882, -1.3822986604634848, 0.3153890142823201, 0.26996714389287363, -0.14999416025333506, 0.0226360934173416, -0.6587614255236741, -1.0399199646868678, 0.9434953537315162, -0.014617009711611303, -0.7610344791587349, -0.644904907309479, -0.9288702550689438, -1.0606674018984854, 0.006131966330193288, 0.7060067843440309, -0.3727935346400979, -0.11352452890101623, 0.7784797450274453, 0.447925563578203, -0.8187065440532856, -0.27708587317498007, -0.30226501426752017, -0.12435489449881754, -0.07651499507456053, -0.254587707682214, 0.0843008553579653, 0.216998973685787, -1.0959946907502294, 1.0789460366987687, 0.5536998966626913},
    {-1.2883626194329358, -1.1304094875592847, 0.7152736726717291, 0.7578650442215524, 0.66734282173312, -0.26686835513628593, -0.26372428776075013, 0.48222944657010275, -0.07672675056906851, -0.4003254777361254, 0.3229364749634167, -0.15122822533079203, 0.07436649623527228, 0.47797304084038067, 0.9877003015102471, 0.46915688267870764, -0.5693057116008642, -1.6026625526691802, 1.0304367224233029, -1.2244680991049415, -0.8559490359487452, 1.4340447207173916, -0.08732245971282301, 0.7072433268155581, -0.014282174088646106, -0.25946390113887396, -0.3102376821822724, 1.4077952840098729, 1.4577566208966537, -1.1340889268134096, -0.3766975347061825, -0.6471224092587361, -0.270155697624791, 0.7580116458802113, 0.2185317023631697, -1.1631779883706914, 0.6842792709984117, -0.5003996950146464, -1.2728164856182997, 0.658020992547501, 0.23883790303932825, -0.06818606459748905, -0.003624409288332786, 0.358272961712959, -0.04630909081045315, 0.8864689313937535, -0.44371669673475467, 0.3603354740133948, 0.17744661234371462, -1.064862724707626, 0.20849117690978639, -0.23639413288521788, 1.2219868334737467, -0.6501465371398661, 0.779272405752346, -0.8410603272113231, -0.014249517770942332, -0.18547983724525072, 0.08770662390020349, 1.2189853425411967, -1.3795570777888113, 0.45086288551288584, 0.20129963092257744, -0.06302815641240546},
    {0.3443556341862336, -1.0881832129384628, 0.5180906465430768, 1.3071070121482502, -1.0033722241330072, 0.25368026430647933, -1.027553437338914, 0.7649225992750918, -0.5051922918754062, 1.4055509373042585, -0.49350085182346975, -0.515965320080364, 0.14715241231131293, 1.0056094820822317, 0.9702127603947078, -0.32216700862577635, 0.2445821358978943, 0.07572794256917179, -0.250358190653033, -0.6861504707407301, 0.38939034653591686, 1.0864976605362437, -0.24766203142933746, 0.5734801542312944, -0.3204879885174481, 0.46483402043680094, -0.5697181539886417, -0.2706699069949267, 0.3431218397428139, -0.6556377682892003, -1.348551789246998, -0.689244298802876, -0.18882614587927207, -0.2249401382986723, -1.3518920460244335, -0.6364989081684638, 1.4802554936349823, 1.3931994193732018, 0.5219664954665172, -0.23289756018577595, -0.8776071019018588, -0.20545163882806805, -0.021696617738867007, 0.5585011212909445, 0.09530563217690502, 0.2554949556419699, -0.8591755435629495, -1.2845547681560436, 0.01562535497719417, -1.0654474129974116, -0.23432426927389338, -0.39400095673369123, 1.302939549138553, -0.32965661872919266, -0.09904603036349328, 0.7329199033925423, -0.6651790145394507, -0.18146765060610118, 1.5400429371865325, 0.6990074220929577, -1.3333732529896667, -0.012315893202145118, 1.2853647039300593, 0.4165063212855487},
    {-0.34026709397157273, -1.2080357855177937, -0.38672334104580824, 1.1192030719172354, -0.9017055183322914, 1.2171155184543847, -1.004352533106093, 0.7962427496150155, -0.8671749254075217, 1.0892870833158714, 0.2358757429726192, -0.5581453974275615, 1.0499113290646047, 0.4249038960971167, 0.5261837649218976, 0.8180660706402987, -0.40985470449496647, 0.42443501672281797, 1.176375282582279, -0.4201664113019773, 0.3718197825044385, 0.8452707980004794, 0.9682789797354732, -0.05802258350004367, 0.9980580797515339, -0.494615776518854, -0.8372962070863484, 0.7784122999090801, 0.8323089414280573, -0.888789583405168, -1.4203479366266603, -0.4280229869059909, -0.8709686256217033, 1.0980150251228777, 0.47568975712339057, -1.091395751130543, -0.12141165286102855, 0.9530299775912715, -1.079955221234713, 1.1564684629458648, -1.357961036823364, -0.26688005675576176, 0.10258360018411128, -0.4987117671778038, -0.32803271465361206, -0.9594381324728569, -0.7682383824399912, -0.5460476368729597, -0.3406867856348947, 0.47252710012714677, -1.1898634096188585, 1.0443447608366037, -0.5330310281156205, 0.5283575429328226, 0.8284545270640312, 0.8953347746152782, 0.2139084791184917, -0.380981448639949, 0.7275108290142077, -0.05167680435984256, -0.8081686366235938, -0.6168855969658986, 0.7930563641418606, -0.07030003222207791},
    {0.5034672640268228, -0.343165607297057, 0.8108427770199266, 0.14464077659347638, 0.23871427442829454, -0.2726297876089377, 0.6105338435350948, -0.02347704626725505, -1.2328553791155388, 1.1934745322342293, 1.0161661347645126, 0.1596947937673999, 0.616478090693712, -0.06897853693878968, 0.4945828576595085, -0.3942988340929098, 0.4191169968157484, 0.18084690395076036, 1.0247699024406127, -0.21945938975197793, -0.12931379189962414, 0.2537219998700896, -0.5963387881064531, 0.8577051928615135, -0.568400410667219, -0.8487836301403775, 0.8923880789926827, -0.015842649901698053, 1.4617394539549409, -0.05397886891243065, -0.7566909795158034, 0.4663495209817815, 0.920532432055541, 0.5358724915480054, -0.4992898314387022, -0.08321387489953194, -0.315791856583706, 0.38713534589196064, -1.3462332018701066, -0.7402334433718402, -0.36271097834040494, 0.2328609027003595, 0.7843267997058175, 0.39567330979458465, -0.16056010121669242, 0.2514801637228262, -0.47430919553675377, -0.3757055667771477, 0.26680041250286735, -1.100799651236166, -0.3105020816876146, 0.25669445350007153, 0.12579950355659758, -0.27213975162399007, -0.9346280340868697, 0.5775979884120315, 0.7331754881584067, -0.8034084845133068, 0.7751651308567398, 0.4793456291540005, -0.8229348967703566, -0.7992683941437398, 0.38407305472077413, -0.7764908119958713},
    {-0.5558452884136575, -0.03153479529107031, -0.8230469033726124, 0.10572716171756909, -1.3815821632168128, 0.21702887616694608, 0.19316489826050692, 1.0284943094814016, -0.0832588485829278, 0.5992735801793327, 0.10327234457583091, -0.7986285289319426, 0.8875333901020768, -0.6261520706518523, 0.8412672807070601, 0.8937975354560889, -0.48304691707126457, -0.5921240949661339, -0.19199430851667385, -0.8074820562317754, -0.41431185941184817, 1.4935202573096578, -0.7940888005465834, -0.044879846634640466, -0.49799430038185616, -0.24297231523710924, 0.19483004453544636, 0.6126665224009039, 0.9327452938059523, 0.024393716994500117, -0.8994529552573948, -0.9689309107267596, -0.7354979161452138, -0.6707014517925558, -0.2840717946314727, 0.6613693251048659, 1.0519307390645356, -0.08492987522880505, -1.445276788731914, 0.6732349193051637, -1.0618911016026318, -0.7861044119061744, 0.6644325186891237, -0.297217007932168, -0.5250144737378206, 0.32484675077446634, -1.1683650403428587, -1.1149066462728443, 1.352192814188473, -1.3770151717743027, -1.363017362204865, 0.28903194125443443, -0.03637471936945948, 1.0831454609205553, -0.381557169901281, 0.3632855116036846, -1.2084885060331871, 0.6971919605304615, -0.5753636977494255, -0.34184191149037907, 0.6072691010728051, -0.8370568975143415, 0.5889868792438526, 0.6092496270226155},
    {-0.21282535011975082, 0.7411000903809446, 0.015216345902264294, -0.29159902383780273, -0.6198804973749111, 0.7429806517847242, -1.0454669018843052, 0.9622670754386804, 0.32452876417172516, 0.58500945795248, -0.458909924568306, 0.6265224923674115, 0.8570164167537411, -0.5925866115692077, 0.28884122838127385, 0.3733700534472318, -0.12871864163965002, -1.3523679436065508, 1.0146649488682264, 0.4987336518745195, -1.1166412866998432, -0.26385604283079495, -0.12193655351729377, -0.2356266500569964, 0.041811346020920744, 0.26479491759450896, 0.35273593149716, 1.3254008302433342, 0.8346117296747688, 0.1578947861201032, -0.9951139461481754, -1.1971925478848278, -0.905631616684877, 0.8899088797108476, -0.5003194197428715, -0.8594261331689482, 1.478421659477546, 0.5428693436639402, 0.18437418250775967, 1.2392555989158105, 0.25469736061974446, -0.23703645515481753, -0.543979041929551, 0.7358982953763447, -0.024979530466772766, -0.0810313169277092, 0.23718063467788475, 0.20108679898563225, 0.779592208906486, -0.3449866431144153, -0.49343040919046477, 0.8791902620542223, 0.7601182042670862, 0.6523986887295993, -0.8267947275355975, 0.32389862797656843, -0.8653643995916895, 0.5507554821749159, 1.0499600135830378, 1.2036707915491438, -0.8842246348019948, -0.13246180364995594, 0.3636343159293179, 0.8384314695724083},
    {-0.35244726129036535, -0.10924294032099509, -0.14674053341984417, 0.6850427292342204, 0.5772387543406052, 1.0958243583331586, -0.6061499562508535, 0.8371282902370561, 0.31420737723474984, 1.0267036191289385, -0.41628091698318226, 1.155166746946531, -0.004694533849283091, -0.4965556771808962, -0.47827930444125005, 0.7978555846104158, -0.7941015973872249, -0.4291709793294033, -0.5579561775609666, -0.10835083046272112, 0.5685996706899733, 0.8703156482040428, 1.0757179773489036, 0.46312800939429105, -0.8757354570839105, -1.3732200532990404, 1.2088664233960429, 1.6778489498593205, 1.2951205789918918, -0.8567655822189134, 0.7040869616373215, 0.11410561866590192, -0.08744548615390735, -0.6934357552341134, -1.0346118003218487, 0.24012565240293807, -0.21718303976559672, 1.0014340078778576, -0.6598928294226646, 1.2903041519477543, 0.546806376860315, -0.22188375493531742, 0.09993181803698743, 0.25677817508092254, 0.8657150390241578, -0.15389916869977988, -1.5215909899898632, -0.29709573854621574, -0.04620277232598397, -1.1374798372173833, -1.4729269843055075, 0.3666756081284484, -0.25007392535153067, -0.952385860732385, 0.8369707992621841, -0.5159009993656203, 0.3667256138648218, 0.08915987721674709, -0.2869385992238275, 0.2579913800119308, -1.161114686442576, -1.3111894219380555, 0.20588230679395236, 1.4196529383496792},
    {0.043814747702992964, -1.2946339787602674, 0.8434375906212087, 1.4088111148026872, -0.6680786508732064, -0.40184503150667, -0.6881895307550013, -0.1053607795392329, -0.7860466883686211, 1.4730199978494387, 0.32959961359123024, 0.14172427493210663, -0.5940110625956126, 0.8757297709746841, 0.8318221797036496, 0.4224571682664678, 0.6420930950325714, -1.2740331510859912, 0.7692607720878492, 0.46023446605206514, -0.3043150783964079, 1.1331505754543028, 1.3533451077920537, 0.7950319582370083, -0.2718368165902947, -0.9818600202562378, 0.6708425099365791, 0.9624387813449646, -0.11263896316791569, -0.7385115984254481, 0.6243105754534778, -1.1838726905938481, 0.3022754446185669, -1.2141267283073758, -1.132923479266838, 0.16203139393500807, 1.3246454872728763, 1.5820219534284536, 0.03958429778375932, 0.36462278786710056, -1.417312704968268, 0.9486760613793404, -0.6404650618553321, -0.44147735172623065, -0.8005506260357467, -0.205138904239451, -1.1147998461686506, -0.32155364142145665, 0.01223576132282273, -1.0077439759961537, -1.1679424172370594, 0.9090149760658935, 0.2551126128111065, 1.0657834383008504, -0.3788450340603847, 1.197654854646239, -1.187595940836309, 0.19631842267559857, 1.513118408585815, 0.7734752817002434, 0.5081159104163011, 0.19140735301234796, -0.18055589251622733, 0.19222115962092104},
    {-1.462252777527629, -0.5804200120685165, 0.19876146868988048, 0.8270155230298457, -0.047361756248497894, 1.1860979600445454, -0.23269302078964063, 0.11967616315607023, -0.06297794886351582, -0.21948902563731978, -0.7429474904818412, 0.8536791524991992, 0.733949693731154, 0.3873397414632012, -0.578930139739544, 0.6256759453725727, 0.041828024807629975, -0.8170795240589003, -0.2367946897308351, -0.5500849701199377, 0.05094197663727737, 1.3766608850145305, 0.24325262610145282, -0.5822279371660444, 0.0015461590938546043, -1.6802824563377505, 0.004437588808686073, 0.518836696084817, 0.4117795369564277, -1.2730371635485367, -0.6646802444759813, -1.4245657060776287, 0.5171346432117973, -0.7396934259592745, 0.4749876822778156, 0.49296336339184776, 0.34901010818105505, 1.273494107307891, -0.3124318691474601, 1.1676890958532686, -1.1297694008466335, 0.9089589942844523, 0.4881210294886832, 0.5847169929852601, -0.23860643844142262, -0.6894543845433362, -0.5954067340877226, 0.42518395501852724, 1.1745878175319804, -1.3843158526264603, -0.10280360549112218, 0.5162860848595316, 0.37163261719666685, 0.563642512102368, -0.6779782677292513, -0.02407699502077932, 0.055087638643488014, -1.3354468345361357, 0.5460227773228249, -0.7296315082943693, -0.8689379673164669, -0.6602150458863607, -0.5464463165013225, 0.8752917497329671},
    {-0.6059371022558532, -0.581094191708691, -0.2304789567973971, -0.4641870802429761, -1.0658342813751942, 1.5095151702603595, -0.8312050264923447, 1.0432349185257925, 0.04216280319680386, -0.24825436004764534, -0.25627667511853597, 1.2229603716273327, 1.0767789663593117, -0.7783746902526176, 0.9991759528004459, -0.6324282917900222, -0.521617614801576, -1.3839186623243716, -0.29515135615561805, 0.5125058641648719, -0.18542134380845923, 0.3449097417191873, -0.21915241835372726, 0.13616390091234787, 0.7771416137539726, -1.835487959771238, 1.0400246824361947, 1.5690371770478655, 0.3556306857239561, -1.002346825884088, -1.3217487291964212, 0.6349621657157761, 0.1473764233274673, -0.13133006743443662, 0.36008141831963103, -0.7757837939846595, -0.23174065756669815, 0.7518862502494698, -0.1650005243275848, 0.778441152861636, -1.4678066672506234, -0.4746996614779412, 0.5949739846471944, -0.4216142754522193, -0.03975127358781635, -0.6202898785042482, 0.552070898210257, -0.33209257145729054, 0.4221416872926831, -1.2701151755196982, -0.739897720234833, 1.1668188924354497, -0.23677508729780214, 0.027503497285764015, -0.774435515252482, -0.4905202988286887, -0.20382675503153022, -1.0434583555604227, 1.534318472542695, -0.6857120002256818, -0.26891255784713286, -1.1087292874105674, 1.1739888435219832, 0.9515904504635817},
    {0.42011620015309653, 0.27287568421472336, 0.9663432088013784, 1.2226750615885855, -0.7222778903153828, 1.0630454810999295, -0.42847881638883933, -0.4419745432332284, -1.002644931869566, -0.31127395129565594, -0.03453483879610259, 0.5164522602006516, -0.4726868851159234, 1.0158759220013185, -0.006818056900974356, 0.4512131652108583, -0.7646920465636445, -1.013108359089291, 0.2843754394357228, 0.39056727605820807, -1.0852975912087137, 0.571090578083445, -0.48882400849888724, -0.6773045476991487, -0.35988757359014867, -1.8804900458175275, -0.6545632177053731, 1.0825577278668896, 0.41955286289313404, -0.6024093583260798, -0.6187731034334947, 0.5503413553812131, -0.694393281445879, -0.29787398974234996, -0.5932449556889584, -0.1839468095453268, -0.7963947014111251, 1.4155550139804454, -1.6737303349435289, -0.18669791099974709, -0.5423461691976154, -0.6772070725492411, -0.5122790716210673, 0.7758989326587361, 0.3104125579860369, -0.4287518965892154, -0.824188792872548, -0.5675073364799682, 1.2205007655636566, -1.4636155015190475, -1.2351448184874607, 0.8228751078533778, 0.667023681970163, 0.13821041771548415, 1.0385801290957204, 1.2157941859610382, -0.050222956306623094, -0.6532100387175118, 1.784213832915896, 0.36011128851936913, 0.17655272201420952, -0.7045683073684186, 0.723812116080445, 0.4045484257199736},
    {-0.1498749467301186, -1.1753559715313595, 0.5210734028329425, 0.6085000552764829, -0.4045604796472549, 1.5244294680617998, -0.9811174554813024, 0.9421632700952135, -1.0007418329088598, 0.9301554185930493, 0.9906722467340298, -0.6989847018358387, 0.1527329023397976, 0.5865691443444675, 0.5809804722666794, 0.20777048586151356, -1.1920544689880166, -1.685311564511678, -0.1296707822054794, 0.18483533758298282, -1.0051621856146984, 0.5143694921760061, 0.9359616576260098, -0.40445406134154865, 0.5710936059037913, -1.8655043045477562, 0.8966958771858684, 0.5091783134933783, -0.32248445347045335, 0.51812771812326, -0.4388085177896807, 0.059839828409157456, -0.3447179474133592, 0.3473273341902673, 0.6027287491110304, -0.4056210864543474, 0.4701808489067359, 0.996039516005122, -1.2808285844889755, 0.3582317849822901, -0.27140790165869505, 0.15752071896993913, -0.8040937506604778, -0.7977089791930231, 0.35645166691986196, -0.3156020560794511, -0.26210838293545125, -0.08105699565391851, 0.8212585768268166, -1.5352223650589705, -0.5879797849286592, -0.4342958816549762, -0.6120724705132298, -0.7097377797799957, 0.7441585874416695, -0.2301874715743133, 0.6106319703683374, -0.5256241268995826, 1.6502318125387714, -0.20781261933157869, -0.5945341913498338, 0.04713683939695528, -0.20393897546629633, 0.5122199453614745},
    {-1.4424585138894856, -0.17002035430932091, -0.5421151060894969, 0.27303102980723093, -1.0716964962032995, 0.20249912327686415, -0.5352143796479965, 0.7881253788851418, -0.149770800109705, 0.6646938102006285, -1.0861130377069361, 0.9338923131847656, 0.23128353433838936, 0.3581710323652624, 1.18194989219477, -0.5390687777278449, -0.3823705128971183, -1.1668619917238157, -0.20655044774311812, -0.5884357207741134, 0.8310479380701685, 0.5409159201546799, 0.44762781723580003, -0.3996544646077834, -0.778384910669479, -0.23408850706659354, 0.8525066350223813, -0.41276475990171824, 1.552818727294489, 0.06715641206425765, -1.082030622530729, -1.4494676409445875, -0.3589882571582246, -0.6897834698389039, -0.10335975037117794, -0.16581101517375102, -0.554035464352998, 1.2968729465380444, -0.4766923771648282, 1.427978973394649, -0.8966063622974447, -0.7419048729095644, 1.004593263605685, -0.45712887792281626, 1.060669935883323, -0.8347540075634924, -0.22147605513113672, 0.11217392335171723, 0.6044630003175141, -0.477137136276556, -0.5068212423082911, 0.27360273172253785, -0.435286535245378, -0.24151417011694398, 0.5486514572133846, -0.8467652978636622, -0.016755689419155263, 0.4984065749123615, 0.7574588933370743, 1.0876251128467977, 0.24957796257756873, -0.8186761292052325, -0.4354203082995267, 0.24044835608565657},
    {-1.1476555974529463, 0.3734787001015555, -1.0745468273335441, 1.0075812043512267, 0.1525304586642145, 0.49873321914705976, -0.4936991241977023, -0.08724653391978326, 0.17279571184734974, 0.9265945305703513, -0.2472988346582226, 0.9082875383407191, 1.2973478791011768, -0.25879650614724825, -0.05632276071006544, 0.49215225665467516, -1.4496158328809625, -1.8407971510778531, 0.8996052277986512, 0.16254137625442072, -0.3561043008904488, 0.9151744011636322, -0.2779388912181779, 1.0034162849883344, 0.7706951682210302, -1.0619638331805852, 0.4107568197141309, 1.1146485602694214, 1.062335276939227, -1.4954120670423778, -0.5915673699312135, -0.645905159260273, -0.12293082889315113, 0.7607993445752613, 0.03481083997698574, -0.8042443056203517, 0.8082221627030712, 1.800421820402133, -1.137730404428396, 0.3064696994903124, -0.21073370396154484, 0.9001974159945783, 0.6687193365210172, 0.8519771392072755, 0.6086289010472924, 0.2105979930460646, -1.3975712086509327, 0.36487816141756724, -0.7079152030660837, 0.26641348541021925, 0.215952521697741, 0.1246363147876663, 1.0400407892449905, -0.47108016225616417, 0.7114300798069542, 0.49178246028929834, -1.2920046352312589, 0.25944192964476825, 1.5548929577884751, -0.3364774551335168, -0.532478203274196, -1.6534451445683098, 0.6033978282499585, -0.2412580721399727},
    {-1.237562169813256, 0.4458091892623556, -0.5255776159037366, 0.617734264257697, -0.20099101474253397, 0.9849616085143089, -1.5329981167141624, -0.5559570847554429, 0.761898941660409, 0.015052682751570708, -0.5211620221882811, 0.36036850773524537, -0.6855116059697783, 0.7718859594941759, 0.5651824401214826, -0.07227669222509336, -0.8730347167852005, -1.262417435978999, -0.6921984463234363, 0.8236948319246254, -0.22384202145570073, 0.16051745451855332, 1.2051602438389444, -0.8124115362936571, 0.46177133084570665, -0.40426325821879816, 0.7809547928349232, 0.9361615249778772, 1.034093461275537, -0.5059367282121332, -0.07652078982835644, -0.8970087569406971, -0.8371331244082133, -0.7094082013405677, -1.206403030243618, -0.77662069155335, 1.4786408419282902, 0.4783008037106127, -0.9805355998702334, 1.2973261353284251, 0.5199411024904066, -0.20654639372096342, 0.019835873251446944, 0.5016141273863537, -0.7633506216330478, -0.8450176969655397, -1.104936215101521, -0.869480944663317, 0.8595739704054733, -1.3042568690732366, -1.2139610054666505, 1.1165922833157274, -0.5835436878136465, 0.9112167127755112, 0.1006826279829387, -0.037183901865257225, -1.0441518007455737, 0.667161380580828, 1.7059525037117709, 0.7156134067610611, -0.2130172125629715, -0.7685253038586285, 0.34000245646178895, 0.7183143289698337},
    {-0.46373298699432447, 0.9863381719104978, -0.1789158853116093, 1.2567725868378141, -1.3811239785401923, -0.49528151102007406, -0.1563955943338375, 0.0034754355484728633, -0.9138461312588112, 0.7203776690207311, 0.6563924304675588, -1.1863170214231382, -0.21111107222676181, 0.41058470218581283, 1.4380887419677968, -0.37816317635102015, -1.110698011588019, -0.1740350775735655, -0.8216560606383548, 0.22047014210518215, -0.4622199556007144, -1.1455854703643364, -1.0707387519759917, -0.372074885541409, 1.067355066552883, -0.8845456733646984, 0.647301607665149, 0.792768778924927, 0.7349140188954896, -0.2969377235227172, -0.536264698314283, -1.2660579249033757, 1.034623933057203, -0.316706547171628, -0.060943184746774376, 0.868387838051924, -0.00112075491648595, 0.41719133714691975, 0.006849743318068203, -0.05799825360985614, 0.17910258804334406, -0.08830587352688717, 0.6041415853116996, 1.1991811496950548, 0.5962136021573182, 0.048986854180209614, -0.32999621602252777, -0.19273735420802635, 0.3193099210127454, 0.908179713095733, -0.44073995338278, 0.14722118703351794, 1.0515114554358609, -0.7918746552031425, -0.7531639327907574, 1.3986721384748118, 0.6518326925802158, -1.3192233110543692, 0.10102251728490808, -1.05919267890007, 0.2657607091877479, 0.526069974130594, -0.39700894350052995, -1.133467349828824},
    {-0.13089067977635116, -1.0243353347370756, -0.5931408329727571, 0.2763250527935855, -0.5739962148420893, 0.676357301348853, 0.22421289355384444, -0.013095451240980082, 0.7087161405422132, 0.5207182584505212, -0.44119020538979387, 1.4152205261877706, 0.6657471012810948, -0.34699149977651134, 0.3988249181909603, -0.01164157369412159, 0.14513147698905157, -0.10140485741853839, 0.19735757660203848, -0.7345416200258503, 0.9710089865696299, -0.8791565867825969, 0.23433090876718993, 0.14249122752148805, 0.3783270302493413, -0.19779263347415119, -0.04243975892012473, 1.0351966617031696, -0.6584327594298192, -0.3459955323061409, 0.667118127477827, -0.46958879150937166, -0.7587871584076847, 1.0412667307857517, -0.3049504086182834, -1.327159213134922, -0.20027393370526428, 0.010187874062085727, 0.18568092042077827, -0.6925050340181064, 0.514585872246902, 0.7845561764642325, 0.42419605704370583, -0.9186407890901627, -1.220384595038086, 0.9257557916457815, 1.0406774705604454, -0.7364994859264836, 0.6203053743752259, -0.15840841741825212, -0.14907849411900748, -0.17147462187460893, 0.7963826963890949, -0.21851103572673847, -0.6733783552715282, 0.7134175752300244, -0.7702432727687356, 0.03871888103010133, 0.7661528251380553, -0.6878835168974782, 0.17417379622546403, -1.2279614334285176, 0.4181642553872754, -1.056331765717423},
    {-0.1610415548996299, -1.6813535414039213, -0.13455090586883495, 0.11288400363073242, 0.9307175411682909, -0.1355096967329714, 0.9394874553925956, 0.8513255936589623, -0.05975238258367239, 0.26812974491940184, -0.005269160537632949, -0.42186259284389127, 0.5985270018094138, -0.664426540984535, 0.6167428282520995, 0.4066165407578781, -0.7983208809772571, -0.6613753800052736, -0.8650164346261305, -0.9112340153955671, -0.5684363727698242, -0.8342994830327042, -0.18567761549371753, -1.3647766029920638, 0.3433742968785846, -1.1587202891576107, -0.6906889529519299, 0.6945427228631004, 0.6215833959324648, 0.4340865130509944, -0.23427860249949467, -1.139339260101939, 0.15673985017919506, 0.29182741972592185, 0.035355559696557404, -0.5620708279653648, -0.7431647976647291, 0.6379156385604081, -1.0745801051636943, -0.6488053528100569, -0.4025218586467382, -0.5336593373729303, -1.0809874987891526, 0.6075934799457547, -0.627348078895973, -0.5905582579864765, -0.06910226255456677, -0.5993762282391696, 0.3160583838122602, -0.25177910181988017, 0.6981452327552292, 0.5171709327287667, 0.7600817356478898, -0.20754473047118838, 0.1713855916611274, -0.37434999800100444, 0.06346525726324248, 0.05104874394872103, 1.2634901575959994, -1.3988123155142678, 0.41517429543308004, -1.279424785163177, -0.0280645309571472, -1.2841079402977515},
    {-1.4194923015776935, -1.4225037836348182, -0.7403451419149967, 0.16166346586388997, 0.30892058465204375, -0.5094670449716178, -1.025937805425691, -0.7613792062737293, -0.08151703506097539, 0.2025159678960724, -1.0002315771347279, -0.6782493239693399, -0.14724933983655344, -0.1334245251313843, 1.1281693813618157, 0.5575529933845703, 0.346217630257856, -1.4618877314363967, -1.130215918441406, -0.6602817957376097, -1.0677991303650511, -0.42191409791196416, -0.48282051470065235, -0.9362493802192879, -1.3030244603024312, 0.725636222782216, -0.7597427127232163, 0.9841052956640257, -1.202309549281092, -0.23879382822315282, 0.49625900394253347, -0.03952411190306461, 0.5265957162712541, -0.2417616771449069, 0.7610369622848416, 0.44610295860430405, -1.0652493227695288, 0.9199025862384582, -0.39156150061751777, 0.8684069869057801, 0.14675525443097465, -0.28355116502022276, 0.9902416305074591, 0.27297653427614454, -1.1189427472166709, -0.04025819611218616, 0.5475370560522901, 0.9225713080208707, 0.004615520540259432, -1.0099409760594924, -1.240494633536865, 0.09824623444697604, -0.37349861320199756, 0.6564200312002242, -0.6157637240303373, 0.5819169422638766, -0.5867751315954985, -0.9032702202047426, 1.1625089497439518, 0.026449991296820984, 1.0198062970624784, -0.5743633302140722, 0.6508956209890254, 0.2568279097263364},
    {-1.1126112141885869, -0.9745048319337699, -0.8866057053403591, -0.7640052275145007, 1.1889455573758994, -1.1021042450014777, -0.44044366663936774, -0.4593309350444483, 0.13172479387471683, -0.9239286162119532, -1.7785986756579897, -0.6093383414409189, 0.24914171522466647, -0.9117119185319065, -0.01265689866391077, 0.5179538296804688, -0.7131531817051766, -0.8888795012591216, 0.30045018451769645, -0.5820666984416529, -1.345859923551066, 0.13785248693070437, 0.16733299131745505, 0.36326067944784607, -0.6985418049795924, -0.802522122671224, -1.0593232614881616, 0.139706205722118, -1.194172614790301, -0.7270666511578455, -0.42844470659010997, -0.18785744196702495, -1.3383325012204956, 0.42182482601605664, -1.2204864714106798, 0.4196363447224587, -0.30637921232461074, 0.7418677827909456, -0.42247942400720123, -0.9915177049657306, 0.394666898385681, 0.4738133028425284, 0.6039763809563241, -0.4956293726000843, -0.44584662245389806, -0.9066773954622177, -0.7550105036914875, -0.40543634684779156, 0.5414652818799274, -0.024919884396220858, 0.7049543887127505, -0.8076117098728359, -0.04985941997528845, 0.5052602652991044, 0.5239980280452803, -1.2431824308183927, -0.4059451079783467, 0.8997361719432143, 0.9904980317331958, -0.5650364269928542, 0.42513692688286353, 0.49081498769506837, -1.474915777378401, -0.21835568582670595},
    {-1.1340501661783389, -0.3051096823660384, -0.11027386477265125, 0.24450911836707276, -0.6641398061068327, 0.9006953726371695, -1.3105984635163161, 0.34621035420875473, 0.11752004059260232, 0.7239822920710001, -0.9503876092293296, 0.944355979841668, -0.2859575766110819, -0.28313688650453644, 0.22258923985413795, -0.893923280141287, 0.9974977355632925, 0.5840435068503841, -1.1164467208924482, 1.153090304366871, -0.013636750376262954, -0.5845001160135632, 0.6568976902669148, 0.04330553763876223, -0.24272091761559159, -1.107086312208584, -0.5172724417059364, 1.0367771823198133, 0.04280156243572089, 0.7733845190983976, 0.8284527642979497, -0.3334511614228477, 0.10253744215549306, 0.9328057927198952, 0.7918739829329128, -0.5972308117743703, 0.3709833101703675, 0.7265489961350867, -0.9280873734931093, 0.6844857854676111, 0.9355599336634464, 0.04545081988779606, -0.2099346522057272, 0.7314083102969838, 0.7005063511262052, -0.43870511867220946, -0.5864839732886532, 0.9700951386642938, 0.29961149260216696, 0.7224516947925235, -0.07229033894218982, -0.7142142044123786, -0.12824728858125942, 0.21720295034579187, -1.1467512690873918, -0.2860399076482593, -0.16727061444415342, 0.4804987423556108, -0.3559411208933352, -0.1963323229731643, 0.3785686591340697, -0.09242543932742427, 0.375046486511833, -1.233427230079633},
    {-0.7501114087159823, -0.8040614163754637, -0.655851542151669, 0.9287257823886685, -0.060588289844610066, -0.46458965378369754, -1.4135224330126686, 0.8178923505850926, -0.04369212688329213, 0.695511584987897, -1.3874014382721978, -0.9148886565988177, -0.7507613827170737, 0.5946022485448827, -0.06674962525821393, 0.8221130941086359, 0.5310520092139507, 0.4100573742904521, 0.10909861756269569, -0.09175079818937934, -1.1525459966629137, 0.6818562672231269, -0.6409518266188738, -0.37185982400498957, -0.8330438037371363, -0.9727120445494364, -0.830701391854858, 1.0592634994334582, 0.7302532438469169, 0.4423666512957699, -0.9142287706255497, 0.4835699992603245, -1.358413078357241, -0.23809809142084373, -1.2807487083744216, 0.6056144854533613, 0.49531273119927943, -0.8753005057966583, -1.2111887812850333, 0.11259452017667958, 0.2912106977062233, 0.44635153591300764, 0.9749652799300493, -0.10231290079148375, -1.1557456119101917, 0.6327133984450187, -0.8982642581147231, 0.06538982767120674, 0.08997195689786606, 0.0618192510018966, -0.19228384582697572, -0.9636874910768022, -1.2664023616762252, 0.5713932903494108, 0.6827524878138848, -0.24171313979471495, 0.33012532783123993, 0.12328826097529279, -0.13467972063666553, 0.06758403585911554, -0.9902344928070533, -0.1308182304444143, -0.7809520798244977, -0.717756724770131},
    {-0.4056086345941761, 0.405881563728596, 0.27981229599867696, 0.81514581583202, -0.08736859825050504, -0.8340091945561309, 0.6627833409871517, 1.31354243245371, -1.062706944837324, 1.0257914170937954, -1.2155424615766097, -0.042801957165703605, 0.6782116300158137, -0.9560803573198684, 1.2265751648936172, -0.6149436758996875, 0.14784923109483458, 0.3885341157534511, 0.6089603678867653, 0.2968220933393939, 0.20589492022273023, 0.879586248182067, -1.399275993323809, 0.2460574233616253, 0.2480508151220635, 0.8650444781776824, 0.4429857018473668, -0.8031169826403562, -0.6983094690602413, -1.3808398338625139, -0.4108943313375928, -0.1713490242816796, -1.19829232866952, 0.5758993178650225, -0.8531315259036037, -0.665810066205493, -0.11440036767771164, -0.7020006604668771, -0.13476153558670778, -0.05543769364745949, 1.0600119905932883, 0.3284866852835345, -0.5027446467818378, -0.09167923148479429, 0.5703224261301371, 0.9436347487942087, 0.4703966761242479, 0.7147029143441479, 0.9660940948792875, -0.39009299766569333, -0.6369944585984033, 0.8754485138290239, 0.24927513821991465, 0.83216151679301, 0.49718687032705317, -0.4051444297762068, -0.3865871899051882, 0.9886605494442803, 0.4208051954507906, -0.8732497004931569, -0.7594571153272988, 0.3126133398100606, -0.005813950889581841, -1.2532483208918743},
    {-0.70683710861423, -0.462743941507559, -1.155963935818048, -0.06672867258062581, -1.0347020808208238, -1.419165445787134, 0.2916068372566595, 1.2086899649015628, -0.5792480165630003, 0.6845811119951574, -0.32591497619991666, 1.1151535817823686, -0.48105443967537614, 0.23821874992592343, -0.43576119988172857, -1.3981157808834075, 0.3625061048958957, -0.08829752945606988, 0.20672802203311702, 0.9249416907135694, -1.4339962749560367, 0.6630632959296319, -1.7575187856174832, -0.6317381269477591, 0.18825768905572363, -1.395534881469893, -0.1457812167993567, 0.8370120866199487, -0.9311394215867745, -1.4364474548264, 0.2517143720143738, 0.37820247549209335, 0.7262203582182507, -0.6229749615217339, -1.459587263538604, -0.8606698485294729, -0.21657542295657625, -1.422759833605459, -1.2709699865996908, -0.8098859418854756, -0.7605720452074676, 0.42157200180335475, -0.029000773529525813, -0.7719196358724675, -0.8237900591062676, 0.5093745398513467, 0.2357729133960172, 0.8693774290494982, -0.9667851132419562, -1.1427370246523807, -0.16094120555867514, -0.7142403549417689, -0.07574264111567858, 0.10122908727869627, -0.9050378962064839, 0.8767023170529851, -0.09640670083051012, -0.4641687318439387, -0.6842812379913814, -1.0268592931376077, -1.2889231500561358, -1.496353450935783, -0.034600398197358107, 0.1890092986628793},
    {-0.2938757756228754, -0.5647794033471204, -1.3896102279678761, -0.1438319367444217, 0.17274056953828584, -0.8472473217350509, 0.8882152069945698, 0.06830050831960975, -0.4606531964349353, 0.1566392331951824, 0.6488472676139284, -0.19837588373190335, -0.8850687176031155, -0.33786255972307483, -0.20434568699408376, -0.5113681817138633, -0.27638655417168845, -1.2802827973115107, -1.00553898124217, 0.002303293387471472, -1.0163276781119932, 0.4909697607988888, -0.23722178122954166, 0.5627149828930496, -0.8795264574863885, -0.8959540325353896, 0.24786513815109149, -0.7670894092898254, 0.2168888077632086, -0.6152599665358113, 1.1673905998162952, 0.7265749045253432, 0.4190580166575721, -0.8158102003517501, 0.31862394237680536, 0.7855066803767907, -0.884490034000735, 0.5564950547916406, 0.47645873773740005, -0.16701761486036137, -0.4701778949112079, -0.36784803134865685, 1.0274087792550675, 0.32613668189082595, -0.4385372028918726, 0.7424282759963421, 1.0455324399601245, 1.27628846507926, 0.003920554438425478, -0.05170390539968024, 1.185881731828815, 0.783169131585484, -0.68131345968636, 0.8370445423123083, -0.7936140469695433, -0.3688706812657135, 0.7764906804764201, 0.6189815462240009, 0.009576275788918436, 0.1094918042329573, 0.1500204939707527, -0.72208298127605, -0.4862174342094031, -1.1845794204894131},
    {0.28413505116166937, -0.13223334989619068, -0.020397186962640205, -0.05082012874584493, 0.4082956720376073, -0.4953735821169563, -0.38513032591966007, -0.824217968868633, 1.0502857381609434, -0.5803108174695689, -0.2761497414457984, 0.5859609702429561, 0.8780628978911056, 1.0064308880276918, 0.16005974857504768, -0.050200243327325235, 0.9895640001266881, -1.0109205768468508, -0.7159037134518357, 0.5397268476638813, -1.0118844739332644, -0.20267690526790624, -1.1650747663955345, 0.23105410345111352, 0.864881979207912, 0.6172748001731306, -0.032170147639222095, -0.036346945800678834, -0.052184453907914784, -0.9778775910822882, 0.08301808561032664, 0.32988985051645203, -0.7903671207517363, -0.7098260469052218, -0.9575575596953904, -0.1450089553112526, 0.741268301743216, 0.3609286662784879, -0.8973040126682562, 0.19063392341080967, -0.04141206370704524, 0.9982998674231671, 0.2582443271707859, -1.0187498383991593, 0.5055323917402486, 1.1990011983305517, 0.24929503070714265, 0.31924523035025626, -0.4568357167747979, 0.8471617036183956, -0.24324833466388834, -0.31164753996968036, -1.145109784324515, 0.8665409713181346, -0.4292535078324782, 0.3541735626796457, 0.9295778911975929, 0.03962420420023764, -1.08569668552117, -0.03200858589242687, 0.40529002065021463, -0.5575738956983224, -0.14390996232071768, -0.42135646540924737},
    {-1.2308037632167155, -0.4326030942669786, 0.10438553276208289, 0.18267845090452287, -0.7719125859940122, -0.5400481100964563, 0.5864123054842809, 0.35026043266288626, -0.12100747444907663, -1.16725189205281, -0.005884382273552262, 0.28852829702033733, 0.6528119246174429, -0.03128361452335702, 0.7190167920769773, -0.061984594916350756, 0.24786315153429453, -0.31023206141985293, -1.3643864737362674, 0.9128569486081411, -1.1275070562547864, -0.8250700434182576, -0.27111775373001124, -0.3461992004248383, -0.5180729769568156, 0.24614365483792094, -0.9824328013769462, 0.5224038667858484, 0.015163782550843326, -1.5613781899349803, -0.35645666363094863, -0.7784802926147308, -0.015712031099357083, 0.8805236115630424, 0.5117801345817493, -0.33495415065243805, 0.49977831263431627, -1.075549097068115, 0.3806840563048371, 0.32539867103898873, -0.9339158901300216, -0.43082242108294183, 1.3286629061467796, -0.18376089816429322, 0.6882015662619678, 1.1516267965103066, 0.4837237803455912, 0.445990067184068, -0.03454158090338947, -0.4552948996826936, -0.7859733058394621, 0.9133260060525729, -0.2029995845650444, -0.7944659903809415, 0.4355516649683796, 0.9872885661027636, -0.06325230976044818, -0.16046089283231507, -0.6768326711998474, -0.343207351661042, 0.5035297485540376, 0.3351528045636487, -0.968434928750478, -0.6861292488988956},
    {-1.0933052341362133, 0.7359175751203508, -0.33057983760088383, 0.10445811147219644, 0.5658428584415095, -0.8614104789130828, 0.3670124896979415, -0.3921227728744955, -1.1522488954967944, -1.0726658532868683, 0.7700778060442653, -0.3933278993852745, 0.02340971028701134, -0.38335621244924384, 1.1391269585034671, -0.5605735341454333, -0.19229087620319513, -0.9652251569012997, -1.5037318215838569, -0.3167732794323769, 0.312794803757451, -0.02826729437636809, -1.1040637413940968, -0.493958885426824, 0.10810904173823521, -1.0213414289630203, 0.7044361466422203, -0.9736627350366793, 0.8472972028969025, 0.012330698987438807, -0.8252858707986087, -0.6459584888842279, 0.029197915459204055, 1.0433693821178813, -1.0838036833722975, -1.040458830670528, 0.4065614891197521, 0.5034143950381454, -0.3204959116973401, -0.07270699213106749, 0.4463708103523161, 0.08796809146723635, 0.5822901519599172, 0.37421463967152097, -0.3683717099180994, -0.18358978304034965, 0.5812174991522601, 1.0047092155967814, -0.05246249701803562, -0.3352674482146681, 0.7261552705792534, 0.32344138655757954, 0.021161891903369916, 0.7362189268509067, -0.03727310605250489, 0.8364830171472278, 0.571925205228059, -0.11585241386026277, -0.15690873558615936, -1.428149809205134, -0.6935426592324926, -1.1724016226180283, 0.6212819306677525, 0.23806126871538208},
    {-1.104877295250785, 0.45127487658132576, 0.6006769956289796, 0.7451265313907576, 0.9080492187010967, 0.21820437374737423, -1.1346533494631459, -0.026835503207848523, -1.230765985010689, -0.3888760517319356, -0.005744418745442416, -0.631007876917734, -0.2529073566503382, 0.574332830364162, -0.48848434398853363, -0.7371887730418152, 0.564671398765742, 0.6684486744384665, -0.5890397755213015, 1.1172881674467696, -0.7475278242040874, -1.4737052722573671, -0.40964878301586977, -1.491277103070482, -0.7570962813971925, -0.3254052964744223, -0.6829722844755125, 0.7609818523867692, -0.07962312688126238, -0.3768258780890545, 0.5550045162683171, -0.9863258404115218, -0.6637923075957888, -0.9466940370029293, -0.373418767768827, 0.7709194731265147, -0.07105866402490801, -1.2814887848881, -0.6092174768889618, -0.6230847900742101, -0.7545878540062744, 0.6508749135982314, 1.101572660150187, -0.3449593555463995, -0.5385782098368015, -0.3462996417606279, -0.5820257143745492, 0.6290673689577273, -0.2419444474197546, -0.28104772142716633, 0.6488730746679279, 0.5699079418611914, -0.19395190780351296, 0.4532427141513189, -0.6634811044937096, -0.357973965049907, 0.47534070583249377, -0.4111986780281848, 0.4418611294314785, 0.010207830900192843, -0.9599359341088086, -1.14827793355779, -1.1165718023993823, -0.45554734363837934},
    {-1.3643402077589155, 0.3058446037451139, -0.8641503655583502, 0.004462482989840453, -0.0803641439194406, -0.9500918159822785, -0.08106767842907577, -0.6600606961028861, 0.3716641530550757, -0.496905691218199, -1.5540889791648083, 0.4676010480772439, 0.5664347730577909, 0.10500520575314846, -0.4217239519914697, 0.13606710028850064, 0.0932467806087299, -0.2530036138848394, -0.05676628039943222, -0.33387221738710926, -0.8845399479326428, -1.3237961954254582, -0.46155323673037385, -1.5697230444775028, 0.23852805474204242, -0.5129894018016283, -0.9874657999167767, -0.1625240518712988, -0.10765946164677691, 0.3818733260813143, -0.7616586978957169, -0.9855970124430934, 0.5913984526050485, -0.5834914561710167, 0.7579369906905059, -1.0542594101200315, -0.8331300599403104, 0.5708748393718163, -0.2515845739254701, 0.037317118425079364, -0.9349726501709841, -0.31319295403163117, 0.9590725979482051, 0.12145942506520394, 0.5002462167143376, -0.8259031179977554, -0.3969961576307621, 0.26547110745078306, -0.6871183289388885, 0.6703156772821974, 0.7100220394288936, -0.6857948535253602, 0.1572304059558559, -0.17959816643085233, 0.4778907512841886, 0.5627025489777602, 1.045134637052301, -0.7628547497660754, 0.24058343648882569, -0.6102710377812105, -0.9596513767319312, -0.8233632042852301, 0.7259422842662729, -0.06730628712831135},
    {0.2788672637187567, -0.36945599646461486, 0.5590588071725249, -0.8107616137664715, 0.39962014350205877, 0.6048005971878075, -0.9812320951824566, -0.6900804320673878, -0.3113060299933932, -1.0661575304671531, -1.1584134070876126, 1.075847450161791, -0.7690867940440413, -0.10853460132293258, -0.19785587000126806, -0.4592774684625634, 0.9396408130624484, -1.3814628983422335, -1.5328149106285935, -0.19415724717477412, 0.20151944074029662, -1.1849956971857913, -0.38768690758946245, -1.1489340931006093, -0.3661686518706507, 0.3267294173162883, 0.05715924024380079, 0.7950205330283912, 0.028323829802425846, -0.9720528732872005, 0.2553079136363196, -1.0465172809477303, 0.2391835125675454, -0.5917346310478727, -0.7079175169561854, -0.5372799413890343, -0.9499250146795882, -0.5326587228181874, 0.863455375734593, 0.8076693485743818, -0.8046668422392089, 0.7148791867385651, 0.5623487702109407, -0.25107501871257637, 0.6143074425746223, 0.6792855456275676, 0.11248200281744, 0.23349953526603534, -0.4875254900534324, -0.09375994254868995, -0.719966808193408, -1.1932983528051084, -0.23142638378388616, -0.5161252440355213, -0.2577500744634461, -0.8970901482134096, 0.017412891934739924, -0.9488050208384393, 0.962852702399439, -0.5498809425436857, 0.26882683661565177, 0.029044744365999266, 0.37778320423680134, -0.9117818459176288},
    {-1.1765299009786259, 0.5346465405375697, 0.2708699197012143, -1.233277845449489, 0.5363197025985416, -1.5266868568212872, -1.4157742789824033, -0.001575747042819233, -1.1979559329473117, -1.1762474856903844, -1.118276184176667, 0.6405463202742832, 0.737294127194129, -0.2780514577253491, 0.5605347312708174, -0.7969435814315282, 0.7534039808485674, -1.3665895546771607, -1.5652538793713533, -0.8009222197921609, -0.4553011478753828, -1.0362015642139832, -0.7320069425723478, -1.558980108529361, 0.48396281025074955, -1.085412524590935, -0.7477700108329116, 0.6473547165818827, 0.2493560858304919, -0.799552973407106, -1.07793112194068, -0.8079425111158469, 0.12315396763579348, 1.1435659316839901, 0.3032282249956652, 0.28902721560927463, 0.49052646109010767, -0.1481664122952054, -1.2114719786763775, 0.514701292075345, -0.32864142373655114, 0.32182871030722604, -0.3152290807585545, 0.8565869518225931, -0.8706258473835726, 0.8231366651458127, -0.34816292318036896, 0.7950294350701909, 0.23959302668258348, -0.7364168280312409, -0.3987028228639544, -0.8315610627163987, -0.6145060759172893, 0.6318136486633783, -1.1789011467150565, -0.9469331472337393, 0.8249777182547939, -0.8724114178747573, -0.9209674723695526, -0.9640701326703248, 0.9044392201213403, 0.8742195723176092, -1.192582236261129, -0.7116244910946363},
    {-1.2681960527923006, -0.958705668826509, -0.25600578337349533, -0.9782983303712839, -0.5080421033191214, -1.411321508684915, -0.6439939010717302, 0.3350779679933411, -0.45183638716455543, 0.125798556252445, -0.486725953888848, 0.49054925702485647, -0.3019720604186598, -0.5749263535853986, 1.1548171493893102, 0.12672501616515433, -0.1985108376074092, -0.6021479019228093, -0.12922561855447529, 0.7567850023233419, 0.026603620251229552, -0.607001695772418, -0.1961840222842774, -0.4436899717764133, 0.594172226830677, -0.3451654668613699, 0.6732502378069414, -0.2561776824114526, -0.4089781315711785, -0.2801846878603654, 0.3568586744533265, -0.5113534403668161, -0.71057266334099, -0.0887541110589279, -0.5328835380832765, 0.6549792996002337, -1.0721509545550292, -0.27224596588838024, -1.2844817148817318, -0.6096684832547833, 0.07590591406491282, -0.6635177528448295, -0.16283985147476285, 0.9673587226679117, -0.6233696678994985, 0.42137368063295955, 0.419823575568308, 0.6827571811405617, -0.1286724171832153, -0.46881225981648234, -0.10842515759293882, 0.07781583555201506, -0.569736742424807, -0.8315015611076567, 0.32161982719468774, -0.45194892656235974, -0.6116890172445391, -0.10460651747195937, -0.6262434669168458, -1.3782638529881446, -0.2286671166634589, 0.47407482977863974, -0.23309365528111467, 0.33119210340641086},
    {-1.3544313385423639, -1.368317132596324, 0.29455076619654236, -0.08786505106243797, -0.8268039444773864, -1.350749708073634, 0.2318134872859885, -0.07292289979152398, 0.08306606933562001, 0.43612995747239414, 0.08588166793123948, 0.8934290552503323, -0.06647704370624569, 0.61169275232678, 1.4793996754930916, 0.15668449937617313, 0.5553543356460557, 0.45535863098578894, -0.7410400276932964, 0.09510718435359351, 0.05408570754728301, 0.16509745410384877, -1.5204916047924104, -0.17352455772358802, -0.8437119801262637, 0.8609294717859504, -0.9253385430584117, -0.746128857060044, 0.9193270604146586, -1.6007127351901245, 0.35648328495208076, 0.5837728663516307, -0.6887706159749095, 0.8945808926747736, 0.5467891999747829, 0.8888562767224941, -1.17668186187602, -0.5434697071470634, 0.8306348646038083, -0.48639519483565774, 0.19252540794705258, 0.5523642969728888, -0.8643354933687843, 0.2289707577449694, -0.6664929649409163, -0.5281831566214955, 0.9887243023511247, 1.3104316925536135, -0.673449945528904, -0.19508200249158456, 0.5431507891878898, -0.9071342319351006, 0.985836680714341, -0.000914072779902143, -0.374372337116378, 0.25914181532872166, 0.8798681572215054, 0.3503000177303201, -0.017656556683416886, 0.5399040491511966, 0.9595219406563307, -1.1494549516598136, 0.8508708802449106, -0.968237869971948},
    {-0.5772294833151419, -0.010005640146214216, 0.5396117344998753, 0.8503108203869488, -0.6635109663044582, 0.12692865553576294, -0.6308549822119405, 0.09287414406614057, -0.05808881224991855, 0.5038409000397849, -1.2002663240756333, 0.6659715999997454, -0.9523876655732318, -0.32836531920026657, 1.289438032009278, -1.3583170434568654, -0.7699070106954937, -0.5691030864364817, -0.42759563306756765, 0.9602387299734968, -0.2863386633358014, -1.2504979568366115, -1.5944360687626544, -1.6439883200062801, 0.43844536572827597, 0.8694632990058324, -0.4062229966242069, -0.21841076139064813, -0.09514793879285517, -0.5658730444028779, 0.6852524926544348, -1.0227625566780711, -0.03953807777421477, 0.9001760313805371, 0.3124116668295676, -0.19953026265860746, 0.44744661128690943, -0.9509260402924415, -0.25388873285239566, 0.46037967276248304, 0.15701797709166693, 0.7670064493636388, 0.6757921487960076, 0.8578827951241105, -0.44689415086647116, 0.5556018959464181, -0.957045299026605, -0.06643707592535895, 0.27717589996040076, 0.5139943740169456, 0.7350673480594327, 0.04429281332088894, 1.078418105667198, 0.8159051693139209, -1.0162464119596675, -0.43275457351928187, 0.02756253277878865, 0.6224591276801301, -0.8414764461692932, -0.01902260366863439, 0.39101126275570985, -1.1630287157826855, 0.09019167699221269, -0.2502753945574415},
    {-0.01855505003195191, -0.4884741983726945, -1.351537077306081, -1.041880507119001, 0.8720119997569463, -0.9350392803306167, -1.2823341622753859, -1.0425981018106456, -0.25950970101961085, 1.0508707133469377, -0.12148303370013662, -0.5520152961358099, 0.060786742713027725, 0.19320406068847518, 1.2947554385117184, -0.47238876584191986, 1.0435820610664017, -1.52435923516027, 0.13897438784013139, -0.29089583997718327, 0.7487900240942672, 0.23349527230786815, -1.2681574369035193, -0.10874204235731824, -0.5154411009118436, -1.1905006825307827, -1.3669806502263029, -0.12873649309321905, -0.303481606257491, -0.002870059404289696, 0.19682883805255946, -0.7328261672625012, 0.783292043032341, 0.9654045444202987, -0.5915522527245805, 0.4479987686787467, -1.353802472565257, -0.18311962324570563, 0.22505366526028234, -0.1677068249907729, -0.6173108188759701, 0.5787115720241639, 0.12483924766019454, 0.6160103372879525, -0.22839194428866083, 0.7489288432847242, -0.045829936386903046, -0.19797688240400385, -1.2051594801624392, 0.6919993077991342, -0.6561299327430352, -0.6907774378099989, -0.06628268386208196, -0.8099313753034751, 0.0719208324715755, 0.06465410638569792, -0.455168459747941, 0.8854916895841163, -0.026933734247384288, -1.0209368994499675, -0.05824392011456578, 0.2739401442167925, -0.2216567755635026, -0.8817143698529577},
    {-0.47709864961900855, -0.9457381190025781, -1.2750938652893553, 0.5131562330508822, 0.2093454179034226, -1.708532667047997, 1.0473337899423611, 0.1119431201759537, 0.8880959630438606, 0.026330369154912266, -0.6289505972089343, 1.3627200467945195, -0.5424055673809247, -0.8325431940055226, 1.0634834537760671, -0.03812656071508991, 0.3832949435129619, 0.24680943301590513, -0.7323574398202242, 0.04736820793121022, 0.9004057464398812, -1.1172571429921867, -0.9591905571836553, -1.814322346723531, 0.5420804619274644, -1.2689926379549539, -0.5320117270606189, -0.4309865081578501, 0.5459350086341891, -1.258395886467537, -0.44342913260999445, -0.18958244447882489, 0.45975598385619576, 0.815681585654308, -0.4703311404289461, 0.9341713932909024, -0.5022009535832608, 0.7957967947800255, -0.66688195561761, 0.6605067221404431, -1.4631245125061172, 0.7841491756955449, 0.4058516121628562, 0.2815712462745189, 0.2815074832131793, 1.127775175541412, 0.4716262584740816, 1.0874706503750458, -0.6786568677798782, 0.39932522232035433, 1.3589418145517547, -0.21692864432907952, 0.6748912525824532, 1.0269551705994377, -0.7959306977368998, -0.1608580577021084, 1.2805593997314875, 0.7969977165728039, 0.2023908290041859, -0.846448627393564, -0.6399459244484811, 0.31460037434608373, -0.5894742690421105, -0.26709420727488736},
    {-1.021925454350651, -1.5864191750417105, -0.2852427282051081, 0.9288020108235133, 1.2872407743675085, -0.5399253966344193, 0.09970266096608514, 0.31422272575514476, -0.12150273018569915, 0.06935846071608509, -0.42244943051446593, 1.3634755700472205, 0.678936641178839, -0.23713005774400778, 1.3643037085901424, -1.0953039587103373, 1.2135758345250007, 0.6145238666737229, -0.92135095184601, 0.38274961078825154, 1.52702408698533, -1.0798742251830864, -0.3862708010329526, -0.7777216755332671, 0.2402829657960008, -0.9994958859627008, -1.1223270543282398, 1.1135024449133648, 0.8808406585925543, -0.8168082191362223, -0.004633395650404749, -0.7764087545048914, 1.618296986546739, 1.81829436950311, 0.2607739297266085, -0.15506891893173105, 0.404101088665984, 0.06679193205673975, 0.10957429441102212, -0.6204890565057223, -1.1760369702157292, 1.3507412510835275, 0.33211612197614815, 1.8183875028857026, -0.04577647446122625, 0.2998631431631147, 0.9231004545212836, 0.7552663054590485, -0.9521074748716766, 0.02482416225124243, -0.4962576500324371, 0.4295677660065104, 1.5939767332631207, 0.2648124696672229, 0.08439683800939865, 1.026908159102138, -0.15649722739132044, 0.4410800410005711, 1.5999471555045734, 0.5598267834969559, -0.4332190708248182, 0.39232047317096475, 0.9666770237119131, 0.4356016120537634},
    {-1.2349793594063379, -2.019061403188607, -0.05201067281863813, -0.11691297945732154, 0.47247897103998776, -1.074761496580651, 0.9215584999203579, -0.7492838869778075, -1.1996795334745958, 0.8479310717247109, -0.21084691428696611, 0.5971432473659544, 0.7329036017485742, -0.6791840817040313, 1.5846228453768914, -0.4737138963958587, 0.9018273422822827, -1.2497730995933483, -2.0629799891968106, 0.4267627881970703, 0.7831927173698815, 0.1346189802080484, -0.11450600153711502, -0.6211964772546155, -0.8359827420054213, -0.03290320640927609, -0.45799684589350526, 0.3015759914895585, 0.026847102187819574, -1.2861566912320266, -0.4249482294794966, -0.05241119631343416, 0.9304318782193453, 1.519595612617617, -1.0410178575263944, -0.6448464622305219, 0.21342727255060737, -0.1214001246225979, 0.1663924002981252, -0.9046730777978161, 0.3144493585806739, 1.3136314552616335, -0.5051380953372636, 0.1545866604155637, 0.6972788143790439, 1.340266626137775, 1.0434932563790316, 0.6474585500010781, 0.22988179649528992, 0.00038871316599022206, 0.587668506041598, 0.11119595836906099, 0.134414409442269, -0.25037183877604763, -1.5999383542473404, 0.24093656614158612, 1.099896294502215, 0.8022365694685322, 0.07413852103669863, 0.15139366284115605, 0.7230440114172391, 0.18326940968310243, -0.5196643817628519, -1.4545273320254661},
    {-0.7757335798300888, -1.5930876647582666, -0.31562548918517197, 0.423523897234746, 0.920964781103888, -0.5449522313156663, 0.7286143124158034, -0.8976066090227334, -1.0390634405381525, 0.3385341977615966, 0.17607971890438875, 1.365137575049782, -0.42406538524258164, 0.676176465978228, 1.223179007319517, 0.2873083995012303, 0.8913138410514655, -1.3446759085548443, -1.4438267815363517, -0.37154752568341143, 0.7937109843994185, -0.3462734889408917, -1.5618405860155347, -0.39370353455468804, -1.1099516363906463, 0.13824608191686955, -0.6553371508974891, 0.5946847685858757, -0.7136921196794002, -1.0364591331415063, 0.5454483322243702, 0.3082496664681481, 0.6433248222060256, 0.2696536347445307, -1.3401956290732902, 0.9785084143674402, -1.329866707533794, -0.20826082488759962, -0.8525787978539798, -0.9727023420151972, 0.13262267103644, 0.9959290200230202, 0.8413333680877478, 0.46948172395824694, 0.04836248878563861, 0.9789675130718096, -0.900700376920958, 0.8264506385964909, -0.840450627739874, -0.04512940515355445, 0.5466889313497527, 0.730286675356607, -0.968332696124792, -0.7639443669188632, -1.3872068141382172, -0.28150979809006343, 1.192960885369009, -0.5670656991249099, 0.06321066681412439, -1.0779548642243408, -0.6502005946403958, 0.7268626185828906, 0.5577231267916806, -1.496349724620445},
    {-1.5323729648252882, -1.6668338477244198, 0.7893526264110583, 0.6625104019978875, 0.15397754738858355, -0.8006255590658611, 0.6138196601128774, -0.39097512020236247, 0.20807443763500053, 1.3703286334985427, -0.7712428972657949, -0.5007754446943777, 1.1466998623209965, -0.8004888396811372, 0.1844784982202964, -0.9622917844960799, -0.4850580443554008, 0.5097634850530334, -0.7575551835990937, 0.28540194169124145, -0.46454829783523366, -1.5703002888984214, -1.6432520130578938, -0.9253121220982699, -0.8186074672352417, -1.2639416457534065, -1.1884048653542114, 1.0753089285435402, 1.157709337400019, -0.13926796384641735, -0.40108084638990626, -0.5135964157367414, 0.05472782669800122, 1.3107848229902799, 0.7139287569158309, 0.7832053683196448, 0.7154572687006227, 0.5954058562248965, -1.0170763804196192, 0.5388706303435999, -1.3435202367798549, 0.5494656350344628, 0.5250704444090631, 1.4082206213876214, -0.8454132476417074, 0.8526800183735219, 0.6874901847738153, 0.4184371920131749, -0.5210342577331616, 0.9761307501187299, 1.095234491042189, 0.19154479514401732, 1.3200086917708262, -0.34014408997492407, -1.1098419068866556, 0.7125768570521865, 0.07141667068300912, -0.5527781552068847, 1.3809276507562962, -0.92591712940825, 0.1577685302748589, 0.6864676575858905, 0.21747868243875906, -0.550042821411899},
    {-1.9348728088384144, -0.7937250787002919, 0.049620899604314636, -0.6178091441200947, 0.7680752285428541, -1.6652707568053442, -0.5410081595088678, 0.9821947002886567, -0.8069768950538947, 1.0614218543097333, -1.1694654810902638, 0.17394635701496405, 0.391883045251735, -0.9251535752112423, 1.0737216492373918, -1.2407561185031393, 1.1598664079083285, 0.9650797851496712, -0.6802191560188214, 0.3453112113716143, 0.33511828691707557, -0.28324319419785293, -1.9915348411957856, 0.10354170830492747, -0.8300404497014535, -0.33377083059324814, -0.3832123563529576, 0.055717272722960856, 0.06519207969264705, -0.9986463192154585, 0.5566777837124343, -1.2621158631364933, -0.12604737141168787, -0.18066477201373726, -0.8189483693448687, -0.18095165028336516, -1.1370750504301856, -0.6413192368505594, 0.7143377219303193, 0.7465595899478277, -0.2716658390087934, 0.8309653879688059, 0.05525677255237959, 1.053863286886941, -1.1265778675518332, 1.4475178176596357, 0.8544071390535521, 1.0004417617056054, -1.0053624652516897, -0.7771841452064763, 0.8527464989020519, 0.6319685045828791, 1.1389345279506722, 1.2383126892042167, -0.7598034545435254, 1.1476095652880636, 0.26863623416276927, -0.5082738897829746, 1.4366725126289865, -1.5049648060207224, 0.2943895816339608, 0.23583161362275423, -0.35938398014947676, -1.2335100203588398},
    {-1.7902173777612302, -0.0026127603629374626, -1.032347572482233, -0.3925317108745065, 0.7903522182573115, -1.5325803659023962, 0.9763474123287713, -0.3692310364891227, -0.37696964069955785, 0.6808587860823563, -0.7733475656636807, 0.71553786735769, 0.020357937034515192, -0.9405226173071698, 1.4784272124891575, -1.0811319543893163, 0.9227456648045175, 0.214560253296038, -1.6893954438771914, -0.20926817876936218, 0.44090545630742006, -1.1600356929106952, -1.0019513515279734, -1.537656586956726, 1.0570865564741823, -0.2565339569601963, -1.091835777193238, -0.9133256740470107, 0.7379184458026592, -1.6445271673542827, -0.5155216334268186, -0.15493948911612274, 0.7431124125803245, -0.1896571905143167, -1.2012213872703115, 0.2810812133352129, 0.24706428731813326, -0.3808590824014302, -0.7371414222439259, 0.06719766278978001, -1.2271290601705411, 0.6572417224551163, 0.46735558183302583, 1.1489986962458871, -0.6793159909304632, -0.3534633917263243, 0.4121072050936361, 0.4760272308751595, -0.8525950011214292, 0.6459557101925377, 1.1323820375758316, 0.74681387210474, 1.2330567899148432, -0.43515805141532166, -1.5365927300796038, -0.43428246502875045, 0.5470224232331783, 0.8069100666500664, 1.3901785861439186, -1.6257647677160336, 0.06781978757155982, -0.43357209174889744, 0.6850597993445113, -1.5317288615344191},
    {-1.3736387873945952, -1.1908055931457582, -0.895384963730143, 0.09224441642176215, -0.4838336341816919, -0.42352878492524676, -0.17427169336386555, -0.8773238209968565, 0.6454096503433314, 0.969739433101504, -0.07046532207750425, 0.7407474542614886, 1.184385406714175, 0.18332459699233264, 0.19678843408850943, 0.40325374920354967, 1.118818304149151, -0.19498626718004325, -1.3437581474219542, 0.14718407305874073, 0.12795859698401107, -1.4334355575569298, -1.3773780213481608, -0.9822185871849549, -0.5587187569850746, -0.6114368580886728, -0.27239861239643465, -0.6606318488312931, -0.2187906498905826, -1.0375306969787486, -0.25389344482955273, -0.39387156470070983, 1.2649338867748678, 1.054508338235022, 0.12148209513002788, 0.01808078395595192, 0.061624340208031016, 0.6325181888515676, -0.5948233540344137, 0.6652811357000266, -0.3428532228151818, 1.1335263159433817, -0.4179850118979332, 1.3552972148068765, -0.48371738025561606, 0.2232079743690655, 0.8077326104585418, 0.7628103836434843, -0.2969816258381277, 0.7783315074041162, -0.7025654850739322, -0.1448500295562112, 0.38803665804238496, 0.005258584428813918, 0.025127544099196132, -0.17562523114243647, 1.0412218870819077, 1.3826994844360851, -0.3227281780757774, -0.7885052065398644, 0.41013755186811823, 0.8597785299674453, -0.9802226870851116, -0.9150157540350022},
    {-0.7137311825470617, -1.5467787306530891, -0.6522693645404299, -0.7849483404227423, -0.5531954033941006, 0.1309280620730571, -0.5122357312556509, 0.6506838722183897, -0.7855071407797392, 0.20451405601628925, 0.10992743887977618, 0.5675970779693436, 1.3947305896372657, 0.004914949119702004, 1.0430598530471846, -0.5722394968272874, 1.397429528595516, -0.4720189164901149, -1.186600112868082, -0.22950347793541262, 1.3236557680978351, -0.08742338721783487, -1.3456225474834902, -1.378591758768002, 0.4398689265563381, 0.19205652827663808, 0.2231299586124176, 0.23729081756453355, 0.6292362692018579, -1.9716425280765069, 0.713524578673611, -0.5978204857491014, 0.3024734169637811, 0.3252396134567945, 0.3852511004260196, -0.4883471308870218, 0.6197209760303356, 0.8675241848140867, 0.15287174047199406, 0.8835819270612888, -1.0229683070153142, 0.7625131729785372, -0.7646583559878039, -0.15091538888769906, -0.391701035235031, 1.2044921559851847, 1.0215941380919853, -0.14999702602374046, -1.2903972689897794, -0.4945028409977743, 1.1578446635458255, -0.5043926972452089, 1.0167603487668015, 1.133982906857127, -0.6427191570026491, 1.548570749642933, 1.245204058539535, -0.3409493033663433, 1.4092803949655195, -0.9075479500285837, 0.09549556116454316, 0.9341529465422345, 1.0734062122795958, 0.1393117251412724}
};

static const float b1[64] = {1.7055744522980893, 1.8723166684334358, 1.6671325389714633, 1.5293193373866785, 1.3194538970423804, 1.5156583858668464, 1.5743378293776922, 1.271803866004965, 1.4000434846900311, 1.5806482021415638, 1.8606498251110706, 1.4587379626070138, 1.661816143779498, 0.8386469658253295, 1.4271101842325995, 1.2556388027141456, 1.6720997619045384, 1.7791968028289948, 1.5429758561388227, 1.2084381809840548, 1.3836179421099242, 1.4859707911456228, 1.6746042690079306, 1.4492012665368177, 0.9718205751338234, 1.7183225913339017, 1.1152277214740984, 1.4085476158627785, 1.5561538932202255, 1.7185764380669182, 1.3398238122225155, 1.6178862627255728, 1.5186709703102934, 1.4225893667227851, 1.6168363182180716, 1.6161560529952823, 1.4062299150495656, 1.7153340783151658, 1.445651081500829, 1.204164604232333, 1.4307417751352192, 0.7400418979825736, 1.2671334006354824, 1.5993098884393682, 1.6943670428124133, 1.4344251293527939, 1.7778762495569203, 1.332527262984847, 1.4740032943952857, 1.5338372723484068, 1.4582494236359975, 0.39070567262356753, 1.3009368231633684, 0.23914921320828392, 1.5261661895899614, 1.5650496494447077, 1.2971162981228765, 0.9137689989557297, 1.6722800644077267, 1.7217267537001517, 1.5604303558946637, 1.799953237044131, 1.6226386321413857, 1.7168303013519917};

static const float w2[64][32] = {
    {-0.7396535774316408, 1.7672559504023155, 1.068817291447529, 0.7054679619874912, 0.40298307073408934, 1.9081738428594885, -0.07165216667508366, 1.6529765024821752, 1.4332174477883965, 0.6562640170981859, -0.1029901171696467, -0.17228265952263905, 1.2558027019817835, 1.002306107780876, 1.5109085818035588, 0.601688617964213, 0.22563153918084766, 0.20561220130921126, 0.29186916951856856, -0.699505716526254, 1.3921510037637659, -0.3030866694678253, 1.8941333141861156, 1.4738002455010433, 0.6308837303215767, 1.5926588213879758, 1.8986639740218603, -0.615888641831929, 1.2920615359697445, 0.23168548305181258, -0.04464432994262523, 0.8932518785015979},
    {-0.7808640439206428, 1.4260313058425098, 1.4253427087347912, -0.39405077115162596, 1.3616830542396487, 1.9071928794709676, -0.6851709605936549, 1.2085665491195687, 0.7560250106801084, 0.40633726527897757, -0.6326627925506954, 0.08765574929467988, 1.0346788092234198, 1.0924096008564737, 0.4297972807851366, 0.047617934183503206, 0.05278894707473185, -0.8624301090918508, 1.288967559927641, -0.08450192176303087, 1.5997456188506036, -0.8727086678634626, 2.0809805745442844, 1.5975806126449925, 1.804575214406102, 0.7425502979077209, 1.283594593221895, -0.6364872424409203, 0.23661125062762453, 0.8966050142960785, -0.4610711534555399, 0.692683889281704},
    {-0.13010661590743774, 1.7186893413699413, 0.13951157002152292, 0.27763644564328566, 1.24453616249564, 2.1406983521300798, -0.14861817120944046, 0.2068186087105579, 1.6112060369500087, -0.18884640172751602, -0.43555335153360814, -0.08945885543015883, 0.8977542730244294, 1.1333543661508583, 1.6825248523688534, 0.10829264750091146, 1.4683338903939653, 0.17901457124269002, 0.5911716470794937, 0.738626679559935, 1.2060245639954323, 0.402933576664058, 1.9367692589996375, 1.3454211437489598, -0.09781140201087563, 0.13285951804367366, -0.06061071222603122, -0.9724989369253008, 0.7517101708203651, 0.423632614338784, -0.4514282522339623, 1.068506090016197},
    {0.7033664249054603, 1.2407511841293992, 0.09655087342413218, -0.8831081573552563, 1.0438142643331134, 1.7384457528372528, 0.1604310910576165, 1.8156852000958759, 0.3919893420619729, 0.19098495763078083, -0.017977981333427068, -0.07003627009181855, 1.4621662262958786, 0.6919267787680441, 0.7478117755559648, -0.6301383836745076, -0.18492956711028344, 0.1129538109275903, 1.7389670010229423, -0.31407274096674986, 0.6330587177488742, -0.34944775225631364, 2.1484932220479043, 0.6935240084152631, 0.07549610135367593, 0.6307186132095747, 1.2648794401301349, -0.1336924377136391, 0.3131959982045744, 0.2403098470457978, 0.03571843821203196, 0.06613583369191874},
    {-0.25260256493042876, 0.8807073208811335, 0.4244146666478281, 0.3590768221991442, 0.6343670800849237, 0.2586780022432554, -1.035661380499978, 0.6339258264440868, 0.5307986657143161, -0.45055438702265216, 0.5375379815862779, -0.20988141981318226, 1.206568420865463, 0.4918937083603211, 0.5875160281093216, 1.2246647289208827, -0.1066767796119661, -0.8920790715071607, 1.5448080026745017, -0.5588797305622673, 1.7833857108676496, 0.45851514282039346, 1.2851540687597363, 2.061269803147121, -0.12897331303572873, 1.6434274881265187, 0.706500828983933, 0.4539235543616222, 0.2444305807319547, 0.031890237535380055, 0.8770245929964041, 0.8800126964166054},
    {-0.7455567441331021, 0.8533752376317757, -0.34169991973920366, 0.47305189828834127, 1.0970611010684514, 1.6342823269306983, -1.1125048641400035, 1.4505437311977831, 1.3868747033475333, 0.11749832771747909, -0.13382182665558187, 0.12312772288136767, 1.2470852282389941, 0.29431372332414957, 2.0619916641441174, -0.4051455488967423, 0.5987686030863063, -0.11063966972255126, 0.46308284404712924, -1.0355645149762187, 1.4532976012340981, 0.17688664301143295, 1.3713751736878197, 0.6253574654962429, 1.6683309602128815, 1.7309797323036167, 0.05602225844000424, -0.8152061614968686, 0.36083988552750285, 1.635688388727335, 0.26067048412360116, 1.4887175681900378},
    {0.15968624478526341, 1.5065366744995399, -0.18449239627492067, 0.07525583742425865, 1.9262594812637126, 1.371596911536118, 0.14556229432240841, 0.507439731089643, 1.6767398575652441, 0.16561084366088338, -0.7209702104868594, 0.8476534888720274, 1.2520704386861399, 0.3498776460000066, 1.5936358523393694, -0.4514879597034605, 1.2379980035593598, 0.6616352612315183, 0.1742821530165302, -0.750288956411372, 1.9080360281891366, 0.4879373864278797, 1.2738764626640176, 1.8135838271788984, 1.181394037018208, 1.5863568047118923, 1.8350164908377882, -1.0964559751419667, 0.27176018314228617, 0.2300667908597578, 0.07277376098893944, 1.926912631270648},
    {0.5590018025168347, 0.10262360598736728, 0.7223222614543198, 0.8020588483354202, 0.3529308352558449, 0.5772494303283103, -0.15165966288101435, 0.8160144945921202, 0.5623998923396344, -0.9161317956624873, -0.05034366682541077, 0.24383947606391468, 0.9718433161210044, 0.8802902479094963, 0.8537836729597377, 1.0734556727270357, 1.2151638430202751, 0.8924705044937637, -0.03885848647843432, 0.8077438376668546, 0.8091477315744368, -0.8116575994660175, 1.841204356598037, 0.17956071782952782, 1.390014616139824, 1.4739921633854904, 1.1233564850307172, -0.24796489815288209, 1.0124974355038605, 1.1558434682496255, 0.044530548405214226, 0.6035231961586803},
    {0.721218436946868, 1.8978593184890824, 0.20414902569921248, -0.0490973106034817, 1.3677598456504727, 1.5493154022150806, 0.1400757092689111, 1.6050584108910642, 2.1127307041174404, -0.20431276954575392, 0.7946603735817307, -0.5684085491377954, 1.4948724246323641, 1.1005829811296426, 0.8649021972231609, -0.398071200456827, 0.9473050896715571, -0.3870323015349597, 0.1259944406913845, 0.12090149963036413, 1.5169130687035548, 0.6459479534685786, 1.2641527926711533, 0.6419386188061574, 1.6619322142775477, 1.088089852265533, 0.42024630660603013, -0.44008846804149715, 0.6001529589196181, 1.2689922454038496, 0.5615959503846256, 0.0787839936547311},
    {0.0980713912943279, 2.114739608279706, 0.948001704472775, -0.17706849163591745, 0.849081833699317, 1.0952569764103068, -1.091471976768294, 1.9845493221726846, 0.3445506649624994, 0.6383429755620765, -0.27889307102770583, 1.295387558882976, 0.7207337284386314, 0.7208486004243253, 1.7720967533703118, -0.5695804288854208, 0.08659889589869511, -1.050282418919248, 0.2366483644457712, -0.9568001924388194, 1.813125323767384, -0.9902316269150152, 2.3986655351911095, 1.396608909358486, 1.6704795833772383, 0.500462599834529, 1.360771539733528, 0.5090326610134361, 1.900468121732869, 1.671972609994, 0.6158658714547082, 1.139360866751842},
    {-0.13465710461001834, 1.7094162477789803, 0.9654885724540586, -0.10248445398964534, 1.1587458784851303, 1.0839298934825132, -0.05684115650033669, 1.1009436073551198, 2.158147535252396, -0.9297716358140333, 0.7607366657204331, 0.39288416490635214, -0.007639815880679871, 0.4628267601212134, 2.0235556643233585, 1.0531183223463376, 0.857185262291156, 0.39756939889365717, 0.20508414221567936, -0.11672018963958711, 2.2871066309982218, -0.2721680029497552, 2.3586211366349206, 2.169375055902414, 0.645157027386028, 0.6851859682538939, 1.5069222799893554, 0.6816945362618269, 1.4390378990837533, 1.0112782542344911, 0.7554061037703979, 0.46069410881221395},
    {0.22315702262703765, 1.345176873857677, 1.4476734722950473, -0.5337166762069429, 0.5505485901932873, 0.875913235122289, 0.5499896096871283, 1.1006495460594818, 1.4319092450480915, 0.6315781580203973, -0.5248348601675533, 0.38122482805870955, 0.09118334080154973, 0.9213673774635384, 1.6123580548093521, 1.0860804943373161, 0.18632941658336627, -0.07882607676686228, -0.22020185316645804, 0.3100779231830071, 2.233391265937704, -0.2290221455072244, 1.24537533641417, 1.0576905625465505, 0.988740588995261, 0.6560632030827481, 0.3959299002007456, 0.15151878648359438, 1.1604130253914218, 1.7318454615711232, -0.6687132109808646, 0.7621259936485173},
    {0.06684428000017949, 0.44889442624537707, -0.36027014330322465, -0.6696844648990149, 0.2785342863087127, 2.059662383597151, -0.834235971594552, 0.7806568599320006, 1.8297917748930324, 0.37706521290753975, -0.22151954433288812, -0.48929602107492354, 0.2937888172937739, 0.5150248006942538, 1.3978106895404985, -0.47352170407466915, 0.7562520369842602, -0.4949284807536679, 0.479069042962894, -0.7585977181265586, 1.3128948783184617, -0.15047653180122628, 2.438303049717238, 1.4876953605486425, -0.1753127456205829, 1.4311023433623085, 1.1780007746742092, 0.09041882188811087, 0.016562272462832744, 0.31335065784247734, 1.0948796855727587, 0.22816617733194988},
    {-0.35616340371670463, 0.21577070454767452, -0.41843517092312343, 0.3435541209977501, 1.4319407098601376, 1.2589738556947243, 0.4708893204971484, 1.5257417813700929, 0.22235396856060083, -0.42757177811943897, 0.34421527695434617, 0.5432477205497227, 1.5685810670672116, 0.691068210450699, 1.4326727548291862, -0.5966832530702615, 1.4564602400949305, 0.29389999058948374, 1.6404886734709823, 0.6023737270646657, 0.28574937966302083, 0.04750801293684456, 1.4391208726797782, 0.4044075328446613, 0.01760219742896535, 0.08839939331354116, 1.4199623806498447, 0.5474753734081796, -0.10434828989868551, 0.5133598566663641, -0.5304083016596873, 1.085514357389502},
    {0.6977572160309516, 0.6125502968644166, -0.026671246973725308, -0.0811439677514065, 1.223193648266103, 1.4763506409656446, -0.4623561402764798, 1.0344754426906988, 0.2444062180532367, 0.07832378168879228, 0.7583728986932702, 0.33967995574504783, 1.3702417655213763, 0.3508271327519541, 1.635034059198635, 0.023055797206277963, -0.26097573701048177, -0.22148498345162407, 0.11407162769348694, -0.89815233528403, 0.8901062753994067, -0.3129475676062291, 1.3254917104867268, 1.5812332174277328, 0.041861062106930885, 0.6013308742416682, 0.1828558316895272, 0.49153725570058204, 0.773047563140687, -0.1599487774473565, 0.447118682734577, 1.5978576168625083},
    {-0.8349396313039475, 1.9598591281332904, 0.33076151142650434, 0.05886629517076285, 0.6167193084620076, 0.7205711471722084, 0.4452418801818726, 1.2466076658099008, 0.7912008876796055, -0.9750653568214971, -0.32453806931326584, 1.159415602006495, 1.3279615469687553, 1.572063572704243, 2.0673452919184268, -0.2723546934901041, 1.4684574829063641, -0.9562195153214164, 0.143994788227782, 0.1314833972400797, 0.5627589758118619, -0.9637128764447599, 0.6114041573610264, 1.8778617776482431, 0.6608996876797018, 1.7617742415870765, 2.0307474661109906, -0.36710167849172837, 1.160666189401016, 1.3765126408202963, -0.8311369300550926, 1.3710976798069627},
    {0.4595284099461156, 0.7847696896379152, -0.21933382108176508, -0.0741209969506947, 0.33309948328188416, 0.7332472549638706, -0.2096196396755981, 1.535740531625722, 1.4647348321176805, -0.7735664320290817, -0.9064784039909395, -0.24617655021565046, 0.25506597582744167, 1.070432421736192, 0.669036199357166, 0.09591271724930794, 0.5294507122830916, -0.6640797893461275, 1.1812859696394478, -0.5015606130045656, 2.059409375477088, -0.2649020125868719, 1.858731161200675, 1.303652134549095, 1.7213656352332043, 1.3175657912738818, 1.3780017123887114, 0.7028438277636375, 0.257373438609873, 0.7458745995751522, 0.3643950455779641, 1.0948782296312514},
    {-0.16439439427441516, 2.0822275857151227, 0.6297879386044315, -0.4197663770528691, 1.4337151874297287, 0.6284318032864487, 0.21256102707511776, 0.3509705316047516, 1.918439889815873, -0.03314733562009496, -0.32820999639219955, 1.235772076441512, 1.0679647508450987, 0.6797059847858381, 1.9935204664128472, 1.2334054452368384, 0.5068252383958817, 0.1201461984924853, 1.6847197174853197, -0.8795171882502122, 2.2534986285202168, -0.08977531783234417, 2.171063983961217, 1.3529810433374034, 0.3375919108225408, 0.8198103886631537, 1.148552933951339, -0.3498552201339793, 0.49758071670690013, 0.13222391659057525, 0.0014849869617972915, 0.09981923680181817},
    {0.03953683326551877, 0.7101439214533063, 0.49893877453669805, 0.10944545763126744, 1.1857493696034205, 2.0347587743962094, 0.5792745077198165, 1.8733760980101897, 0.4155598514876546, 0.6213919571730101, -0.18630001864224002, 1.4449903495180598, 1.5777099856852406, 1.9892952786186042, 1.8354297308455474, 1.2922800484641022, 1.4547850344761966, -0.5783646889384311, 0.962488400745135, 0.3451513347012534, 1.0665269349949393, -0.8468292211372697, 2.4868199173912435, 1.5630631681482845, 0.9331588958849732, 1.1120479977771802, 1.8968578888513452, 0.48159057346028317, 0.9548196168427491, 1.321602127769589, -0.476946169945546, 0.010173353912344765},
    {0.672739480193936, 0.05789386995417268, 0.6760792877318591, 0.2575068801435296, 1.317632132013187, 1.3706510658250208, 0.6363845496159611, 0.5672014884273148, 0.04250370728460983, -0.9692317682806755, -0.8558473702503617, 0.8333364575330563, 1.0993294918434398, 1.1037679787424919, 0.3981315021295856, 1.1240928285831515, 0.5718267970630285, -0.6995081823656779, 1.3035358677613962, -0.5599641293306532, 0.8256281952011543, 0.25228566896813087, 2.0868657230109484, -0.0002113291785243111, 0.06147748400632887, 1.0359548601792892, 0.659629592343887, -0.4180776909671938, 1.6250230792687692, -0.12602773626803127, -0.4003709435741625, 1.3576127655967383},
    {0.7337689056489644, 1.3338448815604436, -0.4968428272505225, 0.10333233442252322, 0.91968146948123, 0.9755212377521105, 0.5225507566856988, 0.9434561896817333, 1.4827170686936897, -0.8656493251288312, -0.2601441139362008, 0.3859847088190741, 1.5757659861987146, 1.858928720393071, 0.9584682833806456, -0.21856576674754455, 1.3097545458675801, -0.5031440734035925, 0.1269805141949594, 0.07885755336616293, 1.1059473514503004, -0.7011639159906022, 1.2427165531297844, 1.2303306366882225, 1.2203793907761165, 0.19810347794845473, 0.7519901313803243, -0.5675415720770313, 1.1547547320790474, 0.08731055815533159, 0.25187738091738987, 0.793727946966245},
    {0.37548991876477605, 2.077280895456224, 0.9445505151205255, 0.544686003200219, 1.3909883867552348, 2.128312093808588, -0.3890383748946773, 0.8922258611726844, 1.9467865891116176, -0.5836219485505603, 0.7804331518268003, 1.1170377814957686, 1.5565183036913017, 0.8951823380069357, 0.8005966036740975, 1.2243142982295119, 0.9951349021639525, -0.4169867606647766, 1.7168163409494175, -0.02502932812454452, 0.5315564819703469, -0.6331767373190487, 1.9502883417868004, 0.9442164118212176, 0.596309162605911, 1.3537944942757514, 1.1717103210418878, -0.7950533855539529, 0.8618414866858417, 1.6253329557912992, 0.2142616514140738, 1.036915257977453},
    {-1.1072124576262334, 1.388727275638059, 0.014975647134301722, 0.06268864326518603, 0.24377793354367566, 1.9438730874674934, -0.7788206926599698, 1.8126417305845492, 2.018727625381686, -0.17923579961557884, 0.17263564693437744, 0.5324433558602206, 0.9507636602320556, 1.8260115486047714, 1.6401410350718244, 1.1061727832427048, 1.2717415607944533, -0.3270397214261325, 0.18685951853078606, 0.3551226187548606, 0.599244666111134, -0.8585338848581715, 2.584636150384971, 0.9231846106797952, 0.7336499290687195, 1.3566824142916922, 1.58783236503379, -0.012606754271473912, 1.9811516415608605, 1.2994284201469508, -0.8249327673789213, 0.028321329716384475},
    {0.6585592858534965, 1.92760698736303, -0.1784163044561704, -0.6801071872917952, 1.3359188950628902, 2.085509769405607, 0.028784428824505843, 2.0193406635895235, 2.2523964455245506, -0.8738875873782248, 0.08558576677154993, -0.08607585749030393, 1.679558705682047, 1.7023920958695091, 1.3742765033170596, -0.06847627804749182, 1.4687988497031248, -0.9545262534187376, 1.4275381339501827, -0.24602187755337443, 0.5479039020390756, -0.6673857732755816, 0.9336934746647835, 1.5099662197390267, 1.7679102196063519, 1.2826708676290217, 0.5902294493208836, 0.7795580910590847, 1.976023796025847, 1.0718165692941584, -0.21118164841172343, 1.3738089973139942},
    {0.18872198376206276, 1.63874582588878, 0.34317199718332747, 0.07095629555417796, 1.2740472462057575, 1.6994824904968209, 0.27595982711059325, 0.5136520004998406, 0.589812361784671, -0.36132777462057086, 0.8460416126027246, 1.1304722414900477, 0.30180414038102654, 1.361535440076996, 0.5515056265316951, 0.09676755397404899, 0.17632525145852385, -0.4506043923855772, 1.1291496264106384, 0.7693797651421598, 2.1499934956642726, -0.01503933920811291, 0.4449092633165294, 0.7737314262646918, 0.3254152692997202, 0.4619079213908845, 1.4224359137606228, 0.7440964104447028, 1.6897283174613242, 1.5143705391640476, 0.31951941206842505, 0.3909697134026287},
    {-0.25736162802801343, 1.126667933762257, 0.2798728037487912, -0.4164536915069612, 1.3039312031093646, 0.7979742613415155, -0.49482773905307104, 0.8832511026392298, 0.8279605739998862, -0.26700011069437396, 0.06283463613684794, 0.09234384999866552, 1.1061125627344623, 1.6456249260486286, 1.1252188244389307, 0.987117636633635, 0.43102899478648316, 0.5147898390880685, 0.9003856820092215, -0.19812001488139636, 1.8013570504684275, 0.5804085853229232, 1.6499199276893908, 1.319036244080992, 0.9438610584465896, 1.1160363813719496, 1.2116097522823823, -0.732985183350003, 1.7540826154470146, 1.4041386369054334, -0.7801775847641386, 1.2351697855528943},
    {0.6568365041160725, 1.7566845847519559, 0.8562526928340514, -0.9739535185619523, 0.49792071680316846, 0.7268328626872219, 0.5773499700916712, 0.9468752991697994, 0.36325573066559025, -0.6014094705788187, 0.014190834814096354, 1.0257775792225385, 0.7589150048912788, 1.3228214788763488, 2.1531721624417575, 0.446720036659469, 1.0076195450980452, -0.7765145020156464, 0.6891631832230073, -0.7779232465994352, 0.4897662820135162, -0.025893385881681934, 0.9717706115763021, 1.505840329647796, 0.696736735907395, 0.9228066104950566, 0.38472573683114025, 0.08505501724952413, 1.1051371715028364, 1.2915931972273993, 0.6850154419027397, 1.7534271801907773},
    {0.28904960753578784, 1.4517921963674583, 0.0826436321450416, -0.945403938197985, 0.847273029542356, 0.70219973739928, -0.5814693243134005, 0.5667714211754347, 0.5301859926363223, -0.012580615411992149, -1.0261485838243787, -0.03809010395370007, 0.9223816061018362, 0.06517669816906511, 1.136786580224912, 0.9753557698072381, 0.5672351846672291, 0.18932364120447337, 0.885527400597111, -0.8343962203474404, 1.769726332147672, -0.16505691108782664, 0.42461361102341344, 1.9527083142564396, 0.19382757532982728, 1.5034105386053405, -0.012077350275726505, -0.7973880117206753, 1.427931631598887, 0.5359609343538745, -0.4047372348117151, 0.8268681787863601},
    {-0.018489014711196603, 1.7127453525424294, 1.2620336911817458, -0.06745161189104672, 0.22067493415335515, 0.8855564990023099, 0.5803823836531278, 0.10343679602288101, 1.6466704834319235, -0.777128030467248, 0.31255285826026746, 0.17256597444411917, 0.19957408202344976, 1.7814666639735606, 1.2757065461550448, 0.8130254054194883, 1.5815805215062044, -0.9849746043466978, 1.3006956759194157, 0.09235284712660732, 1.5425063359799445, -0.7938743569897693, 0.9138917933288604, 1.9798948866720232, 1.4643298612868936, 0.8693059218117618, -0.024629152584724454, -1.1067800377607282, 0.9739269428338742, -0.018007488705360414, 0.5548144603408578, 1.7868929733516392},
    {0.7841797409159196, 1.272038404382693, -0.11510130237272831, -1.0292800108530769, 1.367916674618366, 1.6231009249857868, -0.055894479351844155, 2.185763586359202, 1.5219124267606619, -0.05992620381672802, 0.44365859144955117, 0.4925816957814537, 1.4119348537190592, 0.5984697304176043, 1.1167459868353269, 0.7114200872674413, 0.059774158079567534, -0.9520479153501733, 0.906260026456065, -0.36292321427551916, 0.7055827731148423, 0.7646708603604017, 2.0109633362488673, 1.4197317042268691, -0.05182073592521442, 1.332093900593487, 0.18016814185923985, -0.12858741420409495, 0.8718268011217534, 1.0186083560016006, 0.5831147373766434, 1.4042643235657477},
    {-0.08066791536104563, 2.040239390087205, 0.373048407066269, -0.36870598590576975, 0.7810617916294291, 1.4127743726952897, -0.7091448787783545, 1.7182847487252026, 0.4107650572188827, -0.41689649160889375, 0.7136056006040067, 1.2841617428964147, 0.6562105408367029, 1.864381725332664, 0.3962448682509767, 1.00045635069849, 1.5725052753222066, -0.5415308386636161, 1.5292324715559014, 0.6135390791962472, 1.3481541334389282, 0.3993933757020635, 0.9239789911113222, 1.670411850028568, 1.8787198406019467, 0.03638799253886673, 1.2721255855884692, -0.47287154686370053, 1.9240334667057948, 0.7952004393034904, 0.30269229145949333, 0.6551647153503025},
    {-0.9091430037908237, 1.0600307588025737, 0.31048901315557603, -0.728246263303597, 1.1265346734939703, 2.0038536233649182, 0.28178517168714906, 1.8931807591085483, 1.0222425001394755, 0.7186605815140955, -0.8954810170043238, 0.8960755819751135, -0.19202491486732182, 0.1922890584140164, 0.6454180362546914, -0.025285616502614756, 0.1586396973470892, -1.021230278030835, 1.0227932964054998, -0.4196203352648872, 1.0498910990989683, 0.37283082466390505, 2.239025098344845, 1.752243577810206, 0.9411969967132765, 0.7667274688750724, 1.0662914741798577, 0.7155647708733008, 1.3394573918037203, 1.1683279596866254, -0.131204552631488, 0.3610790939792886},
    {0.3846153870031067, 1.6068349465400518, 0.14079825344018435, -0.6504674457546684, 1.9133805378479558, 0.7555884352985424, 0.27579588358230755, 0.35079086407849097, 2.15524171434517, 0.09038762240668988, 0.8099705039835327, 1.1514037438416227, -0.12352397831005092, 1.4283067698779583, 0.4036881122648443, -0.21528680928119592, -0.041678887179317434, -0.25510806339899034, 0.4233418474447727, 0.4068257207395334, 1.532556767431726, -0.3500939931771685, 1.0788717727978716, 1.7805960550857218, 1.0041219678073654, 1.34201610161971, 1.470065200649508, -0.028322006998047308, 0.017161032099444876, 0.9686815649663423, -0.4998122904935982, 0.33282296596062705},
    {-0.3419345933655299, 0.5685849681516831, -0.6473156352248826, -0.8596490543031061, 1.6426930685478756, 1.4974344922807163, -0.926420770287585, 1.0057063833652018, 2.1530690444997074, 0.6781459296359086, -0.8641863019835324, 0.17742783824605973, 1.0980240280695872, 0.5121382057552534, 0.5499650682644615, -0.3888314939208658, 0.637743323302845, -0.09282546608385044, 0.7564994604823645, 0.08616377000825051, 1.8161095575278452, -0.7187856538565883, 1.0428226555361415, 1.2791708705549854, 0.3925538523347394, 1.6498929796615782, 1.4129884528771768, 0.3498523742283914, 0.28320734810665016, 0.8537037711714179, 0.21352665993349207, 0.7481463113326962},
    {0.7670884227930377, 1.8850552337183628, 1.236898907868136, -0.5368796438746745, 0.6514067595993595, 1.8800895689692927, 0.5571705968958911, 1.1917278674839538, 1.5490179096957424, -0.3695613838043494, -1.0664870777907742, -0.28631892145374305, 1.2502573120180582, 1.7455759594981772, 2.0782695080269926, -0.12617947711455443, 1.0723749381039875, -0.059457283448722746, 0.4758096151903488, 0.13120312834344913, 1.8884858356342749, 0.6049284020018462, 2.270519574513859, 1.4859417133251493, 1.3871915747705281, 0.7814913435416649, 1.9039935159043566, 0.17984232400032055, 0.42289655649943686, 1.3032496532232254, -0.5952806669433801, 1.629357450898498},
    {-0.7000307998348386, 0.4366288602324306, 0.2257600811060736, -0.8018392115350615, 1.1390107637362943, 0.5957786857897818, -0.9620231307749417, 1.9597178936598791, 0.4974445616212098, -1.0670323081338926, 0.0676193462142813, -0.26092108362275984, 1.3825466652333938, 1.4174012120591253, 1.376906287783555, -0.12947967737536548, 0.9411058668349626, 0.6496390662036569, 0.4849029185495261, 0.484011767062508, 1.2624309972945564, 0.025697827884462128, 1.9165759728789973, 0.4902341603985699, 1.3432256679918286, 1.669513163797745, 0.29773357388404437, -0.42800699980004575, 0.6024945467432418, 0.7516332159929272, 0.36226559297930766, 1.789067287202854},
    {-0.8037409512954564, 2.094291540413301, 1.4577736750929282, 0.06279923914753757, 1.8731096635548605, 0.8482523333439899, 0.12244881602541484, 1.8681373993218386, 1.801132472888783, -0.6080510558709662, 0.3008443567603253, 0.8934199025111438, 0.10475246118654316, 0.5337603738886736, 1.199015747387924, 0.4152605791888498, 0.0611942956422957, -0.42083951591352203, 0.06311606566559742, -0.8181274614574267, 1.1286441385015697, -0.9273982481607203, 1.3291420020840958, 0.4180268234729426, 0.38521294872715306, 0.8947225652358338, 1.1193703509104553, 0.7486049508459712, 1.3920298558976227, 1.3911325107427364, -0.41981509085495966, 0.8188824452687684},
    {-0.8676571935976672, 1.6633506365888184, 0.19128169111072332, -0.1609387831215023, 1.0081198726037777, 1.157612566766694, -1.1197995481318175, 1.0950933092121862, 0.5092858133593422, -0.4680172787472453, -0.11395153376172124, 1.2008346963567276, 0.3511800714834094, 0.75856026218861, 1.1977298549219357, 0.29806189794717663, 1.0353579520499423, 0.1479335813138998, 0.8217428301659048, 0.3007540833380462, 1.6102114197788817, -0.7573236979332505, 1.5189027463303495, 2.3264027160505467, 1.0654716423929191, 0.40367599427482825, 0.7555382760086004, -0.3013098264067932, 1.8544668885868465, 0.7992241655110673, 1.1866639538347705, 1.3437894123455656},
    {-0.7800839019815886, 1.2682943212374607, -0.16673633253554834, 0.3752649481655363, 0.302405102420972, 1.459986247397589, 0.6244395240037671, 1.9228068250067134, 1.8688376008273333, -0.4479623323309177, 0.379307833855402, 1.3586268291123356, 0.7731566939034533, 0.8325052349942254, 1.123045411781966, -0.2975327372838025, 1.221978045260953, -0.22318488475369622, 1.0930658777903546, -0.3301223224474767, 0.7608243230339707, 0.6453986394244878, 1.7497713826049626, 0.8797475827106801, 1.1898814425899489, 0.9161318418437052, 0.2373255990222612, 0.3549278569884468, 1.9406292646265446, 0.9202050284100475, 0.1561372653563727, 1.0057270495822757},
    {-0.7787282746289833, 1.1156573383275852, -0.05703819194860889, -0.37457809577150936, 1.3342656286559988, 0.6083774481766443, -0.4631992317977739, 0.40293322644656937, 0.2533645424894348, -0.9387139411118071, -0.9993171117865527, 0.7762943303834714, 1.4871000351699648, 1.3324885898643084, 1.1804982340915486, 0.03745729545072726, -0.18580465466376167, 0.7080767080225211, 1.0426743232083624, 0.24793586488515504, 1.3629034610266593, 0.7168837143568259, 1.1620225606877057, 1.3961626144447465, 0.9703564963526389, 1.6124621836481963, 1.7154993893681674, 0.2987881539939983, 0.349935057991112, -0.10623668086502, -0.0476261608623139, 1.3082164504376577},
    {-0.10896807832458187, 2.0189454108755647, 0.2866546318867538, 0.60949006440416, 1.7918930641105146, 1.649679647986786, 0.6429825666560394, 1.0305358086087757, 0.47723419731672573, 0.31830263904668843, -0.275789114059175, 0.6993241033150897, 0.2659143381389344, 1.9339715427457018, 1.4642823898007487, 0.3815652053041731, 0.7797163344467639, -0.28640660505466903, 1.225518899587852, 0.5869684610665126, 0.4758717796236871, 0.4832982017538145, 1.745708080601694, 0.5841555991205081, 0.6622778828989515, 0.46328772780007926, 0.3256032151695702, -1.0373169216580458, 1.7367156657907679, 1.044669133312294, -0.08648620117560372, 1.690313613360551},
    {-0.2695431130402464, -0.24514767676928748, -0.3587621037823197, -0.7860667599439606, 1.4445027727134012, 0.3193396283357646, 0.1522282293095049, 0.4035402091096679, 0.85704898197251, 0.9051119125180103, -0.7680670274091236, -0.021759945478719192, 1.2759750759995787, 1.011180255037252, 0.5548001497051426, -0.6406421800620804, 0.04590184010671558, 0.6961058147070961, 0.406640957651954, -0.8122531325864957, 1.4429555500068523, 0.9331636139350878, 0.46940146511958547, 0.5056621988303032, 0.06300915630023855, 0.05879972751565691, 0.2632882154875745, 0.27641890936203206, -0.16144603683193748, 1.0336334910964484, 0.7975325743369601, -0.12988393955210456},
    {-0.7245838845758376, 1.432038009044237, 1.3362027641798921, -0.817405247232192, -0.05880354060986008, 1.3818918084180258, -0.30494855587272146, 0.9559889592547284, 1.4446946247398271, 0.655715663492274, -0.6804531340025229, -0.12586385746856574, 0.17202928040285256, 0.6641474335054306, 1.7031000931963771, 0.44073916381126493, 1.4110912731077543, 0.8666952032256761, 0.011207705982003918, -0.3179871378920609, 0.03827576157543971, -0.38718144756486134, 0.2506577712239038, 1.7726048782718795, 0.20364329931160485, 0.7270474283998661, 1.649381222410498, -0.6873910309283393, 0.06528156422027688, 0.08533111978605441, -0.03333799998221854, 0.4915575190696755},
    {-1.0515291736310677, 1.014048199947255, 0.36909160346780073, 0.46840265429521183, 0.5039072652207595, 1.4948749277968396, -0.8025007869077379, 1.1147865292248997, 1.1131859724948125, -0.595533115433052, -0.1812171792751276, 0.320074632469347, 0.3230164280337179, 0.4739471780516678, 1.5419397691134535, 0.12495072982077753, 1.381634533859995, 0.39299584345636135, 1.7408304122887626, -0.8945090837966175, 1.2212620943248844, -0.9465841777163706, 2.004260431829322, 0.869163741190033, 0.9893429588564356, 0.9282563405892331, 0.18286851938355428, -0.8590812242079927, 1.3391312555863575, 0.3111071546661977, 0.09261909641165716, 0.39536027130685253},
    {0.8889059510472366, 0.8065774534079326, -0.07527606584234377, -0.6758509000919364, 1.971115509629803, 0.5704905772939262, 0.12689329856599052, 1.518796456885711, 1.6712453665174634, -0.09413782898731592, 0.8190261406175385, 1.173110895255602, 0.33927777283953436, 1.94888665978903, 0.9533889818522661, 0.16371114559893468, 0.16511100427829323, -0.27441117982249874, 1.698412289939521, -0.7600026607201155, 1.3753806893729306, -0.28889770383879154, 1.7891010012517352, 2.010299823054502, 0.807559286651301, 0.9067527520986675, 1.2908964350898033, 0.4252622975312986, 0.27370606779903217, 1.0723707978139536, 0.7384357246024815, 0.8798007630440462},
    {-0.9216784583572615, 1.2120103328909075, 1.1073311615631485, 0.10031440133938187, 0.26185130845215493, 1.045086182251498, 0.6721220607111836, 0.6119437015102169, 1.822125850121275, -1.0033217095045739, -0.8128510727476006, 0.6209204836546555, 0.44566785667822656, 0.7775890287447469, 1.0410948685520014, -0.1514184838634269, 1.456317841007939, -0.3507742279574977, 0.18229396112769047, 0.4202583307142835, 1.0173049804950987, -0.5090633343923718, 1.1031766969297945, 1.988377468762379, 0.716007613263661, 1.1290291458067074, 0.6922209294662404, 0.02421365680861313, 1.7066896690129316, 1.4362684067376712, -0.6342712823900403, 1.1713848943001834},
    {-0.5294331031798173, 1.378651780338623, 0.3303458179571086, 0.24758383312940666, 1.3057845253902547, 0.6709100894579072, -0.559352136874454, 0.9971167925912338, 0.8221383897693811, -0.825636633016707, -0.9643967753864322, -0.262165428478574, -0.08742182433634703, 1.7243348541129089, 0.27649941265111744, -0.48574869147326916, 1.6033478417158458, 0.06206668925304749, 1.3806264623757525, 0.08627595092240932, 1.6809630636949167, -0.3369780373263235, 1.304704908424322, 2.186869723926985, 0.5634229208401788, 0.45929570373394335, 1.3307856722379903, -0.11342425635113475, 1.4307638249392778, 0.6728658742205768, -0.1434954435398397, 1.9940909533546438},
    {-0.5276361358082566, 1.6336060540776622, 0.8093047230732634, 0.6339887496086303, 1.3713805814226254, 1.49438017835339, 0.6314738356314608, 0.5970163841986749, 0.9567532579687014, 0.7782951848542915, 0.6625696529681288, 1.2298113320890316, 0.6308336564309618, 1.7245555559551458, 0.3946321834312982, -0.6329197544736156, 0.5569208296142792, -0.8142501458293021, 1.4039629442994508, -0.17903625447872448, 0.6628181282053929, 0.9072209676290682, 1.4755701876856842, -0.022048503533077853, -0.24767828816314671, 0.8251158350211873, 1.680706162604934, -0.0006078641858254772, 0.6848463281203588, 1.0497996300726842, -0.5667338652468356, 0.9316659207906245},
    {-0.7105416665879708, 2.0157036436867397, 0.20411672595003402, 0.5313627926679874, 1.389936933635798, 0.8452582636101743, 0.42071475714003737, 0.9512706134192992, 1.9538256596499586, -0.0471529648030338, 0.3692339481315146, 1.1880321580399429, 0.694189203979117, 1.5298965403415037, 0.30440389642221255, -0.5510090260437202, 0.7727314871340304, -0.675591872202539, 1.1746996318727094, -0.9466255136014378, 0.661713527593967, -0.3136991202265541, 1.0569388967695077, 2.009580286835791, 0.9524828631055331, 0.6886710964639721, 1.4497054483795278, -0.1382798369986341, 0.18188079982311536, 0.8144376343636983, 0.7233528032611727, 1.1960752060663815},
    {0.2319696122149141, 1.365435924770987, 0.9436630413638114, 0.24266637785990458, 0.17001731490134758, 0.5557799307371196, -1.0859869161831808, 1.3660701375800937, 0.6359487283213301, -0.49318965530558984, 0.33793780937320955, 0.531538838950499, 0.3015992052872882, 0.7648287994220573, 0.5517855911590291, 1.1194576159656728, 0.8925942507710307, 0.06802765650148443, 0.6636222308206787, 0.19287134070890977, 1.9623845277979686, -0.9513209534333865, 0.8449884635030994, 2.1838430982170265, 0.8648338152848983, 0.9939831223636383, 1.6263952827987251, -0.6467533197997569, 1.5161612522839762, 0.2152635685316066, -0.01737584780570766, 0.1726041379410449},
    {-0.29446376489046105, 0.15564798629336354, -0.1272478138517779, -0.9829869854081199, 1.0797743868604228, 0.29401889691661554, -0.4691137556033743, 1.5957149116175022, 0.6865804938568084, -0.4487271391469567, 0.6305703018519618, -0.42627754228415776, 0.6989853473643426, -0.03969181844272463, 1.924958896147259, -0.25986015831451514, -0.3171205958401747, -0.12252764812844888, 0.8408525607428403, 0.40467567701087515, 1.3589768644798026, -0.5756331906877743, 1.7844737054998105, 0.43323078145770805, 0.938911696233091, 1.0681520418599744, 0.17117507748991534, 0.7296860619800232, 0.7547100935104737, 1.170973798061211, -0.8364157257941734, 1.6023002610863315},
    {0.7620573260736929, 0.11761127110897046, -0.3088019699398879, 0.8146881469488215, 0.017833260336080913, 0.2566241222520434, 0.4947639367358764, 0.2824728161198467, 1.5320900989260737, -0.6031864753913097, -0.7179525432467417, 0.551232658882577, 0.7858381425091132, 1.425138789310123, 0.4585756933559993, 0.4752176853370283, -0.035081381524971984, -0.28676188113525863, 1.4243793777887301, -0.31640686167799914, 1.4604618264637437, -0.24660343155190473, 0.5426696933268808, 0.4171352266224962, 0.30644788701844144, 0.9885657062144879, 1.7414462238232638, 0.735916764436344, 0.10970295506732636, 0.9229537069296747, 0.3303593428356986, 0.32479610529148273},
    {-0.00041280528720803354, 2.0997884146557815, -0.5286060694244321, -0.37275938750608867, 1.790041782368312, 1.8201049879473885, -0.7314824571194491, 0.7312508165764618, 1.957528710008497, 0.6073764858239402, 0.1590734724228243, 1.3463385481831502, 0.7222197816729324, 0.788879096187144, 2.0742678602528324, -0.36055003114474343, 1.5894789186140483, -0.39051753399445766, 1.8272560830765576, 0.7648646873155824, 1.0271251083292545, -0.3830876959509829, 0.5011555869721541, 1.5709121392551075, 0.8783691672523063, 0.9486215738965867, 0.798874236409588, -0.7086806320356889, 0.6611687711542192, 0.23358184982329347, 0.9698671438302122, 0.6545051122433322},
    {-0.6897562268572888, -0.05095357568784158, -0.18503192952737496, 0.1225151686997306, 1.0598623562804215, 0.6277835189081205, 0.38927873695685516, 0.1506395521927628, 0.28562481995467714, 0.3138934524116816, -0.9477082645895053, 1.167313058286058, 0.7411183888242012, -0.045907427327926506, 0.32749409392280754, -0.07234119502078055, 1.429895526596278, 0.10773546518924719, 1.0764158779850082, 0.31467011512730597, 0.605487017254959, -0.45258939865946163, 0.7827952835853894, 0.27485812650370917, 0.42113065167749597, 0.9472170779573317, -0.13480020344478738, 0.06273972272460877, 0.6365256767457602, 0.8687405878233774, 0.38184775755971506, 1.089870040519677},
    {-1.0303760560157331, 1.3503930448596764, 1.302774025079794, 0.11596163867466487, 0.8889581201898807, 1.8011809423144296, 0.027839200979580654, 1.8727676737128132, 2.2141840948262783, 0.08269102371545232, -0.4216965219982536, 0.2327174180970663, 0.04846966632327974, 1.2237632720650837, 0.2966702804675163, -0.6260031471821279, 1.2358080724661267, -0.3183216231992225, 0.24214615869371683, -0.03855780249952205, 0.38778547515998824, -0.8375669866806574, 2.237438910196992, 0.5634944710619465, 1.608331653999708, 1.3707582087191128, 0.7395270732634268, -0.5124921011516597, 1.440457794143675, 0.659055461319209, -0.7565968195406525, 1.8128960265726581},
    {-1.0099865600253264, 1.3145470339885321, 0.4351099905803543, 0.47541855648200365, 0.7140486082216394, 0.4436886084410299, 0.21067744633594446, 0.6768405545710048, 2.1267213091526203, 0.16084160109781445, 0.5555454966940344, -0.0355644559969079, 0.008284092694010313, 1.0172113375765393, 0.3469444728431767, 0.1340862227627732, 1.2576068829993068, 0.7488404869731602, 0.029934059106404898, -0.33840382075551734, 1.973171509849123, -0.7397993467634834, 1.0699235997795196, 2.1733496410954225, 1.4252722972848821, 1.5877148784754358, 1.2602723162716942, -0.8370816976010456, 0.026741373460371882, 1.7032801859408733, -0.3744812737050023, 1.7779650994653473},
    {0.47900347482029937, 1.5374761166867041, 1.2415300253287156, 0.6828729768640082, 1.445279289405946, 1.3551975740724385, 0.29905363465075235, 1.4367927385526695, 0.19655122518037635, -0.48284523802890045, -0.9670133306894363, 0.4053379753505413, 1.2066968356174308, 0.3046328738428495, 0.3152507457662257, 0.03028764409312994, 0.5529007140136407, 0.39547414757757277, 0.02130351842345197, -1.0042029699452844, 0.8355458002673062, -0.8834285546438311, 0.9583916282404825, 1.567872725524485, 1.662974400815401, 0.22327718271079067, 1.0394421700100454, 0.39020380772841895, 1.1308297687831532, -0.37754927672668404, -0.2789807063972277, 1.6131171072423056},
    {-0.8189542825613868, 1.178710205992418, -0.40059687264611193, 0.026968779936947882, 1.2565966526343038, 0.7552309225175251, -0.693218875596722, 0.19711666061567198, 1.335360082579482, 0.5389504019043452, -0.09381947642215413, -0.24728072343025873, 0.7456123179804977, 0.8655471329506418, 1.3239993167832502, 0.7919133015251723, 1.3738117112340937, 0.6502296265518581, 1.320847828693414, -1.0079971239181784, 0.33717356547279387, -0.8754016531350616, 0.5367136320284088, 0.1891639665760039, 1.586874256688923, 0.0838001368555329, 0.2641769957150359, 0.1580512024034647, 1.1597030017329175, 1.5727699027247317, -0.03398228118557478, 1.5268476296347848},
    {-0.3449753063967476, 1.5299878910866012, 0.6105166887116774, -0.49438214990950247, 1.1824844353567727, 1.3143453313926892, 0.6693457090030763, 0.2587414319939504, 1.7241564241681175, -0.6977225421553209, 0.7906992901766983, 0.8987955775003934, 0.10181234825999157, 0.5767542250437978, 0.41876770923408746, 0.026468329087651073, 1.052017314106259, 0.0035607253742251095, 0.9244339859266172, 0.7635117636111266, 1.2727508026204644, 0.8868939476600681, 2.0649804760616557, 1.2900878924151624, -0.05414787472803949, 1.0255344092365632, 1.1986927610151301, 0.11676195976801321, 0.9312292152514695, 0.7741820662143668, -0.19960206037476796, 1.7813159057398775},
    {-1.026854687005827, 0.6403200213655811, 1.1282753902454306, 0.2036671120391053, 1.8106022524778203, 0.7663938804570003, 0.10032934193193847, 1.9571600167878556, 1.9188325923330234, -0.24771708504103238, 0.11828867376005425, -0.03496949582762955, 0.4586353614481493, 1.991618669078875, 0.9682087531823994, 1.027691350558567, 1.2031295791608705, 0.1820174439056497, 0.0209869271606173, 0.7441025401492788, 2.2998869979459236, -1.0029479125051945, 2.127169159582831, 1.8625893504237971, 1.0862255497609312, 1.2880981679706751, 1.2623022620375495, 0.5634609744099048, 0.060841641988773384, 1.531433694246225, -0.3307911904546578, 1.2663851109888202},
    {0.1894956349066849, 0.5169407389409492, -0.21974204893203156, -0.5392044092918566, 1.7974296793028997, 1.2463083175435279, -0.9127962862688548, 1.5475014806112153, 1.8435222969565062, 0.4017486249824865, -1.063464212481509, 0.6054714893165107, 0.8616199278642706, 0.7657990504115705, 0.7862415642667172, 0.9477386436929747, 0.6782058850681146, 0.7942886514110654, 1.6168438491935126, -0.2842429984500993, 0.27123004112868626, -0.5469942285225684, 2.2047121797987077, 1.9097692510592863, 0.061220275991792514, 1.3405019799220108, 0.8952130409149466, 0.5120683499501303, 0.5676548185401772, 1.4634623839369978, -0.2635796328881947, 0.1592618961855526},
    {0.09144774580695554, 1.8045414253726886, 0.17549061469982064, -0.13775511286546294, 0.7930835831921507, 1.2173402889374034, -0.846380286760949, 0.8076649818574546, 2.2941511009063396, 0.5920588520487058, -0.6096922254085272, -0.2595210680039187, 1.2883188056268178, 0.2694521831884464, 0.8128437543411452, -0.5232792572062387, 0.3367903539185116, -0.15248240606512187, 0.21666748332831778, -0.3938959579884277, 0.6548828478344967, -0.9177312336270866, 2.201923720158045, 0.7188801644138945, -0.08123973194240477, 1.6505499332797415, 0.7498334108980607, -0.6677767829695436, 0.7427532750821058, 1.6455001012261052, -0.27491539271335436, 1.141259601318609},
    {-0.5873071352887991, 1.990142846053384, 0.9390931362169161, 0.09570867134804854, 0.7013628227333089, 0.6435511622199052, -0.24037410987849736, 1.5084767091817683, 1.0239913378523429, -0.7525196378714313, -0.11638275556930637, -0.3983058071575479, -0.37810109459135044, 2.0174623802739684, 0.9522850647996326, 1.0613207970756167, 0.15803429889091733, -0.41646727459303917, 0.923817482927119, -0.8815670093981081, 1.1154837693943975, 0.8336294992625418, 0.9278844465584412, 2.311974079096844, -0.1409190413345703, 0.19961251684385153, 0.5727608007859917, -0.14782833723987004, 0.002796602186465213, 0.5299356781530161, 0.5342436914861202, 0.5115878678572899},
    {-0.3710414776457058, 2.0157104146019025, 0.8113230019853567, -1.0723632818495819, 0.5411310395383419, 2.1229129669860547, -0.9710355651332692, 1.2217075836612514, 1.9458954057549407, -0.3903172824463622, 0.10007438497619836, 0.4387839215952469, 0.6024296057820655, 0.6173598013529372, 0.9693512812950034, -0.01973980882578226, 1.0529043822789736, 0.9654147920331145, 1.456966575539172, -0.753562697314023, 0.32039198032247196, -0.5786195653033267, 2.2044851622002963, 0.9244349054416248, 1.8501841918219464, 1.0093375852039739, 1.6239564058749583, -0.29372372979786765, 0.9964114830787374, -0.11471274130089686, -0.18600063688484142, 0.7637766047908618}
};

static const float b2[32] = {-0.23112184427055366, 1.454796377294899, 0.5857738992967726, -0.282111119416215, 1.1125363935682442, 1.2932062583777186, -0.340897874275642, 1.3057292632541464, 1.3589079360088883, -0.3008817945418602, -0.1233103556068319, 0.45124959009563936, 0.8136352380956601, 1.2723514385048809, 1.3173087920157829, 0.3106684245550068, 0.9077996773349234, -0.07286140976223661, 0.9667177661776287, -0.1262205399615886, 1.5157371881020705, -0.11691998380453798, 1.6886399104855794, 1.5125329284094668, 1.0013404905969328, 1.0572563289265435, 1.142819911681009, -0.2973810670452809, 1.2417046567210654, 1.0115543769123347, 0.16251060243362425, 1.166224145916625};

static const float w3[32][16] = {
    {0.12296384704735747, -0.5910883946078327, -0.5902167383553606, 0.8650658498096976, -0.7517095308572158, 0.2543127598273933, -0.07523181750980965, 0.24569586135838725, 0.21333442859528184, -0.28576336271260244, -0.6523155838012821, -0.5232116891791279, 0.8684138487653532, 0.43539702243922873, 0.7846737485134357, -0.9159740496805393},
    {-0.7988662340920585, -0.5521407825044274, 1.2210969751703455, 0.7324642810086426, 1.244623939778201, 1.8360948141978004, 1.6280920680933029, -0.8007651434610723, 0.908764300038809, -0.8747552882808044, 2.219699965950262, 0.16269057486306984, -0.6522245674523971, -0.9524989374139085, 0.20415156978801308, -0.02246709673824231},
    {0.014531777318729122, 0.5425294519119457, 1.408774957017338, 0.4008371554107437, 1.34591887221946, 0.7799592598691587, 0.3471340222289241, 0.8103121123925534, 0.09652839995391689, 0.5391042666225698, 0.6895021781195193, -0.8763715482403036, -0.9408449754899705, -0.11260561452355004, 0.4142788739546077, 0.6435744318439206},
    {0.896174773129132, 0.7934730744375443, -0.6569206331656222, 0.4927597564024296, -0.8495460299881317, 0.3005392712066663, -0.24352382537692163, -0.31763355603973653, 0.3871587336107339, -0.34056825151471976, -0.36792639661564946, 0.7527954819006064, 0.33856993583873346, -0.4551044518468863, 0.593961511128942, -0.21199693841718087},
    {0.2627634577995324, 0.02180404484033326, 0.5094973640179616, -0.7316790978834274, 2.0628820399273935, 1.0476085873264875, 1.971005165644392, 0.4231919907984328, 1.258534408777545, -0.8958262329488088, 2.188904082416056, 0.34654713619933214, -0.9032288487904175, -0.5412236962277658, -1.0588842647816736, -0.024383267783889766},
    {0.9639986989767614, -1.1078538776136542, 2.2218875769540367, -0.9499742161502308, 2.0775652295999114, 1.7200611914802921, 2.130789685845851, -0.42865689148413577, 1.1827942426710558, 0.006517143592679412, 1.3025969907919093, -0.6385371645481749, 0.12659170173296755, -0.4934425532662656, 0.2643478091454191, 0.6155920128478265},
    {-0.3160602516036304, -1.0102192601617543, -0.23607485322465524, 0.6410773548010905, -0.40383175411558464, -0.4849053386119728, -0.4494900633158515, -0.5184163549557995, -0.9671043600201232, 0.4312887434654727, -0.7302140926784582, -0.8208707573974663, 0.7847825909473596, -1.087125840748654, 0.2799255123356705, 0.6577091282161778},
    {0.037101432072276265, 0.23474290882399837, 0.686833354537375, -0.4790942186335722, 1.0091215292053182, 1.8827818902684186, 1.097121936463, 0.17711990032748462, 1.559399332356045, 0.003008089314081734, 2.5295969044342876, 0.7836030807903317, 0.7349413434945272, 0.05769557311616761, 0.7141422879095092, -0.7029560802847915},
    {0.14413529454418417, -0.5021677179070921, 1.3839974431822024, -0.6225141707624983, 1.9589992123082616, 2.5266346784826346, 1.1616363652541248, 0.29528133586004984, 0.9452386788322341, -0.02488639816787188, 2.2141449298205687, 0.5680423573070837, 0.0274613092437037, 0.0004183615159995136, 0.1577505998122131, 0.7318106069438405},
    {0.22739471683341228, 0.024194784650726216, -0.7328692571771572, 0.24184065555482212, -0.4170696951804632, -0.29764012089692793, -0.9006134005206277, 0.20449788585519738, 0.7225253373946803, -0.4553580018542583, -0.3056627715601922, 0.5202122519776758, -0.31113843735733815, 0.11720941230784238, -0.7088797561036082, -0.6914713038523365},
    {0.7131725174227648, 0.34274381739039966, 0.48298479609510964, 0.023625789170186894, -0.48204677568454024, 0.21260867171816236, 0.3502116568876585, 0.6162872291317192, -0.006622656347699044, 0.028735154237195772, -0.396785070351011, -0.7930429430612964, -1.0056111636676621, -0.7166215481889496, -1.0762642889441447, -0.788617826408964},
    {-0.29561254519185626, -0.7666472081193288, 1.6420607829804348, -0.009058287992476979, 0.4738901977516024, 0.2947075643936286, 0.23175912825611455, 0.67116074834681, 1.367432773345339, 0.8136447067148507, 1.6182049444485254, -0.13223458468734256, -0.8317618710750344, -0.33097167824981805, -0.34847094056477834, 0.4954567267589735},
    {-0.6692361309903868, -0.9922666597642026, 0.8227274291871817, -0.2481593365081536, 0.660935341681774, 0.9641192826179235, 1.7548813364910687, -0.47787953769505503, 0.17582778805003182, 0.46992545310725836, 1.483417862161437, -0.37282873665112065, -0.4175277725125529, -0.07587449166196843, 0.5364575876251585, 0.7330386148513188},
    {-0.7623072650824992, -0.3847150008407979, 0.6414533006217545, 0.19745941184307816, 1.4666456076589902, 2.140225827910908, 0.8215200491974508, -0.2824729062773675, 0.6160486898915422, -0.11023334876425389, 1.550716349627723, 0.6492582139841618, 0.22183870982266304, 0.26574179516383745, -0.13370823733820258, -0.2238445574562687},
    {-0.2129769753946129, 0.426434397935306, 2.1119505673998087, 0.6209885312317927, 1.5767442830613938, 1.6095078876765225, 1.1395396967569915, -0.19358603360225785, 0.3214605890834018, -0.42658129507496745, 2.423902401273131, 0.593585473183694, 0.5716313088257856, -0.6779273492613315, 0.07837384440196521, -0.1835358366629489},
    {0.4324897131414618, 0.5498115664348896, 1.5686814853387667, 0.22171895053940796, 0.9240022194039816, 0.5657744181125656, 1.035007011945845, 0.5667331727174181, 0.5417592108930657, -0.4790390955073034, -0.21974535798303474, 0.6966566320088798, -0.11151785382869561, -0.06972625775277468, 0.2898068477776667, 0.4160249088969163},
    {-0.8048725048283598, 0.5440255480063173, 1.636001356422579, -0.7031657307463901, 1.6323744454316995, 0.45906461318942127, 1.3583676654950634, 0.8271932451716243, 1.7908946370820422, 0.29325046687662, 1.6392446114271744, 0.46238763725872173, -0.264436602657037, -1.0178090548741274, 0.5747973725064451, -1.00609949933224},
    {-0.9133913599246155, 0.4876237967508014, -0.12687834728705102, 0.5442121277721312, -0.19484968871201247, 0.533389893738913, 0.23957043331288583, 0.03872573289004499, 0.6161270462859264, -0.3527816304070122, -0.5466363842873428, -0.8747870280979533, 0.4453896799361363, -0.0622336777882836, -0.27028388442244095, -0.866102275032583},
    {0.4751383268992748, -1.0072182782561088, 0.6229892953264552, 0.029762191412574156, 1.6132879880251356, 1.933119094447987, 1.1576216045776477, -0.5700129986333766, 1.5288946192170445, -0.39444200549696273, 0.9491872720591007, -0.484914028505709, 0.7142581259923544, -0.4270525975318816, 0.5256479423536213, -0.1009913296137682},
    {-0.35715838423355306, -0.9188447145620251, 0.33493754217516314, 0.8752476452905862, 0.12561305382606142, -0.7337753247590894, -0.6279813274835958, 0.38034904224108657, 0.22012362073842143, 0.1287837030658496, -0.404126258374311, 0.6379509692253186, -0.24313001039974289, -0.0890677472490384, -0.09297613360692136, 0.833897921110375},
    {-0.9155233153234809, 0.23282174838636183, 2.105698177304, -0.38737551928501845, 1.3048479476844088, 1.5549575123819575, 1.2297921411028228, -0.532670692557936, 0.14070795200395952, -0.9901078863253585, 1.2749255002553406, 0.486346084531411, -0.4442785986543019, 0.591210894919455, -1.013568739397126, -0.5350833166380292},
    {0.21533460495584467, -0.7410744951661886, -0.6256138075530867, -0.2279420299880199, 0.38372095860079924, -0.04901394924999685, -0.41108686347400825, -0.033732155314198355, -0.6868862886514855, -0.7546159430089362, -0.5006722108788114, 0.288631854422968, -0.3618976645175147, -0.7882085537090446, 0.41921553869693756, 0.37609152347284347},
    {0.2831564673973406, -0.1809517480862623, 2.2507403233748824, -1.0245040431144, 1.647029913383031, 2.5853915027705416, 1.0924662767946667, 0.01643104670659764, 1.229946197253465, -0.937633016390895, 2.3689316685419755, -0.7744955051863566, 0.05105255312578787, -0.5755512023038537, -0.7179719037627851, -1.030218877775033},
    {-0.7270194850756266, -0.849242750984028, 1.6282072457652188, 0.48315392693103915, 1.1493700513487617, 2.3661779770145728, 0.790302354400049, -1.0795857044004455, -0.13618182370135448, 0.07611660045677943, 2.416315737494166, -0.7386565266414113, -0.3783977562608157, -0.2595052690113825, 0.15114085383012474, -0.2701136509696385},
    {0.94954159987585, 0.10695971896687487, 2.2255552864120207, 0.26669163750488145, 1.8058319138759344, 1.4234691089320155, 1.1713794536450637, -0.3047542027702554, 1.3172500616741958, 0.33643651372825173, 0.8689382541687538, 0.12860579313473938, -0.6643828445015306, 0.8188200883627056, 0.8695363991949473, 0.7734333153949597},
    {0.5781444818917608, 0.2787610142598579, 1.8505980384234395, 0.9290458353501264, 0.9553944284749705, 2.202819563690985, 1.052896936955785, -0.19893525166815615, 1.4487096629683203, -0.08199272901146884, 0.7007449698365197, -0.3163726223812313, 0.0024450635712117775, -0.20310649135168551, -0.8097388814483518, 0.47035234016034894},
    {-0.9021593946178174, 0.5595889428361015, 0.9438733386302234, -1.1249226306574165, 2.124413887343059, 1.0713295285423425, 1.2075008941420111, -0.41638883501276513, 1.6349864228182687, 0.4952702625079755, 1.6024975098227758, -1.0622179337758124, -0.49976628196545053, 0.7077652412737601, -0.6788043210380873, -0.3397871269785595},
    {0.0675080524602702, 0.46041596446423894, 0.7522640572393936, -0.6305213898628024, -0.1157537748407934, -0.09319602428956386, -0.017659517456911026, -0.889233479533075, -0.4775194813105493, -0.4878480671880473, -0.6191450286361457, -0.8747449538751336, -0.713241924371883, 0.5045057820488593, 0.7196898416724065, 0.6845651369854572},
    {0.1958336881049548, 0.7591912081124711, 1.2111655431128778, 0.3362106591133038, 2.021069069592695, 1.9548793807950804, 1.2376739365298337, 0.0496126414422758, 1.58964592123327, -0.9211614469874915, 1.138371475778627, -0.9882137469144261, 0.6202911543365635, -0.5024160073784472, -0.4675441678578177, 0.014659243618223452},
    {-0.09468487211378339, 0.5708560657778202, 1.5045484588326017, -0.30217224733336734, 1.536881626485989, 0.6925810092089948, 1.5633919907634608, -0.6728771506666881, 0.027240743303874583, 0.17371456948061953, 2.227048285944843, 0.07894204422723977, 0.27507141268457336, -0.5415972206273449, 0.8709255806429854, 0.31047692175712494},
    {0.37855333880635156, 0.9246979101258721, 0.6737952160132326, 0.8209040472064021, 0.4455172415083904, -0.3581621721345069, 0.8260023159690527, -0.06169089867047031, 0.471372131250898, 0.5779511269618408, 0.9513506200787514, -0.6266193381839408, 0.6407431244245093, -0.3883887875921386, -0.35943362440906096, -0.6859673229413009},
    {-0.6511248512815028, -0.03088794436542198, 2.2874541271147617, 0.3365002203484172, 1.399732121886255, 1.1906004514703525, 0.7645298247600751, 0.8337464537439903, 1.0866842820710558, 0.5346108547709575, 1.5911293351860367, 0.36994847634778816, 0.10400369106372352, -0.0381134663169639, -0.19610568657531788, -0.5737060878453456}
};

static const float b3[16] = {-0.07356936287990454, -0.16641246226295256, 0.9477618994777496, -0.16688047212736315, 0.7641531703347323, 1.0919407623552697, 0.7049042232628944, -0.19482590547512774, 0.3391387018245047, -0.07883738297263154, 0.9683649523616596, -0.16006696420164215, -0.20706430495184316, -0.17267949432189839, -0.177665008279462, -0.22288893981391164};

static const float w4[16][12] = {
    {0.6094436656049499, -0.27823249575474984, -0.5256422742238349, 0.11382855634404218, 0.7888618842479557, -0.7017202142051244, -0.9644426408516995, 0.5512173340371875, -0.33208928127763265, -0.6817486102835064, -0.8832712688636738, -0.893146525341035},
    {-0.22183671880197037, 0.48805346103620045, 0.3128057968994994, -0.6424689218638471, 0.1436399109848102, 0.27248632302385917, 0.4432581830863145, -0.273009857920224, 0.8689189540630115, -0.8020339784825626, -0.5235462320964169, 0.7050792590252986},
    {-1.9701712814999814, -0.561843773453591, -1.5883946856200573, -1.538000413206377, -1.8532908314153866, -0.949786019089848, -1.0876010126687659, -0.7961617237814186, -1.0002269191916562, -1.1623596369890807, -1.3737808346354603, -1.4213711302193093},
    {-0.6817980181939396, -0.7701210357643964, 0.7269796651621242, 0.27848240381886796, -0.6643149940197984, 0.3937030347153431, 0.2548766096386958, 0.631345462198317, -0.48325988648675705, 0.3580438563382266, -1.0525871926897796, 0.5269886914322689},
    {-0.2504968132638234, -0.8070998386482978, -1.6701241092210795, -1.2124333367651232, -0.6678569511242809, -1.1123464531903098, -1.2458050519988229, -0.821466949062188, -1.2965785054377288, -1.5404725797827705, -1.6481730424526737, -0.7294657540330162},
    {-0.2248925305716319, -1.8759476595308953, -0.9592632733975982, -2.0325991297655444, -0.6841365783398045, -0.45338550682986095, -1.180809361355046, -1.6530413682190086, -1.326394444046132, -1.3551298144371884, -1.0491170678949067, -2.195412203271626},
    {-1.253128959317531, -2.077522853609681, -0.9098290673935566, -0.1315718254972125, -0.999321117815866, -1.8367339596104395, -1.708051525245871, -0.549846604946514, -0.8983809557935135, -1.4340521853488206, -0.012212617704600914, -1.2905563985518202},
    {-0.5600633663620155, 0.7297544286402237, 0.32759831043396087, -0.39524102299993247, -0.031646156631198616, -0.3328395176932728, 0.8153036195169193, 0.5320724367429134, -0.5942303706327255, 0.1311871954039386, 0.6279974871176311, 0.2472060218943305},
    {-1.4834322661117363, -0.3716979577479763, -1.3426915145495644, -1.4869901570911783, -0.7980477419991697, -0.3421252995165745, -0.5417805363158464, -0.4171647028149789, -0.894426015307404, -0.04210857777610441, -1.6647679692418582, -0.8190899838621591},
    {-0.26561037083694305, 0.7450099636589372, -0.8266010199780385, -0.678495156846687, 0.4996179719839594, 0.7379145220387973, -0.030267827672857982, 0.5735733852205921, -0.9097106679636195, -0.23259092410173077, 0.5803799072548125, -0.5892775194146285},
    {-2.0261558810695957, -1.1926294660164607, -0.7725949448204439, -0.5106604102780032, -1.9287189732044294, -2.1285543533273663, -1.3056481598551668, -2.23646145369089, -1.5191234423323243, -1.2134704048683174, -1.357460051078714, -0.555224330932155},
    {-0.4243428707675857, 0.8117151292488897, -1.010335642839193, -0.6754549760241347, -0.9636262462930145, -0.26499110682144617, 0.5619084837270281, -1.0311579233104224, 0.5468969899031442, -0.9785259183392165, 0.5169634091300186, 0.7766861232781087},
    {0.8090450418093622, 0.6164202239083639, 0.4563324983181986, -1.0357847554437363, -0.9839131335963333, 0.39905847628734775, -0.8624223812230939, -0.9621021318449995, -0.5670369191322303, 0.4079064234647657, 0.5996434648361287, 0.03878785146945129},
    {-0.29295191999563946, -0.09629097644015111, 0.5667874786245486, 0.8583735039052127, -0.21079173956076167, 0.7064380899141656, 0.043668414442864595, 0.01912043930246282, -0.7153337797518762, 0.03640498712060296, -0.6370541426035048, -0.7059497829188309},
    {0.19417654112368918, 0.6314724047691548, 0.8392440910322009, 0.32039762321429616, 0.6452919269893603, 0.66832857163729, 0.6052406527109002, 0.3704174668181381, -0.5962629831060399, -0.24183589872352598, 0.5581613181546806, -0.7271907854100954},
    {0.6265079395032902, 0.6418258321777793, -0.3756990418234985, -0.07951566687826292, 0.4643118073040365, -0.7415088416678972, -0.6319845951903653, -0.9024184216041742, 0.3046515060553739, -0.987742093160775, -0.1834217114167999, 0.43793735520462773}
};

static const float b4[12] = {-0.585830042110812, -0.6816313967988968, -0.6370194322337782, -0.6343063973722369, -0.6054493810717966, -0.5506214668919517, -0.6510125387736727, -0.6904015465529918, -0.6691255113538174, -0.6791631620810253, -0.5572015354207192, -0.6060822341651042};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
