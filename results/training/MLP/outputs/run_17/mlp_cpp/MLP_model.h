#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.3661590117616678, -1.6408674965709613, -1.2924466047972851, -2.80684584724078, -0.9675813952557064, -3.7572583474283556, 1.2289057100483871, -0.72495855251303, -2.0939872647104396, -3.980686454407694, 0.8311387321592041, -1.2642549631418811, -3.726211042492493, -4.433118008064544, -1.6015796363249153, -1.76993084957695, -1.5760922820498786, -0.765172076248367, -1.3892821137070916, 1.4111794768087502, 1.5378773394946799, -1.4856420084442825, 0.3277959884873329, 0.02361276561496616, -4.067433491422529, 0.02495106090810279, 2.4907796341703823, 2.354421727712633, -4.44648184573957, -1.631058670475578, 1.2140262585983448, 0.09316626255287931},
    {2.884093831655807, -3.1291848596289666, 2.2491300021051184, 1.9435458866770483, -2.824417401177149, -2.483333556775325, -3.5008914890035863, -3.718290558090264, -3.159284143902161, -2.10235465876674, 1.6739983915275054, 0.4119842284239559, -1.945618960604746, 1.2078371862783304, 1.6592574903934365, -3.551157306263232, -1.5440658150307325, -2.8730250222546934, 0.14448400522138075, -3.8732826913518474, -3.5008907695890485, 2.2326843926610214, 0.165194827938837, 0.8926703476791634, 2.086748447723726, 0.7032668706432287, -4.221091528717241, -3.9959450981117834, 1.961622362045861, 3.2513555586943377, -2.994097305434022, 2.280443233617033},
    {-0.20000640913744291, 1.9197672220482023, 0.4018487041176145, 2.8431118898030165, 0.19713399316737326, 1.4121885118119974, -0.368805748778402, 0.7544596329413649, -2.8322508372339352, 2.691750673703324, -0.7802525647593587, 1.9527925157900912, 1.2848401145213144, -1.501549749554811, -0.7175760663267166, 2.8328284663600596, 1.6890456370276874, -2.7167679144016286, -1.8010172743547779, -4.008759244334671, -3.0694109015971067, -0.9921990201065186, 1.7832673658766984, -0.3953469240031438, 3.444377421619795, 0.3989049477939363, -2.385187574396997, -1.9052338321158993, 1.7642376791389411, -1.2385994715840656, -0.5613926036769622, -0.8868165627042043},
    {-3.970339614478147, 4.737768348873039, -3.8811021007833535, -1.6804073654816236, 4.14660280591746, 4.8528872254291535, 2.7240914131791825, 4.990044235371314, 2.0873587508222906, 5.483899265330979, -4.117689962489285, -0.14983453942210317, 4.884949027866702, 0.052675134074392234, -3.6613337576070326, 5.424973882397242, 4.682971537813619, 1.3232469179404012, -4.102221102105897, 1.0005858487464154, 1.26142835073968, -4.317587922035044, -1.576122873731331, -3.796040431168432, 0.8832271843189377, -3.2897432917710274, 1.3572422497712746, 1.8731758662962732, -0.8091700183774179, -4.317532347624021, 3.1204646947129167, -4.700412046447317},
    {-1.3109920031895697, 3.3784201999834043, -1.2132254659887935, 2.0619654808132553, 2.8625280730817098, 4.105115583325462, 1.541938558887019, 3.2922379126049517, 1.0964890442057649, 4.624820674390028, -2.4595615030558062, 2.1440366305910974, 3.5520356837246276, 3.485044813734051, -0.5322591973340979, 4.54835424904632, 2.914938228617141, -0.17159726676879528, -1.2416713213720416, -0.4015566287755454, -0.5834846522481223, -1.290759299838747, 1.0170637111280865, -1.0590013881912437, 4.847765628518074, -1.1078856146777298, -1.1295859606673302, -0.4505540432367191, 4.048416560162835, -1.8863934033352618, 0.36071067945548546, -2.7334421956526653},
    {-1.3775671788777917, 5.262640163112203, -0.9051067466630309, 2.166661466616759, 4.0462377212452685, 6.097265605796624, -0.07582869714718654, 5.137952013645136, 1.3750196000932289, 6.3987025054912055, -1.5897182777869878, 2.0743541042660225, 5.56287579109944, 3.3642638852163986, -0.29591893223552734, 6.019397075306862, 4.4392482836025495, 0.8143440712732756, -0.5405592164535566, -1.069823342152141, -1.6359785845285943, -0.7044764841131628, -0.05285613443266707, -0.7156849681369382, 5.427025282081049, -0.9462694998127068, -1.3572904691160037, -1.1417390191531573, 5.4273273971111, -0.8705352401249752, -1.1083276954010794, -2.3133969202214617},
    {-2.1952647877091045, 5.421595311699669, -1.9538347538917304, 1.4467396403235724, 3.7268998555549344, 6.043269419156059, 0.18642272309461108, 5.395603011015303, 0.41080457411398347, 6.176401437033571, -2.8281013121520795, 0.7000111760800368, 5.729819835147581, 1.4947591316416562, -1.7161027452093571, 6.044859245893148, 5.057893321369792, 0.17288317526083313, -1.4334702184405173, -1.1326876961155865, -1.3654207378893761, -1.6538160487491065, -1.459227268393881, -2.006290228615896, 4.514263895283654, -1.7009700606802487, -1.0434790328044017, -0.9328556077365109, 3.730998162532287, -2.289083540892843, -0.5954727752559744, -2.9465371631933697},
    {-1.0565559073992603, 1.2549453903768077, -1.3247853315943814, 1.764815181720787, 0.10859381634445173, 0.37242948805686144, -1.9498680832386102, 0.4141540163729454, -3.2138250090408738, 1.1751310516845235, -0.8245380834495512, -0.21904901194410625, 1.000683702680133, 1.4937069308974034, -1.0192765656901472, -0.02953903591453431, 1.6522812207909738, -3.2720156757936008, -2.0078294999007573, -2.0074277155624127, -3.1437950653296896, -0.7229927984756458, -0.2825608085540339, -1.2370526002992692, 2.596915335789593, -0.2538412490237292, -2.604728105651588, -2.2665126673391556, 2.2436985790708666, -0.8145152459823242, -2.118291743225446, -1.2421892328600683},
    {-0.0122392392905174, 1.224212300312258, -0.3486954763164271, 1.2115485757505446, 0.5639372125970293, 0.7601123969026532, 0.2512515866951915, 1.0975095581141883, -0.5774212154770322, 0.5100283687654026, 1.1443175702080792, 2.1956197005664784, 1.5024398243472419, 1.8769422517740328, -1.4413498684869017, -0.2563525023025975, 0.739812500106053, -1.2225068913786898, -1.1519261039947386, -0.3911370700594512, -1.0881436657587735, 0.291551774665253, 1.4670281151598779, -0.9773684558693314, 2.0474663939767064, 0.1958572052058826, -0.247851416734014, -0.26239212074045554, 2.6575526078308016, -0.44867971848107746, 1.829637595678435, -1.6633975287500604},
    {-0.5257203505431602, -2.570801035944456, -0.08687379201398175, -1.340051653054597, -0.24481656961062062, -2.8929710137733413, -3.8604380066314947, -2.0406694613126213, -2.120205883736202, -3.4348069388111435, 0.5848721717175517, -3.2527165453377207, -1.649078548456246, -0.31456984564028734, -1.6802571042471333, -3.5839821316128275, 0.6558188968733041, -1.7833209734351558, -2.1104247654743578, -0.7655648680636328, -1.504251920424215, 0.121044531085625, -3.700955605137912, -1.7678494210519908, -1.2831439695975633, -2.973837158186273, -2.485507116609183, -2.6923473457116502, -0.12270872500511708, 0.5615091238611983, -2.662391595209607, -0.7958189714608869},
    {-2.828389715433707, 0.9188654041904185, -2.021320565145532, -1.556576728502525, 1.2235504342261816, 0.8889368639042805, -2.1307967178290843, 1.4269575714762246, -0.683187019022979, 0.4642893794891756, -2.335312038997281, -3.0945544290367217, 1.5600183793520948, 1.2835591325638736, -3.1404817741798383, 0.18037965116938223, 1.806198672262083, -0.8135914304296026, -2.206804190138241, -0.4113206524716752, -2.1416540704623657, -2.2490411979156075, -3.499599867704613, -2.37835536340028, -0.12497074102956784, -3.013737031553501, -1.411680697481256, -2.465147925640377, 1.1031320381633631, -2.3236374445367116, -2.011690544543646, -2.5067972463464026},
    {0.3453423540978214, 0.6622206755708127, 0.5035976604287217, -1.1727233670479467, 0.2390128778793172, -0.7015365893637948, 2.7579683240914012, 0.691088144738905, 2.228696653117929, -0.01427387179528229, 0.3944587135553891, 0.7783231418041016, 0.89471956538102, -1.2407988969447736, -0.4210077189236054, -0.6577527085326396, 1.7316878187720552, 2.8506460885732965, -0.7738320337896974, 2.3449928465410506, 2.7059399219798426, 0.25323074553937075, -0.7825717831785474, -0.6151031346101934, -1.513928791511966, 0.07949009338046628, 3.0180735708723483, 2.683705925426795, -1.6088790576953476, 0.3932517348168602, 3.8579024228780967, -0.1425542229031317},
    {4.32813435549169, -3.835536254433007, 3.7663290634027513, 2.9686944195291214, -3.408802642037234, -2.241656932116594, -4.039594362190365, -4.105874415341579, -2.816585768499888, -3.034225420528002, 3.5175419839594433, 1.9647440081668535, -2.860707441016607, -0.7130563658627752, 3.552515712860098, -2.670351211951756, -3.194329577490903, -2.877392425065654, 4.402612933438622, -4.0013699159324485, -3.5915020444701624, 4.176810241000495, 2.5733280699695578, 4.466976242995879, 2.3079748746116113, 4.233013677042819, -3.655901991626066, -4.047029163752867, 3.3566869344248556, 4.111550866358486, -4.453029967020432, 4.305248151898268},
    {-4.180041160047393, 4.0205527208411995, -4.150031948143755, -3.952049694580617, 3.334769229619233, 5.309271109030503, 2.8581792194030413, 3.7645790224456115, 4.4115572612601195, 4.451844987383176, -3.50225753537015, -1.9875662529493034, 4.73849661527759, 0.38477727166749137, -4.068860307444859, 4.05290064004284, 3.729529988180219, 3.940128070936387, -2.4359361780900457, 2.2636258968108955, 2.024198779671781, -3.798315166213439, -4.011325634809493, -3.545400805493989, -2.502089572905379, -3.474522521035253, 3.259691525008634, 2.377153786692593, -1.0819037078162403, -4.135971053850722, 3.6103473416200362, -4.660916377289651},
    {-2.7151668341731177, 3.9378521067404564, -2.69972860356731, -2.8649433604790766, 2.493563884784183, 5.608943540799378, 4.1297755262951625, 3.9326472742381275, 5.580990058449519, 4.393749338036946, -1.6832456564665397, 2.3506310573860887, 4.214531748874288, 1.2139729681440679, -2.211688204565204, 4.9373250903804795, 1.582719143040757, 5.482405852279541, 2.1717220588751562, 4.371123178581063, 3.445833392539484, -1.8070987619948198, -0.7020077842358885, -1.590068911268517, -1.035490156236765, -0.07633040488412074, 5.1920993079651545, 3.838377944693466, 1.024632364195812, -2.6485560772905554, 3.787970219337908, -2.700294781976389},
    {2.169182551256387, -2.05374067090915, 1.7029304642382692, 0.227203491964189, -2.397338469820396, 1.1128625820014417, 0.5393265108000653, -2.3993153353875813, 2.2778444494247427, -0.9910355265097012, 2.781486137738077, 3.185882267753863, -1.183465370438248, -0.4495083715350714, 1.4271912781111196, -1.1180485349300642, -3.4722731627691292, 2.5832951568421185, 4.380273931847299, 1.318116326800382, 0.9202625419011687, 2.6487307604995127, 2.4719850867507507, 2.9016304462043334, -0.27992949929189376, 3.463544462334635, 1.4790057718399412, 0.2524170787319833, 2.335392177859698, 1.8762904956631068, 0.0029108963131791593, 2.8313981963573984},
    {-4.5614641180793, 5.344833711704456, -4.197661213517852, -3.8599955444199154, 4.53844416681743, 6.288166250969542, 2.9908510797543046, 5.605625943484357, 5.320437080082715, 5.6529140858305365, -3.911916653846638, -0.9133227734715761, 6.073060408268551, 2.2880670412559247, -3.8483836577836392, 5.537292593732137, 4.700493984700967, 4.738724007154505, -2.07238310810376, 3.622460001518019, 3.440754494616905, -3.5909625288826996, -4.210682758275911, -4.575158765242424, -0.6316512268027706, -4.050373228454667, 3.310558344885114, 2.7111274718447023, 0.71998475642481, -3.7926227350194988, 3.519252831332869, -4.835613734260646},
    {-2.183613507526462, 3.996719018008253, -2.1561345621396315, -1.9688000084196635, 3.4696271612881713, 5.031430473727772, 2.7089764011376096, 4.472399584268595, 4.586571933670165, 4.041228363154035, -2.190520992991117, -0.1787574490180539, 4.457625476913468, 1.0784070217997659, -1.3062038946425907, 3.9297334657376313, 2.9514437543984005, 5.061902907720083, -0.29786001432066683, 2.977895929098535, 3.9575994329954307, -1.9767564723200557, -2.421092967829859, -2.1863335458401436, -0.7443901539851134, -1.6762669406633337, 3.2343482853197556, 2.60456259283386, 0.7480084475992693, -2.1820305423656436, 3.0586794724939677, -2.8162206711651483},
    {-1.1825451262066962, 2.556440286778953, -1.8994756434196656, -0.9500288203358754, 0.38702869259560535, 2.914915794351087, 3.3340385908381274, 2.506970764043687, 3.3889003130715154, 3.2992802247822537, -1.6387145316125502, 1.4740340575017392, 2.0213687249269836, -0.0350647141523274, 0.004640710671074309, 3.061285656320607, 0.7209873515522442, 3.880914634270086, -0.28834275283005967, 2.995793758768175, 3.392930777754886, -0.8294970301054568, -0.13284796377829225, -1.3209297843965246, -0.4102066423796959, 0.45921641145527964, 2.774406004235767, 3.0451344791397155, -0.5487670388679448, -1.3512563785135785, 2.894067228816549, -1.30454786284622},
    {-3.147631856081661, 3.3983432214793745, -3.3220085818728746, -2.8112125133765153, 1.3074393820155037, 2.8351649511163073, 0.39638417601168835, 3.059988632489125, 0.2870589468198443, 2.600918617868282, -4.104512954335798, -4.076796206169358, 2.9705615600480346, -1.6861639540302724, -3.5662012146727173, 2.888320070241254, 2.003905512211006, 0.8825777196124608, -3.022818873530394, -0.42964828453138515, 0.6756275229122056, -3.294900235670524, -3.743093871532277, -3.6737771222554225, -1.5873505363844396, -3.2228860719170913, 0.2845983328690145, 0.4283408632208973, -2.501150690511723, -2.6895693665136857, 0.9057616051425192, -3.143030035649397},
    {-3.217166736270339, 3.565313059578693, -3.0672156494555263, -2.376234476395472, 2.2609040211942357, 3.63887513530061, 4.053598280623651, 3.7787890311617365, 4.683159186777241, 3.7931781607136563, -3.313551276005046, -1.8097377242005013, 3.2367204256794517, 0.4066025949509824, -1.840696886905325, 3.531775050160484, 0.7631017637292841, 4.050090005967153, -1.295633084133926, 3.5405662364180834, 4.0293695159412355, -2.953885419182281, -2.64783694711778, -2.3273124055990024, -2.7963551536079576, -1.5819058940892938, 3.409901446629986, 3.710964541944556, -3.004863120079876, -2.458968808139775, 3.553357931119056, -2.613816831164976},
    {-5.405696131036758, 3.0775100951420056, -5.152008405350093, -4.56058487783739, 2.785210844009876, 3.5825552452810467, 3.031904200179075, 3.697547894416494, 3.97518254209691, 3.5630654768814503, -4.899111845307571, -4.457093543052054, 3.6993040553905523, -0.06114060746752353, -4.560073793379398, 3.169005925692252, 2.3011055464495476, 3.872091261050683, -3.117383871025803, 3.5753950075182357, 3.343585890040413, -4.954056438165608, -5.428015231176481, -5.097739803028146, -3.8830310522925586, -5.155546659964631, 3.093764961218684, 2.721658745230046, -3.4621027852165516, -4.6709903325175075, 2.587024220560176, -5.270082866264726},
    {-2.487663654972711, 2.3832832854685266, -2.7214017681908023, -2.5389616793632763, 1.690847068497119, 2.533469037207369, 4.016301148479017, 2.3331216098805654, 3.1735308477770134, 2.643142060679981, -3.252235204216116, -2.6780518090399075, 2.3000100732088438, -0.9940098532841171, -1.2777643902163245, 2.8000072083558294, 1.4349698397651285, 3.533558115406954, -1.4963566182902348, 2.4128304494483293, 3.350494451057297, -2.792467367946591, -1.8389776170637713, -2.5258985435251318, -3.4671591916417692, -1.5439451873844146, 3.1033120265142227, 3.139704515911634, -3.8844506839106265, -2.2074845513639505, 2.949357391299204, -1.6977567031898306},
    {-3.5971124491660778, 1.0401780215509928, -3.9734980327099683, -3.160993981654944, 1.1130615723419883, -0.29738696413982185, 0.5555299579488923, 1.2643642706358185, 0.9350109187866904, 0.8800204389149776, -4.416715639951616, -4.758372220768226, 1.0659430851603278, -0.68871601200304, -1.9497223462896647, 0.18667509454581152, 1.7171650056867558, 0.6885397590883487, -3.5161290034545636, 1.264500144780781, 2.2562431791291218, -3.8452469072642126, -4.292222695324923, -4.4368887424284145, -3.4984005580821473, -4.259836825119127, 1.0488486491559592, 1.9837363710761422, -4.117833650475064, -3.114230136764634, 0.7360985675335802, -3.4990900168136023},
    {-4.518640978358574, 4.8477001629048395, -4.364973400079658, -3.479981293390917, 4.520249578482708, 2.962627333416677, 4.136627415378367, 5.098553575150205, 2.865900071431968, 3.7363215857012877, -4.5933460052876915, -4.292910981301085, 4.108215610940158, -1.0795912379631551, -3.7174769104227483, 4.348151091923643, 5.507698871695688, 2.523045125349179, -4.675286028424734, 3.0886182361669334, 3.859508834928001, -5.053046313692457, -4.269505376384907, -4.699769201392202, -3.1639073213015556, -4.622987408918287, 3.8861247609269833, 4.008327225962101, -3.5558772355167836, -4.317678378870242, 4.240773523858271, -4.617697568576543},
    {-3.4732876215181316, 1.7157414255636418, -3.973888493133601, -3.325856987623914, 2.531190473564772, -1.0759547215097258, 1.2904012591296445, 2.4855329174358727, -0.8112453977659096, 0.05454525219664537, -4.499116709051312, -4.656357700263459, 0.614545237768263, -2.9665373975419738, -2.374974593829877, 0.9445089022714867, 2.8298340640468447, -0.2138026991056351, -5.001559539145663, 2.187110377055317, 3.1282826066461515, -3.976070947846607, -3.8555574439189506, -3.8613172058827425, -4.051484889776215, -4.027227085466058, 2.2797260568921813, 3.331864846920819, -4.9746619626861435, -3.7293218114772975, 2.4907099663623864, -3.672453675524124},
    {-3.9887442320236275, 0.780739866351005, -4.233927702720392, -4.86005858851947, 1.990972855168681, -0.33516773210603923, 1.7268127393594292, 1.6557910897688903, 2.7777910483374684, -0.29401098479837295, -4.097725882949092, -5.462510780603324, 0.45441086715801055, -1.833701634441692, -2.928072819925245, -0.17392006907999338, 1.628052881515724, 2.9735148932939404, -3.3619734423684684, 4.183071399421104, 3.8277598011566027, -3.989652155435636, -5.14725115694894, -4.873490545629418, -6.021083033536876, -4.661175919803388, 3.5588043445002975, 3.6310999029238706, -5.502170031766493, -3.3038524387169135, 2.5357757356818618, -3.358708270292086},
    {-1.3504350962756386, 0.8512375294964822, -1.8814491879975568, 0.28090916509865593, 0.7273044953101088, -0.4355021471528634, -0.392055425171768, 1.8918222054090978, -1.4376674398889502, 0.5716669498704794, -3.311900661079665, -3.110881803463089, 0.7572490488657381, -1.4005449231908536, -0.5501617093826684, 1.096228610965485, 1.2784966977338519, -0.6576280292384139, -2.5342030150482784, -0.25295317077213464, 0.5431522308928876, -1.7498567382213681, -2.2482285746690374, -1.7016254452672965, -0.8209865290799394, -2.33771930476754, 0.11898884524826508, 0.8204602451651386, -2.031982682534964, -1.9507467784109, -0.23987736071978852, -1.2543965613385808},
    {-5.370427807820039, 4.2353881298192055, -5.333726399572185, -4.39754224077931, 4.690306362689107, 3.278863370197233, 2.3700076325232153, 5.239125839639165, 3.06728218703229, 4.191507470622346, -5.438953456709955, -4.484980166042161, 4.406174803445205, -0.054719840795264624, -4.17190105959783, 4.04034519540857, 4.9435455329651035, 2.8399088936441976, -5.271405215467169, 3.0019345876472436, 3.645894912782656, -5.562168075839089, -5.486684887160049, -5.698207985240359, -2.7617794139810576, -5.706579258061849, 2.8724196525070322, 3.0778423849965573, -3.648443239086217, -4.747015608158085, 3.187337149131874, -5.8727723385013135},
    {-3.493823068513277, 3.2700419518957564, -3.400643652697817, -2.299835964419122, 2.87399114828617, 2.4911711350440577, 2.812866550446072, 3.6041903161575863, 3.970812773814945, 2.8981649710470907, -3.581480773283081, -1.8499571206206626, 3.191999202356629, 1.3775900928666114, -2.861214548206147, 2.99167147023455, 3.2727337479590672, 3.7180241985898737, -1.7018231280312472, 3.6408117354567016, 3.314984469930557, -3.1183984058005785, -3.8527171947847245, -3.567256020262578, -0.7940735289201671, -3.583341316471698, 3.450464923588851, 3.4196725041961438, -2.0827841667202938, -3.5861333378586364, 3.4812752466110948, -3.7245203849291553},
    {-7.11242930132876, 1.5210043131852182, -6.380696178300551, -6.359330548088311, 1.896301526289477, -0.728720364647931, 0.06778542704828307, 1.9578152522539274, -3.945328551844918, -2.641232177960658, -0.6969825769282113, -5.995041409970142, -2.4140700836748246, -6.023334318421296, -6.563861198065913, 1.2727966933406822, 1.6997141332105234, 0.0818987303444243, -6.291839536669913, 1.4142609072125107, 1.4860260115889108, -6.487953017478869, -6.585774302516425, -3.337687255756017, -5.812167825090898, -6.741102530748863, 1.617936271314691, 1.406615842211059, -6.140496963939796, -6.74187003761859, -2.6316693810220766, -2.917567002746544},
    {-5.805988132166306, 2.279906321578388, -5.06765585125589, -5.128242044434924, 2.2923367083856556, -0.24370208092739729, 1.233115142338208, 2.402838127610831, -1.690173971196858, -0.6354808976766134, -0.6959931923736761, -4.955922932607589, -1.0311409438639476, -5.025727847030831, -6.003214631537516, 1.2870227720020284, 3.098478308303709, 0.3485510661278717, -6.231966236453356, 2.420093452667186, 2.633522147275849, -5.9925538175366295, -5.046102075892935, -4.187813712682855, -4.958443428998864, -5.283513802962022, 2.7600807617835414, 2.9364336057023466, -5.090403121097452, -6.261807135726336, 1.4267023944794561, -2.1360138486639615},
    {-2.340653199845657, 1.3279586665911294, -2.247071976688773, -2.7856716966092754, 1.4009360310839805, -0.8317971141638401, 0.9606774066190655, -0.03877787774539665, -3.2842369458934124, -0.7288576623286417, 1.5597343951124631, -2.409550164949118, -2.9431751597526428, -4.460898821605124, -2.3498107098933882, 1.0052696718386356, 1.845820228622946, -0.5978118623301967, -3.5150878674795005, 0.944005219250832, 0.43016035477432263, -2.468757157111401, -1.6375415805302544, 0.63669165500375, -2.8559968665686846, -1.3792508085382145, 1.3440305320753134, 1.2490674659352046, -3.666227702826449, -2.769684958132293, -0.8589456220402417, 0.0026709680175639253},
    {-1.0498262282644972, 0.738605252531113, -0.6737131864139304, -1.6980041848318768, 1.4075727487086869, -1.3868363329603355, 1.7335649693424722, 0.5950321697369674, -2.6022812457565307, -1.7580180978684201, 2.2636469538641837, -0.6349440945258916, -3.1832586580257436, -3.771981986672996, -1.3283059459376485, 0.5494754805941505, 1.2422495655004406, -0.7510273227575586, -2.0251881763234105, 1.151104476060522, 1.3409210340407913, -0.9840569347671512, -0.9405337056509027, 0.9628570320952355, -2.8523838223234783, -0.23617423355110911, 2.24618931942753, 2.2386995443758675, -3.8576677968819015, -1.84138629934853, -0.24874689734326838, 1.084774503209473},
    {-1.9035443875900617, 1.7998857655469784, -2.3961539974045607, -1.0894098174821019, 2.0154953454835853, -0.8807728040082483, 2.644639759514588, 1.4599068653773406, -1.7415732878988948, 0.1849500803867946, 0.5815082928759943, -1.9855648206065055, -2.1565823928515995, -3.422294620246515, -0.9610684575591115, 0.5022896330307199, 2.0589875698389353, 0.10757971423173118, -3.097678984287954, 2.21395133735156, 2.2545633753028174, -2.3031555367935326, -1.3162315306965202, 0.44250592734389005, -1.649822367042469, -0.8949904808888147, 2.0361541947456496, 2.7931143335251822, -2.085633261512228, -1.6462315608371827, -0.6367293991350845, 0.4419907919281101},
    {-2.160717211336634, 1.8181604795291655, -2.1233080678959446, -2.056116294384658, 2.7320350974788865, -0.45747865636539486, 0.407384930504252, 1.503373751878818, -1.2805296308904894, -0.3496794098074031, 0.588204120764475, -2.7273196887609887, -1.664758002737161, -2.2356013919207474, -1.2113797881841881, 0.7650888203903682, 1.998214153132358, -0.2414523585826465, -3.3412195303907177, 0.31147474531081565, 0.4661258506354442, -2.3663297727892183, -1.1969808198117435, -1.4013653116722409, -1.9432875967076055, -2.6269652979204845, 1.2557048360960636, 0.8600806765898127, -2.6755352166566757, -2.406326611672965, -0.5240937736558088, -1.7230398947833565},
    {0.09163201290036374, -0.1268103710724046, -0.018317168916015956, -1.136353405145311, 1.6034510801635202, -0.832715382538863, 0.03761446045048277, 0.06275936984511937, -1.6293339314998156, -0.4432539430745142, 1.0685913353745742, 0.4775637193696044, -1.7269267718973993, -2.9503767877924743, -0.3322287445264199, 0.5020320311184148, 0.872935809082597, 1.283457689672013, -1.048511812824886, 0.20609183380536114, 0.25824364230126384, -0.42146682370418953, -0.279770239181857, 0.3259541780875363, -2.3662630320767337, 0.06259419693916062, 1.8208890897767873, 1.2070710084491623, -1.7435386527789907, -1.1249211089431213, -0.019656524257223466, 0.4475384487089393},
    {-2.2751810622658626, 1.1656436860233546, -2.4418828815863955, -1.3047883775952935, 1.8541258733705583, 0.5345703586195039, 1.2935364727754122, -0.6524011510316354, -0.5736668311174461, 0.215904699604229, 0.47005331307855225, -0.4021419347111289, -0.7306049880767692, -1.6386651797609189, -0.8242595138906181, 1.6254552780756584, -0.10189760658408041, 1.2856238842970762, -1.3324718119986274, 1.6240698391011297, -0.13547746735224692, -1.5212325212296776, -1.1734578384657484, -1.965232036517859, -2.883607250051441, -0.717171785678603, 1.5868210002680472, 0.2732673066263083, -2.1710890837271237, -2.631846801081921, 0.08225034208498126, -1.3018727061056699},
    {-2.892997394234954, 2.661719714387037, -3.2027132452906617, -1.9077852977747334, 2.3811344534705983, 0.5158099466882133, 1.2005550592293683, 0.6936431781763457, -0.9321717539653547, 0.82690326928064, 0.768539436509855, -1.0277056202329053, 0.20752896904631055, -1.9759589874182806, -3.14335207546361, 0.7035562268858923, 2.8275969056054238, 0.38396473236377704, -2.6590164923822606, 1.4700568034298982, -0.3737214283726042, -3.1879700527383332, -1.4910793500338686, -2.1801869903626265, -1.1564443646766667, -2.73281011242653, 1.8613577148314493, 0.8941975874795419, -1.8251282165217972, -2.9132326194920184, 0.91161162534338, -2.5103529386115246},
    {-1.1370447969148216, 1.2312725906576754, -0.282699000375693, 0.732399905904512, -0.5803051532980353, -1.1436091427995965, 0.6272922419659734, -0.817624070263436, -0.6591981427943473, -1.2360594234424511, -0.3428347070560798, -0.5425195116815829, -0.44729351672862055, -1.0516068550550954, -2.122659886499578, -0.9774645889156495, 0.11685103586294122, -0.3980840843241715, -0.9421643734797962, 0.6257795146889998, -1.2034574525878468, 0.5366629006111855, -1.191751402532251, -0.7799295307965942, 0.5940012695337791, -1.596846303123546, -0.9269196290016063, 0.44254922088146503, -1.1077554816365196, -0.49085454511460014, -0.12315892812411222, 0.09884366299132179},
    {0.27444726867207425, -0.26054340912138096, 0.5251731301547071, 0.10579172586025334, -0.6501110700332484, -1.8120211403526854, 1.064753425957028, -0.8365049696870659, 0.45818400548965715, -1.8657460281278928, 1.4386376765794038, -1.0495045105176108, -0.940124631647546, -1.5109575217929028, -0.6835532529081519, -1.4320688645127244, 0.5209257923544327, -0.2781188662033171, 0.7548206817207961, 1.1124719667842586, 2.1492155055925375, 0.765440416699631, 0.8347752905641549, 0.6932289031099241, -1.0118904697529445, 0.5937632820921718, 0.47822548197508596, 2.020501437180844, -1.6432294784638624, 0.0386286911381954, 1.5843090291106676, 1.4936716484373576},
    {-0.3687173000712206, 0.33247368074424893, 0.6149527730114638, 0.6730991486395022, -0.878203480313106, 0.3127929752089297, 0.8475974307272298, 0.7219397438781526, -1.0288690494465889, -0.6365141710617515, 1.4457505351056685, -0.8575174965605886, -0.13311348941027606, -0.525848442788075, 0.26354804703365053, 0.46675694550265645, 0.7486252214345005, 0.385975326790351, 0.4445443575073973, 0.04869771556672846, 0.4477583002799071, -0.04201271027452135, -1.189806061245176, 0.6499017058657472, -1.650132189111356, -1.5768672949731108, 1.107088463689968, 0.5506276134790485, -1.0647463177530985, 0.9979753862175544, 0.4353231525969522, 1.3819469863301221},
    {-2.400022088836707, 2.0285411978867525, -2.515797054222325, -2.96767759131123, 2.4334961550580774, 1.4819172827338505, 1.1945098940110068, 1.1516557193082229, 1.092908088577492, 1.1659683076821963, 0.1649655727504714, -0.7512884942328544, 2.458114568135493, 1.2934991503171376, -3.207922704486256, 1.2237215032241564, 2.4539305565805547, -0.1470127906188076, -1.4421709220927303, 1.2650364650966968, 0.01482330220938409, -2.2770979109736156, -1.4160211866436099, -2.521875570539444, -0.5329132418017273, -1.554721585903298, 2.166590697527106, 1.984655099630424, -1.353021839522227, -2.1230119523997617, 1.9739016607267208, -2.711582368467178},
    {-0.09774261007002318, -0.04759123093641694, -0.67006147809615, 0.5088904525184836, 0.367257150239458, -0.6702455029450194, 1.9311508797581787, -0.5410912925669233, -0.12593362593428906, 0.42811406517628264, 1.4145135420322368, 0.6335863769519875, -1.3488514403501177, -1.7015476232486255, 0.1809067441982181, -0.44884101177055735, -0.8972063404814926, 0.491429208365777, 0.5988503301759328, 1.7051057301534085, 1.2502462187455656, 0.35696947241517635, 0.6130125955338258, 0.6412295983561856, -0.07455328162970373, 1.2183678591918872, 1.5267747854531932, 1.5612636542500555, -1.4091788079290888, 0.36323492222396536, 0.2826529354318082, 1.842456804041431},
    {0.034857021086392326, 1.9944636060402947, -0.6027168770567239, 1.5766596682954812, 0.48368198237905696, 0.8060023943737926, 1.4038462275654904, 0.14782956471012398, -1.528419141294531, 0.9220470774126506, 0.9729354606460564, -0.64312785538408, -1.186127930000931, 0.07491518503943147, 0.5837507352241896, 1.471013062260382, 1.7517091742300266, -0.10567074220905007, -0.41842345416558174, 0.8256278569525003, 0.18049454771100745, 0.551309534806326, 0.5173790949521481, 0.35159798195528547, -0.5394031508756388, 0.7263469637365095, 0.7426311574744567, 0.11889618351147549, -0.07143414903382649, 0.9313627542522273, 0.5446240440458177, 0.42797740709012083},
    {-1.6915130352080152, 1.4517011827846873, -1.238856105122588, -0.5685539827380213, 0.7194011765172137, 0.7471531483428137, 2.765391326403663, 1.6733323141902061, 0.7145678766412368, 1.4967972302828432, -0.6084774687067278, -0.6380120244355819, -0.612580680126996, -1.2187236182619063, -1.3412091327234894, 1.376025903709787, 2.791902552515891, 1.0291233653597185, -2.537111261361179, 1.8853450620505012, 2.027436660375224, -3.2794383274267322, -1.9468546296310016, -2.0627673814129013, 0.023828479050691576, -2.3613962603569525, 2.0910460264370028, 1.935603418871902, -1.0149397125613393, -1.3303060323699036, 2.0864106946981327, -1.5903628409166979},
    {-0.22685858655562435, 0.5124188574112999, -0.04880223621934116, 0.6652924299506328, 0.594664321312533, -0.06179865150440365, 0.8273064549966636, -0.9945397396020211, -0.6755768010082238, 0.9710347740534095, -1.217871874127338, 0.7316981059906725, -0.6257913285055458, -1.1127048821503656, 0.7374147923778437, -0.2978376459807404, -1.0498723422850564, -0.4443872917890469, -0.6825189806734865, -0.3795544683516665, -0.8127125263635868, 0.277177570458973, 0.7397286871000676, 0.044114873850364736, 0.23308453781804067, 0.5684122621180542, -0.26367068036663505, 0.06802890744959764, -1.8406109626738976, -0.9078456138684099, 1.3685974815613666, 0.8458373623744613},
    {0.5186628055059448, 0.6914253066006869, 0.5949724367279159, 1.6529132114560892, -1.166744595941215, -0.21269289069872802, 1.1052601007429779, -1.505510545968637, -0.9509287791347676, -0.02431773826665857, 0.3055736572570304, 0.0076122808424775095, -1.7907619577755682, -0.2937287408806939, -0.18848839382563343, -1.0100088892846428, -0.7996389905820549, -2.240268007891998, -0.17516164071752177, -0.02983950380910613, -0.7970686934807404, 0.884248912724247, 0.9759286658140512, 1.1849078769874009, 1.316377240524114, 0.08120457872167842, -1.142654653188913, -1.0505417481258243, -1.4742777743320818, 1.2940228219628376, 0.4782096951980915, 1.458991770124022},
    {0.7476614984473821, 0.6677026521450732, 0.3789114523212459, 0.42397383745588546, -0.9091182621466501, 0.4819098030478512, 1.2373260727411117, -1.8115745886744137, -2.183846753977001, -0.447471578210119, 2.6570817690219064, 1.194819784203727, -2.319977827694614, -1.2629735932382373, 0.5715395473856871, -0.15757405855312986, 0.5317937179068685, -2.6096311970602053, -0.5024154939216211, -1.8025636770019486, -1.9654953487386204, -0.22827682407179478, 0.8846981223952157, 1.59814684725821, -0.22925168761629647, 1.3146570228357748, -0.3626728406552399, -1.7515342692292544, -0.7617040501567988, 0.44443566166702514, 0.03301561199454354, 1.2041223321862313},
    {1.7853932295161006, 0.521101423140448, 1.6533516889424993, 1.7455680024200584, -1.9453795396884326, -1.4229270578840656, -0.24233623725391398, -1.551209294884999, -1.1520868606594488, -0.5263708751631282, 1.358903799779587, 2.0633858995050556, -1.7963566211969035, -0.3834052952964164, 1.2940974612630807, -0.954076468194363, -0.9297285581051874, -0.869783580498018, 0.8148888829039791, -1.733303092541326, -2.461202438904981, 1.733440414044101, 1.3299690034332343, 1.2615847930025634, 1.2759499002413308, 1.6268582866389385, -1.0934332503824828, -1.42691288925972, -0.5864476417512128, 1.6654978586864173, -0.6771393852390485, 2.29196967496059},
    {1.2897701620331827, 0.39310724994434215, 0.8018132342409886, 0.2843487822844681, -0.054141076963394874, 0.7761672588687414, 1.7941154515637474, 0.10641921804894056, -0.87445022198915, 1.301298318703673, 0.7390574389338022, 1.6589760483767042, -0.46063105690127515, -0.09243990288804176, 1.1027623413073406, 0.4590487223295219, 0.5910333684413627, -1.7710526824703625, -0.37100024009459553, -1.6077848472271448, -1.1952498290118718, 0.32430787545463036, 1.5098410576014127, 1.660886753367017, 2.0357277245795675, 1.371499286964273, -0.1195042746281402, -1.3950996291081557, 0.7585023588356975, 0.6244846261969937, 2.1888978016905165, 1.287347345589674},
    {-0.26399219447109273, 1.7528551242021402, 0.005639166657936965, 0.9498947651512317, 0.7969856423812318, 1.8474832462891528, 0.05706624763358849, 0.381010359505553, 0.33014515391400334, 1.1203377350155495, 1.9233101220271862, -0.2357361220850191, -0.44113855967412774, 1.2729272236275828, -0.5636457288069576, 0.9928280069971027, 1.9478610032848842, -1.205963579244665, 0.04067750644376233, -0.010758816425600547, -1.6538550859394954, 0.5039445972707005, -0.20232023629933396, 1.4855410384831134, 1.3527469109821022, -0.5036669241430605, 0.1089189782335826, -1.2704048409775999, 1.1209271169887034, 0.5443835760496412, 1.2917566562457667, 0.5523289141020546},
    {-1.0522261302271974, -0.33236689931090024, 0.12040888511782052, -1.6137169343038935, 0.6804674483304404, 0.8901896517487535, 0.3486404030110899, 0.9273821009750611, -0.5890310660486728, 0.9203174296802152, 1.2066279091202758, -1.5195582588283065, 0.6217729290414642, -1.00557559768211, -1.6608950621878398, 0.5833726317848632, 0.42635839246659285, -0.08927163186697111, 0.33209663173366666, 0.21990591858538477, -0.1339159242752752, -0.9143095821481954, -0.011686570436445663, 0.6503296585539037, -1.1922950427608814, -0.33230183900159804, 0.8638407043101469, 1.0479438109552355, 0.15685014228553246, -0.057331958082453595, 0.5230246001554333, 0.20921781908599674},
    {-0.2953986111998282, 0.4145362943504708, -0.616005317426354, -1.3535858210336147, 0.3603748106407524, 0.7068257596269625, 0.30854723288774166, -0.056621474078311536, -0.6080413816601987, 0.7013458999456644, 0.14546476869622552, -0.6486712206666689, -0.5057348131060765, -2.360498044046541, -0.002574442365214842, -0.22828619609293513, 0.17897509650224436, 1.0500721000875564, 0.3095731897842938, -0.40386263769920483, 1.4343685551342136, -1.9385597670657044, -1.9028218837504014, -0.6528367520997999, -1.3389183816896446, 0.07062737134105718, 0.6963868821702729, 0.7541613472810264, -0.7120471982172866, -0.5518495225623504, 0.8580119279774578, -0.500640727312427},
    {-1.1763323212450087, 0.9202541928510972, -1.4770934448897899, -1.3397308393541707, 0.42442084175871075, 1.0628841237888007, 0.19990131795745497, 0.09295024926716558, 0.6654668149184592, 0.7151770541899785, 0.5720869427267042, -0.4327053736767764, 0.9519059959322741, 0.30331395859605115, -1.1384536017650226, 0.9196053293575797, 0.4769795738838137, 1.0152572618336044, -0.18304586438547443, 0.5040954816413259, -0.30147610896455285, -1.1464467566573997, -0.7535513640435413, -0.5800860809342241, -0.42007717150811086, -0.5932003049553467, 1.3173993074974524, 0.31987270506809995, 0.02355276969368719, -1.1151076234695285, 2.526605810330921, -1.3909029946733797},
    {0.11003761372986058, 0.9027530136619352, 0.37325282691203654, 1.0137569472976975, 1.1433740444437113, 0.9522072679133733, 1.2319313614943583, 0.9680349667114103, -0.10091196346206713, 0.5418008641067512, -1.5467357998250215, 0.1284565481907851, -0.20759778669323084, -0.5556322658538695, 0.23529701034578954, 0.48584857004991633, 1.7352103578846327, -0.1107954934898432, -0.7086113983176433, 0.889118130790685, 0.19281853091605275, 0.3790129917044845, -1.2053372425814244, -0.9749503045115777, 0.5169931468327635, -1.8025161783350063, -0.7504423937366359, -0.5034646284450774, -0.3378671181337774, 0.4802743317766017, 0.04441283260269397, -0.6836571642364567},
    {-0.2937372315513346, 0.6767219022261786, -0.837915929472639, -1.9248065960470808, 1.2574032691275328, 0.09639628985113875, 0.2037806624831651, 0.2645319193504396, 1.3572121320512907, 0.4279906362912118, 0.1946461684516178, 0.1797585176726979, 0.9912895575125507, -0.9708223496066404, -1.6172842733981947, 0.3442342858281831, 1.1775770405616592, 1.3368457801616245, -0.7945840826358646, 1.7560836122077341, 2.2940910662493113, 0.09089848727549309, -0.857766753061368, -0.10421625683976032, -1.5371111748371222, -1.511750635316044, 2.2314521167999954, 2.6281899840416405, -1.6551837542677477, -1.0228748995918162, 2.0992419539488374, -1.2278702548048366},
    {0.1225173263799765, 1.2234757130580192, 0.14806856642774807, -0.6488287187539465, 1.6584131305637377, 1.498358873493, 0.4948758865281522, 0.8206265188636656, 0.5844091506431552, 0.78605544131437, -0.7197048312003579, -0.5842743189331153, 1.2203368957376663, -0.4163788515637127, -0.6598350178491231, 1.9139880062788646, 0.39730967630222586, 1.8053589906469336, -0.32554758398545636, 0.2481690019665462, 2.6292941780904764, -0.45311844190837913, -0.7022910704611323, -1.5198372476875504, -1.4682280043381581, -0.8243252742714855, 1.5423087564083926, 0.6746022187991775, -0.058143098573257404, -0.3772518315837031, 2.813954736975825, -0.06416039738606653},
    {-1.456772032543385, 2.732974316300867, -1.4057693465146524, -0.6765778940876094, 2.2794739383768157, 1.7992378220649288, 1.8596632988009925, 2.8035254102105216, 1.735915737576165, 2.290949984466449, -0.5172717238218626, -0.3501460880545717, 2.1427044274569536, 1.2158099762726355, -1.386813675761702, 2.2145692040109366, 3.1605501103992713, 2.113556680649479, -1.2772721957424957, 2.200116180340569, 2.6109532047282538, -0.3726669963187942, -0.17997959309613387, -1.624483766374409, -0.582814140772199, -1.2572528301461845, 2.984721660129577, 2.777005311091139, -0.06812623832112029, -1.0723731642080314, 3.0288278917333544, -1.061850904088902},
    {-1.8769541910848457, 2.4766484928264783, -0.8845690052406744, -0.6090737175370317, 2.3725997353148642, 1.649562363597646, 0.7018396014376879, 1.7580951855067577, 1.7158658106922506, 1.5201187615965521, 0.675918516004568, 0.19800178467216167, 1.5030682784839882, 2.318883109295586, -0.9913711765444602, 1.8866022985158584, 2.739908318815014, 0.8792604571431051, -0.2860697831529708, 1.7805751710639826, 0.5906738582521173, -1.6372685925951216, -0.755094422781848, -0.7800192620327906, -0.6651442003096931, -1.3333193420221296, 1.4265001140852793, 2.6359028210747306, -0.6533888691290536, -1.7466289957666765, 2.4638506617761484, -2.233454205941481},
    {0.2381256057997276, -0.5396300664634208, 0.06286835009647446, 0.8113167075181253, -0.8809058759654886, -0.3916413190827891, 0.5466723288763908, -0.9637479988855967, 1.0065034692210846, 0.7307970719342548, -1.2622304891498217, -0.3385644429348685, -0.46789495831265693, 1.4146521252563369, 0.7266466854331484, -1.1705849873533845, -0.7217359790344793, -1.4917614505581098, 0.5055910733324404, -0.8786624689143436, -0.9804245124052868, 0.8327745172724315, 0.7275799973493966, -0.3975003036109553, 0.3359472096221908, 1.6771640064446918, -1.602025513263342, -1.0815419453325903, 0.5745525712681875, 0.37748969219007034, 0.15662254190996444, -0.4271083682387879},
    {0.10450371974225857, -0.13411322017961794, -0.5639287182905995, -0.5271758717672239, -0.2229168442538458, 0.5090437093772412, 0.16757891691794377, -0.6284399738546712, -0.45492709562060857, -0.2232419322625568, 0.3201137250410573, 0.6461568741120296, -0.6741330362565314, -1.0691163933194514, 1.6917566665103585, 0.3496446292380378, -0.40678442601033005, -0.2592685617067186, 0.48479980331331113, -0.4792816535773861, -0.8065156791784311, 0.2470296708463371, 1.7811479848544174, 0.82009396476977, -0.4469473256593613, 0.9868556033725722, -0.8245427321817541, -0.6033898890010854, 0.45076295361967605, 0.5919460970273587, -0.25890271512544955, 0.304014823784702},
    {0.6867872363555735, 0.861692837002043, 0.1930938649672984, -0.4565438121310394, 0.8361676181428722, 0.036033838471478966, 0.06158229750023589, 0.06384525498036003, 0.7838563985540898, -0.2362348511783137, 1.6960668869329065, 0.06440379024621493, -0.4708306046247308, 0.35574678732661824, -0.18988210093973043, -0.11005051859134274, 0.23272369852608935, 0.9234217322348969, -0.04741765832563682, 0.9740458049440396, 0.34473203339262004, 0.269862005611495, 0.31856590517900346, 0.15419749686524498, -0.2959325058291618, -0.28006954340491635, 0.6465680344084568, 0.46498409280354436, -0.17195338262069124, 0.2956417233177289, -0.36744229905607595, 0.5112333028500294},
    {-0.6327023540414116, 0.7404779005207838, 0.46154260614645415, 0.10972171418086721, 0.956840621088052, 0.6549535198251565, -0.14772701997379997, 0.5524302492005667, 0.8150264750472541, 0.11491471468271165, 0.6923942908886221, -0.2252410941107081, 1.0114072119138868, 0.9479601683376444, -1.324867812791003, 1.3071042834669797, 0.22619865222785557, 0.7790369402778988, 0.2531941933136366, 1.1048049647917093, 0.29737083297755623, -0.47981293675665593, 0.19728651392374108, -0.6445305768088807, -0.06934025014767754, -0.972070980538757, 1.1170646718789587, 0.9125989289746806, -0.2859641580521733, -0.8791067940010268, 0.5120457052771498, -0.218856729736699},
    {-0.5065979673882268, 0.46313756215175667, -0.19394244557204013, 0.13254470242691804, 0.3098793542149259, -0.23393224785405697, -0.9224877852282362, 0.6025004369540103, -0.7635275549680244, -0.31508881557895424, 0.11381556596715266, -0.24217564224011295, 1.0718440724392522, -0.39713805084255116, -1.6472882447190182, 0.21763951397250966, 0.9968270892348959, 0.4430800101432305, 0.053190372463680136, 0.9443754999472171, -0.06315382594699458, -0.21940365747753884, 0.02100354819935765, 0.2297633394835748, 0.5649584102931291, -0.9642303890914344, 0.9724225662982495, 1.1441782220353294, -0.13620763693509855, -0.9146175840284672, 0.4542156874859887, -0.10240854574174119},
    {-0.5871984410024512, 0.5068912060385995, 0.11609008224025473, 0.7503070019294925, 0.10387922276888364, -0.07585113570720457, 0.410887005611708, 1.336152682450995, -1.005539861967485, -0.4279131715112451, -0.0006709108234565818, -1.152187040113708, -0.13231859481712302, -0.9684796437973006, -0.9447545784938083, 0.2601207681366127, 1.1979723526854247, 0.7319487277306276, -0.19907895932285052, 0.433164620825738, 0.4156747782765853, -0.6935895930592616, -0.9432704746627746, 0.610938322823355, 0.6169716873429122, -0.533452723317029, 0.6363653910250734, 1.1416039358630135, 0.7996531517848688, 0.009965154816087498, -0.47207075592730713, 0.5509799974713393},
    {0.20016832027280074, 0.10530756625681488, 0.36716462810219574, 1.6429844487659482, 0.6185580736212027, 0.13540148420552522, 0.7151251946841138, 0.2788052459989848, 0.0044014129501537035, 0.21473859746014587, 0.5064149823618398, 0.5876549486831351, -0.7221936202180398, 0.17151908986938855, 0.25978516237547256, 0.08622348136587948, 0.48710293553775197, -0.37465990731329857, -0.5752521636888104, 0.11388079768613879, 0.9594788194637359, 0.20066429521004903, -0.5450080041257724, 0.8261799785451371, 0.9638710866780789, 0.11257534612080584, -0.40337430941879665, 0.5803532246072798, 0.6261790243946425, -0.035258538022967155, -0.06116646851357873, 0.6661839499511952},
    {0.1506408079660093, -1.1171317450690814, -0.1472720527293927, 1.211368944721065, -0.0882408366817589, -1.726720195659552, -0.8722379198976752, -0.7783779978886325, -0.18422808570677585, -0.9899702510730253, 0.3377255862981438, 0.058641358965174896, -1.1801162146044866, 0.4523772550122251, -0.2261943706850953, -0.9988120414426981, -0.39726992084381296, -0.6694582521801297, -0.7565596087702235, -0.519888053412488, 0.09094086961508133, 0.1950438940969901, 0.20655563307620206, 0.0035548274080640387, -0.014081988992415336, -0.451812300006071, -0.5718765862061445, -0.8484268860126288, -0.942701439859502, 0.26292732795128365, 0.35081418382802904, -0.4646595363435688},
    {0.26659600340844786, -0.5663617663833889, 0.18765874208280436, -0.15151971707273093, -0.39897744874825347, -0.8760828904930877, -0.7168034501466246, -0.5663314740206722, -0.3285764333576293, -0.2657991758401387, -0.18498890528781614, -0.6131141367684949, -0.31707299763372, -0.5031028690395648, -1.4058539824779166, -0.9433353278160267, -0.2276842465679626, -0.3276666965906835, -0.018015487005282722, -0.14203294482818005, 0.8378051342327721, 0.12362722822969387, -0.17952399411216824, 0.4578254788436176, 0.45166157547748825, -0.1774574208136794, 0.49029284325746086, 0.3666781014784938, -0.2745538034616367, -0.0993873159287645, -0.48711664672750865, -0.5888713473474143},
    {0.9687259226564834, 0.015335536702354128, 0.07448032195233018, -0.7268247880912593, -1.0400970099383997, -0.9473733486795811, -0.4773093493458832, -0.1738972757199307, -0.6073342712465621, -0.9229040339976015, 0.8612727163514092, 0.20914409527650923, -0.14808628940569157, -1.1624049898918951, 0.008414168476469055, 0.00014617060622578004, -0.4157616824216469, -0.3917518864903961, 0.5848108355531378, 0.1871402683421902, 0.9800013901251968, 0.7206304235921197, 0.07534253848650656, 0.24329651833226132, -1.0649954059851763, 0.9355899110706838, 0.9494540067677821, 0.4371734178847557, -0.6913050946876262, -0.32139065387266064, -1.882904919283962, 1.1129583085809094},
    {1.1603694186410187, 0.5168442939540556, 0.1324993899390511, -0.682141841904487, -0.8950250443334845, -0.906810315703631, -0.84843668227903, -0.16217233335575804, -0.3210327678586298, -0.565090105570343, 0.5416513492421282, 0.3561835062061059, -0.2655211667979735, -0.5533327239091452, 0.48966625116463863, 0.11882325858226138, -0.4112414293081259, -1.0043519441171616, -0.17095888000000906, 0.08622826232471681, -0.5778519643074853, 0.7489502164055296, 0.9005720403969497, 0.5183438288726782, 0.08094522570400055, 0.5231933631740318, -0.28454900611678663, -0.4292354937636735, -0.4272001323027616, -0.024138268664353296, -0.5938559862022446, 1.2940196355777043},
    {0.33624314752593526, 0.6923360646348543, -0.03031566296706796, -0.2627388777633076, -0.6863715980553392, 0.41458635785550024, -0.3781260208969803, 0.36720005696812213, -0.6453041543514875, -0.007427171664166259, -0.38552166416185746, 0.18827506010433692, -0.21297035744265444, -0.9416901264873803, 1.171932542365778, 0.48803507029217863, 0.49515257465576035, -0.5567565453817445, -0.5126285807680436, 0.3964403771713196, -0.381553903398961, -0.42754475760249105, 0.05067794149652267, 0.15288956963566647, -0.05283336768995633, -0.3518662374254838, 0.14449330138650535, -0.06355782926572891, 0.41874416658386776, 0.13620302171727808, 1.2668007988480972, 1.06705537113654},
    {-0.3958689209024874, -0.0002765475880406281, -0.2574172566059896, -0.5692053145855446, -0.3661696615263302, -0.05235017509755414, 0.490918119276696, 0.33458796611963987, 0.2650635834843016, 0.2520651332445423, -1.3093251555530583, 0.5863715855616132, 0.5190889136159121, -1.329333230339801, 0.25067886752901225, 0.46743046583858705, -0.4484199991173595, 1.4005314831483735, -0.25312068530923043, 0.16061024612207858, -0.5825681308399094, -0.513013700894533, -0.4703016220354194, -0.14263206102430143, -0.6175390739969295, -0.8310937117470205, 0.6915279146684706, 0.4146796836612666, 0.039432379786700805, 0.7286679566106798, 0.4085953144784852, -0.24780750344747107},
    {0.04614960817831701, -0.6233006191607694, 0.23870061972351758, 0.38258342327408457, 0.6522729173941657, -0.09882866107474737, -0.2556535932052031, 0.1746474453228168, 0.567085502387701, -0.6325131536991692, 0.5327494138941061, 0.9877806346252413, -0.4547277687821363, 0.4935328241025618, 0.8534201534819452, -0.05857165551441386, -0.21205943814399428, 0.6724956989640322, 0.6147188849216393, -0.38170721263094365, -1.1080398619006055, 0.10072989532756957, 0.448039361168933, 0.6474310883822998, -0.6281446607813972, 0.1906844979567995, 0.44602006908919606, -0.02023509238169281, -0.21576955095932288, 1.2502779150028154, -0.5922946390189312, -0.1055271740523306},
    {0.7706295530587502, -0.1231804253982792, 0.5880456874434355, 0.5049530175974248, -0.2508108343674854, 0.8898945669981299, 0.46004311501051376, 0.16384477252743762, -0.34886645851051173, -0.27479373243808386, 1.1253031561926707, -0.19258489090431766, -0.42084850807286067, 1.288977218183107, 0.6513577246392638, -0.1940438463400834, -0.022737842804845934, -0.6360790174302247, 0.8352612770455329, -1.0149003871419513, 0.1287475833470425, 0.7268416119062184, 0.6432884716557916, 0.19871060303827529, 0.07229287512211248, 0.12857654001893645, -0.7030275672615213, -1.178785272609517, 0.16173762281300463, 0.2266067435298952, 0.2914470575274557, -0.4627902057727719},
    {-0.06920378408259208, -0.022459210661245618, 0.010138749151901027, 0.46588643852483286, 0.40157521146949526, 0.32516249460814123, 1.1045791856119165, -0.680497997351541, 0.28511258891026353, -0.24116556549650126, 1.14433558930558, -0.1659995993229366, -0.1569548159777254, 1.188775710052007, 0.0790374845708048, 0.05077612854141435, 0.4918043291779348, -0.36470486779779865, 0.5178315644382958, 0.5602620625032257, 0.5188150284823837, 0.08760174891123278, 0.14677585068153187, -0.08879289662356353, 0.29484158949666356, 0.6771521523256291, -0.3929467925950908, -0.28828419096029884, 0.7081692633582679, 0.7448888264796824, 0.658259327638237, 0.5476110496846238},
    {-0.29050961599080716, 0.16205437160167033, -1.1377927869663271, -0.5966048192287653, -0.5222174984105981, -0.07042376184751717, 0.10413863774098936, 0.25748707732967835, -0.04432964852437056, 0.1834887599791225, -0.8147294716076974, -0.6001052156773126, 0.04947085083303326, 0.7420308122235647, 0.5241187371235588, 0.7753636290212857, 0.21880458741576142, 0.3149294031583378, 0.04323279763563384, -0.471969438615795, 0.40302740279038374, 0.292257102829804, -1.14970164473544, -0.5954810233450407, 0.06665780072321043, 0.10492617685145239, 0.2138948762523919, -0.9523485849076196, 0.0980431794169682, 0.8487982500224807, 0.9118924426507036, -0.8239147878411456},
    {-1.087650593994733, 0.24271097636016392, -1.3099847497509935, -1.6087150288602583, 0.5038945926276927, 0.8668100887089972, 0.30948931934354534, 0.9429645558443411, -0.013526009036162913, 0.5546670368872535, -1.445832508768061, -0.07849127389144188, 0.9839103152747579, 0.3492261553066861, -0.16394537548896132, 0.8410054705809265, 0.5326462278921678, 0.4716556098945407, -1.0446132947596953, -0.8813724501638619, 0.5802584324427177, 0.08568605278863654, -0.9755563128621842, -0.5852801974560897, -0.5922938683039015, -0.8398833198536032, 0.9441758904617412, -0.0845155807268341, -0.07026315470065807, -0.7662546728868581, -0.07715290171448892, -1.260520597582055},
    {0.6581134294245197, 0.7707324134914137, -0.1219486692491091, 0.2540870443486966, 0.5262362797126302, 0.16115705814569634, 0.5801676695278005, -0.04977998648896936, -0.2667348465640887, 0.9434380730420029, 0.22146743390962595, 0.6609536201008209, 0.8901518225056652, -0.35936890152135853, 0.38176163258126905, 0.08295676924848237, 0.7888818244959843, 0.01584807906341327, -0.6844075173832773, -0.1373487201386222, 0.20288475636424722, 0.17510963156454398, -0.06678561350176311, -0.04875256066523085, 0.6299655710095966, 0.748157244648143, 0.45302736812813116, -0.0672521356029166, 0.76017286842557, 0.2201704021004407, -0.8490913929215921, 0.7024595048493515},
    {-0.2569911970916729, -0.19561558380240637, 0.47178053242444046, 0.5338432188534185, 0.04633673446740416, -0.9670786935047593, 0.5113035993393347, 0.15849525471833312, -0.04054101473637813, -0.9002220021406536, 1.1801328924321892, -0.12179424644166609, -0.6324450233353699, 0.14690257107425478, -1.311143456536128, -0.7351613147935615, 0.5914228178234469, 0.7384868280654243, -0.12639443993912886, 1.3491928456652753, 0.05203773185190145, -0.05893697547350881, -0.3385843446674456, 0.825286959555848, -0.41890836956421024, -0.21899819384612598, 0.9688177918988929, 0.7572262365296407, -0.5889543572074531, -0.18443433589794922, 0.6610284625123479, 0.6185614183273656},
    {0.2782225488086804, -0.44436703884322437, 0.7087374098509491, 0.44212555434138084, -0.560689200636073, -1.1258027126624155, -0.8172562591680723, -0.6777583883615023, -0.5458330645648424, -1.3099071997707512, 1.253454459742918, -0.34831007730130087, -0.8231815404241464, -0.7783731205523535, -1.115535465168136, -1.4556937188598564, -1.1836950478437154, 0.07559649290036559, 0.7285408807365804, -0.4868028819463014, -0.3129047988756252, 0.7028318223106264, 0.3779489881181311, -0.21141378954207862, 0.37121891695316345, -0.17139199719622664, -0.5066532291256082, 0.3129970115000713, -0.9172583738781047, -0.22331274775612162, -0.2021968032820023, 0.67987991310972},
    {0.21560012947155185, -0.24493582993203805, 0.7426374882323321, -0.06422522095459396, -0.6082715758484175, -0.4940234468916708, -0.9400598518545694, -0.2856584023272195, -0.3877234422072457, 0.008955845368159703, -0.367818809079869, -0.6676619311483253, -0.04448856982831918, 0.21375393278353796, -0.9403298481978445, -0.8202024540793944, -0.13606571005051887, -0.40847593568121665, 1.0535731828789199, -1.190521396990033, -0.4062730224172403, 0.41382254202458374, 0.31986486159327915, -0.4519851509571569, -0.014784935722810928, -0.2990012677795122, -1.2847066903709672, -0.6725974238145405, -0.06127864772154831, 0.224221940865498, -1.06438346972101, 0.0059554952999648116},
    {-0.4924613201469011, 0.12354710242583955, 0.2292755700317719, -0.6830443111161149, 0.5368824999868583, 1.2856165247996794, 0.04973888077538529, 0.695916514553499, 0.2583231732903845, 0.2058749322059673, -1.1781832032583235, 0.01733509697163463, -0.3635364603440342, -0.0009746816373368274, -0.43920753211122154, 0.263562053025755, 0.8675177292765284, 0.4760846628319113, -0.28468561025607025, 0.12495104528384442, -0.2633751929014531, -0.7842519513505676, -0.34785917904575725, -0.49440417224564853, -0.26232815705913315, -1.0677353146781432, 0.800801825901442, 0.38562821595332625, 0.06282406226722663, -0.11454679794730403, 0.29120514757928473, -0.1807479320966299},
    {-0.16475298491219498, 0.022304116438348735, 0.06762514100899385, -0.057595253241588665, -0.40649251138431636, 0.4732681301347881, -0.43295990435477866, 0.5425722957558369, 0.23708837135920258, 0.13746060044007663, -1.0444808889236497, 0.8061887857005737, -0.4876796302746065, 1.0302364179657164, 0.3003812921404892, 0.64672362074771, -0.4489831815430814, -0.08983469317295, 0.4987262822277252, -0.4995183247728655, -0.45158710514586237, 0.40358425356465083, -0.5071798469752206, 0.3449991362042698, 0.9791805556836878, -0.6593715795297048, -0.7867345848553141, -0.6686786947529646, 0.9408959648392993, 1.1474400189179834, 0.2578627579334797, -1.2208743434780327},
    {-0.8000153601739051, 0.40103969550208174, -0.7430580944411509, -0.9067295212351374, -0.11427267936518234, 0.07661119429530824, -0.9301453907305064, -0.2110953600873185, -0.8944797832253815, 0.09117254192488251, -0.07637530057726262, -0.9817275039883052, -0.9544101528105325, 0.5438921224773687, -0.7247405938669303, -0.05279991612284155, -0.00983346143596187, -0.8146974043238047, -0.19562041365040536, -1.6698747277532313, -1.134130851973911, -1.4212055569196254, -0.9395483467988452, 0.3569315369790801, -0.5509989913649744, -0.48231351358898916, -1.5891078089008728, -0.9655672953770038, 0.10912031938316336, -0.44617817907536145, -0.6675354820671813, -0.29693351466029544},
    {-0.512399753442381, 0.7436639665048609, 0.2806943961769283, -0.5942262249753281, -0.5663169875976599, -0.763500519174101, 0.5188093293271497, -0.049283307567294495, -0.6312073688260171, -0.49681716470049286, 0.2148255330630454, -1.247479069874073, 0.7857830036524307, -0.731606716404754, -0.1730019839603059, -1.1457986308394412, 0.22302277807916265, -0.39372565100624757, -0.19246574335162045, -0.08302100465736174, 0.4099842091686891, -0.4810546975441809, -0.5192041939231881, -0.8304183530988714, 0.20778289709624323, 0.20511329617697824, 0.26257096429799154, 0.311963044218932, -0.3444024468844685, 0.06097518068655344, -1.024913719788994, -0.017467568010708725},
    {-0.40051788755892315, 0.044580403490254474, -0.6247640322340005, 0.7418827502666829, 0.5889629058279153, -0.7763616370568449, -0.4558646990361222, 0.29520153447219716, -0.45187200739824485, -0.6076966603148721, 0.3150062717645508, -1.1090451380748345, -0.546846042741167, 0.1607824158168054, -0.15535134165289877, -0.2806401949041038, -0.08573373728496886, -0.627010611656153, -1.1883678292287223, 0.34803106399500744, 0.1594818574971359, -0.3728968242502358, -0.05989309691789533, -0.16716484253631683, -0.3023029187381972, 0.6419565400112955, 0.9434321005456605, -0.09001897307752825, -1.6978142373913234, -1.1145563929848465, -0.0860131846438805, 0.2677086342048399},
    {-0.07285733852791747, 0.04391925644623216, -0.3872327524718618, 0.5112975362104598, 0.4628080106603264, 0.19467725384319426, -0.13413292391164222, 0.006990704803330911, 0.42092615585226545, -0.1545488948071927, 0.7816792338886034, 0.5785258719581268, 0.2869368253840901, -0.7496962554016485, 0.07418601028526844, 0.7642874328529131, 0.02563506972277134, 1.0194355679020772, -0.08959849562053432, 0.0007298570026337096, 0.03444415335773997, -0.04331101224651094, -0.08346813466845492, -0.05166183357166062, -0.7658967846213908, -0.8799263799639435, 0.5452396423798486, 0.42744550426117495, -0.057234693128016614, -0.5892974213719373, 0.3530022805923408, -0.5338857719078058},
    {0.5361732759457627, -1.5783775788219532, 0.07314206033678501, -0.9857144302538752, -1.9832860348358199, -1.5120469969885648, -0.19855445007199088, -0.8260434773846024, -1.0569670784095884, -0.20864798959625389, -0.24982372481760942, 0.0685011864732776, -1.0978577129576694, -2.1621871773204893, -0.16082140866419686, -1.1180948878569301, -0.2938524820822572, -0.5405554026174827, -0.28302412046435005, 0.4122014487432371, -0.5963517675605067, 0.06666272980180778, -0.9268667691188087, 1.0323270967415652, 0.007871783311313574, -0.029723674588570177, -1.1267396407258643, -0.7601348832315752, -1.2961086596473625, -0.02435963311083865, -1.517985987030869, 0.4499546821136155},
    {0.6409785193698196, -0.003828578819137659, -0.272421478096083, 0.2365218742737232, 0.3899495334506502, 0.15986026913089663, -0.026659209619476373, -0.3746575214982503, -0.7059886176569292, 0.6012719815012911, -0.49026809423201995, 0.537910567896751, 0.2086081655549895, -0.21676085805688755, 0.7393607297104349, 1.0045642548845684, 0.49738625557750366, -0.6011559201320524, -0.8115392425064697, -0.24016880157199555, 0.4029276957538776, -0.15968269489174958, -0.45354447251520397, 0.1603554358710265, -0.5182815925891077, 0.33955519668385525, 0.7305266064368825, -0.22116532232810787, 0.5723650277812985, 0.3256345041290499, 0.7994245439288366, -0.18272163181424408},
    {-6.456943711401899, 1.740929123277557, -5.975049634462978, -6.377591300235925, 2.570686181212052, 0.16644032503373535, -0.2959214224651143, 2.361256951221803, -1.5541476086753625, -0.8666157635088954, -0.8362041466366148, -5.8849753944873315, -0.4132031406776322, -3.8637950534428804, -6.243186274008865, 1.383683556044043, 2.578926464388253, 0.9989371326036216, -6.196539157455198, 2.1943002213066114, 2.0276561747706525, -6.551734534431988, -6.486554185634892, -3.7108985027567862, -4.218532752745209, -6.692225735933709, 2.1621915676745957, 2.032076721390336, -4.591329247543222, -6.379290230750501, -1.5086054434583753, -2.8276947715916454},
    {-6.715507382525893, 2.1994863379623375, -5.803310519393918, -5.791499965244687, 2.28078742354559, 0.15468040640552141, 0.3223674765066451, 2.4769215241451827, -0.00022037857993572555, 0.10343496816796054, -1.906003214601428, -5.660768863097746, 0.5552932992655427, -4.001988051604008, -6.784084988593638, 0.4237068449478511, 3.2805442644686633, 1.1438539783865853, -6.574685412943157, 3.2569140988373655, 2.202380902672158, -6.1356612414783385, -6.506475562598839, -5.729879991429937, -4.506387769380575, -6.635807996136305, 2.9609781097469314, 2.613015967618241, -5.02907004431261, -6.2866763439209805, 1.1277065972686686, -3.759388236987457},
    {-2.4799604145830436, 1.4698801254614802, -2.9580970645237925, -2.8542938609575006, 0.9887833115546034, -0.21127821765362947, 0.38004530226707045, 0.3181642789654843, -1.8726507028047525, -0.7476520246767405, 1.309846027166191, -3.0060445912239477, -2.397672170075261, -3.4213704872799893, -2.5937207931313297, 0.9044705586197457, 1.7327584840540573, 0.05447238988005637, -3.109998226598912, 1.1276899714713482, 0.6278168668519649, -2.2822456176839667, -2.175092391174341, 0.3329873300923228, -3.366335022299924, -1.5579498246674406, 1.5807683787032374, 1.0776793856204872, -3.8845290010626217, -2.789132729889426, -0.02423033231242851, -0.1699300614865492},
    {-0.9602709766333068, 0.43180578515628837, -0.7655099657701532, -0.8146942368917077, 1.8593610229606394, -0.7325083297060815, 1.5415230109094342, 1.3716073004647096, -2.0159971379160067, -1.4903695046672678, 2.4658739590177476, -0.7557930030640441, -2.2251324819972838, -2.299844380969729, -0.7871326850330456, 0.7409188762670228, 0.8146671783276884, 0.17503875729198554, -1.3919217710945302, 1.427622853109957, 1.782103663403955, -0.46439542649835086, -0.9531232585998954, 0.49159613573349703, -2.0801443344044475, -0.8644524273807143, 2.064242505554837, 2.062344979983427, -3.0053205584621634, -2.088567875692204, -0.6602410780313114, 1.3476610265627265},
    {-0.6206552260071645, 1.181887732457977, -1.7069723671844836, -0.6788472968525585, 1.7463512388973637, -0.959817170368498, 1.9754610079616362, 0.9271075806707355, -1.0408427177470716, 0.41537681699072354, 0.7547768369190818, -1.422378734640086, -2.4658165712019553, -2.8263052748205655, -0.5316508980295052, 0.9497456386238897, 1.4639352339633367, 0.9731653623445411, -2.095125512681094, 1.740127076802959, 1.7201519583691225, -2.0844567350591143, -1.3083231889159441, 0.9033707881371518, -1.4305575457775876, -0.5576397917993088, 2.0746717955998095, 2.354642898211468, -1.7419906113118617, -1.02887761942161, -0.6507587829074597, 0.5899730679604505},
    {-2.2838859093342974, 1.8814439324108945, -2.9712697077497836, -2.152156471531275, 2.7001482909960375, -0.10167036971701196, 0.3708892645605179, 1.291068003390693, -0.3441918514707122, -0.5515003194597677, 0.7521672022118101, -2.3876578239183432, -0.7029999953569168, -1.0690828710950782, -1.0374770744547772, 1.108997068417082, 2.4095933134215373, -0.03501919644004765, -3.17204446221367, 0.7743739479805245, 0.5253826286717663, -2.0886653500132235, -1.271007009513798, -1.4452837093429804, -1.5593246733417983, -2.128305207865643, 2.000296548839932, 1.3087369155927535, -1.5722320294467949, -2.7002128090867528, -0.31815555811776264, -1.691987749025387},
    {-0.10462776134522062, 0.7171548688963301, -1.0039656006733144, -1.6641601310417649, 2.1150247743383077, -0.4774814945132017, 0.4297503414578016, 0.36748108534952506, -0.24028767656206093, 0.5589058710430492, 0.6807377748784349, 0.6497409755611314, -0.8570561712536244, -1.7592055570481782, -0.574708152778539, 1.168511232085269, 0.6985270964917659, 2.2418332573348327, -1.5030837589511719, 0.6808387921306757, 0.6639338770358283, -1.101194586499862, -0.6577234888401093, -0.41295736772034597, -2.882070706776293, -0.41200948612341853, 2.9761176957892235, 1.6536404758166456, -1.1796207388170248, -1.2913999544815855, 0.7100709607955045, -0.5475492857883061},
    {-2.500439470166811, 1.6651343813412662, -2.887142072292673, -1.6433611454166424, 2.1422162268602856, 0.7132648626878693, 1.490372975364339, 0.025829832678259893, -0.38951665622223813, 0.36384850767967497, 0.21388197144368754, -0.734520615591935, 0.0870219110354481, -1.3497955247546742, -0.9764840791509194, 1.438362047606978, 0.5515543576914155, 2.2224682001838025, -2.070825419387737, 0.9565298486760851, 0.09227809753324158, -1.9671451514387888, -1.6705405952008137, -1.9734568321535328, -2.3762899398825508, -0.8481531975440918, 1.6469899818268539, 0.7212277695583428, -1.8489105790287461, -2.2440758023921026, 0.3877312844529965, -1.704138988090342},
    {-3.4056642976086735, 2.7207166057978447, -3.611958686026086, -1.9333873870558307, 2.6702628875601686, 0.971859465805766, 1.2327119137318712, 0.9349735661244136, 0.038848426771590366, 1.0397629421761543, 0.7401530146690012, -0.9378891612025725, 0.6419668157415532, -0.8158252987970364, -3.7694040869855923, 1.1878425194229731, 2.5490117759386965, 1.241795484509343, -3.047736003683253, 2.4373688011098733, 0.28457778686427976, -3.0192723884196715, -2.6446845708656417, -2.608312262948021, -0.45644960417770297, -3.392968686424242, 2.335520768153768, 1.0878004277279099, -1.0849915492179996, -3.583821026483875, 1.5056069727021142, -2.3496254132627565},
    {-1.1370999969310314, 0.8576851934545712, -0.037794527235880206, 0.6175415478942666, 0.5925455689342609, -1.334362658059424, 0.9469609452904167, -0.6441749351259447, -0.5310081642955528, -0.549508961972237, 0.3237997138093594, -0.21189013875494458, -0.200092261346262, -0.5703265540366863, -1.6404312181188527, -0.8312330707387662, 0.6990497130953552, -0.03638302943841213, -0.9044031291370631, 1.1846822729715532, -1.0005721667323482, 0.4608504071148616, -0.9564107995234584, -0.3040466536318871, 1.137162072312005, -1.7436483829848621, -0.824457213034397, 1.1939537923364898, -0.4970357802197411, -0.1360729217321176, -0.23926405810104306, 0.389590886100234},
    {-0.836954191431724, -0.09368258294255136, -1.0221871257990507, -0.3310017483191983, -0.41976616576090997, -1.6575428848917964, 0.385395831633878, -0.17736636166487238, 0.4098921146822643, -1.8249272475142333, -0.02108303202004892, -1.5451223359207524, -0.5280693929447948, -1.4628104399997868, -1.7276721074204482, -1.090188540012859, 0.6402886860512782, -0.17243579996713926, -0.5574657321171798, 0.6581217779364815, 1.3571832410713827, -0.1634968669400452, -0.7062391812928777, -1.0567384996147586, -1.0975716525557035, -1.3539036325820082, -0.08701652972214871, 0.6366132214150673, -1.710948884115144, -1.0271373046052894, 1.0463912349279088, 0.11347346607792323},
    {-0.5908671980584035, 0.3943172487256309, 0.4780567375489218, 0.594769975100741, -0.32428232923758143, 0.5729919374501979, 0.6322131727201198, 1.634567043756547, -1.2875334730857373, -0.8199269415369813, 0.8847501547633532, -1.1596267261914281, -0.6019211903818255, -0.049848913883867335, -0.545336210631952, 0.5839013986322409, 1.003760723744544, 0.3549833241272311, 0.7177610135066708, 0.1104608246574676, 1.299580940176233, 0.0335187741727278, -1.7199222162050234, 0.38923294807830155, -1.0048895250868615, -1.946247482252744, 0.989415665850439, 0.5295534237944647, -0.4459346451607879, 0.9885468762234255, 0.04643021538814382, 1.2223586807722306},
    {-2.016381218427883, 1.8407908376773658, -2.4204686237769213, -3.323328637037086, 2.5130848969423574, 1.2882855568879772, 1.2318064791044454, 1.9534827287091319, 1.4686359005386966, 0.4018683351882574, 0.46615105030374493, -0.6550405053491084, 1.6103212324477727, 1.493658266625004, -3.062838656000983, 1.014070237746382, 2.233531591712725, 0.8001237861317493, -1.2805508665687682, 2.046224935940278, 0.6031143593835011, -2.082127551321225, -1.5042339542999041, -1.7881405984905585, -0.524698598552036, -1.542189626085411, 2.504254904214366, 1.7971975409300933, -1.0226994792735031, -1.8830158861231272, 2.0494790685473614, -2.3427711594130183},
    {-0.7927366494516259, -0.3734704614390748, -1.411124246170694, -0.156174201144449, 0.3686605196248326, -1.4615534368666883, 0.7692446228176263, -1.158883772701251, -0.7824230252766765, 0.15174903156154465, 1.3292511335195374, -1.0173454962179025, -1.199360832513378, -1.859930737175105, -1.015886824518403, -0.4497242034979023, -0.8563093638758403, -0.13571506173357623, -0.46119508768913364, 1.552711243691764, 1.1762188370275675, -0.546304882707893, -0.6998208847585816, 0.009426979993379147, -0.2706780174936941, 0.052840384385448705, 1.211770572054389, 0.9749616043465386, -1.2798554195936467, -0.2883424879565852, 0.24374073573766641, 1.3622213280163649},
    {-0.39891991121808373, 1.1877403581051191, -1.4387970539438193, 0.38730791249311863, 0.0954845073467722, 0.6617033912029968, 0.4561640100706921, -0.5428304414158015, -1.27281376883211, 0.4483993362925323, 1.0096798344111722, -1.2298971839701982, -1.1823228018702994, -0.22899803053075365, 0.3193609338810264, 0.2745117634703474, 1.2223366961255662, 0.06374385961521686, -0.7663586395416815, 0.8388069266884434, -0.33569864307310066, -0.0453018870162072, -0.47126526004065744, 0.04064152194230809, -1.1332422087659753, -0.3706794411651119, 0.6579108352825719, -0.8196726285966395, -0.904738475013416, 0.7032786525985371, -0.21385432945195473, -0.3349625584493684},
    {-1.8092076563553063, 1.4053874205831163, -2.0859800867476537, -1.5771364835908661, 0.8901282377338106, 1.464987033558394, 2.5939680418970044, 2.3584789962841275, 1.8758929442554464, 2.037005647479464, -0.5182403597323784, -0.8493837327884021, 0.09781663096828863, -0.43612353036123275, -1.7333858250168774, 1.8181281754264496, 2.6178563774198387, 2.247474950882061, -2.20260889707368, 2.5260499669948775, 2.4107753994115075, -3.264111111103577, -2.6546335700302817, -2.475976404061247, 0.1711740838208062, -2.650905145741497, 2.460985301002227, 2.3006399400296953, -0.40194821268672604, -1.1994843420699681, 2.236452939611287, -1.9818291108540835},
    {-1.700679153256985, 0.019544488314004287, -1.6784998991682396, -0.6840767356295437, 0.02242641070193362, -0.4632178790536556, -0.32778138460667255, -1.27587900638129, -1.0894880628578898, 0.12688531744633388, -2.324854030441536, -1.4442166912592564, -1.3848405890560769, -1.4959845740882938, -0.7173106647893299, -1.3712444726499688, -1.1692964103007266, -0.732641154457568, -1.7202443984662321, -0.4121092230206269, -1.186251382252926, -1.2036951129729998, -1.3134474299422496, -0.8699290902865277, -1.127618406057537, -0.6571433334323395, -0.5907588364160673, -0.6926229531622857, -2.052422712878229, -1.8738040174538835, 0.24941680625703797, -0.28800760725232577},
    {-0.06443112168487897, 0.062043902221776526, -0.4107779395217302, 0.04810082792722263, -1.3424042149679092, -0.8512140414857186, 0.25862549666368073, -1.6137695526617157, 0.13100323133364083, -0.7720720465331251, 0.5458088068172716, -1.4576273842153173, -1.700529173152239, -1.1023595310254743, -0.7488492943496077, -1.709898095559151, -0.9432502951871158, -1.5567802580936567, -0.46683079987416093, 0.8119689512535239, -0.0178478753311459, 0.09494243408973801, -0.13652972069456445, 0.10393275707071549, -0.01039040937223069, -0.6226168903656721, -0.14769028395033898, 0.3848985048949872, -2.166171799123064, 0.45335755117851273, 0.5135302022642556, 0.9530666552387025},
    {-1.0006048488215444, 0.36256089683856707, -0.6544551126722644, -0.3054063479207888, -0.265765318845616, 0.3742890044420561, 1.124236910422395, -1.358871481613385, -1.0029982772525434, -0.5163247950969251, 0.9541091799663384, -0.37285067986920445, -1.7519539955915062, -1.4796815239004568, -1.2234524990798992, -0.49580192957885727, 0.9553504969105079, -1.9864325854310751, -1.1543034034996877, -0.6084076121753885, -1.553015178201512, -1.2447099864071491, -0.5470017792902571, 0.4916259106316888, -1.0498589474857283, -0.700714491330004, -0.21300690709069742, -0.6384896250381403, -0.8957455012699205, -0.40648671382209967, 0.4522181518335319, 0.7404799416903074},
    {0.4454495059807051, -0.06857673199090408, 0.5370515933338963, 0.6502438859959281, -1.413746097281133, -1.5886287272693713, -0.7722864138342286, -1.362385274315538, -1.1603314080782157, -1.1585077678777789, 1.1361775224651072, 0.01649969709575483, -1.73312702924542, -0.38120573711404443, 0.05282204706688399, -1.7122512783219774, -0.3093202357441, -1.0115404575826992, 0.5740997066189822, -0.7769446565028687, -1.701623636017085, 0.6187502263885426, 0.1250801714042248, 0.06768713152094175, -0.2313891750981895, 0.3530447553742586, -1.053792297220098, -0.695608598378814, -1.317980228875394, 0.816369561617392, -0.41225911503841933, 0.7146176709568635},
    {0.9604344744947315, -0.3020759177050105, 0.373301684736536, -0.44705632593215466, -0.12082718765694661, -0.22353194103323581, 1.3825093933167605, -0.3540068327707964, -1.0457563437842523, 0.3413535963807852, 0.43676311958443537, 0.6117834543310265, -1.1036528808864356, -0.961805953609969, 0.8510325371223043, -0.8086544302844287, 0.191435033073465, -1.8177542278988699, -0.8017441640394021, -1.1413317196417296, -0.11192810980402738, -0.5432165801277483, -0.10330208342492954, 0.8184631365360073, 0.8633843936513111, 0.5876545387009295, -0.02074351321664853, -0.852557356987718, -0.3848760482814125, 0.1747453787373184, 1.5636097995268943, 1.006546345902617},
    {-0.503332631566171, 1.007914034642545, -0.2626162353934187, 0.13489375247107427, 0.5561421129421166, 1.5563508884375814, -0.049500492644463906, 0.0007981676548561844, 0.7756109897561985, 0.7133343388813423, 1.655087799698918, -0.5910920553520004, -0.9491640570468917, 1.4221052705682746, -1.0803710118540157, 0.4329082508708997, 1.0431984163901815, -1.1653658732720948, -0.4295574668682729, 0.8942872002771023, -1.2493153137768278, -0.023412459497098158, -0.9073952738674258, 1.2215297303418922, 0.9101266798231756, -0.9483288945005806, 0.5275953136710729, -0.9288883677045279, 0.38882188204467727, 0.1290764075044133, 0.822155886701344, 0.17801702575580158},
    {-0.31930058885449636, -0.6041598512270676, -0.023800891780454133, -1.8848127260988305, -0.05265888836759263, 0.15023751054349777, 0.36186696791862427, 0.30948907088888117, -1.2913576403521378, 0.5856729938999812, 0.7253125407582515, -1.5541434168047148, 0.6741188828172098, -1.01255050325074, -1.5028846734136732, -0.06291835852735465, 0.38716358490444963, 0.3274472806885407, 0.6839748554569086, 0.01625685423455286, 0.3199599252293066, -1.0031054865478517, -0.22269509661121686, 0.5855660837179724, -1.5163613547784183, 0.15072923558811036, 1.1294964322717804, 0.6655371224140733, -0.1587603951627527, 0.5054786438931193, 0.8541702952398653, 0.5035696612710359},
    {-0.21206127016459145, 0.19014855477247786, 0.44145567077746356, -0.7036767505140518, -0.49086369869487073, 0.2511490847805803, 0.7441509172291568, 0.011322229372500612, -0.8999239417238238, 0.6683077035082391, 0.44082698696442685, -0.17484141452049637, -0.59546096968617, -2.03176912326682, 0.04016239394639495, 0.11547386777573096, -0.15086373527108082, 1.0328915256557099, 0.12314110283494757, -1.0356710130882891, 1.3385139685258565, -1.3367879258228028, -0.3538461709490186, -0.6865390367830074, -1.2566051687748163, 0.42371519943555225, 0.44097648469135486, 0.23691771831570801, -0.860388445337628, 0.07915454342315927, 0.6911945066741839, 0.25094048780299016},
    {-2.0904860829431993, 0.7071001313712426, -2.1377911806669987, -1.7819159859332934, 0.45203644098642615, -0.2778903221243866, 0.08647749027491838, 0.3742303492486666, -0.053090985984848064, 0.1315939543319578, -0.03802707276441006, -1.6179345321259238, 0.2431023079669323, -0.9058278687822758, -1.6323560429592694, 0.3087765879549526, 0.5223874827297244, 0.6523485118689761, -0.62330730816047, 0.08778663987440054, -0.6434366794478773, -1.3205974110464098, -1.5493646250213176, -1.3301578160534628, -1.7257917643188967, -1.4258043493232577, 0.9315336586338059, 0.052169546365141165, -0.9818979757041918, -1.7533207354719058, 1.6217376831166295, -1.2856363004794806},
    {-0.26474563604099205, 0.4792499345195779, -0.46401276040127, 0.6321084132859777, -0.0031669824764752465, 0.016900877395323387, 1.099507618145465, 0.6422493579793667, -0.4115653664610727, 0.2870333457984486, -2.3338758381286526, -1.4065870977002237, -0.7038014099163646, -1.1294809831498545, -0.03965441031936752, 0.0438661406081582, 1.2678716731370585, -0.7117529980324798, -1.564554493421723, 0.6150655488816469, 0.151369228511018, -0.4140205074932187, -2.1772508388319096, -1.551429362100969, -0.7771404773191307, -2.064475618602483, -0.954690705776054, -0.2619506429527706, -0.40703280311586004, 0.2986936728844684, -0.6376229884456701, -0.8013247225094016},
    {-0.44610995998318825, 0.814718939154544, -0.7923492698706457, -2.3332251374947233, 0.8517951493022665, -0.45987114133653384, 0.23940848428115546, 0.20529287040534783, 1.511185340495982, -0.0803818829986287, 0.8513894812400153, -0.5200178528358965, 0.499944769638364, -0.6390294957997609, -1.6714084836236276, -0.2690044679142345, 1.593296818511476, 0.7769654204966443, -0.4419390258525511, 2.1333294089887076, 2.0002191620435257, 0.606571146531065, -1.1916990722278002, 0.3459381998527299, -2.1245390736390255, -1.3852573967414161, 1.9770473532008916, 2.133778188997554, -2.243342071050655, -1.666030276171823, 2.232556853810211, -0.5162165839251669},
    {-0.02374582109225377, 0.015275819588919652, -0.162814752914993, -0.49710671170138504, 0.42995746779340943, 0.01070862500384925, -0.7329016733904227, -0.5206859268949378, -0.9636714541518077, -0.7905618199696008, -1.1973664054043194, -1.2799384375060305, -0.35114822880065616, -0.8150654470265363, -0.37910384777189227, 0.14136174069168236, -0.14248169405191796, 0.6250155151983258, -1.0627156345920092, -0.9119003975920584, 1.400838950027146, -1.184003182302833, -0.2839195443945389, -1.5964635500124422, -1.2945213769923107, -1.7292967063105604, -0.06134600807174538, 0.1614698956440557, -0.09810304695917442, -0.7127717249575838, 1.2212849701318258, 0.19045952077807068},
    {-1.3542333949611673, 1.7146553269941187, -0.7696245373060132, -0.8031605241197838, 0.9434546787962445, 0.6114677370544604, 1.2423070719018725, 1.4015069086188674, 0.6376076626915536, 1.5352082097192803, 0.021850826519073586, -0.5619660367668189, 1.4351301678517239, 0.6957783025940975, -1.216415435278254, 0.9166431388177076, 2.0318383723573303, 1.5644040938592014, -0.4265625047704326, 1.7587094734467577, 1.458411497277026, 0.0847614365119643, 0.05836895860463625, -1.0328867704617815, -1.028888254645647, -0.7160629571319291, 1.647940907538822, 0.9438670341802555, 0.29012025118688517, -0.9319257430294822, 1.5888249526316347, -0.19522575011381638},
    {-1.7698580540929096, 0.9981133617883187, -0.9134668630893943, -0.8822643053109257, 1.0754416332018566, 0.3724822068548172, -0.36891903968617673, 0.840513087985813, 0.49906049584498513, -0.07101747448602189, 0.9558375926165061, -0.20677556530643784, 0.7245813547856822, 1.107532255152119, -1.0503588196064235, 0.5371420215036906, 1.1064865215418862, 0.405594358992616, -0.5407739801648898, 0.5180214783108786, -0.9380140292263175, -1.6286051512001203, -0.988505907847214, -0.9496141059598299, -0.6180770279724931, -1.5364151883637756, 0.6762181619269244, 0.9524557580283701, -1.3633612297503133, -1.4239066019564517, 1.1030175377030476, -1.757937948365359}
};

static const float b1[32] = {8.280461698816396, 8.464369781109227, 8.144285024592147, 8.283753838289812, 8.418369089755036, 8.492678088348464, 8.3005369733773, 8.533531118676267, 8.39993212124544, 8.354975213402938, 8.337514283618232, 8.545542564946954, 8.39655509622369, 8.702545333835998, 8.350420848210943, 8.350791105048666, 8.538194907120156, 8.491924361784488, 8.075555358805598, 8.381554175129992, 8.375607197722465, 8.275292168577007, 8.280307224715635, 8.26241708280471, 8.304236774958214, 8.17002978223671, 8.46225471147625, 8.464773985907387, 8.447145980769065, 8.170218555979458, 8.487936630324969, 8.185727217695952};

static const float w2[32][16] = {
    {6.9465861549086805, 7.115394662551329, 6.648573941091467, 6.341370773596297, 3.199955317854849, 7.396818388418479, 7.066548052200546, 6.351698840485706, 7.033987636790997, 6.563911154446648, 6.687233468009896, 6.551003674606282, 6.505623188134062, 6.585031122072364, 6.251587764421689, 6.939786108392425},
    {7.105464625560659, 7.1204714015153705, 7.529704470952382, 6.348910919890747, 3.52769321649887, 7.320456629823085, 7.632351530926904, 6.548674476767985, 7.304926919268755, 7.665873576704349, 7.409235590353642, 7.2532587060184035, 8.047194983768394, 6.713572800251535, 6.792453530935498, 7.5309221951110175},
    {7.117579454658356, 6.480766326089503, 7.008374327460085, 6.5591950011885105, 3.1589369372638987, 6.845067309866718, 7.434986503628859, 6.504713581347167, 6.890681852041951, 6.851942746652169, 6.783929669044924, 7.403264914588927, 7.442098234717761, 6.251521448782691, 6.4095762738594395, 6.710581419053051},
    {7.813109888022387, 7.404931117424609, 7.066497173256543, 6.793141984712481, 3.5711863734649674, 7.372766010528797, 6.977535448742594, 6.459463364662938, 6.931018558855438, 7.235859667522409, 7.121011779132564, 7.004915146019429, 7.169078159608206, 6.23391320761867, 6.737736603262148, 7.58530576259442},
    {7.23187709563114, 6.804671494893526, 7.607147546342522, 6.7344764903382766, 3.6326586865463537, 7.384367171927297, 7.443702662485201, 6.703966930327492, 7.117878396794354, 7.109995663462196, 6.980601233134172, 7.498700167094092, 7.575213900447477, 7.345807420582177, 6.833059899453975, 7.5059161444472515},
    {7.484081650503337, 7.8167437626352525, 7.546214396834721, 7.059150742723196, 3.890147479017612, 7.697396512130235, 7.214290390919263, 6.9166352547526415, 7.62617153001015, 7.072553032691319, 7.796169852152657, 7.573817748854181, 7.488037754762361, 7.13341875326154, 7.340481553064851, 7.478956665291555},
    {7.517625748374187, 7.546567985102699, 7.366857606896376, 6.844120177023503, 3.715751559229838, 7.415842205947369, 7.533882509328663, 7.13598447988062, 7.732210832573254, 7.400903369244232, 7.1871214459925135, 6.992564344679733, 7.012875588497301, 7.131348306825249, 6.987607510144738, 7.709923960112606},
    {7.177002350422729, 6.895521801588848, 7.764335962151951, 6.777632918030932, 3.809623484924616, 7.473921470933398, 7.438706584963143, 6.460601542056292, 6.83287532304013, 7.358954643697987, 7.3073190093902225, 6.552655162824274, 7.103808437278158, 7.060543006039314, 6.877896546693888, 7.549149659252441},
    {7.265922038556502, 7.224153757943646, 7.224460396970055, 6.83629546978455, 3.727719425220884, 7.343302580787943, 6.8680205242628345, 6.573142270879457, 7.289376343501367, 7.356201260571804, 7.133037255575522, 7.610754586301057, 7.618303916302218, 6.808928633982742, 7.048671919498694, 7.413071103800304},
    {7.981884646997413, 7.723929522475248, 7.645269824159787, 6.654800995451543, 3.8875192391428417, 7.348831674374758, 7.919127373044978, 7.073711918224446, 7.20914938948424, 7.694281429361442, 7.558604360346583, 7.689916104372934, 7.159331155829191, 6.866671872829409, 6.826174385801702, 7.63593122846061},
    {6.844006578046366, 6.611645237184909, 6.810449034654559, 6.889957069569667, 3.303185247941063, 7.0460693199580415, 7.297904897643825, 6.27482348980587, 6.453367598843577, 7.286264064657501, 7.0888317569387445, 6.64931126304106, 6.852334299762958, 6.292716806900606, 6.43654686998885, 6.724253247638842},
    {6.777498462165929, 7.21028025052115, 7.214264871522371, 6.893799699347002, 3.8287718278906113, 7.205897524692947, 6.970543864613462, 6.602159645784288, 6.677877764695383, 7.401961193398396, 7.464577641621198, 6.7468700689546, 7.34018502899798, 6.345306272453552, 6.724885438477492, 7.193007590888236},
    {7.5354542216236435, 7.7870893545954925, 7.916990436703551, 7.031261278464144, 3.566003742867828, 7.451698029374471, 7.108562463612899, 6.849041396952899, 7.466397529483962, 7.408234867999707, 7.158662765230166, 7.41642219580351, 7.499198374256191, 6.904150265710422, 7.256514075868662, 7.616662907888961},
    {7.925494254870212, 7.948441060415935, 7.346890434244835, 6.976200724625908, 4.008698630548816, 7.452223469928085, 7.525500439129411, 7.064622957906356, 7.822178144087514, 7.517165542918456, 7.287284343804279, 6.984523716507318, 7.4127936970976585, 7.530336270591933, 7.282658191031635, 7.155021578256806},
    {7.808849751971683, 6.639391625057926, 7.155528180285615, 6.746002822644891, 3.2296740393639816, 7.512467023375368, 7.0490863411131635, 6.8234250730708945, 6.991702604786067, 7.154607970137324, 6.602120585589833, 6.797514163682979, 7.210907642971815, 6.61245306324414, 6.88001581501978, 7.054377780290411},
    {7.571022751407682, 7.664046174004969, 7.586654114058344, 6.807648720831648, 4.175646063745954, 7.234159679414087, 7.856773362688933, 7.0415206044101115, 7.119597684137691, 7.801943256968862, 7.043359466178394, 7.438769089525531, 7.173046695454234, 6.966669008392, 7.262595627185391, 7.722732164522629},
    {7.0639749014377164, 7.540368928478294, 7.378904164545271, 6.7443689157318385, 3.742823326452295, 7.442393446183855, 7.8056180328928155, 7.131285830332449, 7.097861051229565, 6.971860353433808, 6.693678651633368, 7.181660961910485, 7.8979304611861885, 7.035972443660497, 7.18183794303933, 7.262615688039739},
    {7.420484578794632, 7.822068616523892, 7.3078475072733315, 6.8201723016553295, 4.1601415121564225, 7.598586854530976, 7.099724622958607, 6.561846285561379, 7.37652265268621, 7.091501214251215, 7.171337896448752, 7.209810977056892, 7.801405731599081, 6.940057129696834, 6.825532382294823, 7.18556860266762},
    {6.984844460699834, 7.0808303787191385, 6.952329232788495, 6.741407576973559, 3.7518476089816346, 6.782719857447148, 7.103719765368738, 6.643508647876093, 7.128868254895499, 6.472132030916205, 6.648035925618443, 6.934904209859672, 6.893241927389071, 6.463405587356403, 6.685120675716714, 7.229854498282233},
    {7.087944737545248, 7.212751628860457, 7.205711339981565, 6.832693755558019, 3.599867769979398, 7.491957790533644, 6.701206395980306, 6.311476191199097, 7.036426944587077, 7.802744521766233, 6.818963000470048, 7.337463384897539, 7.246803935183244, 6.654892593687822, 6.943637589161783, 7.06984614423418},
    {7.25590524979619, 6.976883243354665, 7.5379697474250795, 6.755040240733141, 3.559083732024089, 7.406943517600657, 6.943944454604316, 6.97613574086783, 7.311503731161247, 7.623826601507392, 6.9615918615197385, 6.71681813268841, 7.713652661795774, 7.02447282968163, 6.945543377338289, 7.449964979766707},
    {7.0794985280202205, 6.554497003186468, 6.725480606228963, 6.457536470960311, 3.5750112515921972, 7.14100763269794, 6.727097136098112, 5.880440996992718, 6.667418756851185, 6.711201279319756, 7.199008209869825, 6.566418121188619, 7.153881046899394, 6.433985710093938, 6.671590070359661, 6.572890295579946},
    {6.907316398019531, 6.570086140719742, 6.8764843450910424, 6.397571985876283, 3.535451813362028, 7.067962100396282, 7.148371983607422, 6.670862261964643, 6.953056732851392, 7.2280339862622265, 7.135710707426328, 6.544494854735028, 7.006799778315206, 6.205848123431283, 6.720906629090428, 7.207480374221545},
    {6.925317327235359, 6.616441098456436, 7.136364250863179, 6.510803053137829, 3.2311370758622466, 7.255861204883854, 6.663623783438244, 6.108685206269943, 6.841708004052171, 7.164922970238605, 6.519380764343765, 7.171395004969873, 7.200791758014849, 6.527245695238237, 6.330882769502944, 7.15603613782426},
    {7.542407322095908, 6.976305610754899, 7.267159771744721, 6.735071721791316, 3.8658241869683057, 7.309913834720397, 7.86221675161468, 7.464610030042129, 7.169322193874297, 7.320426356631617, 7.646375676246845, 6.947336413776067, 7.230680191557475, 6.867460683808606, 7.189256754150765, 7.35863247170223},
    {7.142618634426157, 7.2624462543573145, 7.18084928242684, 6.890970249778124, 3.0764566774947086, 7.128244124626028, 7.1175670203411965, 6.366639741789048, 6.290383071315005, 6.866586959105743, 6.675251840291585, 6.971897337243098, 6.854256825914008, 6.514259639385527, 6.438973002896658, 7.186314514198912},
    {6.932628970230912, 7.119694599424175, 7.407744085031922, 6.312349189431101, 3.869080391489225, 7.392220950774322, 7.21284617466086, 6.5365551826382555, 6.967657625918076, 7.132116717873607, 6.628866742414275, 7.024436476790906, 7.155166959639909, 6.106895863622562, 6.597269142589794, 7.076607453961668},
    {7.293157093468541, 7.342578885715042, 7.074635915605342, 6.629901207842401, 3.685657282602135, 7.645724925099099, 7.315004353648448, 6.573442542629057, 7.005032742580381, 7.705844657211101, 7.550897145095697, 7.13090131065828, 6.958070506230159, 6.631701902796985, 6.673377875547222, 6.98975564690172},
    {7.392524330622376, 7.1588266244692225, 7.309820820822163, 6.528090982532257, 3.3244192387593623, 7.445117470933494, 7.15860274500074, 6.34733025100359, 6.95935301352291, 7.280039579936015, 7.501468471204434, 6.4087886075217115, 7.187289841086984, 6.138147945427891, 7.002127432918853, 7.096620169407872},
    {7.69235186513759, 6.652496994743842, 6.883988865398497, 6.261678317668907, 3.742166689202345, 6.758100641832561, 6.961268293519611, 6.2753384348798225, 6.909605289376805, 7.260072240452899, 6.817971549927593, 6.872673209619967, 7.513490862313666, 6.119033606035376, 6.836479990976501, 6.922460295319822},
    {7.533880982163613, 6.833100057754002, 7.117606497714732, 7.107770255377255, 3.685664327885965, 7.7548786673843715, 7.627468587650152, 7.169366158040658, 7.341886186720717, 7.692999122745797, 7.406268719517822, 7.220350209322753, 7.485026119921317, 6.86929076862884, 6.8383145635439435, 7.420874543871224},
    {6.895024856135949, 6.625809608447217, 6.919626130477328, 6.398932872302432, 4.101213954629571, 6.910640415868753, 6.677613432509055, 6.111891550167684, 6.698931114801893, 7.355170432634786, 6.572468126655801, 6.643078655296343, 7.0812483369818535, 6.5007408025128015, 6.583774409991661, 6.552929074675057}
};

static const float b2[16] = {7.1962943549914025, 6.949878825013294, 7.085274264360512, 7.235044627046733, 4.430454082832562, 7.018617376115909, 7.091204375322342, 7.158069451627721, 7.133108308586333, 7.205233537978264, 7.146831851959986, 7.069674064448056, 7.018785370253857, 7.144602495518069, 7.230620901801322, 7.047404857265769};

static const float w3[16][12] = {
    {-4.984345859640762, -4.981545044743987, -4.853025008681764, -4.397740765703197, -4.357920339405779, -4.735131977087806, -4.761369730996034, -5.466928743593658, -4.778858598393104, -5.026934600171409, -4.667349746911261, -4.749000312191047},
    {-4.703678328946393, -4.733318030802013, -4.342256085086978, -4.5048356716223035, -4.479239396733558, -4.783278861583772, -4.714657005111633, -4.276325215167369, -4.582320061335067, -4.466434953586528, -5.648180177550113, -5.798610662631837},
    {-4.929111906426701, -4.383606610461579, -5.234198745690051, -5.402788351697786, -5.209647109762214, -4.71864971442947, -4.840370611076991, -4.518686110418193, -4.76947756868345, -4.685270188712751, -4.512090685457048, -4.961974309264706},
    {-4.063367988187638, -4.13893993107957, -4.911199167319936, -3.9305159589188188, -4.0815279214913, -4.212453697903897, -4.397782058286531, -3.8808928078335385, -4.801394062896978, -4.015900822890283, -4.567130995985949, -3.9897522926281526},
    {-2.1578334547321782, -2.589823536664515, -1.9326178320307854, -2.72941997475484, -2.6658469207023385, -2.241836227176774, -2.32556532218461, -2.1012412221662142, -2.5694405552836534, -2.011238660275451, -1.9276741891624138, -2.5457345488890333},
    {-4.922134741278581, -4.793344879682813, -5.344415408447937, -4.506176314818736, -4.452395899265454, -4.525735608043355, -4.781879001939456, -5.7774333153587065, -4.253260658265501, -5.220695609477684, -4.704328760147123, -4.637199912948089},
    {-5.495705782333919, -5.268273835042435, -4.715763824391003, -4.479378610256469, -5.313255445842875, -4.764859202289429, -4.817852781520558, -4.215090859550481, -4.785099731907302, -5.014292757537121, -4.737559920383877, -4.452122011439564},
    {-4.531465201381898, -4.230712169261022, -5.0095465266081485, -4.6358485099985245, -4.735956484386295, -4.168037969677022, -4.356101933069576, -3.9161386293230467, -4.8569235019413926, -4.599571371438951, -4.474946557216941, -3.494781460158726},
    {-4.272603402336203, -4.522087421654469, -5.151767070819848, -4.499430299711176, -4.831380985180157, -5.59663284778713, -4.491846486822435, -4.777998707567209, -4.092346985377485, -4.776811915330994, -5.171991886363437, -5.35069151055822},
    {-5.4404083796925935, -4.246182520938421, -4.607596525775895, -4.885867724263764, -4.9083782570824095, -4.8640236247783, -4.501642465470625, -4.439998820756907, -4.486819926859285, -5.311998810587353, -4.800752873719843, -4.673193804286317},
    {-5.147568014262224, -5.0158571257180045, -4.737309173793198, -4.793378030705025, -4.937171139139191, -4.184651202969425, -4.745598385928202, -5.135939338896509, -5.098421578600217, -5.020380948563798, -5.435276226089832, -5.011731413367312},
    {-4.654490387346848, -4.719279251486587, -4.145156221468517, -4.571548417754093, -4.629390011244598, -4.887937516701685, -4.9715427944726205, -4.698657996680883, -4.58414652195535, -4.31222359080539, -4.133258551023539, -4.5269206793321155},
    {-4.45685384327108, -4.704468892300291, -4.79713498250503, -5.360062448711162, -5.046931222481951, -4.595556157776762, -4.899222220200446, -4.773719357450854, -4.923442074836672, -5.131625067352351, -4.453014743742575, -4.346637179087574},
    {-4.547651511366802, -5.255162815528383, -3.6678298491896006, -4.692831760879141, -3.963237844676913, -4.272548679384828, -4.988730371084477, -4.477341743368457, -4.34002575336079, -4.610622541316314, -4.128413597921007, -4.944526948784835},
    {-3.870772900455436, -4.916968748292329, -4.534965856749824, -4.371432301130221, -4.612634748149507, -4.800941433840784, -4.823882469294855, -4.624775346379798, -5.14164139621822, -4.248651785221432, -4.042588029974515, -4.638345856420616},
    {-4.353362640371042, -4.335537294557934, -4.479565951884344, -5.135610143032432, -4.554691044186979, -5.244764728474191, -4.315948280103832, -5.410862635951058, -4.829944176272268, -4.067667509854079, -5.044300191957103, -4.65648871940679}
};

static const float b3[12] = {-2.667775677077564, -2.787445761435461, -3.376803796765102, -2.6803311723431325, -3.239030487450746, -2.3652988175057206, -2.001343407038772, -3.376733127239356, -3.064795299038585, -2.7500901833316256, -1.1225108446680665, -2.4345385520658334};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
