#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.1885782601131205, 6.862208966314157, 3.7269292265807503, 0.5933169548423484, 3.284642090895996, -0.3485973145338524, -0.1994265184786271, 2.6980884095900777, -3.00008240721728, -1.7793379973986878, -0.3446650357556356, -1.187989140212185, -1.3878497445969407, -1.5113422152588596, -2.706808435595043, 0.169909835029952},
    {-5.405511282474767, 4.23642936505446, -0.37700376326335205, -2.755065564433198, 2.693593002955091, -2.720901298426414, -1.9387898768019343, -2.7585037303581177, -5.0925458822248295, -4.408880892560153, -2.125243414973896, -4.578359200138891, -4.12771824706888, -4.436655586586568, -3.984384500675834, -3.2627237441434316},
    {-5.860791138809296, 6.545231321732034, -0.5587025934582195, -4.953331502600282, 1.5883317478560817, -5.0919645615931595, -3.4632458551475693, -3.7797133055035537, -6.386752515072496, -5.9951667695245705, -4.136696575791922, -5.523637963013251, -5.1717571156090685, -5.0377220425988956, -5.34098865107283, -3.941541622755387},
    {-6.174730583342019, 6.132669460419127, -2.6674340820086155, -4.163242007596206, 0.9734697280762906, -5.887685164871713, -3.443699866582678, -3.4532927259358464, -6.1557686728914645, -5.882937825517453, -4.4070360166840565, -4.977157361466265, -5.385436690638376, -5.21223315179051, -5.772082500556063, -5.31577166817981},
    {-6.602486434364438, 5.589707810898633, -4.7279091376614755, -5.620387398983975, -0.128059299604348, -6.18790262146703, -4.67431738924653, -5.545725021045629, -6.503598636126428, -6.366627582337167, -4.711337108795638, -6.102073347382922, -6.273851231226944, -5.420287047555506, -6.236893759608877, -6.142810504504615},
    {-6.68123718076051, 4.5351024604151045, -5.134306882887637, -5.572552437633046, -0.9277993825836379, -5.970298631196621, -5.125504660241888, -6.171147095052025, -5.7162886996298505, -5.975386431552689, -4.299202452820984, -6.031737159466124, -5.996484743319523, -4.679499749827359, -5.786061723401329, -6.311698209705826},
    {-6.4132357003498255, 3.6526648975429286, -4.745542776738113, -5.349079258210377, -0.9277975741585957, -5.565368079210301, -4.794848448002015, -5.686261376681991, -5.070418530764948, -5.6986132703214585, -3.954190426173555, -6.226176738243371, -5.683870166768399, -4.6477690979383, -5.179865844005118, -6.236647438362643},
    {-5.927189483364314, 4.220973720058925, -5.220002382123764, -3.6975763016586383, -0.8850369205795189, -5.962799507604471, -4.002394258885421, -5.687227071677322, -4.990484831150078, -5.107206124717404, -3.606603543898002, -5.368086888842294, -5.138935196828963, -3.676563838508256, -5.151726990354608, -6.426101811959373},
    {-5.572268048593642, 4.216103336938481, -5.192990342583689, -2.429993536023501, -1.1667766241469866, -5.573544669507497, -2.7578627296394336, -5.228501271776632, -4.639077730567799, -4.648485834754601, -3.0697060942202907, -4.4005620165364, -4.559450566191207, -3.4003440577804698, -4.44343143064584, -6.203368771939599},
    {-6.457680019906587, 4.490742660838104, -3.8276887203007597, -3.3129499797228665, -0.2482688959956844, -5.52818109263038, -3.2445881000640964, -4.713791092334074, -5.334989831530959, -4.927615167297181, -3.3783075061955246, -5.029278006164739, -5.381723635530797, -4.222811860455114, -5.118945298037278, -5.701202902899865},
    {-6.238212796893468, 4.468689717075174, -2.512025200440352, -3.6658431025619795, 0.5710505617947526, -4.170230417800476, -2.518875073077971, -3.1629209480513802, -4.491554373375433, -5.110749956551077, -2.750439735372323, -4.867753155625654, -4.987580409756482, -4.0151073876994055, -4.848237808875953, -4.339641588603812},
    {-5.793335751672877, 4.424039732991121, -3.340011763575555, -2.70739011135911, 0.05906536944329089, -4.486534322613906, -2.3835806807742403, -3.6784949453911584, -3.708071298989865, -4.711608007822253, -3.4400637396093834, -4.173293095616511, -4.435652479445304, -3.4294849354710717, -4.7945336808182475, -4.640842672584081},
    {-6.140405889694771, 5.456974832673431, -3.5984627626043864, -3.3217099797585057, 0.6755275285063835, -4.990039020152762, -3.1512907880985734, -4.682388980383763, -4.809729578815632, -5.258524741762665, -4.044407895335501, -4.8855067320215335, -4.718884534869425, -4.259132452042392, -5.311538565160186, -5.125944886185533},
    {-6.250444358393331, 5.044880741287873, -4.383477573203071, -3.8848572556006267, -0.00211616263151113, -5.464245747269732, -3.817953241816187, -5.298916545704353, -5.246977240473398, -5.5506021109074535, -4.555306019620611, -5.369450198203375, -5.125134102313239, -4.331765643802094, -5.868358767474379, -5.359013266900136},
    {-6.316003587467977, 5.750455485894726, -4.377974258767745, -4.060525783126469, 0.8174742933895041, -5.469697306331644, -4.054309707990557, -5.4360544042698375, -5.220385784865218, -5.4923717451307175, -4.56041801911622, -5.438319825151774, -4.93584623076498, -3.927641483925759, -5.619968845533712, -5.534785838664712},
    {-7.086068025071819, 5.252565242613126, -5.224837405002328, -4.933310256271952, 0.40783761094093407, -6.062310592950771, -4.493043146289254, -6.164949075836813, -6.026727697090789, -6.025227340140979, -4.834582056348901, -6.12292238422561, -5.877491438931811, -5.227197399054711, -5.805590564060691, -6.212729507364147},
    {-6.37313028014093, 6.365616399823158, -4.595507496236736, -4.3247710817385485, 0.9206220137275746, -6.072935933637424, -4.002103717352981, -5.663375048153885, -6.054036474866107, -5.9234735852459774, -4.314292221242467, -5.560503010180892, -5.477428939938973, -4.891297739678317, -5.46255781790674, -6.133525452035182},
    {-5.646954890087852, 7.08239024588429, -2.1227454816968527, -3.20372673277078, 2.405968167271552, -4.972828410568817, -3.346199095091014, -4.259894334537665, -4.934329126853347, -5.1080871946404205, -3.8810581376397213, -4.147209065833727, -4.628524574737793, -3.779997385972677, -4.92126241175997, -4.779300608612314},
    {-5.494856606669381, 6.653323596381601, -2.7711106640814736, -3.606921348672661, 0.8771532773943296, -5.137424331770644, -3.7996916656413813, -4.323290112587733, -4.659376862213762, -5.49958605432401, -4.1276098780586175, -4.698046802936014, -4.519517146249355, -3.3196640217129696, -5.089985427412626, -4.576030616015928},
    {-6.495049032138588, 6.446613655589464, -3.181581188999075, -4.1080110452804055, -0.04720090214185389, -5.295670648388674, -4.351676076021597, -4.383082868354027, -5.66245121941923, -5.803089141124264, -4.7445932388870915, -5.326967115331597, -5.260302607027941, -4.625094050590937, -5.897775575883398, -5.592342561040529},
    {-6.802109880306174, 6.25562324694037, -2.8523814626990602, -3.963537237985277, 1.6251936236096707, -5.00100776082101, -3.7839996237982403, -3.8933266491751004, -5.586969945616995, -5.81309558987106, -4.568349369860184, -5.269737965144724, -5.37690078666263, -4.587164066120281, -6.060444148775199, -5.0241385845549145},
    {-5.899270870141396, 7.676812527405531, -0.5268806780227158, -3.3962788389284446, 3.2040490347840334, -4.204113338775822, -3.1113673103018167, -2.169417173927793, -5.390705429330052, -5.738901305562018, -4.283695984554529, -4.236287511853829, -4.775346122089336, -4.233089226857037, -5.26971936672049, -3.64153714199596},
    {-4.905045287578601, 7.593524685097701, 1.0659347320488055, -2.280342279441167, 3.898231754928872, -3.3426721523720526, -2.537884476676551, -1.2581647660205288, -5.083449811155147, -4.912909878544016, -3.5257763882447843, -3.403976654070264, -3.9659914304785815, -3.4307052971317793, -4.891240611606095, -2.3125762419339693},
    {-5.7454085040067255, 6.968959594550077, -0.967796227273126, -3.0403556782848336, 2.897970635462586, -4.356045703509096, -2.9394786226089193, -2.833227851928542, -5.464026397039961, -5.422024812042429, -3.911736324334155, -4.478776506768953, -4.565884103850624, -4.033405366225466, -5.282938304929656, -4.142279283042683},
    {-6.110985329995658, 6.203382448482554, -2.071983602739515, -3.448242290161111, 1.264004912771426, -4.681881236830068, -3.51706290517721, -3.624048044636939, -5.719009720582353, -5.641923922862765, -4.487331106725589, -4.646784404328087, -4.98268786118459, -4.949997878453932, -5.748353469918312, -4.977758260923646},
    {-5.369590324483806, 6.769807364689245, -1.605880249564548, -3.2399875632668773, 1.8701686947529839, -4.016532957652961, -3.2579896191388373, -3.16066843613648, -5.258854702319286, -5.297726193834989, -4.050498881919246, -4.530148421183787, -4.486053629923125, -3.997457275829653, -5.192679240284671, -4.17067122116795},
    {-5.8952867058794824, 7.26501139375702, -1.168780629820143, -3.8786373559709557, 2.9544911695675036, -4.48034989058563, -2.8160900541768723, -3.7078784215714276, -5.840028329313997, -5.82332786051246, -4.249157199992247, -4.784559119021274, -4.787432944400665, -4.693300570572551, -5.131528345920758, -4.035942843750991},
    {-6.457072694580145, 7.2337269750755855, -1.7207185738293571, -4.5372337931081805, 2.5125436735402027, -5.26997045049638, -3.8673561900937243, -4.045602658274173, -6.308724312499241, -6.213430813296813, -4.868635041386754, -5.246311419431852, -5.497770833079446, -5.453740643898282, -6.084551824734523, -4.771727072133588},
    {-6.7210330896064505, 6.6352074808075105, -2.1313655768682906, -4.509923254534227, 2.296008277695587, -4.673642488220871, -4.085644016292855, -4.183520073910707, -6.17130071087025, -6.258377965454282, -4.48169329491596, -5.366941129404157, -5.525395106657425, -5.427828360212509, -6.228744443178348, -5.008523352918276},
    {-6.6106803947164385, 6.04076765934217, -2.0690021879660647, -3.5520774583022416, 1.2769085405039227, -4.454622999098741, -3.813967273323025, -3.7364271039655366, -6.377502199371866, -6.1436683091452995, -4.440623532071005, -4.395425433428825, -5.18131088330389, -5.532629691943838, -6.099995143265547, -4.6375996361890985},
    {-1.2538079339137767, -0.021879344784945364, -0.3155977938121129, -1.6161123542116935, -2.466778653631772, -0.7613919133753142, -1.4127817781914322, -1.4225168875977028, -0.39817554235848346, -1.3790662941227518, -1.4480912016473402, -1.3942426842300946, -2.27367926430929, -1.6910281169690657, -0.1190792242325145, 0.1989023920195859},
    {-3.1062360453063538, 4.604227767808904, 1.6051274344808182, -3.65603662764643, 1.3829086588449437, -2.540285040987917, -2.2723664712444296, -0.3145442278591558, -3.4071656696776373, -3.129074780956272, -2.6232172375250173, -2.970761016287202, -2.9024889869070827, -3.5024535036405684, -3.7211887865920557, -1.5724993507467213},
    {-0.6847301628009689, 0.46818037003316176, -3.2583661379249373, -3.1630680717524173, -3.503549071995032, -3.815415342695879, -3.2299175535057087, -3.2440287513385075, -1.267065933522787, -2.3769033770193078, -2.9650310886652638, -2.1263746374908434, -3.26117040067266, -1.590776067853442, -2.4186182486636674, -2.9755135907383283},
    {-0.4133209111440515, 1.35925681815011, -2.6230282356265855, -1.6343856007552569, -1.9332593543047567, -1.8574213915456028, -2.207686675517172, -2.220310531143446, -0.985523983940625, -1.4857828254796897, -2.0546360021783197, -0.9854035022050688, -2.3586070689224217, -1.8310032919817194, -1.837660694013589, -2.094988898058484},
    {-2.5354563987922623, 3.0932356408041364, -2.394084052171155, -3.9929623002344616, -1.1611742819569681, -3.4899492059377972, -3.0715007874224245, -3.1308386868903626, -3.245457195669658, -3.492452722821635, -3.1671672280519885, -3.134015250427769, -3.7349664294565534, -3.480592204882054, -3.511060817749981, -2.570290145688686},
    {-2.3613824636471623, 2.8179657191801573, -2.850159480709667, -3.5453938751337244, -1.4236521918464848, -4.02723823456298, -3.5110817062994935, -3.306852571258309, -2.872857046998254, -3.0550620048997357, -3.071813017117695, -3.082905613144629, -3.4922107104560833, -3.3582189837460774, -3.470361283045332, -3.234813607053247},
    {-2.3384349425551387, 2.827542890328342, -1.9589868778910702, -3.1494414624743805, -1.2729052299207602, -2.4883291677122465, -2.569448768704088, -2.604970511850299, -2.515024885221154, -2.750594960338158, -2.515133725963323, -2.7920692143903856, -2.8341518313875733, -3.031167019793251, -2.9276943584491, -2.386122006385162},
    {-0.8194650093556951, 3.2629616806524733, -1.968680200326004, -2.579954404995892, -1.2714123752777482, -2.100922384531106, -2.3061318129617767, -2.918560194337142, -2.1450085196218964, -2.6677697568783456, -2.866376000193716, -2.335184519344179, -1.786722873280879, -2.7383185288954093, -2.7567099689581585, -2.7164006595423156},
    {-2.4008587389911384, 3.0427518455823677, -3.108945169787308, -4.023229162500695, -1.6074338515219115, -3.993567318051295, -3.949163586252558, -3.8475650642206474, -2.8107664436839674, -2.7599276157657977, -3.5472143150935787, -3.4557593900179335, -3.95084045524105, -3.364657808135551, -3.581639760918239, -3.9581807984502544},
    {-4.00102054240368, 2.6491908908448307, -2.9425214830744, -4.555650663547879, -2.162905443340046, -4.573773742981127, -4.364904467679931, -4.2123204019307945, -4.547152895660157, -4.712098480672145, -4.760194642155098, -4.818123678254732, -4.802896145772182, -4.521369894697946, -4.54215009299773, -4.2605864125123185},
    {-3.044491069381835, 1.5130730758260433, -2.831365620031605, -3.8122918772362886, -2.81676456506255, -3.314183584488696, -3.468238431860722, -2.7218197896827716, -3.3315760886425996, -3.50545298126453, -3.4839537823813833, -3.4817671365689495, -3.9478499235429214, -3.963971847570678, -3.6227283935407484, -2.635031885553333},
    {-3.704436658240835, 2.096976621627625, -3.3484258844376122, -3.932685363283825, -2.977067437382868, -4.182705337287509, -3.961741857729622, -3.647854944422193, -3.5597346603963835, -3.7413074989419557, -4.03071587255913, -3.9132525912934675, -4.22529891493961, -3.8651289325706513, -4.3641551425261715, -3.5760853207265},
    {-3.8617515684582617, 2.5036117971515437, -3.480317947953191, -4.662823615145966, -2.746751586247287, -4.6218301175607674, -4.498472410351398, -3.9701953887198567, -4.263881643892304, -4.4891185310944595, -4.752111830804001, -4.2189202202208635, -4.582709184942297, -4.5429280711208735, -4.608962046940283, -3.7199471816281378},
    {-4.080606846855744, 2.160804189926594, -3.196137022205709, -4.43220654321993, -2.970960096045675, -4.7566416088695185, -4.65891982045649, -3.899708390422006, -4.06986795421633, -4.249732579258563, -4.481824871403138, -4.144972529936332, -4.751110297783744, -4.400852375341546, -4.204003496663696, -3.8361564158049393},
    {-3.438476478416054, 2.3416615644886756, -3.6271576458393127, -4.5660446060433735, -3.44815621306648, -4.910666823379508, -4.590805568765908, -4.032680289909975, -4.400317579725235, -4.250756042309679, -4.46130465752554, -4.934521111175766, -5.239601801624336, -4.064092580615199, -4.436682591981565, -3.85470966987289},
    {-3.5096461628546725, 1.622469113631913, -4.265802659425419, -4.520326905342446, -4.900040288461772, -5.217807523295325, -4.736842734765893, -4.675406128417367, -4.1320578475571335, -4.115264979025331, -4.448443614279595, -4.55191531820503, -5.057290451006142, -4.030307724617625, -4.315503600732806, -4.818591348987461},
    {-2.580850611603215, 2.824717098353444, -3.213494392389677, -3.9287742053048307, -2.9040907280576884, -4.1549083631187775, -4.310658254016422, -3.699965793971904, -4.139865488317393, -4.012058501917495, -4.398658412769257, -4.355724659459462, -4.323567468609256, -3.8029155606405496, -4.0759968008295875, -3.520439285199315},
    {-3.267238004072842, 2.165507393837828, -3.0987573295050526, -3.8127899331731974, -3.101566637856762, -4.382424826991188, -4.121216798638966, -3.9902909890353855, -4.231377979053399, -3.7814668872083637, -4.48910547234779, -3.718271744758604, -3.9078584525145588, -3.504647736000393, -3.8660059982581547, -3.9826993204594388},
    {-1.9258549513508523, 1.6559090209296745, -2.7509989272802535, -4.782878551276887, -3.0661305609942477, -4.295351266934119, -4.81493929905163, -3.4584093764476402, -3.9181710805578747, -3.802952816351305, -4.900983225413115, -4.448783545557302, -4.423498769981555, -4.014276649200769, -4.342893063413549, -3.0075613696780237},
    {-3.3012864366679353, 2.1071066335953144, -2.926464549275253, -5.089288439350412, -3.3307137728700176, -5.0319511357962305, -5.294685363519534, -3.5025068587862753, -4.622975453367884, -4.742153248416181, -5.206868129038417, -5.603113572322037, -5.239391014616304, -5.030492149201646, -4.979774615380225, -3.674188876708091},
    {-4.730374989910628, 2.1941854177530487, -4.022538537979773, -5.447796466842156, -3.5365614227190156, -5.024635820555262, -5.2334857997470925, -3.9634670142514508, -5.2053856905026725, -5.221398073495236, -5.497097301972917, -5.213558722623152, -5.627000507807936, -5.656080579888703, -5.256946908027739, -4.106756625559066},
    {-5.196822120494477, 4.1282101681337435, -3.1684746124199727, -5.849035996107077, -2.5507701125960205, -5.105651868273593, -5.8957047516510475, -3.653018843724597, -5.638752618625158, -5.568582855156562, -5.419477379013453, -5.87104996978528, -5.817005650798934, -5.657253063315281, -6.022274203453342, -4.428328552605286},
    {-2.144426178963438, 4.405519813475675, -1.5067923993278307, -5.25175897562336, -2.1172148945179665, -4.520051608633967, -5.100513582439588, -2.368479136520144, -4.394288592640717, -4.216678469688633, -4.697918044784109, -4.963580305238707, -4.984456110539975, -4.1492515739564855, -4.687014564916354, -2.4558135045498863},
    {-3.035483073614396, 3.1482168306043916, -3.4618609048191393, -5.718558750078086, -3.314225590364026, -5.512670227243835, -5.876607635453164, -3.954292868432735, -4.892240261573437, -5.163579723771331, -5.373103647364833, -5.597692162611716, -5.7557504146475305, -5.192674957316408, -5.260915583833677, -3.550718819934777},
    {-3.4513868268106376, 2.337919226613134, -3.6139939133977714, -6.288061403783685, -4.247230051131414, -5.276120397991002, -6.011328386177299, -4.412355861495855, -5.737570698530151, -5.694520290221603, -6.241464932194437, -5.835942591597553, -5.422696296099419, -5.495381540649729, -5.876513443899977, -4.113732406113353},
    {-0.8687378474213234, 3.0241999774109605, -2.67609386342779, -4.840342748703671, -3.301273059486727, -3.688953132529137, -4.527414016189284, -3.1097476509361246, -3.143553932723921, -3.163561554258503, -4.329154290803713, -3.691858061439007, -4.275801665594565, -3.6190311650816422, -3.829496151351027, -2.7071742719097225},
    {-2.6134955631567336, 3.1141806841535424, -3.9318982816068675, -5.482704290440995, -3.4451110200754917, -4.552432459482697, -5.137864318776045, -4.456500987904578, -4.573604111738105, -4.438699078588736, -5.084906776906072, -4.904569326168473, -5.103803078713617, -4.3734642156587515, -4.485893679813393, -4.31439820629508},
    {-2.6475101935909167, 2.747107501859066, -3.588875516305036, -5.300275822582608, -4.183526161203341, -4.7520707147691885, -5.595354259178016, -4.381754863500657, -4.986976585014925, -4.280191094277458, -5.38612876940687, -5.298783223623436, -4.8694945597706125, -5.157635973773992, -5.177731850585194, -4.241600709036502},
    {-2.0873801765330486, 2.9023190371179783, -4.105618615458726, -5.163856942536989, -4.49062204227931, -4.311904400571344, -5.235523722374846, -4.59993922159431, -4.349993243588379, -3.8724078838122176, -5.154296231589754, -4.988781793308473, -4.557647434725672, -4.256438318925321, -4.525020764323838, -4.434108525784417},
    {-2.605254993588517, 2.410204944157332, -3.922948171361521, -4.406727664134092, -4.528020951143499, -4.402526298365566, -4.933122421518513, -4.153387474394216, -4.40494954670523, -4.420288248473216, -4.866437530580741, -4.829195807720232, -4.927097618518556, -4.629431003659037, -4.326635488259112, -4.1544797176751125},
    {2.3790821267106717, -3.3038241699185997, -3.285255587078043, 3.1568185220736793, -3.5374357255606674, 1.860419905750806, 2.7286573482223826, -2.8523950472223314, 2.8400424569436034, 3.284607616250965, 3.43667204221246, 3.088607955665795, 2.2817471127852413, 3.5249061675821944, 3.079943776579579, -2.398970300335702},
    {1.1616382387513795, -2.3106934057789017, -3.1923590832450555, 2.8302535345265856, -3.4514194157736284, 0.5728688683083241, 2.662324363393911, -3.396970089089519, 2.3442170447933126, 3.266850453225494, 3.102346054588329, 2.5020894896178674, 1.7896221778793922, 3.4303771306504927, 2.4246411381373356, -2.857600045669424},
    {1.5811722103955035, -2.335334807344012, -4.128402797542344, 3.8545390178495476, -4.861966282055482, -0.011449234874358175, 3.663325374579408, -3.6366364605952834, 3.193008907102534, 3.966885144320022, 3.9734653917910916, 3.0125143772224723, 2.5953943539111695, 4.032001298921865, 3.251617958543084, -2.969300572977463},
    {1.816017203454026, -2.4321373494251746, -3.7502519616258168, 4.0692030367974645, -4.103808177938879, 0.857317431995183, 3.6177958805044486, -3.3533263978836465, 3.0927347615389698, 4.007267890322808, 3.987495578367228, 3.3669515061667217, 2.7830934486739367, 4.338189671734358, 3.372749781473066, -2.8358307341295124},
    {1.29324266460167, -2.1367098856523774, -3.88224646962164, 3.786598330542088, -4.096946754766362, 1.4169930615031552, 3.295711863041268, -3.1798977511253432, 2.665112244520017, 3.3185391455587916, 3.602158212852357, 2.730869625180657, 2.560297284017251, 3.733475392430998, 2.96993322132906, -2.7687765733702694},
    {1.904435983044237, -2.2250009446853194, -4.3791501632923815, 4.097930012411151, -4.619443323902652, 1.0340083608456705, 3.871219613804705, -3.9024060862710144, 3.1212816229156584, 3.4270140659881214, 4.032951951158491, 2.717176373019379, 2.5564609457171557, 4.263421527618664, 3.35629285552571, -3.2426235036096602},
    {2.1713196770272063, -3.012811341187416, -4.80955607261788, 4.199635781718263, -5.297238592499666, 0.40297012703413254, 3.425231865458138, -4.56966022775478, 3.157853534172532, 3.5973272845124695, 4.300795473098947, 2.89611554660915, 2.5763548951320066, 4.3807047199939335, 3.4722819376874545, -3.7821370954297278},
    {2.5087018927314197, -3.4482160890177362, -4.565939043724528, 3.8250748070225367, -4.859807439317274, 0.6362370898735892, 3.356342294192001, -4.1739637916641295, 3.458711585535804, 4.240190669645579, 4.006049423687585, 3.1560512609865117, 2.129056170193689, 4.474573488880498, 3.9008411442633872, -3.639524360515937},
    {2.774075175330074, -4.132907367912403, -4.755707363464983, 3.6693978409417785, -4.946367564200541, 0.1033657922131681, 2.816573625416999, -4.380927453757419, 3.3204035639920764, 4.185255300840291, 3.8147761920132583, 2.7435616133169356, 1.919923847269447, 4.359653647296477, 3.854180692167241, -3.8991100939830967},
    {2.0619046799791243, -3.2184328184326674, -4.709134168060082, 3.416965801782856, -5.036962744272831, -0.6276332796064458, 2.627012250742046, -4.6774294530685925, 2.925595876636749, 3.79506636982535, 3.4022562283998345, 2.3300869449050907, 1.182482596592831, 4.13859708413376, 3.5698984641523697, -4.157744250267404},
    {2.10761607450044, -2.57581356929612, -3.9584861441595693, 3.8258291661680466, -4.356665722393966, 0.4762292864354107, 3.5885328975272013, -3.4644165301847427, 3.246118512251538, 3.749431699462016, 3.820701994454131, 2.6556369287812287, 2.2902424246512765, 4.4121263427648465, 3.213902649783629, -3.2554707181074014},
    {2.473898138800427, -2.0770349248770192, -4.012540308676604, 4.233371844910718, -4.483986386407286, 0.5663599120481567, 3.812577225672813, -3.8531454269902703, 3.430243852018762, 4.4233186969494644, 4.507147893182715, 3.0994657114185253, 2.6825416264934296, 4.531621249368559, 3.7649854455573624, -3.119788058239008},
    {2.234057007961309, -2.567729904255308, -4.588993487139664, 3.8129947496570336, -4.613275792203939, -0.40856668543056973, 3.1662545515154608, -4.3047139815890345, 3.272027803006891, 3.9586480698053523, 3.6727613032632864, 2.661814270523267, 1.7322221323865783, 4.548002610827314, 3.6356860113653053, -4.099672512992014},
    {1.771152862923061, -3.245678308331434, -4.739093735034066, 3.4849850814385905, -4.3963324094158525, 0.10012427318137256, 2.8346148681797776, -4.308037840506584, 2.543799927370211, 3.3045158968813144, 3.137176949315022, 2.2385896275217427, 1.5873137146413412, 3.629970156985618, 2.90625783034226, -4.033784355708919},
    {1.399926127028863, -3.2732537012006806, -4.852706712405827, 3.316008484158336, -5.079185421530801, -0.3272498728973364, 2.815761617896911, -4.624957329661763, 2.2398324660573907, 2.940529110861668, 3.320300300879832, 1.8183730196219319, 1.4125732167417742, 3.601689627851668, 2.233446708860759, -3.8835275062557066},
    {1.8888869158693518, -3.0351326928581694, -4.590192083400215, 3.9028836499209496, -5.4458597514788, 0.18343492062762318, 3.357190988339563, -4.43134426856876, 2.705572643272119, 3.1270099431497442, 3.576551127453562, 2.480008628172758, 1.9953332052756192, 4.0163655122363116, 2.834158086537436, -3.9341660329703885},
    {2.7008968612182307, -1.9445183790464937, -4.299925686225786, 4.697915029549355, -4.556607395077591, 1.7437071215281978, 4.181462230782905, -4.114456497854102, 3.877285746042782, 4.667344498276384, 4.546581298855155, 3.8428061555141735, 3.6930384714743694, 4.82875545216237, 4.264340346187969, -3.258426951170234},
    {2.4798433404952953, -2.869109360086813, -4.836320417758647, 4.730332715649726, -4.939379411930134, 1.2344031800985877, 4.369258507617289, -4.23948174070755, 3.861144784977434, 4.381635815837117, 4.846246333631751, 3.622055112599771, 3.227821555256796, 5.040012513692795, 4.082829365516539, -3.770929451067568},
    {1.7268502904454337, -2.7389871062276105, -5.262128352325132, 4.282877634814856, -5.0515577298689225, -0.09286896124812784, 3.789977943148539, -4.774979838766393, 3.112282609763971, 3.921973838337551, 4.272551477525482, 3.012688612873269, 2.373275201134778, 4.6925861965293345, 3.4128010550559953, -4.024469454500426},
    {2.972777643066836, -2.7876469468532865, -4.917140900903295, 4.5035630159759465, -5.2927386357235795, 0.8965109967005139, 4.248392303095002, -4.923758245617293, 3.7525475851250096, 4.462446631684148, 4.5819684557811255, 3.394090870496607, 2.9419356767005684, 4.883639680060465, 3.5816322146234327, -4.34056881377169},
    {2.821462371538406, -2.83013770584595, -4.66913236297435, 4.649268285711874, -5.036542212326034, 0.8633909223873812, 4.238242070671432, -4.736671815039569, 3.7038711062169702, 4.506816881776433, 4.466809701551731, 3.4725302185697475, 3.270115348004976, 4.819945852745394, 3.7713815150533097, -3.989568867060696},
    {2.643028991651343, -2.6798538108087935, -4.666793857378971, 4.73936678372983, -5.175174445664951, 1.3068053207625823, 4.092932100106173, -4.830962860084621, 3.9418259148779935, 4.674052444861811, 4.663298497826052, 3.6621760881234464, 3.289339479354319, 4.948520344149, 4.092245974466321, -4.06590895926081},
    {2.455542819507061, -3.085540714208014, -4.862601176049666, 4.495490464648375, -5.341318800998349, 0.6960935809496837, 4.119601757340683, -4.393282928516059, 3.753302886247733, 4.448918320708031, 4.569231257105842, 3.71324182471761, 3.185124241394101, 4.8707965389384285, 3.6947607950462813, -3.672684174135351},
    {1.868295860199227, -2.983272160491839, -5.401468079564993, 4.77540497447769, -5.795911369415718, 0.11981341336441216, 4.172543748127576, -5.2715814578399325, 3.6114953295099297, 4.418661116904925, 4.564102351865641, 3.2958698885402233, 2.2385294830191267, 4.902906813694561, 3.858660397012018, -4.771690712593569},
    {1.861499949576503, -1.861681078930908, -5.36272336137341, 4.842625496500422, -5.179337312858398, 0.7601301877502761, 4.545793068597488, -4.94621626840329, 4.000790941420654, 4.617162479879122, 5.06726174201357, 3.830953662973295, 2.731349860417209, 5.048441960271653, 4.19066033563262, -4.375908224635128},
    {1.3224033786142062, -3.471490682047261, -5.625841498823419, 4.3214458846947, -6.02783725103176, -0.6459414403971129, 3.6370649051908694, -5.392394161339318, 2.9872178038948327, 4.2849788349487685, 4.1973898977370565, 2.8849437137322056, 2.147382880937114, 4.877628594988993, 3.378853097025987, -4.983181727609147},
    {1.6745770988112465, -3.438404572350648, -5.64038868684147, 4.775796992605516, -5.780902863435031, -0.13678972226772254, 4.109486384382293, -5.469144066142674, 3.6236482085955863, 4.203665379888943, 4.834241656563221, 3.2515418999269285, 2.533954420626279, 5.238625053930534, 3.7372016237191454, -4.777823928684776},
    {1.8593838622073364, -2.276629436364294, -5.494334418380421, 4.854682820074215, -5.676331220424344, 0.16688521278302998, 4.416565763259724, -4.921909286906743, 3.7286924936552124, 4.670774454877119, 4.734128506491652, 3.233233356509219, 2.60836016719626, 5.263616477106003, 3.8350849815734365, -4.609266854307499},
    {1.6668040683242347, -2.2035197469319265, -5.862177529089381, 4.957026202266454, -6.0500703136108696, 0.004136229065721831, 4.429592216474247, -5.556333714034343, 3.523747803924964, 4.427934226491659, 4.79213397058655, 3.2332827597855447, 2.633389772692365, 5.3508664385866815, 3.6513309224048554, -4.799129575037526},
    {2.2308604262588583, -2.658134757623482, -5.571055719150742, 4.73029185536353, -5.722490002188273, 0.9011198694530963, 4.418755970097889, -5.026880161374443, 4.021384844334013, 4.826020486246427, 5.024585746948396, 3.8331402853800176, 3.009359809509847, 5.05649384230345, 3.9978880125902077, -4.638217973542686},
    {2.473053230078003, -0.1760679682010627, -0.10348380172562557, 1.4580547735603664, -1.5045559889561855, 0.2967019400098895, 0.8123769508668359, 0.7878549330402848, 2.4051702496879064, 1.8503452099020703, 0.2867458205111606, 1.2441232198013397, 0.6424097686578967, 1.4056812119847726, 3.1140997427805788, 1.6838918347622323},
    {1.1923757156561299, 3.064296822212961, 0.531748309278536, -2.362608172232901, 1.767711908462417, -0.5723256542705152, -0.908089664601154, 0.3822331121902078, 0.58474470182856, 0.019914839288518275, -0.9094141850984173, -0.7445603186692079, -0.7319656593557105, 0.06484813400843784, -0.9247942988271609, 0.7643264433561658},
    {-0.8193477351402081, 1.2190788730894013, -0.9786371605437657, -2.047490406914824, -1.683031934542689, -2.4649682067069247, -2.8700888307350367, -1.1660333228976605, -1.0915691475349873, -1.4119864135234304, -2.281342234950976, -1.835701100481977, -2.6005249384864295, -2.3720419319620993, -1.542841150117845, -1.2715957363208708},
    {0.7852608808852083, 1.7923612205860824, -1.3111142290306648, -0.826106838203122, -1.2907605244275846, -1.4758671842684437, -1.3558430878827217, -1.112780190781371, 0.14426959105947174, -0.16199363841537298, -1.1784430738079772, -0.5105637467634341, -1.3049970946796554, -0.5875783094846658, -0.6188319738781745, -1.6794100212541285},
    {-1.7801082355507878, 2.845272101849605, -2.4275680292894806, -3.6760698592938876, -1.2916501261110853, -3.6317767274337722, -3.147909720337503, -2.941282751038956, -3.1679908543388953, -2.958261007096223, -3.148421391977638, -3.075319455041968, -3.6005623956856767, -3.233360787721767, -3.169139175693287, -3.125496661212264},
    {-1.5627489219353743, 3.0455591305583023, -2.035381411264659, -3.0417940803026102, -0.42413979400444474, -3.1819857588300398, -3.1835740909557604, -2.881110612424387, -2.1114026653073, -2.6821246225885185, -2.7239347155474474, -2.434333424178478, -3.3306723634805313, -2.7739675258187817, -2.7007202333317797, -2.8906495702770614},
    {-1.0323062913577559, 2.702034124347248, -1.4051792523151176, -2.2336650108645904, -1.2471274129142815, -2.016211008293154, -1.4063806567290456, -1.6961577412855453, -1.4144575875883414, -1.4569953299983198, -1.573985578920102, -1.550192391115521, -2.1730154159508333, -1.815090306152929, -1.4314170056571605, -1.6958687950874047},
    {-0.5869135424094154, 3.4077052936153387, -1.3367977793778947, -2.1600302193136574, -1.1775921953928807, -2.1725305070553187, -2.2936276480050553, -1.7661273099215122, -1.7081975743910134, -1.8619992540528698, -2.1047018535356536, -2.3390144908813766, -2.131459582518091, -2.0807696486234937, -2.0628585606246883, -1.9959402350518132},
    {-1.661934120588684, 2.783686620493623, -1.6159204597189798, -3.098797601303755, -1.3235127892900798, -3.3459210327245272, -2.816799074153683, -2.2909715453615176, -2.5911477016633504, -2.485403827625061, -2.960442382854731, -2.810122869247175, -3.325088605762771, -2.7808802556804113, -2.956560793730326, -2.4407605379363364},
    {-2.926974268980523, 3.111635858333793, -1.1073963332472607, -3.5369035634842523, -0.6503757055655562, -3.4619569594924364, -3.517677288070043, -2.129544636308488, -3.3953510599123926, -3.3902562297389576, -3.5064703100118315, -3.770504282655403, -3.9918369169048105, -3.441926976057656, -3.573725278322176, -2.0666140826488326},
    {-1.8424483849306152, 1.272516855475015, -2.176887035405537, -3.094525465925249, -1.8541458908220187, -2.9371544802647143, -2.8066783072800883, -2.1403432237453757, -2.135494971480507, -2.474768373675462, -2.8477831370492157, -2.80131167393457, -3.035336722130744, -3.05085910787386, -2.804553114570792, -2.0683289031220973},
    {-2.1230467393902432, 2.056246461448901, -2.912467547964014, -3.3249182738699723, -2.7207106424566745, -3.1018265748233014, -3.3484407532546316, -3.117648771593481, -2.9091386307860647, -3.1321172651794607, -3.5967533279942057, -3.505849559805842, -3.7438135037537092, -3.2165118282914005, -3.0224555727857574, -2.846652906353069},
    {-2.3961986949952405, 2.6250658372884357, -2.7900339347256256, -2.9352172493009565, -2.0689901555610755, -3.7152823738821046, -2.6752827094804323, -2.6535640318081737, -3.2987855030479687, -2.969166623305744, -3.046589411057024, -3.59065868579379, -3.7698877912800235, -2.9861507507977207, -3.0363125226291583, -2.497961543315051},
    {-1.9629670909721935, 2.357720251028486, -2.0842693511589525, -3.6919208017531493, -2.082151062501386, -4.05104832203164, -3.6144024094656144, -2.4838847360959866, -2.794206177531327, -3.0624443160857355, -3.4156171715655255, -3.411700334088229, -4.00439383597394, -3.359199587248161, -3.0904687905408226, -2.3252866756614776},
    {-1.9888862178808462, 2.6073201736336458, -2.078248743610914, -4.040508118704538, -2.3287126361083854, -4.256792936986286, -3.971876623868588, -2.7070430510018464, -3.451160393038254, -3.9557489021730112, -3.7702196930922276, -4.316907146263946, -4.650704450479125, -3.6183685803879047, -4.004162839902143, -2.3385355142831474},
    {-1.6121306621857505, 0.7767767896506282, -2.82209381540058, -3.1186490296596876, -2.9952596791236816, -3.7192077472300653, -3.1952546610314676, -3.0127097963162757, -2.395282208789921, -2.4338855306104796, -2.4707893925049875, -2.8279505588050156, -3.1677022767692202, -2.385597660073094, -2.2678746453513647, -3.3434095627478517},
    {-1.2092081829919805, 2.0391400131838693, -2.963831095328177, -2.5612900733480313, -2.9705020379573006, -3.4063628621032156, -2.8588055378211727, -2.4345223218594145, -2.326214484419624, -2.5857664495947867, -2.425473978915975, -2.9764502377312665, -3.4925114983091627, -2.7308103665816117, -2.2666049956761642, -2.7800078697656625},
    {-1.8522507354636184, 2.0957772165809976, -3.076937585338764, -3.1487824329731526, -3.1810171910725407, -4.262243649978073, -3.5075807577115685, -3.204241982966154, -3.215963433006837, -2.907146318870004, -3.398777515227728, -3.1400532459836947, -3.743642413261158, -2.7911697893240794, -2.777919761722014, -2.9289267906914076},
    {-0.2595071350556565, 2.2112906121838214, -1.8764486258658735, -3.303918198475549, -1.9478324481228746, -2.6570632960590865, -3.4885593123693877, -2.441967577590678, -2.343703633361247, -2.3600883299055706, -3.2364444210257757, -3.177698209809165, -3.6528167308663018, -2.7422064229262966, -2.885065861829808, -1.761114000191317},
    {-1.6559510857389452, 1.5877573698408631, -3.2087728000307076, -3.612732553907101, -3.955442731694068, -3.7508599824280537, -3.7161525994269744, -3.2160398571674143, -3.2773987912318483, -2.797042537009221, -3.4498687846762413, -4.021077286217269, -3.999997827940199, -3.3093237224553285, -3.1389156024311067, -3.0155180568709214},
    {-1.6306534568042808, 2.6222319809318733, -3.81220783016724, -3.801447098433941, -3.529627111348792, -4.09745541816914, -4.000969220759018, -3.316076429216891, -2.9957769445609586, -3.3583696508115963, -3.8265935683728958, -4.098587733396132, -4.14946726603913, -3.839676606093122, -2.6689400290207033, -3.332275509624662},
    {-0.9699372845703658, 2.7346145923205816, -3.334215346468347, -4.016370377108924, -3.4030835886287925, -4.293786523588082, -4.503630908818415, -3.1075930081080245, -3.204637222236201, -3.3361274689923626, -3.9460054517877077, -4.2974599514300955, -4.49945618215728, -3.688087668720262, -3.1241864375473436, -3.1965177184383067},
    {1.7056970469850212, 2.230436688228174, -1.5000692560474405, -2.378060461880596, -2.3436076426302916, -3.0518669276493156, -3.313089449690309, -0.9974349045887528, -0.9910287256596887, -0.8309450915925373, -2.3394364952738234, -2.9251174893026297, -3.3837695587637855, -1.762245851697782, -1.371771631233149, -0.7152241509863732},
    {-0.21526357066640348, 2.350335831386265, -3.241888464996008, -3.9524351266965607, -3.6262291331748586, -4.257613424229323, -4.365901841941119, -2.8943877904300597, -2.615703934196985, -2.723775931541386, -3.7204949842722193, -4.165621492080009, -4.492670827264854, -3.383852995376797, -2.770889468723449, -2.6554176484532137},
    {-1.2938310074721944, 2.152308624560491, -3.456012455969219, -4.7450614627677945, -4.29708174881032, -4.554268997060934, -4.881314282055635, -3.5630889682169586, -3.538875372240233, -3.3204278652708292, -4.736965629335728, -4.611210728465369, -5.017552663862532, -3.9939446157639216, -3.7222033768362746, -3.16720329955202},
    {1.1811953466242548, 2.6157317097450337, -2.8930106405714358, -2.438045841836592, -3.018809433868971, -2.540984805848284, -2.7395126884720487, -2.483560630440867, -0.45684365076761785, -0.5517525460990825, -1.9849700308043914, -1.8513219992771988, -2.5993604848251657, -1.506136070308258, -1.552969272900812, -1.9961588346403827},
    {0.13624167993862552, 2.38208924848577, -3.3031224249609017, -4.1317907817491974, -3.3230765220130416, -3.585317677315625, -4.230003813563708, -3.5075645591041273, -1.7951407550719267, -2.156556749055539, -3.479484610496271, -3.728831013677369, -4.063096402221395, -3.0752917542643257, -2.2367842638127096, -2.773532573701113},
    {-0.5549589685853819, 2.5423970655096495, -3.777559606030015, -4.36422966517496, -4.263727748692586, -4.0420895097464715, -5.018250217096325, -3.812041292445093, -2.91808951932853, -2.916926768636978, -4.044676460325198, -4.4978893013136085, -4.478066679546515, -3.7675061991136958, -3.3182907040522247, -3.299245183345126},
    {-0.08802280473903398, 2.6365658961059144, -3.6673459380493734, -4.307033046831756, -4.094155355369127, -3.9083995154461952, -4.416437308793498, -3.7575710729277136, -2.1560907765541883, -2.4745451868104653, -3.623293010933352, -4.3301790963616, -4.135457120296342, -3.0404032246724384, -2.730171048757438, -3.1331837382239476},
    {0.9759676680813545, 1.3210543780289714, -3.473157692299567, -3.0261911092053504, -4.1073313984330575, -3.3845251612505796, -4.542071594623517, -2.8288187129501003, -2.172915831585378, -1.9172596688450725, -3.3257367660880974, -3.6300052740801534, -4.1938773833919845, -2.9748817975519946, -1.3173942086303676, -2.56188098749825}
};

static const float b1[16] = {7.50582316510196, 8.740470441360543, 8.048284511906116, 7.188185316789498, 8.251751413797509, 7.20283555123105, 7.2726772020725745, 7.912132464050291, 6.995468125213612, 7.124526895678584, 7.318577546204084, 7.1321228306625475, 7.399271108438743, 7.200019076244209, 7.299500566814481, 8.021794070402096};

static const float w2[16][12] = {
    {-3.549341434227358, -3.3745960236913013, -3.290179312609002, -3.7413216077554052, -3.3367676584807207, -3.177398074807656, -3.9680838413708277, -3.8451414966531354, -3.3336580079862785, -3.9166375366399553, -3.8648484322263514, -3.609487358290204},
    {-5.796474637307827, -5.5568796421972655, -5.83368645197393, -5.985271167893911, -5.839539743832476, -5.728046281472178, -5.625327245312864, -5.652716592342017, -5.566905016064196, -5.671588608427435, -5.6584486150674635, -5.649463764549872},
    {-3.898294738463508, -4.374183731408827, -4.044222698023886, -3.9218183520924486, -3.7323311059293807, -4.552247175305479, -3.562436450856469, -4.757198781745224, -4.028638488516155, -4.049448881501885, -4.255974756617708, -4.019533224596989},
    {-3.4439850845033613, -3.274684279350596, -3.5434847143917807, -3.8832903068027287, -3.4629018184757574, -2.9957540296353162, -2.6533914199854625, -3.3991966934572195, -3.432496652952827, -3.028135303189434, -3.5363800371734726, -4.301523774129},
    {-4.705923317508956, -4.6998647797168625, -4.340075363040283, -4.5591904127871326, -4.608163744819737, -4.41828941489805, -4.610010063145881, -4.243886799919176, -4.680131110210688, -4.5031669806389605, -4.424936710509463, -4.523134114560687},
    {-3.402585227669338, -3.551410237955827, -3.528743783244935, -3.172720505852557, -3.684846043425834, -3.4937215489902322, -3.1696302794728903, -3.5486370737920305, -3.562367899813678, -3.073126262465987, -3.4493363497350997, -3.2794637394277624},
    {-3.6127373168918218, -3.672810306210427, -2.9730267926275262, -3.545222015528926, -2.901119642396857, -3.578487144355183, -3.7787933864299497, -3.1088636022180878, -4.005483342688394, -3.4739463543751246, -3.7002858416071716, -3.0050208162716876},
    {-3.681790334348519, -3.526766679751128, -4.3461698083624665, -4.1080580435812175, -4.123223774839937, -3.314595240483141, -4.430957963746439, -3.9575213081671046, -3.6972156954330506, -3.9535226667322156, -4.470929611997217, -3.967587525327395},
    {-2.8257670903238155, -2.6346004192873087, -3.6502449568563033, -2.720115099639265, -3.2645441301774225, -3.3818625272681655, -3.911870550948079, -3.367495174684236, -3.613927772050744, -3.5475208882996987, -2.559459893407568, -3.8952284615638337},
    {-3.8715294100383395, -2.9917344208121235, -3.887942853702632, -3.6291286027818477, -3.70491549863993, -3.491715506795811, -3.1585600249059604, -3.795536788995778, -3.2911989395851453, -3.1666879838102715, -3.337469743770728, -3.4254465335582696},
    {-3.8233415701771047, -3.55511454215774, -3.995954598808674, -2.9702149336857873, -3.747831401242713, -3.3044327088859506, -3.7046079213105583, -3.8128384234200836, -3.185041764298837, -3.4669763295147726, -3.7378499338008546, -2.927604221591992},
    {-3.2151729392294484, -3.6167144945353846, -2.866748588182276, -3.687870560972371, -3.1601689901660395, -3.702208286473642, -2.8871184934862004, -3.413008611440358, -3.743262962772771, -2.567002013471427, -3.9795399611140176, -3.590069247835076},
    {-3.3740785683790255, -3.538236564728394, -3.479708762974708, -3.5702883135976546, -3.395343678943012, -3.646185184441307, -3.4013696152184534, -3.1593714733355993, -3.2997808890177356, -3.9874309929040277, -3.7274180161222943, -3.198234246139144},
    {-2.8735308121232896, -3.7555273684522334, -2.945851670640037, -3.3032256572041034, -3.8372524621533786, -3.991884303217059, -3.596146838673328, -3.203876987188778, -3.2852347795109513, -3.81183813832993, -3.5440385511462407, -3.2803156976814587},
    {-3.82529337003161, -3.9899055260419907, -3.5981444123992934, -3.5955113823375995, -3.2579268081650015, -3.0576186739964246, -3.792878643273668, -3.4559236777159614, -3.299816658855457, -3.8425504537791664, -2.682966940270447, -3.335010400535441},
    {-4.180349026700395, -3.990767545451221, -3.6432069301025685, -3.81773017596, -3.931837603346063, -4.163770202699317, -4.02177456336222, -3.526302799868472, -4.176388415533121, -4.020946525484228, -3.263911554417252, -4.0500814671229035}
};

static const float b2[12] = {-4.2072949738421945, -5.967038024745133, -3.3635618249849197, -3.6221517805442893, -4.2517793802830015, -3.200843536430728, -4.310708560199076, -3.8326233210026937, -3.0135023629878015, -3.812303071539736, -2.727082587590124, -3.0071768590928616};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
