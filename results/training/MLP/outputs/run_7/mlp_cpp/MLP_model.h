#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {2.201020240932594, -2.3359846146398047, 2.8645177663779493, -0.49265006353893076, 1.1166932230717352, -4.136956606902416, 1.9998479325797862, 3.166859466362077, -0.4650938744575995, -3.3377905176444926, 1.4129879771233507, 3.0842094567283107, -3.1783283961525473, -1.5340168208008689, -2.222149366255663, 3.665084492452611},
    {-2.478362679726491, -1.0320323242628187, 0.5709120105250588, -0.05164143649817686, -1.1049186828913389, 2.056155298077837, -1.043116670508899, -2.3688531510911797, -1.1191131966787544, -1.905901509050693, -3.432402945615463, -2.5062050273319088, -1.1574632864590473, -1.203615460027897, -0.01241676661046313, -3.1167892448121184},
    {-2.0368863250953617, 2.0629858932988947, -1.0247061476516695, -0.9302408354037822, 1.2705734181149886, 1.2124584676645456, -2.250000455558669, -0.24294762110589488, 2.3592206027676355, 1.3054315942417316, -0.6800972802319488, -2.576154121938351, 4.603118165304113, -1.105563117835559, 1.9422544234630645, -3.1805646876125304},
    {-2.287334916689385, 2.1821648827028506, -2.954823800909265, 1.043770745782928, -0.21957742259698346, -0.7547707047972968, 0.45765942195659554, -1.2300163233022015, 1.2225175743876482, 2.8393399573800395, 3.0115981079215564, 0.3041509006303947, 3.6397321586205744, 0.8051865322869538, 2.3449196911097006, -0.18816587969721635},
    {-3.3052214506209774, 2.4553446311684866, -1.4027590876417206, 1.7039789589515046, 2.7557446660588654, 3.266795348154921, -1.97108832291882, -0.7252838258218782, 3.4255878654972016, 2.6212688565292077, 1.5354321077359738, -1.9384431447358448, 2.9988996575935096, 2.4384592434854313, 2.6641238089087906, 0.4138080219213455},
    {-1.3332251555481978, 3.050039372064327, -0.03108831742150463, 2.1502572946692755, 4.940528567838671, 3.638591186419945, 1.566786058588026, 0.974596434404768, 4.391409411593374, 5.736000611061908, 2.2942820646720463, 0.7594531618805029, 5.099687546269931, 2.973310933898219, 3.8820572098025674, -1.396089951905053},
    {-2.6184482120834955, 3.1562247465318825, -1.3024532963244577, 1.3375941972164815, 3.352803710994498, 1.6567996543337282, 0.5322124144430586, -0.17971977830791233, 4.289345089388503, 5.6237716989970155, 1.9715709771732475, -0.9129076132560173, 4.094881343191945, 3.028311255583197, 1.4943845777976443, -1.2266975711968202},
    {-4.413540116901625, 2.6955701465424164, 0.33028649051237013, 1.5911842730639536, 1.2361676378271875, 2.353440315353743, -1.5450329392227058, -0.15151993647828335, 1.553691080239593, 0.8764813601196572, 0.11442176558514702, -2.3895773987640685, 1.3975077338075788, -0.11431173457420596, 1.7155465069083429, -0.24450756287718928},
    {-1.0073490893319403, 2.765774628556283, 1.2926779259330352, 0.7935179505780974, 1.8555203549908217, 3.7142964699890726, -1.2618860988872058, -3.147386137712583, 2.5956142539591323, 2.5661463267576967, 0.10794022605455036, 0.03577839960862024, 2.576664933596169, 0.9453190140891892, 1.161417350851141, 1.058866467592187},
    {1.0882647079227723, -0.8143134966402277, 1.1171016292799092, 0.9231941070786016, -0.7222127922019002, -0.34627190151706627, 1.719478734783595, -2.673199341412828, -1.3208162939511903, -0.027438156051252664, -2.6475656826432994, -0.29973719707058044, -3.2514064283360313, -0.5287293800313065, -1.0430235103741758, -0.5113374667298554},
    {1.272788718212065, -0.9722787444496054, -0.973315621152273, 1.5577989523289593, -1.2160910967829524, 1.5105132408763111, 1.1506050482508534, -1.9322056179376839, 0.39765473575784643, -0.2648020482401048, -0.1870755201559666, -0.4763826029537709, -1.816381540100225, 0.9077417665775173, -0.928510849814444, -1.6488626988986834},
    {2.7224103012247096, 0.7079112055035436, 0.5056933770658969, 0.36483364040970656, -2.6019216809670094, -2.774300782177171, -1.3007305089658012, -2.125251065618865, -1.4269815791980776, -0.31749027797629, -0.024875239683673025, -0.10290085513063266, 0.48105213536092895, -0.5050231334221346, 0.18652657658007454, 0.5738988320131261},
    {-0.05108214695920297, -2.9536059673534223, 1.079270590988968, -0.4436939696774388, 0.4262992840962736, 2.131709314420635, -1.9593907576792577, 1.3443730119609236, -0.9177266065053952, -1.9575595891750244, -1.4629395881169944, 0.8508305649729733, -0.6681665852102223, -1.3912780966960758, -3.1192830247491443, -0.93082031439},
    {3.313427207636494, 1.4459489383059403, -0.26983153826004214, 1.8052692834168167, 1.4994598260113927, 0.875409285484415, 1.9416641079590689, -3.2426623181659266, 2.5512510390479517, 3.58718240342231, 3.062545470428411, 2.793639583385083, 2.595917565195946, 2.522549241032857, 2.7547675883565605, 0.43801704327484015},
    {1.4987655482588311, 2.5349822450373916, -1.9345453673676665, 1.6834648904477705, 3.5755366579142294, -0.7468366610432999, 0.6840201463717398, -1.064466678124718, -0.15708701585522075, 4.656067896038683, 3.043871041503635, 3.2642160862242138, 2.392089168312993, 2.354404511650203, 1.1145066272490096, 2.039286229040801},
    {3.4275590609780027, 0.5577608260702467, 1.1867537491658573, 3.3904973880675238, 1.0127903478727671, 3.412009718594053, -0.07079194607287839, 0.7222246660837827, -1.7320169456972014, 1.4116473123357518, -0.3730695214219818, 2.673453326663956, 0.13846826280594146, -1.8071340496325257, -1.9133602115624369, -1.256970893731356},
    {0.9465098296497315, 3.245617378717946, 0.6799399800032117, 2.000592621578376, 3.0719565716051114, 0.7715737424876529, 1.3787967661956693, -2.0080599104091332, 3.5515486837599153, 5.327316024082428, 2.9049587747881316, 1.4282873285947124, 3.5727493349536226, 3.2813479076637555, 3.071389908148012, 0.6821765539379083},
    {3.4626063629845496, 2.856523577217096, -1.7635867069331095, 0.8121784132277747, 1.6483122913544297, -0.09934673651992501, 2.7139873149798324, -2.682738996231017, 2.6231388851905764, 4.109223988046307, 1.9786406843766913, 3.6130687881232233, 1.7134216446571304, 2.0233793531562227, 1.4584346211297607, 1.0013133098768343},
    {1.4556422297977858, 0.9182633786174952, 0.7611142136808972, -0.31905105033956616, 1.5439673184898823, 1.8572528801156811, 1.2688319085867603, -0.9482507152060006, 2.6896671199070004, 2.4756923412962917, 3.0760566673145338, 1.9043048555481112, 2.046069856584918, 0.41525145467574653, 2.0001292001346562, 2.0447031689317865},
    {0.9693301460696057, 0.13150128201515776, -0.30298074983073586, -0.8224625531599274, -0.5009819635999402, 0.4118282957956853, 1.0128957233367482, 0.24436726447986426, 0.7597921890617765, 1.6924885629123954, 2.4641615234608483, 0.9580237081530931, -0.5479584424310445, 3.035243212835632, -0.19635605196023478, 2.299678940140751},
    {0.4874006617677655, 1.274933364194079, -3.0785969349193545, 0.7390149576601852, -0.6572508288190417, -1.472310585694875, 2.002564393149846, -1.5827014356506117, 0.7580449930267102, 1.2210999700018648, 4.224643576367987, 0.9081927282301894, 2.1262459668304023, 2.2000626758347996, 2.7090265874707513, 2.932267055811756},
    {2.002060972746836, 2.2316537876253366, -2.5864368170436394, 2.165182416771556, -1.3037254881834635, 0.20776572380243644, 1.6749135040515222, -2.2835036193387745, 1.391666008022851, 2.899123748400754, 4.1038656034706325, 1.3752693186449436, -0.6252590372435203, 2.226152836389602, 0.6638586912904508, 2.2499373324967733},
    {0.9854069798437486, -2.278603187445869, 0.2924700636182594, -1.31628941167793, -1.8740133734319873, -1.9492437600569505, -0.20361876914476762, 1.1934257683701512, 1.383537619800475, -0.15557376236553574, 3.8976527313225096, -0.31445424575212155, 0.7078123499984287, -0.2996958393519464, 1.4529366173017588, -1.1749814171809925},
    {-1.7574883478047327, 0.02834997618134184, -1.9738781953443325, -1.998031909980713, -3.250494846752535, -2.401454921233648, 0.0845633468860523, 0.5017210947326688, -0.22845683722343987, -0.272648083563924, 1.0763487739946473, -2.1422658500763285, -2.338763027230854, 1.0764242933915373, 1.7697185062466316, -0.2739125515747958},
    {1.5402867579493371, 1.0304434805244216, 1.655274290958447, -0.3634212723602762, 0.6448263791803578, -2.6317130068536128, 2.5283269402519384, 0.3271067334611915, 2.4194456189931106, 0.793616696309741, 4.196765120226114, 2.1093424805138152, 0.42831496094321725, 2.171502429141852, 3.7882782918172375, 3.446519330179049},
    {0.03994560702776177, -1.3641211344459283, 0.1995955173244831, -2.1936263143430015, -0.38262845323231853, -2.6952416618671022, 0.09793989018014386, 1.9656868185862557, 0.9065764374726437, -1.7904880388323003, 1.4593103939507834, 0.48269073871432505, -1.8318192843507226, 1.469362100061215, 1.0383810735777312, 2.529192987957338},
    {0.6647044859620008, -2.5682128369958566, -3.6345395001334446, -3.6675702705362188, -3.481115790297267, -5.532983962543117, -0.6864912296213364, -1.2907018883427794, -2.0121463382805787, -3.1243042590028614, -1.0924043357772772, -0.6284887187411793, -4.869869525734113, -0.7238682753494595, -0.7789650946404956, 1.7634807479475645},
    {-3.1728884292459827, -2.1266258456888716, 0.7643000586112385, -0.9445762913424692, -0.672927469940729, 0.6715168307491581, -1.960963437570419, 1.1479362919577805, 1.5150086306525747, -0.9236201400591527, -0.8608471110435275, -2.8832501923925524, 0.8118574119340662, 1.0325407330171756, 0.4048365826841629, -0.9133269813806955},
    {0.5710445658785775, -0.7656550322744093, -2.8626584867366685, -1.7619028729294697, -0.6936862138713223, -3.1512198427634237, 1.6729209052931384, -2.6236762823774935, 0.6472685658774289, -0.8182758612169471, 2.035136565831326, -0.971422619101439, -0.017380992400275727, 2.602369252621515, 0.4901869780960925, -0.11856060264368205},
    {0.8743112847841561, -0.21625192398234447, -1.963845312424852, -1.777913954095769, -0.9782581979945922, 0.325680233637727, -0.11058662638367328, -3.1014437995889006, 1.7933731699495628, 1.7649816586834166, 1.2122848410860743, -0.5973367443445454, 0.6301882526315625, 2.1334599729946815, 1.5679701460642272, 1.2726990293930307},
    {1.8469641908523826, -2.6596177714342777, 1.1019199653469967, -5.313132524915111, 0.9502598331558794, -6.217153737100494, 3.2873028153907686, 2.3832314975319457, 1.5205082898574793, -3.6445197989957974, 2.062793571129301, 2.2371701143937113, -3.6974046750785905, -3.4254267458695358, -2.278612693364506, 3.0547835787467297},
    {3.3588251623832157, -1.9795081394164469, 2.9220140011368003, -3.8645024255658407, 2.3302352063857774, -3.196626152508904, 2.105824584376297, 2.000894254650589, 2.3342552150192235, -3.6863039044674135, 2.424369384223276, 3.51353969236443, -3.0964652473686995, -2.385869108320197, -0.005596908215421963, 3.1235016816944494},
    {3.1591662334744015, -1.677570783862328, 3.594035373751234, -0.6786543034888606, 1.2222636127843214, -2.7615406664600326, 2.6303768088846455, 2.295109099748907, 0.8276981517400495, -2.159882039844697, 0.22991439600532296, 3.69684638286697, -1.6327679687680754, -1.3091229461484566, -1.8197284879455988, 1.8082560943833719},
    {2.41245631359856, -3.0346833865434686, 2.83527752913399, -1.5651171329843303, -0.7622428234783658, -0.23252436695681045, 2.5636149155266237, 2.8603082390920833, -0.05056096716501803, -2.3311132935606462, -0.4324837159956682, 4.52186108927784, -2.340104250102221, -1.7303148921606057, -2.295748430588717, 3.3105147633967347},
    {2.8840474865816836, -2.1937873453983285, 3.0359496288066867, -0.6509538050129553, 1.9589063760608456, -1.7097043112104227, 3.4636924246376637, 3.197344928443708, 0.826873681680588, -1.2066373572002216, 0.1937358529874627, 2.9167301734709703, -1.3175220475707374, -0.1961311371619897, -0.285138727786793, 1.1609955041728937},
    {1.44456390396975, -0.8816936638578878, 2.1627213506345586, 0.0634775762185499, 0.870022666821962, -1.6461115976703669, 2.065807239739994, 3.3364239990258975, 1.1514655718942168, -2.494553478833751, 1.4408645065769008, 0.8100526365689584, -1.029473468579437, -1.810898609883473, -0.9120883312095537, 0.709748938728374},
    {2.696332806600926, -1.3547835384623212, 0.888103333704278, -2.0076797438997938, 1.087098782440555, -1.2171105311672545, 2.4875166154077766, 2.6594126487117307, -0.09369295095947146, 0.13703139278712892, -0.3956587779676218, 2.249574697451257, -1.073707200496291, -0.7374102413237302, -0.42243184774114595, 0.9356564682564751},
    {1.7665034434222877, 0.4936544793997402, 1.8870374676177237, -0.9412648049957668, -0.44932846662626974, -1.8669452283986425, 1.7788590729390077, -0.591055228266873, -1.292461358007073, 0.6127337940736637, -0.0057769284363755795, 2.086313808092758, -0.22431001180750235, 0.8253302664344944, -1.6031130591705232, 2.0550863751373316},
    {0.6712680612711659, -2.0634776032675113, 2.5439671702108626, -3.0821320048048646, 1.1159012327261493, -2.171184834305243, 0.7835334427047426, 0.605405505989222, 0.4699391905872009, -1.0432425230488878, 0.9827048281849939, 1.5246619028952373, -1.5104322676787343, -0.6456385918743942, -0.09481134885121828, 0.5192713425416965},
    {-0.6393831800509421, 2.3246472606783346, -0.49777265780129437, -0.9634757920378886, 0.2742045958870883, 0.4576949658881293, 0.08321265177035503, -2.56293993597595, 0.9620835386192321, 2.0883382803232275, 0.6496956740408202, -0.8793979669572348, 0.5290878515396084, 0.8411276037743959, -0.6206234978028908, 2.452867805471798},
    {1.701466782119723, 0.3264670034753385, -0.32078592132924777, 1.1729748846935568, -0.7107516817343014, 0.17979319645239727, 0.6932585472548662, 0.42531946412142185, -1.1583548005486612, -1.0017402490439917, -0.00048419974870578703, 0.9508860276014794, -0.89364842247585, -0.7507249983348591, -1.8659512770095033, -0.6119438570008305},
    {0.8302338140195443, 0.17505474821941974, 1.2839953412578502, 0.5406630241943682, 1.242947643867574, -1.792727413355611, 1.4196658489079148, 0.2474879835601044, -0.48417799834693925, -1.1177665884965435, -1.0016819605873577, 1.7046037004789145, -0.5542629320408822, 1.9504734046117485, 0.4501406428317176, 0.5615890529550499},
    {-0.2541835996154379, 0.9548190881130307, -2.8807499024717145, -1.0155969139102998, -0.3454683240139488, -1.5231585713811955, 0.644968854301215, -2.88467074306431, 0.2865760621964055, -0.012438958247504628, 0.13621835648190914, -0.5541728317783486, 0.4923640224619491, -0.15746709540610931, -1.290563380194132, -0.07146400238864749},
    {-0.14072330957095905, -1.570963905696063, -1.0435675068889974, 0.868323865138242, -0.9219585298837092, 0.12979078923792284, 0.2988802022766493, 0.8525478014943951, -2.2476661483849747, 0.19553331497019627, -0.6943766153720781, 1.1164739775574803, -0.4228203483235818, 1.5468630575441273, 0.4592758093343095, -0.48083887890491145},
    {-0.4962643190291833, 1.372040705507465, 1.0248921530392439, 2.9457718048687567, 2.1257907101195945, 0.7134938314397071, 0.7236819360396564, 1.5608575545070034, 0.4669976150535903, 0.9090123418615763, 0.5664458543194858, -0.5834969691301198, 1.7886293085118108, 2.715346279765365, 0.9351251237980462, -0.34593377378033385},
    {-2.243074842119215, 1.512436095131463, -0.9842143969761626, 0.16160065702043427, 0.989496427869913, -0.4134931659131709, -1.2107432573270582, 0.09997174629695602, 1.884915519732847, 0.5355487006127326, 0.3121069490755831, -2.755830713098116, 0.8149353743211627, 0.47695637415974235, 0.22789598308489858, -2.1473341679379137},
    {0.718103738657352, -0.5964328230083826, -1.2926837791594905, -0.7039880076119275, 0.6446162965160347, 0.924871623850173, 0.7431686588258687, 0.8217458187616072, 0.0041159537976437266, 0.11083502723288646, 2.0851544705103673, -1.398714582597003, 0.1598971900286172, 0.9671886720010434, 1.1013793407766133, -2.571294910481227},
    {-1.1634165977289646, -1.7860227900062817, 0.28082907658824463, 1.7772254675397177, 0.08465915640553169, -0.2770346290166753, -2.3242087319257263, 1.4323112121521098, 0.24957764996810194, -2.560086808664267, 0.7726198927528697, -1.4674163212628133, -0.2053506324737378, 0.004787905109821791, 1.7490262790588682, 0.7761196871921993},
    {2.1570720026137042, -0.12185310569714891, 0.8069635063469691, 1.5396190910159209, 0.13661563953455286, 2.2430602035994127, 0.5471138539727036, 0.6350821839710621, 1.20947978700436, -0.49124749521409883, 1.181754091237963, -0.6118928198162844, 0.7500207780415973, -1.1848786216323886, 1.4259322407855255, -0.5289205292892828},
    {-1.4673852307116928, 2.2151653165054435, 1.8627025433194655, 1.1060722425366407, 0.712720527315004, -1.0046774138157182, -1.4861832492988587, -1.6583919382252728, 0.18313942724367904, -0.462145435954984, -0.7573119469842773, -0.5798249039809085, 1.7809516669109668, 1.7847124449801517, -1.2057425749437405, 0.4214560541455},
    {0.0748927520254958, -1.2410825942883612, 2.4894448120848143, 1.0975286632785721, -0.8068839542112455, 0.09112412774964872, -0.8896203235453928, 1.4842393047479208, 1.9619083374507502, -0.34233655311753364, 0.06927377926525946, -0.7342823102322461, 1.6794816081481654, -1.8230322787591695, 2.2315062445349336, 0.3893850262983389},
    {0.5702224305768466, 2.2540331439141306, -1.0730100561251312, 1.1590157702007744, -0.944048837146604, -1.082904537131593, -1.3462652581420913, 0.9971166344238559, 1.2896567195381146, 0.3279403067118405, -0.9887685175135726, -0.16185262746741647, 0.6889849726439436, -0.4199840130024452, 0.676228328573454, 0.9682575353855992},
    {1.1166037741913049, 0.464108079477772, 0.008230487855910181, 3.0765510289940816, 1.779826447317389, -0.7185862203394029, 1.7999376812410142, -0.0062564547090266445, 0.49737502660051325, -0.068920338676068, 1.0813518243809959, 0.18850780130037967, 0.8592730850150073, 3.406500917768075, 2.9131543801952064, 1.3913757315935922},
    {0.08394248398778353, 0.41782217029223506, -1.437918579201021, -0.011072924738884594, -0.8717223581217448, -0.04973658700064198, 0.47122973070273194, -2.3221943229697026, -0.34034818537032624, 1.3267043001329721, 0.5319961137093796, -1.7899079343911566, -0.34920287781220577, -0.37655044977315133, 1.3167990591328262, -1.2953488857240711},
    {1.1137200872348783, 0.8623428786809433, 2.061624753764164, 0.7954601083794328, -0.06483556038737828, -0.4341339084764739, -1.8838231635717466, -0.4454116338573888, 0.283947583362183, 1.4148272493395109, -0.4723728542457924, -1.311875080732437, 0.6154928596296303, -1.3749453311856548, -0.025473071811283155, -0.6844920390310848},
    {-0.06226655507024711, 0.8499251935915043, 0.06962184430857056, -1.7081048612289464, -1.4253481717607337, 1.0068561996016048, -0.3156571701441964, -0.8197643448996249, -0.9399712761156209, 1.222978959961895, -1.2856292719787608, -1.5058414112747205, 0.8821985608329371, -0.2241552178529166, 0.3777819536214125, 0.7169021289062454},
    {0.0759221572000297, 0.8721206291914655, 0.2792800530909598, 0.42714472152073957, -1.6130102820374452, -1.6111563483892253, 0.058516727869370386, -1.0204279252702995, -2.1875457911365963, 0.8179374265214632, -1.4795671503455332, 1.6907023068118296, -0.3151503034749158, -1.5063355239491543, -0.8221112192879101, -0.054158398092533325},
    {1.1632503991933758, -1.634002679741542, 0.046569477638974066, -1.3414655028252567, 0.03624320975604734, -0.3285209099422394, -0.878722003728017, -0.715871879876828, 1.662067879034708, -1.0627331392734385, -0.14626350237199084, -1.3021815808597559, -0.6562748778385076, -0.7497587320029533, -1.5034100212808414, 0.7148596609635794},
    {0.15494158741639225, 2.3998302402454557, 0.8996668867874629, 1.4137369511817994, 2.2715887390683953, -0.1327670161530478, 2.3813122825862494, -0.005956923868123359, 1.7409777415560914, 0.9903241885533088, 0.8558142533612519, 1.7782114861365377, 2.1787105314249526, 1.9040433110649626, 2.0621342316113553, 1.2932449992358452},
    {-0.7568148914482798, -2.1552321248595563, 0.7040507528458761, -0.6426830128195212, -0.7767187869486364, 1.2702329152941016, -0.8977932679835061, 1.9750681008737099, 0.372436162832409, -0.14314905782693463, 0.43964465805462827, 0.7940243467479964, 0.16190618948531665, -1.719959735293873, 1.8651128453380688, -1.5399662490063077},
    {-1.2521851469205547, 1.0287027561534832, 0.19179976062954388, 2.9339298190772576, 0.8642625313607144, 2.677535264721906, 0.31845980564348686, 0.2222424589337045, -1.7938031544441715, 0.037223475727952586, -0.9202914016516717, 0.4420326959181976, 0.4701386332195913, 0.8363973011762702, 0.9515789676944907, -1.3389432839610296},
    {-0.7555286398229785, 0.9634867396016663, 0.9932856370908004, -1.4489928329874024, 0.6182657488785451, -1.3923203743060526, -0.9314402260522925, -1.2375675215550734, 0.5594191923203106, 1.2344851295945138, -1.2611465091562997, 0.35708753499935003, 0.2843044370161321, 0.6875387103165409, 0.21720326187772904, 2.187802045711281},
    {1.0460162892447318, 1.1970328722798678, 2.461732647600173, 1.1435328366271125, -0.07883300520048155, 0.08775408861506621, 0.8341118194561495, 0.682914796423135, -0.27870035659005576, -0.23762506385412113, 1.9584140584053742, 1.122552441457834, -1.0826289230985744, 0.943907538878127, 0.6623459953764882, 1.123520852264498},
    {2.4861115140170154, -0.01312093797715201, -0.8660698716683831, 1.4043962340634952, -0.8351254360491281, 0.5869526323694946, -0.14040986362383673, 0.15094505950028772, 0.14960881288477662, 0.913701105574656, 1.2336648605532883, -0.11786705446088765, -0.3442345693031394, 0.3792739264795406, 0.012240870919465302, 1.5925493483876327},
    {0.20611733270605476, 0.8702190467575085, -1.6438527540810277, 0.29845880286212045, -1.37650680974801, 1.5752918946230334, -0.0004998624444084239, -0.4393906195062362, 0.9262639658950182, -0.6632548271161872, 1.3802894114583504, -0.11234788397465965, 0.2981707614647977, 1.440696838750092, -0.7763893757223203, 1.0269468321985684},
    {-1.7091335594136865, -1.2227744395595248, 0.23262801635967043, -2.424572377592205, 1.6052721654615618, 0.8716325721641298, 0.22933963789039735, -1.5460594770593414, 0.5673776532666225, 0.5806143812284794, -1.2132183558781082, -1.4019637186679978, 0.7655309600437409, -0.21605093854895344, 0.2982759986427414, -2.476614332810997},
    {0.9852220991525424, 0.7496181378967044, 0.2963110117262745, 0.9588822775454978, 1.8420005388577632, -1.4515267876302123, 0.9260846220274571, -1.562532319922964, -0.3933056341856063, -0.589240636803392, -0.8011407975266889, 1.2446733269726329, 0.6971869397669298, 0.4943353716295042, 0.14880194793873983, 0.42913886660612605},
    {-1.5868046569008234, 0.12791198065969586, 0.9523231561160066, 0.3839885685749578, -0.6460078459669554, -1.8121321977607543, -1.0296909918091683, -2.1203947674350596, 0.27620281856507356, -1.6199027403767916, -1.4263165845155497, -0.8347947937915872, -0.5852539785552978, -1.0485711314990307, -0.6488366165383372, 1.144397998249087},
    {0.29776078819432633, -0.5768250795070893, 0.2710272303269907, 1.4764477292029154, -0.7527628463733087, -1.3560341318373974, 0.3360098211571164, 0.3199169849389386, -1.1939481011076731, -0.49824087722093335, -1.6876627469870842, 0.9353317253057775, -0.275857619826014, -0.8089212480156437, 0.5953871617206734, -0.2896660836494354},
    {-1.3231537381776008, -0.19480858999086048, 0.9909700366578387, 0.9142375304558468, -1.3503895434021922, -1.5869316985108162, -1.1068898932387845, 1.0836261964515361, -0.0976044052284956, -1.02551696703187, -1.8211477141862877, -1.6167463691705233, -1.1886790533294824, -1.5058620805070169, -2.040241933472539, -1.2092366636455492},
    {-0.3129291152890278, 0.11600823127813858, 0.33238661064633135, -1.8837574974128997, -1.215029765838009, -1.1404576331563963, -0.14991530194547675, -1.6530190922999477, 1.1473192231287248, -0.973109096182136, 0.14452196798032027, -0.46217537682666165, -0.614265138559613, -2.271254366923367, -1.316454019095915, 0.01213989701276734},
    {0.013278720191444495, 0.45519216673883767, 0.2916293098053244, -0.6150152313009124, -1.2548388280827583, -0.5286906771453774, -1.1431518405735648, -0.35796347344299995, -0.3643250669373601, -1.162357773286541, -0.013281895090339123, -0.01253782417770637, 0.5070662493047845, -1.4746161337027166, 0.24884762643068417, 1.9796788145424495},
    {-0.09204492181453407, -0.3771638281349219, 2.7231551538164065, 1.0434595790936876, 0.46183431641128947, 0.8173920853250692, -0.13066671571555566, 0.4007713709721282, -0.6236331553624535, -0.41232948908407724, -0.44535646836525405, 0.4308643111822333, 0.5616470437672353, 1.2002985420046848, 0.8285384183798011, 2.1688134495175992},
    {1.7879678989387433, -0.011246857927003332, -1.9801873101790808, 0.3651744235541105, 0.41719920457424853, -1.2160494087900942, 1.720455595314037, -0.683624964444986, -1.0367588820541194, -0.06045483371470509, -0.43540737779134325, 1.7623141444910215, 0.4518933731050773, 0.8303955873553396, -0.35212558623744017, -0.17249528095936248},
    {0.287869379435815, -0.8249956800876495, -1.6816012127944457, 0.08509139229881514, 0.6949287035659081, 0.15884038324652408, -1.0221016477880773, 1.173076584357025, 2.7497737093667287, -0.4669018686609542, 1.8604785915476663, -1.1246729822717707, 0.23441881843208584, -0.2664318622765864, 0.7628686761848104, 0.8055513371606546},
    {1.1631346321724496, 0.21003764122786422, -1.5138878903583852, -0.7499015859457006, 0.85450128970507, 0.5574477897419231, 1.1460648569554561, -0.11576966463243787, 1.0171912090819528, -0.28242125931448653, -0.8867065352538048, 0.5902045246300198, 1.1648605871410869, 0.5625680902483564, -0.6829420393709024, 0.4909108811926326},
    {-1.0663852986714717, 0.7386452871426809, -0.33444796741774624, 1.3696319889522586, -1.5657901416798032, 1.5055834793441873, -0.4537914534751763, 0.2294876777993232, -0.8725719458244383, 0.5611063262974686, 0.11479147291390154, -0.8838941468661393, 0.11823918588732528, -0.014112615669596314, -1.0305789559968228, -1.5642170876946355},
    {-1.4562043857501472, -0.6621701899578034, 0.8369952212710857, -0.7909707069762817, 0.4386232683171428, -1.4784160215100328, -0.3633341882446308, 1.1011925088846053, 0.3673157810521988, -1.188520165585839, 1.0732204587611782, -0.4260144476005013, -1.0196736531810253, 0.1368468661073442, 1.6479205784236959, 0.22760009132660375},
    {-0.7356633430527137, -0.013258966950233635, -3.1623434506540162, -0.23721558883036484, 1.304110022775928, 0.4689839806190067, -0.7166435846820083, -1.7375662541241936, 1.4353860455366938, -0.4150381762573326, 0.0482801985779845, -0.8707639813324051, 0.07725521937452232, -0.7174527424088286, -2.0897302518478447, -1.8209705826493259},
    {-0.7964388390397766, -0.041912695455463805, 0.05588091310919395, -1.4713302102380055, -0.30528034920231495, 1.2899344593150095, 0.06736826423549855, 0.7592467192821344, 2.077926108131353, 0.8560343826367754, 0.7501313743449838, -1.1267122971927939, 0.8254842529486751, 0.3519585703593886, -0.16269193645197452, -0.43277376596318134},
    {-0.24551349605103642, 1.10169598625586, 2.3454379052870387, -0.17316676905257442, 0.16637219448229928, 0.11442633365869816, -0.5985831430168027, 1.759721184426985, 0.9843339646383128, 0.07564745963538783, 1.0681638466495076, -0.012657492553690976, -0.15532779038608335, -1.2380757380563112, 0.4373901690412638, -0.5544598803010873},
    {1.5682848692592692, 1.0467799680533245, -1.3785172959787046, 0.9588924302089845, -0.40213745635538567, 0.5041368091547062, -1.031756808719262, 2.2308336707355423, 0.06478085580679491, -1.0305055282259663, -0.3566899645227291, 1.7942559973968744, -1.5946534004019932, -1.8503539359133747, -1.7669467637902994, -0.7049274420771852},
    {0.04785124657103775, 0.9313770262213366, -2.7208360138978502, -1.152455958896851, -2.0812863870125398, 0.16645406645091285, -0.36239293356954344, -0.19022590627974514, -0.29713433994543814, 0.25729040287043686, -0.7830205089790724, -1.331174759556449, -0.4604840844743416, -0.9748217873552016, -0.17315723412022035, 0.6243847257699713},
    {1.717118038799793, 1.3195019454226868, -2.1835898355849857, -1.512414741721344, 0.6150925679046959, -1.2172115309746931, 1.6230324946022, -2.1137006750859912, 0.6831652434793039, 1.468004805236783, 0.7987628878676475, -0.16157342950404083, 0.9096927396634569, 0.639251818779112, 0.29685258790909913, -0.9593645150801562},
    {0.6555443894114803, 0.4826284070722592, -0.5510881047289705, -0.690127934496381, 1.3997253461402792, -0.2496256056809845, 2.1866393255044207, -0.5763343565992157, 0.06511132728386093, 1.032656247557899, -0.38651520479348195, 0.32748513481246877, -0.30255581728820086, 0.40387699645268926, 0.06320529308897586, -2.349136709067199},
    {-1.3159386610582746, -2.1766122596408315, 0.5270842111757803, -2.5320014813934266, -1.10143607036754, 0.24412157016877625, 1.7310378840253793, -0.2937836546682988, -0.30211852576495957, -0.2719601355993737, -0.9875220586190466, 1.7997570319172984, 0.16243006831581433, 0.695358288681329, -1.0226700075634787, -0.9929924125805837},
    {0.7053600422229794, -2.7816257045629214, 0.0845828403535097, -1.7092776026572387, -0.7422605629682679, -1.6161725685744357, -1.6153222659725037, -0.7120956223385708, 0.4603509795470229, -0.9380752592884761, -1.2353033704277971, -0.7680722275905412, -0.21936537841506507, -1.288328068965319, -0.2544326888963733, -0.9084107399662485},
    {0.8714274547662165, 0.7400184813536776, 1.0167771331895246, -0.057869447830862335, -1.6007061542015666, 1.0679057991538445, -0.5503162673384457, 1.4884308386018137, -2.049347207431509, 0.5129489441740288, -1.0314590896380096, 0.39195763596020666, -0.6058834521332379, -0.2601190372867957, -0.9116231894535307, -1.0250279405373217},
    {-1.439247846527873, 1.2395920841642911, -1.2917230541049982, -1.325597452906009, -1.31509911173548, -0.1560930284707999, 0.6223117649542913, -0.26123683645438933, -1.9304876370710027, 0.2619700112836409, -1.8703175907110834, 0.4474050090277485, 0.20307433516606935, -0.16301917313215264, -0.7779605007819882, -1.045066896987796},
    {-0.30295976483808906, -0.588356678998973, -0.4022463712490672, 0.20340397069217322, -0.1566413824236837, 1.9241174734937947, 0.21074965119789493, 0.9494329776859736, 0.014339299518176871, 0.43593392031492034, 2.226730150157813, -1.2070132249776522, -0.031289190313955655, 1.4705274842701155, 0.9988995339529485, 0.4966181806994336},
    {1.9131689187722452, -1.700062366542484, 0.6253486236063258, -5.483673561184563, 1.6606046796933627, -5.1722753503132655, 1.5637420841388336, 0.6247000806272908, -0.060546873451697104, -2.503638573078865, 1.9324129419537737, 2.4015561496544047, -5.141997516006074, -1.7884160769058746, -3.0330297388342573, 3.2703729406373383},
    {3.1386002219924727, -1.9560224260634256, 1.5193936563240087, -4.912634839800457, 2.1666702668320186, -2.3141155625035434, 1.3889670641264515, -1.012924638849612, 1.3147509034600051, -2.1373328873027195, 2.637424786418889, 2.213955667800002, -2.2009750347644044, -0.25235489480380535, -0.8279594058535659, 3.0286812803644465},
    {3.8475469474104362, -1.824100831236542, 3.9028731254609546, -0.3018080785955731, 1.5699923382412617, -1.8920864136660456, 3.510705252040189, 2.419444477639987, 0.18094738247338996, -1.8311548145973513, 1.252580204750102, 3.89466420764882, -1.6197922528323125, -2.2387442600862113, -1.1047138099356797, 1.5499252105331562},
    {2.867999397710161, -2.549789555134054, 3.5436298506529056, 0.27304667431699936, -0.5923872055525025, 1.124202167152865, 3.0316639066707127, 3.5070961419553828, -0.08687256290330958, -3.0379640079958787, 1.039627365323774, 4.202750495151527, -1.8450421518641793, -1.706206584861972, -2.2778028300740685, 2.1936548734876533},
    {2.613310235514849, -2.87145255216448, 1.2419164102359654, -1.7711437454265337, 1.2534185104517395, -1.8921083669127194, 2.072194447754943, 0.5054462880668683, 0.19145296326000552, -1.917722110619865, -0.9040331834171131, 0.9370669949113146, -0.954618777202536, -1.6706446412099805, 0.13033531274406301, -0.5571781449977374},
    {3.6875060429096767, -0.5316648235408099, 0.44678081739363307, 1.1062935352313685, 0.13858932938482246, -0.9765851099677015, 2.4285141465691975, 0.908310994951582, -1.2646062637804576, -1.4489984159978717, 2.3424059585226935, 2.2440297208095523, -1.447353958199123, 0.9303953883964168, -0.7552071204498632, 0.9275401191389792},
    {1.863003251926515, -1.3904647823518506, 2.460315634875301, -1.3199829259925613, -0.68675192485089, -0.6059746819875492, 1.4954137220809753, 0.7268005994236023, -1.5307998304844002, -0.8896536714250559, 0.7165818290306248, 2.8837823940565066, -0.22701805747857653, -0.13447041697484458, 0.07388581923393703, 2.6219504427756872},
    {1.6001503093409124, -0.2979350883162754, 1.8086108019972897, -1.158445468054241, 0.6406488292827063, -0.19226861175582194, 1.0871096674202554, -1.93724299996911, 0.5205584125707954, 0.02007951757607804, -0.44893900254693647, 1.0079489967743918, 0.24878178369813048, 0.5861559847236062, -2.0365530721673335, 2.3894051739881217},
    {1.2732920559620677, -0.7633572786348523, 2.937654497388121, -1.9231729620504312, 0.5073685363600534, -2.1597962889951012, 2.097541352478985, 0.8554153303642146, -1.0830823099959521, 0.4719010153442929, 1.3155318991595544, 2.4438193674959767, -0.07575518353656298, 0.673001421460803, 0.6320116514666099, 1.4934086458574798},
    {1.1562100100137853, 2.839501369276421, -0.008061165760192165, 0.3743410053793675, 1.624351151878241, 0.10138669282274035, 2.32840554462725, -1.7910532668117565, 1.703367928805502, 1.5574552632177983, 0.06675475565781432, 1.2547665764794382, 1.6336025440555404, -0.0669856017684936, -0.9449554935272264, 1.966451441608353},
    {0.7641020115068428, 0.3603625309718398, -1.6687054660811835, 0.8813615587308206, -1.6185322986897959, -1.6942675757491712, -0.44207449818428823, -0.7360720884050546, -2.659148928531982, -1.1625638723346738, -1.468173393814797, -1.3736658114894624, -2.2579184631339277, -1.6370126934156113, -1.081070400243362, -1.92129849696251},
    {0.38168957281140886, 0.5306529326390786, 1.3984349654449257, 0.6510092010367341, 0.586235437921353, -1.187398755093414, 0.1161956813263293, 2.011310139225074, 0.8657274423916227, -0.6655296793463369, -0.505537867731294, 0.26328966245145063, -0.567212204774022, 1.2432812311159274, 0.5411578444266575, 1.5511404909129622},
    {1.1120298990951452, 0.06688678943700135, -1.201308506833447, -1.9862492136870074, -0.5246897225936781, 0.3301194431166009, 2.6066493291905704, -1.109540971821353, -0.7519257128151642, 1.0943663743574847, -1.0864746511889158, 2.30150498460807, -0.6917238041142593, 1.9172096984581652, -1.054101162224984, -0.3841960204328772},
    {0.8596130155957984, -0.8913104264808407, -0.5262996163123899, 0.6048655354487942, -1.5042414435873193, -0.6216176414597665, -0.8968933569764634, -0.7002002514804437, -2.19165345850704, -0.29249015079956686, 0.7132338312536258, -1.0760715219509283, -1.38953278800648, -0.6758021708174139, 0.6252000701202796, -0.7427243018998492},
    {1.3333037742314509, 1.7812381317930117, 0.6322218860034106, 1.2905912364209484, 0.3846423246360822, -0.26057467556781677, -0.4259106016012723, 0.176839539684451, 0.8874013634286599, 0.3781561397562974, -1.086445052882119, -1.440205031417207, -0.6889831370284132, -0.3309233276052642, -0.3684076684100719, 0.24310293867550184},
    {0.30720523316723714, 2.041119947143912, 0.48198449589948833, -0.8135956206740504, 2.76769873298048, 0.7400856209690135, 1.6330413882504404, -0.04039306958069812, 2.633249774430106, 1.2556764345159341, 2.0643278403542764, 0.07059440276140377, 0.46280652376680753, 0.41427969413981564, 1.499049357930074, -1.1141613142799944},
    {0.1625136074670476, -0.07836921712276759, -1.263455605385823, -1.1769904580930868, 0.1722516579541064, -0.18482661522067148, 1.8627007203646804, -1.08081806301892, -0.9108611320860498, -1.1850708557858336, 0.784474635179396, -1.071857981958876, -0.8559793821854536, 0.9972542374216424, -1.2437491114297377, -1.4724004712943004},
    {-1.4159057140862126, -2.4013566436036915, 1.3198854186550855, 0.24404707591089952, -0.6831646509160454, -1.178551710097913, -0.4839831096095576, 0.878753547025595, -0.012771447405459874, -2.7046380189273678, -0.6960664235815297, -0.5857884277845258, -1.6375622359989257, 0.8159752075123681, -1.1798329531521128, -0.4809460120291119},
    {1.705594216142106, -1.3940520742568643, -0.3460240754989474, 0.32217572949785633, -0.4516871405402962, -0.43808542879998424, 0.8731006641176139, -0.3364835291002228, -1.0902059472656065, -0.09951412776963142, 0.31313858011856915, 0.27654263600604506, -0.9114771782557264, -2.3780696559568724, 0.014571688385733098, -0.7816736447103537},
    {-0.8284382639018922, 1.2916561674825442, 1.8442235908355753, -1.1904201860805719, 2.230548664368642, 0.2545645742320701, 0.8750300955025453, -1.6110056057640358, -0.02974752769011363, 0.3604486372322947, 0.46549082885124, -0.5791571319172761, 0.37704668745407577, 1.789289397049686, -1.2328797563483673, 0.006186107694629031},
    {-1.1706083895098014, -1.9174073733105215, 1.9796231649819995, -0.6402287197748147, 0.1899693628063455, 0.18224829724101924, -1.2671820613363092, 1.8817359679782757, 1.036250350467785, -0.2992830271093631, -0.8497744972816337, 0.4394611113383131, 0.015535020627803198, -0.14109374647526657, 0.42407902926211605, -0.9364898932497382},
    {0.49384999257851714, 1.8406382621677733, 0.8734173457249893, 0.8203834732713402, 0.16784808710280888, 0.9278665916020167, -0.07627851985978104, 2.117882684466561, -1.074422983478144, 1.2576019171418744, 0.9699654165520062, 0.8066643510213632, -0.4785728270258198, 1.519685285658632, 0.10326681602989776, 1.704555105551212},
    {-0.44218220329816205, 0.2466843998733881, 0.08610446945425873, 2.5862980929934953, 0.7093095622493422, -1.0367868790239954, 1.0390435456373495, -0.5401221386903228, -0.885077531400437, -0.23464521367195343, 1.7447382727866372, -0.27208599656710636, 1.6030552068960808, 2.2316043728619013, 3.0077686391553597, 2.1038119008401543},
    {0.3003089028208037, 1.9282758593485179, -0.5775827819263183, -0.47825977880628173, 0.6951565353848166, -0.47766926106895186, 0.719201181069715, -1.2420638594142388, -0.4855001585197576, 1.4360892050798497, 0.9586048906257079, -0.08747820683787008, -0.16560026383112159, -0.19599505295907296, -0.09966047254092303, 1.33439629935231},
    {0.9529356138194548, -0.26895098402682965, 2.3302312785003982, 1.329983582128496, -0.9187709164321595, 0.977443905033614, -0.6410917431871406, -0.8883125888434033, 1.5366944172498656, -0.004042565734872991, 0.21567783222203948, -1.4703058868256236, -0.7284705925386638, -0.9385727243065477, -1.186740264910868, 0.26797847516938145},
    {1.039092909711547, 0.5644594007857996, -0.7635838717417418, -1.58764600655532, -1.4558222798182263, -0.8482925602224609, -0.8023900414249222, -1.4411985334183697, 0.4559426850581337, 1.7248181235255984, -1.3119123566390887, -0.5626589963306486, -0.8439771945729335, -0.3181519648809793, -1.0810318296324253, 1.191388821502247},
    {2.3927719141518273, -1.6756474176792473, 0.2550692217777729, 0.3726685221889253, -0.7739182139603097, -1.2816682602881908, 2.126075996970318, -0.9772351282239459, -2.8309575221858654, -0.5793820554292416, -0.37116636547608095, 2.4592524071322686, -1.4388629991189863, 0.7111443479024896, -0.003178395464061243, 0.46746572456500474},
    {1.338657710407009, -2.162041841379533, 0.2500876485971978, -1.9516078322902315, -0.7687884641646834, -1.6343958140109847, 0.708823846840653, -0.4529036567207702, -0.6671218827663579, -1.2868898730126603, 0.28413118435660173, 0.38762824526492246, -0.8384970531882507, -1.0668968863338295, -1.6692645222100753, -0.3840776466380003},
    {-1.6505207520633347, 0.49195440427352743, -0.47986704455155876, -0.5716736191853655, -0.06489622169577582, -1.5566504586419134, -0.5283837418939572, -0.9741598810495429, -1.2356872157691146, -0.48714655575956195, 0.8187023236164344, -0.8161601014481975, 0.16773162178962353, 1.8440071332261616, 0.9444030407490693, 0.6692979697841711},
    {0.03590037862513314, -2.1660615321464185, -0.45051015664523897, -2.1665206882086525, -0.3393001537609504, -0.08272462038227345, -1.6966827332151393, 1.5950605539569076, 1.0147349667771937, 0.762585088811343, 1.2012145032365167, -1.1885167315422414, -0.4699386161029968, -1.7820475766011306, 1.7034237056468857, -0.7989484378370766}
};

static const float b1[16] = {6.554243819113929, 6.245254396850384, 6.965579739102389, 6.986080417939204, 6.020696653746543, 7.039624191833964, 6.543303783987103, 6.888772224188154, 6.958993271117323, 6.493489024765882, 6.743910957822728, 6.617830633533295, 6.609204196241295, 6.888220606108413, 6.413867162904001, 6.643425893695457};

static const float w2[16][12] = {
    {-3.6093534281375876, -3.5092483092883806, -3.586529771622654, -3.0131439081448854, -3.1836078111142347, -3.760260564789354, -4.290091800957737, -2.7858099987613176, -3.4311700397093943, -3.497364675893789, -3.5439107889872936, -3.1677752134936523},
    {-3.5155691804352496, -2.533670875862293, -2.8081677997219687, -2.6436812041509916, -3.096441425102545, -3.0861557450799966, -3.104381870739495, -2.946029108976388, -2.799042762134508, -3.575073175993605, -2.8209481434848507, -2.500273342226646},
    {-3.525094857389714, -3.366350470609833, -3.7140862581187037, -3.1576240739300694, -3.720010808937946, -3.482672996802504, -3.6249297081178358, -3.841350979605173, -3.3423750504782777, -4.016212214839773, -3.6767215609326116, -3.1399327436686506},
    {-2.8437267427367456, -3.4346357730673036, -3.6004263519010857, -3.8722168001373283, -3.7245450894341343, -3.533599373723191, -3.2795810453066316, -3.699682407975287, -3.7819102487890968, -3.3700863729215387, -3.6238092946222933, -3.536113600247529},
    {-3.2452141640600303, -3.227237751174828, -4.072170987159047, -3.380993268294283, -2.707219638825915, -2.1443693248831197, -2.5487797990254193, -2.4347631904424683, -3.5460484488884125, -2.6285642830341063, -2.8449272093725857, -3.589957846791164},
    {-3.2428259942263327, -3.3762544546897195, -4.033587906793631, -2.369877625966611, -3.0009261102963323, -3.0781811857074155, -3.589030493040741, -2.69635623249381, -3.558477833215166, -3.8227896222595867, -3.831774404668701, -3.7011012220329884},
    {-2.8117506927610774, -3.0489337751795285, -3.1381207895917, -3.924302150190981, -3.1135342306357003, -3.4064288984541515, -2.989661832582411, -3.8558952241842293, -3.3348456053546967, -4.128394162217275, -2.51694883404048, -2.7305022069275164},
    {-4.116942802351748, -3.9203276143712786, -3.826938722434947, -4.10585068564214, -3.2535313426935515, -3.7466425593716344, -3.4139168951571994, -3.3063640579406592, -3.8915453032824816, -2.9226112388946834, -2.873988111413659, -3.620179732537627},
    {-2.758432334863604, -2.731985053951872, -2.7861048143413876, -2.7799136784130782, -3.937105609645104, -3.513675900164527, -3.2407202264479147, -3.850440111316757, -2.8702417999334755, -3.4252325415281497, -2.79485548710207, -2.7624246471162444},
    {-2.3041663596498902, -3.160235052083656, -3.078450844479142, -3.972833151667622, -3.2805829604833177, -2.525801551898342, -2.883785371548867, -3.7459708521357173, -3.787464968394885, -2.6701516087846264, -3.0345246849041962, -4.369860030636683},
    {-3.949242639720516, -3.0379950668562326, -3.0231808089700825, -3.90814645405621, -3.4666712378948206, -3.254767163035015, -3.0578271089569893, -4.186070843901374, -2.62730106604123, -3.2444500558642084, -4.210791614565716, -3.9563544815924114},
    {-3.1039348140281837, -3.094346131529026, -3.001389838070187, -3.3621947792529183, -3.9944345944047526, -3.240919373827387, -3.8459241302102405, -3.654012982943933, -3.2886915518037343, -3.1391396565519853, -4.393541594874743, -3.9052721725410677},
    {-4.094700204593406, -4.323328917607449, -3.872492305878724, -4.514967458718669, -2.7011295041106367, -3.868281958743203, -3.10850023608292, -3.598842490059776, -4.212471524987346, -2.388659315294536, -4.539388486687063, -2.658443737890983},
    {-3.5385040635446403, -3.0439069387639934, -2.866681311995701, -2.8224262119998356, -3.507867906583583, -3.972843108934172, -3.877433233375099, -3.6884045355072317, -2.989358033502915, -3.389437799890108, -2.6906791160090884, -4.071394631418315},
    {-2.983883889879948, -3.1041007687144786, -2.712635820019473, -2.3589823703503288, -3.1021839068110255, -2.8799059323261584, -3.0950842124972575, -2.8835300525723557, -2.801320811426507, -3.965668798495073, -2.9003872444895222, -2.2257583148055375},
    {-3.864965454580551, -3.5916203373021656, -3.5799295883329423, -3.5866487457392737, -3.1926275936951893, -3.279813973683961, -2.9303124494250254, -2.822384828524403, -3.460170514440463, -3.3565597615393026, -3.029167375639806, -3.5959257921634267}
};

static const float b2[12] = {-3.634240575761329, -4.1086612527306094, -3.751338911386449, -2.643234932956639, -3.160097438564663, -3.6790858346959094, -3.864939737776197, -3.6793085629609688, -3.153400599513776, -3.3924474944182808, -2.3007925747166342, -3.253783999845487};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
