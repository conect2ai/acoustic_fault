#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.7601808078501667, 0.6865904874076671, 2.160207279690918, -2.3347964686965392, 1.86763027272292, -1.8660604157169915, -0.9382351884089941, 4.680957543937175, -1.5135368795141328, 1.6379523183705833, 3.581743376332717, 5.215021965027919, 0.7934153844598462, 2.9161298081222897, -3.734631053074379, 6.341373474238985},
    {-4.740626833326743, -2.401968204674179, -3.9360079558690595, -3.1866691191772585, -0.8438864248920077, -2.687047212570786, -2.3407644285738596, -0.43793463133989785, -4.706636636328886, -0.9127220042241625, 2.707639126160522, -0.022700804449228507, -2.3290745506822574, -0.7429069184793898, -4.246406140013182, 4.643249108636273},
    {-6.216265576293441, -3.1640772781521203, -4.223437023111175, -4.949712826875549, -3.2627081995538245, -5.386767100954402, -5.806350634365429, 0.6288759008803602, -6.320555614219272, -3.523662484564086, 2.3654165737198727, -0.01267034397033599, -4.690050827758812, -0.2058136228678929, -5.06688592512598, 5.991049040163169},
    {-5.794769339255761, -2.9428440265227382, -4.1911051002657755, -5.980371994014419, -3.0735489904057616, -5.484267780748566, -5.0416089146575915, 1.8202449686670572, -5.857527748449948, -4.701492736401413, 3.615946444943041, 1.7001629056957097, -4.6529075881887625, -1.4908222997525498, -5.96116650616761, 5.940546186981673},
    {-5.876145892970317, -2.007733344479318, -5.006038448551536, -5.922959292391743, -4.779252698906203, -5.873437609570089, -5.035438769272798, -0.256077538937926, -5.933115738937515, -5.18507486687695, 2.2204380649614364, 0.09051640363893107, -5.614665459852906, -1.9206720454135005, -5.89664643364904, 5.126227864287507},
    {-5.5924413407027185, -0.7234590743228934, -5.0322397038850015, -4.833531344904967, -4.723376584606987, -5.8925260502871, -4.600083309531699, -0.9844026024903707, -5.7756138104610475, -4.690782358713697, 1.5551577723723113, -0.16330421530775724, -5.103782641661042, -1.728258755914849, -5.441829148677671, 4.742285560766056},
    {-5.008460854798324, -0.3727340912889558, -4.8935766303422525, -3.7267130228978003, -3.7854222167266354, -4.811182690152387, -3.5054353641334783, -1.6263595167031322, -4.973338051426834, -4.1595456508094015, 1.188485734671768, -0.8955038507250409, -4.08247296684243, -1.6891503498376663, -4.553914544513189, 4.328330412085199},
    {-5.151561970106427, -1.0518183127437082, -4.24204828180171, -4.4276710285848955, -3.4937308418730506, -5.384116416186059, -3.6384269920487124, -1.2338000844175394, -4.8421157486916275, -4.6148899325735675, 2.5964104283559895, -0.6561638509343403, -3.1249354294374276, -2.6041791053702217, -4.879941022721439, 5.061570669808595},
    {-4.957283505895288, -1.1490876356667086, -4.5065441786324865, -4.811615987570402, -2.659286756515944, -4.9417876359344115, -3.292822525220245, -0.4288180338696677, -4.706490141988793, -4.569027222689754, 3.0865181926621736, -0.6242447055172856, -2.806950953954002, -3.018324561338575, -5.187593498241461, 5.149178215173923},
    {-5.013042746980926, -1.2096547395042256, -4.970975100187402, -5.025026491034327, -2.9106670331655806, -5.071515394839497, -3.4523409758913264, -0.8157326983209762, -4.7494436983340975, -3.8091026710518454, 2.8880929041937957, -0.8708186839669717, -3.359909343911836, -1.8935841654821997, -5.379543203014121, 5.372914850054634},
    {-4.048977572089346, -1.3162920704310987, -4.800532641448586, -4.03764657445469, -2.4894339192962534, -3.97548243927951, -3.1831740064329193, -0.9393700621234444, -4.365434231466393, -2.806009134821038, 2.5644222568603285, -1.0867657173656602, -3.510527381068315, -1.647283742981211, -4.273943393866065, 4.268716748954526},
    {-3.649507329378677, -2.1441951958268013, -4.326264315573447, -4.286494524208032, -3.554086967496458, -4.376899868032197, -3.419915180814591, -0.5367366845632162, -3.907332170325376, -3.6119679339804716, 2.760257058147086, -1.1908634193642336, -3.604075459571395, -2.01532727794321, -4.431984630412111, 3.7009166548338337},
    {-5.144981973775238, -3.473525720483963, -4.41659736683504, -5.138576461852356, -4.346047428397974, -4.815625189580151, -4.866115644158765, -0.17079078349572846, -5.108844712636139, -4.255731586398383, 2.186211449951431, -1.489633561676304, -4.471897161859093, -2.3444526272862705, -5.341790033389438, 4.185244809442605},
    {-5.182792000044387, -3.133779720303944, -4.748165549523413, -4.847868541442446, -4.493393806640327, -5.3348503036829, -5.093739503850298, -1.168917171556978, -5.331423895525842, -4.8174481882055575, 1.8349997550025043, -1.7390917221550077, -3.9646838811683947, -2.906083269560569, -5.259900782868145, 4.367553568269816},
    {-5.218625287870307, -2.7886332215062666, -4.781957257206491, -4.140434113912242, -4.011190147582659, -5.022544758955996, -4.667857927106054, -0.8143517422670465, -5.107490241048072, -4.431093344758794, 2.6542845426620927, -1.2978243168939447, -3.1549239066128845, -2.2222303978425937, -5.1120053367333735, 5.506991245690539},
    {-5.67869507148182, -1.8155910397175399, -5.469771397995021, -4.516440081975063, -3.7004150930467326, -4.942315321331923, -4.6625980085509955, -1.6737323350942643, -5.510372228127433, -4.4947970241971875, 3.123525964828642, -1.9317535106677781, -3.5711192646656746, -3.0271219329415278, -5.142738284996084, 5.704787083671018},
    {-5.860460964882893, -1.621682202324567, -4.9761598141639345, -4.312354042875111, -3.5774971256742156, -4.959558044193804, -4.364973670601237, -0.8142698443929864, -5.848593883695422, -4.319753356784223, 3.342334950542739, -0.8784426743206315, -3.1217935302336492, -2.557494583951769, -5.049674914959741, 5.940650480135427},
    {-5.348333643139431, -2.703246648538693, -3.6471710296545026, -4.424725950564183, -4.153023223222433, -5.134289397228978, -5.2596126497427305, 1.061211899285629, -5.335312250166483, -4.198533614459136, 3.681931537331945, 0.44718080077801864, -3.3034950719658993, -1.4347111468514504, -5.040408248100674, 6.8141318600444984},
    {-5.447895639526103, -2.571860956259712, -3.3078256017021643, -4.5122752458656255, -4.432944238981188, -5.4898527776159645, -5.172984475877713, 0.9227458306844051, -5.070103717739786, -4.684614011244542, 2.8538137868718843, 0.05618688446636657, -3.6503540222065722, -1.7941807540973074, -5.3044520500583925, 6.4595126443640885},
    {-5.273974496440013, -2.441581506304935, -4.319674361948393, -5.194021141339225, -4.642276521662248, -5.829973205397173, -4.6083863816604245, 0.175858721313808, -5.23391336971977, -4.507060430184152, 2.893919101056644, 0.16798310491038432, -4.161329933557868, -1.9675305733898574, -5.371155703283901, 6.540759121268619},
    {-5.484476236579375, -2.693721031737275, -4.271778540781203, -5.35535353214282, -4.201810539172771, -5.679038216556627, -4.535773057910565, 0.4247773796821648, -5.20283461311231, -4.481566577117217, 3.066936283370968, 0.37165622207364474, -4.170987724804699, -2.290115726051015, -5.715477852576909, 6.147494421314445},
    {-5.449091586193555, -3.44576271644391, -3.768749104312434, -5.172306863757275, -3.4966226091553003, -5.379810055769767, -4.601771206585214, 2.064108539088654, -5.078704715381105, -3.544763722156739, 3.604768228697737, 1.4244117656101873, -3.7227316048657375, -1.42046164438787, -5.609006250641439, 7.170473928906095},
    {-5.344972428642944, -2.730132342910497, -2.4475306047742014, -4.557666397809937, -2.9962632515929615, -4.470882946301854, -4.65214131973649, 2.8533941169327104, -5.098785772348286, -2.5824857393803398, 3.804730378696311, 2.459000957609737, -2.946032235492775, -0.15898867504381575, -5.177300943891403, 7.3004517771066375},
    {-5.160083857124272, -2.7072550222151324, -3.628681688300074, -4.653944527930813, -3.4173808298822195, -4.9269846154874894, -4.307789863757178, 1.4497535691624306, -5.0730788687995325, -3.4714135729632005, 3.393031987320926, 0.8490796746811707, -3.073587948827841, -1.7475326393685446, -5.209945768078288, 6.404417000589555},
    {-5.37314907767809, -2.892098155097109, -4.81071753205366, -5.119382626858852, -3.3224846419522054, -4.955010217459705, -4.059009121487552, 0.3765123318926082, -4.973646882218348, -3.579100123451163, 3.21210995527989, -0.0919019970814375, -3.840598003189787, -2.3996454556546998, -5.087545242619196, 5.592804933034146},
    {-4.560700593607277, -2.4110981734609975, -4.124498761517913, -4.537551824331144, -3.217868959115094, -4.577368784699799, -4.229672972093957, 1.0921295170626282, -4.37947273331845, -3.428735427374305, 3.3530400111822045, 0.09564314324221039, -3.470216881958756, -1.388672770619099, -4.711718173811117, 6.206502717600268},
    {-5.766007453583926, -2.86236073904855, -4.548381032286183, -4.794188935853497, -3.0446599749218386, -4.554058341268083, -4.836904084824362, 1.2151251103650758, -5.665600543732289, -3.5563031490634613, 3.5540479193026795, 0.29072656928685414, -3.6236667750186378, -1.4063672436463932, -5.390824027027764, 6.304956450563118},
    {-5.820162703718643, -3.287817311631428, -4.9503938279447555, -5.481549720783724, -3.8100596391659587, -5.346114425713721, -5.4047926074942305, 0.7100218380754825, -5.871719619518695, -3.963385050354078, 2.968202632704764, 0.17323413747253774, -4.5689777332906365, -2.1216641010458757, -5.907316955183874, 6.318442808862446},
    {-5.6715603143408, -2.752526420025903, -5.239952311358846, -4.872066556354127, -3.9647029222242316, -4.80365454097837, -4.693905286738073, -0.310006864393523, -5.263825377360204, -3.38553961752627, 3.0002305786709353, -0.5979827518421599, -4.212077365479052, -2.1046991969357944, -5.470404754818803, 6.098596443895055},
    {-5.604305660410955, -3.3109041612685717, -4.980803366721051, -5.206010735237004, -3.2315667945149986, -5.107303238366497, -4.290203002173473, -0.45617247115136084, -5.508445683946103, -3.1502637383852505, 2.7577761647500805, -0.7540799745163085, -3.4488262792595576, -2.7357746801775393, -5.767982804866721, 5.443381900987768},
    {-0.5034953675065402, -1.81739818066248, -3.4697015279752166, -1.7275313234370224, -1.2518755344543557, -1.3862194209428524, -1.6170504229399578, -1.6926292558224092, -0.9484881091408641, -1.892616211433265, -2.2174873041865486, -2.989423703464937, -3.0981101737248427, -1.1502552390171306, 0.4918877888997924, -0.5167069878245169},
    {-3.005265472048888, -1.0265873219108852, -1.862736443857697, -3.309199603139105, -0.8405269007711966, -3.5217918812386793, -3.46748018423388, 0.8381546274356608, -3.119130383834108, -1.2361500549852662, 1.1148807614941842, 1.0490205756552566, -2.5054383031598033, -0.17531111849885755, -3.142055428682964, 4.009673394214334},
    {-2.788464444189156, -2.1567141318204235, -0.6788657916072518, -2.932299408592051, -3.137055294141502, -2.8989561930393295, -3.572263974926597, 0.07104273523171384, -2.798899236665763, -3.862222756018911, -2.5047302460668543, -0.013275275432580093, -2.9401661636152334, -0.40524211357763357, -2.8922224093433027, 0.9336501502805479},
    {-1.3428965551459648, -1.0369584740984847, -1.3135926558718596, -1.800579418417021, -1.5718040730968854, -0.8029372471046372, -1.2362709656261532, -0.5470015839725026, -0.9085603780373913, -1.9546440994872032, -1.3510352893819415, -0.5930670450632657, -1.207654377631072, -1.4720825845456298, -1.5112016653773799, 0.41434875818257344},
    {-3.457254529396945, -1.364516016140259, -2.478302189947543, -3.4660950392180885, -2.5530359578186026, -2.5707709140990738, -3.2749008542396805, 0.41297086633754587, -3.0305878292324056, -3.3051465440636636, -1.174222125019798, -0.019193108426367494, -3.10232088683677, -0.38469724480834605, -2.3388398690137913, 2.3933975658816222},
    {-1.9136071856670998, -0.8022129310322422, -1.2001514255154704, -2.741929079635767, -2.0496798350123724, -1.8218368754503222, -2.5814912947375896, 0.5908281654438275, -2.2369560632915566, -2.6794290402784835, -1.4769444750283702, 0.25665796096485183, -2.082692098789351, -0.4562759603084801, -1.8555717457959287, 2.8176350978807925},
    {-2.8278715993308037, -1.351841835974367, -2.343022334209731, -3.182218088603128, -2.749417310498338, -2.2844382103416674, -2.702775695790033, -0.11806569092345143, -2.8145370099862337, -2.58675950853857, -1.6883067679099948, -0.18041018031041223, -2.8069947310118475, -0.7310370390369133, -2.479352424077137, 2.2484707998486977},
    {-3.4487267251963365, -1.6708435150851813, -1.1749599683625762, -3.5712341918206545, -2.917872598727346, -2.8143589290034994, -3.751782207918876, 0.5740748671159097, -3.1793149373520486, -2.550710823711521, -1.2042081176547637, -0.16184520192885904, -3.0246337721075176, -0.7316882931285998, -2.960161027130679, 2.5613812691708313},
    {-3.0969646738273697, -1.4781915688618659, -1.3928050534238494, -3.7213937073092156, -2.6587427373250576, -2.692487991910637, -3.226697276792321, -0.011990774577896966, -2.7020166878982277, -3.129321312200545, -1.5849338105692983, -0.11147676430986851, -3.055720939755619, -0.7403959006773629, -2.9513896072600305, 2.741847396898959},
    {-3.690641609370552, -1.8400905258277986, -2.644025265280717, -3.624791539808509, -2.9505305866229414, -3.3277583662584385, -3.711118976586742, -0.19974642527501174, -3.522111343729296, -3.9391613896533606, -1.8995399323752133, -0.4789437060882191, -2.8631637668942282, -0.7833944050904891, -3.2584850027774266, 2.964820021010314},
    {-2.55088821605086, -2.251169709792471, -2.2778807387706888, -3.241728052467867, -2.5329419763550773, -2.056204804299276, -3.0165612644173456, -0.43578347394075334, -2.211193615610383, -2.5247195109216327, -2.9708798138335544, -0.6503217167770267, -2.9627895388577676, -0.6126299237223343, -2.288825374659263, 0.8464218071471993},
    {-2.3239267502444134, -1.611644963088794, -1.6854821447292667, -3.2855101899752226, -3.084969679753691, -2.589947561103192, -3.1792254342303417, -0.04699672481487384, -2.411020156679341, -3.154664772826478, -2.420369431495244, 0.0070838498060752444, -2.595799428879254, -0.3686193131356118, -2.6069520991036823, 2.120661261783496},
    {-3.2998981016719653, -2.704116437869526, -2.422877768020841, -4.162778397949492, -3.4246587182797747, -3.0764289819734065, -3.905768064192764, 0.010379142755522812, -3.353201716114985, -4.158040858575487, -3.714725239527031, -0.06659698683182283, -4.095349430985723, -0.5955964505081117, -3.0596453255145857, 1.9003516319070841},
    {-2.717557117931337, -2.1021617259828256, -2.6793152781800953, -3.216161585584315, -2.8221667923272653, -2.0971512653322635, -2.8315217169668925, -0.4170014087006026, -2.2406418022423353, -3.801979401658972, -3.190701316599022, -0.17301788058145365, -2.9453085090374853, -0.9034645263907756, -2.0980019883080367, 1.857193835195159},
    {-3.502839739273334, -1.6471306961775374, -3.2067716833982867, -3.839234185480176, -2.7584620143097993, -3.1782845921872793, -3.7120852129428514, -0.7322181763314772, -3.265871655907129, -4.244718846846013, -2.9613586790650976, -0.6807536773957878, -3.126377169611144, -1.3459133137774417, -3.1131693298149132, 1.7331575513265391},
    {-2.596484630772976, -1.3934736684440925, -3.0874419622235765, -3.1776552018039053, -2.800202108768394, -2.782997409333024, -3.3084651982760014, -1.7044236229507423, -2.5840876908853345, -4.1404826080180035, -2.86595718785332, -1.7911714179841047, -2.2752890597791624, -2.0381793491218425, -2.0948066740292175, 1.626789544773007},
    {-2.6886663399383814, -1.953320884085357, -1.5309351158769293, -2.8971717539325277, -2.8394676754011523, -1.595255591765931, -3.579952478489403, -0.1234510172593908, -2.5406549768164117, -3.5746312742951813, -2.59929033003748, -0.3806138711914207, -2.149886642188972, -1.0677027281581155, -2.524986630346512, 2.624524428475745},
    {-3.433433450252033, -1.9918371157683112, -1.4599177638702825, -3.3572037260684944, -2.452811942002994, -2.8720231187603935, -4.132223988077864, -0.07905882651694825, -3.3339852780809562, -3.500714179612572, -2.064594437898282, -0.6019475019690053, -1.7054370903947897, -0.9478320538940388, -3.2477283492987534, 3.0164880129579323},
    {-2.7305338474057117, -1.3987174659342494, -2.0457994959389856, -3.4189255733854593, -3.554594796143204, -1.7783322803604258, -4.324147414759858, -0.6321413884229841, -2.4518480083742187, -4.459705931562176, -3.6341533513447075, -1.0963090770393287, -3.230678051720278, -0.9747772592091717, -1.9666877415390398, 1.7718412515755073},
    {-2.7109129343681966, -0.8081352066905989, -2.7877721188114526, -3.2839877321165747, -2.991491297684813, -2.0772650860035866, -3.6424780879532026, -0.7771940165201147, -2.1403207154591946, -4.260262950960852, -3.9931595307987795, -1.0253390783846053, -2.8197935518346493, -1.4224781560182274, -1.8664801369292274, 1.98753544606141},
    {-3.366314701676643, -1.8426112635147402, -4.410047893856787, -3.9618525863754623, -3.4256260488517283, -2.33157507833422, -3.48679805749835, -2.0162281972065594, -2.8012729863256003, -4.741688471180665, -4.11389201890189, -1.5385180943760388, -3.843408075735174, -2.0470829506900925, -3.046281749397982, 1.0704139352001714},
    {-3.1507862001071953, -0.9696451581472983, -3.63747355288334, -5.134796036562447, -3.591863968205903, -2.9390782026927007, -4.364254375571357, -0.34644012409592045, -3.1405905114414367, -4.782012280327451, -3.3007790110580784, 0.2802394286286941, -4.544174893018291, -1.053316643666683, -3.1690940559496674, 4.015180203044338},
    {-1.4931169448458983, 0.23879474710741871, -1.063297317123924, -3.3775744635889664, -2.602808662302453, -1.0630478876482816, -4.018566065093339, 0.7359281410697294, -1.7097637751605277, -4.013619533685898, -4.429668496081071, 0.7632530505031351, -3.371254507303357, 0.8088460669266181, -1.3222755701615827, 3.626729090627738},
    {-2.2804223816884317, -1.0360153364314928, -1.5984583459151065, -2.872467240930706, -3.1506392878374236, -1.4475227683416672, -3.763962529104855, 0.09548341438618968, -2.1416676688547036, -4.539457378311007, -4.497573872577064, -0.5560926939596998, -2.901380173896585, -0.42324321996712044, -1.4082726725746264, 2.658125321178435},
    {-3.0392674589831166, -1.5068886192519506, -2.796199909443933, -4.409045751122427, -3.6638511371633182, -1.9952998837185778, -4.653240047817141, -0.5089031300643265, -2.390611566860683, -4.62663879350576, -4.8005094090465406, -1.0086592220442083, -3.7543998873103774, -1.0609425127600216, -1.9722098108155388, 2.5947133055223155},
    {-0.7148034591277758, -0.9484433549589543, -0.28202090087833254, -2.487241231942758, -2.7599876340899994, -0.3743472534659324, -3.454699077789979, 0.9920443448979486, -0.8930066489324356, -3.4468793132925675, -4.869494586236136, 0.3956036921716958, -2.767322362698552, 0.4137379981772486, -1.0934979447926227, 2.7662977931485644},
    {-3.2921407597902426, -1.2790518400564737, -3.5349088979543204, -3.711710706143425, -2.5716663245521656, -2.1177743553343564, -4.009842556671641, -0.9053800931284853, -2.5857218437205916, -4.782509387917379, -4.10299800885477, -1.1662586096265009, -2.933842893871984, -0.770668845772577, -1.9066925111685125, 2.7896292980242796},
    {-2.7235763866327973, -1.7291413258027586, -3.8651036304075097, -3.6803534300196974, -2.8787736644311313, -2.352339684435297, -3.741230671578728, -1.0888708503796136, -2.0068068256924514, -4.551514271927377, -4.992434681454541, -1.2162057622695424, -3.2415793207511148, -1.6022346952206292, -2.0692019306293172, 2.5274101331648473},
    {-2.1285179560170686, -0.5771695026585565, -2.458365622088396, -2.693510641111393, -3.0255493745503936, -1.8286392837551555, -3.8849850378245727, -0.6630770633689476, -2.057665396417737, -4.681591550248512, -5.3079041584555195, -1.1244159551287347, -2.5955140137238497, -1.163713616711675, -1.3677884876725301, 2.6626519818025476},
    {-2.6200152600681603, -1.7379495692522926, -3.1657401370040947, -3.5291853619166926, -2.2720993788432278, -2.3244003706047573, -2.597354636111412, -0.9534131189467706, -2.258938717093293, -4.826155810767673, -4.996185042856779, -0.9247191274807238, -2.049468332873074, -1.991033009628422, -2.3501707186425227, 2.8037551590697007},
    {1.1902434880624186, 2.6848617208874304, -3.345793396305974, 1.2390860380790063, 1.6514150702693606, 0.9933333205190256, 1.4718952496881517, -4.723461765456451, 1.4348443285087467, 0.13058102521332643, 1.3790956434688157, -4.54993150031034, 1.657923840907005, -4.54447605751562, 1.105501835100121, -3.8383395771932123},
    {1.589616962341271, 3.2656867580580418, -2.457661614890138, 2.2976033783130636, 2.4405704841629157, 1.4006250513764724, 1.8663635776406555, -4.385870722332926, 1.8076494197237316, 0.8203662757210732, 2.61621483332001, -4.091401684935301, 1.955861722191834, -4.0473518185916575, 1.392416260534107, -2.660913826349227},
    {1.87653145362356, 3.9649125123385107, -2.5126511662916937, 2.068305662592814, 2.519581871655042, 1.6294076603298846, 2.012816722933114, -4.864297265206256, 2.255355041834269, 0.8015490534840232, 2.5002260504871754, -4.922563365053979, 2.5254756043371223, -4.483901222259293, 2.251662961516257, -2.737690411849063},
    {1.6576198147770325, 3.645422330008263, -2.2596487230540947, 1.9961311793982437, 2.9658387148562326, 1.2063394019037854, 2.4472675140434967, -4.4631586876555, 1.6997404303513128, 1.0123703113835962, 3.2099952889992354, -4.3806183426434195, 2.837017835299822, -4.475754083162543, 1.9996438154374325, -2.8123815231487836},
    {1.4588561878362967, 3.4350619460474507, -2.446719133630388, 2.3384833455602227, 3.0092064283956783, 0.9051696352027147, 2.7715039857004364, -4.241143226327682, 1.554727309694626, 1.1499366940159785, 3.1269884846689027, -4.4417714926123955, 2.8563094586751374, -4.185083812510612, 1.5374758200582728, -2.2636289885416607},
    {2.001623732679244, 3.914566588032574, -2.966903613465237, 2.455123173105978, 2.6266930718403336, 1.5361252126931275, 2.344605271915104, -4.983473303657622, 2.024383262190625, 0.7258779960505114, 2.7130818705621085, -5.264530446681308, 2.301677606772683, -5.319466243361087, 1.8131928952358474, -3.0236366435058657},
    {1.6602492891936635, 3.8815113358461466, -2.9467864582908763, 2.095151385033564, 2.7319341591069195, 1.3755309768037478, 2.2976381231261906, -5.38880233074972, 2.069388891380814, 0.2656049445560217, 2.032357758267674, -5.2131486325148, 2.5304403633204906, -5.165292802934986, 2.1773465573375996, -3.6801352101747162},
    {1.4130978745767457, 3.7274509055494702, -3.3642280176745007, 1.3957638950921274, 1.7154926085783124, 0.6972271400073708, 1.6657795085805942, -5.125785916862822, 1.2240746697566727, -0.2920758730035525, 1.7847522655457722, -5.237498025248302, 2.095040970330054, -4.916944933445784, 1.2933051106986226, -3.940595276231507},
    {1.3892670462374836, 3.951069690038187, -3.574676938165278, 1.870071825832204, 2.3301129722692204, 1.4342603896528234, 2.2307661923270534, -5.786369172372278, 1.4716728658834162, -0.9634713554266008, 1.7597283989446584, -5.899650751130605, 2.3842127259620782, -5.6234305591834755, 1.7121246440322941, -4.6379231243159795},
    {1.8209386005669337, 4.13544896888441, -3.930498785862435, 1.5576645983553823, 2.6203682538797257, 1.4921679907451002, 2.3559317735940533, -5.7178198781754626, 2.0277776245835457, -0.7009486908214589, 2.119364477616714, -5.934487122838022, 2.4901087046002175, -5.573222153011236, 2.132032705620314, -4.004841863616103},
    {1.3516235316932017, 4.100370772870233, -3.5192446995407396, 1.5636300349396923, 2.3310165787541783, 1.376041510995126, 1.6608962710480235, -5.193974953416458, 1.8659248030882354, -0.36697547945397224, 2.0876413170560735, -5.198587255210902, 2.1519785229694914, -4.978029489376681, 1.9942173296521306, -3.4164181853309485},
    {1.143224180300632, 3.9658023247050043, -3.6813914365923948, 1.391999292258589, 2.098986793262459, 1.2998657876672681, 1.619344443261663, -5.172840680433548, 1.4956727501848086, -0.14384784593025965, 3.2049745027135823, -5.141085123903542, 2.1141548898342504, -5.100777841272153, 1.6953356876165357, -2.4361758716870283},
    {1.7322320249894163, 3.9273587488431314, -3.5081836104650863, 2.241025416542153, 2.4448028700823654, 1.7333142577174352, 2.337204779132355, -4.9891959462145445, 2.2933092020060792, -0.4316243103688145, 2.959977150711286, -5.230431064432311, 2.584586216219968, -5.141544405508774, 2.2901386901560103, -3.08826560518878},
    {1.877405019241199, 3.6692044748363255, -2.9729319345170757, 1.6038721239476328, 2.7964029590282378, 1.5866408456620709, 2.160148150037402, -4.7681892922949745, 1.9193351664294038, -0.2452396487962246, 2.00399076270727, -4.822974638985034, 2.6858195407859338, -4.743084864290979, 2.3229770173924766, -3.9201890965931643},
    {0.9880399048459354, 3.0440673352867864, -3.671484283667682, 0.6905724792077502, 1.483835988965177, 0.8428901721701076, 0.8840655563728944, -5.4170209617037415, 1.0766391472814059, -1.033543491268299, 0.6675965294979871, -5.559706218583738, 1.5336339848539344, -5.204720497719252, 1.3486672012246688, -4.061346562850398},
    {1.306287940738573, 3.5613213884806605, -3.4883230678060695, 1.4561670445937982, 2.124777126879482, 1.1469740201491532, 1.8833097907789782, -5.273773863245364, 1.697842338249158, -0.14319889917533493, 1.7218759405120383, -5.315811084465151, 2.047952745269346, -5.166573741041761, 1.6880644247931782, -4.1817918006425},
    {1.905416048863601, 3.8816179885285065, -3.6921766565107497, 2.0888103225481873, 2.638631442764692, 1.4533755298700006, 2.2459402353167204, -5.397397331484698, 2.3667530071295246, 0.27276543265334763, 2.052321313035208, -5.389352795200771, 2.8661605655664713, -5.177045822042026, 2.2512049276124784, -3.9038189230620555},
    {1.7106762031330491, 3.888875221134341, -3.778860200412561, 1.2387043009372054, 2.0812054133600326, 1.8003590407641858, 2.0218021513944824, -5.6228447060929545, 1.7621941524014202, -0.5601049603169377, 0.675733860823209, -5.73241428181713, 2.6602030973312107, -5.558245781639987, 2.3221053691058993, -4.540510576581457},
    {1.4848628207437173, 4.0352992876662315, -3.4474447331974996, 1.6643126339226662, 2.1666507181539165, 1.275830315553432, 1.6829217434792538, -5.432664978918964, 2.0167148481724553, -0.3295025804990624, 1.1513985506105917, -5.869482319708021, 2.214982676434052, -5.11423895188367, 2.0725499257276634, -4.413609620197246},
    {1.966658957877957, 4.3248946200861536, -3.259762565121536, 2.0578434599569757, 2.635642473084295, 1.5180822278438812, 2.272645838649389, -5.344209781229589, 2.2951082555599043, 0.5239713001731939, 2.676030334570964, -5.555368000289174, 2.606701572390327, -5.442181599660874, 2.5512266570829123, -4.396167240973161},
    {1.9122339163043545, 4.2939231880860635, -3.3448632971496606, 1.7228831711759964, 2.3446818571552233, 1.9373932734341808, 2.063044188320968, -5.35592277448469, 2.3256881103158507, 0.3149877876907646, 2.7318800740790032, -5.379352199348586, 2.5804162209638495, -5.316084863145054, 2.404942203356977, -4.233682833566586},
    {1.7485633108520955, 4.536692404169751, -3.7323830345830284, 1.12871381876263, 2.4229641996681606, 1.4670170918557208, 1.8351068374967223, -5.594126198188898, 1.9903260428051508, -0.27146368816119687, 2.1715262763382617, -5.926359537554934, 2.58933238460941, -5.445971282165129, 2.236103808437554, -4.292378239133593},
    {2.0637052913944216, 4.339512646272595, -3.66895364970939, 1.5661995909528532, 2.4841327521617567, 1.8767166589140405, 2.161909396295354, -5.584136187046462, 2.5429361006347917, 0.23195142724391196, 2.2175822385553428, -5.6955262368327, 2.665320361173459, -5.513188048682793, 2.62540925767927, -4.203593199714629},
    {2.114519272326325, 4.752726653721942, -4.081637942154749, 1.9887246771415548, 2.6253199088423034, 1.7388842998603038, 2.4009423363939333, -5.659255958304658, 2.5707309643161227, -0.005375485561903109, 2.2476088813566037, -5.85542262681301, 2.932708587292362, -5.319660787860495, 2.804063402042186, -4.48360540034442},
    {2.1787635511359076, 4.700173704925508, -4.05382683164665, 2.2377664834341973, 2.8538170499123208, 2.238597494329849, 2.24472037591966, -5.468741535330788, 2.87209256248945, 0.27189692020909584, 2.7792520641675558, -5.414667098356601, 3.0258457426702488, -5.2319015069755155, 2.9279271318703937, -4.141342307751896},
    {1.846349208956585, 4.405095387219023, -4.109005971809425, 1.9415256692533058, 3.023260949977829, 1.5196870800421978, 2.383674390688473, -5.790321242127079, 2.296019190513906, 0.19181393434064803, 2.6655860393155026, -5.746417986343591, 3.0406419899665593, -5.723661101476017, 2.490388883089074, -4.646280718740833},
    {1.5371636856086086, 4.171533334632676, -3.7079571747105535, 1.8347202555155249, 2.4328120997780847, 1.3047006939060248, 2.013204263862164, -5.9187268496449805, 2.1877791429963125, -0.10482428430482599, 2.245303910091862, -5.95371553762605, 2.344992543230821, -5.498797369195787, 2.175918210987943, -4.3446179403497105},
    {2.0791845088959517, 4.5671867360161285, -3.8739398713995836, 1.8504037069247243, 2.7725430127980286, 1.7655016483744963, 2.2843297148551653, -5.815911664896096, 2.537825461612006, -0.4335081402116209, 2.987540743501443, -5.519889162815197, 3.0336754346046733, -5.347419807442957, 2.599380678962289, -4.160967003530249},
    {1.737612569362623, 4.374457278389926, -3.949189006168073, 1.511155492662988, 2.4386334930987905, 1.0846906911745209, 1.6543661251812916, -5.825054365508511, 1.8904612558834495, -0.6116950753354411, 2.4890897385335227, -5.679039168496376, 2.451913745659059, -5.458561926254732, 2.192810552906745, -4.01346795664752},
    {1.7947637973776216, 4.749872854480866, -3.523182845221099, 1.6035065111495095, 2.9021537222910494, 1.6615934259665126, 2.2863852846529977, -5.531482507380332, 2.390365547053802, 0.4441076957610669, 2.538870470880734, -5.84614113190786, 3.2420662122347057, -5.4375406857558275, 2.3436875315384005, -4.678956335867848},
    {1.4013728446772367, -1.5118816744235024, 0.0010082594476194093, -0.3649565267626539, 0.3099403625197915, 0.6243358558308049, 0.5868161074730007, 0.35720951494181385, 0.9358844091302762, -1.8464660371108992, -2.3573431077997413, -0.6337468103537747, -0.8235982409098954, -0.1759908096104964, 1.033786503471447, -1.2819388499714002},
    {-1.3472545635454594, 0.44558471954387646, 1.1549306036779543, -0.5799326331557529, -2.149367867319113, -1.2019376883878585, -2.4627748713852196, 0.50593141273289, -1.792188352654972, -1.2560531417164724, -0.2831198259375117, -0.07090870637376372, -1.5057712049574785, 1.1489367092471454, -1.2724783640655035, 1.605647931305908},
    {-0.13144350157644275, -0.105108747953309, 0.19273283932426677, -1.1729325311585028, -0.8648725911617949, -0.6517866574247699, -1.1522401633507764, 1.1743049191976782, -1.270908381001676, -1.354824346314313, -1.1185414691534223, 0.8818097646079652, -0.8148141983975227, 0.5265822068076386, -0.8247896996319364, 1.87757028751465},
    {0.3649096060586024, 0.31670825235110067, -0.6997357345039027, -0.6770555446296033, -0.3065407952261936, 0.16295319034780562, -0.41592007032758194, 0.1951606520752736, 0.7848836071410566, -1.5048716311868062, -0.1677346939100672, 0.3142641946739545, 0.006907716802654619, -0.5552865773589123, 0.18245101790661208, 1.1573612469826495},
    {-2.500648932573864, 0.039299428912897276, -1.3156287804736762, -2.711395931924378, -1.5822999000758968, -1.9043168369563221, -2.1537135401011716, 0.3093173204282617, -2.338403720095846, -2.6058859511243746, -1.3190092316758764, 0.7361074866038843, -2.1823009062778143, -0.1921036194601756, -1.7018494159308923, 2.520221960990406},
    {-1.666262122695165, -0.4770270263390814, -0.562262976674538, -1.830221876961477, -1.7104641708056834, -0.9049019447199774, -1.567630361551562, 0.8009721299726963, -1.3473163195827749, -1.8190016884996594, -1.3671225505806994, 0.5877062250371293, -1.5092825145559297, -0.3787948476720337, -0.9809579024009557, 2.4398020130247944},
    {-1.150998903438822, -0.5702547308228899, -1.3936448799593328, -1.8991559925759174, -1.4500148491040652, -0.7408512349489182, -1.397538752883344, 0.12415848997486006, -1.1732726923545218, -1.434410384706772, -0.8419270671818461, -0.34788980991325946, -1.7414536008063846, -0.6339176084393562, -0.8556884228523758, 1.8841180091398428},
    {-2.490702591220031, -1.3101099992001728, -0.9536015840684137, -2.583333982164785, -2.0327214771456825, -1.8012211120338681, -2.1299704822515273, 0.39569343708689375, -2.1207052587646116, -2.0898100428363104, -1.549851572431526, 0.008421340634058864, -1.8726145967095367, -0.38133650260427493, -2.172643318654508, 2.6690442245971693},
    {-2.749359695687224, -1.401045198913717, -1.6050907806911932, -3.115194147725934, -2.145685577265008, -2.374887091736253, -3.1288922943599866, -0.09434001796417282, -2.764254939349589, -2.8818924407775066, -1.3942436006290697, -0.2604370695315477, -2.90686316421097, -0.7876355560355407, -2.6764857993011195, 2.170792014517748},
    {-2.1128204178558256, -0.05244420181889748, -0.8887679272125386, -2.7578811512779784, -1.4772420618893918, -2.3679379712503352, -2.196097555390917, 0.9918677830944204, -2.2040343913204588, -2.522745354159276, -0.7954038958270951, 0.7496949330097286, -1.8444085811956104, 0.2453659130372374, -2.1159454661389283, 3.0402727628439865},
    {-0.48052194873786136, -1.0128114766118523, -1.200656535934563, -1.8545043135085846, -1.9277447056123387, -0.535821585380625, -1.916656396456234, 0.1643530662852846, -0.4843077743789079, -2.178929241206781, -1.7791691784669945, 0.03322098035828106, -2.2604213802054067, 0.1708943106054553, -0.47335666697328743, 1.5425313777327523},
    {-1.9520351938846539, -1.6530512753591748, -2.135975362047417, -2.8154304957613605, -2.75145846705564, -1.5569178889599795, -2.535633562414134, -0.2551936057438958, -1.879641170633298, -3.126085345635826, -2.4407431061371048, -0.07915805303803178, -2.123491261379953, -0.8634515486069585, -1.5343612067997323, 2.526460741319713},
    {-2.026743631117376, -1.8371149452296924, -1.3234947515377062, -2.749356396727478, -2.606286426603833, -1.2953670637291335, -2.6675285074758506, 0.8624760187161761, -2.2203657560249237, -3.124366997231802, -2.800249049081248, 0.8199566573404768, -3.056176456507013, 0.5501382918241319, -1.9612679295136726, 2.4054724557757283},
    {-1.3174212513273864, -1.1203936334948583, -1.2522098437282858, -2.007460961066229, -2.4463808270817666, -1.0112681314249972, -1.974476607680476, 0.2586191325774729, -1.4339069482715634, -3.418049656750121, -2.7248633507207956, 0.3472162164484783, -2.1046744528422003, -0.319013648095099, -1.4745447236277567, 1.9799918200084223},
    {-2.096160648832226, -1.041270680596951, -1.799400319921307, -2.897270084888898, -2.823351489994495, -2.177017695381162, -3.2179588041555895, 0.26466754985502083, -2.0608418495218253, -4.246112269548494, -2.184954889515601, 0.41867272264443656, -2.7283293587108397, -0.046786619491452616, -2.445042354150112, 2.302605402272688},
    {-0.5492855161352139, 0.19036357091090658, -0.6867825698125567, -1.1330756740819163, -0.5637669153010284, -0.12303839358494632, -0.6610437069565915, -0.2136551004600633, -0.34120454557726276, -1.695941746571684, -0.9985403685916273, 0.11725928870127122, -0.5506351666457621, -0.4621252696066616, -0.22989472585394366, 1.6547908643177},
    {-0.8778566682443835, -0.4486367730213457, -0.3812762269708664, -1.4170528466363068, -1.2199104746172715, 0.4183787665274618, -0.6801287704156792, -0.03223018457598693, -0.8212581619170287, -2.786591930871, -2.1651416687656506, 0.3906332225549489, -1.015822419606178, -0.2549638991897131, -0.747662503347401, 2.075638465889763},
    {-1.7104448583202574, -1.1427464639095946, -0.3874010226778643, -2.7220959626507937, -2.032307840448347, -1.2458196946974527, -2.614527750657455, 0.8406976559696574, -1.6894320794172661, -3.4522985243133277, -2.433195249974588, 0.7046267446506219, -2.2881127725514916, 0.4011941182571215, -1.9552930087632125, 2.594566532137838},
    {-0.5825664049485392, 0.11256777637689148, -0.8965322550710305, -1.6511245955820109, -1.9436557714903415, -0.11178446835476537, -2.0457939960435474, 0.2700127275564241, -0.1526661396462972, -2.8689448606209975, -2.5559555756289525, 0.1617408920152711, -1.543015885207317, -0.047077024734090596, -0.05479066837534225, 2.1201465813560714},
    {-0.5738222805981974, -0.19104399530588523, -1.8448094578305239, -1.5828375539716661, -1.4254103524833055, -0.027114744161181162, -1.5783144465314576, -0.09583120735691458, -0.34081158394310046, -2.9819266530789834, -4.140735227528239, -0.04621675145922952, -1.3826551625928618, -0.45248947720126326, -0.24662331541841476, 1.6107491289356528},
    {-1.2903352956968, -0.5401010805844826, -1.0137857688657903, -2.010984001062475, -1.8860315910434455, 0.39968682850846454, -1.501694158141123, 0.3360508935876663, -0.9540059895767818, -3.7729620441555474, -3.285922884238717, 0.4144232968881281, -1.6398808846142336, 0.07244182137286298, -0.7951596376828727, 2.124899718116831},
    {-0.0827464764000037, 0.5669414103718887, 0.1950078003186031, -1.9012159801451054, -2.086308654638038, 0.32237391059420856, -1.500213231757123, 0.6172597502889914, -0.24544780434321514, -3.960475125754547, -4.14355620817029, 0.9899952077869637, -1.7044603271634173, 0.5665554341966758, -0.5608896032468628, 2.5546584464454183},
    {1.8269633460536912, 1.2048744552757544, 1.8665136653182945, -0.24487806486911926, -0.7479764888145469, 1.7328745949074138, -0.30508004429844554, 1.2674264726917222, 1.17759130597904, -2.8325595856481836, -4.079632397849554, 1.5881128936585553, -0.2462749491017383, 1.6385740829018036, 1.1969221094345044, 2.2844343542241945},
    {0.39948248310362117, -0.0917437684078826, 0.39810547687941106, -0.996417633920205, -1.4379313520939583, 1.0775480249813587, -1.116150698120906, 0.8092087120360637, -0.053878731666442366, -3.277861925086772, -4.3337173787975765, 0.816887993089786, -1.2363983222770392, 0.5779020737262283, 0.4838347770745384, 2.323673976640837},
    {-1.0050592303940227, -0.5193991004014137, -1.5442867636571462, -2.763920739475143, -2.4850873134130222, -0.37445427886914684, -2.49018691430635, -0.26615220992179295, -0.6655959472867943, -3.9396344728247517, -4.691383808198291, -0.15090528890233293, -2.437751328646089, -0.09653210482842328, -0.314391957629272, 2.2847865939986653},
    {2.0489844388294225, 1.0510592254441566, 1.0958632722687036, -0.5716750974386562, -1.2620730410070737, 1.5588330091549798, -0.8906477287482687, 1.2372041113561438, 1.2979360584620048, -2.466568898499761, -3.738360380480779, 1.339617933805032, -0.8024519634042111, 1.247196205140808, 0.7309082469870204, 2.924372288219787},
    {-0.5199964539152312, -0.2315727474624282, -0.9317230841296859, -1.847186695014296, -1.6526779985441251, -0.42345122315042494, -1.8956337910507595, 0.13270770779082194, -0.5064910190645393, -4.233020730519159, -4.817129899539078, -0.09113698775703528, -1.876542082285753, 0.6279277362304443, -0.16367177933622448, 2.2285148753938113},
    {-0.2716664512791356, -0.26454371970012397, -1.3863970015037528, -2.0508563128245734, -2.09735530362228, -0.5613542282830832, -1.8734714575788558, -0.19692230245732945, -0.1932402935899659, -4.502596426128011, -5.283678008453246, -0.15049790796579066, -2.070350490682076, 0.02425880226870189, -0.28593940110320315, 2.1225218171596847},
    {0.5608236872075084, 0.5518714451563771, 0.16181215313914438, -0.9185812218391196, -1.7940149759597777, 0.7497934881111399, -1.661982097824124, -0.24798705945913868, 0.34614622044575705, -3.601418715596916, -5.000186150829179, -0.20932392894396393, -1.445252592579577, 0.2791896156876628, 0.614435473248315, 2.482614812444112},
    {0.09817086560525054, -0.8211288083057166, 0.209709782017833, -0.6844152471112752, -0.9015170279070677, 1.240830649209689, 0.22575675702341227, 0.008722855557994822, 0.3992385457355822, -4.17845430711955, -5.488558019356676, 0.15701861508351211, -0.7416997415440661, 0.23916169569170784, 0.15889799409552502, 1.456957678223878}
};

static const float b1[16] = {6.509670359947075, 6.69265436846959, 7.1542376451322625, 6.5366769202418284, 6.076303339301808, 6.336222394614237, 6.36337217189612, 7.373922828149944, 6.410261233774475, 6.892674858298524, 7.4100094876172955, 7.462993062057299, 6.508761527008936, 7.3881856797921275, 6.482831589271509, 7.9763828188204835};

static const float w2[16][12] = {
    {-2.5222766097025398, -2.1690365738405806, -3.2474563159148557, -2.9572473329229068, -2.739490943312884, -2.702259017976087, -2.8556434604457177, -2.846073751621686, -2.0566525579373978, -2.3994274537887677, -2.528428394921311, -2.7019253023901837},
    {-2.6214766180043894, -2.467349666760589, -2.7770301303101865, -2.4045149451248955, -2.782308530811814, -2.8627725129824166, -2.7382333012680378, -2.876753959841406, -2.1561158233543294, -2.73035799976943, -2.7098911092814597, -2.4310559196429455},
    {-2.8470287679194635, -2.905202231025474, -3.1907292649467025, -3.309537096357524, -3.199328650790958, -2.971922375634572, -3.1618417338142244, -3.0942073636389384, -2.977845995869411, -3.4998428941408117, -3.336979657603874, -3.512006630479037},
    {-2.7148580879159945, -2.6088118738323236, -2.086660119728493, -2.2055355741011686, -2.871628460111227, -2.826564577053238, -2.7286768511052184, -2.302044962118897, -2.698175284032175, -3.051126146300758, -2.3003201971558163, -2.6335535543117787},
    {-2.948388696193739, -2.898877397174291, -2.7103568813577774, -3.134950186344471, -1.9032773300942916, -2.48043310536469, -2.3496152691726353, -3.1843378293828213, -2.9002486315316203, -2.182236439532299, -2.8484495967671646, -1.7562940141495187},
    {-3.2117680649854363, -2.5240674123587965, -2.5723612103588005, -2.53842111206826, -2.267728496766291, -2.1186079468487584, -3.2358046518096586, -2.804354732706233, -3.17072747591697, -2.7910366502438304, -3.1763973929243856, -2.557347782047327},
    {-2.4135464718779014, -2.841746869033973, -3.2535898788849287, -2.5332834621726197, -2.693075104584446, -2.076617454733889, -3.3607146798919314, -2.037129388599805, -2.444130540365783, -2.3650764779424573, -2.081515249274841, -2.6972870719242024},
    {-3.6132427918291623, -3.4971269155391886, -3.125460855358564, -3.898397141761201, -3.107713225889254, -3.621011034116961, -3.544625080575818, -3.815663954278864, -3.939964832949904, -3.4388567895980944, -3.385983687746185, -4.157236032213256},
    {-2.1400759273291503, -2.5355300822854847, -2.694289229826659, -2.8505847145253607, -2.991197207750692, -2.7158025565828994, -2.430900297188998, -3.0066484636323803, -2.6668854041569814, -2.41139791954911, -2.4408769526800476, -3.1667004858196033},
    {-2.7252504216852125, -2.8521669008196104, -2.623372942301302, -2.4299575618265856, -2.55421437670517, -3.1284332641713837, -2.3596755965999177, -2.877278898838815, -3.157806123494886, -2.5051662937571857, -3.144595591613687, -2.2367563091276232},
    {-3.086754054256675, -3.237869310116151, -3.0426815943604875, -3.096578315376781, -3.056680810222364, -3.042029137458747, -3.1352650018143957, -2.9732732120904926, -3.3252792454639577, -3.0011641116830967, -3.0545888938767725, -3.1759425982492226},
    {-3.4306611578712642, -3.9518349489360403, -3.930611540938438, -3.437929447150782, -3.9460693703718803, -3.3329943225420924, -3.495511459615489, -3.3158815356326103, -3.4994660509967876, -3.326464912199896, -4.250000958053513, -3.6111280947648132},
    {-2.3408366238521827, -2.2998039038347238, -1.8901150367937956, -2.4711397026752664, -2.8461072244667776, -2.2772153809948024, -1.6546318975074197, -1.9876899565967332, -2.5481696392787674, -2.7492530672938407, -3.025664891623465, -3.2944683774460115},
    {-3.890543959505926, -3.5929184081212777, -3.5713438692571517, -3.352815530904741, -3.6085643699590735, -3.834174652337971, -3.8453995913137122, -3.777115604778852, -3.5353917874818253, -3.5555451344177875, -2.939349588878073, -2.933206212130485},
    {-2.6110603117528792, -3.007846263228441, -2.212027448900732, -2.419239785318189, -2.302354321813637, -3.001338834278176, -2.6044414820356145, -2.514344924643698, -2.8670214946667683, -2.8375130267276334, -2.160099896137888, -2.4133009868051927},
    {-4.600408855214931, -4.28452185642976, -4.593704552029054, -4.62131256045926, -4.667422860094567, -4.560067769324815, -4.398834587981058, -4.468174113911383, -4.2920318565346385, -4.789820073102468, -4.481954344582411, -4.320965296880503}
};

static const float b2[12] = {-2.968412509751686, -4.551598458793044, -2.0197043684133495, -2.423513238195529, -3.2334773874558738, -2.542971728442547, -3.462225281779973, -3.8759097596269805, -2.6805256645470514, -2.974717267596371, -2.564469932637243, -2.9579552242878195};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
