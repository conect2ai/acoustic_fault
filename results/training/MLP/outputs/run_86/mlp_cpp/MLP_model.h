#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-4.776383789243127, -4.350298553446804, -4.277238352703278, -4.619341452056367, 0.956360647652812, -4.494957998236936, -3.898364273616748, -4.4556117870182765, -4.388392307055946, -4.391226658246546, -4.0642783343551026, -3.530543794337797, -4.14513064282035, -3.76388325069119, -3.888223221334247, -4.6215237049904605, -4.590355419964253, -4.481335720554858, -2.9866654008131, 1.9090234653760667, -4.603183695958721, -3.103407849660231, -4.450332194422168, -4.184219273294019, -4.502277830296058, -0.22005884176418156, 2.1552906246729595, -2.1400268963012037, -4.055454913012764, -4.007929331349621, 0.6059447633821513, -0.028130917514387968},
    {3.5407810184403026, 1.03156124291618, 2.5168919763545765, 3.38937423447822, -3.5571013403873577, 1.522271500297096, 3.359704097713995, 2.503980341159941, 1.4527245774578186, 2.4351941332551235, 1.2484864932291515, -0.6603456117013746, 2.36077157567393, 2.8753228506224158, 2.30396234205485, 1.5333139404239573, 3.1663616722511763, 0.21008620322302599, 3.9405559163507706, -2.7811887959426307, 3.8024563965112854, -1.1356790881107064, 2.712561123121022, 2.702747035930644, 3.5289295883363865, 1.854505686818135, -2.4297876067941617, -0.82290270966264, 2.6349847441646164, 3.467791840909032, -3.6807599703246305, -3.0207921355612912},
    {2.637351739687714, 2.907216529227457, 3.150294055103891, 1.1953203707499058, 1.0605239950789909, 3.269159200604939, -0.3368640460665045, 1.1762908937317176, 2.291284111569818, 3.0442558361615157, 2.983066544980615, 2.069438705758187, 0.7493870348922117, 3.601055548477427, 3.7466040989603617, 1.78092075539494, 2.439149339009694, 2.975684693138584, -2.071583083121841, 1.1906036814748506, 1.2203252187512197, 2.961058098086611, 3.0439935189615044, 2.6298140030774366, 2.127821995886408, -2.8362777399976813, -1.230570013491013, -0.44738336758851527, 1.49214318132501, 0.478159273240132, -0.09883090700232992, 1.0639802920494474},
    {-1.0910405347638876, 2.280182667831099, 0.744820065983487, -1.069395482059466, 3.604048160794773, 1.9643479574143978, -3.0844831424563517, -0.4557760128616996, 2.23416967798875, 0.17657601240709545, 1.2382298796503937, 3.297759193022314, -1.715794477582388, 0.319318889424374, 0.7050749804979012, 0.9776650347810575, -0.6055141577824718, 2.723361552424379, -4.013310162466532, 3.639113621180596, -2.2286781941596345, 4.063098847556575, 0.7081580661734641, -0.21671505907839525, -1.5589915451875174, -3.287691500612658, 0.8773013736476278, 2.3208192310853377, -1.7907875488462393, -3.249485860051313, 2.896783892965149, 3.601621555089443},
    {2.602520621275847, 3.671249018867818, 3.122399926739632, 2.6722074840666727, 1.57263807033704, 3.901394171883549, 1.4697065024323466, 3.7628080409534235, 4.155435774183988, 3.481148378632907, 3.5948483083656955, 3.7999934507757747, 1.7279728161898746, 3.526515170608423, 3.523394802781889, 3.461564426783009, 3.4132010213359143, 4.075848640437201, -1.902692295026572, 0.9566818838500367, 3.096645182960219, 2.7170043612538692, 3.308993372543689, 3.62987046854896, 2.9530051213375645, -3.0409553426892257, -1.1427082712808123, 1.979040711900094, 3.357785256058476, 0.945198295365823, 0.8112085948674581, 1.7319602471662596},
    {4.498588496500323, 5.24382754486359, 5.01903667330281, 4.418801923882987, 2.929462385545508, 5.024805060080621, 3.5653747564278757, 4.074981269977794, 4.554397639638699, 4.812624188698075, 4.877240833055686, 5.623026323043872, 4.1708621943786195, 3.9096412079288125, 4.146186709395462, 5.005443543446551, 4.4700904922995655, 5.083554752610501, -1.3005108570083748, 0.9522934350735192, 3.7873480132456536, 4.378465072278306, 3.9992371581432207, 4.2726438195843475, 4.093026489081121, -3.4654534725904087, -1.0240228528594315, 1.1304871762309234, 4.125751984542393, 2.260730360840722, 1.6273165957400875, 3.6685586816104636},
    {4.113447222059091, 4.91279580421802, 4.878319632946901, 4.125619731001759, 3.6522322802797516, 4.6917659517472075, 2.915762449127767, 3.7657851616536173, 4.528786629201981, 4.700534739509787, 4.530874611244411, 4.989450850655079, 3.9275684708528042, 3.837227118064415, 3.8977784840253107, 4.596130363556508, 4.496200529317576, 4.820408762449554, -2.264579662171515, 1.729363929545271, 3.381406026143047, 4.57634865650258, 3.869159342531896, 3.7339609454173077, 3.641327064428162, -3.1077220979900915, -0.49161688775833795, 1.4920527044061938, 3.5406896994785853, 1.5186095131667177, 2.0807339796169106, 3.930303631170638},
    {2.2810906022119237, 2.158446501779879, 2.4088087259730844, 2.783599174189413, -0.6932347074505281, 1.8825303520025576, 2.4597301669245994, 1.265852974131006, 2.0957253328987067, 2.4743807374639855, 2.332868969533341, 1.656052849642495, 1.5250367054929415, 2.7602042227951498, 2.3639927830607634, 2.364634354481561, 2.960847247971551, 2.624931716040984, 0.2748003391503061, 0.5374599487726541, 2.484748928872347, 1.3593978025098352, 2.560226756308655, 2.7031587046198324, 2.1509749726904617, -1.025444068082089, -1.0256007547293065, 0.4254469541844405, 3.0875045239151935, 1.53829753188129, -1.8520570777247631, 0.5971601346030342},
    {3.3371553398741836, 2.727842010024301, 3.055372076541804, 3.263929418102594, -0.4017060665391501, 2.91228327340062, 1.2448305262338424, 1.2222665899636147, 1.711085665542081, 3.305273056966435, 2.674361867822839, 2.398540661101766, 1.7663778625623434, 3.5003398401232513, 3.134947575125679, 2.6973678905359946, 2.7208146880363278, 2.799615203965044, 1.4221233268252338, 1.472044205909681, 2.147922862572112, 1.1815463557103836, 2.961684368916525, 2.3089737140485913, 2.205292111583162, -1.4452979732761566, -1.3553466877744949, 0.3783293213025881, 1.4429558722991331, 1.6903509644158397, -0.8884036384256528, 0.7596657468922818},
    {1.3155311684471636, -0.8039195770938946, 0.49490687160050495, 1.775193431467539, -3.4513993306383957, -1.340303104489686, 2.369858185920676, 0.8460671309149965, -0.7571193121742618, 0.17352661211995304, -1.104765235572509, -2.2444687628818327, 0.4102924800045289, 1.7079907319119645, -0.7743015957399786, 0.041957993171358926, 1.398625790193867, -1.4918561440494849, 3.997617507743651, -1.9008502662030637, 2.034634516576972, -3.1710544859035688, 0.3784506371717646, 0.8563508003776851, 1.5623485670063044, 2.0047307995842027, -0.7908829384200513, 0.49946630603705977, 1.2280931087494564, 1.8141477132524924, -3.778602066190419, -2.35021202711846},
    {1.3450508350805228, 0.06164862655496678, 0.10939457259240817, 1.355458923576535, -0.024186921410824763, -0.6839798819542523, 1.3096843869538417, 0.5439956825904575, -0.6459392481746742, 0.008848919151625048, 0.01820714722126675, -0.6261456636268932, 1.1209727936975127, 1.1837126403910863, -1.3978314168233488, 0.017633277262684023, 0.5192509927210732, 0.0171542057931018, 0.8240740577217894, -0.48192870699090257, 0.5880187272308403, -0.8896410039026397, -0.30082663351794503, -0.33761741302017867, 0.9382087918663098, 0.31529806722531617, -0.9392566748601952, 0.7317838568579488, 0.1301588056519797, 0.058551806688371934, -1.3661106554546896, -0.5899591862091925},
    {-0.22691659808701975, 0.3090935145357248, 0.19079380961796577, -0.5230656054895001, -0.5503322969518816, -0.7910446789704029, -1.6961870318400705, -1.2185850146866135, -0.29521208333521587, -0.610988962292125, -0.6614332577753639, -0.7355287018947674, -0.247813246435991, 0.26392662880458995, 0.034742957130507096, -0.6719512417125189, -0.6149669358321136, -1.2706010470478186, 1.7053976736953431, 1.5205644575980422, -0.8800010793083985, 0.16749541343491697, 0.4117890542256908, -1.7508967575894379, -0.1730642095962226, 1.0313660030032517, 0.29602508475280787, 0.5554835399414613, -1.7553976828838496, -0.1494330525270189, 0.05069674577283651, 0.14993584472894292},
    {3.190565597727294, 0.4328035057622233, 1.961543789524558, 2.9344636830196396, -2.748007641866731, 1.0142503118200383, 3.9679306200993207, 1.0443312199282455, -0.2347508343526026, 1.6293432386338265, 0.5729476918081975, -0.43332782829915123, 3.5432410531175993, 1.9799391690953074, 1.9900472801020956, 0.7737185495497567, 2.2592979603328773, -0.9666938121227742, 3.370644379125177, -2.7813017991923448, 3.35577761189925, -1.8019037738625445, 1.54051314546756, 1.362387909934445, 3.190719759217439, 2.4586976736525057, -3.001680954314435, -2.4347165406819036, 2.723454313853423, 3.9032985126334245, -3.0079177011390046, -2.3884184168730154},
    {1.366982528353128, 2.980983462142305, 1.216442394363393, 1.7680180331779474, 4.323069229068417, 2.2000575679724377, -0.5190289646915055, 0.4123700703453217, 1.8772774744551195, 0.9629501888928955, 2.27669383777272, 3.610529270141473, 2.0040371004862014, -1.5058966125686084, -1.0762391692198305, 2.1064522923442315, 0.843331205296209, 2.654227501636487, -2.272196826007033, 3.0318827864437843, -0.8086349832385715, 4.311038138718712, 0.8889665329653673, -1.8847142918582334, 0.1486657543267931, -1.5887866876975407, 1.3247300477677584, 2.257284675105825, -1.5818846672237736, -1.737748191236466, 3.821725946405193, 3.911113694463029},
    {-1.690114668105725, 2.221973086920547, 0.30393015094383974, -0.7706965793544921, 4.921254227303845, 1.3661414696124405, -2.9868638959279106, -1.823596720115694, 0.10214795959515145, -0.6751553387296575, 0.05799775258476, 4.255253682719902, 0.4786076346494615, -3.2578136054159663, -0.9547976377295851, 0.6565051314507397, -1.0397533638891185, 2.4397913638076343, -3.9211242370596207, 2.8199859720129576, -3.135014489131746, 4.792142121874231, -1.4396863347502984, -3.1055594175533874, -2.4435518496831765, -2.3836569579227906, 0.9797682355091666, 0.2479548277055303, -3.122742728062492, -2.706198825497452, 4.9564261003905905, 4.201996934965098},
    {1.1777913312086632, 1.0011514237786472, 1.1419146940592468, 1.3856791402186786, 1.0096875372096483, 1.6236950838321962, 0.8812954201924457, 0.23720636208480667, -1.334650867576107, 1.1635221930643518, 0.7308963859374341, 2.236530267198274, 2.675372318696559, -1.590215040638469, 0.3569205179815959, 0.7586089829789959, 0.3960497569584623, 0.8115556110379677, 0.3328274001544429, -1.1421283899848513, -0.13656862114073673, 2.1488931466280854, -0.004893850231442792, -2.045097564592192, 0.5969742287281935, 0.6661122539700542, -1.0196437514802328, -2.020259579085489, -0.9684592878252818, 0.6039629566643945, 1.9898997464517476, 0.8901900256875414},
    {1.791562801538955, 3.6466139308817582, 2.6828031460629966, 2.539838490162325, 4.579006644022939, 3.059223215083942, -0.05942336982157423, 1.1553991881939152, 2.826622204886367, 2.0721294791131664, 2.1827951805586014, 4.754396722780793, 2.358167410863247, -0.852909670090751, 0.5050354866730952, 3.1228891463461754, 1.7888384349892996, 3.818497412098102, -2.333284296967095, 3.0763285911896996, -0.0815172806608764, 4.700908300926492, 1.6392391116330427, -0.6733277624315951, 0.30513007920749874, -2.1876486359806706, 0.8082390773599243, 2.5794123831158804, -0.9305692118314316, -1.7415324964625958, 4.262114161278321, 4.478981840400765},
    {1.473626026034995, 3.1840093408626693, 2.2700369034844194, 1.7723162386808369, 3.483497661460547, 1.8819373497617828, 0.2580487017590978, 0.6381358073947269, 1.503607787728949, 1.7999728924479121, 2.058643135890631, 3.5027852987574857, 2.246375075716997, -0.5687711446317848, 0.20171558908655662, 1.8796415387630838, 1.1931889492874832, 2.3513751533930742, -0.489091568468428, 1.8995230868290527, 0.2779909583496516, 3.6863524967751014, 0.8666658345491646, -0.7559574969593137, 0.6609240889020459, -1.3362148041755422, 0.23457329766563242, 1.3685519792050496, -1.055546562101218, -0.645071845618721, 3.5793882141498954, 2.7739800347458363},
    {1.3672882114150458, 2.6035146277407555, 2.365074113453811, 1.762947652571532, 3.0860847225098533, 2.8562037868684005, -0.005404678909108375, 0.7266149540461045, 2.636500809898865, 1.738438999299635, 2.1156724682176087, 3.0312395047919662, 1.9424787864500346, 0.11139243837914667, 1.927404294031772, 2.7098465813119725, 1.2673826645123565, 2.1908808344037234, -0.983953149469925, 2.1599643800709005, 0.6005534373771879, 3.28522961747307, 0.9875370248242333, -0.038084012283276826, 0.3688660584004527, 0.9276117305873544, 0.97980071083276, 1.0247142260478908, 0.5150734756464824, -0.28979670762829274, 3.5580723847998246, 2.2226319022571563},
    {-0.8333951411683094, -0.6883767678444781, -0.989420255932721, -0.10905843453637451, 2.0313146237922814, -1.2946904259677259, 0.46068680623557756, -1.1214290092408843, 0.017169538005846228, -0.5149021283560793, -0.3992327069704579, 0.13595487869271716, 0.046998170574252554, -1.6722552068308634, -1.6799974631619141, -0.0676573334690328, -0.03737851433839606, -0.39889937591202956, -1.6492572535488523, 0.4201595688680788, -0.1572134604314442, 1.8864864876843357, -0.3050765303708004, -0.6542010657501547, -0.8211975842502031, 1.484122187873238, 2.0954338636386467, 1.683783959277287, -0.726576178306733, -0.02936173189499832, 1.2723591399211813, 2.0150969041967817},
    {-2.715724545991987, -1.1810535783688438, -1.489600511806851, -1.627782758007963, 3.6663007335743747, -1.2687430570046374, -2.151496179538446, -1.590199441024, -0.6316046489786995, -1.4483368762127287, -1.4917037121512853, 0.7254125025428827, -2.0060387570028557, -3.3673044503248324, -1.8529437325704436, -1.1729137226475057, -2.0312347336882364, 0.26125887578248747, -2.4953890929855005, 1.3518520531582174, -2.0952165636788984, 2.8000028465751976, -1.7239901850589123, -2.2847313800614493, -2.800467823860466, -0.2549592264252813, 2.475493434664711, 2.0177494572028496, -2.4657506015780797, -2.254967930776507, 4.0469081350499625, 2.5977951885688904},
    {-1.9971099897220097, -0.6595655759147914, -2.149852299360933, -1.1690864152900802, 3.3923929135925657, -0.6215758807018289, -1.3559766777430917, -0.16273886781363678, -0.28053283431880954, -1.6838996278829006, -0.43093329466070246, 0.5339691459255034, -1.3506739813480628, -3.0523920983150004, -3.4871111899960012, 0.09625145875571936, -1.4456555815800958, 0.6387181564721061, -2.9453901343070026, 1.14565305792099, -2.7142117217530637, 2.2919363727968993, -1.072879000706748, -2.7809708545379626, -2.5373964846863952, 0.596572326002014, 2.939879090337378, 3.175537313216508, -2.008470679229504, -2.9586964140782603, 3.3036203092727927, 3.151235461913755},
    {-2.7597787472417252, -1.7048745945815018, -1.8180114080009138, -2.034424394859122, 3.094272289291964, -1.4617276666521128, -2.356886405995723, -0.9984581276169018, -0.9084434443262366, -1.9456389835375425, -1.7902618487930808, -0.16724163308572193, -1.6003527025612188, -3.5820574741259317, -2.8134487874340808, -1.4742576719469467, -2.564897654210021, -1.4908418151623186, -2.593267182166216, 0.800154609169921, -2.2209447076917748, 2.5058994957552874, -1.6834313787068007, -1.939859755497845, -2.756817453258153, 0.6274768080790509, 2.528477217013061, 2.103785523340669, -2.3886256594962303, -1.843560580131466, 3.9403642014581117, 2.1631327426733242},
    {-1.6812842554985197, -1.8372511778634344, -2.4346468170122613, -1.1326315132830347, 0.4394905792142856, -1.9044647020527268, -0.12437987194555211, 1.0930552244898948, 0.34388657822096313, -1.5912588125106968, -1.2478458170206426, -1.8178161743106673, -2.002924080140504, -2.230675815766541, -2.2156825145856853, -0.6977777804940645, -1.7855199975582396, -1.298615197707248, 0.25506883245587725, -0.09188703777943384, -0.3947734947453476, 0.04195685760112273, -0.437916764887456, 0.5509226290889769, -1.4776174948151084, 3.0649754674482286, 2.7935735934059065, 3.557865958748187, 0.6470262333621416, -0.8185311047405952, 1.2322011364424486, 0.738442974255024},
    {-2.0249343743714903, -0.7717807094783793, -1.7494951867950645, -1.6274386445397566, 3.95133226909255, -1.476877363102268, -2.419199037654975, -0.6465117290389772, 0.59740323612403, -1.6382397869055028, -0.4262060593053396, -0.6269774655904065, -2.820792940821986, -1.7231934721368387, -2.5329468460583167, -0.7746968421253394, -1.5480055806815631, -0.8858515172262018, -2.2989360266366803, 3.527912733823389, -2.005614330201749, 1.7950692372616328, -0.8679319789972187, -0.826229384613159, -2.264668373045155, 0.8209067226976487, 3.854588280012926, 4.319012240687203, -1.4448857998925977, -2.7377254454091604, 3.731876943848301, 3.852481963396856},
    {-3.5654974527472985, -3.1373621632409763, -2.9037191134722486, -3.1496067679736863, 2.211815996708821, -3.0649451727977928, -3.282689951606403, -2.1177925955399597, -0.9475568680235028, -3.341428933062337, -2.82971174564618, -2.9596950489599925, -3.9035062584766913, -2.2162701815447754, -2.619105375631635, -2.896106389812639, -3.0263889817751797, -3.0552159743649776, -1.2810161197990997, 2.9423118641863577, -2.445243225079308, -0.8073223385902213, -2.0906578569383147, -1.0398724017513032, -3.190578646653115, 2.4253214591810552, 3.2399725139940774, 3.8400007332764092, -2.4742695749142527, -2.75032239872333, 1.7652517844279514, 1.8883251632162172},
    {-4.689249568817497, -3.8511473495344597, -4.455436941688684, -4.074751460586587, 1.9812300783833945, -4.286512534371527, -4.067479550056541, -2.9257760879278516, -2.060502691223417, -4.524325869971106, -3.7086415344271595, -3.3841787931458187, -4.123049723047443, -4.536096170120268, -4.1860465349038165, -3.8507497360926344, -4.3403377501586204, -3.2420700785165018, -1.7126860915215825, 1.2858578822559317, -3.871991043146304, -1.3159308900515305, -3.8039193237384623, -3.4571696247637775, -4.326430117764813, 1.6696672109776591, 3.010903880526148, 2.884432561519967, -3.9562427444274695, -4.104354670364303, 2.3698571292078316, 1.406581285313021},
    {-0.5280454913036925, -0.26481599509592996, 0.3687771032715711, -0.3768985270049439, 1.6197172283174535, 0.31340977983637786, 0.5592360241883944, 1.763271765309486, 1.6753909996982852, 0.5439709895782797, -0.09853502912010044, -1.7729128775116774, -0.9713201788726331, 0.7196928087710049, 0.8928385407507943, 0.39808903638552684, 0.41158843532705536, -0.25305055373711083, -0.670427307195066, -0.04652711350010482, 1.2733207260183652, -0.02322937311954368, 1.3405543997080018, 1.70273258914594, 1.0855486389333127, 2.2881225774656757, 0.8065502526615719, 3.4684130816412546, 1.4150181886384041, -0.34231705481052566, 1.6605055165740852, 1.6783236470859777},
    {-3.3101325799941814, -0.16987983515388524, -1.8847063273931774, -2.6958906664507194, 3.6515644316608054, -1.7574397680224767, -3.6907397614294726, -1.0731387133461054, 0.40220644283216217, -2.3579415358614955, -1.5071776319185783, -0.09686123235640436, -3.129273636878417, -2.686783356161612, -3.0520035438088176, -0.6708415484709056, -2.539537391581398, -0.2366827922681998, -3.019843293065159, 2.9169641038925875, -3.502076928218062, 1.9268463252866448, -1.5843692435185999, -2.691382215370117, -3.0910536643021675, -1.7198623263379191, 2.3130402431163164, 3.774425985677143, -3.3322644386855917, -3.807527491959484, 3.3383060517378307, 3.488799495105424},
    {-1.3399319295488878, 1.1765210184239854, 0.45864753635621003, 0.3242954138597015, 2.998242031836305, 1.1551790652996936, -2.482202507381266, 1.7013103079945264, 1.7235849490768231, 0.06701447393018646, 0.27950098913082405, 0.9100755033681338, -0.9544854415460753, -0.29924592573285363, -0.3079664767705503, 0.8830570765139195, -0.9728687327794991, 1.0901561840751695, -1.6698640764045736, 1.9944838631144155, -1.40665455263534, 2.1134633951052786, 1.2581157940181331, -0.7184716727587085, -0.46045078361386843, -0.5864566030533827, 1.2937976786299976, 2.589291882940002, -0.9150902752145519, -2.8258735551741414, 3.197054044197409, 2.9468974259827747},
    {-5.013881378597071, -4.802886896907122, -4.31613458242137, -3.973327865547347, 1.4137226854291485, -4.824830683972469, -4.1072012491991, -4.17449265528491, -4.5326486970749675, -4.593231222387634, -4.687562052934201, -3.8684420469285987, -4.397061915892743, -3.363699884543025, -3.8736863444948306, -4.94548873245577, -4.688572635584861, -4.804182722032609, -3.604854386257281, 1.5877214567225268, -4.760507871651869, -3.321146429040021, -4.8995490311105065, -4.578061662317442, -4.775219353825447, 0.028057442992183452, 1.5546637106348349, -0.6763169838768965, -4.706550142024117, -5.019324785984114, 0.7961132593776992, 1.0027509185914754},
    {-3.623432416159108, -3.875452521003664, -2.801451449344207, -3.3070868972412826, 2.761356681840226, -3.7067960724330247, -3.8822287846459975, -4.091837508261439, -3.0499855884854745, -3.4001069730371256, -3.5433983923231596, -3.2457406655117484, -3.8763249414627823, -1.7800136836544662, -2.9040890391522685, -4.298935052737916, -3.2734447177114503, -3.4208390115558793, -2.3970612349910807, 3.30056783246119, -3.8017518597852265, -0.7474383577406503, -3.443433045300683, -4.187646186851485, -3.8549303908850403, 0.27331314556898334, 2.1340642060524284, 0.47217737610884175, -4.256124636129057, -4.193509948393144, 1.396307037318609, 1.6938451793643297},
    {-3.0403851833555215, -2.613470160731432, -1.8318889822484123, -3.038299653268424, 1.740507774539322, -3.4105609541996516, -1.8079883409403634, -2.760235808204051, -3.391700547322388, -3.3737370852918867, -2.538502459508166, -1.773102378890705, -2.351109116269625, -0.43026735102252106, -2.4895569481988646, -3.1560925265077633, -2.5668723424215294, -3.717454723094732, -0.45163089934509415, 2.452779449327928, -2.3886323808292604, -1.3489743706632213, -3.0459639032717822, -2.588466264269179, -2.7985590719485214, 1.106576414439789, 1.910510520800764, 0.4648560068304504, -2.9453894609656075, -2.2014590787006623, 0.5019216615976254, 0.783013084189292},
    {-3.2089842477512933, -2.6043074849074554, -1.8790716240909675, -2.770377457647228, 1.025388720503211, -2.6409609249768473, -1.9153761463663967, -3.272839409414769, -3.613884478143864, -2.9777597297668947, -2.8279790921670456, -2.2468058575405174, -2.61863216990661, -0.5334786677942598, -1.8562347418084282, -3.3335300617970605, -2.889980001214463, -2.9264063892271475, -0.19207519416020444, 2.552881277311842, -3.1073846430176584, -2.0104547568390907, -3.0192211122790176, -2.3347128605751686, -2.7070180070898444, 1.1056245839721952, 2.4541228158139767, -0.08835714229998032, -2.6390228551347072, -2.1325037312908104, 0.8224305794271103, 0.49445215511463764},
    {-2.2494760094429314, -2.011640678805367, -1.6979230714299844, -1.3590849813618535, 0.9011311159281916, -2.166535806881858, -1.8122118458561256, -1.879161852605843, -1.9155660141380817, -1.7646734661472674, -1.1409886650522016, -1.3472244063176173, -1.6221016428597677, 0.29079067443595474, -0.8718305447208102, -2.392297433735084, -1.4729896985216766, -2.1068087346144213, -0.44839044673203154, 1.439216095392044, -1.462117466911219, -0.8981290326452126, -1.91926099848566, -0.7179935593476008, -1.5117187840121429, 1.8033147502706592, 2.526584725280098, 1.0680615642766824, -0.7946800832824148, -2.5221417990794737, 1.5658007507007228, 1.0792032140326797},
    {-1.914749021281956, -2.1937913488154868, -2.1263755594502927, -1.4851117573149386, 0.7356017245017143, -2.1435976914450143, -2.2541729711256706, -1.9512296006980823, -2.4621971593699494, -1.8118660121954082, -1.4257864089645196, -1.4777167826979185, -2.2264354935112127, -0.16432343875301514, -2.0106370688076223, -2.8645034910688674, -1.6391642312210377, -2.583381707531646, -0.7896670194972653, 0.777591623597478, -2.240125342150078, -1.4141071938342349, -2.9912295038451906, -1.3653666155546715, -1.9529227041991177, 0.4529408435023895, 2.364818577483395, 1.1708466406358247, -2.077640044689599, -2.472487901692181, -0.47342653565037024, -0.8968926984932983},
    {-1.7971895761746175, -0.6693005815947536, -0.9399577318850543, -2.053728255778091, 1.7163532717095484, -1.431624805120816, -2.3131152035411073, 0.006148784721717777, -2.6361452845550675, -1.9322166064731696, -1.715067334446097, -0.8965962678127125, -1.5144698570576307, -0.20518130037001103, -0.4616281913081247, -1.5693147753237084, -1.692707685885358, -1.3091276659943825, 0.11788905301040711, 2.447971438713346, -1.819090434131792, -0.23701803722585268, -0.8912678931099771, -1.179340510263009, -1.3924570817079207, 0.596746075832289, 1.5250360643996805, -1.0094151114065288, -1.757077642846941, -2.158607235023238, 1.5360206186001604, 1.7809398531073797},
    {-2.3561732236796926, -0.06077254241492669, -1.020365991449697, -2.6030009141803436, 2.0103914409112313, -0.62583521545125, -2.1611457575206945, -0.8716317180969192, -1.4968047818674464, -2.260041907595672, -1.455742988620402, 0.31599405924947416, -1.119708735717288, -0.8703368323480112, -0.5885021534100202, -0.37520833093295947, -1.7045763657326618, -1.0505926715604414, -1.9913603986935648, 1.626947510251017, -2.5037099787760364, -0.2956856543576057, -1.122630356118604, -1.5212199104119497, -3.107833205617364, -0.5728361862423332, 1.2487666703068838, 2.38896585080273, -2.0269810421824284, -2.321911011031359, 1.81497868524655, 1.5716299997009675},
    {-1.2555908289858755, -0.5126135442524087, -1.455261322457161, -1.5111487998887874, 2.3886925331265667, -0.7998675864531701, -2.9300526353307825, -1.7375221684425946, -0.9690037978125697, -1.6032498423852948, -1.4124934724291378, -0.5515293307139194, -2.5662639387904354, -0.6954214646083018, -0.43526417926646427, -1.5056144652318746, -1.1079657723369143, -1.0238908256496069, -2.7335353939329186, 2.191806513720664, -2.4010227493094565, -0.10062855062416025, -1.899450546251009, -2.401565795145952, -2.030291543726892, -0.717600848603821, 1.7790087419773042, 0.7204714277207959, -2.119884539209308, -3.024668511066477, 1.4227697338982386, 1.8573121844772074},
    {0.07854538516870073, -0.1412012243106823, 0.5791281881631908, 0.9508310789609314, -0.3166748985895429, 0.16046908226264972, -0.7017575522302415, -1.7369157686062526, 0.4695361774961405, -0.17102587875323524, -1.3955384030976339, 0.32304731275223175, -0.7829418004027322, 0.03248859683310826, -0.392883483215909, 0.6784217187096535, -0.586804113977715, -1.2176091713432238, 0.017148953038875876, 0.9447373360576987, -1.7507058293694189, -0.6131812951214779, 0.3344635513444839, -0.49225186147294253, 0.1292291165757817, 0.9496709117028879, -0.26684995283421054, 0.47000395857330485, -1.340705322357684, -0.8439318024012368, 0.23369977236069805, -0.37097102692861433},
    {-1.3495051206377697, -1.5933904941723391, -0.1392187098611378, -1.949937776628366, 0.404784487668247, -1.2727327313476677, -1.317749617393749, -2.187572812317301, -1.0537892610809336, -1.4211948318550442, -1.3059079621351457, -1.2888575957119885, -1.5378125692324618, -0.19454310621259704, -0.9273978186809533, -0.6529969681922324, 0.20345387283598496, -0.6697771004143068, 0.6142402434007771, 0.47844755603550954, -1.534247009186466, -1.041335631548787, 0.4593333330757318, -1.4751725769217867, -0.7431350638514758, 0.09483984063372805, 1.0348903189924785, 0.7093477000031992, -0.7945888601956667, 0.4860060609696089, 0.3443742290309188, 0.974132160480359},
    {-0.37972789719417993, -0.5934090606673708, -0.45409646096925443, -0.9412555633290904, 0.06633286680335602, -0.03593778732357254, -0.29454191586979045, -0.3926816184061517, -0.6933953433778588, -0.7846900046020514, -0.5741737356685535, -1.132158327274116, -0.40836968441560945, -1.3034893500687008, -1.4845788390214403, 0.03584140010792483, -0.33727863097565963, -1.3813734370826867, 0.9496504186731859, -0.8757810842269045, 0.04539930338519192, 0.04031632459737622, -0.09464487955911988, -0.14376208907686938, -0.660267260345572, 2.2201334609031607, 0.18232819772293848, 1.2234034257937634, 0.1461407920252691, 0.6344319834690022, 0.08327122007950968, 0.7403488579696605},
    {-0.4636455335037026, 0.3287873427438312, -0.014054393322090334, -0.046727254143505065, 1.9002753457640424, 0.38523113844460893, -1.7557411211996048, -1.5457520388994173, 0.5154902660433479, -0.8890070070159839, 0.10861166085208755, 1.4573444471778871, -0.6104285992837091, -0.1987403072458427, -0.20470207888743136, 0.4894253615031698, -0.18636969563207229, 0.34673006176389687, -0.4574835990699947, 2.171261750220833, -1.8785908030174476, 0.4695225887375317, -0.05899467371838819, -0.5811470137417394, -1.4990909608488863, -0.2572352918090165, 1.9901218171846717, 1.6561623481857735, -1.7623153049707372, -1.6964927008384323, 1.4297157502876714, 2.232918298828477},
    {-1.4697747149647848, -0.1327566925390778, -1.16078112259282, -1.7731305142582743, 0.9228547280978131, -0.08765988831655867, -1.2854791747283991, -0.2111487878682158, -1.0965850528045835, -0.08798069668585067, 0.7022444187752857, -0.1997825600568231, -0.5620980177149636, -1.5889264989760423, -1.3838000804568598, -0.9007947643203527, -1.7413090004138831, -0.6120030286225674, -0.7960799516646548, 1.095086512750788, -0.5218817397832446, 0.9439311172098535, -1.4961443742776186, 0.04077349256598468, -0.749713420159341, -1.6118401464023275, 0.24059006583176212, 0.17721669569759899, -1.072425571395478, -0.7151379762155289, 0.4561602638237499, 0.28667047619192426},
    {0.5018252363362659, 0.2054278355453565, 0.21708912100181488, 0.5222625644221097, -0.24467552825683017, 0.22672344857740245, 0.020887316990252588, -0.4287211177402672, 0.9020873901421316, 0.1416099314735864, 0.5572314320917138, 0.6277735766190876, 0.09820058136182945, 0.673534655841664, 0.6095588922259955, 0.9837513782326087, -0.221087302141782, 0.8668581660946995, -0.05217255464664438, 1.269364997990448, 0.15358024102352721, 0.8797101605307507, -0.09928805550684665, 1.1752608579863504, 0.31059530609819364, 0.4997800280752964, 0.30423404798535003, 0.8984625349745816, 0.41016607045676806, 0.2183665763192518, 0.3649678324935129, 0.36846512404189397},
    {-1.0866759974115607, -1.0293302432108065, -0.6058545000634604, -0.5802760568942451, 1.049373767072739, -0.5856591685852423, -1.2623776283288148, -1.306620587658891, 0.02686488274185478, -0.08602993880144348, 0.3158203662824984, -0.80478208268183, -1.38603053472236, 0.9729426685359286, -1.6916016049599696, -0.24767040697614748, -1.246087884458286, 0.17040841523342684, -0.1584754203255936, 1.424782006470918, -0.6305637619320598, 0.7383260299312595, 0.21355279383063558, -0.32794144074352466, -0.36560513459777055, -0.5675197659799779, 1.5394488595210098, 0.24128829120944442, -1.4188916320711362, -1.4219680176479368, 1.0162652153905058, 1.8100886790742585},
    {-0.15068115163540563, -0.6583287291989136, -0.6746958495698063, 0.6613538982161483, -0.5014701382381, 1.1418135385697237, 0.16713118582827718, 0.5407999122624435, 0.24580687753491237, -0.04643393805466925, 0.8648546345260165, -0.5014474322128887, -0.2518246237450321, 0.905127873997642, -0.5797635077286136, -0.5361063877050908, 0.08014334292489726, -0.08378517191364628, -0.3387855569450552, 0.9101923821971851, 0.7374866019966578, 0.8642214527159828, 0.5438107134397604, -0.0809644570029127, -0.3771882056439845, -0.8538708908799566, -0.5742955057903588, 0.5404419833273211, -0.7793544918447626, -0.1527943300606287, -0.04347438990719079, -0.17379350015258713},
    {-0.4315183859511466, -0.8038397468296026, 0.2879371710024287, -0.3134071903682441, -0.5851436435306263, -0.11054847392922953, 0.2312634151735386, -1.959627401747448, 0.28383279915684173, -0.5634488566788325, 0.19992438667453458, -0.24755024430301967, -0.46774110992526596, 0.46857780060222604, -0.4212372552272204, -0.3377885932244321, -0.1982989868503005, 0.11626341873739655, -0.04540143352206335, 0.7064459690876506, 0.13218785009701106, -1.009296250759534, -1.1407006721633943, 0.2943174261675725, 0.23685288252294312, -0.37072580470145355, -0.0772290273402652, -0.7335706889751202, 0.050623272940329846, -0.22934982245082344, -0.39584782736073504, -1.755303241454733},
    {0.7392531304928862, -0.5345644250780759, -0.07411034247939634, 0.4589733286229523, -0.5938222849277973, 0.17245487845518379, 1.2836808228782028, -0.605567755914413, -1.1283065675683948, 0.11002772612624298, -0.707054343486381, 0.06112717103616151, 1.1475503290801472, 1.6398036502184419, 0.9630606637476375, 0.13108208097350482, 0.7492372621310613, -0.44484118469532763, -0.028614580259185615, 0.2598128637098772, 0.19089172361098047, -0.46010404719900094, 0.5213334434446882, 0.8767042653509134, 0.5454884621574675, 0.25892684337400235, 0.9351018378387732, -0.31543086542289633, 1.145042064576176, 0.7580263953249761, -1.2251101335617174, -0.5819185014968437},
    {0.6907801085182852, -0.3863017858798836, -0.2295589984388446, 0.28009786298495004, -1.2060265130782037, -0.5909824523985499, 0.941078734628708, -0.7684600309055396, 0.9580356643334373, -0.18569715010358132, 0.12603264227634864, -0.3180571165331747, 0.2655695608842371, 0.7247518749751487, 0.8137845440199221, -0.05183824096024353, 1.2960846503735712, -0.8415337371536356, -0.34145022967519867, -1.9877494324584744, -0.08961682823234172, -0.016082143239573733, 0.07460366130885224, 1.218070774423189, 0.8166016054355207, -0.5387330453736993, -0.7929177501188611, 0.2435239155564567, 1.101755791284108, 1.5004601800808182, -0.9113951500485586, -0.6459548165963881},
    {0.6299791935712502, 0.23821639848309292, -0.18584958663111575, 0.48100532204305607, 0.3973914400538042, -0.22292151172680097, 0.5375099376262586, -0.3947532074136978, 0.8784374131076599, -0.044370728370137384, 1.130585434679477, 0.6906906895803021, 0.39123033756051606, 0.894577774695045, 0.004358003801852792, 0.43543111589876604, 0.6097756660914825, -0.34247913230757937, -0.3400600078905691, 0.4055142641912218, 0.26787797252446766, 0.38276095997546533, -0.14969619480766527, 0.8778916613195998, 0.9830380946570038, -1.8290443580877456, 0.42079204928613556, 1.4399800995891534, -0.56176291519994, 0.32240404253893096, 0.5593912746664845, 0.22121804758106828},
    {0.5236772358010499, -0.3932939943530675, 0.19561178644326493, -0.1198899709630718, -1.3633685614256679, -0.0625560497237029, 0.7982070261098387, -0.27005453525736767, 1.0274905775137975, 0.10089834842562888, 0.11974326118306272, 0.21285492046686227, 0.4904829194351731, 1.477804160251747, 1.3749254693349013, 0.47386052777234333, 1.639690775985747, -0.5388994660843264, 0.3159452880491916, -0.14902881947070076, 0.5702767078217963, 0.6970283229713967, -0.025841637454218927, -0.2803501842818108, 0.8322601689402243, 0.4017813712477948, -1.3656251893002704, 1.603784058894039, 0.7124145032562902, 0.11261311140959356, -0.23247360848930934, 0.9331847055530575},
    {-0.43285160688600655, -0.21059526389412994, 0.18515795687411218, -0.44132667289607397, 0.41450276742555653, -0.6128685958318211, -0.16596271502046295, -1.8545760559687428, -1.766600828225869, -0.21135607470149614, -0.9611780669143749, 0.22781805309911562, -0.6937295265784302, -0.3143693738958365, -0.1103314767472049, -1.0730685080414422, -1.1649587142301983, -1.0124865243997874, -0.20574937127500273, 1.6283875083996024, -0.617274594690249, 0.6628862210564759, -1.643021230118321, -0.3032213655150492, -0.5557333885054421, -0.10840543576911903, 0.19653365369367903, 0.16214997479271953, -1.1713864270650227, -0.2456754798405179, 1.254703534700774, 0.39139469556559087},
    {-0.12106482739135181, 0.4510304852042397, 0.2953949783250678, -0.0830162302890981, 0.45113596404719614, -0.12673225778370048, -0.9531130772470164, -0.9473944699010118, -0.34876510598884886, 0.24162657326426498, 0.3198159237120455, 0.057677688434345085, -0.3191872049655649, 0.48625932941599087, 0.1933085933944369, 0.03182744627712042, -1.1763059419451514, 0.42583367088717433, -0.6978255165886411, 1.0207646709143365, 0.4147622814089246, 0.6450478487811098, -0.006160282664527473, -1.4105482969417977, 0.4632940296535148, 1.692854698009749, 1.222653591775613, 1.2878007466549188, -1.0766877884747574, -0.9861616186256251, 1.1298562301125499, 1.5025624096638945},
    {-1.1431800805152357, -0.027816028117386146, 0.31789340380954584, 0.30711213038958307, 0.517030665922263, 0.5893879697566087, -1.4123452519005217, -0.04064916716726704, -0.596758874267624, -0.3309638794483224, 0.1369242897023713, 0.7716687568783939, -0.8105072376016494, -0.4524670224464601, -0.36921118318643287, -0.5332775453196423, -0.9182654768182943, 0.9542913227738984, -1.5636872362611594, 0.9147149324214353, -0.5770775604407622, 1.4586746834602267, -0.2927069601418228, -1.7008431371481338, -0.726359481847555, -2.52767753760985, -0.1681206272604831, 0.10532576690776019, -1.467373720190692, -1.266578627815528, 1.6084188914546087, 1.0613050586099935},
    {0.17157269364791575, 0.08713460891099377, -0.4068624926810494, -0.17599182408870098, 0.42782216458114786, -0.2003483210977184, -0.5692131621824562, -0.24227712712533414, 0.19735028776689312, 0.8803728890541704, -1.3263428405799924, 0.44373823107044874, -1.1451580837149917, 1.0877545180884298, 0.48544466413410586, -0.15592230905085677, -0.8271884789344871, 0.10131082458520216, 0.10439449904755922, 0.6106288801427207, 0.05714533986606077, -0.07112118854320346, -0.7772565137245641, 0.6367424591594345, 0.6983320669450023, -1.5410478829169074, -1.253881913801808, 1.9171357717875737, -0.19367115183996866, -0.16489670969329226, -0.2248057512925245, -0.23867839137573788},
    {-0.10674633791401127, 0.4139073048752594, -0.7993465185248709, -0.9883370638160007, 1.6514254603988756, -0.42974543524982206, -0.8144570320484879, -0.8147848030443808, -0.4885573682390552, -0.45448822103634734, -0.4107143487139083, 0.0872716735981317, -0.34880028885396375, 0.0828489075233429, -0.918168277834769, 0.26696263054559405, -0.7142287565335884, -0.21185260893515975, 0.9744513012292016, 2.274600415785462, -1.4270759445851633, 1.0881523888771225, -0.726947649584759, -1.457919363516649, -0.3903931547384891, 0.8672145123530965, 0.9372160227068518, 0.7781285278020713, -2.1090783823229176, -1.7925104544163672, 1.4809158816541144, 1.2872498205403309},
    {-0.2296064118078645, -0.3822338334924839, -0.5867458535693442, -0.7454416867403837, 1.225723311626762, -0.16545004538431476, -0.975184659905767, -0.6970150886284061, -0.06031679248579153, -0.4323807030392171, -1.0570311281914893, -0.38168685008814546, -0.9355961876646928, -0.3334139831633951, -1.1126077151496676, -0.90627946096378, -0.10271891012305115, -0.3121507906525247, -1.1370305080576366, 0.030492183102403557, -0.9986733405402785, 1.1544531805230067, 0.22784305589482856, -0.6770324497971945, -0.3780535613914034, 0.23577870108650417, 0.8957067370994565, 1.8251482215206478, -1.1904269298112053, -0.32412153717772, 1.6412975333687536, 1.7500012536751466},
    {0.04042843649866806, 1.3486221356217603, 0.011564227939304077, -0.02889095469014836, 0.7425984508216005, 0.18839258794453978, -1.4335049708612144, -0.751998352776064, 1.0319632540832524, -0.2918670236376209, 1.412843335526587, 1.2778057981086735, -0.4802645930473401, -1.2509015829869867, 0.30892475374740225, 0.8596290015843043, -0.8730090401059954, 0.8778964644965366, -0.8304098833578359, 1.6258761551210845, -0.9229495256276193, 2.05176223696116, -0.1166854459508394, -0.7628817663101966, -1.2199776704146266, -1.0527288519001916, 2.145361373583632, 1.124415588402894, -0.3099858714230426, -1.2335664111826874, 1.0065264211892029, 0.029926015201697218},
    {0.2517443291831094, 1.1913474424518564, 1.411029579551297, 0.6618857450884428, 1.548623317526052, -0.2227490916062006, -1.2421413059878184, 1.0275719868386362, 0.5678060175507936, 0.7770159808112074, 0.011222068372029964, 1.3675392064777985, -0.794527923570661, -0.35418082823704633, 0.5988795458971866, 0.8251956773240174, -0.3827600871423616, 0.3387886417047903, -0.6281922080742771, 1.672166465970547, 0.486180023122419, 1.5793790074353162, 0.8906272803721377, 0.7226212723784742, -0.3535538402250469, -2.179052531770881, 0.3738172835407347, 1.177294475445493, -0.6505397584104139, -0.2691890966650656, 2.0506931984037893, 2.2152602603142824},
    {0.48379265303775565, 1.4062587510389581, 1.3875517302653655, 0.6918064307722359, -0.4512155417216649, 0.6530368756464949, -0.10523400315027319, 1.749737098887253, 1.0306815072589097, 0.771664808587517, 1.1611628272402752, 1.0917758756609306, 1.4786735276093188, -0.008732746755463011, 0.2520416624868018, 0.36906271473955277, 0.9277246836189843, 1.4550746074841645, 0.5584529564700622, -0.1406885310989949, 0.5161201279221924, 0.055384657534386456, 1.365590295282794, 0.6306193619528324, 0.0635786653552807, -1.2216776535589382, -0.4856723490337191, 0.26253628680604885, 1.500224355873778, 0.8901635557878481, -0.6232912545030656, -0.9826683843955237},
    {-0.11001042665790733, -0.26157148765530897, -0.2166756001502648, -0.4514982024366393, 0.11991795631900337, -0.2814547731142175, 0.328840985037944, 0.6500604230214652, -0.3711827613262269, 0.3794955057961187, 1.3962503494334964, 0.25204993862399216, 0.2997054168278921, 0.12787188245151562, 0.00461347916475321, 0.14484788583287206, -0.5886222603324636, -0.6772263635073228, -0.6307852160420434, -0.41775453300696513, 1.1393489541634192, 0.6694708628203669, 0.028422041601372103, 0.35226798285523775, 0.48211303449743304, -0.7847161219082497, 0.6965684827913007, -0.5177864009118496, 0.5951031363019202, -0.8361580979389719, 0.51117187637897, -0.6666043878380765},
    {-0.24762191057951652, -0.5723526663924853, 0.3779945741168022, 0.3240542966428661, -0.44079159495411685, 0.28034095933306885, 0.39815260518198226, -0.6594035746638882, -1.1164486508480371, -0.6201437468506183, -1.375462939154575, -0.31845961775125503, 0.497034271244552, 0.2884477368438592, -0.2853853497870296, -0.22689034125196156, 0.1979149875793142, -1.159478448494487, 0.4803327202523776, -0.6921068029898015, -0.31751161890522367, 0.13658563717014868, -1.0100312249195642, -0.9304970764588743, -1.1250421016099943, 0.7853996087840727, 0.5144017749167433, 0.15104901190908918, -0.6464807454367069, -0.049082116917755596, 0.20012183073671222, -0.5288398240691641},
    {-0.05774860225203059, -0.33095081344286825, -0.12332384158048995, 0.6893481551025333, 0.7356433577244608, 0.09562528071163556, 0.1345288207456606, -0.9930762660406913, 0.9962041319984843, 0.07223465779364294, -0.9182946233121952, -0.3086821057695363, -0.13174960763174104, 0.13033989753798625, 0.22668528774184138, 0.5668407597164276, 0.7812592126839827, -0.24213556762523447, -0.8294710073779504, 0.6763155881786194, -0.8226292014497816, 0.3873155825738091, -0.44514981504385975, -0.40374184148611747, -0.03759592526398903, 0.2786140539067405, 0.8154852637581965, -0.1008614974518125, 0.04925527060287374, 0.19371847757604493, 0.7766612878929746, 0.151925096134604},
    {-0.3376956137177543, 0.06491692184748676, -0.5934997864993244, -0.07112856558205566, -0.3788119238328323, 0.5706067099408033, -0.02179080579438507, -1.0477703556125195, 0.5814873243768661, -0.9473215727078974, -0.8691674324909752, -0.19392805050490106, -0.6594448598296438, 0.19478162417045658, 0.41563793794432174, -0.10609004736578719, 0.6729157529401762, 0.6064899741350274, -0.0840178723325524, 0.7756578317395006, -0.720118506011926, -0.5254227173642839, -0.7184180537826046, -0.7542118369635482, 0.6485801095362521, 0.24574173289847115, 0.0037701436639438787, -1.0263217509613438, -0.152315415993341, 0.29523895214299495, 0.5500296467525139, 1.2639838697009707},
    {0.3358569572103856, 0.43614681137383887, -0.5914851214569695, -0.3406770467786205, 0.7636072748430824, 0.8225816889800831, -0.15271473197188304, -0.012577338993842073, 0.3699665167693695, 0.5325434624367936, -0.4294585876667243, -0.2251038545753449, -0.9972713690971896, -0.4685307746493799, 0.4779516934822236, -0.32494811978227656, -0.0027056709727522137, 0.9911058512200013, -0.10167106957237924, 0.22686454425437433, 0.5646385709186252, 0.29730699730722765, 0.28817216010560137, -0.2765474883210501, 0.7472586058575722, 1.1988911687297021, -0.7557154281251263, 0.31330977365712176, -0.66870367314734, -1.015172353568803, 0.34208115466247646, 1.2825949795469271},
    {-0.29270235634633307, -0.4164866614867673, -0.8236435890756382, -0.12253006858390011, 0.2717530819845605, -0.25297764167825815, 0.20350741671811406, -0.26565777133014207, -0.51699139844217, 0.41263762465563225, -0.5577941532608068, -0.18187412275190437, -0.7199924537458583, -0.011335761885534265, -0.1340089820951529, -0.32034070792066077, -1.2230493538237994, -0.09761222414495617, 0.8459084988045031, 1.0072444319507285, 0.22208941377543623, -0.001755418377511582, -0.15395412370687514, 0.5299276506761639, 0.09987761318268128, 1.6880233007497543, -0.5895434211150438, 1.1421840436213988, -0.1893461368437181, -0.14998592371412003, -0.2811604912121314, 0.19864813479905066},
    {-0.3891693032387626, -0.5664576184483514, -1.5323994808319121, -0.10387596787844712, -1.042141920142975, -0.8414722471964589, -0.9542383913055338, -0.9329830723976613, -0.40729775394634543, -0.4456509048979213, -1.0651352489467172, -1.1004549779969781, -0.8691171619635036, 0.027674007279629355, -0.16189643210536125, -1.0687672124838143, -1.338561358364039, -0.3412982904779572, 0.0361625249463598, -0.2097212392731229, -0.5960810670907248, -0.1597529459387189, -0.3570599956645585, 0.7509947720327559, 0.044381674533961, 0.7462694148229916, -1.3399041638969929, -0.4241498086964791, -0.9800747457942887, 0.1916537618769423, -0.46322483115822444, -0.8472848170828059},
    {-0.2500767563982837, -0.6427595126471136, -1.4702478724389203, -0.8186873062860414, 0.4692137828323445, -0.8727930958236447, -0.30301113251106016, -0.8855794823022954, -0.7614431215801487, -0.6878475589998642, -1.2801417511326993, -0.44461722567522355, -1.0673934797713795, -0.49297615158967095, 0.22812188770181852, -0.7743934925604871, -1.2232361079583998, -0.6108132029382476, -0.003975062716156696, -0.06866309074602446, -1.5076165230504783, -0.15358405326673713, -1.7856955019161342, 0.23046696452888935, -0.28450144524188936, 0.3601408439187409, 0.006472172513205782, -1.0973714865194226, -0.48820272118718155, -0.24925857447071062, 0.08893802001433763, -0.155152112298235},
    {-0.19678499945959108, 0.03519025794752, -0.06346658896460922, -0.3410474357833633, 0.6152395693634273, -0.3346286837722696, 0.6219679801771492, -0.18216692893239822, -1.0639227891190086, -0.6600004937781963, 0.0609430653439293, 0.14948446071296567, 0.35832131113840043, -0.4755799060999764, -0.03725294231729487, 0.28822104729471054, -0.19321419004480567, -0.6034632978792979, 0.0856234476520782, -0.4566564623444924, -0.49726470211179774, -0.4672114293030968, -0.8168764539067588, 0.4828627733838981, 0.22836790752234146, 0.549900239065793, 0.7190600174645968, 1.036711916902619, 0.6572369758444567, 0.43122168379825154, 0.1913386939509351, 0.33320819701067317},
    {0.05462098868962774, 0.5960508824702622, 0.296019242860605, -0.5886563296526605, -0.5937655250540036, 0.07741690751165761, 0.6060326897699705, -0.6543314516502825, 0.22174385343286682, 0.048627901930304085, 0.6333083665407472, 0.07507544096843109, -0.11248728203683307, 0.11855645751630783, 0.3493701953860233, 0.6769954300482396, 0.167405911969946, -0.9473921689360032, -0.13012080468974366, -0.2074168689153802, -0.52799301081957, -0.4748499904030595, 0.628005216954723, 0.19908227255185862, 0.4187314716883078, 0.11948502564731649, -0.5015746640936448, 1.4667951225056026, 0.40716212077181974, -0.3594688409598157, -0.1159384827303897, 0.3079746623696176},
    {0.1413542112348707, 0.26621949580362775, 0.6417243860442279, 0.007427770764843529, -0.3162489725487509, -0.10526868941240708, 0.578017711033373, -0.2998097201993927, 0.6865576395416808, 0.8246079619639678, 0.32792193210751097, -0.11420000307277492, -0.8681963220523693, 0.3016143786775905, 0.0012355826704878114, -0.5054941894426441, 0.29051159322731174, 0.430121245821904, 0.4111999511450302, -0.21130166784491952, 0.46179131563635084, -0.3908399376176481, 0.10979260732469505, -0.47604485493306087, 0.991401241753755, 0.19125861675443065, -0.343017465906683, 0.18456345658150164, -0.4040804325033425, 0.1151478675758343, 0.2548306585433219, 0.041745189655207585},
    {0.45103273679482236, 0.04453179782139158, -0.48220893595801606, -0.12318643590511381, 0.25557290755258105, -0.16887621643174036, -0.5497031194367848, 0.7073969841327286, 0.3678537294065927, 0.2617099791273173, 0.5490625201458996, 0.5673670643390407, -0.4507915208691364, -0.8304711519828425, 0.3951153338051034, 0.48202624785942116, -0.6637157094588744, 0.2813559354361728, -0.6451280241273104, -0.23472041668818666, -0.03390337599078906, 0.15322715379981153, 0.40450731582262567, 0.24818273257690138, 0.29304219157743916, -0.02955607366750531, -0.28232036020967843, -1.2745132350874109, -0.2995671929760138, -0.46338128119173205, 0.0841990817372125, -0.3021971257660609},
    {-0.2146115685191849, 0.1659355515625092, -0.5485787765128678, -0.5781072904809111, -0.2071536458383579, -0.20072983390862467, -0.8388271721792836, 0.6497151813639677, -0.38919594128806095, -0.6188326417298655, -0.57973905647082, 0.05276026401951028, 0.013054321565756831, 0.15865669514812192, 0.24312559912373305, -0.5413555019584239, -0.6615102273360371, -0.7505881348645537, -0.28877400617658905, 0.377002262117352, 0.40269589085710455, -0.10837248304291654, -0.5312678738921783, 0.5762452239910801, -0.9416630842040509, -0.22052362493958913, 0.3150484494052666, -0.02928599028941545, -0.07616665254962637, -0.26738741684900647, -0.07060804465008345, 0.8668127382889105},
    {-0.2369179268646369, -0.3739024929532857, -0.2569720184733011, 0.8517826255691848, -0.40767081012410944, -0.07812758888286865, -0.2117972096011476, -0.03634929812747971, -0.6974262547126457, 0.40031930661115317, -0.5110093406493902, 0.07964756761773086, 0.6272700260579387, 1.2441712556299307, 0.8223886486312271, -0.3998696316991762, 0.03807680301170703, 0.4363440198187462, 0.18391162204736441, -0.22923948498901817, 0.6778926373220847, 0.519688724662138, 0.2281016575054743, 0.5138680118889346, -0.355998757234401, -1.0554776542679007, 0.18618297642771486, -1.0277184790696727, 0.9186925393976924, 0.5230909189086248, 0.21074790276173533, 0.08157446101346519},
    {-0.3019519399147911, -0.8595543608786668, 0.40318696165749274, 0.14429702507522726, 0.05670042336051539, 0.4005603294089061, 0.47461728096753225, -0.05827815808880738, -0.6160744354064199, -0.34528627924554556, 0.17522483768687572, -0.49671415288171095, 0.2688091726264919, 0.798859889751259, -0.481530816369755, 0.40975443598951666, 0.420631321678709, -0.21763897243160507, 0.16106774061686224, -0.5946963436606121, 0.57802436711013, 0.010737293234309785, 0.2028169111308684, -0.20293216741722453, 0.23970373613893553, -0.049484625637200796, 0.5035027212168467, -1.2395980660986732, 0.09944728637519797, 0.8739337812782747, -0.014594967785588867, -0.2972784133044628},
    {0.028344330667231472, 0.05645207355523316, 0.7589528155827199, -0.8314450673320861, 0.06392510699041784, -0.26849164068242354, 0.2206386325797992, 0.6924605599103619, -0.007318918448342146, 0.05863528871101797, -0.23837198870429224, -0.3017191470841014, -0.5008693251605579, 0.2821194225195813, -0.5425426277407764, 0.49252290862468134, 0.5065480692065895, 0.2270621268019031, 0.5929109776339405, -0.3453189371104932, 0.7839373228285245, 0.1867794604990671, 0.666966062289585, -0.726755315588563, -0.10795091659190448, -0.6681606711298111, -0.7809146415052525, 0.17894158964853807, 0.09415169649578327, 0.4677115939931913, -0.3042461391882751, 0.06482454165854598},
    {-0.3241548008447248, 0.5407638015806158, -0.30948737976484575, -0.545576794967649, 0.6573109286988298, -0.1659505857084834, -0.014829136155676631, -0.3606213022497236, -0.5136690682566996, -0.048600848011094266, -0.07669290643024994, 0.6238027219463399, 0.0758915233851065, -0.06960438124187643, -1.0909710539762272, 0.4805886205596701, -0.518052041898612, 0.23384417260003743, -0.12815521879559702, 1.168625369121985, -0.6655457903152588, 0.5774254507529962, 0.05885712187130123, -0.6837738107645237, 0.2757858841914079, -0.006640924534372186, 0.6433310068219148, 0.2702695606270754, -0.8011272967394428, -0.4897228406696943, 0.7439539429585061, 0.0466433057546805},
    {0.8297396610057473, 0.10678280297626885, 0.5632259954015834, -0.3591931249761932, 0.597557191956708, 0.210533419428118, -0.07948351219609884, -0.8472904714323123, 0.10022703895437039, 0.6441835944749408, 0.5222432315055889, -0.36910236674097535, 0.18124191318238206, -0.7315595567040857, -0.27947524927585393, 0.6561824145113793, 0.6756241671524922, 0.753661032955419, 0.16423459478175445, 0.24321652985015765, -0.027204356654658268, 0.1886960887592895, -0.29014684369501803, 0.1918598452597203, 0.5225074637403547, -0.7605569151833868, -0.3198806497383527, -0.13128270008879045, -0.303082047211185, -0.11303660003178799, 0.7856892741358267, 0.41446772900109596},
    {-0.3925721275586752, -0.02261049868742156, -0.06512811730791074, 0.29786471188498687, 0.26277180678032186, -0.27485111494394815, -0.8664431888198448, -0.824881663383346, -0.2683588369527816, -0.559744667970173, 0.13962570353501388, -0.0316872959524027, 0.06087168643857424, -0.5609472711979561, 0.37206721497925316, -0.22333703207566288, 0.40473269207804086, -0.39997959082897827, 0.26170387381842486, 0.050735622197239524, -0.5071413297787659, -0.16580652101431056, -0.5022595572580374, -0.3760381775929579, -1.1280366100203718, -0.2828439133070496, 1.4138403744226646, 0.5715206561176271, 0.2292908984536907, 0.3876749741353405, 1.0842969102154925, 0.9237419294604461},
    {-0.43662760976711334, -0.6916384899141503, -0.021986907608059606, 0.5008991022586381, 0.08647519961477183, 0.01093326060982663, -0.7398727841054357, 0.24621385537217094, -0.7618832910084952, -0.12453589392600783, -0.9185502654440671, -0.5656930798893853, -0.30451577170398436, -0.30906460964809224, 0.5170137782205468, -1.12446249156119, -0.4434641892372942, 0.47181474207001906, 1.4460102429624204e-05, 0.10918149621674011, 0.28191425439037593, -0.9276398419840792, -0.7280598686811749, -0.5659406379239875, -0.320087166951881, 0.11711410173836198, 0.35353744940957804, 0.3099998559488557, 0.43997958717692276, -0.15190774628717887, -0.8226505834814036, 0.1999367535593675},
    {0.1621361467857399, 0.2836825646742061, -0.313372307617332, 0.035036678538851534, -0.8896535195981601, 0.5440515622180054, 0.5891526501605966, 0.10664977978336486, 0.09241871856549086, -0.23738888460404436, 0.10279632702393052, -0.08295814580621964, 0.7488540436792323, -0.015318736040961296, 0.4521510928606641, -0.5277079217827445, 0.3598674358585244, 0.4326802955473202, 0.31379233330565764, -0.052880261443888854, -0.4012077347091336, -0.3626448895480151, 0.7652591606427926, -0.06692426487210879, 0.5487928993747049, -1.2112141343898, -1.0434734679328306, -0.7645280506917899, 0.06690014945852481, 0.1674083457578655, -1.5872902763779084, -0.4342499997388101},
    {0.7481145247597492, 0.15526921028194748, 0.49598267713444133, 0.3391869367862811, -0.5633117539290408, -0.21574689800638086, 0.9016465626307755, 0.08870222063917133, 1.4780904820987624, 0.18460567893314742, 0.9411614417971722, 0.1781654995803704, -0.3716297691037014, 0.007519838779225186, 0.5624869137014604, 0.9090898244005274, 0.03322552824885521, 0.03704586529247058, -0.12462569366240916, -0.3578770015397144, -0.3496569886269474, 0.1651008560830958, 1.0546957206021337, 0.48478431391919924, 0.8920113672368024, 0.8369276291182144, 0.014748913320861045, 0.4053393472879219, 0.8897246246000218, 0.5495557874778075, 0.0014440185710223377, -0.24695823979978557},
    {0.5104954146866331, 0.4919636109636198, 0.11397277113725507, 0.3737438062475268, 0.04732909215030874, -0.42550777570086057, 0.1541707965030977, 0.23170171398498257, 0.9849252872865344, 0.11422315455556253, 0.7657328770459532, 0.01098737478736998, -0.5117653488256013, -0.17207723816435222, 0.16632981577984463, 0.14838344547780885, 0.07602943860286217, -0.11006423834291078, -0.4531590218800178, -0.48564603986082017, 0.3099712880724154, -0.49583350227434575, -0.3274994590782139, -0.6873510424277105, -0.20961069082106276, -0.10196571666941351, -1.107230190904743, -0.21573523451485416, -0.28895249968604253, -0.5891556671919043, 0.265486288976775, -0.9488128375215018},
    {0.1862534808804487, 0.2476379691063204, -0.5540406302695333, -0.5313238060709704, -0.2852077091542673, -0.6231971670292069, -0.7631246274017256, -0.583150629223827, 0.10953558521155597, -0.5610037084659479, 0.04247800360947319, 0.035256520095377025, -0.7380344582379553, 0.15898294673471616, -0.19325737232574752, -0.7372253603426423, 0.4148253146347781, 0.01533307025536425, -0.9686458936318559, -0.013569304351599544, -0.06760373736505822, -0.4100645459262228, -0.5792174980259267, -0.5803287808241634, -0.2966920420179961, -1.0436744613950553, -0.6885412449069104, 0.957263226685572, -0.4270516759995056, -0.6593077799925965, -0.1848348182609015, 0.10323763705071666},
    {-0.4062758932003184, -0.3266121106025183, -0.8092358821276727, -1.1070823116675075, -0.16866660635696787, -0.38559268994246926, -0.2685261980604146, -0.7424671284908954, -1.3506215414439853, -1.2293961901329353, -1.4279466124418643, -0.39564915335511375, -0.1972032384510029, -0.4254101216471114, -0.014683139120106336, -0.20161976083262192, -0.2809992220837491, -0.25748730379868356, 0.39523046352668023, -0.8648036788326315, -1.7860396234263234, -0.5927304374231895, -0.17468790067386486, -0.12032502795613614, -0.030213321915425966, -0.03234470605379547, -0.13892877581469995, 0.8162524288347741, -1.0247739764383963, -0.9554079069637159, -0.6147980276343489, -0.29426110856734927},
    {-0.6088675819795469, -0.8757681949802434, -0.8892865175199869, -0.5572342305864996, 0.05421916669743071, -0.7725045828780873, -0.6765805234557567, -0.3700837303282095, -1.2054042132477127, -1.0250480311489782, -1.1314830353879552, -1.1416814186206286, -0.578030492845987, -0.21680180178020927, -0.6284837572995903, -0.9782037548855501, 0.3040475770406349, -0.5793193505757873, -0.10854058192678231, -0.47409021396817946, -1.511880705230666, -0.3089647973828443, -0.9065380486430548, -0.9272950438360239, -0.8211620384675921, 0.511393588302218, 0.5953110431099548, -0.10181813480407653, -0.6158031893220721, 0.495838777310256, -0.592014965840714, -0.7002880592983289},
    {0.5699313325802932, 0.005282489864798443, 0.49520082440768876, 0.9228407426544795, -0.08801129164820118, 0.3679744770592064, 0.18424650266131895, 0.877882914296112, -0.12130518066625079, 0.8565465551593636, 0.17422662185910687, 0.5210413626033948, 0.30805292292472497, -0.8626920127075565, 0.07187923858187308, 0.45937912987855767, -0.3592838530212352, -0.7949475370684, -0.56187046994005, -0.5273859286325907, 0.34974166299130904, 0.2510030003639914, 0.9346831931904637, -0.7125363700480123, -0.352246833030159, 0.12398923418086509, -0.1518780802175092, 0.3494929087189993, -0.03386316477375829, 0.5166424901347771, -0.18769428609080618, 0.16715069463874693},
    {-0.8343142651816332, -0.5936364234428232, -0.5987472942898061, -0.5271166244193383, -0.43914165362000335, -1.5246860649496412, -0.22408384082958901, -1.2908702978978914, -0.47130597481369835, -0.44438778899936693, -0.07602137643403083, -0.8673087067094508, -0.05170215444577868, -0.7241233936221821, -0.8520934693928859, -0.027874070167533228, -1.3574283444206916, -0.680424486663012, 0.5890580515501261, -0.2531323397483658, -0.3867518863268091, -1.0529200224561106, -0.09635049123945434, -0.25563060358663275, -0.39821046907074, -0.0284121521405119, -0.04734162312560626, -0.3411374210718107, -0.8317306729200394, -0.8784176257010983, -0.04051086853519954, -0.14497895102305045},
    {-0.1854586086466921, -0.12509728004784496, -0.018136887855169384, -0.9902148540005972, 0.6680310044093684, -0.21208110014083312, -0.3202304822945318, -0.3681389038991977, -0.4652198816481932, -0.28436256346871625, -0.4063072654599867, 0.18101157002278556, -0.4361566648288962, -0.4465958447974604, -0.6977683199057837, -0.3424304844894975, 0.5165731168401174, -0.2012715045112557, -0.16624432369458986, -0.19422000540053622, -0.5221415793892745, -0.21706408520127973, -0.7208194871729482, -0.2023217412843501, 0.12333398450058256, -1.0292147057116603, 0.23633333326807737, 0.3511094059609516, -0.3297851631656458, -0.00676107330504999, 0.37035528723591177, 1.1331702662848089},
    {-3.9156318410302613, -3.7892830851846804, -3.0825357176799857, -2.640587799055737, 1.790702818153769, -4.2588681451475585, -3.446113406315802, -3.661564963004751, -3.514696495688387, -3.5620317098145002, -3.83666889316516, -3.259241617167951, -4.0855495362311745, -1.9858281205268613, -3.4042486004045474, -4.081805329982252, -3.64081876383513, -3.8489152844924197, -2.3570205718049047, 2.2058417504221906, -3.5605192588009595, -2.051349227612517, -3.9002709587851205, -3.8438861069456776, -3.618356355040765, 0.33560852433800686, 1.3804431497055256, 0.28852160094328305, -4.214254857064565, -4.759829825176458, 1.1010778374358081, 1.2488672164916916},
    {-3.213192564553196, -3.5474835913307605, -2.523573338075005, -2.6458459415390814, 2.1545642113158214, -3.6187022063965086, -3.7489953479474254, -3.9482309089390313, -2.2176386275018056, -3.2320882528318924, -3.5365093712196463, -2.9621925364825485, -4.003324019851127, -1.4283251556440841, -2.3079539007744, -3.6764544140569937, -2.6831799143629413, -2.636521058465657, -2.0269026921335556, 2.8758457493522114, -3.2856620176718354, -0.3534117200251218, -2.9801878221658047, -3.795501545807511, -3.4205097443894554, 0.40262798808940153, 1.650542735008067, 1.1388929451535401, -4.121262220944831, -4.3186770139018575, 0.7521445375818508, 1.6663036443915828},
    {-2.3279428945315614, -2.040715556464569, -0.9684167702455572, -2.3489239624290708, 1.5690554195583883, -2.8278082443992107, -0.6391382408229945, -1.7561464593017362, -2.4725715584154373, -2.794071062911986, -1.6446821715526985, -1.2158628944350436, -1.9835814477390774, -0.31229010378365524, -2.3673821041711176, -2.3188808064175443, -1.8622841715204241, -2.889598648548797, 0.6100862922396646, 2.350168272080784, -2.1207070996557222, -1.2721238742304888, -2.6375903993438885, -2.5544952548964757, -1.9305570524572064, 1.531698359119142, 1.933867755022138, 0.9065786188637067, -2.2998149985487326, -1.5219976755531197, 0.8629960168110095, 0.9704829319788816},
    {-2.3667224600003323, -2.3994594088332533, -1.5995312565496986, -1.3600321947905327, 1.0518250351331413, -1.5867073516717276, -1.300340576497837, -2.4785989800528605, -2.9755423961622385, -1.7962294929907985, -2.337807560011834, -1.903472333438754, -2.1851840769382602, 0.36653083690983895, -1.602888904576573, -2.5709687687928997, -2.2530252396097232, -1.809634913935075, 0.47409972738361617, 1.950278076014638, -1.5584575182810814, -1.8548769258634348, -2.0805763485162143, -0.907063827456506, -2.3158776924196722, 1.403629875981205, 2.383644120323041, 0.5780804713536204, -1.704647234506014, -0.9945161885950115, 0.24967073123185418, 0.7520471025067622},
    {-1.617756143104715, -0.7312872384484341, -1.2716940419507798, -0.5063535493963613, 0.7719522303641329, -1.2229035610821182, -1.2702011492911995, -1.6026691161168645, -1.1658811592382674, -1.466112175585174, -0.22493980902735272, -0.5634902350912548, -0.8123476983686522, 0.35454027289189644, -0.45447896533706805, -1.34006351758742, -0.6976231681368714, -1.4390008356474815, 0.3692933366022809, 1.302656585078859, -1.0952646078676564, -0.5226860326180579, -1.0058781001557944, -0.8103882209827257, -1.4012649774648749, 2.1968705899973595, 2.5606554104725725, 0.5363316284816106, -0.7710522177847647, -2.01915453781299, 1.6216931538630424, 0.7716903410478485},
    {-1.8874051720584093, -1.8912249374379788, -1.8992513271294924, -1.2239225824202873, 0.2890046676655301, -2.1385746826500034, -1.872480918806963, -1.8705121846248736, -2.885497823258314, -1.6453741878505104, -2.0104074836155195, -1.7638880502371737, -1.890016569022559, -0.16006835934106028, -1.5857284425816014, -2.624225245118188, -1.6937400040672335, -2.028935035985424, -0.7688672982094011, 0.7612280592688412, -2.2984081817959403, -1.499248581530773, -2.899818954987913, -1.8581838527283252, -2.4852171157119125, 0.2960299289625089, 2.1641304506309536, 1.0582703255794796, -1.9304097304460546, -2.1864179041957925, -0.8925240379217839, -1.2819715186722365},
    {-0.571413564709179, 0.43065841762047224, 0.4560312059087327, -1.29120168755833, 2.2635003969254295, -0.3272509427515527, -1.8514047605595256, 0.9893917211250502, -1.9415004330974888, -1.1801991266265508, -0.6734663990871844, 0.5311752167015201, -0.25411930282230816, -0.37005059032921067, 0.3961267836293386, -0.18747599285785713, -1.0383355453789391, 0.21553300740617787, 0.08218618713325555, 2.3923810905940357, -1.2909008225181327, 1.0291046606134509, -0.257520829386354, -1.444587144757527, -1.4703763318397913, 0.11437951718971977, 1.8500580702846723, -0.7775866418209865, -1.2674984828950346, -2.1696178048515864, 1.8157088030922286, 2.155429973078996},
    {-1.7313677993422645, -0.24482992981726953, -0.9145515132862038, -1.444083254027603, 1.5746609306773214, -0.7060292516589556, -1.7672076745002916, -1.1703635107196426, -1.500200384501221, -1.7461018481636341, -1.2193822139798807, 0.035962595635366135, -1.4399859915593907, -0.4530553654440441, -0.47930933786185537, -0.49567956636905125, -0.8704542630512192, -0.8418962097779396, -1.180612948417362, 1.4765271679086043, -2.103569643805194, 0.10643905481329301, -1.0432562105564118, -1.6218872409698948, -2.5218174011252974, 0.2889120560334698, 1.1772953678594202, 2.0888321754399106, -1.5849959182609599, -1.725402212667983, 1.2482865626554462, 1.2940267340821283},
    {-0.6074939031677733, -0.47258975217598265, -0.9281064473727481, -0.45855152404025384, 2.2186301052165867, -0.07213483509705358, -2.4896894301959915, -1.509525944894667, -0.46436776222727116, -0.8718738461574372, -1.0323762752461725, 0.0920414023006686, -2.4071457834691414, 0.28999087966979875, 0.2552081174455853, -0.9399205265572439, -0.2033921441354595, -0.41795651737934514, -2.32686203247672, 2.012652618276118, -2.0982687201109607, 0.6070010412972989, -1.9132172342003209, -2.1947894562147305, -1.1657100999370216, -0.08979761842853012, 1.5403707189084346, 0.9661699951024851, -2.7570431524910965, -2.9232785395495293, 1.3347778903353558, 1.928240492298679},
    {0.6135906249788841, -0.13447823342261628, 0.7343507414668391, 0.9697983499495858, -0.5287259229596966, -0.05802738348719328, 0.0012206905106208125, -1.448900875063486, 0.19356811895869594, 0.042500598182895664, -1.3504740001877873, 0.3677262358726731, -0.7443778801792861, 0.5675402528392827, -0.5706857523378939, 0.4528294787348952, -0.4996317144457046, -1.2631267341105732, 0.4904241500208041, 0.7270213973166667, -1.370338643861217, -0.6293340666926186, 0.32101177531447583, -0.7145471727299999, 0.6952931638417913, 1.9601565106718692, 0.1544370492099485, 0.8237876264788955, -1.1910652946149745, -0.9758953732227755, -0.10852771198624994, -0.38584922262203364},
    {-1.1028616491586627, -1.7774926110040739, -0.5784909609510038, -2.0918954263015226, 0.07894115661952025, -1.3432054417855672, -1.4681528110253994, -2.2515669697968814, -1.1343482266684917, -1.783117885005146, -1.9525754539369864, -1.4442999622823969, -1.8128979420958728, -0.26860962251716636, -1.6142669145499269, -0.7187705495864539, 0.27264307509469515, -0.6868821103241032, 0.3582281211375783, 0.6798379213285355, -1.2739970903662443, -1.2185913900413907, -0.020692676164128673, -2.016301090511252, -0.7730620816680647, 0.3845835168940968, 0.18012796697683678, -0.31599578729641903, -1.170959094422972, -0.20576106373899775, -0.2704961244793121, 0.9712508564110283},
    {-0.47289437280203755, -0.047179430843146596, -0.2580039003618657, -0.39472590114636824, -0.08279715221480571, 0.16200023340185774, -0.4099238455413238, -0.004855535678122395, -0.4839458939184726, -0.26754119975277074, -0.7921243309291185, -0.7486891686035196, -0.7052045380756305, -1.0905750777847443, -1.4261517300934603, 0.20974659634213816, -0.2751214940133196, -0.7501097619057864, 0.6566594025819434, -0.1341972269064974, -0.008872905230438098, -0.1946836983024863, 0.22014065912912728, -0.05342632103187933, -0.23513573278099523, 2.0563318528965295, -0.08217583372343322, 1.3486902154171785, -0.18459920646986844, 0.02311943021470918, 0.6130053127664858, 1.0635757025907895},
    {-1.148453884478745, -0.676998341427483, -0.8520409582326235, -0.7784834270454843, 0.9452623135071361, -0.8151517529346228, -1.8834270613146595, -2.2636886997607975, -0.8384726639214295, -1.6024806002595045, -1.067055972392464, 0.6051524082993723, -1.511978947299422, -0.3274750811717294, -0.8545356771894911, -0.20634631548106372, -0.9849198695419568, -0.6408967677722034, -0.3239279895485485, 1.2307922246451162, -1.4457564593191083, -0.6960968866702473, -0.9057752499724919, -1.0669302163662258, -1.6974650922143504, -0.6139321184796777, 1.185587239917765, 1.400511999664606, -2.03496414353942, -2.0792531872232423, 0.6864405593577803, 1.3522043710307834},
    {-1.349468235179396, -0.7501349669743049, -1.074892077017738, -1.9434506977203538, 0.7830089148609695, 0.23990972992169454, -1.3722403191961743, -0.33582829026884986, -1.6002566274981191, -0.4935963615636057, 0.5776936157407728, -0.7429009210831531, -0.9274587059254756, -1.6736378189753724, -1.6038845521923653, -0.6362791731692128, -1.3935818622102945, -0.6727115117193336, -0.33730346524092925, 1.2391177287638078, -1.1431376975023502, 0.711627156626258, -1.6431829060390866, -0.48775799349828725, -0.3383229375476127, -1.4573901825716222, -0.06925764928820045, -0.34744547804906767, -1.1545738924382487, -0.6519863055183404, -0.13512499172890235, 0.6030819908082546},
    {-0.47159708240414583, -0.748478507129788, -0.5836344348072758, 0.5181803413456644, -0.6006046351792101, 0.01354600006168246, 0.030087481475968413, -0.9798170688199528, 0.03364500472641457, -0.5824761026560362, -0.022658230835628356, -0.13395640112472432, -0.062109580981625716, 0.039796036119002, -0.5508084851741876, 0.48015998690174033, -1.1954947481858773, -0.08524792506772845, 0.191490593294485, 0.5346428730049251, 0.10622611090888641, 0.30583900580244305, -1.0365338748163275, 0.12836718116674914, -0.5241214880528838, 0.4000814471027781, 0.05754620112574437, 0.10637678298079754, -0.11433033522810554, -0.20072329722302498, -0.37483336691659974, -0.30118281296763644},
    {-0.993029806328689, -0.5422122852294715, -0.11324334588601885, -0.17773756027971438, 0.5774184582824209, -0.21917094778698173, -0.3978140071276851, -1.0585823316492395, -0.7478964688393906, -0.09502243173775587, 0.33922027737853494, -0.22257186322408404, -1.2783959341490434, 0.5565230349124022, -1.5231979510801283, -0.48223199884570783, -1.0586933980785813, 0.43032770491920747, 0.1332544014772665, 0.9095234085854744, -0.34581201982837384, 0.7882146886265825, -0.28414033205939604, -0.6598182105671414, -0.21142049463348456, -0.5453673946936245, 1.421527362815481, -0.8895468762835412, -1.6167257494553307, -1.525692160567496, 1.0351707555686964, 1.6424279291079324},
    {-0.3872265287789493, -1.4806375731703747, -0.9336999632515881, 0.20304255119461964, -0.6811531763040053, 0.5447420932276301, 0.13203257928753728, 0.36796202491795693, -0.39702533476372065, -1.0087917623211675, 0.017870982287392225, -1.3078433494750312, -0.8876215142075018, 0.363844892187192, -1.2421230159678607, -1.3919149005699958, 0.036134886321547446, -0.3650068842645617, -0.3127234870447541, 0.6300284113277184, 0.35783077913096534, -0.3245315049947883, 0.21072524441197538, -0.4599942841845603, -1.1372192393496126, -0.2370877729408753, -0.1183829625058701, 0.848623330632505, -0.5546928395021526, -0.13746914330492072, -0.6935692081378094, 0.017982089850773163},
    {-0.8427292437367683, -1.2063969516245379, -0.07128007482916264, -0.96697589937034, -0.3332232334526303, -0.7835114102950638, -0.5775420371863386, -2.2839394221096834, 0.27467099890614577, -1.030305634226106, -0.24784641608710947, -1.0130080649467825, -1.2361870982562315, -0.11872076190340737, -0.8127079184765449, -0.4833579519006303, -0.298455608479089, 0.057011462356733454, -0.31461367444958926, 1.036058430889261, -0.3720384534263311, -1.5604916218441405, -1.4739322695041202, -0.542104464577902, -0.12679271225117386, 0.16094636812626162, 0.24617549603521238, -0.8952705863087539, -0.3603436246363606, -0.8712564229971343, -0.1866784083068564, -1.4325104488190874},
    {0.14097780213818464, -1.1944173441602028, -0.6994415297911634, -0.2905449827537774, -0.3412242908792424, 0.032666558700197995, 0.1347881811802312, -0.6303633599908532, -1.6196072967338777, -0.18081010306372405, -1.2507697216809375, -0.20444022228000067, 0.232528923463355, 0.515556312643111, 0.0764619217759158, -0.6216539217368358, -0.06992248460140371, -0.698203988169893, 0.19430632657168773, 0.8680460660740513, 0.17329613745199654, -0.7543587406234442, -0.35806055904143125, -0.27254552179734387, -0.03785148445387207, 0.8889543231019134, 1.0309115531288275, 0.31121399757432505, 0.7149208525305539, -0.051462075985044736, -1.0663097941150685, -0.11942241673574015},
    {0.1159295565851558, -1.327860410686584, -0.8520859312824507, 0.05088714870001311, -0.7032177226708323, -0.8193666130671173, 0.3829459215352355, -1.6976704209096618, 0.4069740401531036, -1.23028982761146, -0.29119722202586823, -0.690880587424648, -1.0155858059451544, 0.5395106621428302, -0.11037342960534242, -0.8925463400596662, 0.9840019383063346, -1.4466455573401102, -0.09484499834898259, -1.6133050045669075, -0.619442389516766, -1.2470920978530091, -0.3346773170178927, 0.001889184308491264, 0.5990298952552633, -0.9999822580111376, 0.018562266032789536, 0.5942445496253591, 0.669545140289738, 0.5802978555553148, -1.3327131790556312, -0.038964590406061594},
    {-0.07410112111475485, -0.8373839840091848, -0.428634635312958, 0.1814957918327482, -0.024071946285970508, -0.966590075713884, 0.09946868154853489, -0.9877386752433727, 0.31356595342025806, -0.4651083204264549, 0.46754995962358514, -0.48744801649643876, 0.34036870139688696, 1.0640875449622116, -0.565679914643395, -0.38527834559769936, 0.5104542007697278, -1.2970963754476332, 0.10966257919811914, 0.1454917466066155, 0.09232179410959526, -1.0169863461036517, -0.3588593720640052, 0.8385479628358908, 0.7067314224786183, -0.3017939562885764, 0.9871034996072379, 1.7931813438569262, 0.06689681747070365, 0.200223413495176, 0.5305645082510095, 0.7936023816403168},
    {0.38409587412183405, -0.9895804864160186, -0.34132353720566355, 0.4082727189929231, -0.7038098455651726, -0.4918121362457894, 0.9093966334107586, -0.14767092096893622, 1.11995061898163, 0.45387261721977257, -0.18643569750026662, -0.06493795465698692, 0.23882848179876962, 1.7374714329264405, 1.0297144884955876, 0.16788019402803983, 1.7360145516964989, -0.5800588577652817, 0.43689747440822313, 0.11673305377108711, 1.1497925766337118, -0.08402686122159368, -0.5411664746433664, -0.14307824364612617, 0.7920590594811131, 1.3744997493684958, 0.3397790226411496, 1.9217426644295623, 0.5567835637263816, 0.27466716569176125, -0.153963393612952, 1.3559243951055377},
    {-0.8481674106541275, -0.6696179656157814, -0.15610571160681835, -0.8045722197855621, 0.39356905351346827, -0.6872823744810695, 0.10221384810724307, -1.4537017024948193, -1.2048708202333052, -0.2845550537179861, -0.9419243532933366, 0.10085484183724913, -1.2184116278162118, -0.4415586142318092, -0.856265082240709, -1.447721757625001, -1.8804917060164723, -1.19367407325381, 0.08730202174187178, 1.651704334813814, -0.3071230066400621, -0.08844598158277313, -1.0973938807612478, -0.3136843210385364, -0.7145790250298194, 0.9533343091409324, 0.36486511740471805, 0.3957034889085381, -0.8351488470314362, -0.7014882536353051, 1.0308799250704925, 0.38192102832476915},
    {-0.44982030867089656, -0.6383849962679816, -0.004990043730522185, -0.04956488817505166, 0.0544940734061239, -1.1178462053566498, -0.048669427642891595, -1.4218245400874212, -0.8820952052325727, 0.3766702669939066, -0.6529381534636293, -0.2146463738369405, -0.2770991554112567, 0.1403036328613944, 0.4283948159619481, -0.33924653521937426, -1.1219475097096074, -0.6040151860464205, -0.4573055165128831, 0.3094282474372261, 0.2644308762764775, 0.14708595121688128, -0.02914767638064639, -0.7461604119061689, 0.29417847301538125, 1.5988126578879622, 1.1104932507445602, 0.8806621027464414, -0.05928945645175247, -0.030565483292356765, 0.9415703794264788, 1.1840504035616017},
    {-1.636774260408689, -0.47986212357570096, -0.32897744061282824, -0.335197884411309, -0.3062902977888178, -0.4337956498028938, -1.2513559386764965, -0.5437560344631917, -1.3021906485854826, -0.7485180051712415, -0.8366533763812113, 0.056588488397918885, -0.9357229989682204, -1.1648277606211415, -1.2675853083690063, -0.5735316129256953, -1.7213550856823518, -0.0808879521068808, -0.8698702674774438, 0.5767848087331345, -0.8223005870033964, 0.6199127411475346, -1.0337678363663176, -1.7898817334578105, -1.156730691564813, -2.2846035646868557, -0.2057343888931318, 0.1855078837877076, -1.5154476437090387, -0.9016492858581115, 0.7797650885012415, -0.05892694593304328},
    {-0.2307698938754033, -0.3002611154131919, -0.747085716244316, -0.5609265579805459, -0.0923554916261056, -0.9516525982396635, -0.866319519916814, -0.7274394923194303, -0.1277362376175804, 0.2849860643478447, -1.6039536472928253, -0.08363545510810921, -1.2260499979761923, -0.14035199210132554, -0.8556056289086118, -0.8666940312947908, -1.6082815195070799, -0.3686378917195052, 0.020126049243421606, 0.3282017530651587, -0.20426153594850352, -0.10589285002677966, -0.7164284478482204, -0.03777795087389076, 0.339922878771585, -1.2859224551148736, -1.180167569342288, 1.6184995195868055, -1.1504903209496076, -0.3319039021430507, -0.3195285909143763, -0.04655735333202307},
    {-0.6802336790184036, -0.34885201386798453, -1.170853379393673, -1.3841509383946264, 1.2235685164589338, -0.8717132094474496, -0.41090971436515344, -0.8899787685136114, -1.1128391249353717, -0.6441763633080951, -0.48326388511322654, -0.8096100926371627, -0.7139465100422172, -0.3337807685245374, -1.1136701703648706, -0.783613926431832, -0.8848522033430404, -1.0610659567124514, 1.2752907404014253, 1.7350841422636278, -1.4908182821106608, 0.0872139941509114, -0.8396463481154838, -1.6743765126524708, -0.9561802784152837, 1.3624462605655725, 1.53640045780498, 0.41942201718060396, -2.254097948935558, -1.6442177402658442, 1.0625121693452417, 1.0309588896646527},
    {-0.1624415894773584, -0.24411061223408123, -0.1122572960160262, -0.6395244054720114, 0.557671103922289, -0.06538010995733108, -0.8091131118208171, -0.5059919508011891, -0.5097297494548788, -0.1966063352878662, -1.2195659294594996, -1.2624567173713999, -1.2762302405085018, -0.12445050194781114, -0.6264614674849083, -1.1833559947578494, -0.5255741224229636, -0.8669634039608202, -0.21128154597662588, -0.5990096596907141, -0.23111019050804324, 0.30592939911881917, 0.24475361504013599, -0.8135259459364355, -0.6089330059486084, 0.5883336349515292, 0.6521127918641675, 1.3883355745092167, -1.010887619217758, -0.4076031860095467, 0.7740064432526131, 0.5595859153252974},
    {-0.6311504820556232, 0.31790539337751295, 0.05035955292233921, -0.72903676851667, 0.2526757860097794, 0.18722033244055986, -1.3280102553895405, -1.252066424142147, 0.34262621663011217, -0.560333693666088, 0.8697915281985436, 0.2332477134519864, -0.7925054078636083, -1.2243070419839965, -0.7068837070318656, 0.2653491354403956, -1.2722643409604704, 0.30334305933521427, -0.4363605705683418, 0.6581649323619277, -0.8501297158099417, 1.1248570287297934, -0.25169618356411766, -1.1596774469410656, -1.3976058111250587, -0.6820287486697316, 1.5590448106558155, -0.18545228883497572, -0.26350462390078305, -1.1093323663637145, -0.019150891207815646, -1.0509962006375795},
    {0.5208164409906769, 0.2501441141487955, 1.36509906348194, 0.7714026638466321, 1.3760896193789243, -0.6894827247978556, -1.1930762602403016, 0.9114631242208638, -0.3233908683382872, 0.4803556353705848, -0.7839906676077516, 0.9489684810788067, -0.8164680857746814, -0.4477163761953067, 0.9402306202263033, -0.15044410739693093, -1.0918674709956107, -0.09016906793927916, 0.1315870680583665, 1.3349140184765582, 0.8710619709118093, 0.7524108368590395, -0.05384400054888884, 0.5953479155860486, -0.9990325728276586, -1.820225827818352, 0.08527266486102932, -0.0114921421116434, -0.3879172437001394, -0.36603890264932115, 1.187881292858346, 1.2512574638110614}
};

static const float b1[32] = {6.094583819062279, 6.132845695378467, 5.931079904187949, 5.964012919319434, 6.248744963118634, 6.119159684044312, 5.790743333886178, 6.014135029832592, 6.063253859580891, 5.965051300667401, 6.067025033457596, 6.160298420624891, 6.144206329095657, 6.099609952799915, 5.848825234858245, 6.159561103320196, 6.0810850658036415, 6.135414879120683, 5.837621938846003, 5.917634384853454, 6.031095883488556, 6.17072406755315, 6.03360515643722, 5.813475554466891, 6.111786187982571, 6.247978456865874, 6.04435731054936, 6.350484426660256, 6.0447541331647825, 6.0885083406080085, 6.218018674918121, 6.161897385916136};

static const float w2[32][16] = {
    {4.982092785893391, 5.371754808338439, 5.00527766442371, 4.961045484368335, 5.205956135875816, 5.452199177262731, 5.190144924172144, 5.155013674095687, 5.503016993032843, 4.207923411338991, 4.982765535041178, 5.208970321782869, 5.194237415434592, 5.297415021491815, 4.625877817727985, 4.662347207557138},
    {5.703612752802816, 5.49696517546895, 5.153692236071494, 5.045697973536634, 5.3819159360679265, 5.556556070348111, 5.402910794299417, 5.58237343285295, 5.153722871755729, 4.824959898399762, 5.631941843312566, 5.337893050807646, 5.510970998014036, 5.273495100342345, 4.78043821856883, 4.829786824233683},
    {5.371737368225398, 5.188440727866878, 5.451328684163356, 5.496353107685738, 5.713098571489752, 5.641742033508872, 5.69109693782073, 5.721638373840406, 5.215321014519388, 4.56991646784195, 5.490285031343959, 5.384920940142134, 5.188917271679547, 5.389815827830367, 5.1610632095873585, 5.409741905127401},
    {4.910641338592173, 5.06885524683307, 5.43513029718622, 5.128187054387611, 5.5041466346137815, 5.740767594049216, 5.014053484520474, 5.298273403920592, 5.440860545974105, 4.408210092409266, 5.343271492909352, 5.3573164509839675, 5.154467736900812, 4.844608703131317, 5.27635887433086, 5.334456338632531},
    {5.421608817091076, 5.747273821410176, 5.182552346814841, 5.357012065889293, 5.5027859393235525, 5.351774817591769, 5.089323829556156, 5.843264240418309, 5.18247826712857, 4.292023929037718, 5.525183848916498, 5.482880731236133, 5.451778963844709, 5.162962301014133, 4.910519892475161, 5.400808189419908},
    {5.2143573972142585, 5.48205700712754, 5.616698893094201, 4.84998613430216, 5.044082175177297, 5.232854874809173, 5.222595244395519, 5.526060019163887, 5.403597523000369, 4.2685069854922695, 5.267348693692601, 5.181183631303136, 5.645590043729219, 5.027592098751051, 4.8742995773964735, 5.062355294293458},
    {5.349394964435902, 5.048881331663799, 5.317357369304219, 5.353948346220215, 5.427594869386753, 5.0342276680384, 4.983560280594432, 5.059120528492681, 5.154363404733694, 4.694249164870521, 5.332075663959704, 5.404853979495556, 5.294011430675643, 4.907559167559453, 4.820451846224139, 4.919580104605043},
    {5.0602155788529775, 5.354549395416042, 5.752479599466654, 5.488038107752122, 5.306617690920154, 5.21244600739633, 5.344623409034489, 5.165159151931204, 5.776720254602428, 4.771405399891461, 5.711455539854847, 5.630698659460056, 5.207700106066726, 5.338958092238566, 4.991892757729174, 5.120198862571943},
    {5.3464379598111265, 5.696447610752633, 5.804754268248759, 5.370134505912662, 5.547022334078043, 5.392587735155671, 5.42191617935244, 5.770425997133841, 5.191495779512231, 4.718873829073842, 5.370586108460593, 5.6545671515522935, 5.597428626089452, 5.64830307496705, 4.867623442497702, 5.012055810661485},
    {5.420508789297535, 5.296770378797244, 5.613903180393555, 5.4507940970134525, 4.998185946514864, 5.6645026230951, 4.954290789929646, 5.240999701082639, 5.077875929574708, 4.765991416742776, 5.535101495187262, 5.067291525004969, 5.574892160000884, 5.412692991657223, 4.5861918436561435, 5.057109633477594},
    {5.110522148591024, 5.589362166994248, 5.167339947536315, 5.134789919820614, 5.463171343377624, 5.574439219498058, 5.592783535947119, 5.84586756569679, 5.390978858427094, 4.799836997605978, 5.32921877167442, 5.478678032333695, 5.672316074967773, 4.921783080554256, 5.249607635804444, 5.332366566754036},
    {5.433875712002684, 5.2242004446082095, 5.1598106326627375, 4.973049830343833, 5.278094215899748, 5.872841951703565, 5.593145412855332, 5.609217717315206, 5.235139990988539, 4.25427388309606, 5.86960188088838, 5.399766490871552, 5.429449843203834, 5.384220282445475, 5.245550452701694, 5.259690839441878},
    {5.499931913396182, 5.131959834412911, 5.075957597249964, 5.339482946701755, 4.969379983664678, 5.289327464741009, 4.901434176212266, 5.633393036401137, 5.584845225447105, 4.400379773267994, 5.176949021556095, 4.941225244169141, 4.8538964457823734, 4.952733806015017, 4.726682883789756, 4.9866158806451315},
    {5.782017657053726, 5.2493383727854654, 5.4625482049604654, 5.163089487758152, 5.449998483150008, 5.8611922002557995, 5.8046260620611285, 5.627958456437493, 5.342913968063869, 4.459489852996034, 5.701715593345994, 5.360945258198255, 5.800920229989294, 5.638042143100847, 5.314536923083605, 5.441660912319328},
    {5.696685423359492, 5.196838844298249, 5.446678847433126, 5.044597605317798, 5.499575705811451, 5.295072899232354, 5.077625980638157, 5.451416572761541, 5.67406082191357, 4.340064876106676, 5.237424789449714, 5.708593641361835, 5.56597142624241, 5.286763491426394, 5.0059720094607485, 5.248865400606837},
    {5.409212345028225, 5.2602792171131085, 5.531720473733409, 5.288685709406401, 5.066197399652159, 5.715910148511446, 5.344947572755985, 5.4647162508771165, 5.353316477490171, 4.393679853254962, 5.373895071886971, 5.435328901605731, 5.473468645591306, 4.800243389248067, 5.2785199792877275, 4.772977041791567},
    {5.003318698246792, 5.386390567393459, 5.3763994431949165, 4.992960579274491, 5.430229678878366, 5.644638292725818, 5.036467440474703, 5.2974687378192735, 5.27232761848155, 4.670874673806076, 5.489204222659616, 5.210816132541538, 5.25751452781089, 5.088178500767067, 5.043575531917299, 5.207001399199944},
    {5.078028254608424, 5.248026975484053, 5.550468579149914, 5.284325322021799, 5.200515409091579, 5.68009879207955, 5.208180313749675, 5.592945615253671, 5.47278336391075, 4.3098590364475085, 5.679091806426883, 5.502608022757295, 5.337721607010981, 5.210920201509841, 4.895795071120899, 5.062620940952271},
    {5.55710404625975, 5.188739280025172, 5.362559203614287, 5.234972037909854, 5.618592800193153, 5.24160059846567, 5.2028572222316605, 5.228877360130265, 5.773756432975436, 4.496943676458482, 5.338722909201732, 5.593058761459419, 5.670644212328427, 5.518023421462416, 4.963949954550619, 4.896233501705609},
    {5.651629047969921, 5.298548193785951, 5.605962772407416, 5.395591866567076, 5.823030980424393, 5.536041213332105, 5.839773863251583, 5.4152591976057805, 5.8286222704069965, 4.64946662073346, 5.516903978153323, 5.432847183866502, 5.7298197831969375, 5.7714372615105, 5.423244130943137, 5.497337013302416},
    {5.378556551883314, 4.98128547916601, 4.999277085877175, 4.892069153189453, 5.219639521350224, 5.426702460164246, 5.276864164007085, 5.335983505156051, 5.526728209419348, 4.261200891719575, 5.075339458183751, 5.26134651147027, 5.030228728514837, 4.838437774938355, 4.5896727353380475, 4.660214909833314},
    {5.587782813498597, 5.444914751298683, 5.46805604915327, 4.947865616093524, 5.671588895095974, 5.930896697947867, 5.200474705529814, 5.7345211619272956, 5.451598336411176, 4.3602166086038965, 5.8200407384651065, 5.702942851357179, 5.213600041177739, 5.427559432703417, 5.351128318347972, 5.515381477696558},
    {5.1417916185439205, 5.345965929158312, 5.848282989695175, 5.441716320254915, 5.537021161737438, 5.614778395727856, 5.604608923612192, 5.795216559406567, 5.48129434582126, 4.322221989986526, 5.225864527493482, 5.419804398803067, 5.2320015354921425, 5.189667819830424, 4.902670542317363, 5.447371184377763},
    {5.202539928695564, 5.266084089339227, 5.499050633117236, 5.480342188489788, 5.408748392616677, 5.5839220723304175, 5.4844991236552145, 5.445266693384774, 5.33646605936429, 4.193798169748317, 5.200908393449776, 5.193482977650468, 5.580565759872307, 5.062647740938341, 5.123967476599813, 5.208329931837605},
    {5.3518326102928455, 5.467294868214088, 5.335448526619589, 4.848037315254418, 5.525274697401783, 5.4171951845010575, 5.143414542349695, 5.610668692862348, 5.42868631331666, 4.425919888752666, 5.181508289182065, 4.918639031454881, 5.351393806189251, 4.769025216443884, 4.974243444158845, 4.699983096564589},
    {5.167526495330428, 5.2699869491048545, 5.51440053220744, 5.60745646902659, 5.7652522634415115, 5.440836873903194, 5.492233210819995, 5.943594701821041, 5.503746336794983, 4.70426813569275, 5.90878377492251, 5.3761762943861795, 5.575078789204774, 5.187825026670311, 4.941756506565362, 5.35094947966676},
    {5.3997729122589915, 5.272790058419949, 5.375379280600017, 5.159783910742183, 5.710258745990786, 5.609325893429688, 5.423846868149868, 5.396367456287638, 5.769261513431391, 4.362736768653357, 5.299527213692112, 5.72630532309014, 5.7271762597397124, 5.598252577388489, 4.969797269363036, 5.219484054454701},
    {5.119192447860521, 5.418622117338742, 5.393986894405939, 4.983784558637978, 5.445743340277317, 5.273563854524296, 5.3359388006383295, 5.558777901155883, 5.812331876799791, 4.57821499387018, 5.382833666675841, 5.515507847966347, 5.470842846474254, 5.573347996909776, 4.862488405203507, 5.58178582923975},
    {5.09773845965273, 4.977239188916846, 5.354327734404075, 5.2329593426007355, 5.00255754907125, 5.213099848159151, 5.328785331867698, 5.108179793487171, 5.567188279678002, 4.507645713736034, 5.586954272444309, 5.009553262104737, 5.422457647897931, 5.115383347914225, 4.573166545274693, 4.757447765521263},
    {5.184491109605796, 4.850000349300056, 5.503089709714658, 5.012186647362026, 4.8966393227567995, 5.041387820171528, 5.1601696831467025, 5.577403783979191, 5.553482946041559, 4.18471613418386, 5.1175819274377226, 4.950707473224458, 4.80457814941009, 4.734689897007323, 4.973920613515368, 4.73653922961461},
    {5.207326167343018, 5.5114575064461295, 5.631630454290178, 5.417186178058012, 5.1002028346116015, 5.354472102310344, 5.419630299377813, 5.606376848928059, 5.693255251915471, 4.280757336695097, 5.373409941555223, 5.490238440000242, 5.442214785469885, 5.358703995666046, 5.130540425766643, 5.607097790331149},
    {5.520664469966532, 5.6435321311638775, 5.30843098199442, 5.127215257150305, 5.552973372682049, 5.890747218382584, 5.393687675157318, 5.671055144327287, 5.584450228772401, 4.743559450871937, 5.6747024361097935, 5.596063688571946, 5.539482087213129, 5.294524185375889, 5.428639434809426, 5.529981625209335}
};

static const float b2[16] = {5.059903809505366, 4.66750504686892, 4.973265528337482, 4.921134307473159, 4.958960415239403, 4.935359998294185, 5.021179310309605, 4.944266154217558, 4.979618577424673, 4.513744523743328, 4.784508485481311, 4.863593966590091, 4.980377071685975, 4.95303361541685, 4.9673581414300125, 4.994337199643773};

static const float w3[16][12] = {
    {-3.265869397426704, -4.216926136827276, -3.821408535671477, -3.579573238008745, -4.073242095147255, -4.191328936856795, -3.4882145790558967, -3.2830687270999035, -3.383092958634872, -3.141132659920502, -4.0106109377602, -3.8552567051134217},
    {-3.561695040645872, -4.231945014087736, -3.630950790994121, -3.6620633303629404, -3.7888400308381325, -4.190148641252547, -4.219875167293194, -4.22646087467359, -4.0789657788458635, -3.8812819679611636, -3.5465405870994213, -4.1062958824383395},
    {-3.8644745950012087, -4.254058458085914, -3.4384992353533796, -3.5662433108659766, -3.7536773111378388, -4.208388976527136, -3.6051556710364023, -3.5793414342988594, -3.38943873706782, -3.8806299860129574, -4.071117555388879, -3.955126495896253},
    {-3.3151813316914227, -3.423403006836637, -3.3919526402290825, -3.3649509815779126, -3.1160872899684176, -3.341144470303871, -3.404713288711885, -3.5284320215257057, -4.0700962100049285, -3.232982940902022, -3.387987485851664, -4.133242408194074},
    {-3.9428157177264884, -3.5800541205436827, -4.237806163169383, -3.944717541097082, -3.6611969737972396, -4.153512936130804, -4.101274521302441, -3.5026328230746446, -3.1451211903254914, -4.142543101574153, -3.3645990249233155, -3.4671409973470957},
    {-3.563339225629771, -3.4446269733640333, -3.8407436660019423, -4.198244207768651, -3.5935244280225866, -3.458366993646258, -3.567696702346236, -4.114865604931979, -4.121814343124894, -4.056511632969681, -3.916695907807979, -3.6288481842245766},
    {-3.8224582964683242, -3.9550083575850294, -3.6880040398576304, -3.6454732706324138, -3.880261829205496, -4.010118325632041, -3.548308365501507, -3.924968638585624, -4.243131976058683, -3.67648536415305, -3.2854838802089734, -3.6305974290731053},
    {-4.170566020351455, -3.7381728701329924, -3.9864530683559836, -3.997448049084796, -3.9310729617626747, -3.904635519202511, -3.8925647830340497, -3.275838627894857, -3.253752072677418, -3.4071131334506752, -4.133595937810929, -3.4893719068107147},
    {-3.4475902635114912, -4.188680122317463, -3.6093750403345517, -4.332654061377917, -3.4817923603015997, -3.773290840095832, -4.224308245286435, -3.228110510721994, -3.9669397214556703, -4.262732994560391, -3.7047048972912573, -3.509200426191569},
    {-3.0273223256844832, -2.5038677518077725, -2.767790832083972, -2.412773719773885, -3.1809836539041556, -2.547352062199533, -3.3516196377693075, -3.297516140253525, -3.54494567052269, -2.7852666985815873, -2.8662629128306323, -2.693385040374106},
    {-3.617075625344337, -3.372109717747101, -3.9949980451359144, -3.796675792889184, -4.076552358882718, -3.6546702698627302, -3.4362765432299978, -4.06712960115037, -4.064945684387313, -3.730010636472187, -4.159403610835345, -3.9773721145572636},
    {-3.9675061404395575, -3.6464196057916647, -3.817704878701993, -3.635639034029584, -3.797514375247948, -4.401944912231165, -3.4684444496854305, -3.491304125708145, -3.1945802539712447, -3.864027969732928, -3.713461219226838, -4.180487333588713},
    {-4.075235985812905, -3.7327361238493144, -3.9243589771063783, -3.893329654883539, -3.9546010755653938, -3.289807589778392, -3.513208691952628, -3.91867408800218, -4.066477315398419, -3.460943658527196, -3.464814097408851, -3.575835066689379},
    {-4.18191685749856, -3.703482875371299, -3.946239984888514, -4.126231097592044, -3.6416701671687473, -3.3156723250931295, -3.665210494905425, -4.142331485450414, -3.494784343056909, -4.126027275056876, -3.289214923720203, -3.543565469135169},
    {-3.120049651328864, -3.1491637644695687, -3.3702859691378593, -3.0952616882840553, -3.0167989509299415, -3.087923673195981, -3.452235562109801, -3.3756773389756773, -3.736858291720428, -3.7190021688398747, -4.20102036038404, -3.3264483475632813},
    {-3.7916134558224357, -3.5423971480109984, -3.260333279246853, -3.3983458201271186, -3.6867176837517808, -3.2082866886871275, -3.868326838321307, -3.970885658710846, -3.2099543826859978, -3.396898176822692, -3.7539330321423106, -3.668269043784163}
};

static const float b3[12] = {-1.8714175057439597, -1.9280936253714434, -1.6723394796976703, -1.943144000710097, -2.2255255083867076, -1.9859526959606368, -2.024842145703237, -1.6263189060769643, -1.8205481969109547, -1.890383017171954, -1.6917098880819514, -1.4510189482392188};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
