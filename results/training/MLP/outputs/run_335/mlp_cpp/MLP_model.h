#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.45693625324835535, 1.2490482379380727, -2.6885599609439508, -1.8227675103888463, -0.8058150445232806, -0.2337959886920348, 0.29816889664841445, 0.5878683517641733, -0.7214856631603991, -0.5672421905559857, 0.896137239601425, 0.2847457986311527, 0.15295877576655323, 0.7938309962144918, 1.720665936037717, 1.8037942916189147, 0.04260581473879455, -1.448221503890211, -0.7568337760791943, -1.252457670843075, -0.6887393634604735, 2.02461662919986, 2.1291189984577623, 0.003507348067173769, -1.5227598810807623, -2.63291378656446, 0.9647133992081287, -1.3613408291733862, 0.34504310514751396, -1.3193708801829669, -0.11399851212019696, -0.6847251261903622, 0.9741900142504877, 1.3387053087664298, 0.8263422178337138, -0.7688618226465704, 1.3708148739687664, 1.061679351954872, 1.6233265947045434, 0.36306724905438087, 1.490994413505139, -0.5963372439609699, -1.4725598117035306, -1.4477901806362836, -2.0800931726991894, -1.244852579203218, 0.7250426698269075, -0.09535250467385332, -0.7758946138581797, 0.8698831864565519, 1.4852807793666025, 0.17474397896252644, -0.7440494660643214, -0.2785146982698234, 0.5377150735601837, -1.5767616433454648, 0.649769316667615, 0.38153257001648677, 0.7490491589652977, -0.9937791578728441, -0.9678144474083491, 0.08233374126524239, -1.1000869751242381, 0.8993237483277119},
    {0.42548992232443167, -0.4603713999477777, 0.874499589851985, 0.28668167991974924, -0.6593213172547835, 0.5497269247507286, -0.3235852197569075, 0.05269098497106186, -1.5742800917598814, 0.530913369631012, -1.2340799327527494, -1.6238468620177404, -1.7624734260307309, -1.901553937224282, -0.41648881616772365, 0.6938482851833685, -0.8182861972898264, -3.4031012882364378, -0.17434689079675683, -2.088714729471732, -2.098133929356267, 1.4546772585224124, -0.8275532926339961, -2.2688812885158613, 0.1918262961466089, 0.9174601819822538, 0.9493074982596748, -0.3135286719571881, -1.5490841040437153, 0.06406853369523625, -1.4813379912374534, 1.131787869442279, -1.1677717718112388, 1.2302873254070286, 0.5108000460930702, 0.6087699433591572, 0.1933466019880373, 2.3018651678766346, 0.5431305240247309, 0.5846524825158018, 1.217128650823892, 0.8802027064444773, 0.2502163836990949, 1.010106289207801, -1.19841950372158, -0.2718555504592005, 0.8811288078307695, 0.7423291922665425, 0.5016833427455284, 0.07508937737542, 0.5259564909507346, -0.5762914750493311, -0.30376058102998577, -0.5036940158628315, 0.6007021369885913, -0.5968901496493292, 1.0493383527738476, 0.030507918980955485, -1.363938513260346, 0.032784375341836015, -0.6309554192584794, -0.47316174172140435, 0.1452550528885875, 1.2902371127010592},
    {-0.5923074717795115, 1.011753831145193, -1.3300009066079292, -2.2106726655784406, -0.04599336948439364, -0.25972607592452135, -0.8036918992398995, 0.3396545046005248, -0.7198257607833267, 0.15898078714773645, 1.769485460495923, -0.5472527185302809, 1.9673062468749558, -0.984868424645609, -1.3115174806465848, 0.45952236289238924, -0.6080971074097841, 0.5685151770351036, -0.8428592871299094, -2.1536505316227688, 0.5453867948917341, 0.19891682413274364, -0.09194609308561957, -0.12344858765854672, -1.5486165448178761, -1.2192738513819905, 0.28399747942488396, -1.2016019033847314, -1.362012299990552, 1.0228484436808907, -0.04059526190802672, 2.152492615462127, 0.3418425095057263, -0.9515341287319262, 4.627308119158283, 1.3843642472140838, -0.20508174717499944, 1.5093354955989042, -1.0492738156707562, 0.8929478203757336, 1.555059982239483, 1.011751268019614, 0.6419374217870295, -1.2288047532442299, -1.507244708405633, -0.5108562548668143, 0.2739108338360479, 0.2493076922626586, 1.6465886273179346, -0.031450241148936964, 0.15035714845269735, -0.7341210007073825, 0.7803524122008753, 2.569318052958113, -0.24617380691314636, -2.4728101728629994, 0.33019497700470546, 1.7749661295969776, -0.9749058980170738, 1.2116503678188602, -0.6464402617715307, -1.5668855413195852, -0.06690761931790677, 1.0355873441227397},
    {-0.20391436803904828, 0.4135652083934925, 0.30575696167295663, -0.5566357466466358, -0.48715118141415586, 0.6391729700905453, 0.6097599004264252, 1.7880021586471968, -0.46136539275700744, 0.9698447849637656, -0.8645600140951032, -0.19183180258276944, -0.6299743736314106, 1.9449504357501948, -1.3333566244879287, -0.1070659130678948, -1.0841595588697137, 0.43577933586702333, 0.9573474543722854, -0.417388101634585, -0.556092727020651, 0.6246281791588233, -0.15939040799052198, -0.004137380032618383, -1.7584082546109197, -0.4203210846446595, 1.5826876600981072, -0.9949605891240215, 0.35064728688021685, -0.07930662634802796, -1.0973116368707423, -0.04571354436675035, -0.08352000937135227, 0.01953600161257684, 2.3609630827783064, -1.7716097656082224, -0.9217613660634231, 1.5541936808946366, -2.650366525089604, -1.4132463085490432, -0.352752962044814, 1.6104337239846953, -0.0037385788310680475, 1.0952300778928759, -1.8566258384454375, -1.7449219210364249, 1.2968160554636747, -1.4250291793946925, 0.2803508343031109, 0.30660878145641235, 0.5390536315742955, 0.38702405557723957, -1.5367975555864144, 0.5853809389164132, 0.8903367384818484, -2.1520117781530903, -0.7987461904362468, 2.415195135407408, 0.1269242740074329, -1.6671012823688744, -1.3909554348106739, -2.2672971795934838, -1.770130004665684, 1.5986980823975765},
    {-0.9374075174737975, 1.1721875333289486, -0.9060928833179548, 0.3322798270272648, -0.14091498072578684, -0.5598216613364195, -0.8091427257580667, -0.11334680817057755, -1.0039103336355084, 0.6307941102768895, 0.7252557249908486, 0.15493361911092823, -0.77243134465513, -0.9085714335146371, -1.8822262442325355, -0.14204425811404187, -2.7277984064828313, -1.298771775785266, 0.27113381082890736, -1.312095767673067, -1.2661187053205687, 2.76755444982593, -0.7051666712226001, 0.992736717118378, -0.9183473639098466, 0.35573431179919973, -1.3185291664781817, -2.7602565229451006, -0.5164171327893083, -1.0302589589934539, -0.136380899288744, 0.7118302985944154, -0.8792300139877215, 2.1465156292147114, 0.43685179297694204, 0.1635955498769376, -0.4860895413133924, -0.1733187646232509, -0.8021677427087643, -1.171642549559257, 0.5292193565622036, 1.834843756235863, 0.27011311135605576, 0.4815976636645575, -3.56012512913056, 0.46845377657848625, 0.0715210774461495, -2.3016829043152094, 0.3094880666750942, -0.6877427478203505, 1.5813807644982665, -0.45992899098157636, -0.9190578589028854, 0.4892209349707196, 2.120158661220496, 1.4521469393806714, -0.29708768611869546, 0.17174621721686634, 0.09664636632294447, -1.6031152405942928, -0.27611874934866026, -3.4872307352531786, -0.7270047369733746, 1.628647916813573},
    {-1.7965386858877574, 1.184499583854322, -0.9459577182576181, -0.7631485548980698, -2.123772044607284, 1.3114445886940667, 0.9574632448383213, -0.7322419784101735, -1.449898924199759, -0.18711058316408047, 0.775845299979946, -0.41138347741389725, -1.0841871812654098, -0.31620116583947516, -1.0548620191549654, -1.3183011673218639, -0.7101704454749891, -2.302757851586453, 0.10767032555372293, 1.7113603384819813, 0.1898946003005044, 0.648651237162645, -1.9182529436632105, -0.6563006292956924, -1.9496508654570388, -0.3374572169171861, 1.7176551697746072, -1.06585278872077, -1.3281550063193444, -2.04861556059906, -1.0068430649814375, 1.3883870394660132, -1.3997662039573104, 0.03370511943621697, -0.5796615036120362, 0.22151287086865387, 1.2647383187068715, 0.5469807443747609, -1.5283367362094613, -0.19681672527076485, 0.884785355561887, 2.041014820504961, -2.685473857423754, -1.076519942195684, -2.1351717991238286, -1.1926253948301109, -0.31645609086494053, 1.3434373221997, 0.313274120125098, -0.8219588069334766, -0.6658326394798159, -1.0519079993639864, -1.2232484866423936, 1.5814105852594804, -1.9583013173367154, -0.5297309930213904, -0.13430138078761683, -0.062321743054747365, 0.12091545131995968, -0.38156487989910987, -0.9468625340386647, 0.4311692655025432, -1.3338527768025654, 0.7398260693090282},
    {-0.7331233096534016, 2.7369595397268647, -0.5683490329272765, -0.28787032827178294, -0.52315099888622, -2.284414309298686, -1.2427940201167773, 0.7646055186420729, -1.6773564601116056, -0.6076804838602858, 0.8685394986931219, -0.6465116804464134, -0.9101242445827565, -0.5701088714848029, -2.623565455347942, -0.4300718576519603, -2.2072256925525027, 2.852660864771775, 0.3058092735479764, -1.5765173549490925, -2.7589888297696854, 2.7756374607181757, -0.9727277792458268, 0.5931947421621571, -1.0206646063540235, -0.7444162236677017, 1.6076467628077926, -0.07993315615410303, 1.4776839430077977, -0.19455711752151203, -1.2656614334633645, -3.4562795180755868, -1.9453553790190137, -0.8720005994801566, 0.10653058116009195, -0.6681301369673407, 2.290449966517435, 1.1719510882733102, 0.6369796141324399, -1.3292776080975086, 1.3723254379017857, 1.9512295642853141, -0.9875270679633124, 0.5229292034188354, -1.9063688567990722, 1.116537073519082, 2.7042175091686835, 0.319372891676519, -0.4713425237106613, 1.6612211296140613, 1.3670074099624656, -0.19028479025144826, -2.6301043456797366, -0.29697048756000194, -1.4834548157789558, 0.6284806705128444, -0.4064207357277585, 0.18724844993671197, 0.22522612011432366, 0.36108560764371295, -1.2948772585399035, -1.1392065490343914, -1.86730664599427, -0.04087071224198582},
    {-0.3659320545384643, 1.4806951482027726, -0.3366916607013346, -1.614205487082266, -0.18475703240066496, 0.5487325572907817, -2.0463738873702053, 1.5578684487922092, 0.2710004705350528, -1.7496251886201648, -0.3575769002444069, -0.7035803180473399, -1.8059904890869658, -0.2283928156087162, 0.6872954382982653, -1.453681868349941, -1.1200111167445417, 1.90489239487406, -0.12692454097610967, -1.1933632309360005, -1.7679764315071618, -0.03167957576926811, -1.662104607191902, 1.8981520017875422, 0.009762758909302657, 0.3475725002727016, -0.7390983840621875, -0.2107524527260892, 0.23758533316180397, -2.199112152179529, -0.24086071634770476, 0.14288761886656887, -1.957702098870962, -0.15711330248190475, -0.11273512588023307, -1.1740641874968456, -1.6307851087243828, 0.44570671550522933, -0.03006893374141104, -0.271200666081262, -0.07244122045383597, 1.5170071362879276, -1.1108264252978146, 0.725433646526591, -1.0835688673744606, 0.6452422820956095, -0.45505806973439605, -1.5450972019799571, -0.9777258041198365, -0.7193846588870331, -0.661035159725993, 0.18615702074314644, 1.855331241130338, 0.9452967527729855, -0.6561868288951443, -2.335397392268861, -0.040973616767648574, 0.5541459719698822, 0.2800812588541024, -1.9600584372603564, 0.29056582695620276, 0.7558177237896867, -0.5839291097402456, 2.777444565006924},
    {-0.660308305915852, 0.2642783702045203, -0.31641596146681245, -0.8323918796975324, -0.9027433326040911, 1.1296489038661104, -0.4004363819817417, 0.49342167875178833, -0.8464134628649679, 1.1174438533045992, -0.0779138431911607, -0.9117942672179993, 1.7784697319439673, -0.007695656936703653, 0.10922528590128949, -0.34109941025371765, -2.3827017170997453, -0.8080397945937308, 1.1191207651816102, -1.5138631208199769, -0.8797402472206258, 0.5777609683218043, -1.614717132143591, 0.0663764803187755, 0.5895475108239602, -0.6367201853745197, -0.45179399379253027, 0.6562924323807271, -1.3302392415739244, -1.3482052367635868, 0.31663476869085333, 0.5904332379776736, 0.3961563348932797, 0.461438442935634, 1.2291690596855878, -0.024392340502534894, -2.5279686344436945, -0.7872989247644808, -2.608548321391167, 0.25791021879312925, 1.3787605942396808, 1.3101451565207032, -0.40465846052519416, -0.6297566600923675, -2.4036295859758043, 0.21864634480123216, -0.40173390063621234, -0.2954369634078938, 0.7879573789504204, -2.9604712899520482, -1.0664524147187555, -0.1255512795908845, 1.712610294889527, 0.7537311349562442, -0.6777923140321392, -1.032316438467877, -1.1550141862842762, 0.6674500788480653, -0.14762594999084885, -2.7725448715659327, -1.0834415705089941, -0.27045578526543207, -2.1668733980886943, 1.77872077391726},
    {-1.019961211754473, 2.4124502363235103, -1.300890306473005, -0.7307074141543612, -2.900197309953916, 0.08510290745245762, -1.7062053289093289, -0.13533780090403638, -1.6070960975673132, -1.0646499659174606, 0.11664790903609012, -0.4171899123479619, 0.600154954975723, -0.6942683552684218, -2.5781651572174304, -1.9802345922495803, -3.276650970591911, -0.422465603303794, 0.48634666934733095, -2.0650037279673317, -2.7308519367039925, 0.24843611687596845, -1.1533669405521239, 0.21679244848040158, -0.6997437877162731, -1.19361190879065, -0.41640187057885675, -1.9673877323133202, 1.047806980443563, -1.1551240178995685, -0.30478414749490573, 0.07144960971547133, -0.1246600028354764, 0.8048295829819716, 1.404490317782794, -0.32795529945022167, 0.2818915917362848, -0.5607653352247004, -1.5951174697615451, -1.1341682739625611, 0.6620708134016042, 0.6466114353315806, -1.0771997586620463, 1.1302268478782125, -0.959342924910723, -0.00014943330636679226, 0.6317013988883212, 0.05006047901007173, -1.0119607445408907, -0.7529346117615283, -0.11249423762422617, -0.013429042565189848, -0.6477002490286039, 0.05386716187791708, 1.8862946594725911, -1.7345801138261574, -1.3465725153172303, 2.207739956087033, -0.8821033741127436, -1.0779161734670983, -1.919786780072037, -1.0267852759263478, -0.7102466513610198, 0.6831622508244269},
    {-1.1685761944301323, 0.23860044286776208, 0.5827397835557486, 0.6529057695277847, -0.4062556786698144, -0.24363780219976278, -0.2129458766885431, 0.7812619788895261, 0.5341856217324238, 0.4127735885624786, 1.580977260462089, -1.0362636904881353, -1.1118819729417124, -0.8452445506253142, -1.2218251435181249, -0.38372484251259426, -1.2669413312540563, 0.014659121015807651, -1.3149505988829493, -1.4586169319006899, -1.5925740865857678, 1.1250022601790077, 0.5166161890082829, -0.0825668206649987, -1.5162005431983554, 0.1409806618649624, 0.36902188262722513, -2.249915616723689, 1.0889036003466874, -1.9414437582876174, -2.888517700200433, -0.8903051529706056, -1.6767341530519262, 1.525609893490098, 1.736741539740571, -0.00032235831002953744, 0.1966405988231668, 0.39523285679337816, -0.35019327130762956, -1.4250122547278916, -1.634475048915763, 1.3082627061943208, -3.286963226336787, -0.8956726200346563, -1.2947334616742672, -0.7972962144021742, 0.3802796354094698, 0.322563112014937, -2.3907738159839163, -0.07350135251295947, 1.1365873409392355, -0.7709893171730219, 0.6140136401665712, 1.221328684304663, -0.08341839793917853, -1.0460216789542167, -0.784699455959941, -0.2309029512353788, 0.1618086943046984, -1.8490768164984588, 0.31500821122399403, -0.6555483490929297, -2.273958154306991, 0.09547287220014919},
    {0.5387953037673576, -0.7066717809276116, -0.7420482918117329, -1.7988300555477446, -1.8939863975598978, 0.2969025051311381, 1.3207943808090874, -1.6458542140558474, 0.3891250962461799, 0.7976315043665205, -0.027774694742465467, -2.5152369985147667, -1.5875796459738252, -1.9724624602041703, 0.10696178803691407, -0.44294463909277965, 0.34331604843175656, -1.2130314932355857, 0.7810140590031318, -0.012660237589221373, -1.4626349907090634, -0.2770242331349502, -0.38189963480402106, -0.781322132012511, -0.44495774265563537, 0.952303857930014, -0.7561390706696591, -0.5615700349998909, -0.6358625521393594, -0.3122133524045302, -1.9033188531963154, -0.7833174264147881, 0.7642675250631821, 0.09947917784144605, 1.008018036153495, -0.8259495783774146, 1.1136230149110884, -0.3746329779008208, -1.0438687732985075, -1.1054873179200815, 0.2876431115066968, 0.9647021212923308, 0.2420909769680666, -0.33950958739982706, -0.9783201890038844, 1.2571655287386545, 0.7780671587605928, -2.044244778248004, 0.26675703152940206, -1.0114430119480133, -0.5511892406839671, -1.6635975446702913, -2.480253766803343, 0.4507170751919889, 1.4008343808840786, -2.9659346710225005, -2.717616878083658, 0.5774220636291236, -2.2051330008367755, 0.14294418508809875, -1.353229831302297, -1.3929681773662117, -0.6591819074202877, 0.41670469164479645},
    {-2.1649851445360255, -0.2589059905005274, 0.8003321789052019, -1.5269179252379743, 0.19629842120976057, 0.6891962045867382, 0.4771898974079208, -0.7813366592989883, -0.6033912159984759, 0.43098716461895303, 0.5265595338635235, -1.4437699158349948, 0.43458717215012427, -1.0965686684775062, -0.33961372250578675, -0.4736451386126051, -0.8751490133206391, 0.3957683823282323, -1.1229739157222824, -0.904061888182947, 0.7494030536080861, 2.6652954951873915, -0.696602150533583, 0.6077021381642298, -1.3658262318216705, 0.05121850675723035, -0.3206674662598108, 0.054684126296283185, -1.653397495060243, -1.4639837368691957, -1.5309342016974437, -0.753483125854881, -2.139038646139363, -1.28897650094971, 0.29108305725215006, -0.8050864714494933, 0.7970334487583842, 0.8431279230827796, -1.797907615176626, -0.2766943706793137, -0.9240275089503734, -0.12667178327717063, -1.0788578350471092, 0.412743985459406, 0.662192148292611, -0.9630725405334406, -0.2839365625712313, -1.0431525379327529, 1.548665785003919, -0.10438548569781687, -1.4156826550789292, -1.3904266079576917, -1.7870800400237283, 1.0368752780485706, -0.23707308354163076, -1.6493848162016402, -0.2616210945212811, -0.2461339923805254, -0.029675783336384928, -0.4800743464774177, -1.1685301221475484, -1.7613596331272101, -1.5763959787355042, 0.11109524087184819},
    {-0.7599791436576936, 0.37378809896828163, -1.5716869702708653, -1.658219139978951, -1.3037404004817572, 1.7352128218152487, -0.6256739455707917, -0.9333244189135143, 0.041398232171054435, 0.8221937344515305, 0.26121028904954385, -0.660579478239216, 0.1178388650202783, -0.8866741480572153, -1.0021842119898512, -1.026947569828812, -2.125359561018037, 0.3282600728380805, -0.3147129362337034, 0.09588962008123919, -0.8603049573560193, 1.0346611431915957, -0.7630821945123274, -1.3594404756797822, 0.06412063312641594, -1.42010666215914, 1.778546524004172, -0.9108956181813092, 0.8356461240870052, -0.45703418951732505, -2.0508362762527304, -0.2514390656915973, 0.41822101623053753, -1.1776579684846014, 0.7357487722934977, -0.23787368939291617, 0.5375274001664928, 0.7682859131254665, -1.002844304110544, -2.725892869808821, 0.2347277343626659, 0.7732418533557109, -1.8945790741116917, -1.1956063734310596, -1.7460880693491905, 2.5286620835877582, 0.2838508772891757, 0.20138265225655982, -1.1253577312023455, -0.4798209155836452, -1.5753351493252747, 0.05827042856456531, -0.7131437744295411, 2.053430701088708, -0.5841300512724553, -1.4860532178221373, -1.1083300265121623, 1.9194769855777005, -0.5438247197844277, 0.2381178644083377, -0.8012995050329706, -1.714678766079213, -0.9004794000357876, -0.34166346962803523},
    {-0.9171305711482, 0.21536206521135381, -1.4570326032138055, -0.1486031775812602, -0.751007814452231, -0.47812366560272385, -0.8071297111865448, -0.8753043576387257, -0.9249341946190366, -0.45788591316072935, -1.0775778282198067, -1.9777727884926402, 0.9103438611390076, -1.3181203573888831, -1.8028576157038665, -1.3761568953802943, -0.32610484680928625, 1.5615968616945082, 0.3039923050173525, -1.6667420715874746, -1.042476289638139, 0.4267305989777742, -0.6542390007502258, 0.29938770142424886, -0.07082702453936997, 1.4393599055175035, 2.180820170913671, -1.3859092754527185, -0.8861595457832433, -0.002474763679779337, -2.741464581829664, -0.03938942189877607, -1.4549693337257952, -2.1010300830244, 1.0727019428029876, -0.3661091197395177, -1.5635332773714319, 0.9462566005097335, 0.6384254679657947, -0.11973850286107736, -0.05863901838534624, 0.9625100779729037, 0.8638160953500121, 0.021113073054081923, -0.6870120053833441, 1.6592357647029166, 0.24857039905626516, -0.6902108755053231, -0.06600239365840353, -0.007278102989388231, 0.31651789602861563, -2.4684342557488246, -2.902476606535226, -0.013673848884643715, 0.8987279345895621, -1.5086359710558017, -0.7949744576876705, 1.0843383462121454, -0.5934631612468297, -1.4833677051446388, -0.6969872758263688, -0.01752778155665636, -0.5627028911020834, 2.022910894556536},
    {-0.8471111896628246, -0.7066353975167718, -0.9004752602605968, -0.8600502987237912, -1.4471772442916921, -0.1796349821222215, 0.15683322427119267, -0.8127022758294318, -0.6845340048430072, 1.068998367998615, -1.1645313256391525, -1.223455698232665, 1.0946476772306244, 0.014195627053341944, 0.14476071622279257, -0.07153989181237119, -1.7144645068465356, -0.34454886484973035, -1.2709431061055059, 0.24890548425105052, -0.5406177363202486, -0.0473968179885369, -0.9433050910263194, 0.49718993581752857, -0.21664943965525313, 0.4789165722249147, 1.2526672508424985, -3.742882606472473, -0.7238995208741583, -1.3204553567299608, -0.25660765557150955, -0.5839487387395247, 0.24367979615926388, 0.5850031559302296, 2.5477821437382864, 2.0316091310219204, 0.37287897887280086, -2.0742671931547303, -2.0006045899054667, 0.7316060130665261, 1.1284535520403967, 0.2552958421952815, 0.1570926426001141, -1.8551276852176195, 0.5180768518199034, -0.721885066410803, 0.3847171570768549, 0.5134135107810708, -1.1932323865372683, 0.3040417110361336, 0.9832051298002595, -2.1943658652842664, -0.6837647928435266, 2.340487336204645, 0.9168546647215614, -1.4080848589249253, -3.4264032659874593, -0.6828442370497236, 0.13877363026815304, -3.2111274985800065, -0.004506084659696133, -1.378951033414124, -1.372657993725655, -0.5724114562061794},
    {-1.9596360628638092, 2.4041033014920337, -0.8430491829523593, -0.21744556756259215, -0.10953067959261215, 0.8263333768669515, -1.5719980122432609, -1.9732300114240509, -1.188685273622921, -0.8275512468489309, 0.3492497998229295, -0.7695437863986584, 0.490431565922095, 0.10216334425507324, -1.7431427972071183, 0.31144058756577214, -0.6763733187067824, 0.23136042797278164, 1.5112607085493788, 0.12233663230515782, -1.6361768347234709, 1.678584993222017, 0.35627704508914976, 0.06740270507413826, 0.13955110493007808, 0.4973228808525299, -0.20320251733939418, -1.49809564431868, -1.419841413958675, -0.8447307668335938, -1.1238573325261578, -0.5059390406985709, -1.3911394597868054, 0.4133560256130108, 1.0816659870992233, -0.051819820532841454, 0.7062561384712488, 1.7957694325992952, -1.1253024268974496, -1.295254014840011, -1.3459850248919056, 0.8267861521938517, 1.647576877027601, -0.5433248481949965, -0.865589307841983, 1.5092698762799162, 2.014965646910379, 0.12212675272319622, 0.7238316318102955, -1.0958951499098661, -0.7145418434176247, 0.19388920333867898, 0.3612489397935888, 0.5261038645801495, -0.027946015575869326, -0.7034266553755062, -0.5639082817963289, -0.15807939291797712, 1.0109968590376446, 1.3774198780022482, -1.6625398234666735, -1.2025880758081415, 0.5545397060818319, 0.3316594549829211},
    {-0.579233919414913, 0.7127225455816006, -1.6431791395151452, -1.4972485500553203, -0.4876273760302741, 0.08821633702137062, -0.13076420337592737, 0.4875752294448838, -1.6663533311093788, 1.081623366461597, -0.4544878063909306, 0.0911825614812332, 2.6059829595742743, -1.2959779979022223, -0.3901401338569276, 0.03818669572616808, -0.4986907282045223, 1.1707334202137194, 1.300356420255247, -1.0716343175437324, -2.471836865955153, 1.3653246353637902, 0.1690800402369603, 0.1660688594096609, -1.8702331994937407, -0.13491474376920148, 1.0432895233896187, -2.360328331760098, -0.16396896563544724, -2.018509070265162, -0.40731331362942996, -0.10757760605400861, -0.8336607654452876, 1.794050012773926, 1.8432530813646804, -1.743126402620071, 0.09282683314920263, 2.2894871893127062, 0.13585918560208893, -0.8998182057389288, -0.24349881513245653, 0.004249501933199191, -0.5633914948140579, 0.26040974478990775, 0.4785466882296501, 0.39438161213385486, 1.605831186064612, -1.848864873753922, 0.892653725608817, -1.9066015620373813, -0.12135367813367003, -0.8105678632093407, -1.243269516488279, 0.20355921376970168, -0.2514508635432239, -1.7254926114795268, -0.3200134322072667, -0.6184970166377228, -0.6222120131536084, 0.4184586753835779, -1.2434257263443742, -1.068470691301524, -0.9794879210382793, 0.7519891377691843},
    {-0.2654094540427057, 2.1016767828309755, -1.837153653528209, -0.5817808251128581, -0.2936754987492936, 0.400241600703335, -1.1629116920534863, 0.04686001487042106, 0.46664274835914155, -0.7195854434008168, 1.7590382285043975, -0.27063819228594777, 0.9012166493654784, -0.3840321255792074, -0.6707507657388253, -0.8099148313868395, -0.8535005437284733, -0.6658563088980267, 2.0206655053317863, -1.3635001484057727, 0.18146717470466653, 0.5924131749785191, -1.452713410893117, -0.4147818708236876, -2.016958714163551, 0.7247864839752408, 0.5109537964052097, -1.029253641301636, -0.20682153810566423, -3.076399618903381, -1.1769289450501232, -1.0202257872926446, -1.4617743181986187, 1.0308381668589228, 1.7152420692852641, -1.8012002818126955, -0.5793329815183957, -1.2812474013753783, 1.3333795339879504, -1.5670386923990907, 2.640982760711052, -1.323281065770953, 0.5669944050341652, 0.6061873831832681, -2.514119650342468, 1.1961168300385752, -0.11544702120417401, -0.7005377837976637, -0.6712756539414927, -1.2705225132576834, -0.47806134676061424, -0.4026291568946989, 0.31062924349026494, 0.4089604735002191, -0.23726184690189103, -1.0340049302613634, 1.6320091724467862, 0.2548493937858583, 0.037018522572579066, -1.3986647942095842, -0.38021194402876857, -1.9437530217565377, -0.050073615123993234, 0.815555523499096},
    {-1.1542695690172042, 1.4066195144371212, -0.3382055003959506, -0.33618532963581627, -1.7048941758385625, 0.4791611454527339, -1.023274781188271, -1.055156538451374, -2.6928071099631294, -1.65895949831237, 1.5595879955139966, -0.8492645622894951, 1.0145955983837731, -2.300260923646084, -0.021468215926716803, 0.9437031629533178, -2.3701034849281664, -0.08556853853648194, -1.5174925313709529, 0.33157778412070504, -1.355600413658024, 1.1207575443541156, 0.011105364771648312, -2.21029950480869, -2.2377164415955377, 1.2028264161094606, 0.27966517369450905, -1.3585551544882064, -0.46772699775645776, -1.4677028655370972, -0.35502456631838386, -0.9016737142617223, -0.2987356615305792, -0.8970551647812247, 1.5334362152827807, -1.0929896045496998, -1.2114189234215584, 1.8190505367330558, 0.5184066345443125, -1.4749119892017277, -0.3649750430827799, 0.49684635004941485, -1.5756559719493222, 1.2023568669096223, -2.368476463685203, -1.4607761572485496, 0.9714281040847842, 0.6659812706159012, 2.691499742731281, -0.2978019401988168, 0.23206058275489963, -0.45908743581387795, -1.7759640480851855, -0.9371627127110185, -1.563554161609752, -0.4549430923165057, -1.9946094794501947, -1.451656042617312, -0.2829094852305178, 0.879984539605716, -0.8928630275078109, -0.9785464289552044, 2.1217136700033894, 0.3391611237665392},
    {-1.277208709443095, 0.6558622759852285, -1.9177067844131406, 0.037329634728082775, 0.397969351156173, 1.4128230595650615, -1.354885124859398, -1.0633613859787407, -0.4824068210448104, -0.9141825006098856, 0.3397566381457035, 0.3597770571827928, -0.39078676791418626, 0.6344092353415242, -0.796835979763533, 0.2635649414523942, -1.9991625896354932, -1.117395735390992, -0.30617668351532445, 0.5209762528352982, -1.1316237934018478, 1.4801873848543288, -2.7442447259146068, 1.1078228163028423, -0.6647157218819157, 1.0687228494567766, 0.021663102216612603, -2.2628628660211345, -1.30936038448088, -1.9739158510881953, -1.8920138548287908, 0.6992579292537905, -0.7428449501784901, 1.0126243359021863, 1.5627995292746502, -1.1181242100202125, 0.24387514249415837, -0.16525335494051013, -0.06566959713871932, -1.7860785657327773, -0.6805891489771461, 0.6181437985667034, -0.7934640883578982, 0.593184889817932, -0.8482524065367069, -1.4468249939721667, 0.1885131631617829, 1.0062148156873463, 1.8943241663654984, -1.778022776869547, 1.019722949614138, -0.8696075215244141, -1.3462714001510125, 0.476762905983235, -0.424236330214376, 0.13355388885940597, -0.41789781339092913, 1.4763161311709116, 0.29479424022015516, 0.8518435938961622, -1.3500664532636437, -1.9447059685034205, 0.15314716056187683, 2.6067045835357403},
    {-0.15087117298179703, 1.5220526069484153, -1.1920456691261645, -1.0608415325424287, -0.22244203020881068, 0.8027618611299676, 0.21423594389931186, 0.051570603741403855, -0.23611762755109925, 0.22485140534519654, 2.661262228997448, -0.8633117977906709, 0.4090810712575072, 0.06854703131979707, 0.14461655627845107, 0.2956302083196828, -3.1792160915480374, 0.9759401696378242, 2.0022323905132917, -1.6068346623312055, -2.762019957286967, 1.2540820380824322, 1.7670873735466672, 0.22569932673783602, -1.6581527063432124, -0.1713004135999923, -0.1888883108925445, -1.1447625104010974, -0.8297987553511135, -1.456781469654679, -0.6206585560382175, -1.7264694494373136, -0.6070015263803769, 1.9777311443445615, 1.3766728367328345, -0.3817727556696298, -0.3901857500940822, 1.2455465080886545, 0.8046970179526364, -0.19186443863542785, -0.32184973677973094, 0.28784014181826834, 0.9671373316726795, -1.93969487616526, -1.4250561288030166, -0.08936808612971217, 1.8565313234218848, -0.507267925448681, -0.039066681104611166, -3.2112482333952936, -0.9612806679380859, -1.5064871549984338, -0.18579237466101062, -0.5593847490842268, -1.4922444318217254, -1.65050891445288, -0.5326831095593159, 0.37612024661284116, -2.4828217341988155, -0.30732026794506767, -1.383715621039259, -1.56524356045817, -0.5089832313923055, 1.1377196689484834},
    {0.2050193457236861, -0.08891796270216351, -1.236028305632623, 0.8726144539318782, -1.6007674047252087, 1.253105385078058, -0.30183716739721583, -0.09922153077625114, -0.19331955856669833, 1.0573891964755668, 0.08394824137362522, -2.643485016869213, 0.04472829103737095, 1.4525522954774586, 1.0996480157981368, -0.3296179101099558, -1.3242579468622782, 0.02169925913852041, -0.6881835464224549, -2.107206563444984, -1.540066684312266, 2.2550341781108303, 0.36063849150169586, 0.3152963773816475, -1.1706602582332664, 0.5170605827428323, 1.3136806712919047, -1.6015387436078878, 0.12544314985043992, -0.36935048105943635, -2.0447713122729825, -1.6829054016978116, 0.24100136920253654, 0.7926582220337053, 1.6291865006993083, -0.13554437883857315, -0.9622301580294763, 1.6540200982768345, 0.24415558603599663, -1.6191734921136292, 1.184820979135141, -0.6161597366196012, -0.4014696846047982, -0.07073915418452277, -2.611251234500078, -0.2798509192820555, 1.1821776250523963, 1.1707858732934284, 1.7964043937654723, -0.4310156406277756, -0.6150103798992592, -1.4483801072787974, 0.38884559532102614, 1.5875067807107648, -1.5556332728014033, -3.0026567402884337, -0.7971596477282272, 1.084620671857009, -0.413219782271004, -1.0789894722471025, -1.4513625146761266, -0.36384481447338346, -0.9398022182445522, 1.2233869838138398},
    {0.25155667032009305, 0.523566833506285, -0.6459927982862046, -0.42775979899507943, -0.8218044526852161, -0.47953433250069744, -1.0471380955480123, 0.2521542234177772, -0.982053044341225, 0.28019270048020745, -0.4555309501217556, -0.7345077452860027, -0.2996992779647745, 0.8726043044247597, -1.9370298079531225, 0.004960538467779218, -0.657288351484942, -0.558310460635294, -0.19158029066662366, -1.3886113422997861, -1.244002876258368, 1.7051104400793777, -1.2630617354966118, -0.9735359374420379, -1.6521823935077935, 2.4603968824381117, 2.5202943144463643, -1.5208721272025205, -1.011454378338145, -0.6279358433192196, 0.8660789546032266, 0.7414817344772435, -0.3244995842570872, 0.40887893267022624, 2.106366399228878, -0.6956138556034592, -0.233536813276636, 0.17290580884731424, -0.7307060290876992, -1.040770309110068, -0.058043975358280715, -2.699704795688686, -0.06867801385886876, -2.3461430461523616, -0.5056980243675555, -0.07316573403166586, 3.436076064695308, -2.162559492389954, -0.12561556694152515, -0.33368723910634085, 1.503020917913894, -2.2736817564056038, -0.8898225702432037, 0.36922009635645847, 0.4892562774436106, -0.7278126506232756, -0.45465767334716845, 0.9157558923208639, 0.22393292824621241, 0.9883904545828835, -1.31920220873989, -0.7784111691973105, -0.11471069878211367, -0.2785544404910813},
    {-0.715984069658769, 0.6409332274915609, -1.111003459104507, -1.8199608243293361, -0.7367035141038811, 0.8622335642932162, -0.8928731280051372, 1.1262273012768962, 0.08595732752095792, -1.8089578254790994, 1.7732095316844785, -0.24459728927726357, -0.9325085294055346, 0.30691740805426626, -0.20211575946474333, -1.7428235441701472, -1.4270620679675756, -1.2235154920650386, 1.1004856175189652, -0.7786720163481676, -0.6453187996851405, -1.0378150241729613, -0.9990953242547738, -1.2715742084667994, -0.8458482281864903, 0.43093008821806406, -0.1575151885610961, -1.8979869561178706, -0.19648103344017337, -1.3686620484912408, -0.8337161837251507, -1.5289560479715913, -2.4254609875973414, 0.2843844249319519, 1.8081778025426043, -2.188313198605422, -0.6070750344518602, 1.5587955584719035, 1.0348020892039336, -1.2491681347314267, 2.3544138085757065, -0.41581783407392825, 0.11975481369181867, 0.43322745510164895, -1.5991691782643358, -1.1413385426798937, 0.37636541591975725, -1.9452812880728056, -1.8313464187540054, -0.4787864209345353, -2.22211706723618, -1.8707836948639962, -0.793566118308065, 2.4938150503429966, 0.5295670799588528, -0.9264501250235676, -0.022031386400837853, 0.8611762880321683, -0.5762651359709501, 0.9028817719680405, 1.464533801498275, -2.600708005302816, -1.8299794937523073, 0.9450004004308775},
    {-2.3540803491431554, 1.0226575463066545, -0.9160955301877104, -2.16206514509718, 0.47352353596699237, -0.7686939327309292, -0.3730397333893811, 0.3276346208754717, 2.3302983710517036, 1.2411249714318882, 0.43203022506762917, -1.505398465341569, -0.4643410492880491, -0.31585394312166076, 0.3818167473088899, 0.711884487805657, -1.2823384627810868, -0.9998034658556061, -0.06596609145171844, -0.6847260530494337, -1.0850587776291565, 2.2194885859975133, -0.44235589174312145, -0.4184143366101303, -1.1043621173194609, -0.42750315299861236, -0.2465840407585798, -0.4527088969785126, -0.36286569478415776, -0.002571328853952741, -1.6486170384405938, 0.00903173827430561, -1.9530717007980567, 1.0699245728131745, 2.0125066435651298, -1.6503262275836208, -0.5509144432792379, 1.663682948208845, 0.3730231097568966, 0.35412440921422267, 0.6472959932504297, 0.9374249808348122, -0.33631643626336327, 0.10354188436700894, -1.1444704261919496, 0.7719886977096082, 0.026881589053949065, -1.501374260508498, -0.7200400211443692, 0.4987851323505575, -0.14282484353809694, -1.0292035840913345, -0.1446478412516497, 1.1055555106374788, 1.9390192306026666, 0.8152712431170172, -0.5001435196277542, -1.4303685024553965, -1.9124682462348894, 0.7241425457224202, 0.11185793300278003, -2.5552231572105195, 0.39171414580638114, 0.3598005089371706},
    {-1.277604918481335, 1.3192826322171987, -1.06891766691449, -0.3182546210513696, -0.780685393415425, -1.757556488981969, -0.6508576824890377, 2.1727367502040154, -0.6995273955006863, -0.7472113268679113, 1.5252414526220273, -1.0136998664087802, 1.2277615457753064, 0.5762250992174169, -0.8365800006711936, 1.8778440200520674, 0.3985122258506188, -1.4539741405571693, 2.1219779716391303, -1.6684550734463819, -1.6118509831420391, 0.0747615233046326, -1.8850630234383856, -0.2379019601897643, -0.8576685066585639, -0.4509281523328803, 1.607107107022256, -0.8009424571006913, 0.5867506914326819, -0.588657940030265, -0.9331614768424447, 1.7214958026229625, -0.373056835173418, -0.12816758315700771, 1.567358707511241, -1.9526215589734415, 0.055034202992218034, -0.19208669647503834, 0.15356324614000835, -0.44233722122983526, 0.7272188540846393, -0.29039488928978885, 1.4995806170296258, 0.4430173984947363, -2.001352264859295, -0.30370166661849046, -0.8667238446364888, -2.0093005250610534, 0.00850330143277069, 0.0867060526079158, 0.06432688473906703, -1.7098500336737799, -0.040916172819619234, 0.2876043300746385, 0.055516187395282975, -0.5527634206177803, -0.5316587395073281, 1.0193574253701243, 0.3341272843177468, 0.9641769618544352, -1.71042278760606, -0.7549660594011955, -1.8187587332519366, 0.06596186842013099},
    {-0.4649915877910153, 0.9409307035235425, 0.8351906422488297, 0.15944582105175253, -1.235579425120113, 1.4272605174531117, 0.18722618246218276, -0.07585357733071225, 1.2537765331348008, 0.2110356706689692, -1.0858808592042832, -0.34987539163949377, 1.442851621513086, 0.13565097024009523, -0.7607434287739279, 0.3631521939772341, -1.958892086643155, 1.9742292794381473, 0.9050792384039796, -0.14296687079851708, -0.6351046132367816, -0.07086524295799757, 0.15720013879185277, -1.890144711552844, -1.6309144740273058, -0.1277827050197124, 0.6806321691146394, -0.9260015808887389, 3.117828292489287, 0.7809718328121142, -1.0189494772062095, -2.1323340955792376, 0.4001900785604002, 0.007488048570939338, 0.4190726312977729, -2.049092237943733, -0.21269562712333304, -1.0222263974282348, -2.1679623161985786, -2.070415870023544, -1.7905812130085248, -1.041165484165882, 0.4188889110749963, -0.9460116603254282, -1.2256111203935423, 0.14056212337330473, 0.9020213751142856, -0.36330228964672207, -0.6907366695902651, -1.8691486366119925, -0.02616635856650771, -1.9879101588505201, -0.7057742271642352, -2.0014987406627753, 1.0366019622742788, -0.7750721543571927, -2.539208482354148, 1.0817688491242128, -2.832219736970623, -0.2769014456733058, -1.7434755744978105, -1.7559345138421467, -0.9411372531204273, -0.2515079640583189},
    {-1.249628362551044, 0.6631962219500459, -1.0472596809713326, -0.31699979600070816, -1.2727096372596831, -0.008705945674153514, -0.9150943128850957, -1.185364613127222, 0.09772373309933231, 0.3581258876081061, 0.8147727667017702, -0.8747174747829198, 1.054209591902413, -1.224401093281161, -0.39554534893651544, 0.11375131318183072, -0.8976794491726385, 0.7404467386085717, -0.36833366593687394, -0.14446682436316433, -2.8453524776169004, 1.0508464130286759, 0.8399437077214619, 0.49844537247510917, -1.7768585024735373, 1.9852406535185494, 0.919504349183504, -2.576986732620694, 0.6990414501014547, -3.4706055390218062, -0.6184460901192139, -1.4477701046847893, 0.16941095141625195, -0.5888218541388801, 1.6045461114647832, -1.3814296603018523, 0.2847114116084352, -0.5888976931297392, 0.5039574432980184, 0.5499210509942826, -1.3184199534674927, 0.8966914417939694, 1.6145877326357938, -0.20650515011774206, -0.9944718574825909, 0.3183316712870348, -1.6921760012134075, 0.28178649746344275, -0.34646411662408483, -0.9796038518377285, -0.8879732576746429, -1.3413014291529703, -0.09606216277661098, 2.5112567112320328, 0.36303548315617973, -0.6156052206877018, -1.037582460308874, 0.6468592137516062, 1.3937295122574986, 0.21172868580627482, -1.5821096764327445, -0.5045610864999412, -1.2453998008406766, 0.09956094226062298},
    {-1.347385815497668, 0.28257108140406934, -0.5824056077349717, -2.0965175893319516, -0.25567859790153424, 1.3578506347109947, -1.7015209118712415, -1.4278453727128189, -0.31967619165115047, -1.0774186404497257, 0.43281100437530867, -1.2605726708291118, 0.5116737738869785, -0.8399739747336702, -1.842785064449888, 0.7698009683882403, -2.3233410756557458, 0.5449552375695964, -1.216636403098068, -0.6736219982348092, -0.8884098686714401, -0.2430405118260396, -1.467659450754054, -0.8889452237128489, -2.5126591685873447, 0.0004500667881482056, 1.2658490178915123, -2.81039840246873, -0.4828846222547354, 0.03240485463439924, 0.3479771249513613, -0.3014684627998027, -0.8312285019308085, -0.8045751355592633, 1.868575447510774, -2.0454426596120157, -1.1801067704261574, 0.9511442837609893, -0.7397360579590359, -1.316636241668992, 1.1732096343566758, 0.710263398224556, -0.3791798246057229, -0.5247213505425631, -1.5535637328108245, -0.8585458543577791, 0.8736942053463751, -1.069073863634314, 1.717357996662073, 0.02651759394261133, 0.6837364823123994, -0.6889987480322949, -2.1478474861627506, 0.9752234946251368, -0.9264418617562238, -1.056883487890592, 0.6984967359875032, -2.2707971232362993, 0.21043077577535318, -0.1977793496294394, -0.8539570489388684, -1.0525877217227846, -0.8409326041647105, 1.8305785686336074},
    {2.238524787333455, 0.5299473853070416, -1.2540171885232394, -0.05981110682558766, -0.041315287825803695, -0.4549008979579113, 1.5787756644951112, 0.09470804722561588, -2.013248137832544, 0.8236214618721209, -0.06511521706487, 1.2218900273885887, -0.08420996975244917, -1.8901275662328536, -0.25667153058667114, -0.3992116170215523, 0.7545863386599165, 0.1937992021461328, -0.0012199314439874619, 0.5125750767707447, 0.7802661403941928, -0.753425413753355, 0.05250597204191581, 0.09855340425348072, -0.9499587023126431, -2.6592848624009013, -0.9739949454911754, -0.8345842190334626, 0.7660854163934335, 0.5534208913355879, 0.9180940078294367, -0.6139448762559503, -1.321991117636382, -1.769967897845209, 0.10000500206145231, 0.8720665257440364, -0.8654895364142852, -0.4476986315179294, 0.6529231007503413, -0.3912479001006728, 0.015359036747683151, -0.8832392091390626, 0.8941145166758138, -0.5901689934681161, -0.04417243471522673, -1.433156536710522, -1.0233305250115896, 0.47076124093458904, -1.8592279188050216, -1.3481740574892043, -1.133445121347296, 2.3273918074099584, -1.5483085688109501, 0.40613320501434275, 1.3680379406061483, 0.9873919653766123, 0.18850126375054135, -0.8153794735918778, 0.9225754359753173, -1.6736873130023353, -0.4465589601975095, -1.1344770430131366, 1.1679652455543907, -1.6995227505822783},
    {0.08181745300897572, 0.8315044026291607, 0.01722229719632226, 1.0391588506652099, -0.6260479531657059, -0.598860692341286, -1.9383059277841865, -1.4765061212699022, -0.8387419628688977, 1.9112918614839165, -1.57162895817963, -0.7823059154755407, 0.4493210789261931, 0.04722386116638411, -0.5892314111639224, 0.2017672441295694, 0.47726202718882704, -0.8659829324927283, 1.9596945829432484, -0.8202900099391024, -0.8145553212537604, -0.3923385569279501, 1.8152817719784478, -0.5394409287433006, 1.0243563170598546, 1.0306640242641478, 0.5344835097929932, -0.7125092203856267, 0.987061669673614, 0.6559991636846016, 0.6011107651636745, -0.07805823762775646, 0.46183154611412636, 1.320467974036782, 0.01661786417860229, -0.2482052198348378, 0.2017089072251116, -2.191765528967893, -0.8374120503534639, -0.042320840818459236, -0.39757244743102815, 1.9050440235240436, 0.23487224615641414, -0.21821876933716539, 0.019945803609364043, -0.46777412619996567, 0.4832051955196798, 1.0653873194345427, -0.6108696888721842, 0.7418537056856748, -0.7586532196940878, -0.7842455493156668, -0.497000648029507, 0.23207598975429858, 2.031410049419629, -0.22259442737607327, -0.8027777998587173, 1.281874393059276, -1.825146857159927, -2.420072081084611, -1.824523166144162, 0.03017263186624856, 1.8227932586676774, 0.0030538858216703248},
    {-1.0596069425457162, 1.3729022917333316, -0.20138101090540483, -0.879807189546867, 2.234901569933652, -0.09953710039563676, -1.186287545713745, -1.5170961673238472, -1.483347050814228, -1.0662121337506965, -0.5836666918315183, 1.694639604884018, -0.8791302013996141, -0.9410848131195221, -0.2508498706822433, -2.245660765300516, -1.1815617768281836, 0.2568111367947243, -0.30636143674871935, -0.49914059580606757, 0.0441241886047799, -1.0660822572630209, -0.8184538908952806, -1.5317838146615637, -0.09345357087848963, -0.9373925940144164, -0.7972133678110045, -0.7013738669149382, -1.5303111656330708, 0.6799863190140596, 0.2626492959207841, -0.02091683459271017, -0.8447146380415307, -1.221298084369951, -1.0925998093576246, 0.1719681573695375, 0.1529865582754166, -0.0867131095770384, -0.5607622199643809, -1.9245721478292608, -1.835563241615673, -0.5923547507523909, -0.0686830765305382, -0.21066703138400636, 1.4688959130219268, 0.9691727567079078, 1.5610404625919332, -0.9696982100584141, -1.223849919033263, -0.2984845696704531, -0.523639176172078, -0.2683181176884595, -0.7822829849350635, -0.8685414101318788, 1.6346530641811634, 1.9327561476163242, 1.702550389318314, -0.22277552216779642, -0.8738665116061937, 0.22803759871146592, -1.7878652992666928, -0.6244869419985271, 2.4147226124170165, 0.4479096176197096},
    {-0.8877387694624399, -2.2356631079860008, 0.05491705651480064, 1.1556213441114667, -0.2969505837358549, 1.1416825107220312, 1.7026207840446008, 1.0660785648042381, -0.804362201428061, 2.6148763802689277, -0.3587222945294409, -0.08394174944763202, 0.997754460839669, -1.0500195150957001, 1.3533387445253868, -1.4725982360055025, 0.8138305398384439, 0.5384380136277338, -0.8882840084126791, 1.3229296356772273, -0.5429148838722624, -1.3747874638365163, -0.06216733335954396, -0.5411885779520864, 2.22670361841465, 0.13086913523843346, 0.43962586123823333, -1.4269417270686262, -0.45988720826291646, 0.8674496115698264, 0.6188813748086445, 0.28864640123912005, 0.8607498701278765, 0.18385551721370658, -1.861355164967567, -0.33974002596068137, -0.3721906699096715, -0.04081924790761441, -0.8242335837284723, -1.10115964734298, -0.6476121457389318, -0.7842526891732257, -0.2338207730892025, 0.2790466909685786, 0.5089245611895639, -2.2497105639032626, -1.6034765036319676, -0.27376506385146826, -0.5266993322756321, -1.9419340432941459, -2.150881387958633, 0.33414599962387953, -1.664302183504329, -2.1081013796393284, -0.3458679474576587, -0.07879079690676573, -1.6376043533460072, -1.6875757497494774, -0.20056406075232389, 0.6187339337743594, -1.3062233260194622, 0.6192290758447339, -1.0756152198461277, -0.5797986107076668},
    {1.308694928360051, 0.5854243252079094, 0.8892114265601795, 1.9357915214331491, -0.257788537375065, -0.35888067032901005, -0.5221221416757004, 1.2377923994394082, 0.7674937991564589, -1.4731028558727273, -1.56096625986991, -1.1480159825481167, 2.5284722168368328, -0.8388866937231785, -1.8520449984531455, -0.32777101096723954, 2.1399424793341915, -2.8048141201066077, -0.04984309703157963, 1.5015120092983156, -1.912475368002319, -0.4525361894237569, 0.7558515106587194, -0.01641420204759005, -1.4835296919977163, -0.1672905487898719, -0.4596864630516873, -1.369145442319751, -0.6404566176055214, -0.37350666620586687, -1.2893470937530294, -0.3659925034077644, 0.6533522873970921, -0.47835078854343344, -1.5895224636998717, -1.2128765371400694, 0.5972292692375777, -0.5311426347435084, -0.16878280995633918, -1.2808454280876063, 0.2646356620885026, -0.39765644082587454, 0.6409766268483393, -1.526665557291768, 0.06312689708944709, 0.5787737237078259, 0.4918487995036426, -2.510122028324898, 0.032657812352801095, 0.15710184074355643, 0.05126550630031088, 0.6330485424965435, -0.416575955597908, -0.8231153709071232, 0.3964643325909014, 1.029507212269471, 0.7103823883628836, 1.3782910433947244, -1.4143016276407492, -2.1580621213559934, 1.014487265527141, -0.037943278392131276, -0.06277721077275557, 0.9241781049032302},
    {-2.1208332739855917, -1.872383421317094, -1.698831678356677, -1.5332527711177608, 1.4025817428429317, 0.2546610839260329, -0.06530878820269549, 0.28731168247699185, -1.1075335230966148, 0.8853787624215637, -0.6636655159918701, 1.9608904233125384, -1.0599696642461847, 0.5515164488679337, -0.22878550836374612, -1.631498151767908, 0.13868986747364828, -0.24506187574690894, -1.7968042341354136, 0.003612168955243566, -0.33688512607527105, -0.4406717814254694, 0.18581154439109845, 0.052402738201124587, -0.5008620711294168, -1.725788355428485, 0.5865050922425964, 1.6803874296331807, -1.0919328321130957, 0.07938920497992899, -1.2712990588874928, 0.07072275430516185, -0.6473924048877286, 0.8425622513091132, -2.6035239674655792, -0.4817540125829112, 0.9086691001879053, 0.24013455939556475, -0.8097198491578922, 1.1686894790957634, 0.1696889562592105, 0.31023943470282317, -0.6288100869430945, 0.8323390632465677, 0.1027702975295635, -0.21284720225866743, -0.6583102489754677, 0.35926901358369195, -0.7793111192618065, 0.3111505480398596, -1.7243969040371714, 0.32090908265162527, -0.04448448047736774, 0.5906721380656564, 0.31127871977096494, 0.17777484736876958, -1.8532602309084092, -1.2657458293790531, 0.9616830706839056, -0.19679880389948343, -0.6672250827978651, -0.8527566943355598, 0.8566164902000772, -2.138233813411253},
    {0.08872902094693014, 0.49721404508244754, -1.6773859197324354, 0.7644954825792581, 0.5667817628663003, -0.16547014712343433, 0.525959338511642, 0.5353001633894221, -0.11545776328850083, -0.9243588593700757, -0.5223148458707819, 0.8837324455139248, -2.437036449082399, -0.4145948147887738, 1.5874166514127968, 0.3382675623637261, 0.8364233198441975, -0.33687885799769746, 0.017974711791294028, -2.596453280355908, -2.27934706098818, -0.769096561585167, -0.24258366458179345, 0.03637785220858753, 0.1045400790588906, -0.5320572169644624, 0.1449086604520871, -2.150637853463576, -1.7485636346297586, -0.705467014302634, -3.062937363610788, -0.778152107736691, 1.3183090131452009, -0.6309562206967809, -0.7448246447081671, -1.3632436359114688, 0.12894113450067446, 0.3819154123698476, -1.8330168052274745, -0.8107229313747962, 0.42149086731943264, 0.3402220331202065, -0.8432241557999208, -1.829503671054097, -2.9705170399178322, 0.4089381399833664, -1.0258047512976114, 0.6142645511889412, 0.9128145317247217, 0.6993493682212896, 0.9613145168578211, 0.49183165580748456, 1.3287516377148176, -0.9188362598159217, 0.6143965801721406, -1.0764057952737027, 0.6308769677066093, 0.3913416557141431, 0.9104511144403382, -0.2688552601294168, 0.33870968199496937, -0.12290703537624964, -1.8833557976887556, -3.41718443172817},
    {0.4380780071904712, -0.14780100202513777, -0.8553759339115214, -0.037626809052618566, 0.959126593576309, 0.8461564010415646, 1.387648348988654, 0.8296647815831997, -1.812954980550253, 0.8644911638365738, -1.4259254061841806, 0.7287299578235938, -1.8822921183629233, -1.532842048080534, 0.5550535384273844, 0.08350943973181991, -1.39570618452521, 0.45142131820150894, -0.07668309040755097, 0.6879655967347399, -1.7360248168179073, 0.5645355994441816, 0.5576739152496508, 0.6324860975148345, -0.7681298933182407, 0.02248334745317771, 0.8758945158379627, -2.0134689609880385, 0.12483515306129699, -0.3148688508089912, -0.6144576939300906, -0.27980862567496073, 0.6835629612453473, 0.15174691447760152, -0.444803294003662, 0.5654607428723948, -0.8397754585384469, 0.9508425202523086, 1.330885444172736, -1.9070467388926922, 0.132339799388127, -1.526751411160025, 0.15352278862997823, 1.72741615870986, -0.11681047304670897, -0.4153186183605015, 0.335471816285842, -1.3283750180201397, 1.6280031195953963, 0.3257371180689821, -0.7741020970521747, -1.0294093442892713, -3.274983742897163, -0.20252412785075277, 0.39502815410074327, -0.6984016783677587, -0.9325539514367864, -0.628735902274466, -1.960282470969337, -0.9549210234137447, 0.5103575216854823, -0.3884503495326254, 0.4373393790117076, 0.17872776088318135},
    {-0.22312843383856915, -0.4326721956394867, -1.3186128122141738, 0.9631884775000928, -1.5470473215681095, -0.38402364229875297, 1.9277644056435976, -0.9453419713046725, -1.430138141890444, -1.020326897102595, -0.5042698863561224, 0.5582060180994328, 2.018010838625162, -1.6857443925017865, -2.6886963309409073, -1.344401673275223, 0.7467757902912427, 0.9434337906480101, 0.8765047211896932, -0.1481027138064661, -1.555603740566176, 0.9243416894931957, -0.962939860098932, 0.96163883312104, -0.7769560667872452, -0.8593795418270586, -0.7455326928913593, 0.0572260783984387, 0.19388539274104752, -1.5097033822650663, -0.567614227888935, 0.9378533533865059, 0.3382673559234369, 0.26595319320416644, -0.05251354928784913, -0.24638671882450888, 0.14953849490133395, 0.1707458470233805, -1.0152161551548695, -2.0016236421348497, 0.8249296130722401, 1.597245800399935, 0.05858503060379065, -1.3596737893236854, -0.76325195713301, -0.49413886320370787, 0.6493680689038932, -0.5973313107047118, -0.9076016506143658, 0.8333929575049162, -0.831303327330215, 0.2443803936711265, -1.1116099882710706, -0.3903851216010354, -0.4304877013544955, 1.1130976989669272, 0.621040981368242, -1.0166273667191126, -1.050786352220405, 0.18928969399838347, -1.7938011178697646, -0.5807772144360005, -1.201942687504691, 1.059533075029795},
    {1.0738009250708882, -1.1357073011665197, -0.021039194138276422, -1.2328140520390465, -0.46394238895407836, -0.4652592234345161, 1.2109742130084327, -1.078840728031577, -1.7583916776830661, -0.11553694918178394, -0.36300998841758514, -0.7644683069272372, -1.4845069547359673, 0.8002745528398031, 0.7441966324974247, -1.6156030672786326, -1.1325673236758451, -0.660087630683453, -1.6516398400629844, -0.6378329604925222, 0.5892436920997081, -0.15042324721184305, 0.605824478615955, -0.5590844053944547, -0.0003653091055697137, -1.8699408559528716, -1.8643659282028204, -0.925573070175629, -1.3103981282462245, -0.935274785011004, 0.3404165481287456, -0.6946189784735942, -1.824052817214615, -0.6332940298363289, 0.6579389062904304, 2.0646282874658324, -1.502008212032574, -1.6735757521086785, 0.3849904901395587, -0.970352662468016, -0.5438714342750891, -1.5469615635834408, -0.534106018845322, 0.6509903746379756, -0.9025389373705632, -0.48553689654131527, -2.0167029498013096, -1.7527510283049974, 0.39993294613612096, -0.33466057066150584, 0.6770770439992125, 1.908988641619466, 0.014046442231656112, -0.1504423152962309, -0.4366772174582468, 0.9378089842641896, -1.0395271793099377, 0.2590676595958482, -0.03208546325700238, -0.6253615122312771, -1.316975161342378, -1.2649323490844768, -0.4799876734753103, -0.9898697176048626},
    {0.24902345545978358, -2.408642000303234, -0.4775967812036471, -1.8735586471164045, -1.6416042601006628, -0.8632276311373214, -1.3090792483249485, 1.9930432148854191, -1.4601941702116845, 1.908992935915874, -0.7119154034517088, -0.2092982013786109, 1.169310222648201, -0.3791499258215899, 0.5452765144951119, -0.2683905173443846, -1.605149118576188, -2.128211231750953, -0.5209209921723368, -0.24440394810909558, -1.749190556139845, -1.218842681457918, -1.1051130033704764, 0.2985024552334084, -0.11692937745848403, -0.07584946546758146, -0.7314078778260308, -0.7081200116998345, -0.5313078778937806, 0.23546982394124102, -0.12370139262755064, -1.5763999385538026, -2.8077150440320757, -1.9356007185102162, 1.0984440312322619, -1.1523918988510566, -0.6444227004409592, -0.9720889562500167, -0.4884733604935221, -0.7658141364073546, 0.6099390699886966, 0.6210573563388251, -0.5904707635913761, -0.4328054312210097, -0.04081057233240251, -2.0089781190969256, 0.7913156613011714, 0.11716510252680794, 0.6258143992620091, 0.17617843518444032, 0.1467350916800596, -1.5390150466113077, 0.6460570767627584, 0.09742764818966258, 1.261684917806806, -1.3188471110399684, -1.163587828356039, -1.8260043337287193, -1.428832133431797, -0.3120533054322482, 0.14302375813810306, 0.6601505687520485, -1.2295801436631082, -1.9752232967351036},
    {-2.4039209262858567, 1.7809898204914314, -0.46511657952214913, 0.5562567468755895, -0.3845086009132626, 0.469129184371879, -0.2274121091614186, 0.2445706138010827, -0.1016757813840517, 0.5831080393417613, 2.505782879101083, 0.5529929306919967, 0.35730085443297344, -0.7271621190232717, 0.5922617677152557, 0.024351921936840448, -0.20247479451745523, -0.49579174442359997, -0.28639309444656863, -0.9556009769389477, -3.151325038258557, 0.4246910577012863, -4.453648141496616, -2.1087461496906394, -0.19804107245373348, 0.015168215807143004, 0.7398637208858971, 0.9778100151366913, 0.9044183960940322, 0.07145375007916732, -1.080753540344135, -0.6472939292510181, -0.688386558690594, -0.4563388049772788, -1.1409826625866462, -0.44999929876867995, -0.7543140892393971, 1.0795138733816538, -0.5588794574121503, -0.5204769756478248, 0.7925565299447029, 1.1392310716232719, 1.1647519988119428, -0.6700183573469412, -0.43915003376531064, -1.2112649504888706, -0.14937313414664066, -0.4485002244922653, 0.014470836828048114, -0.4149248769045274, -0.06897620542758166, 0.36070081799491777, -1.718398143317566, 0.7661975782837585, -0.7907708361438339, -0.498581969090477, -1.3576985581979166, 0.4556823595579657, -1.602413489716067, -1.2281537437787609, -1.1681872965288282, 0.8247301874038792, -0.24288321556738668, -0.465151822933804},
    {0.4280645787539868, 0.6981877169468979, 0.03147441994138076, 0.1893122321483473, 0.72516622347296, 0.02481903777582582, -0.7613783396729721, 2.36156283073643, 0.646526345656634, -1.0085184361290327, 0.6802464746866576, 0.12707191151140976, 0.2569496708576392, -0.3044660257227004, 0.5544483490633866, -1.0421385356534356, 0.0542017213671482, -0.5977477420506168, -0.4208294428410689, -1.967746541198445, -1.8333295695853904, 1.4368942412878913, -1.925576328626334, -0.12552626069500336, 1.2935802113654922, -0.1662225918625369, 0.28871559392358254, -0.6610030251767285, 0.23901946722511463, -0.878332466458533, -0.3152422407205256, 3.590781919042984, 0.15777870557520246, 0.09499474814485806, 0.5063386263569799, 2.0801232828916225, -0.5249658158561876, -0.2831553494568403, -0.6366869461834358, -2.0037558249949026, -1.3997530421761082, 0.04552515764425792, -0.18563927169092595, -0.27528002883125346, -1.9044085282909329, -1.2727921955787542, -1.5348327917698996, 1.3396371625796537, -1.552084392801036, -0.4762244467059843, -1.7768897941205697, -0.2738533381278855, -0.8663062145905839, 2.0045046222586542, -0.5590880264798087, -1.3583912367421902, -1.0869821721682973, -0.44720122317821853, 0.30188187961812396, 0.0958418211329744, 0.9039606877795962, 0.4687625689209304, 0.1673237502358483, -0.46549709875332923},
    {0.012327785047911531, 1.6063913968301409, 0.11352191890220217, -0.4440873717433551, -0.17500084168812008, 0.1170727322750672, 0.01959155126953333, -1.7218746905892481, 0.34442084118616645, -2.46824892284645, 0.7370527760003146, -0.9095110513391452, 0.6650972060539099, -1.060547209589395, -0.43806800380816224, -1.4993907365322405, -0.46999762945542295, -1.1910504938460162, -0.41439560442582885, -0.6934949834705063, 0.1689334239047591, 0.5943805020952613, -0.9034372392191737, -1.3899951502113874, -1.4107532443122297, 2.1565085532922343, -1.545028737308177, -0.905253972220108, -0.8764804734116465, 0.8282312944539056, -0.8419737802378555, 0.24077898446955345, 0.49430043067081636, 0.08403596047200439, 0.06736379871418428, -0.20457864023931502, 0.8497077641937318, -0.17948014767232903, -1.31682682380136, -0.26759756306484006, 0.4941004763187666, -0.06092253387219124, -2.077418805660187, 0.030104154130788617, -0.3105355048552186, -3.11577512393504, -1.1427337273177818, 0.34500994412250285, 0.9986761460751941, -0.1711670860329453, -0.4436736584619251, -2.201714559694544, -0.16315061586380514, 0.11743811045981045, 1.891702917888721, 1.1540288545603357, -2.1002230125305648, -0.6755130879243318, -0.3073557989919349, -2.395723720996812, -1.0265737824486394, -1.0035015781691954, -0.5251642622296135, 0.18483947485260543},
    {1.0537482449720017, 0.6787496511042198, -0.8582595564402411, -1.01429604514355, 1.0018756234352648, 0.4704697738336738, 0.4409797253866848, 0.09546378137466607, -1.113343484866013, 1.0523822058645962, -0.7507325365190153, -1.4462284379893886, -0.3849986933983295, -1.0341786152643848, -1.7381038814623895, 0.13512050309786, 2.2389598223170664, 1.2679718364247274, 0.04528130402220786, -0.1004418561593121, 0.036320112957875884, 1.671174873807785, -0.8663813060551934, -2.859922299204335, 0.6170834764047105, -0.21669947006758944, -0.6363100218065685, -0.013304373290356032, 0.881189642131783, -1.2463170734111408, -1.8438780447311187, -1.2940038939114173, -2.201326325090884, -0.5908411270753818, 1.6134636534575708, 1.1944839646001029, -0.0665393170518361, -0.6990910258487404, -0.714450286070931, 0.34673777626512914, -1.1596794176644407, -0.8562381528193134, -1.114330855384756, -1.3561194108663646, -1.7193405945342806, -1.359866632820787, 0.3930557941651514, -0.5820562689226655, -0.8785402662620838, -0.23030175004666717, -1.0280442715160305, -1.0599771146451422, 1.805839415708576, 0.05533192107820944, -1.3524103089967656, 1.197194828480727, -0.2949994147454492, -2.4168350519142483, -1.5580114321634309, -2.6918015679567766, -1.2075218407729507, 0.7253539674764123, -1.1613374842235724, -1.1806968440584988},
    {1.3120396793590727, 0.5557404575833632, -0.12254048701475716, -0.8039499429059306, -1.270318345187928, -1.3705310731368803, 0.9749714794848832, 1.55499913034523, 0.07980236351806157, 0.8592211493386452, 2.2482366276681622, 0.18418957846954487, -1.2908500162612575, -0.7065844160396795, -0.42415849706986075, -1.2580001669279697, 0.8246344908514204, -0.19084161464594956, 0.20766993587176508, -1.9194528824278403, 0.1467343270792107, -0.8896877262405388, 0.8481654245517254, -1.3569118233936879, 0.6533294624953491, -0.04182679374295136, 0.7604822072929446, -0.8560209738255281, 0.2499481223960875, -1.0630547639946075, -2.6588531834485423, -1.4454313138529475, -1.9965103925084184, 2.350882431501467, -0.3209244265592203, -0.05921769975306445, -0.2964561382169818, 0.6218210103885801, 0.3329392858011401, -1.2029486298411134, 1.2736586033195985, -0.6100856425172645, -0.470106808603788, 0.47890203191632896, -1.3490121319870205, -0.4926670318219682, 0.661402775255826, 2.108880516264445, 0.01000179471963722, 0.247905143582951, -1.0468460963112718, -0.5289089435042922, 0.055436233050284965, -0.8557739036382833, 1.4014269055022324, -0.4812573580008199, -0.3881196957864625, -2.406295525661519, 1.4982433040730774, -0.09232095888627118, -0.7810949707299294, -0.06713757070462746, 0.08493712257627983, 0.7621705135737673},
    {0.4636064499886734, -0.40120872362229854, -1.414517512283054, -0.6454806194854679, 0.25123987267391945, 0.7306294455862059, 1.8106497081076582, -0.7823015581234598, -0.4802850029670583, -2.3424841052699583, 0.8074697123617663, 0.49572056662053166, -1.5138776858468506, -0.36515683570538027, -0.21150425236089687, -0.8539262541744788, 0.09267117850841552, -1.3060766435224413, -0.7166617941887035, -1.134833628857854, -1.326028526043352, -0.5623865123370533, -0.3086366025017353, -0.5465310582509276, 0.8253502507353359, -0.36398763330499145, 0.7563298806548943, -0.3825843104942897, 0.22176411338703814, -2.446765550981695, 0.5616681696390227, 1.1038140700321766, 1.1270601961602826, 0.08420842123904933, 0.923810354715834, 0.5485606362577317, -0.00020557364584643776, -0.7433829957908386, -1.7817738516066026, -2.5888794316643224, -1.1159909998470425, -3.2758733626343712, -2.015852284454838, -0.3523327659354882, 0.4151206113149712, -2.337118717745769, 0.18400758327949862, -0.6736705383410044, 0.41496724268997076, -2.3108518736401984, -0.015513633985453272, -0.5818120008323378, 0.06697201236826203, -0.9015802171986138, 0.03494074220038497, -1.2688321566592973, -0.6624531281737157, -0.23686783264213312, -2.194849195261655, 1.4650149257051999, -1.6288458959085002, -0.7670965682929515, -0.02398551886382922, -0.9104991393915034},
    {-1.9422154047300084, 0.8314794801037114, -1.802597293482535, -2.0521489729276183, -0.8901782452195371, 0.7045359505085425, 0.991290062345977, -0.8448973349824668, -1.2390811532723365, 0.29890969341438406, 1.511962076475884, 1.060446551149612, -0.24270219409250327, 1.0034416127764896, -1.0998926431602545, -1.38089027616065, -0.06380254619889371, -2.2062484391155275, -2.5287281101604644, -0.21185791131068576, -2.0306375312780056, 0.9657186478298994, -2.3106940696241076, 1.7248205612556344, -0.23050608192121602, -1.7606953376245056, -2.0315200955121657, 0.6275831096213912, 0.41083942428463194, 1.3762390438305923, -0.2724929888763791, -0.1270884848191284, 1.3018203242982245, 1.134590342411524, -1.1917197967107336, 0.8851103729585644, 0.5732050964192684, -0.22524862801224907, -0.30800654073558903, -1.3290334220094333, 0.08029096718419947, 0.5935015242781247, -1.292561179655768, -0.09705282004244897, -1.1696585993185038, 1.0349596348141579, -0.07814697989266194, -1.773899383040882, 0.21463309216292845, 0.6527074372696122, -2.3784732246885842, 2.062942408188471, -0.9213842517637133, 0.8634404963583807, 0.009344338924531152, -0.9794704990223233, -0.9876039630445108, -0.4917381084198983, -1.2465727770878003, 0.6375078389454484, -1.8239529772455916, 0.4522035615858366, -1.200275428456587, -0.7906125099878019},
    {0.07564380508486503, -0.129831891145499, 0.39591835669071984, -0.46302693027884967, -0.07534855144755487, 0.18644336928734598, 0.18258417055074397, 0.17768637535566362, -0.8973454733848284, 0.24642526334169368, -1.611305404873608, 1.486467760761844, -0.6672242238991501, 0.16269057606875745, -0.028912665826371232, -0.4700019290706013, 1.6335771878904386, -1.5387200718172953, -1.7330015487283248, 0.2358474115983626, -1.911485630047, 1.0805080769898665, -1.014521536662937, 0.1664866376825818, -0.0413665452050967, -0.9667511891182791, 0.11648763306026888, 0.766304838795524, -1.1925122329215496, -0.6721400448888902, -0.29329850433159516, 1.5700467180680984, -0.010083795160446867, 0.45663049519343885, -1.774586588518886, 0.16780097531151741, 0.7671995904641695, -0.1576501993270327, -2.129805509563197, -0.7378655257369826, 0.15709511087029676, 0.20239780763857282, -0.05213063446386717, -0.5301976365856308, 0.061622215739039164, 0.676782050556821, -1.0317743873820853, 0.5750172200941859, -0.25772454705177356, -0.3648509221806936, -0.5623434515301571, -1.7920242605654246, -0.21436367161551126, 0.6987757458165205, 1.0329293050000112, -0.8249314697529021, -0.10034693230118406, -0.6255466412030409, -0.7831804628511351, -0.1489967779352906, 0.3674911780546462, 0.020491734471238747, -0.407014244009976, -0.21282872793288507},
    {0.2541379503197541, 1.5689206136156832, -0.8539349356591708, -1.0661106751259155, -1.3692354745724256, 2.097901761813068, -2.6608476504431655, 0.4730550226180468, 0.08364770500902693, -0.6679307643005091, 0.21383204386180726, -1.894227375105041, -0.19131002758580498, -0.41982662922475433, -1.0728599728111716, -0.9954269911181746, 0.21998004768963295, -0.02847386888784894, -1.4823947734228076, -1.1811090822617143, -1.4111395913985705, -0.8184076513798136, -1.7330774056435116, -1.0344820842375522, 0.3387035848424185, -0.8425281931176046, -0.09369820941355045, -0.580694163903861, -1.9182289976800646, -1.7513522307198026, -1.5968852854984008, 0.7185479585909261, -1.5334374901662688, -2.1557176461209564, 1.3505955322739875, 0.04092603936109389, 0.8353860995369657, 1.7217073828313219, 0.08348212544140306, -0.04598088593875101, -0.5612002060856508, -1.8704440536939286, -2.019893780807545, 1.1202177451852238, -1.994710855047905, -3.77877060532746, -2.93610469671712, -1.1874689353164838, -0.3396401906403341, 0.855838173432611, -1.345273426022481, 0.981514608163056, 0.7115547702881485, 0.21223718456958746, -1.1477944550867658, -1.5738118012868105, 0.17226179070066655, -1.4820539215577182, 0.15689773682572208, -1.8488998395269365, 0.5011147024857671, 0.18918981258578024, -1.7919122410050718, -0.47983888432858635},
    {1.165816790342306, 1.4506565283033388, -1.3183124659210712, -0.6740766595808773, -0.7101415452656386, -2.0351458681138905, 2.3257742799901386, 0.8842510759138276, -1.8788121824827402, 0.9073868005331518, 0.13919807959164388, -0.03280234941345653, 0.1897674696306215, 0.7438810700797265, -0.9388604517426256, -1.0579932958840526, -0.37942714542118766, -0.20797552808710823, -0.9745335327704779, -1.8825206416195361, -1.773317352381188, 0.6016959964210652, -1.0536093203918406, 0.2517699340377622, 0.8088943567555174, 1.1391444609658827, -0.2438116832929151, -1.8458654328163966, 0.852940134562093, -1.5798811747091197, -0.4078562341002166, -0.38949513464734, 1.5488574483306186, -1.2373357742945474, -0.29986175990027125, 1.6138227244049788, -0.9494599200403874, -0.5889816828025743, -0.23071430135747611, -0.0038550615316556773, 1.078170526872942, -1.538990867962883, -0.6695375200206117, 0.18269804508653534, -1.3843272176734358, -2.32780288052006, -1.588581564053735, -0.0019758091271411845, -1.400115778293878, -0.3290631564509816, -1.2089904439983175, 1.3618118545397468, 0.5034303019890928, -0.8621996010140058, -1.8474901194127167, 0.268980160956342, 0.13256695538495072, -1.1960286074750854, 1.480468020450936, 1.6380035513220497, -0.9470699644226426, -0.004537779196792738, -2.1079043933024377, -0.17322126216164352},
    {-1.167440481168054, 0.4033461731567766, -1.9521614995310044, -0.6088101285903386, -0.7259233109458673, -0.6230317011682205, 0.054322791907483084, 1.6358316682810927, -1.2170227070110125, -0.40902727818278334, 1.30247175569007, 1.858894021501766, -1.2509611826778506, 0.44922275547019075, -0.22552451308825697, 0.14217456094842487, -0.2855122479926873, -0.3332572444711226, 1.3806506232867723, -0.748010218467881, 0.37589501288654853, 1.5889725045496306, 0.4384323501293384, -0.7296661470882569, -0.4845110986646875, -0.7078479828372851, -1.407047740000105, 0.9771487792563895, 0.8709810218046011, 0.2424541446382007, -0.19670353527705675, -1.487684478596358, 1.955873144432723, -0.10223016780225386, 1.761211888373927, -0.9984607098867752, -0.9773512638077867, 1.1617789253683175, 0.1018224627968007, -1.723171335160059, 0.588059603864131, 0.6407236139302644, -0.7937342857320292, 0.4531098649440965, -2.2384074050109377, -1.780694953943258, -2.405665992582802, -0.6480425785268509, -0.26137097176567103, 0.10821942959060556, 0.37078744601701585, -0.9276962882269552, 0.012296630970598956, 0.4394271875652605, -0.9189755894032916, 0.486788597300677, 0.3185601604044331, -0.8689678564336843, -1.062057425465869, 0.7176814629088989, -0.6897721192597531, -0.7855648461480346, -1.9407000781166353, -0.9476455690676763},
    {0.24116678398161998, 0.5381942345002821, -2.8483734855808915, -2.5573228399901624, 0.6648174406859153, 2.3408850666689234, -0.21087564196802736, 1.1023135860450626, -1.4868913697120656, -0.3937699335449824, 0.20217873269424505, -0.9518865643549587, -0.354408814413386, 0.09398382177490576, 2.248160363794517, -1.8462232134865881, -0.8381755579995614, -1.1505250919612189, -2.9731460750143794, -1.857741727296189, -1.3301751532914234, 0.7299933760423575, 0.7432652530746658, -1.7719797720772998, 0.9809040459299286, -0.07127004816172301, -1.0629529305724883, 0.4267033117363927, -0.49315320187110956, 0.8035427383601949, -1.5525433858926214, 0.7534092208448662, 0.7709138623343499, 1.4606253999015697, -1.9805822836990645, -0.06582943654087321, -0.2940924068341061, -0.5094132835515687, -0.06316190219389095, 0.9479274139928158, -0.2378785163232494, -0.7652909533039425, -2.1932288101143507, -0.5611980446100487, -0.22139864366284573, -2.8341143987019097, 0.18816147212687806, 1.4175143788930435, 2.1024692564543477, -1.6351881510653932, 0.06500472404212841, -0.10978157162543269, -0.4764829646378955, -0.025697374297121572, -0.37361309625899175, 0.047381673752640144, -0.2763785651884023, -0.17147896133132073, -0.2721902006643538, 1.503404094822192, -0.22517481305926723, -1.2263680980577443, -0.21245526623504096, 2.3487767421538224},
    {-1.1804066791455796, 2.720446680146394, -3.0969409995028956, -1.538015870882522, -0.9208746999795807, 2.37767955212745, -0.006351552115364154, 0.7707593909912847, -0.5782925283375443, -1.0119922593824187, -2.2648187869812206, -1.0718109100583053, -0.4181891093133106, -0.794154795973681, -0.29621288634408033, -1.6613314252726852, -0.977103679924957, 0.6496899563726255, -2.5048983472413346, -0.5167218054724235, -0.9909154163346102, 0.36126309008525165, 0.7470854918686595, -0.2555699564813093, 0.5829691591097504, -1.3743248217639215, 0.08477362659256014, 0.81222442799278, 0.6680956111198765, -0.9661052921127459, -1.6861217130876711, -0.38437305239961883, 0.5822606774812853, 1.0718236969670254, 1.1172739090149133, 1.1684633819349284, -0.5493801136298595, -1.8492019019620696, 0.9349372479120139, -0.9767190231631271, 1.4805657108066865, -1.5905814620842516, -1.8234525042514744, -0.8294026281596812, -0.5916129110611884, -1.1169670246936272, -1.470854250473916, -1.1699935621946993, 0.9761427844422155, -0.5809820000736093, -2.0579295383705665, -2.063893641477982, -0.11307076023053375, -1.681912846300728, -0.09130882850360675, 1.0979880065269412, 0.1002741244795364, -0.9388203686048863, -1.321472665251131, -0.059104082563266845, -0.7536469944781521, 0.020659344976991, -1.6527938400844597, -1.5072315016081488},
    {-1.194821838944318, -0.8843254687185617, 0.03900809408126596, -2.023762248069192, 0.23183310163325735, -0.2499141537987008, -1.532440650364497, -0.7914424326117026, -1.5474524392770603, -0.5073627529563951, -0.8600415931155933, -0.11069351588799302, -0.9267686408764274, 0.010945416448310352, -0.3732735083269291, -0.12587958529542242, 2.0569064144415603, -0.9461882818332341, 0.376853167936111, -2.777112781266766, 0.11681405186226794, 0.4686511406952714, 0.6281792391215171, -2.5710454547610087, -0.11133289165268048, -0.8084814461723876, -0.9025217945803737, -1.62789906673788, -0.5151084401053434, -0.5452968446784455, 0.3211662047638925, -1.048246391530689, 0.6593819094682151, 0.4025236510540034, -0.9285578968637243, -1.5074030495871207, -0.03885719655435178, 0.28645619956681956, -0.04207946635286121, -1.1424657127074878, -0.993853832076908, -1.8914144417980236, -0.9592202589455, 0.8601920569632182, -4.482500345183355, -0.2534898656585336, -0.06594449173780337, 0.245549806685235, 0.6174764560279484, -1.1768556217716146, -0.6586902109501757, 0.18043829720432392, 0.56307859668836, -1.7875059569608474, -1.1751881959193167, -0.9451705082759388, -0.49556200263193484, -0.5920584876673649, -3.218906638398828, -1.3883554543431806, 1.525742872583638, -1.3022632377369197, 0.9457798205282667, 0.4309763280808916},
    {0.45826068267596937, 1.3073645748713145, -1.895352518203775, -0.8481772456354348, -0.0447396406674754, -0.5258737363446536, -1.0608558773626833, -0.0778733102039978, -0.38998670825330745, -0.6654475649637182, -2.054908385321506, -0.08951153522983978, -0.027132125787321694, 0.8395285950632274, -1.3765138930059324, -0.2853761961140155, -1.0772861206803244, -0.6923155899027968, -1.1386903215156483, -1.155724495186065, 0.4995538080708869, 0.35822779596337956, -2.00389493993087, -2.526334661337349, -0.44556254751880664, -0.45189538209324637, -0.7810723009605615, 0.43424230900004424, 0.20713384418885517, 1.2477422185643474, -0.15256822594419295, -1.2886012795966642, 0.0018884491966856404, -2.0857799933003016, -0.3677767289921635, 1.5310262793270673, 1.3104211033446151, -0.4450917257291439, 1.1105388235403821, -1.975884486444864, -0.36229089399561115, -1.3424773913205807, -3.1529796344888523, -1.8229888441689115, -0.109920718479581, 0.44618180775865846, -0.055854149968150565, 0.5515740861086694, -0.5969507890904676, -1.2283396291911215, 0.27753910609664945, 1.6435220992180968, 0.8674348395907553, 0.7427715808342515, 0.4813952694112788, 0.9567024351942074, -1.0594060854047607, 0.23168962454287922, -1.1163951942951018, 0.44275444287951343, -0.4815492505397714, 0.5310865947936169, -0.43782683149811147, 0.5199193834427013},
    {0.7091811461223737, 0.47795069710635146, -0.28407466189485464, -0.7828591859123987, -1.8847575616453431, -0.17401857501038107, 0.22212622044214364, 0.2680066692566375, -0.09459449019505947, -1.6540613985285437, -0.05530289898611632, -0.4913479494534387, 0.2616686308494139, 3.028451239226837, -2.364572674679094, 0.39111006019740013, -1.4076052290213437, -1.1727153110722965, -0.5372806823746905, -0.9989453953112437, 1.4609786818056063, 0.8676777575145038, -0.47623061093916547, -1.5837943479280687, -0.17397582031358017, 0.9782134929889498, 0.3584486510336645, -1.1297387406633086, 0.9290853297361352, 1.300302602737258, -0.6760410297416535, 0.16485883925810169, 0.794097940384793, -1.0688477830467378, 1.463158938280135, -0.23276334182898892, -1.528473170547512, -0.9803611618972402, -1.425170881528378, -0.30271897567924017, -1.5131918217195446, -1.6459787522875249, -0.765976463508192, -1.6155800259777284, -1.6197694992600111, -0.8098693243297241, 0.3068247780852948, 0.1201518228501215, -1.4601484369362245, 2.1108588534684993, -0.3918400698368202, 2.3465875040454094, 1.7085704525099508, -1.4917162116625577, -0.2571108404384178, -0.8075681654845296, -0.322270193435088, -1.0395734936063585, 0.1852254623104239, -1.0683890623884371, 0.2209853649602872, 0.5824439612023821, 0.5442969234265621, -1.08468508694358},
    {-0.7036507553575113, -0.787209162875517, -0.40949608960353406, 0.038869014862630745, -0.2419583224205012, -0.19921297620089862, -1.4171897134003375, 0.420146750722356, -0.7024351179689445, -1.7487831008483143, -0.408229133836356, -0.12515689101358518, -1.446832777964183, 0.9474990121263628, -0.40857614485273874, -1.2248104662639823, -0.21128247183603133, -2.155691213674524, -2.640391620430077, -1.0815427434470504, -0.16973198096065295, -0.7311323955564081, -0.4826804649554212, -1.4057901886335948, 0.7174409176040558, -2.106532489259984, -2.0777191572889873, -0.9568569361100174, 0.08007946484603978, 0.7525112711108622, -1.9865687120735827, -0.6056298814545702, 0.569642197939894, 0.4642074626270445, -0.3144740717849329, 0.036943971797712395, -1.385379596037405, -2.019153976037863, 0.9559510901688967, -0.03925646850768871, 0.2834272761098681, 0.20849301498385714, 0.9871260549079316, 0.42879770587453725, 1.1319262800751364, -0.9237825997024817, -2.6251963773196683, -0.39221174876517045, 0.14593139764887747, 0.17569672427988514, -1.0304840474591235, -0.13135221392186078, 1.368976863218738, -0.293282188788789, 0.7529652813738473, 0.2750812887677502, -0.18516811055134666, -0.1003303942346271, -0.6394359763559425, -0.9701380811045682, -1.0531638255433613, -0.9455379859636633, 1.105647323943985, 0.21199327512335797},
    {0.4183861607369352, 1.4149448374934535, -1.1389320475932834, 1.109728505229863, -0.30506507853670867, -0.3029412143282955, -0.20761675204537733, -0.25403137826257866, -0.1571510105782643, -1.7173771078484183, 0.11176904500507191, 0.11723448482533096, 0.580930115018971, -0.015065485096621683, -1.7385944437553968, 0.1187601947387166, -0.1950646956567947, -0.20558701978856372, -3.242094254820649, -1.0728276013297, -0.6926023451585733, 0.9966929465084399, 1.1961637934208904, -0.8142657725739706, -0.6600029043810898, -1.0429309592424332, -0.3408274171486485, 0.11592608150378395, -0.8648498952831748, 0.06767548943332119, -0.5538109960533968, -0.8055080010786533, 1.4291659949892055, -0.36837387995124454, -0.5573495770675553, 0.5097367660218937, 0.4990907914485652, -0.2090986157529141, 1.2175855837947465, -2.2330500584520383, -0.2723231517796019, -0.5696312610439376, -0.7095327583832468, -2.6090008738095514, -0.4334021180863242, -0.27087464704382835, -0.969591187306797, 1.2986446740688693, 0.10700249435822834, 0.7354602875658935, 0.7162111536131525, 0.18591278710191647, -0.3740669017536893, -0.28821836832024955, 1.7696065079264238, 0.9285798708121734, 0.6747173997676618, -1.9617186185318676, -1.6718363181494509, 1.4181932711594365, -1.921941441925532, -0.5149585645456604, -0.9792929293661509, -1.3139673572049035},
    {-0.3335519580569235, 1.025692441774805, -0.3894918911441704, -1.2576506714270321, -0.25441877162745086, 1.653051568875008, -0.8269438096421802, 0.27439493213143984, 0.573262060935728, -0.137859919277766, -1.5021304735948813, -0.2603404183226456, -0.7693945333402286, -0.18823580906453038, -2.628052693625194, -1.1818018364430882, -1.3060181172357146, -0.3741090438788966, 0.06644296694919642, -1.1060819807572548, -0.26163854455361685, 2.3692616021470685, -2.6304708841305815, -0.7237634706657049, 0.38854501923774265, -0.6579884276209801, -0.06066594013869662, 0.027235067847402244, -3.0534064475548774, 0.5540546774492191, -0.031320974773409754, -1.1204776820926239, 2.0441300057951364, -0.45481448630912086, -0.20327567099500218, 0.16263307892078754, -0.4023713755798206, -1.4999619787732945, 0.41388359420122833, -1.1559764719724606, -1.0309696666826216, 0.6966585819684217, -0.15280854619521198, -1.1369790132756412, -1.9178678488208405, 0.6200089611217003, -0.18171333563198827, 1.4864715011776624, 2.1492371079202433, -1.7946671400752643, 0.6672164103442062, -1.2778299499909427, 0.2741318977366156, -1.5223636965773182, -0.23986302194256473, -0.14608630947171364, 0.5917681437733009, -0.35396059675001396, -0.725636788343366, -0.4623208153660611, -0.7020553889052263, 0.4169843421880472, 0.23239613447141547, -0.6839816623434135},
    {0.06344533479971835, 0.009659287336818348, -1.061402117371196, -0.34550063740481696, -1.9360010628876718, 0.7151361013157834, -0.19371780540164169, -0.9357241960460827, 0.17289626098435779, 0.4232420088234053, 0.6396223931846685, -0.4923248279780646, -1.5132235499602749, -0.07114109541380499, 0.17921212420571525, 1.140040463113636, -0.6522742793478008, 1.312343158470259, 0.4782293081307477, -0.8489852745303305, 1.3865421761945282, -1.6101514635882777, -1.1935241313555627, -1.7450033185106313, -1.276536639085385, 1.2524779497864704, 2.2178691243262705, 0.03423895826810979, 0.24277315976542993, -1.2531491104803079, 0.12899273235259684, 0.6268416351114778, 1.4561084074003752, -1.9302446737168169, -0.8465160650227466, -0.1021982510353064, -0.8881327961562333, -0.43172243247951203, -1.1079365243965695, 1.0814572254748085, -1.771509975649175, -3.267803776271664, -0.11975390612284773, -0.6722787515416156, -0.2832660993651261, 0.8805950397426702, 0.46850228325122123, -0.2348306317070029, -0.5327414434456667, -1.4345771589942693, -0.4068865426870686, -0.5890689438388221, -1.1388609892016024, 0.04272980878411993, -0.1942692709288738, -0.27249245932307037, -0.5146298321131657, 0.42901219354974496, -0.5165896465941997, 1.5881381067913423, 0.10588371556360518, -0.31331720665225254, -0.30949082621795887, -0.614195367822251},
    {0.8209193062983361, -1.9919618307360991, -0.6071670763643695, 1.3395671042931472, 0.5987896482152957, 0.8866644448611614, -0.6363860274422927, -0.8359119142827971, -0.8392540401155065, -0.26884575138728867, 0.14011481298652043, -0.6897973179448526, -0.5686922175165506, 1.3145969314508086, -0.6868358729121266, 1.2973465688548647, 0.08829356137184258, 1.4460984707716256, -1.419120757386294, 0.48419195149981153, -1.2065236785569888, 0.4610028263512293, -1.2477930468303615, 1.1847877386824983, 1.0569198716676524, 0.6235759404673568, -0.04401861691916033, 0.5666217883264731, -2.627906904115909, -0.23653645006596422, 0.43838774707182837, 0.12407063685190245, 0.09701091092669539, 0.22134613338398482, 1.9112181701283375, 0.9706040565980532, -1.3989325975759488, -1.6466945397725723, -0.19415545252744856, 0.7935299161564565, -0.10809223866559275, -1.0799544650202328, -0.3859542043010541, -1.5143468405741685, 0.5389831022877737, 0.1648813341413803, -0.43278569588038734, 1.0056208297276459, -0.13604993769332374, 1.56363150667923, 0.7593205248076652, -0.2297085442643009, -0.5574617569969786, -0.2861571627661959, -0.2976724502977378, -0.5961708130554, -0.4554107236857503, -0.9519314949069596, 0.13576903713677027, -1.0704900682038456, 2.4087020698025907, -1.7072153653742588, -2.1803167715833656, -0.4702512996221453},
    {-3.155245088394385, -0.6237346779634922, 0.3695601518432917, 0.905555470785328, -1.5296250819127628, 1.1942839017073035, -0.3509322810082767, 1.3851560463758246, -1.4934334108471872, 0.5615885785891568, 1.7366709134608682, 1.599388276016827, -0.38980801745494575, -0.5515023189255266, -0.4908329303889096, 2.8696324869375416, 2.0691600543871282, 0.8580105778591619, -0.41662696200989935, -0.7700516909223634, -1.1005446768323888, -0.2662521508953161, -0.9545283105947987, 0.8486308925602354, -1.1163117689317157, 0.7219116658506946, -0.808181756991123, 1.5030200484890788, -0.6726418876146012, 2.6942909526561536, -0.22010164897775625, -0.8273904195413443, -0.5626168928329975, 0.8543765262926076, 0.38779224467371093, -1.4363941945898429, -1.8827222052370896, -0.30369753371679864, -0.6188443362800738, 1.20065714048347, -0.03588035197812914, -0.22139348678198942, 0.055507953415565, 0.6055708306796385, -0.08387879455913118, 0.09276849516117351, 1.0500848517497823, -1.0495703300242603, -0.7460312180448784, -1.4582129119207077, 0.1598572228341744, -1.4190888523625713, 0.8625958906182475, -0.09159218520676159, 0.11567436045566606, 0.47552427780530326, 0.5675365180408433, 1.1608403411073813, 0.37351336612767116, 1.9202002003666265, 0.4095367281764238, 0.20370718384510436, 0.510156275792478, -1.5034476455014172},
    {-0.7883720017538481, -1.0654074168689085, -1.2581791887540537, 2.0008313856341, -0.13652142744547463, 0.6325358369484926, -0.22646341861126168, 1.1280822846794683, -0.2143253254199957, -0.20736607599644855, -1.1193001779087923, -0.4532781924711652, 0.9440274487800705, 0.20148134444053095, -0.17910794385833548, 0.7295617789306612, -0.06363156062317202, 1.735117558953723, -0.339884292325096, 0.16702000269320202, 1.9220795294640156, -0.4487920743757609, 2.7935345849665163, 0.15281383293562778, -1.3407278418440542, 0.8112375007837928, -0.911999679057376, 1.0200870434265468, -0.5186405958338507, -1.1687059603180052, -0.812776271938027, 0.6177297787360809, 0.7372271949930913, 0.7890321462998825, 2.0018303091382847, 0.40942998350924487, 0.7522325911967276, 0.6071153812063657, 2.4866080476894488, 0.864762921883473, 0.4271838150633666, -0.3988228291032127, 0.44257295431904115, -0.043482354417509965, -0.5487515418620662, -0.7332832487044749, -1.0739872873967804, 1.5792861255078103, -1.340002097212883, 0.06086190929013745, -1.7041836111418764, -0.7979624054218063, 2.1361520329213772, 0.36575010452180795, -2.391203117616808, -0.830313671480018, 1.5667884486961168, -0.705558161611971, -0.21827645538210147, 0.24023613402442515, 0.2590074809751937, -2.3915881910208414, 0.3433986248562047, 0.4057414881567958},
    {0.5511331558466354, -0.9478266991006297, 2.671623626097091, -0.20736141465019628, -1.0779487365510405, 0.43041243219484787, -0.05966668166822766, 0.09180910129030029, 0.6436884743817607, -0.5927667192173715, -0.2557632899698094, -0.7232365441090701, 0.6613242320787615, -0.564947632709819, 0.1636573563521632, 0.2997058480738139, -2.554858802759869, 1.023356035520591, 0.10260800031353563, -0.007221151582931574, 1.174292411751449, 0.8556357832688583, 0.4803124079161982, -1.126198285827208, 0.9829475635688439, 1.3857657291723355, 1.2605330175073326, -0.29445665078642863, -2.7709835647881356, 1.0541068105118105, 0.26509866387919245, -0.7197956707621191, -0.1868725937128492, 1.2499733739052061, 2.595991764301636, -1.8605430212180352, 0.9929825569430624, 2.228524845278011, 3.286545298165848, -0.05135301259406554, -0.005105827899405719, 0.35085814966851675, -0.3297943537904697, 1.3086332816423412, 0.8074034441460108, 0.7500279002855698, 2.0302219485807544, -0.1250713463291824, -1.5258172258811666, 1.266569807364997, -0.5397017282308935, 0.16845703046382765, 0.4310925778718179, -1.1688277777585037, 0.07094740964766544, -0.6229028522337806, 0.4943457644267839, 0.8526343260228132, 0.5542958155756942, 0.6668179301297115, 1.1299359184574653, 0.06757239482577425, -2.2191976835678013, -2.1508243477133813},
    {-0.498905168381049, 0.7867031320665157, -0.7749123702371147, 0.48080123824712534, -1.9332220595024463, 0.6154502174126151, 0.6655520451093538, 0.2846790883494914, 1.5001011140276417, 1.9867547291231114, 1.246562294955694, 0.29155772295115395, -1.7441714444400047, -1.0768749127455697, -1.707040609240752, -1.6574328589419538, 1.123807886985151, 2.3053591071835253, 2.913053289404828, 1.9878824936229964, -0.7415450972721844, 1.20216437693969, -1.807858757095382, -1.0472407021671846, -1.173530813547769, 1.6719359468716333, 1.4346898092232658, 1.6167869552142777, 0.4753789789284804, 1.1341656913213771, 0.6561439290738128, -1.2226233526494903, -1.964209341847395, 0.5721547775958559, -0.43583013944064514, -0.557478326749576, -0.3172176261329539, -1.5072535240868312, -0.2610451180717895, -0.8989324644460397, -0.18816495079890752, 0.8398416319544713, 0.5561614276419942, 3.1366704963484815, -0.32828087720066795, -1.0641534701787707, -0.8524634481390971, 0.8290685071871099, 1.3497529689316385, -2.238179981699579, -0.553239281549623, -0.2818897974767723, -0.6220045526361772, -1.5024617698124039, 1.9157692491978138, -1.294169072191209, 1.1267861652435927, 0.14150563450915177, -0.4462182440563083, 1.6193758327540388, 0.7841639082851884, 1.1550530947527284, -1.1476370516514418, -0.6683451351662106},
    {-0.624559492095508, 1.4604151807635477, -0.3428462818641398, 0.21717055176386377, -0.16518901893589252, -0.6721896128254112, 0.5431883091002925, 0.7086641441603018, -1.3770772524703514, -0.20846179679597074, 1.143999983749581, -0.4458312002461368, -0.9224819145720246, 0.09164247993646145, 1.5028327513141762, 0.3634339462492805, -0.4248610386704717, 0.40016093749571124, -0.5117635331258427, -0.17000613602284168, 1.1115042006260618, -0.7592508498852943, -0.042792884140599466, 0.24064241364008354, -1.529077291538522, 0.4955312684864341, 0.6102443980919213, 0.2719966879514155, -1.3669871838235135, 0.5961916473662965, -0.40383814721618483, -1.4135152176471986, -0.18443301582610627, 0.5953598218797995, -0.5563969603183655, 0.4814926279488755, 0.3302819028723581, -1.062893693374843, 2.443328140388205, -1.6363399043403808, 0.4517219153837411, -0.3709943927778929, 0.2563796502094762, 1.5402781800392258, -0.9576569355851775, -0.5176704715164602, 1.134407744930067, 1.9376921712226614, -0.4340999097519788, 1.3122616047015228, 0.09431707829674513, -1.2236129682377417, -0.5601519813814402, -1.4914985734457429, -0.301171643221721, 0.34561158111161216, 0.17930919360318445, 1.5919342731897248, -0.6380093796852675, 2.770278846566941, 0.1888284317799973, 2.0669461645862723, -0.8738685747504484, -1.204621943706206},
    {0.9668984492057706, 1.7306764725590928, 0.32563407763123076, 2.206216180475152, -1.56524328691502, -1.8115005454304232, 1.0108077282495707, 0.22461162327695894, 1.238232061832606, 0.7567012214389519, 0.7510318080503054, 1.1072177032085222, 0.10807430181358403, 1.2336156421434963, -1.3490890074181663, 0.45023833324849133, 0.7518868331225513, -0.18935033907210075, -1.170307681498691, -0.9084527617404541, 0.7639678496193889, -0.09658931562155582, 0.9980478439398353, 1.8461981192203318, -1.1156821935328356, 1.740426349863906, 1.4269620820043232, -0.2845644067364229, -0.007678772974290729, 1.729821268013701, -2.1361327168136284, 0.9179744395610167, 0.32629758568343176, -0.6205370649443601, -0.06047542560385701, 0.3953019503822868, 0.59367430794528, -1.8740489191074985, -0.11457475525634417, -0.9944608171922461, -0.9262540627195844, -1.7551060138528678, 0.021501196094083273, -0.16076879558696738, -1.494834823998772, -0.6182361179693756, 0.9732096134353121, 0.7615028738963997, 0.03036051438120464, -1.8520232061633013, -0.10859303408775396, -0.5263040592751436, 0.6987210120958489, -1.4913888685546157, 0.14453411663732685, 0.8051363277155084, 1.01458567874192, 0.6081333783627437, -0.10752850158897341, 0.478756758847089, -0.4185443528793862, -0.32353828032458076, 0.1575767997859219, 0.29153906697046345},
    {-0.30388691499171105, -1.1648011024620208, 1.0408767344106884, 0.8352847271782079, -0.33483934654625824, -0.23114607109753119, 0.09161298783563446, 1.1386698328276095, 0.7176044963905582, -1.0813927753752868, 0.7132010072410823, 1.6557946942433248, -0.4056025592889097, -1.107905803166432, -0.15895692212400833, -2.8668822546187167, -2.0957534162014677, 2.009252586632417, -0.06921325486943532, 1.79549450684687, 2.2056854050060815, 0.7918564066441041, -0.1342779599810106, 1.8719207585398416, 1.1097888719331115, 1.2923264976535433, 1.5879606498996228, 0.554086510352772, 0.5417422276508631, 0.00011671581420360646, -1.164410084189616, -0.37714703278640116, 0.081344734076517, 3.0366306792684097, 1.3546480855187568, 0.5081495284995847, 2.1527538357470197, -0.7858517257661489, 0.9644610349438841, 0.07364981151122169, -2.2440582436932965, -0.6783823715128207, 0.33340332917547155, 0.1078580890113895, -0.47347908674665135, 2.5494695357892234, 0.256319952232414, 1.5059076082141352, -1.0630946432948032, 1.5769491834625506, 0.21576666635502778, 0.16551858874327782, -2.030972983193811, -0.24462884561994164, 0.4912889479001298, -1.1379275849846235, -0.8550450019591114, 1.620046291545477, -0.02944977298037337, 0.3663847655480198, -2.656939580912675, -0.9290387259071838, -0.1305594003337562, -0.664944874017933},
    {-0.6537460580797112, 1.7002732192308998, -0.10733358719149629, 1.865096091781525, -1.1118401231318664, 0.2265191357813161, 1.0661406624603684, 0.3109290147128511, -1.4808235525954272, -2.085618444872914, 1.6341531327298562, -0.3725935235972671, -0.7838747538713571, -1.444646059272305, -0.5689179275962374, -0.6751447112622777, 1.2463587309810185, -0.9238683053275413, 0.7125207791379634, 0.862353363836777, 2.1134917660846, 1.8313198593532105, -0.07287130309514259, 0.8071773910461886, -1.9998469565756132, 1.4138636911581817, -1.3983316540126065, -0.7823469623007002, -0.6084473860838872, -0.2095105821491828, -0.5592115925127825, -1.3513318278791866, 0.6182849846087307, 1.844371610723831, -1.3087773231268627, -0.692079288213913, 0.9245439931466328, 0.4824691620605827, 1.506242326620238, 0.4053142989557468, -0.008324011399406974, 1.7744293772780249, 0.5902626665150357, 0.13329001661462886, 0.30795572603829424, 3.0733411308013387, -0.6072715985312289, 0.4248143060170442, -1.005264690678522, -1.1209098577923309, -0.5417921534118518, -0.45559432760648594, 0.22361073923076114, 0.1444444976714876, 0.44902288866819595, 0.18981078022463638, 1.5822501946098657, 2.4248725244447153, 1.5055760156118205, 1.552167718120437, 0.6973066451928982, 2.425128961924861, 1.4202032669215872, -0.6487829011976249},
    {0.2106658267263182, -1.3417274611233456, 0.2897782880796544, 0.3178786993500487, 1.3247705693744762, 0.6984072945992259, 1.200078252620468, -0.5743107864665331, -0.16665512838162314, -0.23521923835909603, -0.2986021409951935, 1.9468169771534365, -1.736385432071311, -0.09935336947479437, 0.34911366795490373, 1.0400874711639585, -0.913884154269105, 1.455430893950831, 0.8056093527268706, -0.35280596587581126, 1.9071237818991584, 0.7852311829393875, -0.501507097973769, -0.32548390236225194, 0.3833011484822293, 0.0699139057744606, 0.2801859908138664, 0.08023632418404694, -0.7126482705302575, -0.3578119000344911, 2.1392808038695277, 0.9709735342000996, 0.5603582719759859, -0.9773837484044733, 1.6755095388275245, -1.7394136850937785, -0.8594815871491095, 0.3977626678577878, -0.6052441260112927, -0.8152542584724393, 0.9833223685712286, 1.7066424801518858, 0.6616760616112294, -1.446118889795802, 0.025239018755227806, -0.5616932763529874, -0.923464969817386, -0.14687471528313767, 0.4970986085426617, 0.29878087038086837, -1.1528342988932803, 1.8188124381602213, 1.105715828673292, -0.7780050025210071, -0.1226126058639531, 0.9426781185918779, -0.08722840521079561, -0.46238965655598, 0.4874503023735642, 2.046553121662126, -1.583868576870053, 0.45650872276175597, -1.0657243821597973, 0.9341115971370271},
    {-1.1930179942498786, -0.12552454282796813, 1.4124545362850915, 2.231616396279654, -0.6132679876933292, 0.24706571485458473, 0.03764834805945746, 0.34997523943898096, -0.7203975997395589, -0.18152107533926712, 1.9711315896220778, 1.2041711694396757, -3.450712522326516, -0.45919895809661226, -0.8193439104068854, 0.8065598896475102, 1.1831815995046502, -0.24217022850059802, 1.760137433830023, 1.4749785073587716, 0.1099291086959314, 1.5993776797722903, 0.39961481256113685, 0.7793610409429508, -1.0401513619956997, -0.09274403952363681, -0.9100224309821606, 1.4614726487847842, -0.37311047852333246, 0.6613953748549514, 0.19938799081508915, 0.4040143438202137, 1.6316616139635496, -1.163165278186323, -0.3822236895857799, 0.5609171154250024, -1.587313924946144, -0.9909714720960547, -0.5558309425633456, 0.2914639441382897, 0.012348322264009141, 0.4810062522516671, -0.4842959795071795, -0.7218282659480763, -0.6959537454214778, 2.59984720506471, -0.44411586186862845, -0.33916586558184886, -0.5671224553536784, 0.00024200050925092997, -1.6469205066153911, -0.7518708902856069, -0.9582690998633271, 0.2844078323222536, 0.32083981726557487, -0.4455093412727944, 0.14486901063752108, 1.3379994865157891, -0.46807707052101244, 1.24327108003827, -2.7851890007232805, -0.23988415036028674, 2.0469647879804507, 0.9335089615855604},
    {1.024586372208755, 0.039215311980812025, -0.10338981241119614, 1.5149404291563098, 0.12925651051027265, -1.4677908318936994, 1.0562006006830607, -0.15418992449905625, -0.050734172711009475, 0.9053892359293336, 4.286675611385453, 0.401259973473891, 0.15267796185053084, 2.7705040665689253, -0.4460025253713049, -1.897564284038413, -0.3601303878686976, 0.4911652303344885, 2.8597033184840748, 1.1428955727922634, -0.6455164909851038, 0.18207441603880628, -1.7242084454238706, 1.783100004004824, -0.30795469577371143, 2.081940434987879, -1.5150558869430364, -2.3295275103918804, 0.9873854796068394, 0.9855448128668035, 0.9907739606104434, -0.6791623410836793, 1.8623737621888923, -0.4975765767940857, -0.2854199347509112, 0.5969997064978405, -0.9226113610001802, 0.09282978409684586, 0.6577417489665638, -0.7770345831595052, -0.37430047254757304, 1.675747203136454, 0.5184781822552834, -0.43015963210401553, 1.983671934607277, 0.7760309475585095, 2.9798472039685255, -0.26420681901796117, -0.260118143768313, 0.17393636516209093, 0.5421673745701309, -1.3774703156952406, -0.5635659921532429, -0.8955597329231246, -0.5224351026647645, -0.29061621268559873, -1.1732679272578708, 2.1219166528118314, -0.13237215858146772, 0.8168171324861784, 0.7277955827950614, -0.8508648777213117, -0.9573911955097932, -1.7771989298583906},
    {-2.8966254745416737, -0.3839119406440524, -0.5774442921239417, -0.5872114732426946, -1.4480562806112156, -2.4610352915906755, 0.26910360672192984, 1.3930349088166303, -0.5876296342541186, -0.6378929590428044, 0.6802569497737874, -0.6567009728316285, -0.49557285645724247, -1.8827650189854448, -1.8080745315053177, 0.49727462766871383, -1.3347103682745642, 0.7860671643603023, 0.8667520865030246, 1.6791133032375853, 0.07143891071487646, -0.49284738770856573, 1.7587945719406293, -0.8149142591383322, 0.3575109362869024, 0.8263396366314186, -0.351489378969571, -2.651285648543444, -1.3519358175195029, 0.5975345899467187, 1.3319214377415265, 0.09553973971234941, 1.7635297610626048, 0.4328674764795498, 0.7989579955733652, 0.6536537917746129, -1.543456450810811, 0.7181523956805292, -0.19001843467238327, -1.0714876245196274, -0.7607972490517786, -0.46101427041309734, -0.3334903838674248, -1.7608526100162392, 0.6887515900791668, -1.1983098249662418, -1.7091584409209524, 0.6206904030825385, 0.543861113530327, -0.47913875092401964, -0.2258755081370339, -1.3923879546817015, -0.3329382787353206, -0.34242768890718145, -1.531544987771342, 0.1151132025424276, 0.9885588903710144, 2.4741907996265815, 0.7220944097871663, 2.0199341513155256, 0.9015860826838388, 1.4063578869158126, 0.9399637167234868, -1.5123356157114205},
    {0.32989457673871475, 1.4098254229096638, 0.04739601358203129, 0.3128233933668854, -0.6763314177823497, -0.4149578476956908, -0.8459378879082968, 0.38807661409763905, 0.3175167933843852, 1.4778159121407446, 1.4598632942013234, 1.3143715483792224, 0.6397345740305506, 0.35118123057100703, -0.679601677131819, -0.035875499339907024, -0.4089612739786497, 1.2272017361812526, 0.16416782122489024, 1.4459573163487245, 1.5930372961934922, 1.0624395691143684, 1.1988507048530856, 1.7090056625620265, 0.23049196049919785, 1.230951089151182, 1.2190755551648735, 0.9153194418713809, -0.8764116999281659, 1.517573542722878, -0.14944111309663297, -0.34443011797358647, -0.14939633302341498, 1.501014204525874, 1.8588373202567359, 0.7871855482806773, -0.7384005545686367, 1.2896763390736292, 0.1387611126230895, -2.1995699865161145, -1.1126470544013223, -0.21771115286626389, -1.8111975834038523, -2.1342733012573447, 0.8760735769583485, 1.55168618784055, -1.409093295228571, 1.2450314690206357, -2.625422598977858, -1.2030481111336553, -1.300217423512607, -2.492082882705448, -1.8222769029690227, -0.8843553452397793, 2.439113526803048, 0.5117002548043785, -0.9179532198316753, -0.1269804657516363, 0.06292604306863647, 0.4358775056550294, 0.3187321028062172, 0.9319464560795224, 0.08801761695133065, 0.27963196961931447},
    {0.35216136411716803, -1.133653411337231, 1.3361885229195851, 0.6652520172956533, 0.8974079155682325, -0.7357929864909954, 0.2705520118247352, 0.086881623015879, 1.3321452295815925, 0.6545987267708088, 0.8898666796095505, -0.16143964780966072, -0.14910324857166923, 1.1675311980364669, -1.1386225421913816, -1.1765794990997378, 0.09924775365245829, -0.22630203908282895, -0.727923348256606, 1.4616764327759773, 0.9530895287084604, 0.21714399454027708, 0.7163885150061373, 0.11321373039387844, -1.7066504937336202, -0.7481146791638817, 1.6639597140335036, -1.035992724800054, -0.3950535589371403, -0.5079639581870404, -1.615261343864431, -1.372911990938363, -0.8175959002704071, -0.6807960403124316, 0.4018468261952296, 1.244334229276835, -0.1155648392714146, -1.1266039198156221, 0.46741824408556554, -0.06229975815977381, -1.7370335313926621, 1.5171628640494346, 0.10313236897010229, -0.6311931173636953, -0.21289322558611612, 0.7303767435107869, 2.0917610920599516, 0.7534017536427295, -0.4712891441951768, -2.40203346664408, -0.3259931983853017, -2.1698681522114245, 0.38851779451701146, -0.640516686282414, -0.28733092461792525, -1.7076630743180616, -1.4861647768208084, 0.1296566115096419, 0.6265815417708124, 1.0450855392611247, 0.005888875638786479, 0.2553742345047237, -0.6095387032406018, -0.1046334400003761},
    {0.08393631151545512, 1.5457933008468623, 0.6661400649663093, 0.5739007497757267, 0.7069360432663818, -2.138616891844797, -0.10692207109073054, -1.5854860689096684, -0.06831201397367534, 2.221905890084875, 0.8591952780366567, 0.49945295913404913, 0.05000589104650842, 1.6873065509195826, 0.7468048156435052, 1.0223600290328012, -1.3141498638608768, -0.3966586170515085, -0.1357494752763833, -0.45355558169457993, -0.6288311532622227, 2.3985823657528647, 0.738095352671254, -0.4148351817847316, -0.40438934449018993, -0.2887960040344846, 1.6166686787125022, 0.5553096551135503, -1.3570485623659208, -2.5340481512674855, -0.6211177927223559, -0.4467029483176795, 3.012959221953611, 1.7593318755550669, -0.07890153935763236, -0.8609176901615457, 0.49972573073624793, -0.12210599707165073, -1.645606287136786, 1.2558366820484632, 0.9574590855912557, 1.6585246600793915, -0.5599131027164853, -0.09184817803959007, 0.31242478832551984, -0.8228493092296841, -0.08907905863855044, 2.176563130287302, 1.0503067044374839, -1.8058817267589011, 0.8152056107713576, -0.03564948182594866, -0.6623375635140093, 0.7692091266361644, 0.9175037631973855, -0.46663031671028554, -1.0680003954667052, 0.873952713722028, -0.5306762072100834, 2.1177377639906747, 0.21070561689021775, 0.1132272283886051, 0.45880226906457366, -0.7977641507393392},
    {-0.8646913045122213, -1.0957890773915666, -0.15009950313925638, 0.6308859843629772, -1.0814447262532154, -1.7667515778259921, 0.8588640388170279, 1.0317964984372368, -2.9041881476914333, -0.6259806741451024, 1.0920709232720318, -0.5333072545951987, -0.09234372812669578, -1.2687822030130216, 1.3387328640045342, 0.5715649033530624, 0.44101194024060647, -1.2579475588565172, -0.047910765109437294, -1.455509220099696, 1.967715751360056, 1.098931891030397, 1.0184261791499187, 1.0398187641094125, 0.8797248679185397, 0.4824996803163648, 0.7100166026296086, -0.6681636891158645, 1.3042883679919142, 0.8019859646693573, -1.7386934252549218, -0.8079979234953167, 1.2475554357027485, -0.16978594262217925, -0.6430462978503568, 0.3915847177915624, -0.0745682837998316, 0.8392248840157513, -0.3729645888211267, 0.5942185066830293, -1.0906969649693385, 1.4072081306488777, -1.473535570510987, 1.3551030659846561, -0.06431288329276177, -0.5600069641984265, 0.5463633852313765, 1.9579761744156818, 0.08252074088502358, 0.9179044409603621, 3.1916280096463296, -1.196067573538733, -0.197722552692358, -0.8951810966089756, -0.6108491577607483, -0.25986049030408115, -0.8145418945320738, -0.5501958540525019, 0.1253887165484324, 0.9579715708246596, -0.4069009787843574, -1.5979533431469168, 1.4329071541343803, 0.9167521549241998},
    {-0.9421593681111735, 0.3945580644042766, -2.023866582779131, 1.4328846831830668, 0.9107656320951163, -0.8125669469376309, -0.8290066749348665, 0.8002832899017585, -0.8285884179246217, -0.02969929844749118, 0.1682983648464904, -1.8624911037105296, 0.017713094438357387, 0.8159954803076013, 0.5862890264609045, 1.1525682084604134, -0.0717579329160744, 2.327934519100531, 0.25194494262655626, 1.9499812359276998, 1.4344971146287866, 0.18448249384023035, 1.5153694700465488, -1.2783403466388348, 1.855136655182393, -0.06840419707229509, 0.10959571379434188, 0.4135187595095505, -0.2766829781840797, 0.18580184429287075, -1.084758706308207, 0.4892777587759842, 0.7072451704884932, 1.5906704800779314, -0.04063770048665207, 0.03858436493457754, 0.7460833195822051, 0.7250452656442838, -1.0606291028909978, -0.982889353082895, -1.2003396533798916, -0.6306521679491384, -0.4567343915414777, -0.0715641000205976, -0.4899070953153361, 0.6320566304107796, 1.434583670667699, 1.3924614226422198, 1.4048424434793874, -0.2731064864236812, -0.12409688635105234, -1.1624972865856478, -0.820854885226012, 1.7455610998596227, 0.37330692795670517, -0.698887427212541, 0.5617395649147796, 0.5337182128045752, -2.0055528523305983, 2.5419796941341186, -0.36000100454086503, 0.44807121107711934, 0.09547976901615662, -1.9822854406807031},
    {0.47053217494617183, 2.3892582662292896, -1.9072281114623686, -0.5944544598042484, -0.6716013810755859, -3.363032858137225, 1.290731487330355, 0.0750319455087757, 1.2753021351719587, -0.06456614924294887, -0.1953226249846103, 1.3741285414330355, -0.08597108586530633, -0.026666884801671443, -0.5134849553735363, 0.2541200121702933, -1.0434882938299221, -1.6960266612379544, 0.4255940522039906, -1.1548637864101297, 0.9646556014442695, 0.1730539972750354, 1.300488098914293, 0.23673239511103938, -0.581392053035558, 0.08611444252399576, 0.4507358234323123, 1.5014994707868556, 0.29068896078777623, -1.5197070806718167, -1.9870955596974944, -1.3018625785658067, -0.4009206599669438, 0.8617151240207974, 0.4885219451551546, 0.6616213561697247, 0.41045556106374814, 0.2601090335650202, -1.2896564566613702, -1.1679779620472583, -0.9859145250435536, -2.0275661030047814, -1.2596879380245956, 2.043389450385323, 0.8141400768668765, -1.0090808905457713, -0.6673204242746409, -0.8521707533478748, 0.4865613513241776, -0.9611966898322115, -1.602597773254494, -0.284941252658336, -2.2320171301224287, -0.16659095158328868, 0.2859756367600475, -3.1690553466376357, -0.7557698549207833, -1.9148957143827188, -0.880643146127882, 0.8493460107029749, 0.6314953078207032, 0.9995572348071015, 0.4337966453153618, -0.30364687898357734},
    {-0.43135330091028196, 2.796178832902449, -1.3057568336011216, 2.8772505197795737, 1.3308683642566286, -1.1885303169407075, 1.5505988963024329, -1.708916723755276, 0.279240498998211, -0.9964412505093925, 0.9946034972711394, 0.3540658301638441, -0.003286219715256305, -1.1392288384987173, -1.1360501083702745, -0.30744599607268386, -0.5653112590028576, 0.2584232601308006, -1.516225891790828, 0.17048442190830274, -0.5460555094865254, -1.8403363084158741, 0.10424765284230994, 1.4126185040271269, 0.016766775610395357, -0.028738724283071396, -1.5239186823596105, 0.366104766650351, -0.8122712771219701, -0.07670638796435263, 1.8160063030454623, 0.05683238758687047, 0.5631759598236743, 0.7021422688495974, -0.6830294041534908, 0.08948389136529698, 0.6668230861150767, -0.30721173495680754, -0.6326535604199447, -1.0683918179928527, -1.3402321252538867, 0.15392428465786834, -1.628178950109226, -0.17473125249464658, 0.27379859718738747, 0.7348846988285368, 1.0180246449792383, 0.936623490803331, -0.541009260204995, 0.5351702880362861, 1.716403497043663, 1.5859855546940942, -1.3241589288761269, 1.3005275421633071, 0.05406835088491409, -0.4837070336602386, -1.4513129714504225, -2.3020861868024034, -0.17758653864993706, -0.5726102275567955, -0.07126237422812229, -2.103684961068198, 0.8525618384132622, -1.458750228653606},
    {-0.45109171465980663, 0.4007340086088715, -1.1836489852167034, -0.35725833786193856, 0.6157095723889316, 0.26539153937814525, 0.9344316922103084, -0.8506215367992922, 0.6434024654588663, -0.9399823641723151, 1.2340468619301854, 0.2349485269750893, 0.6700416513574574, 0.22975225512770517, -0.824009434307457, 0.8513837600480372, -0.20019902475031065, 0.7058281203172191, 1.4925591012389352, 0.53585773619321, 1.3958546491272308, 0.12676787884563864, 1.7796670624701239, 0.2386133249510893, -0.5368328104876263, 0.633139367848268, 2.18755631254614, -0.4921653534340891, -2.266875480534095, 1.3749768204894048, 0.8308422901264378, 0.1578152646750073, -1.771022129733556, 1.1504010504669402, -1.6127837865893773, 1.6353509304462361, 0.6063560075774974, 0.9246817906676618, 0.6539215588081588, -1.9440277210839378, -0.32792566239521326, 0.8284032030821554, 0.08411389334679886, -1.3889382937083572, -1.7030336845410923, 0.5255218930163663, 2.043237646545406, 0.07174335410734621, -0.9513761653459941, 0.2721711601584289, -1.8623079609544684, -0.57203862825096, -1.247702912969058, -0.9685204713610833, 0.4928832957942811, 0.4940495602855588, 0.07163453482537913, -0.3270999108318631, 0.5593482593160959, 0.7020757748188665, -2.3340552650094373, 0.030324353554878298, 1.3116660603065007, -2.5555786427460796},
    {-0.9554217849099556, -1.5869478563930808, -0.08338690246263437, -0.7981875331270419, -1.1651907248581574, -1.1565806678417512, -0.34106833817378207, 0.3475740681417053, -0.21234090983955076, -0.6287456688654597, -1.5223791529904542, 2.2090351018506227, -1.3991778557425116, -0.46902442735684713, -0.6670663789841689, 0.031255394476122654, -0.4277967534376316, -0.031883191922233496, -0.8636868828091436, 1.5493157648600386, 0.2917508814493956, 0.8930811747498804, -1.889085181465251, 0.35900998831230957, 0.5708973974955149, 1.136172295958483, 0.778161419531598, -1.165126963424661, 0.7311161268950279, -1.2537204359407668, -0.9904687537914862, 1.0193726095584275, 1.0382685976449892, 1.5466782482056163, 3.104947314433323, -0.4223867573947349, 0.7711842131938499, 0.4044766901602778, -0.8739255383869161, -0.999581435280443, -2.180617343526289, -0.6829665594439417, -0.31622238117023127, -1.018813439608535, 1.6599076932644803, 1.4230781758464528, 0.49079725734315044, 2.1450149485312484, -0.02426660308988809, -0.3524329062098432, -0.881802010527304, -0.6186148018517765, 2.7529108657624497, -0.09274021003170585, -1.2381714499858612, -1.4567711860249468, 1.0568372126685375, 0.02254832742445514, 0.6917042269637351, -0.1314482609521607, 0.6773355711589056, -0.5947619574719645, 1.3067286394666773, 0.6105426757637803},
    {-0.21072464633505236, 0.8181665173001486, -1.593120721258807, 2.5098547048200817, 0.8024700390850581, 0.08370998851596845, 0.46833946373357793, 0.03463489991095795, -1.2653507449996269, 0.10807180076125913, -0.41533521931930256, -0.07540817610731443, -1.3692918985991431, -2.2285869256031123, -1.2462531596944053, -0.5240488090839306, 0.15469883854293007, -0.6116546028161874, -1.3425651370819738, -0.7028695033640399, 0.817929934987488, 2.248443876225118, -0.964970956334614, 0.4386269086947428, -1.3787631657136887, 0.6327312221412785, 0.9099581019359892, 1.5848297194739922, -0.7127602004954633, 0.8139135625622981, 0.04696978561434876, 0.06249406358806543, 0.7337284525026899, -1.963324237348858, 0.17095512984677555, 0.3923028175461066, 0.3829409671243452, 0.32927846697070695, 0.7479390568390392, 1.3384536343283313, -0.1613929382845806, -0.40309096502065983, -0.29684788111762156, -0.2908705431324855, -0.1479647078105299, 0.6553630024224776, 0.3782641106967897, -0.44663433152611515, -0.7651767386557591, 0.4272609626827961, -0.18027814618598487, -1.9550837014706979, 0.35375501092206735, -0.6036932167781075, 0.19378648235162288, -0.6150614013597309, 0.7730838954320669, 1.5623829566517664, -1.6152286318462, 1.6504247186971097, -2.250426012662358, -0.3569418746980321, 0.8598654001389252, -3.2814598744474663},
    {-1.5359748293909272, 0.6452665688966475, 0.33036631643978526, 2.7313484157988257, 1.576042227082538, 0.42612236077969534, -0.856950029455507, -0.7903562715926337, 1.1093556995796214, -0.18341904673150888, -1.8993305575154547, 0.2068276304410881, -0.4868615609474338, -0.39550419321878433, -1.0484049512427094, 0.37426690348521435, 1.1192852235288082, 0.7815453147647831, -0.16823810399672415, 2.3929683269548, 0.06619311899813951, 0.7500467884420992, 0.7787776818452841, 1.1016194606035017, 0.6626036845232793, 2.242163115745906, 0.8590855378374812, 1.115199429603335, -1.3245024330257607, 0.18469295502217378, 0.9610244924282956, -0.22315978420965646, 0.42037724931902215, 1.174741081245623, 1.2796756278825043, -1.5989262144407113, 0.7940893748232202, 0.14530447151599643, -0.6442854768469577, 1.5323565405646626, -0.8613121309376, 1.3673125333407248, -0.3730767603631379, 0.1861758253052304, 0.8281672017782815, 1.4663284859734282, 1.9122754079732855, 0.35672289058623297, -0.38838082646485844, -0.7647615568711306, 1.1308137778912783, 0.25202720491906083, 0.6771368084386806, 1.4820322103325023, 0.8972349925774995, -0.41782936927693215, -2.2818962157334877, -0.1707081001442427, -1.0516863278870288, 2.25090150453697, -0.6359203200404581, -1.2132068589349525, -0.8744163436740771, -1.0321032320575718},
    {-1.211847888907013, 1.8956229557781794, -0.09783501098802715, -0.7327474729639268, -1.551684109204366, 1.4599616812186837, -0.9812796011641125, 0.24004876655469015, -1.698915368644889, 0.19072250604626623, -0.6225608027053646, -0.4038332379961983, -0.8375252881009938, -0.6648151244786329, -1.3717564083540668, 0.6059583746905647, -1.1263593305056898, 0.9061643761722046, 0.5551255389933138, -0.18721469923550998, 0.5727152140391556, 0.5451513961327964, 2.4889253946561456, -1.0539193808108964, -1.362729268128973, 0.39901033575227246, -0.6982023381660083, 0.5820672046179023, -3.2845137177316093, -1.7276996025638909, -2.6873375205344074, -0.14337303059328002, -0.1932666167111966, 0.13129252200039696, 1.2134571476118414, -0.1598877822883168, 0.7755410148750734, -0.7939653971571314, -2.051369604165796, 0.02233790182716269, -0.9652179075939942, 1.1614746685021826, -0.9159595241461909, -0.049420726780733115, 0.6899953559828857, -0.23604371924271958, -0.20819592552822364, -0.3272443952919702, -2.24535048272272, -1.5019445668489093, -1.3082996513214313, 0.22864897065761233, 0.16477217142754833, -2.3510127519429584, -1.3469733531740085, 0.337328366025806, -1.9059486465378213, -0.20803585571460814, -2.198795615254403, 2.249765921739656, 0.3488204012462063, 1.8567562117705938, -0.5468621600237227, -2.4285958519256488},
    {-2.8552085061511274, 0.4075400116488642, -0.3652514634582881, 0.28717486343811066, -1.4089818272005052, 1.3557445496145326, -0.1137621321485398, -0.2814383090158748, -0.8744736202213271, 0.030346158870516535, -0.11662219685240093, 0.6299136521401275, -2.383530766195406, -0.7993589636809212, 0.7758102512443866, -0.14670552189663272, 0.12011481563937478, -0.7703043325398801, 1.2188766766049923, 1.6746339641994838, 1.0111284315202769, 0.14402134583810516, 0.9133145969466977, -1.1372083576955863, -1.8747597867144832, 0.005530372996637391, -0.5584615073687194, 1.0033866009933667, -2.192987834688557, 0.18626120503879337, -0.6553556484012142, 0.20230837049974473, -0.724827447156025, 0.5946958643515661, -0.2974933137872492, 0.1890299456107856, 0.10590232627424101, -1.3636191761445464, 0.9751855994216422, -0.05246714811514799, 0.6504615175010777, -0.435187617540105, 1.7872171251875857, 0.30958477493535747, -0.4688629231004099, -1.5570803662527406, 1.681487659978817, 3.3120454169221882, 0.7495159706441213, -0.7630691891015701, -2.9504872579617167, -1.5927963518990833, -0.43113468024146806, 1.5282457825234264, 0.3110249574720519, 1.1789069230882696, 0.8342705557600416, 1.6796861181319571, 0.7488790140477912, 0.2142045372560993, -1.78599387475436, 0.3457190439307242, 0.4459875398164859, -0.49759605006992547},
    {-1.2909634607362976, 0.3221284926035966, -0.10130584821087997, -1.8596946545871613, -0.8183682786137779, -0.02874860114072534, -0.41389727246551894, -2.0861578079217207, -1.91964766977964, -0.6871978374979361, -1.4649179997099917, 0.6129039934410989, -1.9528858290944302, -1.6595898343308635, 0.957672682606526, 1.9125184228187126, 0.33002297925241714, -1.2388130949273821, 0.1560332988392244, 0.4508739591062454, 0.25667211248460736, 0.8507466120744296, 1.5362796970780253, -0.26858002635446343, -1.7043460541226798, 1.1926275932450452, 1.0186592755716175, -0.6267130607705652, 0.8651790560470931, -0.8375882751608666, -0.7385805081099772, -0.3362642549016394, -0.9181141564584515, 1.0696261036433954, 0.60805327273007, 0.32501789424736743, 1.5802240514003176, 0.9169899844008038, -0.22553395735488027, 0.27724704427440783, 0.5662183362391876, 1.863234626756999, 0.41795211046339736, -0.8538010692304309, -0.7702622717862743, 2.1319877004089385, 1.276982162071799, 1.0451824575623514, -0.7548285255489172, -0.1748684937060482, -0.6004147436331017, -0.5676015170642862, -1.7848163897603178, -1.6367125523304102, 1.5346286694508298, -0.4107527002591437, -1.305843188017516, 1.513753137018027, 1.3517060972649753, 0.5117829536461385, -0.9731862642008322, 0.26568407038798797, -1.3535226938077045, -1.3763077952514404},
    {-1.0577621054267856, 0.6059188678167408, 1.5054345423990732, 0.46016703250396374, -1.1107512990399337, 1.3394089791027328, 0.05071669300834243, 1.4034937511965684, -1.9663327128689898, 1.0221394259705694, 2.7793836131816216, 0.7914857958374799, 0.276155682361441, -1.1803767442482895, -0.9116492955124434, -1.6692304847566641, -1.4405373334816525, 0.33337094193785854, 1.0662778311271721, 2.8033501912313548, 1.232442859409456, 2.2087248286683776, 0.0342373117610112, 0.01881041204252202, 0.27155645263699446, -0.6309005813457976, 0.8800243188074902, -0.9465429427399983, 0.4524817984264902, 0.5104108307718731, 0.3364096036337732, 0.14249033661690408, 0.9338212644917674, 2.4447455637258755, 0.04174526653469368, 1.5498388369172567, 0.8658167193025055, 0.0813843576619616, -0.04673529286705367, -0.006203105274437609, -1.2387191487267302, 0.48934998264505486, -0.6717263473808166, 0.9282956173553318, 0.08939098927910286, 1.964142465563573, 1.196454558253003, 2.3927702013125005, -2.0500091726881378, -0.16019617851377743, 0.5877082832721826, -0.23259715619203056, -0.9119446617182786, -0.5968027141619452, -0.9094634279086028, 0.057391573765061835, -0.11369037711628191, 0.8636462596357055, -0.7640577483462757, 1.2549138757745983, -0.4445522811029133, 0.6212496976572078, 0.6355776910930511, -0.8259506545104304},
    {-0.9882187314814603, 0.9892762296542007, -0.598878477794147, 2.037232979303366, -0.6230637077971066, -1.6396152767371985, 0.5202145529632894, 1.0692584142650043, -0.9850074423744067, 0.7903469195558109, 1.0187129242349446, 0.8188888007443876, 0.7608359703467981, -0.09781536070188288, -1.3304926125874723, -0.9590823053929779, -0.7830501294015548, -1.2346449840879699, -0.08209860046454917, -0.8353402886377551, 0.5840978646679118, 1.0142819710868967, -0.7862123272041928, 2.2396458128511414, 0.7755765881693163, 1.4835354690496905, 0.9662457955862718, 1.962124151551591, 0.3606548670930374, 2.4301571482660567, 0.5962437923500187, -0.22258282996282333, 0.5197430282163987, 0.03770735815516882, -0.22503791880783797, -1.779135837831664, 0.10159508956864148, -2.518756062361607, -0.7500823268300609, 1.8172789823020206, -0.1492904861963456, 0.6246596267116776, -0.35191289814749277, -0.292180961192324, 0.36874198946583076, -0.005451158713435686, 1.6003923164914855, 0.7523556779230338, -0.4316910327056565, -0.22260787022091827, -1.8419222713619272, -1.1534843954065523, -0.5182139921463359, -1.1264617277819162, -0.2119433724974151, -0.2949872466301673, 0.5489162915178548, 1.1173256755220806, -0.3326401129177561, 1.4319671788918538, -2.155364490532969, -0.6341839394725103, -0.38793796755950727, -1.0158648799138852},
    {0.702335918223992, -0.28481610907369653, -1.6781509495160583, 0.26177781090929175, 0.3652499371807628, -1.0102255435020828, 0.4159159707962962, 1.0013087273923142, 0.9331308807027067, -2.0287631985751404, -0.32076966304779236, 1.0568621255870219, 1.0523222590611763, -0.015749310816340675, -0.21466306355954726, 0.8750765790580453, -1.6208059140203581, -0.5880153306238488, -0.6983967966517967, -0.39934899812015406, 0.018097089304890086, 1.2391757158594543, -0.9931941293652021, -1.2878983701601403, 1.460439809081032, -3.322707792710972, -1.1517984633973948, -0.44399221078403933, -0.8198029391415605, 1.2710421885634386, -0.36244614267629455, 0.874700148389404, -0.7820340447081261, -1.6178910934239783, 0.5007505075875532, -1.0919636876843133, -0.37944444496386204, -1.8778887282755954, 2.148710784654298, 0.08508736119416999, 3.009894299239033, -0.30487801646102936, 0.4245384357251096, -1.553907784187707, -2.356437156453882, 1.157477133340497, 0.20354654881336803, 2.2106906472665386, -0.3129746113340241, 0.8692344399168883, 0.811424671822756, 2.092661037730255, -0.12442705566700707, -0.5923411031729677, 1.6753404633667142, 0.6571210369583576, -0.09933917710260254, -1.4169422827081077, -3.5204207252959447, 0.04083327190709556, 0.4904514461366785, 0.17784757861294803, -0.03893290281328749, -0.15343264029879042},
    {-1.9288113008878296, -0.1254958436079064, 0.13643219870161616, 0.4835528485213846, -0.23492574625769233, -0.13144518879584793, -0.42142987648590846, -0.09146353610521168, -1.4458590738577692, 1.2537452927436192, -0.9911872149063113, -0.07474791871027096, -1.8303394889746467, 1.6064168830181118, 1.1737511966094842, -0.4211224117494244, 0.7206699809749622, 0.678211054652164, 0.3294995256863426, 0.7602290275199717, 0.9396414392115451, 0.36277650285280155, -0.13859967728644504, 0.48050971919310775, -0.2824998923395097, 0.22237977411285126, 0.3933831876548194, 1.4652469120011242, 0.6028869407627551, -0.5632161487277403, -0.026918305060900146, 0.33409294427160346, 0.7088512128519533, -0.4033123230543097, 0.5239543976722423, -0.5119124429930214, 0.5042052345957073, -1.0283928514727856, -2.139452567692214, 1.5271738171242986, 1.8900539438813366, -1.2621433493635321, -0.7882937351287974, 0.20073214192885683, 0.43413678757375324, 0.5064619425022056, 0.09498921656723049, -0.15655076446056107, -0.08580210799538546, -0.04927822872703732, 0.8164582946978504, 1.0878872359869294, 0.08011385317361176, 0.2960842817058187, 0.5773983718986034, 0.8331188975718516, 2.2877401090450418, 0.3643712933701208, 1.2235167595944305, 1.0609691335708489, -0.7734340896379086, -0.4653873088058769, 1.8825603394800414, 1.2946395386183902},
    {1.0296181766635235, -0.8132263273028422, -0.06227768742988467, -0.10259615736793674, -1.585213253323464, -0.8889106329773041, 0.2559913720954258, 1.076043905120544, -1.871376976741249, -0.9976049871072409, -0.8823407577204533, 1.1169720943864856, 0.8452530578560609, 1.987016598862225, -0.0839506382704404, -1.7347185037214643, 0.651832136324487, 0.06558138369674492, -0.4240232184679371, -0.08559406955784668, 0.3373340298783612, 0.456581752422388, -3.3715823260788294, -0.8336939334472784, 1.5483976015383922, -0.7870614393773084, 0.368111997330381, -0.1813263759566806, -0.9246199345093302, 1.3683324412322029, 0.0030618312251147724, -1.5264401326133297, -1.2982371531979267, -2.0516238026291616, 0.8265883310397907, 0.20104148235837763, 1.9963352873978804, -0.9198168021676518, -0.32267329500175324, 0.9225749793461838, -1.2101623420800132, -0.9022716961563768, -0.05719771521368667, 1.3545879951035384, 0.8100034094676345, -1.3423724176416905, -1.574682664877916, 1.3191831175698858, -0.9775555106864838, 0.39393165280972464, 0.9391665116294254, 2.546085980331018, 0.3820768856559958, -0.5436517983455544, 1.8226869622461352, 0.011624008818981298, 0.5324864335136719, 1.0073215946635443, -1.0339926511959516, -0.7183156382391139, -0.22508324790395923, -2.791365059388664, 1.4320326484246781, -2.278266410050516},
    {-1.9343843574295179, -0.12437650253057057, -0.9281029135962102, -0.08798418803629231, -0.9976407831950548, 0.959957932200738, 0.07825831494615343, 0.06060077776177727, 0.6543340658484365, 1.2424848810350755, -0.9840558175219858, 1.3700225320188784, -1.615391953233959, 1.7693847387226729, -0.8871273567900355, -1.6182228945967196, -2.2709304705843225, -0.9978338854568841, -2.011454863552572, -0.489899216067643, 0.8332909312696506, -0.7473568620704785, -0.13516516649131566, 0.7450086936846773, 0.2030995790352517, 0.519468353499094, 0.9977270700400681, 1.8745041336492743, -0.04538933629482754, 0.20863421654540518, -0.9417150871538896, -0.707253563935347, -0.9763900866048622, -0.6323355963618664, -0.45460662732069373, -1.0809087155220367, 0.6442597174089486, 1.8143065698813052, -0.43984698045096193, -0.6876372866294785, 0.6486084785471791, -0.6655022163137593, -0.06714003409026563, -0.35550932198597013, 1.8122470253960687, 1.0472397865049734, 0.07568055417136257, -1.0875116676378078, -0.14997001099120022, -0.018948440246041302, -2.8186905061555554, -0.052483876451637476, -0.36611272450336113, 0.08179722021688143, 0.10301052415370068, -0.07573306435547435, -0.6014811126820031, -0.753734505682698, 0.9637081975483607, -1.108903964595732, 1.6303686404363964, 1.348969148388693, 0.36880478587454324, 0.4374085988483604},
    {-0.3103798028554996, -0.08226005960894485, -0.025380883694191697, 0.8624958254115213, -0.35202671368838623, 0.15437517182892563, -0.42133214771245836, 1.2832051686228338, -1.8505766921657762, -0.9582880278257797, -0.24039313509878169, -1.245942829931467, -1.3089412577998325, -0.8175440681574861, -2.8041924494750017, -1.027854076802639, -0.8625162289008503, -0.5646228708402881, 2.847778003650393, -0.20634778041185667, -1.873251912916973, -0.4593858390025344, -0.3590931124654616, -0.023215736025772093, -1.3062303388496317, 0.931597243653102, -0.5858176246635809, -0.3025808311421015, -0.6347667141238723, -0.8515184783725817, -2.3819434533714103, -0.9043062704714423, 0.45956499164677567, 0.5597250913916603, 0.5352569777962483, -1.1978171998721314, -1.784310197567417, 1.701400691987281, -1.4366281834533845, 0.9145899767747648, -1.1197296377264339, -0.374043071660526, -1.5979335426802108, -1.0000791375142912, -1.0387830242023524, -0.23857966453560892, 1.635652009452195, 0.39022343859317987, 0.8593752831602833, 1.1788724008852893, 0.11267087939630374, 0.12116667265089216, -0.47729783105942986, 0.2733778266486278, -0.7785159476364323, 1.6638509261686916, -1.390867341230309, 1.2456228061649441, 0.5662339068822286, 0.2898442218002014, 0.6319261769079736, -1.2091693153640295, 2.4023075238431115, -1.049473001222315},
    {-0.2151410741450145, -1.8826778566121511, -0.2725224108009029, 0.30053058658808246, 1.4166949442801418, 0.6859816150095736, -0.4607064091100493, 0.7685804736729713, 0.154161564239529, 0.3728002540033483, -1.7736637576320233, -1.085359594997496, -0.34903877075157197, -0.5939408031247619, 1.487222848062514, -0.04659272563198861, -0.6974603841814359, -1.1356229233410453, -0.006717070234668151, -1.0904204943996312, 1.4140112205811752, -1.6150635415657846, 2.04236339550401, -2.127055258514215, 0.19177984251530944, 0.5895288791878938, -1.1138985296453334, 0.2740600743357936, -0.7499464234530243, 1.2292064457250724, 1.7061841284523598, -0.8284837068656941, 0.7956237359890844, 0.39931719225938866, 0.556913269283369, -1.6856076660574828, 0.6232949817229493, -0.5274437786047875, -2.3381612923278716, -0.07235953939345473, 1.527582070690373, -0.4869681456231417, -1.1193647538582954, 0.956997517296079, -0.23005718480358298, 0.5877017857939562, -1.2821159398406485, -0.3221314178426658, 1.248162063112078, -0.12638826891524438, -1.2658454707993863, 0.40300173435730063, -0.19594411916167048, 0.894778879898915, -0.24655149260618459, -0.10664318834641108, -0.11340538641350459, -0.37411836276096583, 1.5547611409918372, -0.7005938982971456, -0.9959237596606544, -0.9786390052106763, -1.3887374086873376, -0.277009693052384},
    {1.2841294426974819, -1.2054828606564734, 0.6669777697895966, -1.4536439225522992, -1.5142003238797506, -0.27658863948050283, 0.058409233507308485, -0.55984446439271, 0.3801765773362625, -1.7470150372537088, -1.6066385010643227, -1.3910977095962271, -0.9833739912016615, -1.0785003543367546, 1.9656574576402932, -1.6940238083423935, -1.9494613611260216, 1.1561985427058412, -1.4089336786739908, -3.3146790019601857, -0.04696660289123933, 0.373280850370635, -1.7249799025558217, -0.8703921052918862, 1.0400322939268556, 0.8156647891851946, 0.42821549845241985, 0.7783054833606196, -0.98864992241453, 1.724429019118805, -0.4527716060398016, -0.1268337330303991, -3.0004996381342126, -0.2658525701499797, 0.5519988999418101, 0.10850823358308856, -1.0118275547161466, 0.9917020045730274, -0.3046774073145151, -0.7881435463717508, -0.8510905900288128, 0.34838614000301377, 0.4000569607596153, 1.5004848224355487, -0.9115523537205382, -0.3412099360565005, -1.2982603384555071, 0.6303112037311858, 0.1864280964175347, 0.0978164653378572, 2.3130488470888038, 0.25916101478803727, -0.1767982958731538, 2.3274956443364836, -0.04932245077112441, -1.0698734938530818, -0.41562715659714194, 2.4040857346633593, -0.7313317551833881, -1.117447302286092, -0.636128760773813, 1.19961248744052, -0.1313773855926237, -0.6804598385146475},
    {2.1965789234314648, -0.933744754977956, -0.019398432663385298, -1.061209272642733, 0.5273361388875468, 0.6407414628653213, 0.5836309476914476, 2.312975843192955, 0.7828248097618307, 0.0623818920519762, 0.5859177087823308, -2.0685051616124843, 0.8251357796646217, 0.6503758773272205, 0.32638170257398313, -1.7286275616186884, -1.3322083390702781, -1.4455062309753903, -1.096277790107467, 0.13912541898680716, -0.022129601203491975, 1.338947876343246, 0.1133653981320191, -1.2256074132924208, 0.006787488305756467, 1.6717383372624135, -0.9987787863916441, -0.9360281800266114, -1.1770656474398211, 1.3168712688980087, -0.6581098609140539, -0.4211259291473061, -1.2781069529254834, 1.4498992354784108, -0.9128175027534847, -1.66261916365846, -0.91862574347738, 0.7186451420159349, -0.3999825848045772, 0.2692384339667033, 0.09921423232840978, 1.5624396813779864, -0.03601939384119389, -2.8868522790402706, -1.6997956481117515, 0.2997743588103468, -2.780117248359115, -1.2914487800379024, -0.12384513937368129, 0.8566376892107475, -1.2657553671788946, 0.6848881551229566, -0.057024917638982875, -2.0518416692939794, 0.5303828068749395, -2.298552783900248, -0.3850230001310679, -1.1191506520981722, -0.02604561200868575, -0.3617123554562633, 0.069298509795918, 0.3979399465223556, 1.0659691477486228, -2.5042641316478376},
    {0.3948039275088966, -0.2826735644005302, -1.064639837811776, 1.7643444638674215, 1.2150776085457542, 0.25939329364542585, 0.39956450039810226, 1.4734805001634508, 0.03634377351944554, -0.25198824666215563, -0.2985280036332371, 0.9475672330831321, -0.3543343779700017, -0.9420976530379709, -0.9640221607140419, 0.20145274148808934, 1.2515871853683662, -1.3542476081498582, -2.6842482945079604, 0.39647899329957326, -2.163036752947147, -0.19490685180647677, -1.3580620416016156, 0.10528065255570283, 0.6886350837861346, 0.40910384495239244, 0.3021549401908183, 0.30281434958361664, -1.7219953177478082, -1.7406877820945132, -0.4763387708419028, -0.8003186881888742, -2.449068934662945, -0.212004102222141, 1.0988588200677232, -1.2887838970885006, -1.504976103039885, 1.152969120601187, 0.9686425635795841, -0.33714323540750774, 0.2701788059646647, -1.76156616076774, 0.04185011991897465, -1.0753985357170943, -0.0941215068034825, 0.40699314531434205, -1.0646880718445813, -0.267832136588507, -0.8296316252520857, -0.6281963489075997, -1.0064480083983847, -0.4202824913867013, 1.4329703910825755, -0.19331581969552486, 0.507034380519221, 0.11177485395273731, -0.09219745145174257, -1.3244646194524488, -2.97248105821942, -0.8401833767544415, -0.36272098979366474, -0.45616759753498387, -0.8098271881465482, 1.380156427925388},
    {-1.8032320148948973, 0.5224855205765556, -0.7384735279769478, -0.7365748065842042, -0.3886433138532763, -0.6483457974038115, -1.9255294507757632, -1.963535116551175, 1.4661546320314607, -0.7956452664943586, -2.500812736031158, -0.09911511610409499, 0.6666270256388545, -0.8878521351131375, 0.23570228846012467, -0.6928985530019002, -0.21175606293601087, -0.44750287968554314, -0.9451262780921935, -0.8138585602226586, -0.6533730448244743, -0.32338268500167777, -1.8832192851014498, 0.2411344214343845, 0.04001461209769437, 0.2682623792222706, -0.014861457814824074, 0.6622481647857897, -1.07435029852615, 0.1661548156770386, -0.9478589660705506, 1.5893016077271578, -2.5617424431246745, 2.0539926156223682, 0.9978328846111161, -0.9050669760398575, 0.8834995820336158, -0.4316487733582819, -0.9681504115946858, 0.5287976277242993, 1.3304823012649858, -2.8294634502916747, -0.9156325465925204, -0.9106744017915075, -1.42702935570296, -1.263713539461256, -2.3769763889297395, -2.690825128558318, -0.2594538859289487, 0.7120894408411812, -1.5339180014147937, -0.7880744877586576, 0.554630506988848, 1.8231618537897016, 0.37351664455787265, 0.04123972534760473, 0.9090027609598889, -0.12936881112415186, -0.7615960624048053, -1.7980657412170038, -1.5712804320147475, -2.50701479748959, -0.134823317752829, 0.4910183173667824},
    {1.7779013548027753, 0.17685976764083236, -1.3719771082226264, -0.019239744930816725, -0.9434885275579723, -0.5258012840910367, -1.272441064895716, 2.2596855692154363, 0.09849747469966172, 0.7171454418008743, 0.4033968266024368, -2.8224080875234026, 0.6480543465920369, -0.995158391357011, -2.715328716389756, -0.610650181019804, 0.9064004017958308, 0.07421298815721622, -1.059838126426898, 0.18177064763169304, -0.14106924992329836, -1.1363542714679915, -1.1798729349138377, 1.5690495548001804, 0.9711932242667092, 0.6966498022334325, -0.6189189213125463, -1.314872457299219, 1.3677701383366163, -0.9776148044276242, 0.0877856667361197, 0.6510045329482601, -1.499214759685852, 0.02020407422573053, -1.7618563101605738, -1.1156245806702483, -1.2158904756619837, -1.8843022793894555, -0.4537003334205742, -0.09009973068467084, 1.3844010175434316, -0.14512173093280786, 0.8369503042031303, -2.0590996939163357, -0.31755518296266944, 0.6517763634002226, -0.6260590669727525, -0.6731367183474604, 1.276998196637631, 0.6144039055891066, 0.2916677593220823, -1.5452580721826699, -0.9343450743156478, -1.1965935336829083, 2.127678165077413, 0.6086236888705963, -0.13520751055970945, 0.08987034047502201, -0.230565300850107, 0.3226959982313824, -2.3201695899598196, -0.4131742860561673, 1.9240177056770806, -0.2478889672230099},
    {0.3624806171249491, 0.8561442649327083, -1.14067789375685, -0.1263460072115772, -2.0153007676283266, -1.3900552191758557, -1.2691416148535868, 1.2876118551593263, 0.46525179916781473, 0.7211182855212663, -0.4825694874727059, -1.0560805437362384, 0.9841189859984681, -0.6841712150419408, -0.3653683816009378, -0.06688951558197993, 0.39071902666866354, -1.438461795521027, -1.0931696688033528, -1.2534852160038503, -1.1082262157812555, -2.021383439266163, 0.5920844580032267, 0.17696167867422163, 0.4222226627720544, -1.02673857208676, 0.5248712621986253, 0.9864779888472373, -1.3751727218791312, -1.1611386933713346, -0.05338688791906049, 2.5644860883425697, -1.6836754645741365, 1.3075574500457916, 0.6112269176071796, -1.1063549023584653, -0.18787718355930935, 0.6303687269073912, 0.4389956942624273, -0.11301636683122548, -1.243515709378621, -0.4782867901621916, -1.298038351416819, 0.9179006555303039, 0.8602748140908902, -0.4986167096549299, 1.7467083064311495, 0.42644374668284185, 0.30052447586999426, -0.9070335658221698, -0.9480519917493484, 1.6016034232293754, 0.25452115993998947, 0.3193927184559238, 0.7338716049680281, -1.0425371471594334, 0.25551851731757275, -1.8105995854776011, -1.759536477800191, 1.151215140546939, -1.7769885419489952, 0.9211126236275683, -1.9638473874226512, -1.6874245194337498},
    {-0.7049794035936332, 1.7980749710918584, -0.3722505226987068, -0.8919086067439987, 0.725809105254473, 0.46146440650639403, -0.782476064158869, 2.09233684387745, -1.898023698807225, 1.5075242538421503, -0.3822955720289042, -0.7396365311423126, 0.6465361460118825, -1.1289404764078226, -0.7593000646709345, -0.6997763159302102, -1.224016145771969, 0.9974252417148372, -0.11749387713607465, -0.36685372364212443, -1.9418412177707214, -0.47214317380729903, -0.827672819265589, -0.13569943017943237, 1.9211694313225136, -0.1257421897706979, 0.6780298536221517, 1.2238523858494648, 0.09192564805742927, -0.934043058759383, -1.4917368975453174, -1.1680035770200434, -0.40606395098562126, -1.2589334160597998, -1.8884932349639485, 0.6630544361659352, -0.09971179794686032, -1.0332709088126037, -0.8664370289384968, -1.8471240028512665, -1.187284285065104, 1.2783580426637855, -0.4466118420786855, -0.7252239291726059, 0.7398761592653718, 1.189709453099521, 0.13964079406309135, 0.921846551314607, 1.0538278779341168, -2.873828757540203, 1.298849624932167, -0.4310580859138009, 1.4745370137308103, 1.6214553942916912, -1.0994530437163383, -2.4143069130300434, -1.6777168116178667, -1.0886192442783986, -0.5670369076561468, -0.7059451962378693, -0.1187828805460323, -0.22607500912796663, -1.5954056959107787, -0.5923220234042182},
    {0.19494537937308293, 2.049626735626575, -0.24731929475988865, -1.1591023895064687, -1.6706771770053788, -0.6549544096167568, 2.0202617061160675, 1.6266375652381908, -0.7125931665631966, -0.25921753796501334, -0.8461895319241639, 1.5052808662421562, -0.931916105858509, -0.6281408983315881, -0.1773463853031729, -1.3727851958442798, -0.3060709923021994, 0.8560325183306643, -1.6934149773121523, 0.5262406705854739, -0.7201195760362462, -1.0992118996814413, -0.6028423148836375, -2.2610758143940277, 1.0042009094498883, -1.5270302639354596, 0.7177036082469589, 1.2828249877280244, -0.15059209677469648, 1.3082560906181637, -1.8612039067993758, -0.534072130167443, 2.2414187536818395, 0.5612319648692821, -1.5355658223864816, 0.4119825959110323, 0.9110454237874601, -1.5770808428431469, -1.8498035035661082, -2.3623085658176475, 1.208742017785444, 0.5596811384691087, -1.9999962880302304, 0.8868688532773841, -0.5798887256980598, -1.8459229225405256, 0.4939824179593138, -0.7170336115149777, 0.10835906718125853, -0.2066125107586064, -0.15650135997108813, -1.2002820320126515, 0.39212874856638225, 0.6389790431357983, 0.29593645855987827, -1.1975973090117444, -1.7397804189898798, 0.2386946499506058, -0.058798444682800925, -0.27055185925285213, -0.9072784655414315, 0.7570365385969431, -0.9896834313444672, -1.4573548029443861},
    {1.945549512524067, -1.0744029162490103, 1.0780830269155293, -2.7923184137021164, -2.081806159016411, 1.8506050417305293, -1.2269910987928485, 0.019976966567358975, -1.383376483906809, -0.7801902556851521, -0.48797874209398706, -1.9411942442047891, 0.9517910456216826, -0.7061587941630072, 0.14107523336205446, 0.4466577344194255, -1.5201871638859792, 0.41750309524403717, -0.3814987619493533, -0.7562817596327213, 1.103416170568111, 1.9773615365757036, 0.21455926867430797, 0.3216051019098882, 0.8778380376416088, 0.5087758418836531, -0.3697603650866152, -1.6173835535497305, 1.3596103744322128, -0.7256981966956174, 1.0558449830868557, 0.16886372201988498, -2.136206373557972, 0.46204107507095743, 0.16190730075157425, 1.3314009060040402, 0.16890984952010307, 1.5343802719531017, 0.012954639422633406, 1.1280374222553062, -0.47377898549108477, -0.31610413603291465, -1.427017623426009, -0.0042824255094905325, -1.015513268551326, -0.9621819762387971, 0.03608580051426961, 0.17928597885188097, 0.514724893004722, -0.233036844497167, 0.3104817095591236, -0.3353530163203577, -2.0847682903196687, -0.986840571259657, 1.2974157143855152, -0.828176552553249, 1.3296376701887702, -0.11841012131616686, -1.05938925997229, -0.4639016731397662, -0.6613934521846313, 0.7646571679611097, -0.6268680495500583, -1.3795108553612043},
    {-0.3029790174262565, 0.3736333230924581, 2.025384726287639, 0.3681534964301835, 0.6669574406185221, -0.4338025092078737, 1.8454945528810167, 1.4473122361626711, -0.2610406406427034, -1.2717567461519048, 0.314222135804979, 0.3368395740213143, -1.5381674668871006, -0.9753092419678674, -0.3839413286052954, -0.09967612389622757, -0.07256260795136706, -0.7020558611262085, 0.14036541701567445, -0.7049433326545348, -0.320267735181856, -1.9739582494929944, -0.3476558368360228, 0.4563501459572383, 0.8947258272781415, -1.4180510105545199, 0.10889959570518315, 0.2368313647719581, 1.7987036342810647, -1.5508030067790937, 1.5188499602422392, 1.3017614876777108, -1.1571900027576547, 3.603232505171903, -0.3793532977006134, 0.7709856685652823, -1.556029145993933, -0.790534877681388, 0.031169043649582045, -1.3738098726072694, -0.3844306911186683, -0.26047524357172974, 1.2509152068193514, 0.888160387853341, 0.39085016933242583, 0.0075617869979778376, -0.4284833231476495, 1.3792795937248952, 1.9084103734041247, -2.398988288660442, -0.3695645851125181, -1.5198600274912517, 2.864875646412302, -2.1286186838309216, 1.4904759587719794, 1.3446683046931143, -0.20932017992070306, -0.8562987707561664, 0.64122402597924, -0.48891233778405335, -0.21213534984185253, -0.8700923331144333, 2.0178282049215053, -1.9733627568205965},
    {-0.5999374247258387, 0.5908902573358776, -1.3125970205066164, -0.7446558927408872, -0.5711405102406283, 0.9437562499720135, -0.37904516784388353, 0.8060563889259347, -0.3289611372164541, -2.058805932889197, 1.458554371773796, 0.1915628457548238, -2.1090700752023857, 0.9442076684266482, 1.6019684790551985, 0.07193867294577444, 0.40675581718844045, -1.9108268700674305, -1.1652967631814009, -0.7936593053756096, -0.08361931848743008, -1.6616352271689603, -0.41224914209762126, 0.37558304846930574, 0.4984905876717813, 0.15320208496435822, -0.5085203200596339, -1.6778202632463088, -2.9355029490861098, -0.20132393865380674, -0.010822238020463809, 1.0936087436082733, -0.4909394150217361, 1.3306044608208154, 0.7315660805433759, -0.7255248495620373, 0.45571226799296705, -0.13008471693432264, -0.37083054586320613, -0.896454979047214, 0.5869870336693969, 0.20885527769589254, -0.29557158584664955, 1.0146892126694298, -1.167431581851602, -0.9120844312625234, 0.952392631116105, 0.8725965227635315, 1.1039605565567059, -2.6744754842655065, 1.3922357917267558, 0.059658127188809265, 0.8267604001741673, -0.17410466283756199, 0.8881248290853108, 0.27283752119049953, 0.5111772376935281, -0.2596247735248978, -0.6553911306747057, 0.9293546283154451, 0.3056045014249087, 0.3012555120930201, -2.5051599392603445, 1.5188988658633917},
    {0.6763192552827639, -0.21655442898756733, -0.20093362776757992, 0.7583761478892744, 0.6914227750441165, -0.049580652377043136, -0.30501036925738506, 0.8122826883539893, -0.40560937958272475, -1.0319156797844842, 0.949409101770349, -0.3621238378740122, -1.0485205931720563, -1.4614818535520449, -0.09813874543296375, -0.5449547247056485, 1.3713606227337996, -0.8887074595256957, -2.0126644490486356, -0.010863636258582823, 1.367274599588594, 0.3500182226006036, -1.3650878287791262, 1.774534842759562, 1.7323094863061625, -0.44888075323912097, -0.14789584716382037, 0.1250166991962679, 0.8847844615539072, -0.41453868301612673, 0.8792585513097761, -0.6844351731934146, -1.2944185265115817, -0.13089347239735144, -0.3673595640284845, 1.1457849806107436, -1.4203930697409721, -1.040805458836903, -0.42285231183730976, -1.1021743756656648, -0.9482569184800277, 0.9180618074559427, 0.349015913519564, 0.616762851142401, -2.8791682425633622, -1.5821297106624834, 1.2663040508420136, 0.42489511499228794, 1.2867022630021887, -1.2965117307459935, -0.5714434244507439, 1.0075150984974977, 0.12205846526177658, -0.5375117039499999, -0.9501164738589334, -1.7549803631289107, -0.7849502235550693, 1.2156416333677615, -1.3736470007579522, 0.9939245013241378, -0.5510799279708744, -0.10907404982769667, -0.4382697971231837, -1.9831116155767055},
    {-0.6167232416741988, 0.7172614987889367, -0.9045596425645509, -0.75595631268508, -0.23113163074845242, 0.4574642787136859, -0.5264821301646369, -1.4437999897242384, -0.11098206374169585, -0.21949304382213278, -0.6528031527436741, -0.9823506122052971, 0.8999599044100974, 2.455981742673892, 1.1155551075626404, -1.4912319855650304, -0.43299645700692, -0.8797669012769638, -1.7366126271589946, 0.013162931469607496, 0.45461538705579724, -0.9396054682748457, -1.0685603692683505, 2.090572704008857, 0.06963068163525665, -0.018122110411681085, -1.9239434388509578, 0.07359533924894486, -0.27638125096988775, -0.1378988957000831, -1.4919290116943087, 0.3986035052833, -1.0279980665660093, 0.39565980454818356, -2.1909839015065127, -0.839279691368855, 0.22888768131741744, 0.452363151865857, 0.2240981377880092, -0.62095264852072, 1.609670138010021, 0.7425266512561781, -1.160400232595497, -0.8260484461353087, -0.7953151486252866, -0.4633669087007839, -0.7841824193933729, 0.2739260484086645, 0.5681061473667977, -0.4395064303800001, 1.6827965047412081, -0.3863029877730164, 1.502996923933193, -1.765559265814123, -0.7337664758723487, -0.6093287084974958, 0.05889791221682902, 1.1794943697874407, 0.8791368181986022, -0.38712407835979046, 1.2546925248714533, -1.3735781568614895, -2.0392385764354857, 0.8730969901987465},
    {0.785235369834791, 0.4767476921397085, 0.026249205890603946, 1.9354558305272855, -1.1784963502601797, -1.0248277909259926, 0.8427582685137256, 1.0632688440432028, -0.5720271606790155, 0.0481981200624345, 0.8590992861495216, 0.7494166874842572, -0.07548360251978146, -0.8275112074268434, -1.2586161940807983, -0.8246263950646321, -1.9598195329489896, -2.012164183333925, 0.42662626149746663, -1.46107487022746, -1.3156071859101661, -0.15016578519807852, -0.9843201863253322, -1.1128146998166641, 0.2086208738242931, -0.1305499547445423, 0.39263024342981145, -0.8217943954818356, -0.8297335103486253, -0.5722905030190429, 0.15527568005654185, 1.2027716013323595, 1.0385582141146472, 0.5536775805830806, -0.48237257714026116, 1.0082788965095593, 0.3757362004657078, 0.7760261862252917, 0.9996424025808569, -0.7992234621457389, 1.1307485485728923, -2.6536777348027814, -1.5991748626390458, -1.7782032797073415, -1.4203354036180835, 0.12718633229281823, -0.8482959323519444, -0.15803582453418538, 1.3021444194537963, 1.4716470927519232, 1.962099399028924, 0.411963944471504, -0.8066662580753534, -0.5893959130197685, 1.3331743845847144, -1.6800008606075059, 0.9251852860047246, -0.17107498678971061, 0.9947795734685831, -0.8501216320870946, 1.0155079273123788, -0.282303599592026, -1.7815663893361016, 0.1511791083155832},
    {-0.34996469930580826, 2.8826303349909526, -0.9528688837579413, -1.921863735418183, -2.6341803580396084, 0.15878999893761567, 0.17745357644928839, 2.0746587416243742, -0.45173911938554817, -0.4323260537367416, -0.7872209833447781, -0.787728816097539, 0.14475942238279943, -0.0676348999359221, -0.6932327336414692, -0.8741844084880079, 0.2147232056243399, -0.9362095362978602, 1.1368095901762145, 1.2957514102026237, 1.194154748194101, 0.029811427618443916, 0.7646702664648395, -0.475782262730364, 0.0554083697580807, -0.330408303637734, 1.3209693748128095, -0.01657709273311595, -1.876390831679187, -0.0385867337927698, 0.2523740168681304, 1.8319674889243458, 2.2947716871075934, -0.49800540359378787, -1.8935091713704257, -0.43061586432163246, -1.2215598241580448, -0.19439725871262314, 1.769752772320704, -0.01138360152762941, -0.2615104867838226, 0.011841192719101744, -1.464035499528788, -0.08434393071169226, -0.032913478725582944, 0.664166283546922, -0.24882457800450464, -0.406231580076071, -2.024699939581325, 0.9955778397607452, -1.2405446859732405, 2.739683565360945, 0.36641602828323655, 0.07667204781020004, -0.31190178941272895, -2.2518245293750567, 0.1394819687515846, -0.22639191413499715, -0.4091747320102992, -0.33897270477280445, -1.2446027658824688, 0.2375879332250888, -1.2543385632922233, -1.1202259417072413},
    {-0.0640819056610894, -0.15713677218880917, -1.6242734768676468, -1.61300625999665, 1.5172038964864445, -1.5402297881109683, -1.0298893183969002, 0.6853238513188606, -2.280958973218111, -0.3799473989252982, -0.20382958140842547, 1.7334015592532694, -0.8040932413975073, 3.5639555399771217, -1.2192681328491142, -0.2537441300450555, -1.9904078325146741, -0.21940249182213423, 0.023793689517190273, 0.19719760121138372, 2.599966263729407, -1.1768220129297282, -0.915743085814824, -1.0716468204537482, 2.622729659111543, -0.2308209944191868, 0.7441808143073843, 0.34510996002972383, 0.18978325245838082, -1.00584161743316, 1.654469286942377, 0.0776570655034503, 1.0183570947388783, -0.10462312222360036, -1.2122361070405876, 1.011258198597565, 0.0653804769234379, 1.3579811638268917, -0.17182043075587794, -0.6757547622392059, 0.9598406351127394, 0.19980746730059823, -3.5843197761860637, 0.15173082873186833, -1.1191007688440544, 0.24572914543797497, -0.07938900702710665, 0.21269768078222898, -0.32997492035061937, 1.663801592390667, -0.28167368021507816, 0.505251782736561, 0.9083372450594679, -1.5537002977752392, 0.9358331737633185, 0.269268500518127, 0.414900786771255, -0.2743099520022765, 0.3469480745488594, -0.4003517191408122, -2.6691945692666015, -0.26805549324445765, -1.0917157139824214, 1.5426652049677456},
    {0.0961106232092828, 0.3141303879069261, 1.6545505451024092, -0.5912306185915714, -0.826075868080459, 0.29741974000068716, -0.33574041449381636, 0.41332225672177864, -2.055473284757343, 0.40725285016833834, -0.6563071744262176, -1.916662619946043, 1.1022596007852803, 1.245564458496036, -1.0246079127832302, -1.8938931626950855, 0.32650587254212676, 1.6424979692952852, 0.04833999133527838, -0.7400236051474561, 0.8153227380598889, 2.36973381861541, -0.8236912743426006, -1.1319702325295455, 0.4319324625305653, 1.8430686143212782, 0.39269768694495355, 1.5332182942442072, -0.04957623251329656, 2.056519326212992, -0.39429806552918206, -1.541758398831431, 2.693043680963791, 1.34226567870471, -0.08193904188918127, -0.06531340336466106, -0.7922026340997493, -0.2088107965179474, -0.1834929421299085, -1.5472165667212157, -0.2943678039134044, -1.287784428772545, -1.139688544115703, -1.2520504312517753, 0.14981951708069932, -0.9079230641415411, 0.4045356112181596, 0.23133719594672092, 2.5553624034926505, -0.7829802745022558, 1.7016114635023625, 1.1433353013313419, 0.8924970717637747, -0.410229330609734, 1.2735937344062924, 0.16668003184423824, 1.0795455890935097, -0.7994011329031281, -0.4113628426329186, -0.39137427783586093, -0.321957229190816, 0.7178582229047092, -0.8975868091384633, -0.15802938940310238},
    {0.25180535651335034, -0.02910946017627174, 0.5373296204051781, 0.6962695253598797, 0.16097897556858803, 0.8291593888532436, 0.33444888252885885, 0.3656518514477166, -1.0022413383263424, -0.8056769444035469, -1.574080136108197, -1.2020869782273338, 0.3351807493465736, 0.3449136249843453, 0.11940849018927889, -1.0871226918818715, -0.5213017026092466, -0.6534250355729825, -1.848190990301265, 0.7063400983785988, 1.191404268633943, -0.9657245598395764, -1.5517814745192293, -0.5213198561997002, 1.8901798129266332, 0.08168404471166846, 0.0696154561070488, -0.4950671099221534, -0.9878878223926046, 0.8199436721364215, 2.6595607613260173, -0.5918746026607575, -0.4792174411107967, 0.11974333322448535, 0.7007723154097276, -0.04862649855068086, 0.09404678908730081, -0.11088610037006366, 2.015686709578025, 0.19628387103082556, -0.229964754716728, 0.23435029651277586, -1.9309157768564047, -1.521564452617504, -1.588406303327229, -0.1226776396150777, -0.26766138900537667, -0.03498468259699815, 1.059942479131957, 0.6547419396238657, 0.8259545021742509, -1.245308169978998, 0.334400491797318, -0.21583051889270918, -0.9688109229076771, 1.9530947561931582, 0.2583877263019324, -1.3342383500973627, -1.2222040336426445, -1.1436388801876813, -0.613342273113595, -0.48843649296187697, -1.0464387953649639, -0.43555778639764753},
    {-0.9917603641516572, 1.324999294496919, -0.5378587473650288, 1.7656991929503436, -2.43988868404702, 2.3726429944857754, 0.5055212154559542, 2.139406912676111, -2.0760801211474957, 0.46824563408919845, -0.06588835107842565, 0.8111560858680085, 0.06617700875822866, 2.0950651698471376, 0.008578516680478042, 0.3195238974912799, -0.43533394101200495, 1.0073246854027897, 0.6115365744218876, 0.5173416660517184, -0.5060868294019693, 1.1331896600947173, -0.5959804434625481, -3.387982790489028, -1.0107073222459944, 2.269882642266881, -2.2717610217969986, 1.9430119617305996, -0.5861796366076507, -0.6473660785295073, -0.34696380030641005, -1.177316491054614, 1.8995473699877288, -0.8630872943604175, -1.5396890728765562, -1.0607061933346433, 0.1514546231172355, 0.6541210156996655, 1.2775728482992126, -1.3764067400539421, 0.30780206489185413, 0.7201153582113713, -0.3073402068589033, -1.2168042863963637, -1.6998981881545685, -0.7656929563540616, -0.7870440009440739, 1.099420629357877, -1.0843359910429293, -1.8161726896397437, -0.840656168590441, 1.585688717149722, -0.6966453002018053, -1.5224638460044428, 0.08756875098242244, 0.5553966714934464, -0.2015439693318952, -1.1681373350959126, -2.3649723756889545, 1.6608582523754152, -0.5513461715365309, -1.9172534531100862, -3.1263073856005934, -0.8375422429374995},
    {1.8443479574696504, -1.3422846640832802, -0.08455808762514637, 0.7566141882435153, -0.31828917114479593, 0.1847025841760405, 0.5765783676346163, 1.0861870190623135, -0.7387898893094674, -1.4448458031865865, 1.1224747703539653, -0.7729418583678929, 0.9845820998507689, 0.17818495523629835, -0.823421325768081, -1.5569006788054933, -0.9964932374040867, -0.22192403179157, 1.1712705190404489, -2.412143630591195, 0.9821777183104311, -0.586262826688314, -1.1880445107423987, -1.7212130239189745, 2.0163984779443145, 0.8020151116694209, -1.8142674594946901, 0.5737659536232592, -1.6846766660864492, -0.5453213516186631, 0.47219754850170315, -0.1155986395637743, 1.1114942309786133, 0.4261560491647251, -1.3139436947669711, 1.8470238527859146, -0.4653083388198696, -1.3471069152462842, 1.6231732078492438, 2.314299857802613, 0.6102709872952398, -1.6298934563042864, -1.1216496176034028, -0.04965985938184124, 0.6152372556752241, 0.8448464344962909, 0.5812298027859009, 1.2040330136388617, 1.341548957405649, 0.0738417504169833, -0.35641837281548827, 0.614806918630457, 1.8998734587366488, -0.18218565156018152, -1.2277851599470746, -1.008196954264051, -0.1889537195111073, -0.5699051372841771, -1.8793645169370423, -0.6145868732921435, 0.6868409040871395, 0.9944503966695407, 0.22807998020279202, 0.33427821096977056},
    {0.11446879390661469, 3.3842812387602144, 0.6955213836591113, -1.1462175274622433, -1.0272829244418644, 1.8313139836407821, 0.193594896161757, -0.7900385990882371, 0.4501802445643532, -1.420486667783039, -0.7291717677692772, -1.5528415489047973, 1.0933349600199465, -0.7189529492734628, 0.45105770240778015, -1.0710520466007238, -1.0580496156451118, -0.47700746392819104, -1.7071355945404856, -0.3791111442129776, -0.4512089688070975, -0.35537732147297396, 0.10681134536812059, -1.0705668873968976, 0.27022843319902323, 0.539806530058406, -1.2848945009369497, 0.7997535954014199, -0.9176940531520665, 0.8089213178688777, -1.1674911825632759, 1.296152399961085, -0.19032798703175577, -0.6313872811166974, -0.2881927026835964, 1.289219705191103, -1.910373253495314, 0.40490457366056437, -0.30054852708402297, -0.8579166877792491, 0.7648720475588245, -0.4590635460625267, -1.7506079278561417, -1.1645642065626194, 0.5600015385997212, -1.1743455695556002, 3.5986909827875726, 2.05910126904329, -0.541227138917352, -0.4938872098998384, 0.9228891819532894, 1.2750659077835431, 1.7078099160930602, -1.4858472871610406, -1.2511556631424983, 0.7391486230860248, 0.8105680843569666, -1.4202215728307879, -1.1638036161835776, 0.4535199740286247, -0.29891426083851635, 1.972395771730464, -1.1362207120883991, -0.10886260316509846},
    {1.531275715885673, -0.6525305101834268, 0.3076578888036879, 0.14706731590510133, 0.30048022090830007, -0.08959601653781667, 0.3558493836478276, 1.7574212894628762, -1.1936007081119762, -1.7367868295028774, -1.8548945802412682, 1.3266959284968298, 0.16802877515698403, 0.4825299048364995, 0.9315062007654316, -1.211047927898533, -0.38596349538126545, 0.1893689338049888, -3.417917454005901, -0.0677043494706425, -0.8468358095419061, 0.38654819878409924, -0.7454743231196941, -0.615083502726727, 0.06603932312937437, -0.25169714604258697, -1.4721050440399632, 1.2651135995564957, -0.1629653993079032, 0.11347135897165443, -0.2886998983930057, -2.4700698360244595, 2.144040164796093, -0.6641840158999601, -1.2676050492747226, 0.5980128852987437, -0.8143301142424332, -0.9217425209797542, 1.0187686802673868, 0.18476720955702586, 0.3700579271962014, -0.7623528514051464, -1.1305527539855664, -1.381065177677575, -0.85837407111357, 0.7480368819214278, -0.615008723229101, -0.900453031424805, 0.13594471064346908, -1.0993799729356002, 0.7802921015699547, 1.440931593540949, 0.3642132050850802, -1.2430187073342134, 0.5703765352336745, 0.2220656019025987, -1.7464203396208546, -1.6406224933253735, -0.7179663013016824, 2.03537962041925, -0.6292964538857496, 0.09772578478301874, -0.7879460386815406, 0.6323822718118386},
    {2.162229642000465, -1.3811112347027958, -1.8828711073268343, -0.5221684386310478, -1.3097832464384462, -1.1277420894929002, -0.11426099955419704, -0.6839403804407292, 1.111249854996364, 0.09137482943568878, -2.0720678139681903, -0.795859315943895, 0.5564288195422095, 1.2023992184726282, -0.0771569288238995, 0.6839064458890823, 2.6547113539903777, 1.202836860462776, 0.8153714214359927, 0.5086386694102132, -0.9132848618379178, -0.7436369199964477, -0.05806763690830541, -1.6321349514450676, 1.3578629910924906, -0.3083288788240965, -0.5860379425412003, 1.0853454749490874, -1.9272041183816155, -0.7131676772554524, 1.3435798779639423, -0.019336183132115752, 0.653413005132632, -0.03004144567385526, 0.17486152453644732, -0.6470906943501885, 0.9025589752123666, -0.7280038080881301, 1.3103193769260673, -0.35379654965272794, 0.42789573592949254, 0.49143716590936215, -2.0288329311350726, -1.3751839178581473, 1.8442760983721578, -0.4658835616621488, -1.9859668435881437, 0.9076700594202275, 0.47702709947627814, -0.003421060198912276, 0.10962973421948183, -0.4964154386863841, 0.982854580005857, -1.8828077385849797, 0.2930064990198927, -1.234917954190132, 1.3535793263872944, -0.5929428260739937, -2.1074954941217023, 0.624201797121842, 0.6916577340761786, -0.3102520103881694, -0.17281305565353036, -0.19955815673861357},
    {0.3484911325785811, 0.8812893126143386, -0.7778341773627946, -1.0018574011516148, -0.505899236107367, -0.7383343431469481, 0.15852832130892805, 0.5642592009533578, -0.9764452375794346, -0.3590776773649018, -1.6919886515886524, 0.009918095458121234, -0.044320700626437066, 0.004766131457979434, -0.39648141125630215, -0.2625524691943516, -1.0821246421412154, -1.8045596300747997, -2.174748511271753, -1.7287701100039132, 1.6750809654218985, -0.6341595108254755, -0.06205129300323532, -0.11296048673083822, 0.999279544022822, -0.7065923005559147, -2.6874958362383032, -0.9065458379007919, -0.26008292316928744, 2.717300847290452, 1.3070097381583334, -1.3757249092602393, 0.5430312128399191, -1.070870472870405, -1.4164611760140202, -0.9187138076026099, -1.790749131473876, -2.324397253329094, 0.332239503456306, 0.7327963469534855, 0.9209510771481818, -0.749328544105195, -2.3517178186110486, -1.2171834004716202, -0.4992970870257936, 1.152856778135326, -0.9142108313684116, -0.15492451815470407, 0.7961224524325351, -1.1785414808649177, 0.26248585653038814, -0.263495661825618, 1.8660392389503635, -0.8689259307385677, 2.531431784207186, 0.6381217062956918, 0.6518575515590475, 0.9801967484504018, -2.0141396093543427, 0.915892421703958, -1.6232401002964663, 0.6323897262240272, -1.6325326155193656, 0.44659365175004856}
};

static const float b1[64] = {1.51117880451758, 1.591123316079362, 1.5314765098155516, 1.8012929438532066, 1.0571334558775207, 1.3767753438087535, 0.18669207865723078, 1.6260041140621762, 1.082463775182009, 1.2810634785921167, 1.5797535613024103, 0.9256649584340456, 1.6374096713527093, 1.4489641205139059, 1.2034126146372568, 1.6675611269112158, 1.6349235808391018, 1.4007879395524458, 1.7840924815708836, 1.5939052022275442, 1.930202121899557, 1.5452895178239057, 1.7927937079279836, 1.7143847145514701, 1.713756285961473, 1.9044422045876763, 1.602864782459314, 1.3587467482549882, 1.1376751793808846, 1.306290734390465, 1.3112955552318093, 1.1517856756555807, 1.4806211616840772, 1.587443330740009, 1.7197264449168712, 1.396068752343158, 0.42041489893695794, 1.7247350025261674, 1.6078928198873996, 1.9743333903446143, 1.6105672549371535, 1.5375853844515377, 1.7580844333454289, 1.4795963471927214, 1.5911801776256889, 1.7396689063920066, 1.7534470478275248, 1.4994707500517033, 1.4914185924463086, 1.8401761805624757, 1.3723650087529793, 1.5936718212370193, 1.109675659102456, 1.5425729656347011, -1.1580645401867518, 1.8240770461175633, 1.4148961252021641, 1.2887588260306673, 1.5062861960972533, 1.7218597844465222, 1.5934538884774987, 1.740427287725868, 1.4922336279561597, 1.6911040986114552};

static const float w2[64][32] = {
    {1.2587390077800362, 2.0444125102866475, 0.38082359527610615, 2.212264684078783, -1.3651996733309204, -1.8316994082811553, 1.6188820903327197, -0.6075916740617063, 1.6408909690580726, 0.0261479048787782, -0.6458411736362344, 0.3929289730091165, 0.005015111779259691, 0.7878248992313285, 1.2194829842822776, -0.3723706281989221, -0.6175612034021122, -0.8140140479410359, 0.26220991490333373, 2.4402406545237803, -0.5747665560284911, 1.3961086064296722, 1.2096707475890718, 0.8404003486585575, 2.9847276784586625, -0.8911082022243172, 1.3223404990220249, 0.5057790989924349, -1.7814374964588573, 0.35867828011873504, 0.6280936145051891, 2.9180095583413124},
    {2.948372182371019, 0.8154042320368368, 3.123562633831984, -1.0036186481161007, 0.2239656729575468, 0.21680244632106868, 1.334288773130686, 1.6135969223587356, 1.8542660829703363, 0.5187774115748537, 1.293383827187918, 0.6736429438652507, 0.9344445958336622, 0.0254040811002877, 1.5407484834617318, -0.439464450127659, -0.1419785648180873, 0.13610858326760641, -1.2603408176062498, 1.3408039120895585, 1.2066416903956232, 0.4204050994741691, -0.6653152507492847, 0.5819197681272302, 1.15335487814745, 0.4858038061405487, -0.4119485810934312, 0.000561646876433808, 1.1262093936032758, 0.08580198023254912, 2.1511219794836434, 2.2138982592020313},
    {0.19143277518380017, 1.0220261613093413, 0.9362517635360755, 1.1886999396463562, -1.5151920929320881, -0.7968835620993269, 2.325450263371808, 1.6923471682351576, 0.8026354665324542, 1.1532385460742887, 2.1608202924560196, -0.19538441938443096, -0.45447477218833165, -1.1781906975991894, 1.8547364162390794, 0.1007425491113545, 0.24796475260533338, -0.4709754628255276, -0.8517748380350461, 0.07610887883737408, 1.2907926086086217, 2.595146999350408, -0.5523251189235183, -1.083940736426744, -0.16848988526021372, 0.2258350780444755, -0.2506942811740794, 1.3562225490484596, -0.6134705854909503, -1.1058102971245136, 0.48240652377321674, 2.0995175157377397},
    {-0.1578084706410589, 1.7659281920605916, 0.9005627439373138, 1.8952404216394485, 1.724121783132858, -0.8261581739074454, 1.3095570878316105, 0.10792633480422423, 1.081009292000179, 1.4667712788320797, 1.3929323458271141, 1.2790814336028027, 0.1577357677864427, 0.15089803679642042, 1.790477288368999, -0.01624494211065276, -2.823881053709046, -0.8302654018354381, 0.1769366987930097, 1.7075826597842791, 0.8670347971589095, 1.6237422702585405, -1.659539816209316, -0.19388911049422453, 1.6453699130996309, -0.03847505312938786, 0.35215494402503855, 2.34877764047162, -1.3283056587184323, -0.09563628693197385, 0.34699123059095077, 1.7470633616661362},
    {3.196768449590147, 1.5704080813296946, 1.0927254392312382, 1.1748935913011795, 1.6862065909024841, 0.16645817336726199, 0.8157734994297529, 0.10960436995166749, 0.317883684125818, 0.8264848637436711, 0.8539354667433617, 0.32723480407182304, 0.17320118002262072, -0.019253117426083204, 0.8692796465717981, -0.3262526523256341, 0.25897894339551286, -1.8043195861800823, -0.6518656861862308, 0.039901070548537525, -0.13364818774081563, 0.8235384108602771, -1.4966105044532718, -0.4044323984562175, 0.11596098419441277, -2.639613254283326, -0.41342846086083185, 1.9769464984135179, 0.6176424419085418, -1.08126796142452, 0.2827535049034828, 0.6094743049070597},
    {0.3366665392989108, 0.5890849254170577, 0.7971123418083541, 1.989353071529435, -1.6408924814959993, 1.2836290955971723, 2.2626309194690744, -0.9120949644292047, 2.7929359461722507, 1.9056406491671132, 2.396207759881502, 0.3735630198339606, -1.4407843502079338, -0.5768716425412881, 1.4773858434454261, 0.03690900553846282, 1.3356439747228264, 0.7153870863050418, 0.7392020575941248, 0.12043866899856186, 1.0013063048966777, 0.6996460794613198, -0.43022227359866155, -2.4035380785179687, 0.4267706623168505, 0.07869552556404256, 0.4326756243898536, 2.6546453671023618, 0.13132101040600003, 0.2652531591358794, -0.5653156110626132, -1.388102886564824},
    {1.9664289327723625, 1.7530630135066498, -0.3326795165925636, 0.24887710319605258, -2.3216456255874447, -0.4298816164223688, 1.1136471647438724, 0.47852586105549805, 1.2663164744131994, 1.3483725104493645, 1.693730618138074, 2.199036553558062, -0.8377779547571755, 0.11759050833178453, 0.7710028560841915, -0.4945277520085149, -0.8195096495347781, -0.09795633386010578, 0.8883064226515807, 0.18475026956820614, 1.1318421587359102, 2.531022133510478, -0.9645804525614492, 1.2685731775162807, -1.732626157774987, -0.3277433493275328, 0.5174215139667027, -0.17644601808817734, 1.5772857692998767, -0.8621219201297898, -1.7190359105992057, 2.110411995108483},
    {1.9607229485319015, 1.602161909542164, 0.7569368253947522, 2.3562000416167566, -1.6596983771112255, -0.399432470701818, 1.4677513328240561, 0.7997135179334061, 1.6444280480104594, 0.7921408088278323, -1.1243603798877442, -0.5402484708626308, -1.0467341310819764, -0.1656033311570894, 1.2245530318920015, 0.07815939795549101, 1.044837695736303, -2.2193744386380874, 0.3830074507083701, 0.814125407230503, 0.6491294215547727, -0.03768989105028066, -1.9222592074059162, -0.3212243975369267, 1.9821632471494741, 0.6447034307432176, -0.05611104579354449, 1.9514165786859414, 0.39703605286291016, 0.8348974992012339, 0.5333818614603489, 0.9362097337891981},
    {2.047468004984354, 0.6377213163014577, 1.375204385316253, 1.4879813941705768, 0.7434684414127587, -0.6633149059271058, -0.2142637301852874, -0.09724139893944105, 1.9515244811577783, 0.33759738309206894, -0.22344448036365966, 1.5116272260956185, -0.6426343688633032, -0.7227271518631861, 1.7649067182771516, -0.4918479939006626, -0.08554166185294174, -1.4727653686874653, -1.4753809560317042, 2.474523509791382, 0.9063656042406595, -0.5873712730961931, -2.5995611395278764, -0.7404546119362407, 0.6554904839137043, -0.7997385030796293, 1.361059842256895, 1.4604301486117148, -0.3323157867586677, 0.5063257756189656, 1.116914511699017, -0.24268394017374753},
    {-0.8199045617348351, 3.0938115965180124, 2.6902354514544586, 1.6238522557178867, 0.647397299478133, 0.5397086168536448, 1.3554445281410012, 0.1263873807310771, 0.42767355897307224, 0.48848395792590565, -0.5138858828167507, -0.13270091059104772, -0.889179756437765, 1.6215940224434162, 0.9431982977490456, -0.19822259470097323, 0.7117268189970933, 0.820228581504409, 0.07919857319761063, -0.5768503936898408, 1.6374228803271125, -1.0487549873110456, 0.8537048615626902, 0.2884529444952253, 1.2857473020812407, 1.1684524439398902, 0.5143505376800895, 0.4322544242837117, -0.196293511652802, 1.304010204257294, 2.0296246318888347, 1.1350992738836159},
    {-0.5701533897717241, 0.9489081117156062, 1.8230846668418164, 1.3343431386842086, -0.3881765847785571, 0.6746723968915895, 1.6606530338900178, -0.26479268967450464, 0.8751311560203172, -0.014063178547189222, 0.44939942000428745, 0.37550953316886687, 0.271079796264904, 0.21022453351269185, 1.2777693018448033, -0.8531430832376563, 1.7572001051825423, -0.09744208134140293, 0.17211400435502913, 2.2131005023267107, 2.177295159583179, 1.633561640633319, -0.3141647462729532, -0.40681041826562797, 1.332315962133786, -2.3280499618903514, 2.1932964239482535, 2.6567595507844244, -0.48933984439307027, -0.7764645999771349, 1.657019592962834, 1.6721033234268736},
    {1.0856566101191267, -0.2095938763972551, 0.3576472915295249, 1.2127466755295708, -1.5400692668958158, 1.5600652152314025, 0.37525574271951506, 2.227267190146694, 1.3794314446895068, 1.8491634879135468, 0.8095158042014358, -0.5457680336564543, -1.2087480293752961, 0.8504257292246244, 1.061603569489204, -0.11390434800889694, -1.7470902335773517, -1.129246063950422, -0.37051308407303185, -1.910398244861869, 1.328272907863864, 0.6608221333108156, -0.4234780605992862, 0.5076729496272497, 1.0282385076939784, -0.19035342297129665, 1.8576775867676136, 2.723480992978737, 0.15350713411743855, 0.3149387399096116, 1.5032184436961173, -0.23043730885957017},
    {0.9573043206083027, 0.07158593403146665, 1.3150121575036893, 2.1853002831285546, 0.4486757438514913, -1.8208782549991558, 0.49682577533887556, 0.19026642489702877, 1.154903772014975, 1.3525719937555172, 0.5011093147994362, 0.9996921952350465, 0.11199659629163661, 0.45818536945498706, -0.06128371783634062, 0.500756442584837, -0.83317370448717, -0.44802335896143114, -0.34587775131585347, 0.4518897960324176, 1.3594425818317855, 0.3254118658750568, -1.1860751707178379, -1.7418365477974984, 0.5328296754276192, -1.071262273755831, 1.159446068790066, 2.816810546815311, 1.3201485962792145, 0.6591823245902906, 1.1177938523081312, 2.0553237672043014},
    {2.186131028047878, 1.1492161417743152, 1.2890654644741188, 2.042845768253859, -0.47468261678199775, -1.4530951062146833, 1.511363788149744, 0.017065299846852885, -0.6205699419792415, 2.7725478003548845, 0.5905552700993586, 2.2460345418680907, -0.18128919891084047, -0.48413978549977826, -0.02228705873565544, -1.8339152765400963, -0.7721309358385585, -2.793616580211609, -1.20206863466909, 2.571640738299953, -0.20921587225419738, -0.5135646536889121, -0.8368126693707972, 1.392279224944301, 0.42196674883287344, 0.44402378377043905, 0.33642335691808967, 1.4432614225810794, 0.012667850403183713, -0.6394956335095889, 1.1859002070626818, 0.9154794542539229},
    {1.7500470473070857, 0.4289628472269361, -0.3858823516502704, 0.31905099257057684, -1.0187364017954297, 1.911913118102812, 0.9351610977249845, 2.339277820891813, 3.0159042275256573, -0.019664986187909562, 2.0956744877072997, 0.9666179163565028, 0.34586549539156664, 1.9133022992668958, 1.0698232580644527, 0.6560316416586183, -1.1415741723188324, -0.3847951605513619, 0.3256654995033055, 1.5393610981088017, 3.2102793486030223, -0.4909377096177076, -0.6868022732465279, 0.9720651583674061, 1.250768772057697, 0.8295213851325216, -1.7557576867508782, 2.8549585273348996, 2.0237570212885556, 1.9522056790514153, 1.987558031820871, 3.3838340671567324},
    {2.631370670274512, 1.7362662732087908, 0.5908702484794596, 3.4939009854955763, -0.9377288444500549, 0.12835224876939053, 1.198715414297747, 2.4166410587722553, 2.349545142050294, 1.06207088485808, -0.3283021535678224, 0.6184204727826467, 0.3808770224280653, -2.690046196937484, 1.6111426434813423, -1.0921545744032677, -1.3266198356252858, -0.018419075021669843, -1.1422736139286374, 1.2528117528966334, 1.5421201085687262, 1.736984961862373, 0.11809388406913346, 0.182740416865748, 1.8442700535932612, -0.4872045544099168, 0.9184557618957224, 2.467706277812756, 0.5835730236524845, -0.6573992333312472, 1.1369401053522656, 0.2506353741769891},
    {0.7242284219525665, 3.3731601399461835, 1.7702722590660447, 1.5692503914666862, -0.35230453853881005, 0.029144680600223277, 2.494621507019774, 1.1544911868246892, 0.6849393250957698, 0.7449537880272041, 1.7087836678418102, 0.04481247916725459, -0.3381674733066643, -1.1092391544774696, 1.5801270526899542, 1.0639254213033968, -0.15422357515413593, -0.2509869799480323, 0.4731976943689746, 0.5446048266636324, 1.0765204878765293, 0.5509245090428725, -0.37852919676969177, -0.5338534436759982, 0.6323516920378823, -0.9497486482468886, 0.7496533383620658, 1.3573929124658022, -0.7474039296808901, -0.8124071698490976, 1.9296371690143777, 2.224102497165468},
    {0.0366305338495283, 1.2095550993595316, 0.5908208931435887, 0.016554868046126426, -0.18719903982933234, -1.677600890839557, 1.6743961693316025, 0.4287421620712639, 2.0818883364407292, 0.07470536643344917, 0.5498704061918749, -0.12072712808533807, 0.7415495947351811, -0.6237106109678233, 2.1887332313453056, 1.215225782100043, -1.0224737346256265, 1.611464610398901, -0.33136967922307137, 1.1063064901316082, 2.2328503249147342, 0.4789994092738497, 0.03952420156544754, -0.22202782329707732, 2.9287746001323005, -0.23864275677235017, 0.17274173666978737, 0.980183961435869, -0.07682634330989388, 0.011508487292486167, 1.0036437416807866, 1.0670615722412526},
    {1.5084968756950483, 2.1284938590118943, 1.9987312215964828, 0.6494851195886958, -1.5760713175322356, -0.08697053800988117, 2.868029049070648, 0.8802509140908628, 1.8104740936806705, 0.7171441172930063, 0.5829484422113406, -0.07941173299282654, 0.13017021044319532, -0.6286533665921341, 1.568901667990857, -0.37796843989270335, 1.2155049095300652, -1.1949127625962495, -0.36915324214876427, 1.3414069917162394, 0.6863842514540381, 0.26661934340603916, -0.09012279885165965, 0.22663903239215802, 0.493594999501069, -1.5208188179010549, -0.520001814474907, 1.297508848161768, -1.3366785102895227, -0.8227607430964228, 1.3308970949906025, 1.334803221186643},
    {1.5306983051987406, 0.13636358341884217, 1.3655501137552721, 3.3760354876355936, -0.3317768731425123, 0.49207459051274827, 1.923791723147899, -0.19659395511439318, 0.04820851076559192, 0.9732098405478514, 1.5430942501786307, 1.4784458504909532, 0.1550081197494155, -0.04183963283679929, 2.637705043546873, -1.2937810161758347, -1.1180461965152824, -2.921111663389038, 0.8982000392418359, 2.4943457388138914, 2.4954791064678576, 0.37674068887710505, -0.1817397806661949, -0.6784003484764762, -0.5345870657768558, 0.1811261167704706, -0.8080640912258596, 3.06596572086306, 2.672757279259892, 0.7126700954060347, 1.7148014285550568, 2.9792189707453005},
    {1.7073489593289728, 0.8770802777387654, 1.3994901212528967, 1.9463101329426964, 0.31468819759148453, -0.481093774982312, 2.441303185355262, 0.12865368450179873, 1.5552084682127147, 1.0467711927856223, 1.4116620055881837, 0.8305212265653216, 0.8354975182346784, -0.5961122972429114, 2.7803351221937564, -0.19438312890091125, 0.7051188902610538, -1.6272947484409737, -1.947110152455702, 0.1977887466100346, -0.45876082711395755, 0.16705444570291922, -1.1614731159440654, 0.21212364191197464, 1.906299148490805, 0.695895602749299, -0.43337809532831545, 2.4142241733215215, -0.5074600989934153, -1.6447374565433468, 2.4460304418848455, 1.994343932824078},
    {2.103085891043076, 1.6459019158624613, 0.7168398602659471, 3.2731537419071106, 0.5066638374648292, -1.1717573808842832, -0.2738594389523977, 0.3324317731544849, 1.2514745551197677, 3.117090353154957, 1.2544025308240794, 0.1348452219563577, 0.5955774687666657, 0.3365702685680067, 1.8381664268580467, 0.6958978700583706, -1.7269305773480124, -0.5112244089945409, -0.5015371985543591, 2.1700940979656944, 0.8696894462226966, 1.2083210457034697, 0.4899100257964321, 0.9634362411858131, 1.8622081925477487, 0.399079049985077, 0.4311939207140573, 1.801840300249562, 1.0222501953556098, 2.1486677903475577, 1.1449407461471073, 0.4582343169136025},
    {1.2685279052857892, 1.0883868854578789, 2.483930802432674, 1.9886102453066417, 0.8653166845362652, -0.581401431901417, 0.27904880664908843, -0.10351039930829124, -0.190826342253259, 2.6716614370727876, 0.5841878464996861, 1.5735807348832098, 1.5215906135177035, 0.0365105944518656, 1.1095958289026502, -0.3229576556422746, -0.43597488380697064, 1.0705047999931163, 0.6459168002948029, 1.69334776647703, 1.773447763305748, 4.744872024172062, -1.0549958802164006, 1.108789781695477, 2.081253469905959, -0.3862657500139648, 1.2839671664147558, 2.878517357448156, -0.48725193072281253, -1.126178544553033, 3.3115768173619586, 1.307037382758934},
    {0.12075845913446347, 1.8565619871702466, 2.453287196392867, 1.735941365412044, -1.4685163821941727, 0.20908152936616256, 0.5981696346127747, 1.4081133253310096, -0.42592855129103724, 0.5921632679729666, 0.39619182150590165, 1.6029450257390805, -0.772083990963565, 0.47132227061875925, 0.0951992523061546, 0.2250567254075692, 1.109695689132802, 1.2917513057565997, -0.5000582255332652, -0.3915563993881476, 1.7004808566537475, 2.157012121306215, -0.3321688103680853, -0.4821430720344283, 3.0680220943662517, 0.8007351287565173, 0.5786921526830471, 1.4000129568417172, 0.25036630014643424, -1.204752624005226, 1.1393657047582633, 1.7259681192341914},
    {0.21371176581225368, 0.8550966444340006, 3.1133045614831003, 1.0165223966630939, -1.135760459223592, -1.1660668680259247, 0.5979579204729697, 2.7618547961563054, 1.493266654488096, 1.7093514731600665, 1.536808018222728, -0.2843457124534944, -1.0942605884227468, -0.5815751693837178, 2.836587919737022, -0.3949306361988794, -0.6628952560251987, -0.9261467650179086, 1.736024354164127, 0.9796805322793151, 1.6215398295976646, 1.765014654698046, 0.0533644251004328, 0.20451092681727226, 1.2482842326882542, 0.5459351663022362, 0.4306554142360925, 2.009118455904471, 0.31009848894269965, -0.3603258831700954, 3.053825936036204, 1.5337007405440573},
    {0.46053820824362035, 1.484972916381994, 2.769450261837927, 2.1160145222685185, -2.1665699260609985, -0.30843947463587196, 2.6530020898909594, -1.0237471230154596, 0.14336465917938582, 2.2165639847952243, -1.410865790183852, 1.023267854753295, 0.3639550949729096, 0.028821164551624433, 1.066604845429464, -1.1829787028416117, 0.16686786547126925, -1.3598067587185407, -0.4012621876734867, 2.261032776497081, 2.518612578880026, 2.0868390902137004, 0.24865168975292648, -0.3857949521868553, 1.4066362077752688, -0.18851315843833835, 0.5366247906513836, 2.762550596267673, -0.3264062346289868, -0.4645359858052243, 1.9107742905159477, 1.15562802318876},
    {2.017954888846475, 1.2204681963270225, 1.8937281009273785, 0.8701619718118483, 0.2917949286744026, -0.7440280436467024, 0.7118337006202914, 0.20131490969979343, 2.763349028363541, 1.8170677111972249, 2.078338740356131, 1.3987599390593624, -1.5648658610693935, -0.21777488765806685, -0.1934422871620082, -0.0024596139798138228, -0.9850352560377681, -0.8581671957854592, -1.1312369564027303, 1.459082726246599, 2.319921431069353, 1.54511513899323, 0.681172991959394, -1.1947483693793608, 2.223701147104586, 0.9780930779517509, 1.480932336219576, 1.0197082008779024, -1.0857530193179825, 0.5901915285210788, 0.27580838214815817, 0.9644733454094134},
    {0.5122577067719677, 0.36020731698703, 1.905417860797552, 0.9601838452133913, -1.4442636292723627, 0.5978108823307926, -0.3179020496747697, 0.5927195806090468, 2.234943721822739, 1.7232277070451303, 0.09217434327657735, 1.9386669989407344, 0.4712276645165932, -0.30592113086824346, 0.4532392372047996, -0.26133843593270295, -0.6078921254395605, -0.6036421505888454, 0.6496765870600328, 1.6994592277770424, 2.42110412164659, 3.4313226140981947, 1.5124980684543434, 0.7764849628611011, -0.3336276728292956, -1.3286638925840097, 0.8337922110074647, 1.9600977431078197, 0.7073677205412694, -1.7629455616168515, 2.028772335512925, 2.5776192205185624},
    {0.6810058030355537, 2.318404317747074, 0.4271522348732497, 0.9272086831473164, -1.1048976248909324, -0.8676159983648215, 0.3612607636831195, 1.104080180926498, 1.2036095488710017, 1.6333615369047454, 0.555034954349524, 1.3339186909077716, 0.4563928529097626, -0.731846590250745, 0.05862248040460298, -0.19248925977092624, 0.2730101164758596, -0.5828259215074496, 1.5917107576105298, 1.575607511041493, 0.316659082146578, 1.4636839993541726, 0.27479667025122045, -0.9571780001113667, 1.8984476695145331, 0.3446153508854089, 1.0878443517649101, 0.6631795878005838, -0.3406667425957458, 0.35761343594720657, 0.8370958430863966, 1.8498440185289742},
    {0.10762870635353475, 1.9389249831404807, 0.7459757669837355, 3.0031945958152653, -0.4193433903416195, -0.2929759315684418, 0.31445255296478136, 1.5395336810337665, -0.17880148251875505, 0.02074177498429407, 0.06695977732280951, 0.6237726817398858, 0.30416237929695383, -1.9667356306099912, 1.322081444950739, -1.4407241627272782, 1.699684669315459, -2.8688179466144246, -1.0328516780243209, 2.3893081619897107, 2.69490190994172, 0.7396168358402819, 0.69998584538037, -0.4034219143771085, 1.1628776899042037, 0.7525585062039886, 0.7292840011530146, 0.7679314665672076, -0.6376080455232263, -0.49278384400074804, 0.5448455532709469, 2.6100542925725287},
    {1.2169450937496076, 2.8936370825620674, 2.548079561370227, 1.8254608433233737, 0.10201505841505183, 0.12336873049955357, -0.5368599945130528, 1.5081965058636488, -0.36399724414487317, -0.9201644363596114, 0.8830552068502773, 1.6751453582423514, 0.3640766158645338, 0.2850025710554743, 1.5656177529274153, 0.6161934453427339, -0.43253421511587764, 1.39080952612663, -0.5341662839705131, 0.2241730206581402, 0.9797479996145889, 1.5161549384771176, 0.7319014429472263, 0.2536296333600637, 2.778590208361488, -0.18328197361835588, 0.4964094946727832, 0.7001044995519293, 1.8988189111592584, -0.6884755288867008, 0.550546990044865, 1.0173030316230003},
    {-0.4708695938229697, 2.5096620089228465, 2.497250986418832, 0.4305620140968167, -0.4212604843763532, 0.6483403618891278, -0.004739256139325009, 0.5778817536088507, -0.19856369818413264, 1.4212861037382238, 2.3716813070412575, 0.06369869585251657, 0.03614925684149376, 0.8836011403653921, 0.34397593349492434, 0.45337515287532326, 1.3594198328064684, -1.0569048543684871, -0.39265810063641404, 0.8425730596156401, 1.496760264694283, 0.3930586339832986, -0.7378336319625372, 0.30894925323291694, -0.348284947524858, 0.02594630353037866, 1.041754102023892, 1.3844988690966988, 0.5274534263396837, 0.13903628349625452, 0.3484590321031654, 1.8560536390702762},
    {0.43727613104684177, 1.9261028011751564, 2.4030852605981163, 3.160457902164733, -0.6758594701680595, -1.2659992506800266, 1.481588273162433, 0.23626426844389148, -0.24789486136140354, 1.9949051830941356, 1.6493306426886702, 0.34246509887301513, 1.2189307013821984, -1.9670584395454114, 1.2647520943602004, 0.38303241072540445, -0.6739878517306865, 1.3526458034405875, 0.791141967934992, 0.14420365042773392, 2.3188599584959526, 0.6461003966575892, -0.787701900010832, -0.16544929022651012, 0.6817392485937761, -1.9664923865823536, 0.4078176482647374, -0.004522059623835966, 0.7169170908222634, 2.3371441284569747, 1.4059054204159596, 0.6912596364293284},
    {0.7978064070084379, 0.9628024791681054, 0.5921828381563929, 0.6791626921830415, -0.18856893870993544, -1.079463042222878, 2.4095191534532834, -0.22103488537726135, 1.3969184651276454, 2.463499330566527, 2.937222385647045, 0.05375496534956052, -1.2515578691111564, -1.353271432282857, 0.677451165029786, -0.5785428534904137, -0.6868607272325439, 1.5699055933727444, -0.25224579718738066, 1.00762651740259, 0.721909696419989, -0.021370464968721373, -0.2032208296598036, -0.7751128155158432, 1.1602305834300195, -1.1390008817016788, 0.23298155925629124, 2.485591020055476, 1.3085965195183238, -0.7225635512769069, 0.6820747962119066, 2.0739009254605447},
    {0.31252267344203993, 1.5848826864931853, 2.719233858602271, 2.819555311253049, -0.235017769866112, -0.763253662131108, 1.4673070987010812, -0.38218678234271786, 0.4882982599089031, 1.7517811307470406, 1.6128761449378115, 0.4929758727428686, -1.079361505823614, -1.0401767566405284, 2.9035780137230978, -0.6481734722871247, -0.9645188087516856, -1.3765364352530827, 0.034544904597591915, -0.5534418968318959, 0.4598776548444676, 0.27739544391773646, -0.28493457178438353, -0.008283947103969373, 1.2727126089137661, -0.22487645208980123, -0.7832438320890728, 2.7010081097077117, 1.0457625415429916, -0.16977501169781115, -1.089731423274854, 2.030711100719236},
    {0.6012345058373053, 2.276908752814117, 0.37959948402511134, 3.533302140915721, 0.7946874702200826, -1.264808022244231, 1.360675561792173, 1.9534877495780167, 1.9689706466904406, 2.354711393250065, 1.332808746498233, 0.542793283935349, -1.7225197293872427, -0.20586913102049723, 2.9410495689350222, -1.0941894873478264, -0.23695521796883498, 1.1943426918676512, 0.2664348287725646, -1.3593650684900203, 1.2297968573373939, 2.4262883421650043, 0.23610729905138275, 0.19274286005792265, 0.10360887519679905, 0.19921293013849686, 1.0639283299964029, 0.7413586938963551, 1.1666046583155332, -0.05338989573893938, 3.0137630758607745, -0.2598506456575257},
    {1.1900113896663647, 1.1886573313428859, 0.5005661549992804, 1.2682609444532804, -0.44500216979728324, -0.3144296749013769, -0.17588965252863786, -0.31898347781821906, -1.7591693575188418, 0.16216900201910786, -1.0133123508796544, 2.021316462021714, 0.5848587143158148, 1.5263888589322536, 2.329929151890134, -0.7891302297596282, 0.35065298626545405, 0.11503325214790217, 0.6628732648087254, -0.6304623650147687, 1.2426719864180469, 0.35037281305928986, -0.9189464718850726, -0.3877159126860885, 0.9132710549698333, -0.518496860157679, -0.34100619954999917, 1.9709387353461791, 0.658062822393533, 0.04022630405670029, 1.0150369338629035, -0.41869508433973357},
    {4.030469135939472, 0.4626417036280689, 1.4015108999694053, 1.7258690634654723, -0.26769382584358875, 0.019241536392608338, 2.8084492023968477, 2.2274237542679187, -0.3649195150527546, 2.3607409612414036, 1.5842788435190347, 2.145543325501328, -1.015640080295814, 0.1098756612977705, 1.1818966088380307, -0.39795325572491497, 0.3817278618746068, -0.0033555316563240495, -0.613788600571771, 1.4221676876906897, 2.162493725954625, -2.342804984731447, -0.9059782159117721, 0.8839691122997896, 0.8734708039740092, 0.09325496810388038, 0.20335996371072976, 0.7780591230409662, -1.0034323659576858, -1.352326973615349, 0.7871983543697446, 1.578775346193103},
    {1.3858725225548876, 1.9958941054232207, 1.8004702205762062, 2.3064913484767984, 0.44172406732032743, -0.4618597574029279, 0.6869568609800605, 1.7663625904698959, 1.8089663363649535, 1.8018139249882446, 2.0210251925270772, 0.4089825340273635, -0.1789632123152033, -0.7010320037379675, 0.2844552045597616, -0.10803228210366536, -0.5972709178139103, -1.6847443572450524, 0.9613096845428588, -0.19448605669627295, 1.3308891185558924, 1.3122386210593198, 1.7488808311372803, 1.6107713642184802, 1.408583708942665, -0.9273382838983746, 0.1551772991169539, 2.261554981507437, 0.618101027578765, -1.3540179983906455, 1.2898738291646077, -0.3680111802626092},
    {1.1298777247608107, 0.33108101854991073, 3.139483033509021, 2.45858433209277, 0.49964395377698007, 0.38890048530288435, 0.09047974043046648, 0.6286673740681828, 1.3015064053891687, 1.501580067546773, 0.6843554425339595, -0.6630374952756508, -0.7787119748622681, 0.06414194871786921, 3.8592070438819683, -0.5097477724832411, 2.133006932796145, -0.6677453321647683, -1.5313294400554767, 1.8203488353621171, 1.265147043972208, 0.9723032181894754, 0.6366856687446455, -1.4090916654705046, 1.1454671908101, -0.9063309159550934, 0.5893005552328734, 1.580455126857026, -0.40256749222182475, 0.25983677871494615, 2.34412881287583, 2.3622138898283627},
    {2.1342442435193307, 2.0728427071892264, 2.0971038890557305, 1.1395311928441898, -0.7044209286450789, -0.04837876953168282, 2.0950733474235728, -0.13769566853268114, 1.3101642031502478, -0.25641078358637703, 1.0451865806201999, -1.333811078237451, -0.9216385949070587, 0.8234035951153909, 1.840713827124475, -2.3572014358426596, 1.13904173125486, -0.8469646380795206, -0.5671184390474214, 0.8419240529507641, 1.8556737558388576, 1.0465335369009003, -1.3476144492674393, -1.9015822640559041, 2.3085896155596104, -0.7186633509425462, 0.8107947240961505, 2.240406335552597, 0.9544143940196184, 0.8336573775499763, 3.0696362542862414, 0.18785837389926274},
    {0.965366492372871, -0.27171577979340356, 3.1110200066213394, -0.28590098024637767, -0.008796618897009952, -0.9236163407850068, 0.4233314370479777, 1.6090019062437007, -0.11425592762339176, 1.0910338373905406, 3.3760473743280874, 0.6922595072746698, 0.5385992039502815, -0.6117915433194222, 1.1476990273640946, 0.7063577886754143, -0.4758762227012151, 0.9748314503242329, 1.8976680327560522, 1.33009063982705, 0.11027756387173243, 1.5097438666992418, -0.4897928636709306, -0.15508332055501595, 3.622837798763433, -0.14507272750276157, 0.07623412475841218, 2.1879573437799418, 0.6857831274482157, -1.9570438948138622, -0.40809360207765355, 1.9588529370232597},
    {1.1252509589663473, 2.699785491231641, 1.589079623474613, 1.7408847477782545, -2.6547501558150914, -2.577625962102053, 2.6057088558263435, 0.47717519935329233, 1.8522007603687394, 2.5988281122782846, 0.3345149607682594, 2.0569226600226123, -0.22164262143228042, 1.4430099324941839, 1.6913008804209644, 0.9124855971182185, 0.5050016791327543, -1.6694782877540815, -0.9581492510234395, 0.10532117745375424, 2.58348194194759, 1.9911993650476556, 0.04266693925619694, 0.1293951693671934, 1.6743426472745762, 0.6428948265751699, -0.9528778564049933, 0.9943856306638301, -0.09777096001720327, 0.30861416058987146, 0.5396064713265252, 1.303889103240398},
    {1.797655072895358, 1.7889905444395624, 1.6110754550151802, 0.2773405791129606, -0.05748817058963059, 0.5634347483940292, 1.4050835557874146, 0.048655974684766706, 0.2457648650447163, 0.7190963938315177, -0.5905504309604928, 0.1583423561290995, -0.9127734191663159, 1.534204210166672, 3.2927668288430505, 2.129468362012371, 0.8721379677275239, -0.9578241170222158, -1.3069590045569182, 0.8722690031532706, 1.3777134380066773, -1.7533994497333893, -1.02835244395369, 0.17375759264434706, 1.28643659763508, 0.3384012254353527, 2.2436221507267446, 1.7637501512888016, 1.3507732071825207, 0.9606167878919, 3.4383703695163725, 1.6137284625570403},
    {2.343452275917282, 0.5697303357045346, 1.379580046639435, 3.4648654717459633, 1.3477619791203543, -0.45887286216661316, 1.3626825763124757, -0.2921906340385639, 1.433765426598707, 2.395520114851495, 1.2467114113150857, 2.467889656452272, 1.6247447719342365, 1.096380748603204, 1.982150051393793, 0.23715887158870239, 1.0150750384052145, -1.8615564728825869, 0.10779102547378518, 2.369193271062936, 0.5903047079352094, 2.4594432641510457, 0.1361439698423295, -0.4299715114788811, -1.1001392282949582, -2.003766234606797, -0.6225674561931532, 1.3669989129768243, 0.18811927982960458, -0.1458401798763458, 1.0970846886542651, 2.9432476809879535},
    {1.1652934262992223, 0.5536399125946642, 2.740164099860537, 1.661200398638266, 0.17512400055297528, -0.08576214629802129, 3.2188730692484575, 1.7619683545497475, 3.063267815368983, 0.8766521171834384, 1.6529207884781756, 2.189833019269525, -1.4833620850760136, -0.6118391843239326, 1.99357899610774, 1.2264036747508529, 0.020659325941384865, 0.4288613903467598, 0.27030662892995183, 1.5268391630449916, 1.8997057333045817, 1.7701765794413287, 1.3463065094213886, -0.6520404825093383, 1.1655649753479085, 0.7211524696027498, -0.1646826164668635, 1.9457706104156807, 1.425765323808827, -0.2351583104091142, 1.4057855308856417, 0.5866511561082273},
    {1.9503720420785855, 1.841363769749366, -0.30737318571118377, 0.6534786236113769, 0.2868007430484255, -1.18767266693955, 3.9475984919256804, 0.04884134839101367, 0.5220333531292853, 1.9747199695449997, -0.49850155003210483, -0.8517780248108666, -0.7649312803924312, -0.636909041485611, 1.470363091661988, 0.49716255462102504, 0.06873419467663733, -1.9595331930365754, -0.6711784697341229, 1.3563055288638208, 0.33743787448925616, 1.0488675500923819, -0.6327398988899109, 0.12549563810746447, 2.3766721692537742, 0.08968332642779869, -1.4352633115018438, 1.9981732271205235, 0.05947540589251083, -0.4306387054548176, -0.35365202268273666, 1.4297574574130816},
    {1.5602525539886491, 1.996686907338333, 1.9579107740786914, 2.3060915141676945, -0.5398761422361665, -0.9284340566457885, 0.8988916588095547, 0.06208765357651484, 0.7565025135152078, -0.1162222118163345, 1.8887663661831704, 0.6127183585948746, -1.5081482508532609, 0.9799022409803287, 0.6113605478740531, 0.8236918193854332, -0.22398818753173175, 0.3544256907499581, -1.305415115583386, 1.1819657901544465, 0.06028173647794228, 0.5569022955174279, 0.6306803643262477, -0.4649291855606687, 1.2130325305148506, -1.1842400431510278, 0.28048753405864996, 0.6848065688216443, 1.785990648754152, 0.5040356971120127, 0.6568833261979454, 3.002540256030117},
    {-0.6218391758030695, 2.1679678466982812, 1.9510348960998665, 2.033579458885849, 0.7799610607451049, 0.4426017243904777, 0.9316667620452385, 1.900985880272609, 1.638471968584899, 1.2938049525303505, -0.08960594881258184, -0.13513761255299503, -1.2197437120679901, 0.2922591849370948, -0.4194853859987806, -0.9698141652093212, -0.6455860358043444, -1.817965570447627, -0.015326128041762543, 1.450976944932767, 2.6223247520321555, 3.1284989463826554, -0.6718454861700023, 0.5052156642704815, 0.6452384003413949, -0.7908963349022875, 0.7991370385581188, 0.7294940891531684, -0.37259321040754567, 1.2069126148512002, 1.6353085817858415, 0.21167666235107171},
    {1.0997292653528126, 2.92258592804801, 1.507405235758264, 1.7189059829742994, -2.5354659804085067, -0.08228094944905497, 2.6004646779290512, 1.4883057050509472, 1.8150456224221827, 0.08849979440188709, 2.1629860963852656, 3.3464925774335477, -1.8346908680924516, -2.051806582945021, -1.9236878023512745, 0.8518574095918644, -0.7098905162066588, 1.4507705918658789, -1.4071208867539167, 2.816851399377532, 1.478628459799239, 1.1200480401677402, -0.911795281588724, 0.3359966552716105, 2.3615699251772364, -0.21602854532330404, -0.5093068729879531, 2.2894747688040877, 0.2405548683618886, -0.18008162626024726, 0.7811984005945859, 1.6508598297419965},
    {0.2133245248512807, 1.511124560807543, 0.7377602154435271, 1.7577569295499529, -0.8391020803724255, 0.5905148245441729, 1.72644386183585, -0.376718431628453, 1.9152220962030224, -0.5743112258422443, 2.0504033690848202, -0.46487439620713794, -0.16815876779053324, -0.8127545971484115, -0.027685416817107112, -1.6815307259218024, -0.2516249432182084, -0.4237258313340754, -1.272992481819796, 0.5246010115626033, 0.7805901190516656, -0.11627204288786279, 1.1604577530010352, -0.3134205032587057, 1.708239316796934, -0.776287255624444, 0.9841102760174189, 1.0295728075725383, 1.803910191069961, -1.1239341638646896, 1.1573732638895633, 3.373683496680185},
    {1.4701274636073862, 1.8016429537184717, 1.502330548874953, -0.3839572295840735, -0.5768783916688739, 0.42091555507340783, 2.382297430886512, 1.5031572136569056, 0.9045600216779555, 0.8131334941050383, 1.5287643272728713, 1.7461116773660568, -1.912152933711653, -0.22970002558960723, 2.2801023155080644, 0.16544517337848993, -0.1541497486550926, 0.06322159628193487, -0.44554896288630313, 1.5769975972804147, 0.5248694751694303, -0.03439187378529179, -1.3503022427925166, -2.0965859411864183, 2.2249502140750246, -0.8865358519099517, 0.6118568547751666, 2.3097941496005534, 2.1863072030534743, -0.2166903472822842, 0.7990418830958822, -0.048418455135476615},
    {1.0326856899392178, 0.35012115730925947, 0.16357300654527868, 1.877390983459091, -0.6325169254131803, 1.7960324567598795, -1.2220802668544033, 0.5980000596009653, 1.8753841083953287, 2.0668697838340773, 1.0417254662830413, 2.3154698744972557, 0.03583412898585387, 0.7664589276090135, -0.521021089624076, 0.9033015457528002, -0.6573438087518663, -0.6587365289317394, -0.8182921820216847, 1.2554205322762522, 1.9691637192894897, 1.3122298318392027, -2.440058083271912, -2.0716419510765856, 1.5769406707797577, -0.5858149416435354, -0.2514639813677949, 1.078351944874207, -1.781631245061655, -1.541880672010396, 0.5611364836073842, 1.8449555177529189},
    {0.4152039012737668, 0.7568957712112241, 3.182790095320295, 0.38595362078529716, -0.08751003999223247, -1.315350956445785, 1.4595685136390248, -0.2979515024631441, 3.1878432992647903, 0.3626496777164605, -0.12235632892068601, 1.2578671714594154, 2.575589242298179, -0.6870098550149607, 1.5012701164306468, -0.5826900043338153, 0.5959607896666939, -1.5666533175567325, -0.7181834050746083, 0.6049541905067097, 0.7672766195052101, 0.8341120485927479, 0.5852610574798045, -0.7685176982298593, 0.4851734618052267, 0.243276791657474, 1.5166869627418536, 2.9822621144967187, 1.2755908696734495, -0.8594785007568557, 1.6850999726296816, 1.5773388319207995},
    {-1.0986575113513657, 1.42215258284214, 0.09873869090977234, -0.7834023312883254, -1.0334504370661624, 1.4149018644660043, 0.17903012929044324, 0.24542319250156663, -0.2673873372229287, 0.746130460680998, 0.8949042961373908, 1.0682097824145458, -0.8924121670434256, -1.7782201651360654, 0.9460974198699882, 0.5932918874657223, 0.1950513471526681, -2.0986231529993598, -0.2579342833135715, -0.4831023946040509, -1.239251172337756, -0.0456251024415111, 0.5496270983255097, -0.14043725352314826, -0.1613253278723177, -0.18674438494681808, -0.2919359002010645, -0.44011552523917, 1.9908036059564622, 0.039733398951321164, 0.4458305254024795, -1.038085922853715},
    {0.8492534439739847, 0.2202033777089867, 3.3152523743227986, 1.76161610788749, -0.46010896689990477, 1.230231345621489, 0.7207726161169138, 1.4209500552631449, 2.2401503866701877, 3.5509408517016943, 1.572178255193839, 2.242782789439248, 0.9661492837783503, 1.1580141590339634, 1.2326209955273144, -0.5664510802870301, -0.0856363639112426, 0.66224375431686, -0.37106032217065715, 0.6189633777352702, 1.0424944690259454, 1.5913937754492031, 0.9086118275592406, -1.472871591945496, 2.2405763721287255, 0.05275358389891372, 2.0025063585616625, 0.9869257474624838, -0.7371147015921199, -0.42990495801067546, 3.1483066531428396, 1.630537264930927},
    {1.5971659952265893, 1.7943365942409801, 0.8310284800568664, 1.1164990404829167, -1.8078017891508598, -0.9484639952981853, 1.4266101939486215, 1.081544480576864, 0.6762970458460386, -0.8914944438635846, -0.5107326615513921, 0.29367088760472104, -1.0668360002856212, -0.8735484852317448, 0.6475566667914333, -0.4722711056838272, -0.3830633744541246, 0.8265413336043398, -0.091047585543612, 1.6875513366833503, 1.9137884452523606, 2.2729386724218106, -1.0041279816397093, -1.3044107697312124, 1.5209696526806635, -0.9449713583663234, -0.07647864605199836, 2.768280850449393, 1.6094258663908472, -0.4718632233492844, 2.103220995508875, -0.2059619640939538},
    {-0.0713717723299511, 1.0431164842481349, 0.33197955140385327, 0.6205719570934651, 1.4226072343542806, -2.510467634830596, 1.1432878655082757, 0.2915512217066975, 0.36768954701074597, 1.3660361948534472, 0.5694228442996214, 0.788104686782494, -0.8113010747929489, 0.3789599862764111, 0.6399544890762332, 0.10847721144151899, -1.0434771635794293, 0.3351198861859164, 0.8411261335794821, 0.8942035236390355, 0.4233200596550568, 1.8495036708062915, 0.22040044129115116, -0.14842978632238638, 1.294407536859827, -0.09430853707035167, 1.1433429785692213, 1.6453868687779365, 0.18495948182341063, -0.05642786176723213, -1.4926807503345794, 3.8357425057067784},
    {2.6579126662374164, 2.837945362562975, 0.9537714377941757, 1.4068324535123333, 0.3685827588424077, -0.35688508916653566, 2.2004005745488615, 1.2159918168291945, 1.4384841531865868, -0.46514986883294396, -0.07672040939326703, 1.3337048607963926, 0.41045158018431216, -1.1774711992179452, 0.7776197334827334, -0.3612547745437924, -0.9612410785491311, -0.7011038879882568, 0.12701166195254304, 0.07246184220099935, 1.5511382503315936, 1.6746618613025785, 0.6391807402649541, 0.20289014578016568, 2.083152744290192, -0.32666016167017936, -0.45725689960904686, 0.9860713009083347, 0.8816202186666361, -0.599784665020618, 0.7205391086047512, 1.457598985356902},
    {2.334782631999062, 1.4919646041667378, 0.946164610138897, 0.8515472248803181, 0.9365031762648346, 0.21192968787580796, 1.982970739840723, 0.9338144009300241, 2.608729092493064, 1.6247352467159764, -0.05717367394651489, 0.4781662527047029, -0.3976200426119014, -0.8778839852651712, 1.9619425573434937, -0.006733843201562094, -0.5043006043973115, 1.0445298636347427, 1.0527276229685565, 0.04380321121924314, 2.643286962583482, 2.177531968793113, -0.5092875841151766, -0.8013635459115035, 2.484318935879343, -0.3275983966292095, 2.2030528823624156, 2.906825953350826, 1.012251520915298, -0.29151656194164827, 1.2362324787137984, 1.7078168245358354},
    {1.9324713364722046, -0.26251406845984443, 1.7875897276801296, 1.6353987282199745, -0.885311304535228, 0.04207677178516181, 2.0307926734130186, -0.8689238259921319, 1.7504320962920246, 0.6643946701017354, 1.9750851517153711, 1.6452549774097476, -1.0610081442293378, -1.1107567816898156, 2.545972599072186, -0.5332848588952535, 0.21859320886865172, 1.0184309564297684, 0.5391731837121841, -0.5873935686806186, 0.5883942395268189, 0.7978271729408598, -0.23208096774259704, 0.48407089277398807, 2.039342629535411, -0.31488422160319957, -0.47478698549865367, 1.1885259770462622, 1.6558426545584042, -0.2272324267749463, 2.420087851107694, 1.3505512883686348},
    {1.3859712108828945, 2.267530033777171, 1.6979475882012716, 0.6127512314416425, -1.5284017852673766, -1.5974900086998685, 3.752973059294966, 0.41022422796967867, -0.21633641304731172, 1.6917828999579412, 1.7184764214352424, 1.0987462638381917, 0.5194231217233289, -1.989147805671667, 1.4519932086188487, -1.1222887472692498, -0.4999558635096988, 0.7594765880924093, -0.4781087053812987, 1.1954460165890173, 1.8925365656113784, 0.3981867571391927, -1.2464305867623187, -0.23639048251433517, 1.9434652774072998, 0.8182044000498571, 2.6298261847019644, 1.346918171144223, -0.9302799566187929, -1.577563301983142, 1.7807407826892625, 0.3872919312500198},
    {0.10372755587382526, -0.8580790805539327, 2.7070229993385566, 0.6721096610973321, 1.5003968210526457, 0.5120115653487152, 1.5768286408195828, 0.6061103409215758, -0.009248191646308317, 0.6046790983934006, 1.7287867312491263, 2.6354459935622243, -1.0453495940658315, -0.7467203989556718, 1.1768461765449256, 0.05526396315006239, -0.16541670278575518, -0.8701522437018822, 0.7121115708564332, 2.347912814336839, 1.8059593068481647, 0.534169288076837, -0.1248882029876279, -0.27029317880725456, 0.5562637267816136, 0.6562094947379976, 0.5731568284726014, 2.5267813734210067, -0.8164515123774105, -1.8232615052429089, 2.0442108225243247, 0.15470689502864565},
    {2.5420070495191553, 2.5904604654307186, 3.6412230024275387, 1.5104290504808948, -0.8208427751166184, 0.3894252914532861, 0.682067230476834, 0.573824332383461, 2.7908788055439406, 1.1073001825416389, -0.248873452582363, 2.040935646643992, 1.4648053083842074, -0.8485159571711912, 2.2609814134143877, -0.1705757138828874, -0.7877635148436524, -0.1181300454475305, 1.2807341945143036, 1.9178289118109653, 2.077665435100329, 2.0962112517755944, -0.5022855038997339, 0.3658060633500536, 1.284154485048862, 0.010547973450596403, 0.7492790287190815, 1.7566166129763547, -0.16588259265950264, -1.0516258265879213, 0.761931460827627, 1.5196026399331002}
};

static const float b2[32] = {1.6378670363404366, 1.707876238104785, 2.0014250645392937, 1.8755321953838677, -0.17707619052655885, -0.20779165398163219, 2.0137504091826504, 1.0739653819786799, 1.1544692128922762, 1.7206419662836017, 1.3627641720377304, 1.4489495475952485, -0.46911423688934295, -0.1355761103346081, 1.7429118623378894, -0.35127716638569517, -0.22398704731316466, -0.1904063736508043, -0.4392059174808526, 1.6895619923044087, 1.417358845798208, 1.7443355177869118, -0.4362719669476146, -0.3831150155495862, 2.1320102483496832, -0.27514640403217744, 0.43958517851860623, 2.148478250899122, 0.4396976043718486, -0.07242968450022784, 1.854587501053631, 1.8982300893259814};

static const float w3[32][16] = {
    {-0.29506475107557656, 0.1244686066875144, 2.4039909761579548, 0.8361704237903529, 0.7376713968198525, -0.46785945268740103, 1.2760768360606836, 1.1257168676569567, 2.604507985760783, -0.04856906852658134, -2.6761470181042846, 0.381133501881351, 0.14222408012812118, 0.7576806809869333, 1.531637910228436, -0.2501396357726453},
    {0.3322308492721944, 1.2699677902854345, 2.2004494332377234, 1.5354362841866853, -0.8965981513610999, 0.3203252934523184, 1.548035127540489, 2.93423418488221, 2.347931576512957, -0.03077713423520103, -1.241369821131673, 0.6672364338887784, 0.7896773991898737, 1.028740756475287, 0.44660100956676796, -0.5728646597750963},
    {0.5108048588743381, 0.9902724327869621, 3.3676743072962916, -0.6715678136300762, 0.46034647825009195, -0.9249516798916335, 2.3208609289260487, 3.377699875301883, 3.075340075189499, -0.9761013752053234, 0.25138722177688055, -0.6777977654278506, -1.1266267359936126, 1.6526714427127045, 0.9610443576812062, 1.138660740832392},
    {-0.6836865310886748, 1.3984615122610615, 2.8054699079287957, -1.1058548826045818, -1.133823852714882, -1.0463356553698262, 1.8750996379910456, 0.778936716923632, 2.783361606631008, 0.4888724927208605, -1.8626359625110502, 1.2224798134016674, -0.4241448771032384, 1.4504040447182853, -0.2437230604641181, -0.1495874948703224},
    {0.3805160481038641, 0.5648064763130006, 0.22364933832297829, 0.5838727757998675, 0.37448172252108863, 0.50268095462077, 0.5942119937049143, -2.2666570832687607, -0.9650317418058206, 0.07126637457557179, -0.2978286557796988, 0.9140023121070638, -0.4914357885631809, -0.5732580662151349, 0.7541196468800327, 0.048715984213523605},
    {1.4318048635586296, 0.13709629234181156, -0.805679236778344, -0.876452925024866, -0.9530144090206666, -0.2712239776427602, -0.6661763965643164, 0.0204971478555798, 0.2917358676392418, -1.536279309898759, 0.029172623029842252, -0.8795247051469535, -0.4075675584708957, -0.5677530064000872, -0.8675755829309314, 0.27573219933240234},
    {0.3708203793111965, 2.520367116416357, 2.354996963675043, -1.0991175312595818, -2.001956228829968, 0.24137566396637916, 2.3311429774711243, 2.065998952254164, 2.6450035919876136, -0.728569804424857, 0.24093315388797523, -1.6203193131048945, -0.3140925946848496, 0.11017954526397897, 0.0005656106092624744, 0.9652872986204135},
    {-0.41786721503274216, 0.0006129424885192863, 1.8225164030979877, -0.38623891753869993, -0.002155549975073131, 0.5259252076603219, 0.44192017482749835, 0.908773603674496, 1.5414774734095296, 2.2415989791623736, -1.5743469519100919, -0.7110852452565141, -1.5052702447191235, 0.7727577810186472, 1.4548113899574198, 0.2661140421419408},
    {1.3349175799184185, 1.4045840998155177, 2.3920923312041147, -0.3674870689502241, -0.0336794279717263, -0.842517398642904, 0.6506959590110688, 0.3502723108058078, 2.86643361720229, 0.818397318140877, -0.19118623195320936, -0.435608506267525, -0.07615948823447484, -1.3591811504455171, -1.0603334899918833, -0.34367799183824393},
    {-0.385979064740215, 1.0860148017650526, 3.9353395876160286, 1.1710740677873834, -1.6743749418404579, 0.5942865740134587, 1.2051000219228152, 3.0981198620083408, 2.684875355684338, 0.30544071521124494, -0.8681490959060673, -0.18940547608202396, 0.3926487597345411, 2.352253776343422, 1.8466597445632746, -1.3532641483839136},
    {1.6439502965073525, 1.7637741745134097, 1.8723586625010071, 0.6006729213952816, -0.5304741262959127, -0.21686448215987966, 3.7078042393890085, 1.0619223662703674, 0.7898313772970758, -1.2371926280896994, 1.496353445531131, 0.6804011198335213, -0.689889831448674, 0.9634321646823506, 2.1303347477317076, -0.816156940543669},
    {1.163559402607934, 3.1247905996548835, 2.6376421108344723, 0.48309484888389953, -0.504757495514566, 1.5170246786816068, 1.8509991867098676, 1.5172325154716402, 0.6945389334687996, -0.695373196582825, -1.5586847824931045, -0.08456416786803445, -1.5616452302365367, 0.19923780412313802, 1.723793478778823, -0.8091057052599427},
    {-2.2727854972737247, -0.08589140042035545, -0.1927310983855192, 0.8001778046393925, -2.0677283834895017, -1.8263033148036407, -1.2489956989543791, -0.034086665868301405, 0.6217872440750264, -0.04848076289909505, -1.4512576712508045, -1.6266945232051182, 0.13050082554315753, 0.39837910980214963, -0.4486030512705297, -0.111880249699219},
    {2.024712382439108, -0.7918103861490701, 0.5212915022263942, -0.31610574010150905, -0.2184297036180716, 1.1380215376163256, -0.4389152147973884, -0.6379773409943131, -0.7798811112079801, -1.5788999485221535, -0.2910452941419163, -0.3807487378200508, 1.8741399742243456, -0.8861547528253861, 0.5011270897403202, 0.11061177735725396},
    {1.5123666972968877, -0.03319615323965917, 1.9599448785881322, 0.10694260826905273, 0.07583050686376465, 0.40055152714062525, 1.644033276732279, 2.1335624598750518, 2.019453077973068, -0.5507904884379919, 0.442733739429079, -0.9809648627416943, 0.5393803491822039, 0.3322339547789662, 0.29480383237599656, 0.038100270649835274},
    {-0.6916808775766434, 0.2961709554834631, 0.7150170707449124, 1.1773349556052848, -0.29624961983543785, 0.11181937558681856, -0.8160354500152047, -0.32743814229779683, 0.11990388009406114, -0.4530342994755512, 0.8039836116514296, 1.1802161017309551, -0.7765084972116955, -0.4648035196515116, 0.4338419685156249, -1.7640426384037688},
    {-1.140449709025539, 0.938905763832675, -0.89480076586688, -0.23338481458584204, -1.9513154840509934, 2.422952560783676, 1.1019414616619765, 0.736085650394406, 0.6643368636640806, 0.1705619479686744, 0.46616935739809756, 0.8355932135235352, 0.8712856625986938, 0.023018205484633205, -2.7139907784510013, 0.46039375833746377},
    {-0.08383196384301264, 1.1386219653919933, -0.09885506388252463, 0.768109999493366, -1.536293336320924, 0.7282447348520633, -0.9110124465616019, 0.6684878649890433, -1.8273396515425748, -0.27762267053550294, 0.28942595786558467, 0.25207130986247606, 0.10716377110513269, 1.4688667502649515, 0.27142774711685785, 0.5029466541087547},
    {0.1462354566741333, -0.7172100402179007, -0.3825085675400523, -0.8382111460374593, 0.4937068631349554, -0.29857184171844636, 1.2789934248635757, -1.1963389412307333, -1.0391335734838396, -0.6835910242136066, -0.20665625512962638, 1.3204799981529056, 1.2296117285336339, -1.1070804838717536, -0.8659880251678319, -0.8790806326980546},
    {-0.8382663493598622, 1.7430722050235605, 1.383814650782364, -1.966559146249219, -0.7478599790005488, 0.4692642276292686, 2.557613647655032, 0.8316345585736401, 1.6521101307617128, 0.10308141968846166, -1.4612658714617028, -1.267443819615269, -0.20894323217694416, 1.2527734926936582, 2.4414949120831815, 0.12807745331848655},
    {0.10785514942127063, 1.4090053616322702, 1.1468863968504381, 0.6576567663758772, 0.5650530945972065, -1.3378831857565532, 2.7912164635517516, 1.0556748896457542, 2.5310571141864875, 0.40226346537146396, -0.3609617196004967, 0.031188122351777838, -0.1891634962101918, 0.26587905439242004, 1.0458574890012593, 1.6158796919306708},
    {-0.2760359581305024, 1.6113000342401558, 1.7808330786618518, 1.2567492690157107, -0.7890352729923551, 0.03315168080049089, 1.9052237623183876, 1.4773649821428543, 2.3766351723723362, 0.03750780911122531, -0.4875531471623375, -0.11848966271847736, 1.7206077029099438, 1.515999265317051, 1.9623658389520484, 0.6759136075881356},
    {-0.8902251778190495, -0.2830495647743431, 0.342522695947117, 0.25911123672397335, -1.1750006880897643, -0.45330617459074235, -0.7877372695209911, -0.42127862327938703, -0.601017723360042, -0.944515274369451, 0.23230749464617906, 0.7918992264618826, 0.4470349878341112, 0.7221959225231313, 0.39930900437712474, 0.2057536667804879},
    {0.045658743850244064, -1.4062103804407011, -0.5367736624491691, -1.1704272050151767, 0.7898624974662923, -2.1830478189459894, -0.894002319465501, 0.3252476219586, -0.10419475150141604, 0.03213962040083876, 1.5043956744409346, -0.296133718338356, 0.5623347111137181, 0.041690600898190336, -0.5232593529511178, 0.5549776293878945},
    {-0.6558267720345546, 1.874950252852711, 2.2816443156706905, -0.7213222433944098, 0.1487294657799885, -2.304199376825521, 3.168671116995671, 2.135338454333347, 3.5097240800667446, -0.13692124981186343, -0.9638767986087302, 0.45756149110287775, 0.42106380300220647, 0.09693512109525569, 0.12074548996497562, -0.8190481040174665},
    {-0.3412627323392745, -0.9427721849923492, -1.8581807465022246, 0.3118444210764996, -0.10350741429261023, 1.1597036309097568, 0.6550850019281411, -1.9969742760693028, -1.3198671718763315, -0.1476293012381475, -1.205763951711661, -0.8584613062028249, -0.6138793663268592, -0.09483760656131666, 0.24886511141780004, -0.618478072827984},
    {0.579138216362817, 1.3140023656764868, 1.68035400582251, 0.8702352397568954, -1.8352546326562271, 0.1126642954478432, 0.10985582461533192, 1.9775406058217908, 0.23554899018641426, -2.7712258142478783, -0.9433694347202707, -0.10849426793726721, -0.19371446463464734, -0.04078227588502925, 0.548238170461586, 0.5946388623329151},
    {-0.7229626260347866, 1.9355067429983759, 2.351688082670134, 0.17645696753068382, 0.18012367665510565, 0.7899282030233525, 2.608788243148956, 2.3803237411897866, 2.3225655473487397, -0.8223132211554947, -0.795974639981299, 0.7672144454879112, -1.154401105863316, 0.5536206562561262, 1.278607505905589, -1.265527435102299},
    {0.061311317417891864, 0.6212005982083935, -0.8651745380348553, -1.1294470564575922, 1.0503736404997548, -1.061247172199813, 1.2106983976663503, 0.31520389620123485, 2.6260950191227628, 1.3060902706761544, 3.025971604657511, 0.42446229391881285, -0.8353869960351085, 1.0534007938086547, 0.0042572654650533445, 1.6348822322390024},
    {0.2046276099509916, 0.7444534314067387, -0.364676987906064, 1.1499439855669633, -1.504074026824025, -0.5839229611998178, 0.3991610467912959, -1.1396239542091355, 0.9884413205037338, 1.0745385251721271, 0.01498848515819486, -1.619336760371851, 0.26974902754436686, -0.2278060856553537, -0.7669910049631395, 0.3707742538669982},
    {-0.9015135652983584, 0.6763631757771991, 2.5229020933994324, -1.2175394574597649, 1.472243369471492, -0.39139702434165546, 2.8878288047969733, 1.7043777049407771, 1.00142912613857, -1.0116654015060758, 1.246465315889033, -0.626120066006566, -0.7791201793031647, 0.6812825443504136, 0.5267572877534498, -0.3426213155248966},
    {-1.6151282208907478, 1.1489318676896187, 1.7664459519280076, -0.33584803091247994, 0.4444782503359463, 1.4110417047494754, 2.212692856307789, 1.297387884652385, 2.4671440979767563, 1.314697095895936, 1.324796172193975, -0.39462722257916105, -2.348466090914353, 2.698340444019616, 2.022211858407161, -0.5268842168070934}
};

static const float b3[16] = {-0.07192601562115945, 0.8932388177432554, 1.2719490908144788, -0.27819843066359634, 0.029699010292181145, -0.17688349101389828, 1.2737355966140373, 1.1725012630117857, 1.5250611215096888, -0.14747307629812934, -0.1195258987419432, -0.42415215800040457, 0.04390289215071841, 0.6885394700668938, 0.7864145224298595, -0.3148788001633784};

static const float w4[16][12] = {
    {0.7412611418166114, 0.04275678965502302, 0.4757877873105314, -0.9171177676170469, -0.7733965041039033, 0.14940445775706612, 2.048483641338835, 0.13504190549673767, 0.45226090309308875, -2.6412543579049625, -0.22085611042820544, -1.7103634442251503},
    {-1.3145935366010177, -0.4030355035300136, -0.6186047908809362, -1.5646397386466786, -1.5624558711672347, -2.602203030690597, 0.031886236534242676, -1.1379379796775806, -0.7396811018817243, -1.1234413699397996, -1.332741113054081, 0.08674146762063141},
    {-0.6903264703629187, -1.5211031202197507, -1.865845406896149, -1.7766468384519267, -1.4532852894780108, -1.8482587882730428, -1.4414973188536324, -1.4670639839498747, -0.6890437787308742, 0.10576660501826385, -1.6598740723260341, -1.0567028872704354},
    {1.0972335032411478, 0.5661764796586922, 1.0730947769195793, -0.4755133551061001, 0.7170882577771626, -0.5092935420568095, -0.15781004248026514, 0.7786047991714325, -0.6017427720989741, 0.6249663479113844, 0.940800690168788, 0.32180780740547715},
    {-1.888278289751016, 0.5360344085716413, -0.35197176178373263, -0.1624980258770171, -0.7897798947567198, -0.934591467436033, 0.7598041238119878, 2.143172162260953, -0.30353119149623997, 0.44968575851956555, -0.1678230307988938, -1.1847608981611781},
    {1.9347131900939871, 0.1319472220161914, 0.2436228837544679, 1.370326319966273, 0.3484785367760608, 0.9956488018906713, -0.703085748405558, -1.4054021498557867, -1.1254706615253216, 0.9092880564877265, -0.4566645931605207, 0.11305471847205516},
    {-0.07606881728926816, -1.2311666113430988, -0.9618526958318457, 0.3287227230739157, -0.9691325673334703, 0.058527175498978755, -2.4186900462192913, -0.23597379795125847, -2.34339355308844, -3.5715555031027337, -1.1068975504158538, -1.1226502862538623},
    {-1.0508640315661066, -1.7868241754945462, -1.8793433603848202, -1.7718370827687149, -2.5798290366990226, -1.6591923215561735, -1.892025113706762, -0.7398929104167685, -1.132640116071499, 0.2556015929704375, 0.22508847857213324, -2.175214792321525},
    {-2.827555656355476, -0.7651923070029263, -1.0858820475539874, -1.6956647688666995, -0.9282641107272974, -0.390218468549087, -0.49562641354866493, -2.567470422647149, -1.5626534241676457, -1.4297217935214903, -1.8467105132796409, -1.1269123281533031},
    {0.09129333455652197, -0.971481966645197, 0.3915584833915254, 0.6693313218724296, -0.1978746889605662, -1.177258957470691, 0.45815929055279153, -1.8869583741116034, -0.010166300900381998, 1.0333369414955722, 0.7887252999635447, 1.3185768092554235},
    {-0.13911642555329096, -0.47582741291023795, 0.9024262900499277, -0.18437341893308531, -0.7448385799029164, 0.8678223673187401, -1.077007608624076, 0.171539941972385, 0.439781679902382, 0.09235557739225395, -0.29106891290345915, -0.12266393659379214},
    {-0.808105823995759, -0.30296943927813114, 0.446240494824496, 0.8537980891142114, 0.2546302123845744, 1.2918837595648485, 0.5020737282414564, 0.07372017066361986, 0.03499385227120114, 0.2637214675338626, -0.05682413843202076, -0.225113312433043},
    {-0.31876635410680115, -1.2612119463418268, 0.5449664652649622, -0.45597294006717887, -0.4443381114540798, -0.6445835187924068, 0.6510334750519431, -0.033474398213621144, 0.4623670533838032, -1.366066718251184, -2.048944820514011, -0.5615162245800904},
    {-0.7623401846509591, -1.1611920364593797, -1.4258109406821995, -1.6909324224095055, -0.202489721860892, -1.1470701688465097, -0.7563611610605984, -0.9486639503784827, -0.7744261270795191, -1.2673940246244064, 0.5816086862770852, -0.39394505706912775},
    {-1.3845589378949725, -1.5294202507381316, 0.08259257479963063, 0.161152012155029, 0.37017061313142063, -1.7747844721485244, -0.2874559651805483, -0.5726185696060692, -0.3209393164447448, -1.5015587833475035, -2.7944649201156517, -2.7372247161332455},
    {0.7811617835070762, -0.05315368327583589, -1.632449338220729, -0.12174557651056078, -1.4313360471579726, 1.4622928881014463, 1.9910826474560637, 0.03518324230549627, 0.005677563602404396, 0.9081381830163024, 0.29177077909646987, -0.08946722532803907}
};

static const float b4[12] = {-0.7617692257533594, -0.7045995256762185, -0.6600948549120901, -0.4433040101451718, -0.6952701496302803, -0.5929586594028071, -0.7035403453443235, -0.6501001698334046, -0.8605538995368933, -0.8068544483431561, -0.7086875816544502, -0.6641874077266099};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
