#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.05545741620961798, 0.6066942623649839, 0.09520314281252099, 0.03880546710243964, -0.48059857083188606, 0.1236088839251148, 0.46914197982887335, 0.5854941593373147, 0.16315576175267113, -0.06307939411283611, -0.4925172255382633, -0.12968823539529378, 0.5485190136019271, 0.23676906294150238, -0.09015516124340311, 0.3432926728821756, 0.5035186439072845, 0.4044670788659457, -0.3325633913283527, -0.24673593315146977, -0.5141181187844843, 0.09775150195838057, 0.2879884319757026, -0.2771625877952952, 0.08555635117616003, -0.3910790056448917, 0.10010520972172514, -0.18742760468356984, 0.14640969743396615, 0.2733940695513571, -0.17593473115923197, -0.2090989023323959, -0.25647159156456995, 0.6558014295205015, -0.16102381770420887, -0.1908905823332619, 0.6358189111435946, -0.34616587043757474, 0.07000868327014827, -0.38266353451405705, -0.43901095338894774, -0.5417757906146821, -0.16341419187602038, -0.31629834332652346, 0.5575017353810732, -0.4507224279128124, -0.4787325835750538, 0.6466274704159499, 0.5393436212743894, -0.06960061919676774, 0.13816858271590854, -0.3930611220294227, 0.15319620864676883, 0.07313624517902954, -0.5373540344791836, 0.03382877704532289, -0.024313947888512155, -0.1432652306686932, 0.21083605696335894, -0.5038649011433207, 0.1310145947945544, 0.5020227294777078, 0.44988579933803685, 0.08726436358438314},
    {-0.0619612748207862, 0.5815949304062288, 0.3655990144567941, 0.6978955607331508, -0.752578592489155, 0.2653428228316885, 0.48640570331084737, 0.7373175729449262, 0.765529127892581, -0.04997821630654486, -0.8946112949515335, 0.3110891648221848, 0.6869669326170745, 0.7746917398263382, -0.4595465225860469, 0.6359150310109333, 0.7010786354402155, 0.6180410846979484, -0.3282444859192259, -0.6695285875153817, -0.275208713571676, 0.26953745296773274, 0.5764286870322066, -0.31784550947766277, -0.5434825494470228, -0.4672351861472165, 0.2196291734386283, -0.5191551195485543, 0.6268642373746112, 0.44861637046729325, -0.31430260713845953, -0.08909496285544535, -0.31626492703714904, 0.624491863092244, -0.7458541242154051, -0.36402595479468963, 0.5071150818172815, 0.26986279220627213, 0.7589428769480057, 0.14716992649458974, -0.5437369872121965, -0.3331484454742972, -0.21365574121962613, -0.5565828720881537, 0.5434545784159333, -0.5359821393420344, -0.2993354543225204, 0.49668336588275686, 0.5485930042337758, -0.5121410344593635, 0.17279868972302154, -0.11955897448418341, 0.7157784178524312, 0.23475223678650642, -0.5238212078142099, 0.6352536322990876, 0.049099959621311216, 0.3476121394006208, 0.07543406719104598, -0.11064061889993279, 0.30396760214416674, 0.8451058921328937, 0.6436764364086308, -0.26205952405134303},
    {0.23072389609669863, 0.5857442006553644, 0.2580518338974504, 0.2716591442230711, -0.8887422907154754, -0.26694531600416777, 0.8189663021126462, 0.6855443495598272, 0.8221353289508185, 0.006744541517745422, -0.6514143048693897, 0.1227709000342484, 0.7840090453655872, 0.850406501767655, -0.5734407031763096, 0.7063584194256844, 0.46166105728007095, 0.691865609631144, -0.23673468147778215, -0.2560182106853789, -0.6467311896602945, 0.008252591859479363, 0.5250885412471792, -0.03162710773129237, -0.1971954227864874, -0.4879826702642274, -0.24730132273403752, -0.4388021587795213, 0.7189224000851065, 0.6975372097726773, -0.3489323700099224, -0.5424119451415675, -0.33022555224180944, 0.786819981962794, -0.27721481043028384, -0.7106858587452766, 0.43813955904211854, 0.0005244437214952842, 0.4385875739384812, -0.19172573989147304, -0.4189221189668101, -0.6432446712683223, -0.3929273214786933, -0.647465048598486, 0.6523377802822027, -0.6411501149177604, -0.127395708851535, 0.690403227967592, 0.5240590600676593, -0.5280878869864148, 0.032797044611845, -0.7828858285386787, 0.6092014063522567, 0.6104612701346214, -0.5568540200369587, 0.6681004717255347, -0.3386967647059041, 0.3739934621665224, -0.423153090011901, 0.15604984653715587, 0.336612790872751, 0.6663580702183737, 0.6966087141552935, -0.18318844063597614},
    {-0.03206536135527772, 0.8101540501851293, -0.06140701844174831, 0.6797101608706084, -0.8646813329839422, -0.22027145255287833, 0.6139303066115901, 0.5484795623370982, 0.42454425426839665, -0.5471978899495137, -0.926628395689903, -0.38193429884910485, 0.5563147520812323, 0.525129684993815, -0.6163081932236263, 0.7501262253434126, 0.7092838638772868, 0.4216624831471897, -0.5232426627306429, -0.7006982520421297, -0.7387415990278836, 0.016368996399671043, 0.7930074759573055, -0.7478261026644056, -0.5384837251123434, -0.5316891691746051, -0.3119527024068514, -0.8355375930313971, 0.5549828322158455, 0.5399860563696528, -0.509359602445716, -0.7059355214104568, -0.5932462037503209, 0.742617670264409, -0.6141510904102947, -0.4489898888153328, 0.9036545155162318, -0.27281306252944454, -0.11933029197643208, -0.4811967201051213, -0.6776575713335365, -0.572441137749781, -0.4200134298157531, -0.75312029715054, 0.7649796122305619, -0.7978585514765459, -0.7373676452798907, 0.433291255655973, 0.38724894381860175, -0.46617371294006854, -0.41929366802771373, -0.5509710041366355, 0.4567132321788668, 0.1230939247451866, -0.7102333328858845, 0.5225399755471087, -0.46287907287700275, 0.1976344307084544, -0.1720544105139337, -0.038504412441359936, 0.23423746475778515, 0.5347176327317139, 0.5113147051618506, -0.31751848990643694},
    {0.21561924153417825, 0.6977069706750396, -0.18481123694755017, 0.16420372221783305, -0.6295885843342268, -0.46410747126453616, 0.6623350267409037, 0.4344036600115728, 0.6579510457618726, -0.40662530380929673, -0.7753931839712503, 0.016466842009079417, 0.5337595418589924, 0.5527651745260591, -0.6684115674243685, 0.4787500912981758, 0.5246392985145932, 0.3364197224575372, -0.7373951201380718, -0.8460716527926717, -0.44128616024118644, -0.30457361979907543, 0.25366696037020686, -0.678648858697843, -0.711052546800215, -0.4039710289225898, -0.5177395617602617, -0.780424786981917, 0.3404641900694695, 0.23635377411098094, -0.5172913876939309, -0.6184665469459405, -0.8504563763902129, 0.6794155584010785, -0.2741177337556972, -0.6268026464036492, 0.4857054346256518, -0.41248643309906213, -0.35652094735147527, -0.4403959691799747, -0.5320473000644076, -0.6588491326093012, -0.7379806473613526, -0.5657180483923204, 0.6088306009261262, -0.8698799430926211, -0.7212068631048244, 0.2673530374624838, 0.5894311388232304, -0.6214397009255865, -0.3608222500901059, -0.7175896272738811, 0.2379670201302439, 0.5008876173935719, -0.653315216072435, 0.30882063823624434, -0.5385100304768431, -0.04319103559994517, -0.7084729367078357, -0.09488014763008626, 0.08622616914327366, 0.3557085723238826, 0.7105477623622702, -0.44132159234244056},
    {-0.054665143292067044, 0.37010381494873296, -0.2534335625792336, 0.3416106676238994, -0.49805888434401596, -0.8242412087837255, 0.5983791011215682, 0.5707176336176357, 0.6110858282257736, -0.4281100510099086, -0.7222355306644463, -0.26115924700015253, 0.6537344783559316, 0.38884349676982977, -0.6621999443366351, 0.4426025499628757, 0.5858661770925808, 0.38274905623519434, -0.5123487914245911, -0.4510665092135483, -0.6719496529351515, -0.15161714784247918, 0.6984914782325381, -0.6296375494900825, -0.5241496527641665, -0.5805860876037345, -0.4388318597240267, -0.5754712804447789, 0.4571746004355707, 0.3578544606387173, -0.357900255386831, -0.6477494648912503, -0.646132325850853, 0.44939787367209305, -0.26787810353573493, -0.68808032152249, 0.4997663850769575, -0.764270111414592, -0.3477488450741877, -0.4888584376445431, -0.7145263747310064, -0.8122328688259021, -0.6649619022136243, -0.7684693736289033, 0.8008760752597991, -0.7859233434026396, -0.5672816144107596, 0.4181375863355787, 0.4926461617650095, -0.3364525500413178, -0.2486274554394632, -0.3669022995381987, 0.5403388152129364, 0.3646185343466233, -0.6983091764427015, 0.503937565290311, -0.4827295680605088, -0.009093384188388011, -0.621781317917372, -0.024435577829687586, 0.14058816432365034, 0.3502730242756094, 0.7052248029108351, -0.6859612834735039},
    {-0.05165775464802288, 0.6975718018250681, -0.03934373023831373, 0.4849849102727226, -0.47406455025974625, -0.3205736287151242, 0.6458077050807444, 0.5047447921861345, 0.6281561200570162, -0.21963249917538713, -0.6775230485616188, -0.2198151258975783, 0.807145514391114, 0.41638269589199467, -0.6909420786462129, 0.49928549073422984, 0.5529491031885869, 0.49641100576570063, -0.6316379564539834, -0.4526364523034822, -0.6174860837450427, -0.24358483714909332, 0.38387497916705987, -0.7606976731011138, -0.9025012759187756, -0.3257808327229042, -0.9364829731167202, -0.7027236298579816, 0.23554439589069504, 0.2844494834098913, -0.5144959384402964, -0.597563170554545, -0.6571259500555782, 0.4146329807793708, -0.1619383336901915, -0.4395512830003116, 0.7090595261931242, -0.3684887239928125, -0.6015926966701362, -0.17572787608423673, -0.7666417954328869, -0.654892620585692, -0.7318259342405496, -0.6302872768903653, 0.5145423862467627, -0.6994236084555875, -0.5690309561391864, 0.45119502292129987, 0.28152233955248684, -0.6292893073207683, -0.4658098387698612, -0.4298353874476034, 0.3837906023597986, 0.01842755705033847, -0.6802809546092936, 0.23607550777615854, -0.563906189517171, 0.044052106376061814, -0.7017709640093762, -0.31647261022264006, 0.27944215374022296, 0.5611535897730395, 0.6440778430193056, -0.8153663277456068},
    {-0.06689201754107676, 0.504508159956986, -0.292064632546949, 0.46768911379587547, -0.8058833776866074, -0.5613198073784076, 0.5436319547649148, 0.5055720489135942, 0.2766819953466186, -0.4350107785087473, -0.48629676932607585, -0.12924250684090455, 0.8369145149215349, 0.09339706006518878, -0.812506463244663, 0.4872628340761782, 0.5041030375413924, 0.41473616559713766, -0.7037891009293661, -0.8031404266984916, -0.8068804428929035, -0.19542640316222984, 0.5529090261909962, -0.6480555191861145, -0.2092646013787834, -0.5029182594487681, -0.5211617856495872, -0.755436585632941, 0.35974389274651164, 0.24922334378145508, -0.25927153241433104, -0.8780914693776994, -0.7122066242960967, 0.35748209716441326, -0.49904280314233157, -0.17135686781590304, 0.8141069776653037, -0.4522667959263427, -0.4003968244382326, -0.4974314083407866, -0.796183867185766, -0.7202361844658431, -0.45745490158315366, -0.6037468945901513, 0.6456146701142289, -0.8294070271032318, -0.44401006963380585, 0.4478867899874831, 0.6150011882082473, -0.5234855867393634, -0.19498146894373425, -0.7560736120101579, 0.5167735760092841, 0.3197281544315113, -0.4510216823225037, 0.2476248088716974, -0.5854363904562302, 0.12288839536235012, -0.8129906307291725, -0.22537461508572393, 0.08163194847960743, 0.5386357020991593, 0.35417640794159455, -0.45077944130559905},
    {0.018240115673097766, 0.4737198094870704, 0.0005715215773277404, 0.49816693760163977, -0.8436725225747997, -0.46396412278063137, 0.846743145094144, 0.7966978056949079, 0.49742276127561236, -0.5915018795967423, -0.8514202640711432, -0.48997509588394716, 0.6993077697948512, 0.5432147245711493, -0.7886879028821606, 0.32020007197405065, 0.26696745197387867, 0.29065904081438343, -0.7931622254380248, -0.6402569759798163, -0.7653785940016375, -0.5987003486242801, 0.5727232165731073, -0.6486135038579841, -0.5388889996868063, -0.7331040866917944, -0.7626422595278962, -0.7615662930535484, 0.17370752013987203, 0.5525541463898457, -0.39723141114313215, -0.6255287670430292, -0.8311020042926858, 0.7205065508203422, -0.38864669407079544, -0.6799826924790315, 0.43338019040943837, -0.47321064572195287, -0.5772114063232091, -0.47927058111216153, -0.8047909462477958, -0.7390239919914154, -0.5235913573985304, -0.7229614291144838, 0.5234769558445233, -0.39067292652675517, -0.5342023353535829, 0.4280362027677552, 0.48259985434245367, -0.6195428333194746, -0.4555220837705326, -0.9500139380261103, 0.2636207621342702, 0.33476201080482626, -0.6886093372481775, 0.38113091652217107, -0.5210168449954965, 0.03363458767375121, -0.6927535447010018, -0.44116435004891225, -0.027413059145653815, 0.2172084039909655, 0.44257567818728344, -0.4117137802567614},
    {0.011515919808316715, 0.7576644866726671, -0.024494087650573572, 0.24647345628664075, -0.7681845291097218, -0.5037094754168895, 0.4967812077089201, 0.3201289862742331, 0.5630386452328204, -0.3968623678074067, -0.7155920359891231, -0.1946303286261349, 0.7976753282454633, 0.7653145478463804, -0.5884488710361743, 0.6525656763166084, 0.35271086882423175, 0.32496919990263984, -0.4684537991379571, -0.5770047964127848, -0.7375499836973922, -0.23070278606552794, 0.6741238860320399, -0.5491775288264213, -0.6456467943168128, -0.6599266062062139, -0.3817774853489587, -0.8264124354760936, 0.18885826595457358, 0.3670882634936652, -0.3880874555100777, -0.6102315936948574, -0.7978804210844179, 0.3992216177603154, -0.313763230434109, -0.637398907563871, 0.48139476640515, -0.37439629117989365, -0.48458914089387545, -0.332277149837679, -0.7656691171828903, -0.50617655686639, -0.7120036606330432, -0.7353968305267352, 0.6108118311123416, -0.6163540850321694, -0.6254144435184273, 0.449956770228817, 0.3589921162328587, -0.60297273390537, -0.12226678510671828, -0.7209732949059575, 0.29707761145922135, 0.37986210723022856, -0.7684635647151707, 0.17891457976062197, -0.5063130085752289, -0.12789172056420936, -0.4384848870478799, -0.5442565932199463, -0.044743391724026076, 0.4010517737999691, 0.3988338903991264, -0.6376460814923345},
    {-0.3557360310089393, 0.6608267261372234, -0.2104648383948608, 0.2967382393118282, -0.824558798744844, -0.527439132346911, 0.3425988152676335, 0.5887641394498518, 0.5358165877636027, -0.47884687799907216, -0.8301412060412963, -0.3603538894681865, 0.7188595912920248, 0.40007851419426493, -0.9624629904476736, 0.672219898818925, 0.3890873749706202, 0.3532229161131551, -0.6529160174593901, -0.6395740457831504, -0.4638989190420924, 0.018273061556378017, 0.2520675500694011, -0.7516111804815856, -0.48881420220196187, -0.6209764083804171, -0.46126465717853504, -0.608169003515722, 0.3871519241548836, 0.44761627052888786, -0.24884491943933434, -0.5486386900520421, -0.8909770583503135, 0.5253305124435874, -0.5664932242086561, -0.635526407458508, 0.5438334326015983, -0.47251216654038447, -0.1562261329836195, -0.27118066484211356, -0.632408908237402, -0.8254094849481728, -0.46040221475069215, -0.4737236184563789, 0.4809480882046414, -0.5806059552643933, -0.8433409899862553, 0.39076659959641596, 0.26586471024439506, -0.499310207228365, -0.0552980586951923, -0.6295249445183189, 0.3749727929278694, 0.07006233137661344, -0.6387000209170908, 0.3220089440050178, -0.6068545340142317, 0.04431710228818744, -0.5670857474211436, -0.5261540830928343, 0.00724538812189312, 0.4756311151590993, 0.23458558052637934, -0.7462039653643823},
    {-0.38739230139036357, 0.47750968359441665, -0.1237483817320107, -0.04944937083306873, -0.9046767699403775, -0.45069084699273315, 0.566930659874415, 0.7278171469926267, 0.537413684662334, -0.5618094490669004, -0.885731791855815, -0.371943488250966, 0.3406962513661219, 0.2874214259048178, -0.8084724369973976, 0.638438283181291, 0.359547770859279, 0.2261697539968572, -0.682224834086005, -0.689319958295087, -0.7529682952059652, -0.09925258504584128, 0.6369755220899714, -0.8187710555359518, -0.7532866695062111, -0.7973682191816258, -0.5108165403436925, -0.7244984471791392, 0.10474186836817433, 0.5195365158676669, -0.46111171993155287, -0.7455988597829302, -0.8056031704954001, 0.4145608272445712, -0.3520951153804124, -0.5582084915375297, 0.6880847318295004, -0.5485477941128862, -0.45952112370758796, -0.52036727671542, -0.4875644726973136, -0.6662703138652583, -0.658262659308297, -0.4708313345074927, 0.3109644065035235, -0.7391778526632542, -0.6162681831024329, 0.5009312692628969, 0.24103530963563213, -0.5639162085231458, -0.3956643413862887, -0.6768233375606442, 0.4054859320455074, -0.01817154250932353, -0.4461474320822827, 0.06462421608049174, -0.30378358464652183, -0.4344273187055165, -0.5041889264747008, -0.3245983494163228, -0.12102074600305153, 0.5441598163086185, 0.32329035281861235, -0.4627318159296704},
    {-0.41324598382418876, 0.46137016329523745, -0.09096397364160617, 0.2599647975970449, -0.9667932025430099, -0.5159194325110616, 0.2220828985570664, 0.5889147941711392, 0.6558295951807889, -0.27899821057633784, -0.6589985061586384, -0.14752341785909798, 0.777114961506176, 0.2545975772560709, -0.9551962532504712, 0.4981656411329256, 0.48030997003574577, 0.4802709718924725, -0.7306794582669597, -0.4700535006878642, -0.3973209713900725, -0.17342576177970345, 0.5449804854495629, -1.0156035974018733, -0.3419937817543996, -0.7872490873355061, -0.8413109186879435, -0.8157202694178828, 0.36042837264746824, 0.37716243175332403, -0.39049220199309215, -0.6196023750047734, -0.7001531986911893, 0.261766740229071, -0.2894717019543029, -0.452176524283745, 0.5558966744932888, -0.31406200970674514, -0.3079246894674956, -0.09068658892317015, -0.7822359730890349, -0.7905425878565923, -0.6025658605948285, -0.842171266367516, 0.5051336524911229, -0.5156338999908947, -0.5833911606521445, 0.44437004368103966, 0.6014948443110731, -0.6259842592994727, -0.362055218382787, -0.9669314234617936, 0.3385815583297124, 0.07769749553706368, -0.5733062563000139, 0.15383118541495644, -0.6135013589356264, -0.09958226790620182, -0.5099684342178163, -0.14825749359731247, 0.24764237777786322, 0.46818330604173947, 0.3421422529672185, -0.4835923383346516},
    {-0.1303765181516338, 0.3065677793686056, -0.2511723831691152, 0.434980965739311, -0.7534925504292321, -0.7594610264809752, 0.47067733612470114, 0.6520426479233619, 0.5873036124389269, -0.5660080007933685, -0.5937161817855098, -0.35277508352737696, 0.5254618241688687, 0.6114321388711171, -0.9671265271835738, 0.4788297145512003, 0.5735355540925282, 0.02269714583935164, -0.7159325430006683, -0.7285580642560812, -0.3899896999698397, -0.08698511141773968, 0.34531649361145583, -0.6437097645805337, -0.7515633919164316, -0.8449195513127782, -0.5325669111622072, -0.5832482935904307, 0.4742729597973878, 0.009088940110855759, -0.3543849953930277, -0.5963407274305778, -0.25969245345835873, 0.6183593139488927, -0.527050160488866, -0.5528502464296049, 0.28259107299233444, -0.3753258006461199, -0.30363102369232536, -0.04652332720687473, -1.0376984950704615, -0.5724963077523766, -0.8122514879028573, -0.6859953381867611, 0.636194959476199, -0.6978827929217056, -0.3518993486760216, 0.2877272719983212, 0.4288507430710803, -0.26357003238162297, -0.3135414750383584, -0.5797398110259672, 0.5757679237112654, -0.2612390644797299, -0.7206151368080693, 0.34827532070250444, -0.3729154467303193, -0.37402164738994415, -0.5283113362489066, -0.1387332709291834, -0.12451401740412764, 0.4854141488906068, 0.537634570334903, -0.6945098417440759},
    {-0.287026682623544, 0.8779888752371354, -0.2260746741796133, 0.5528914248448639, -0.7742680258021525, -0.5098408618096372, 0.6329840003868905, 0.6986546262829016, 0.4720614804487577, -0.3112739537990074, -0.7578553831412902, -0.09720238795961199, 0.4769526876537703, 0.8220788609700062, -0.6432333059933077, 0.8187914768755227, 0.46907859174013566, 0.3410314841375271, -0.5579869298457779, -0.5579678643058578, -0.3565888224921215, -0.012534605726725085, 0.7171075151661355, -0.5311290889720836, -0.8816774976798979, -0.7379034953365582, -0.5273170164575025, -1.0164200817033298, 0.5973261677745, 0.3523430479717777, -0.47122671994726123, -0.7907048482159774, -0.6368720915057521, 0.7293521595293521, -0.4564023154706698, -0.7577345366818916, 0.5688584362814393, -0.16633631133475232, -0.5898468997649096, 0.0024472189954325148, -0.7334981545334733, -0.7210857057494919, -0.47511981314241597, -0.7036618646758895, 0.6927513790139587, -0.761165316811042, -0.5152311167651964, 0.30055661847046783, 0.3436786690540099, -0.5007033545681496, -0.231430209785687, -0.8036621886030877, 0.5451478733234804, 0.2690755747853516, -0.49787029856487947, 0.44444756413333086, -0.6565151303863843, -0.03156968839071502, -0.49711694459791494, -0.2137408659355535, 0.22534261887500498, 0.6970471598354196, 0.5900197964491999, -0.5355618846965393},
    {0.20674864687746908, 0.8241589823696885, -0.20006585668297874, 0.4079850690396985, -0.6382575386917342, -0.4437511611864002, 0.6295878489520909, 0.7252388996484433, 0.5256036106757304, -0.3609117303095697, -0.8515596076906354, -0.06322846356345399, 0.6140804182750684, 0.7285612257339258, -0.8424825938999345, 0.5353902221327407, 0.6644766300884373, 0.6979590552971636, -0.6989188831314038, -0.8127776018442103, -0.6152825180536756, 0.1612968463595089, 0.6937144848132184, -0.6195143677194526, -0.7803988959298049, -0.7364826189654081, -0.814746953910459, -0.8673142394899724, 0.3049624936773307, 0.612349272022507, -0.2972428426849597, -0.49259951995970325, -0.7034538164001217, 0.6742895368067041, -0.4213122542170976, -0.5834804220283358, 0.782221918300397, -0.31359113922456616, -0.46680415529844516, -0.11448094538759045, -0.8237618222327405, -0.5445583124692415, -0.46751526118661185, -0.7429822172614424, 0.8439493801281709, -0.7207664155257618, -0.7701419866273662, 0.5675568919505093, 0.7115629335715238, -0.7031795125546878, -0.008813934864396085, -0.5496633247637166, 0.6482416585708689, 0.6052159910086731, -0.5764614872062583, 0.3082331332255578, -0.5044984740793137, 0.037434617759633596, -0.398595183969583, -0.034627525088773224, 0.18499685073491864, 0.7927695088864265, 0.5868455127793664, -0.34055369642193145},
    {-0.0008671815918216823, 0.5246889152788945, -0.12441928000517333, 0.6385831937223145, -0.5478941469641883, -0.4705926957386043, 0.8394428328441509, 0.6598347055057404, 0.43064240328633585, -0.3426492958873758, -0.5701521918414711, -0.07138515465454962, 0.6215286759262362, 0.6631126719458302, -0.6303246118371867, 0.7247950308886345, 0.6521965155813768, 0.6528142979005198, -0.5509366993512309, -0.8671363707233276, -0.39419913040500804, 0.13465363781065784, 0.6604415378143184, -0.6189174284839603, -0.32001596597482185, -0.7450759346780199, -0.4920314309382097, -0.856787912415096, 0.31509399948280764, 0.5164090635113079, -0.6067608799260914, -0.5194304174555997, -0.5097100169123056, 0.31657670875605537, -0.5726100229792703, -0.27073093482593347, 0.73112827098129, -0.24381155589009237, -0.20679768527215855, -0.11678770105426658, -0.8936225463878354, -0.4748967126460126, -0.7756737202830113, -0.4292845407447744, 0.6052069558861021, -0.41800638322205513, -0.6973832186572362, 0.6828659526836477, 0.7665111714549151, -0.5885770558201096, -0.29734093426498404, -0.7978923111181213, 0.6827379414892553, 0.15943349018698863, -0.5712576131793197, 0.39604014679958816, -0.4701710094337375, -0.0018443320735782968, -0.47015196260915276, 0.04038760884859631, 0.2984996479208018, 0.6179748722667675, 0.5968788463576199, -0.41134803938711106},
    {0.11304206456067464, 0.7535478522042693, -0.017834697948365386, 0.5097728803837551, -0.7405517391658146, -0.480733569347413, 0.6856108143741251, 0.5137640892051879, 0.6094971043636644, -0.3362954527856102, -0.6764817699475987, 0.039998657000592755, 0.6194134177375439, 0.7021161338155771, -0.5999635050788453, 0.6170794434834661, 0.5802821831407132, 0.5351549856858433, -0.6671545120470105, -0.5687474428346158, -0.5319611185702273, -0.041245830929101564, 0.4469927778350923, -0.4248904525261567, -0.6391832761662833, -0.41129445724607827, -0.36148225338458523, -0.6111468686839531, 0.3639767660840022, 0.6342170612588082, -0.30868661753634047, -0.5394612457719774, -0.696222945582002, 0.6812439205474005, -0.21546677600601485, -0.6029660031042514, 0.7663050562478495, -0.05982638766631496, -0.24282025434576351, -0.1929096508256014, -0.6400910776098008, -0.458570648673984, -0.5691096375571911, -0.70734899616082, 0.8074763445220804, -0.7352287241614851, -0.5936534993645329, 0.7235712341303318, 0.5789165228959273, -0.5609638152413536, 0.1564411008082589, -0.47139122623012436, 0.6024122420318336, 0.4103873561861628, -0.7036749458179321, 0.7010631205762552, -0.6004570662935692, 0.10071809597601128, -0.4690187006612178, -0.41887930663613543, 0.3005303653928417, 0.6114404223238351, 0.6934486234976457, -0.4333194873641199},
    {0.020086641755025444, 0.5972055676179268, -0.1956422383526487, 0.19299312261309795, -0.6445131542442127, -0.3638399633770804, 0.4595617257376448, 0.5040499258414186, 0.6991103014977574, -0.3431740680625636, -0.6207831227767613, -0.3463104671456833, 0.5962747539857065, 0.7642475165526535, -0.5543657164777414, 0.723424477629013, 0.6134652378426626, 0.6054583290234075, -0.5706647563324183, -0.5603379881714579, -0.49197496932575857, -0.11534390396076444, 0.4677153202770025, -0.4232723727965878, -0.42955668824511567, -0.48738193192558626, -0.4430849707463693, -0.6973927728399194, 0.1453033055575074, 0.4828104296747408, -0.6684696223934762, -0.5231385646766047, -0.7051412726188534, 0.6409373674685045, 0.1534878226818678, -0.2300750919280472, 0.6168816831845146, -0.4002749933844073, -0.41125804441096697, -0.17849822707789184, -0.7080680709197301, -0.6506492211468387, -0.5394096519741239, -0.5359152477266597, 0.4660658138927134, -0.6474192244977055, -0.6203180082141064, 0.6387672396779055, 0.49363733596074805, -0.2975413459181027, -0.30559351818913305, -0.802912696257152, 0.38992605646880957, 0.2259778600341365, -0.5872587450829472, 0.4837276969791063, -0.5787051976210792, -0.044076698186949155, -0.5123611960888151, -0.36166952080628983, -0.296164049474077, 0.6970983222383235, 0.3899614411999171, -0.4273777046487314},
    {-0.10474033135702418, 0.5628120026110575, -0.03022621481939153, 0.16945938996407814, -0.5924009446185098, -0.6003866033813695, 0.6895862103886159, 0.7030055266753705, 0.5086770498856041, -0.6950297788948943, -0.8430033033379236, -0.34802135587895816, 0.7350462071856572, 0.5683360954296143, -0.5947424400983833, 0.8161819437682617, 0.5016377787364951, 0.6132819282221189, -0.5806538988880293, -0.6217797016455138, -0.6060818904092933, -0.10237261402411064, 0.3119960879761436, -0.7789734114980204, -0.5390189633161452, -0.8384265991874242, -0.5559823488215061, -0.6586005189149973, 0.37459102392557764, 0.22576820446022908, -0.31283397696781223, -0.6207749724470856, -0.3693735571148619, 0.42718384543596094, -0.21520439538262157, -0.7034467712667513, 0.6328503424059543, -0.4942806407811246, -0.3025792911500763, -0.16904898899894394, -0.7011642140268738, -0.9101638418526659, -0.41767805962614374, -0.6554333558958172, 0.6844366113756802, -0.8723347902457402, -0.6381241938134724, 0.5735166764374688, 0.8518544420310585, -0.6868430451098213, -0.11416940991203735, -0.5538312494274613, 0.5142981546125157, -0.06814426724871613, -0.8393404048858286, 0.4679915711475255, -0.6684792777512399, -0.3981673744715804, -0.599468172522381, -0.3041150588607882, 0.07609794130991884, 0.3967188841912572, 0.4723703505530679, -0.5906781242519603},
    {-0.3819501160261522, 0.7994950937944648, -0.043849620620917296, 0.6379817278641646, -0.5354007231846307, -0.22657049573105117, 0.7530870696282668, 0.7851356697729457, 0.6289371524486732, -0.41272531589916334, -0.7990928161742898, -0.08927702141317605, 0.5754999588629365, 0.5173830055514075, -0.654749025939373, 0.6662427845823677, 0.624930899262502, 0.37370244559310356, -0.5356884284050925, -0.6533082802523839, -0.6149407416575071, 0.049827960089950815, 0.6852341476554747, -0.6475557116901758, -0.7495795973658976, -0.6758335080767058, -0.46965018697168365, -0.7107748070290382, 0.3603761217414945, 0.4687858557114805, -0.4655891382645058, -0.5715270507325706, -0.5887698579623574, 0.5785820576388119, -0.5708038101051313, -0.5444985526467074, 0.5594614925418262, -0.4096939173857168, -0.2789757690554593, 0.09991451479910676, -0.7599264569313448, -0.604832284059054, -0.6033846846984237, -0.6752148249909145, 0.6760691826568307, -0.6493939539144089, -0.5354560660518592, 0.4864299666944217, 0.4011863983758832, -0.44400916721247663, -0.21646092751555193, -0.9445540044072307, 0.4512831596762894, -0.038023785801519834, -0.5852547938236438, 0.2370051217901144, -0.48347334591876956, -0.02907672876561022, -0.4583453213717507, -0.5947847334251988, -0.03822174562184202, 0.6367024586730037, 0.3827730460337827, -0.5208228624007211},
    {0.1201903436173977, 0.5345800317534594, -0.09547052404671784, 0.31831665462623765, -0.6467866853077775, -0.32438140302647217, 0.6220878706814811, 0.6063219910171621, 0.7004155456101138, -0.22859563664630325, -0.6658651229820927, -0.24674679705571714, 0.6542793745711679, 0.8291897484332841, -0.5261181155788849, 0.5707040778857972, 0.7420839797328886, 0.6773433240559474, -0.6714618766162433, -0.7368563633074775, -0.46449744065676, -0.08635988986806582, 0.4126796107604815, -0.7114065413042283, -0.6444837985326958, -0.6137461844871983, -0.4358377651202184, -0.699644011682638, 0.6444454475078326, 0.7682368374766155, -0.3594222801004569, -0.38863607291714286, -0.41955055094862503, 0.6564710063149031, -0.5305617855401956, -0.36110276899846677, 0.841802536146913, -0.26491557155309226, -0.3394668333429151, -0.2272876691619702, -0.867009680798747, -0.6996141619923698, -0.8038366522256593, -0.5928581634743925, 0.6370217671137764, -0.6428441076375898, -0.37524987487666367, 0.545602661556952, 0.5168638403652276, -0.6467528997444574, -0.21529309049977408, -0.7955358109269584, 0.7980626858199327, 0.22689955506399234, -0.5243417213238273, 0.6708266124747796, -0.48683759973519036, 0.08110173055731072, -0.22709934663109932, -0.06268313603238071, 0.06958844677892666, 0.628630227094952, 0.3939194603366529, -0.41326599976088735},
    {-0.023128482161466797, 0.6772847959298715, -0.18792052325123507, 0.24592471141400696, -0.8516856134135716, -0.15480533494657192, 0.7411955424601004, 0.6611289400889756, 0.4118915997350446, -0.3199130944091177, -0.6187601986688983, 0.08352981923032315, 0.5543904628188658, 0.6564520766289396, -0.5043827022613327, 0.6933513364101672, 0.5275631128900776, 0.5930663741609504, -0.5794083045940337, -0.6969788726352433, -0.6402692703917907, -0.14548872364306337, 0.4825010310016691, -0.3496575916170633, -0.42061458385058975, -0.6856474181353154, -0.29718273367568904, -0.4503849938851432, 0.301307975235299, 0.44503471170586695, -0.39500044881081425, -0.45269765745166674, -0.4509733614896548, 0.5928420288885216, -0.12610305980390984, -0.6317130248980691, 0.47353454139871337, -0.31079664767585097, 0.03560140233839265, -0.1330317883519261, -0.7157338852888419, -0.3216951296384494, -0.38746330318852634, -0.5756753824365775, 0.5565875981892606, -0.3616210547443453, -0.717035174409136, 0.6921070258073243, 0.8657215943857169, -0.20811651719313484, -0.24580954830164986, -0.6263883188351933, 0.5079770908576204, 0.27519749777778757, -0.3794376876813422, 0.4627497851984584, -0.4238982357299295, -0.19448346030375643, 0.05148752202131743, -0.04855796194900357, 0.1064460215100903, 0.6882710693457768, 0.5274072641135249, -0.24774790312270106},
    {-0.20760778861345636, 0.8075791962448536, -0.1380837824450347, 0.7039506979477652, -0.8181151179974501, -0.7074250090489572, 0.5997202146673617, 0.7635969419164291, 0.6421588161075757, -0.4751948615004494, -0.6970070196252064, -0.15100094100285968, 0.4280571865911378, 0.74601691486225, -0.8321029823273527, 0.5996958596567583, 0.6056142744733165, 0.3446847162764094, -0.4833396030386358, -0.5899299304016996, -0.5312231677717947, -0.018689147785964765, 0.4608492888230437, -0.5201543640592428, -0.7279713555941275, -0.48635551722060066, -0.3739216959167182, -0.8275039042914822, 0.5120373219002101, 0.2638974808166309, -0.4742978332421758, -0.5698240752316923, -0.40506738555121735, 0.6311317801195291, -0.16914524300948033, -0.4331341450187294, 0.6628518301568546, -0.5470018314301488, 0.12443186599937026, -0.07292085345386695, -0.598267116812627, -0.6075138114893409, -0.7224876463424761, -0.42497344607618653, 0.9004281211880079, -0.47171926678990833, -0.4667503725935126, 0.40558275170256547, 0.6305993701869851, -0.6755673447132665, -0.135107183527964, -0.6541250973342772, 0.5951773543980357, 0.13509079370668314, -0.5135653340059185, 0.46407860300195575, -0.5147127012336513, -0.2555187555738118, -0.4649199117666008, -0.07933065087687217, 0.3681363939784172, 0.5506840538502991, 0.40444161230742215, -0.43503027064605637},
    {-0.07473473697603812, 0.5805880528190829, -0.1626861128593307, 0.6775550909382312, -0.8548085710613864, -0.5009156867697993, 0.5908779037537103, 0.4254082440571135, 0.5717991455218401, -0.4038539001946415, -0.6458693441641982, 0.1034620512987853, 0.7366324096914366, 0.5703070704003942, -0.7778213446956663, 0.5349788561864716, 0.8657597475109731, 0.27327348932152307, -0.6816312828085186, -0.8083498889302123, -0.3389224815454472, -0.08679456770382496, 0.556995530678442, -0.4891770032688407, -0.5633178241658868, -0.7687934085475063, -0.2209397617040707, -0.9175125814689772, 0.3731811977677385, 0.6005612830081236, -0.444361393422045, -0.6263823271428146, -0.45017571026576986, 0.669484979384966, -0.4510584351720632, -0.4820006605738049, 0.5083736745014259, -0.42867682138761454, -0.05892509479465305, -0.15165283483104394, -0.6883726692893205, -0.6120778847939236, -0.5515600452869716, -0.6604905444006808, 0.5700058912609023, -0.6841049906915536, -0.5157387161059536, 0.523147513587861, 0.5533192481086079, -0.4342050882914878, -0.2757021524836696, -0.42233397180292404, 0.454134300289034, 0.4305976002776342, -0.755374746885185, 0.6308832742075428, -0.2939408588851232, -0.017484160471435826, -0.17051682961236816, -0.34905066207853486, 0.2509009192435924, 0.535006556671775, 0.2824773551226084, -0.5462410509278585},
    {-0.22049411946426503, 0.409682975783309, -0.2711488613688806, 0.1796110936082482, -0.8169676770981255, -0.31896051562473376, 0.6945322547989545, 0.36819837633166225, 0.459007386167545, -0.3435961253653717, -0.7079267738459949, -0.3587121946758135, 0.6515623506948593, 0.41587466578748916, -0.7330600083380887, 0.7233083122015596, 0.5832465906040984, 0.43208352727637706, -0.5149539126427022, -0.6009228304383958, -0.5663829587822692, -0.16478336055777945, 0.5590019956413504, -0.7016401949862812, -0.6222995568966361, -0.6716712923740682, -0.391995964047433, -0.6985054757532088, 0.6141727539801369, 0.3683310966466572, -0.6939094478668163, -0.3538313561969284, -0.30559737043995133, 0.6128699995822503, -0.16699946288208736, -0.6541618742297743, 0.6349896766895377, -0.22232467117028704, -0.14425946526235725, -0.12483765864596082, -0.7854340756033549, -0.6814690258425018, -0.8411339880968367, -0.6123347893081947, 0.7823740992828648, -0.7326641856066735, -0.4404353543987234, 0.27197248194472373, 0.62991567484579, -0.6863427582737197, -0.16458019025771087, -0.7157789946864572, 0.597776206426012, -0.07419634630434967, -0.5950606336878552, 0.6452375088968615, -0.49828346613588176, -0.06176409399430742, -0.39125005406722213, -0.3453373032499329, 0.015129126355367273, 0.6404001866270924, 0.3111948301728593, -0.4161083668174392},
    {0.07699583654260095, 0.3928614150623268, 0.05015805398136535, 0.4848097776865557, -0.8201639760611976, -0.24523243853553173, 0.5322269708816784, 0.5760662445329923, 0.4090314984575801, -0.132604069840387, -0.6233059066832022, -0.45287242074970646, 0.6067782944929245, 0.7742720799282201, -0.6532416781272059, 0.7610968789692839, 0.4696170296394958, 0.48640288686932504, -0.7734404309408005, -0.48774701392538894, -0.5715517219202474, -0.21421419663951582, 0.4219286638102108, -0.6605668694659038, -0.31506602258714705, -0.6406531496754926, -0.4934426341309133, -0.7124338780879897, 0.5598715001221071, 0.30943448022427594, -0.5585679765933251, -0.4742838782038184, -0.5863659948551075, 0.5824044589097074, -0.13468496981106287, -0.6582301526252918, 0.802714449975094, -0.2685710151220047, -0.38533651673149805, -0.31430606594697, -0.7047439411988583, -0.5904774389421635, -0.6874675170363257, -0.597003196742597, 0.6743005535973206, -0.7864464706665935, -0.5834923991177932, 0.6098981813108235, 0.5700297389571353, -0.5598095761659891, 0.07458091907858234, -0.7923196953821794, 0.6204246647762583, 0.28640569256924825, -0.38724627732594213, 0.1939803336673737, -0.5185771677750487, -0.04631041633328289, -0.611444056053031, -0.036153557291871585, 0.24124584634101218, 0.523398996163021, 0.638385895709785, -0.6232205774575783},
    {-0.17094760225277464, 0.5018578524863099, -0.053560208591314065, 0.3422169443960281, -0.7044714030327286, -0.5207493806773175, 0.6444176440773771, 0.6776925952544098, 0.6182669050452947, -0.2552042169076167, -0.7953751717473335, 0.011800382793354701, 0.7437380363442241, 0.7447678571017334, -0.5018839530289344, 0.6222120157382798, 0.6305063926290839, 0.6848234638052197, -0.42537569777996553, -0.7204603751180535, -0.7712488202509381, 0.07019047343350068, 0.6313518638080753, -0.5520259456261333, -0.8505459813653032, -0.6090730730673468, -0.524703631274595, -0.5654160913073379, 0.5635071230005245, 0.4667996540039533, -0.40780392737987115, -0.6876680304616227, -0.4427314830704271, 0.6557202752579915, -0.3433801626298886, -0.49280102783685226, 0.7279296375915818, -0.16329152478069156, -0.27952185415057296, -0.0025939610888496426, -0.8539739508678527, -0.6355415810201723, -0.737319150984762, -0.5980263704563561, 0.6216837870825004, -0.7594812299071565, -0.6912480605150068, 0.443935576352207, 0.40818282394770095, -0.34989320621660347, -0.07220009254225558, -0.6502406962581848, 0.5329364438020279, 0.24535886193570194, -0.7801263655782551, 0.43203730104667853, -0.626040946249509, 0.2118028250336041, -0.35743542929050426, -0.4232870450052263, 0.09378420540002372, 0.7745780195421416, 0.6538001763002349, -0.7364765341002905},
    {-0.0346268055062803, 1.0849172418125896, 0.028401446641942267, 0.40355142317129605, -0.9258693903853341, -0.38598817832743954, 0.7745307756719234, 0.6715587604476118, 0.5565800532196834, -0.18408205962046736, -0.7263117043451668, 0.14280917253030387, 0.6044827532720537, 0.5534041726032453, -0.4644631495580815, 0.6889424823179988, 0.5955733257139355, 0.509287939813992, -0.37282482308020304, -0.7895749302142632, -0.6606984205426707, -0.2493806308593418, 0.5176974788893243, -0.4655491755692112, -0.6767939263906824, -0.8348159776434079, -0.3406804748147768, -0.4412907268236038, 0.42174566351506576, 0.8072978892726344, -0.4174796934477906, -0.4424578987058471, -0.4552570050778205, 0.7541410597964016, -0.29703126050671536, -0.6281298884400544, 0.7943086257075853, -0.4406892073289574, -0.26657257309292914, -0.18798493495516033, -0.537851436799245, -0.4411139413015883, -0.7626629415360677, -0.7342427903108892, 0.647408008591299, -0.6251568239713062, -0.5719949344843609, 0.3849643393138304, 0.4580533330527788, -0.3437377148093254, -0.03912081819913325, -0.5141655776548091, 0.6771821911347836, 0.18397960187513335, -0.7665450109726, 0.735168074435364, -0.5553272055002272, 0.28104401107326066, -0.17515489020340358, -0.008867360315281755, 0.1813921679883856, 0.67364584952149, 0.8266940635927861, -0.5125645614005582},
    {-0.04990069876876456, 0.6141380498610093, 0.031990924558759556, 0.6501569468681695, -0.8863435335932709, -0.32751805334872364, 0.63859319068668, 0.6808679430631824, 0.7005668256416641, -0.02940465777194513, -0.7782551092253723, -0.015452039793246828, 0.8203701186240768, 0.6942894216820961, -0.6174009315011691, 0.8961110273433475, 0.6621227172505788, 0.7405283405635936, -0.595522588051884, -0.4357797214047678, -0.4771774132341638, 0.12894018847736544, 0.5314957570551248, -0.5020052982098255, -0.7447911658877058, -0.6542044238750773, -0.11607135957592676, -0.4853341334804587, 0.3509179256859129, 0.34899763188536903, -0.39456534331572146, -0.2876108494240791, -0.34842464014795044, 0.716577407519114, -0.28018082110088555, -0.5071983646600894, 0.8252814449445453, -0.42192769472644653, 0.10036826891783912, -0.06403935957440075, -0.6570632334308052, -0.7757814364486211, -0.570807778966135, -0.48095638103034716, 0.6067370789026623, -0.8504308670043264, -0.606327304125657, 0.41038489492064717, 0.38959778329584616, -0.782056430504671, -0.005546681384124539, -0.5845900670771726, 0.6491984202406751, 0.16201454324413175, -0.6861086700203728, 0.534105295012174, -0.5308316027789154, -0.1905815021445697, 0.014978980220919817, -0.08964597348874187, 0.03018672160280431, 0.8174076021211303, 0.6352849710636788, -0.4150619235461309},
    {0.10930078591570505, -0.5670133870427891, -0.16852525343945404, -0.42040530923219, 0.44113898966233117, -0.41098151991293524, -0.6645028476010327, -0.4533158516206866, 0.10455934643297458, -0.13100553613576135, 0.26509452371572023, -0.2282146402179765, -0.3278129900748466, -0.4426576963911807, 0.03356880208752864, -0.17170998946656205, -0.612241383544698, -0.1853598086909414, 0.027040681977897, 0.3503527895781914, 0.09226727550219344, -0.23840976081647222, -0.42846551864126925, 0.41118902035603183, 0.24375299332747064, 0.41929918245683506, -0.33859838673507175, 0.0851587243899643, -0.6455850371218331, -0.6812866780937923, -0.15937712798007572, -0.11555889726422418, 0.7407860802683873, -0.5680139326501537, 0.4330170983010766, 0.4833748654580016, -0.5104609278690613, -0.1971621962702978, -0.7120876991422411, 0.2783268566677785, 0.04495214406600972, 0.3627508664694789, 0.30101696107472703, 0.055271533260482064, -0.3719171701485447, 0.17375014596567084, 0.20563865259176545, -0.17710652113089964, -0.32044701329343606, 0.018503390971783825, -0.3418424347579928, 0.30479295292404857, -0.15568667159080612, -0.36344601471312826, 0.5445526278293233, -0.2786103676383682, 0.1527111281356478, -0.6475378199355563, -0.10467844286922763, -0.15694962910708724, -0.3203752240181432, -0.19861425169043484, -0.3667714252112323, 0.20086340048662157},
    {-0.39663132039891497, 0.26177130165553797, 0.014788526156225588, 0.19312994328574576, -0.6270349623517336, -0.2359083840406659, 0.021618563840267054, 0.34779013237509276, 0.20494991301375726, -0.423794153049503, -0.47930016962157146, -0.05976967580594385, 0.45749978731243923, 0.4879665698117453, -0.3305328744595576, 0.12231641552779746, 0.49664003689903097, 0.3056577051229236, -0.2739197797112382, -0.1433427596483277, -0.4653741495762462, -0.06683182860058126, 0.28782198194604675, -0.23833606802205978, -0.17667765023608917, -0.3867141229958574, -0.138809606688444, -0.14300123808905854, 0.1590013100477225, 0.4286338513648397, -0.4851228389048454, -0.39905628709243385, -0.11812770212713289, 0.2028759366822828, -0.4586698492332461, 0.030761830225393548, 0.32178701409805127, -0.1270932378659917, -0.10171998967469946, -0.08211174388750997, -0.5640459573500421, -0.2167220588032766, -0.22223923893799535, 0.043772750622091294, 0.49076001057559426, -0.45610889843447194, -0.23633581822435665, 0.25482523772506316, -0.022618246834151257, -0.03068657978757988, -0.2196567011843157, -0.6559470546521838, 0.050467723528290764, -0.1821974542874415, -0.4058095535772725, -0.23369789696596302, -0.5413447112878712, 0.022454942333312113, -0.2468432933762024, -0.06630499700409287, 0.16026869729351803, 0.21116172999220736, 0.21692119564076204, -0.6073999795563799},
    {-0.3029202313899696, -0.06643027262452876, -0.42407552476936744, -0.5925546898104375, -0.04313679620853795, -0.585830206604711, -0.2761087140459335, -0.32703141058359947, -0.07777155114680809, -0.44931923269663043, -0.3775532782672819, -0.680576402742464, -0.06515860174554178, -0.4219351302240955, -0.5658868219750328, -0.3506756855361782, -0.10875876050939483, -0.048848162279141696, -0.5917174000445418, 0.054025596381412855, -0.2476169925569581, -0.6932879650753236, -0.07345438377670355, -0.13989256298947772, -0.06338979312013801, -0.07087701393400309, -0.5744648649517665, 0.09779777895930716, -0.343777094615982, -0.2853439150093872, -0.49773310020866485, -0.21042954177891066, -0.4016036184938609, -0.10284533632613262, 0.3636948288409865, -0.37049274267705923, 0.022195056745193512, -0.34868976498640786, -0.7375000509956732, -0.5020106002580706, -0.4451723221194408, -0.32271798959964754, -0.5881670426436236, -0.28773330176308126, -0.46791652345602147, -0.1786063943026979, -0.48391847079437866, -0.026746273976595136, -0.17806470376565506, -0.2947715689378862, -0.7004179729945805, -0.5922779862734099, -0.3851472968991718, -0.749447089115378, -0.14756887024436866, -0.43361324070881213, -0.6241233903478672, -0.6375640597183445, -0.5009704559400705, -0.4103672112875713, -0.3342474191325343, -0.31658501080497636, -0.31245440069612107, -0.26676506770801217},
    {-0.46345722597720485, -0.2803706208577956, -0.43849369941083804, -0.43990456848545345, -0.45356024868295325, -0.3096030236603618, -0.5279701940059737, -0.28595128119959234, -0.3131396646364951, -0.6709281924701289, -0.45998328728628335, -0.6239288693858882, -0.25235023167909637, -0.4396371760989268, -0.6569083940987297, -0.3536177522016132, -0.4020770280519946, -0.5250813195689247, -0.8691394682113951, -0.47129976213194485, -0.3539365965051389, -0.24837752702040541, -0.3620024301412779, -0.448595174432875, -0.07537286077612503, -0.49633897333285865, -0.555902898880918, -0.2273101976051774, -0.603787788026947, -0.5138975060055473, -0.30627984547206, -0.3575861028422673, -0.44646290750119466, -0.22745376549274146, 0.20354319142365582, -0.09149615233123931, -0.3706547624286171, -0.1634302047461289, -0.7575633849230019, -0.8370986712772398, -0.4462666733100873, -0.6004385126596052, -0.3610066132946993, -0.2543345915721705, -0.4046397941311907, -0.38625215043801353, -0.45188584493146927, -0.5671136239606117, -0.2920441054646031, -0.26557954581321247, -0.434336262070075, -0.6162402438322293, -0.7227397650739816, -0.6328241191791619, -0.1706919024467245, -0.7175977615535443, -0.26250246973625463, -0.5853476072091636, -0.5744927067970019, -0.5396123496349938, -0.615335806825635, -0.25425706615894644, -0.5630310890228539, -0.4258037073908002},
    {-0.41045628487070207, 0.012013061213261214, -0.43751920114945053, -0.3843742368872479, -0.509348532083111, -0.7271839227928936, -0.11473552875318371, 0.5125859578272254, 0.2516060092182849, -0.1911184047889931, -0.47606667430558264, -0.31773317071729246, 0.3620717505786026, -0.27296444496457134, -0.5153237040857642, -0.09837890013956538, -0.08091815737856194, -0.03977769618692583, -0.1832287918233207, -0.4312697417481828, -0.6931395378643206, -0.5621941351386684, -0.33506798804248805, -0.5730622442227922, -0.009026795025234582, -0.3332715934332648, -0.3581069032548528, -0.25581185280022783, -0.09922704175723897, 0.1530639737969309, -0.3956138364952612, -0.6690209605309004, -0.6491600189862302, 0.06125713591605783, 0.2116601100650663, -0.3060728992732125, -0.030019868789450534, -0.7346278769406006, -0.2766345594565195, -0.6317600290901302, -0.6482438443107729, -0.6101411140739803, -0.545254487400935, -0.6105544788394788, -0.13854665556953924, -0.5474363305905341, -0.45447994989367085, -0.5311880905660615, -0.20213455429618546, -0.43840683107375567, -0.629324804728511, -0.7516545359550096, -0.27736741635077394, -0.4455653180875968, -0.1741218420466852, -0.23718942275513338, -0.6680125052940128, -0.3312813177453249, -0.4991592923336837, -0.6222212705131321, -0.06694012836523255, -0.33414163139480885, -0.5835501660174397, -0.45867587112750946},
    {-0.44104238583897004, -0.1809551408657646, -0.2009875228492015, -0.3358774384274131, -0.6035820463075697, -0.41610920953981473, -0.14023704675796245, 0.349977426553975, 0.01327651279991648, -0.7406338911042455, -0.461795814784493, -0.4414995948249794, 0.1570343294612318, -0.2886072754017104, -0.6267718664230606, -0.08665806947343926, -0.22541214413165156, -0.24416109126993016, -0.39820394159214456, -0.3781110152062385, -0.6971491258742033, -0.46840017801059214, 0.18033426765737168, -0.5775771751595322, 0.3193070858516318, 0.01995296555512833, -0.34022404626680325, 0.2555600204314423, -0.1874752838210915, -0.05348090249403352, -0.4863458629328991, -0.4657211651131605, -0.536789584695162, -0.1585730060374461, -0.19649712590630894, 0.2963378355282482, 0.0036528237188041793, -0.43271151098865407, -0.294590148483055, -0.3541740699111462, -0.5128030209611839, -0.5407600608548333, -0.5354397234492897, -0.1915352811861209, 0.13405513501610145, -0.5328559045375297, -0.5828065879282014, -0.14974438950386196, 0.3127431986559397, -0.4108662620281898, -0.05159906292956504, -0.45794995767321295, -0.27389023521964523, -0.5043911172377709, -0.4694641984283231, -0.25094052401761596, -0.3729243976135371, -0.16823237331004984, -0.4332897737142507, -0.6428753416674936, -0.5229586667726828, -0.4729648073586115, -0.5067054307211843, -0.3562187309675757},
    {-0.4512655705295993, -0.33715589633542786, -0.37416221828075197, -0.14179648430956932, -0.5224123710909899, -0.3577393497840632, -0.003110462558512219, -0.017973744464523937, 0.03385892206919066, -0.56384070033693, -0.3161291393194236, -0.39163719200305913, 0.24222186924395894, -0.19687117912366672, -0.26660694425494924, -0.39503956979170796, -0.3306253592844086, -0.2386715427857607, -0.34701001243656143, -0.39068844172796313, -0.49302882655742, -0.5317738513332135, -0.10376264048809279, -0.5149718738739353, 0.22830676917714485, -0.11597510586300626, -0.4304749765012307, -0.1853297083641036, -0.34817077117622663, -0.03379624462184114, -0.32260969609796775, -0.6956715731695692, -0.7399870958407401, -0.17990858136542257, 0.09065873349324552, -0.27861135162898765, 0.009106383771779358, -0.6965337993015699, -0.4678913223978922, -0.1994215131799314, -0.6396642470565945, -0.13354516768477126, -0.6290890210596737, -0.4156779189382772, 0.20358444522993271, -0.49194139453924585, -0.42638698682278137, -0.2437934228208803, -0.4157586973522633, -0.20252055748827524, -0.4476044777435525, -0.6423325439446415, -0.6091350201106737, -0.5313271029071845, -0.39083603071902046, -0.44068860384537717, -0.39273197107835073, -0.46808866082038986, -0.42862082447210836, -0.4629332467130019, -0.4887840289436062, -0.21856976545982043, -0.6052973626488082, -0.4758624832494299},
    {-0.47263271234144144, -0.25415075083746974, -0.5019630361059545, -0.4778390485253991, -0.364326997316222, -0.6100645870460017, -0.06061108539459456, 0.03046266818342397, 0.33879280752423224, -0.33117309520994276, 0.042096443516079184, -0.5560030295265471, 0.3013523034900103, -0.5739333381922028, -0.46170561707714, 0.07243937370930109, -0.45868467274281827, 0.19811389658008308, -0.22525661407701014, -0.2986046441291645, -0.4651579833349247, -0.4245741669305067, -0.022408721227482744, -0.011375937146460468, -0.059586503684735406, -0.6512385599315852, -0.37723066608590416, -0.26184133051272646, -0.13906457856353133, 0.040542024841942144, -0.37445118711948994, -0.3952332643172703, -0.3036061742463915, 0.03352336952880439, -0.1417682585368136, -0.16431658129238422, -0.06313489387727438, -0.5087315314697024, -0.3476241365371345, -0.435437561909872, -0.4391548575604135, -0.7218922195908396, -0.3777808469219186, -0.46789005373057635, 0.0908989591527022, -0.5688093175741642, -0.3084643943190854, -0.01287072663902607, -0.08669884139180664, -0.2777359193790185, -0.35443057329939115, -0.7963533179951996, -0.27799737851670564, -0.6244024822828236, -0.4294087334557799, -0.5342812836484409, -0.562506761085981, -0.29365438151860657, -0.2905231433716304, -0.8688713482453475, -0.1028013658797723, -0.2399110947561707, -0.4845565977064261, -0.3954008851317668},
    {-0.3202217966142034, -0.08517330318065995, -0.5852108058540197, -0.1710583342945109, -0.6958578554064279, -0.5544933501510719, -0.22994572920797407, 0.014620891565736548, 0.12917282099674812, -0.6923811742022172, -0.7193099779533826, -0.6983415727376803, 0.22340086120024488, -0.7991145217665936, -0.35731379880053293, -0.1726048585561566, -0.2062178854336909, -0.029531319564549897, -0.4815316524428811, -0.3599715054175307, -0.6541602689519299, -0.7169049160303519, 0.04527014374078713, -0.3585573519901084, 0.1368073145829381, -0.343529590426987, -0.4732992852776324, -0.15987876231604622, 0.006056575951777709, -0.14851530149075523, -0.5564399790845362, -0.5610929023794605, -0.34339278861289896, 0.04540507279784782, -0.1787059085617363, -0.2516455941676293, -0.21522576657644357, -0.5590122325198222, -0.5928324393632888, -0.7247265505043472, -0.7089370441415974, -0.6901966813135577, -0.7264768873216088, -0.39595780831875893, -0.06252011278680984, -0.5496075210033707, -0.2932127828787123, -0.015594422694384756, -0.006861289085875034, -0.34611200477920073, -0.4277190309624726, -0.5456883245367048, -0.2679441579459012, -0.5611807374316865, -0.4142170962446806, -0.7492854185453375, -0.46048199245148913, -0.5438260552261955, -0.4033927815009507, -0.5609421158533768, -0.3566751123241843, -0.0253062112826719, -0.494152458016286, -0.6729354835385072},
    {-0.4820396092900132, 0.12591727089075636, -0.4969562864466944, -0.5193775196145691, -0.502716438766978, -0.4536546718417714, -0.2313098656686149, -0.00979025322068591, 0.32217002297887887, -0.8046930358967831, -0.5485492588266093, -0.6248186898175858, 0.10648829866294363, -0.41844826759805476, -0.5449913389195569, 0.040133775445322185, -0.22645051778172362, 0.04075240538834392, -0.7007261189346987, -0.43993881422910625, -0.391602396010328, -0.5333063465972149, 0.2762362586916671, -0.5412560604120041, -0.22496325057741803, -0.3346210481624709, -0.5901582898597095, -0.3264290135390129, -0.09025357558017572, 0.24842297942627722, -0.6953862088573753, -0.5994828861929055, -0.04730401694131381, -0.06706786445662724, 0.07008799609697272, 0.15032681106566273, 0.05776061151131764, -0.6955197287518089, -0.6553367960657697, -0.16343484606589745, -0.7292304512099957, -0.5533978899390897, -0.47426147513917405, -0.5114713700810785, 0.2531343847539776, -0.5541419260182651, -0.4258062785437726, -0.06234738149735629, 0.033666839804374266, -0.43299070175267634, -0.21536718899279633, -0.629718689417104, -0.24204866709455886, -0.34241554203720526, -0.47058125184291016, -0.4236578189958442, -0.5636829816256994, -0.6023057023197046, -0.7179010767824232, -0.5157823157510967, -0.31568609369048156, 0.004745331860483362, -0.3781289342976332, -0.426739664887906},
    {-0.7028447961820369, -0.5388823378464302, -0.6009015224817077, -0.4810923691597346, -0.6299950278838283, -0.28305289877089845, -0.09831072209903088, -0.3793697976993766, -0.1835603968141531, -0.6934373252986139, -0.21537191267142447, -0.2541315413810533, -0.02308408593177686, -0.26592414157956284, -0.3268699019256363, -0.5774864587022337, -0.4736274153022756, -0.29026739665133927, -0.4078439929362973, -0.5288652487598907, -0.19230192841230656, -0.5182253962487984, -0.28262861828703906, -0.29060899261958134, 0.044966794191168766, -0.1619608275797561, -0.24441236469159164, -0.20992880553087728, -0.38845135059538893, -0.3082438824085607, -0.3608175807668044, -0.4569122230345291, -0.18334334142625522, -0.26637626181368596, -0.11271913699238227, 0.1121633459184095, -0.13325553557723682, -0.48738811863733106, -0.42028347715495334, -0.4277577546329896, -0.5245576877521835, -0.47286562702022555, -0.22467230555007883, -0.3214990288329133, -0.4685722079561138, -0.38405695780788307, -0.05530043363123572, -0.44603751254009844, -0.23115066090104364, -0.3442130360840353, -0.19950393368791694, -0.6030161607727063, -0.3211015770730939, -0.4350273557942555, -0.31282317309403757, -0.5405088967137011, -0.2959563530578691, -0.24870185200785527, -0.5629552785326715, -0.314533666920106, -0.40329247473135343, -0.45168980721378027, -0.6113607162936112, -0.5379780643345323},
    {-0.31553067913331123, -0.06337939451473922, -0.43455203346889215, -0.2956957405955476, -0.7746970361994052, -0.44635082907456797, -0.11116449021874707, -0.2775051482615576, -0.06402745106779256, -0.5767414380142836, -0.34723417448735266, -0.569606540940204, -0.12982332547709932, -0.6031053876912462, -0.35899754095680536, -0.24206382301369078, -0.5265834654938324, -0.17267404618657184, -0.4601788136557405, -0.3414755640452065, -0.3997208488937782, -0.535383227738199, -0.18384526254438469, -0.3706050715307342, -0.18974669742643002, -0.41507366026539294, -0.5471594789066399, -0.3082987405026114, -0.4765860419008561, -0.44705661014696396, -0.325847939941927, -0.3353587702351148, -0.36778062355802993, -0.06374566807725349, -0.03552935172098918, 0.0033226190649416603, -0.21002704939528777, -0.6007751635387838, -0.6875263110752524, -0.3816829839848423, -0.45026396015280473, -0.4802335824389589, -0.41117460139806433, -0.09375809513203207, -0.03918944173957633, -0.4228704856292281, -0.40332925595710956, -0.38243197002542956, -0.09795648568761818, -0.27797543729096125, -0.4600315139984671, -0.6691280241093372, -0.3940599870000709, -0.5400825780294436, -0.37631606586258276, -0.23567931613864881, -0.6627417900866734, -0.403856607991215, -0.6106973461917838, -0.8003889612263252, -0.458388392069815, -0.38891197099375396, -0.3875046377202758, -0.4641687110133888},
    {-0.4598313639057671, 0.08948126406831859, -0.5202939119755327, -0.47545994290495214, -0.1711735173379609, -0.24646052038890592, -0.4514294973978359, -0.11889779938485574, 0.3696382886557421, -0.4799026549294959, -0.7683733515773248, -0.7692161278631577, 0.10448081628380747, -0.2824730150828763, -0.47005585668478506, -0.27151184907047804, -0.4585197578407629, -0.10049167887692867, -0.3029917860868371, -0.4485688138514259, -0.2811864953434043, -0.5020274066782977, -0.3648188479819714, -0.3767927932589731, 0.03760425746490276, -0.30624447690519735, -0.378515022436603, -0.36055519843016237, -0.3306955122772613, -0.0260485267835188, -0.6283032226206832, -0.6948403317072278, -0.50550404132024, -0.1205724437111637, 0.2142324488093026, 0.0965889361195917, 0.018173381396332133, -0.4543185316695479, -0.4746301242487797, -0.5668264308924067, -0.3276704635451805, -0.5319146301337938, -0.482996568032267, -0.23575056267770367, 0.10552674834707419, -0.5376486911446442, -0.2466685408175118, -0.43734621705243054, 0.3120433584359693, -0.4896351998480782, -0.5600440568552365, -0.39343333110206835, -0.3117621789636299, -0.564165312064576, -0.4865309898914635, -0.49709666899991606, -0.3173581670701069, -0.4179560445719288, -0.6257263864179311, -0.5314814537005222, -0.23672606251404335, -0.13528173776958244, -0.5642447170260245, -0.6194396812976704},
    {-0.5013238776666988, -0.18369231418872436, -0.641561390891014, -0.2586500985717172, -0.5675702663955737, -0.5923590735523712, -0.3108347138843154, 0.07507787717525408, 0.1626184011512811, -0.524278406472969, -0.42495670757861226, -0.6215779617929765, 0.18458169801625549, -0.5424244808334481, -0.45862342440896964, -0.30652446383687776, -0.3175592529360396, -0.035089461115349115, -0.40104958092586845, -0.5991890575715255, -0.5591231675156447, -0.5123893361814325, -0.24023059258418414, -0.433152062057705, 0.13815908374302877, -0.44443305965400826, -0.5383350691318857, -0.3018511530937982, -0.4966070210541068, -0.2099409788729704, -0.3060886765276514, -0.3318998985309177, -0.4237856361057191, -0.050233305071607434, 0.012046222044736933, -0.30451959754390107, -0.09359063213141543, -0.6603878634629919, -0.5972717740622976, -0.6936916219501758, -0.9008689160433299, -0.40062187004239647, -0.7781232444716953, -0.2720688914153897, 0.04757834455385424, -0.3645329438974721, -0.08413948885591385, -0.105667017367575, 0.08719252736490354, -0.345275609407678, -0.574897554136062, -0.6197272071651565, -0.32137968475049594, -0.4232845634168368, -0.3161515143862761, -0.43035174037753193, -0.6028862988331884, -0.5750167645810718, -0.4821062459515654, -0.8490925527377391, -0.3852211335393525, -0.1660022085176641, -0.686799058596989, -0.3606055662348555},
    {-0.5790972408311469, -0.26660916336007323, -0.7640931595647295, -0.42595462658561617, -0.33958793161708284, -0.5540207647487903, -0.3675915727723333, -0.0006613987883369631, 0.2445185080665994, -0.7128176335678044, -0.7560401345176809, -0.6152312906852143, 0.24855949161414145, -0.551902592440914, -0.3403301014062097, -0.12707890082109022, -0.2967785642914943, -0.14360267446108899, -0.585085604749453, -0.5865680251311701, -0.6730192411586611, -0.5421544275547079, -0.2899584375416502, -0.2537399047129172, -0.009630500169977492, -0.12424394349388079, -0.22245171545829423, -0.38699378217479224, -0.31697469479067336, -0.41816697293755767, -0.4304497999268674, -0.5770091261625107, -0.25002945202139665, -0.12455036058801493, -0.07309887859039219, -0.08029414700376056, 0.08805662485726262, -0.7505443309784706, -0.5017377985918343, -0.538501798535065, -0.5940352723961703, -0.4044229042055268, -0.4185553149540048, -0.44365487584765745, -0.008265812118934516, -0.200486461038013, -0.4462313408130573, -0.06660529894997311, 0.0008966828772507494, -0.21428519082036923, -0.7267881681950935, -0.3877166624424766, -0.44593556333571654, -0.8805567757295727, -0.36174841883664655, -0.5741220688785375, -0.22663064738177432, -0.3864040627010368, -0.42495697959137313, -0.6855702239435785, -0.6957063160411059, -0.164893528744962, -0.5232374023559241, -0.3765576942324337},
    {-0.4579842860569328, -0.29435169388911225, -0.45610724441498707, -0.6041864407683514, -0.7079336316132645, -0.46475902517163353, -0.3462823302782937, -0.1775439208757143, 0.2564336320679691, -0.36705678198444436, -0.5786367364221099, -0.5130061783006398, -0.16140493688257562, -0.3923198567545929, -0.5585857516271795, -0.466865115780878, -0.44193587401414675, -0.24841668035847853, -0.5130751942145791, -0.3446760461020562, -0.9106970717931678, -0.6952764321250356, -0.4936003037349706, -0.152480580683886, -0.24400888981093175, -0.1768004065883808, -0.5526600244413165, -0.16721405020671834, -0.18848743322032707, -0.5070510020421525, -0.5815491461562898, -0.5587599176354577, -0.1836224574130106, -0.08750593698005617, 0.1993983642877665, 0.49346534954407717, -0.30724223915608906, -0.7389484406777307, -0.7240797675570995, -0.5938604500650742, -0.5812627119951563, -0.7555668384758634, -0.6278874142172578, -0.2221738346121688, -0.3660347294991258, -0.43912669218298805, -0.3543291553934401, -0.247252196982653, 0.0929239190786907, -0.3394517650664834, -0.886947086972211, -0.5401130912848543, -0.2634507131934766, -0.3761195731433233, -0.6261130618525586, -0.3417770870567781, -0.4751327676516151, -0.46760689274710515, -0.6035287486680218, -0.5258082956340313, -0.396121036043459, -0.2188344577405175, -0.49642408174579544, -0.013713712110031653},
    {-0.5503282430598316, -0.32110242683511786, -0.40430019693571756, -0.9452043966846827, -0.37707791399369855, -0.41954437296477576, -0.2042466295267503, 0.0033202076824432464, -0.03038149976994363, -0.5251389592709386, -0.34936274557864816, -0.4281610208821116, -0.11489743972938372, -0.496548473894684, -0.7455088131816874, -0.23120099660191715, -0.2827518559861225, -0.4462674594464391, -0.3830577293030076, -0.728159801794246, -0.6479000487226668, -0.4164324371998813, -0.2428298768261504, -0.4466538238751864, -0.1968580847090474, -0.2842501329243126, -0.5008592293281323, -0.3904553330842014, -0.16612056352763016, -0.38185862061913045, -0.2895524283793863, -0.4272673068621621, -0.2071563046098822, -0.2337045879957519, -0.09729991254522856, 0.06562525461297093, -0.18270003800185228, -0.3896686603553198, -0.6873892329491156, -0.3014911931098685, -0.6380695425562797, -0.256468382169033, -0.6598843681823214, -0.2921352295756163, 0.03727712591065506, -0.30102128586069155, -0.5389845056616546, 0.033273865958347366, -0.0014063180963237046, -0.418110379463034, -0.44478610969713095, -0.6724793627191649, -0.494608895671148, -0.7728353940723943, -0.40022044906281085, -0.4928498687014831, -0.8490898621744735, -0.6014714885254272, -0.4550753119738611, -0.6119695316365561, -0.5225232658847427, -0.5004207308528409, -0.3045501574907162, -0.3172106480954257},
    {-0.39573083075831694, 0.13401997340990066, -0.5401576822580104, -0.538422001012283, -0.46290304857927655, -0.26998423991027176, -0.23778817827544224, 0.20195410327936011, 0.08132792397279276, -0.41931467689526924, -0.43262658733676956, -0.24111250872086645, -0.11558215420676855, -0.10423325910696281, -0.24891272561038869, -0.1457449724741561, -0.05617190562242849, -0.04726288371226938, -0.43912597033277273, -0.6140173114191219, -0.655859973508801, -0.3509760003488508, 0.1179387511798033, -0.13098755669038326, 0.1761938602128848, -0.14964747347409232, -0.3471853517457114, -0.28040907846017105, -0.0732745907005636, -0.0406244901826277, -0.3972101446724577, -0.4087389517360032, -0.25474163555421175, -0.02693277848373997, 0.27028533781164743, -0.32499979206465546, -0.07167228597907152, -0.6173213106532527, -0.6021945170708389, -0.588142790885113, -0.4218227186341084, -0.16014892404604966, -0.3334348988041446, -0.07786351068363212, -0.01145787686816112, -0.35908493255469764, -0.5032988847919219, 0.07548713900157931, 0.30855272674099127, -0.28867992699035033, -0.22167768807580465, -0.22712880294001286, -0.16114166595161677, -0.29565436500855924, 0.08778921928200077, -0.32603560490463873, -0.7950288051317668, -0.7038841874638809, -0.5090929454942553, -0.48485200592605676, -0.5239854499537784, 0.0961257832232105, -0.31664252369772217, -0.3231630668390907},
    {-0.7643788786686747, -0.22155559213176643, -0.6541196675344086, -0.36428909677176174, -0.041429339548640906, -0.7139909779408425, -0.3932415606116106, -0.06966221346344043, 0.06941894339236386, -0.5489663770873521, -0.22133116882158177, -0.460297396079671, -0.11835775392450829, -0.6473350702401853, -0.3264492974435162, -0.4082773092032769, -0.35904319010039426, 0.1698160994868646, -0.4510344085790663, -0.4495525909592854, -0.5855364571931047, -0.5556758440814898, -0.019830322264061746, -0.3500573817131884, 0.06629753048493793, 0.1588015752706471, -0.5261936010511016, -0.12127978981216789, -0.5708943819931757, -0.610903930612635, -0.5658267994809583, -0.7696376929967453, -0.37890601925116923, 0.13540018866550066, 0.2932050131565229, -0.4387380321140328, -0.35812239915208205, -0.5898121732863094, -0.47320659283355854, -0.4484292572672132, -0.6122434797467515, -0.37415090684762864, -0.4585633184240125, -0.008579508331578101, -0.43147366521657476, -0.4046322589455645, -0.29313934825706134, -0.34057850426218733, 0.09777338105197564, -0.3431999266008948, -0.35861894431323743, -0.4942799918995675, -0.5130134865227465, -0.6561535186707492, -0.13871765362087313, -0.5044884444436631, -0.5617893674997688, -0.4024064944310123, -0.4957680000136484, -0.4505702579610907, -0.33686552208363885, -0.3248559569576372, -0.5283874065149117, -0.66611596149984},
    {-0.5403852139033527, -0.3344630034421813, -0.6659885682451213, -0.6662823262426197, -0.29443193299496345, -0.6464034081934678, -0.47869252516494787, 0.2886682079801439, 0.006342634466031525, -0.6247821865393951, -0.6591897261990292, -0.7338123219408625, -0.02546666973013171, -0.6393056413830134, -0.3898969684302376, -0.48973639560575655, -0.11422685630424297, -0.368972134759485, -0.5192737973024123, -0.5942536963277536, -0.5903927522147602, -0.3849343942160861, -0.08180310506265781, -0.4301896869206264, -0.11037139408660077, -0.3720695353587642, -0.6000145417850254, -0.18735636032983416, -0.4039771376365476, -0.4360885437661621, -0.2021621552835451, -0.6478184020283254, -0.6173791189971715, -0.18385882766350242, 0.05809023466377142, 0.22483677998728818, -0.10159094854295542, -0.296634461356525, -0.5379604722057321, -0.6134640519559683, -0.5289725887485851, -0.39660173961445916, -0.5202597845964497, -0.21684447459290662, 0.0034022997734189197, -0.5013096854066443, -0.5179809798480395, -0.4596810911527144, 0.2001296460937005, -0.3431959305470096, -0.4737974625009932, -0.3911574617018582, -0.3189073906627748, -0.6571830237502767, -0.22643914664811857, -0.5338450086881681, -0.5071456486729425, -0.366323580907732, -0.7501704827615977, -0.4214351873487175, -0.5333032269934848, -0.21630535891415556, -0.37927203925653313, -0.42017408900067466},
    {-0.6358279648613868, -0.04811815019223012, -0.47416473192514086, -0.6606678887141477, -0.5081562792246855, -0.4524331583226531, -0.192608867211582, 0.20217247767788799, -0.11746662938174958, -0.4675512892915727, -0.5711351008381734, -0.32871096782373005, -0.28539334760043444, -0.5126143242592067, -0.9164040342430293, -0.4862226388340925, -0.17449782961172472, -0.017740015578560524, -0.31619009913073653, -0.47753712667539483, -0.6698972550843806, -0.5804523821985657, -0.12383896295166182, -0.5252876230550086, -0.13261471783859968, -0.4061569301663732, -0.6766937485089051, -0.39027864755664043, -0.17224752601692675, -0.6063072650388237, -0.2922509732851446, -0.6794119089836752, -0.4662708048158273, -0.0757740794379471, -0.18450538809883218, -0.014820252280602846, -0.08394609744665181, -0.5755846126819159, -0.5623309331271978, -0.5572305228552094, -0.7069971097330058, -0.6774350389621041, -0.6558679840271516, -0.3882947691642004, -0.06549816022506685, -0.37770928072725185, -0.5579571223937372, -0.3131822629883747, 0.0925626215641529, -0.45374253039477425, -0.2686481607846921, -0.4551817220104054, -0.5066848100853074, -0.3613601728942976, -0.4825570026082002, -0.38569219119951376, -0.47847666569448, -0.5384498386177043, -0.49298697099797206, -0.4569443408672933, -0.14839093646025284, -0.1395056729705937, -0.2882780395135628, -0.6446574817025402},
    {-0.4294930672754505, 0.3807961458049905, -0.34228316808444614, -0.5756126696882548, -0.337928883468479, -0.612540861329456, -0.09423049918607664, 0.06308173555037498, 0.09988644915899449, -0.5771857202617656, -0.5130761003655256, -0.6618189504627758, 0.3950713508333517, -0.01445247968870775, -0.38904088300787476, -0.09090884274943836, -0.1441647057909054, 0.06907275779418628, -0.4647859979242856, -0.5072169841253766, -0.7830098097397276, -0.5797502257624434, 0.06253339313675453, -0.2512483000442993, 0.025791059504134933, -0.2572866439728661, -0.7339776472894425, -0.16571826502902293, -0.2853690126430538, -0.3748083123957239, -0.6927776142900784, -0.5266593448294329, -0.3312869140216155, 0.41666613983166445, 0.24792705896378536, 0.08893926110926262, 0.15889526421914296, -0.36869109411975626, -0.59015468737787, -0.6131243943052697, -0.6063868694018192, -0.6676824505360658, -0.39355206663087133, -0.4477585059709271, 0.4333065967114068, -0.2867545806507458, -0.6278803692824544, 0.15483709100297796, 0.07367524936879312, -0.3439271137101864, -0.4373255698569273, -0.43325004716398446, -0.4386182581478464, -0.5815399964417979, -0.19259191197292394, -0.38002815240727683, -0.41192724345522, -0.6569175417248005, -0.5111992185415567, -0.5951361366843791, -0.41340177955135987, 0.3044906018000973, -0.16032427710554323, -0.3905117268526432},
    {-0.6273611924682408, 0.1891555763912705, -0.5252179318580137, -0.42586333079030336, 0.35790212289166534, -0.5994132748975309, -0.274420698408917, 0.012110665308655023, 0.03834774800309877, -0.6389989505861279, 0.06520204499525772, -0.7201649803347832, 0.17694185010327368, -0.6698889779787102, -0.12396457232072253, 0.12570681607882622, -0.3759894097372569, 0.5753929823542968, -0.22492429040612635, -0.08137515789201241, -0.6377795531153915, -0.6301223415337059, -0.2454897404818413, -0.035958364104276955, 0.4920709403413161, 0.1494427173312846, -0.4227765502355283, 0.2061768676137021, -0.3444601995714392, -0.25983600328868606, -0.3621482896385329, -0.3885435258591798, 0.11298679792776163, 0.0504229020038513, 0.6053340177453395, 0.39132090082109133, 0.0540404864866881, -0.5503495272349703, -0.7761478526755944, -0.521832962778009, -0.48605467601358504, -0.5071733658675701, -0.4254916086053735, -0.12979518429199582, 0.030054180845307785, 0.11590139395408529, -0.461094397148054, 0.12055053509704163, 0.5653808904898346, -0.38675038358164027, -0.4100355226034691, -0.41218054244384655, -0.38620187612865853, -0.5733269489802973, 0.12747020121458955, -0.43829837361073454, -0.3170423017674614, -0.5109500604384509, -0.5053120517007279, -0.33389224383780264, -0.6179993089484116, -0.11934904490164136, -0.0639825577700667, -0.3165533735692049},
    {-0.6806331742932085, 0.14659012154090462, -0.5262100223646844, -0.6363101735967144, 0.03879357311654851, -1.0273613954370444, -0.575556785934444, -0.0658526616387196, -0.09868789004466251, -0.6755861188147374, -0.3308129916626653, -0.8798132127065711, -0.17752117210696575, -0.7309517828033928, -0.4786346338059504, -0.2494872492761376, -0.34404614393473315, 0.2666294586389881, -0.6061702481736951, -0.1470392697403297, -0.4592603436217758, -0.6452755342935955, -0.051416646386743224, -0.21448800955088315, 0.37618308147505863, 0.24033137610973687, -0.38035367316602076, -0.11091423345076444, -0.414859902589406, -0.17811112577414062, -0.3053112601507047, -0.642020075817367, -0.04910795748824307, -0.13477427150974658, 0.6278009552112755, 0.25926606794327106, -0.2407520697506546, -0.6055262758567961, -0.6620303460410388, -0.5048303478263539, -0.6061474147174541, -0.47269118265249654, -0.5072291051376876, -0.08327130832668651, -0.22812068155518103, -0.29161683485153383, -0.4959572530119885, -0.23063822999779798, -0.057965661280984196, -0.4168648491266834, -0.8047562078415847, -0.42904973060903095, -0.4272243472353395, -0.7842301950511562, -0.06868539598805302, -0.419960673010311, -0.38610751446350045, -0.7232077391393718, -0.7885332385950703, -0.3758413702981305, -0.46334611350885785, -0.19505034730823403, -0.40960334528234893, -0.273704175872211},
    {-0.38968656169117344, -0.3719230386788451, -0.6359180127412015, -0.5458345028762891, -0.4789995417803182, -0.8270650732732129, -0.29436839601858045, -0.026337778551928846, -0.21348539195246838, -0.6186040109300253, -0.457854725634614, -0.6429278083162282, -0.13267683702246855, -0.573637382351774, -0.5381592502785206, -0.45993428475044834, -0.4832319247798662, -0.28036849963481114, -0.5273833756639076, -0.5784779396574217, -0.6780611008473563, -0.5345749348472164, 0.07827757907893534, -0.4004118450574716, 0.16566076748831982, -0.12836372014154895, -0.5418693451486756, -0.4324931998223415, -0.29392944453372116, -0.29125319747619816, -0.6040634014238697, -0.8696165858576769, -0.536346031912305, -0.4413879181322249, 0.023056759869159532, 0.06871898840340306, -0.3874354318270661, -0.7493027826496477, -0.7286426162772618, -0.6975896426825724, -0.6972966929754784, -0.6235380177951221, -0.42345082242537424, -0.5803231842215443, -0.32326032243530856, -0.41847190734326456, -0.5777982519294131, -0.15486816349689497, 0.18794839616208944, -0.42517483969581843, -0.6841500186518548, -0.545861600254347, -0.388898329279723, -0.8214485502530845, -0.29398010749560666, -0.4067530347135737, -0.5269786776727093, -0.8149147889410956, -0.5241420158243579, -0.6227785395789789, -0.5765943155672513, -0.13298468484993578, -0.5905353044512918, -0.6620286895023536},
    {-0.7004254230701715, -0.18542884839739537, -0.75691985204708, -0.6514313829076813, 0.2589072236419441, -0.5403133469300895, -0.44545326308574557, -0.4275947299403679, -0.11741094886092003, -0.43889202567196, -0.20695033821388506, -0.7894032130912494, -0.27532192646307296, -0.9000432963864136, -0.4592160481338306, -0.431992023174068, -0.17472023055651298, -0.03783840746810113, -0.5237034240447425, -0.17473560695296814, -0.5462460756965949, -0.8109750387878785, -0.2577794735055262, 0.014689762480878202, 0.42169440873043557, 0.42686821407090686, -0.591540463110115, 0.13007235756966531, -0.44866050744162, -0.4203485415478538, -0.5422326025204338, -0.5134619142602791, 0.14707230044738864, -0.18889457314895036, 0.4226874092514497, 0.43557674491041204, -0.09778817316867933, -0.5668950631658294, -0.4403448166800293, -0.40531841056857687, -0.5993396015346601, -0.282907660558343, -0.5979588392509025, -0.012295190637532944, 0.27114142098429866, -0.15252720570849695, -0.46229118769388694, -0.08768684017559251, 0.40356105904740214, -0.33205195401056875, -0.6955888494027358, -0.2608979920160531, -0.5504903539705726, -0.7369074712835227, 0.031338255960873924, -0.46662970892370464, -0.6196916097275337, -0.8971741437290004, -0.6200812066999313, -0.4202353389699557, -0.7301382587097538, -0.089135539838937, -0.695800132721095, -0.23369983600700445},
    {-0.6002906030278778, -0.0015872128194138887, -0.7118845303532793, -0.5250249170256545, 0.01268850385266139, -0.4733687888297263, -0.2543246275729412, -0.10982510761284844, 0.06496597837493112, -0.4763411780700066, -0.05794279365354059, -0.4907951140689754, 0.11110674583522191, -0.5104949566535327, -0.39278853153766036, -0.31685669251683357, -0.394346845882213, 0.0478016658397722, -0.30055605166881594, -0.3617033621645371, -0.5397361329823267, -0.5850335788371462, -0.16503843724031747, -0.2064549013813187, 0.4529111247569725, -0.026997589854089944, -0.5085073252266789, 0.20434745573074795, -0.23566981569245565, -0.429861254398351, -0.5195546101975629, -0.5112968164018388, 0.20498991325543917, 0.04523942756904515, 0.3672662339630804, 0.27521548073311375, -0.0006835279821722721, -0.6069119470015588, -0.6717699007303958, -0.36836103683239885, -0.6558318803740084, -0.5198281161807184, -0.6448573971014414, -0.02859785097515154, 0.11470414577765448, -0.15719683711829138, -0.21334296718927231, -0.018997644382108592, 0.31738028250184164, -0.12068790357401465, -0.3990404964033625, -0.1884085700646057, -0.44551757421460764, -0.4001274894076179, 0.03488339369591935, -0.35623627406862585, -0.6304876048764071, -0.43594106657854365, -0.5646667124305405, -0.4897403690712743, -0.4164991833070777, -0.15018183522553144, -0.4437807023597506, -0.12519529065228724},
    {-0.9907844417051671, -0.17731844265509036, -0.6897578155671745, -0.43232273981177544, -0.353676678224255, -0.7313556876488725, -0.2616194870503254, 0.007536921959468919, -0.03029814715173799, -0.8566382595277269, -0.24818730830530475, -0.504154719353397, -0.27766220478376996, -0.5052291005061579, -0.41205795487683067, -0.12876862836466385, -0.3974681576255781, 0.031194861834500348, -0.3280582462515836, -0.22735021919893314, -0.6669720855210509, -0.5120767705014563, 0.01271459251809406, -0.16672848718234207, 0.24674362776237746, 0.011542137510139844, -0.3704333170822476, -0.30971777552577123, -0.3946445108606799, -0.5247077224851808, -0.4502532112558857, -0.593930404404388, 0.020957758964342675, 0.17973520909521784, 0.3909245561248812, -0.20740967932726007, 0.005252420082105771, -0.6544056288918352, -0.6937998874655857, -0.6586120624705957, -0.4888638456253372, -0.6231264020488495, -0.552449443547521, -0.14078879778697032, 0.07137503163765636, -0.27970423039661607, -0.5936913440631116, 0.1627394113636909, 0.46523298187392587, -0.5275963528588954, -0.6456167612689397, -0.6463493075890417, -0.4088117452028301, -0.43145129992795195, -0.4130846167976925, -0.5571421478636649, -0.6503562771027809, -0.6090567791195879, -0.6067914102687462, -0.6045295322965276, -0.544719795309534, -0.2956740600708585, -0.40239001462460966, -0.670694186775199},
    {-0.6915277752374892, -0.3575829705997983, -0.8023869269039264, -0.625008428968374, 0.147536503539865, -0.723207118626842, -0.4904900616493222, -0.1366355448826131, -0.4770164796773025, -0.6785223023002189, -0.2089964302204852, -0.7042809528540951, -0.08527784968697943, -0.471565116564283, -0.21299386969829606, -0.396408584381317, -0.5328325218305842, -0.12346180801723976, -0.5962703526547093, -0.14337480792614715, -0.671311825628321, -0.6018372436010434, 0.11427761144060632, -0.2228747194610862, 0.2516342687856837, -0.08225529265412516, -0.5554383167078446, -0.07747022908892812, -0.5129838614767813, -0.8339148560833465, -0.552399353880885, -0.6191870267609112, -0.08961814334085766, 0.046571760859102855, 0.4135553947398009, 0.22576343761621842, -0.2215945567476928, -0.734680111812204, -0.783348371731975, -0.6418242943324792, -0.6649877473812219, -0.6979170417789454, -0.6000269151582016, -0.3543295916878466, -0.07985982470637235, -0.046833089287226244, -0.2813266245722936, 0.0400574670686995, 0.3850647682220623, -0.5158491935724602, -0.4359552457460099, -0.5229592871415568, -0.529390403353974, -0.8490953321303276, 0.2793702166321999, -0.5865378858125804, -0.42006329993864333, -0.8369126360650792, -0.7635110009423607, -0.405611605169563, -0.978947071261064, 0.014246013711697014, -0.4069993606664412, -0.6314329549644684},
    {-0.6950078541595975, -0.11644814458338662, -0.5262469948751121, -0.4710632278170195, -0.0291248668108916, -0.5153066881574211, -0.24168098759366946, -0.08494847512735512, -0.30275246922728505, -0.6264059228932914, -0.39141324419932577, -0.5900536767015635, -0.17962381357190127, -0.2956959275463579, -0.7423005772740228, -0.3471924489849507, -0.3176076501544346, 0.19329066130059533, -0.7054659697741387, -0.2704916118349069, -0.42817868096118844, -0.7928575431191407, -0.11206851995693953, -0.1811638056256742, 0.01777953297013743, -0.2751967202280159, -0.3582317663519651, -0.05442995944529401, -0.36725032813170366, -0.3548096304582623, -0.37435640502216416, -0.8875261798664051, -0.13561440118409107, 0.2672594732456213, 0.33277375909760387, 0.16664906937777368, -0.009620142398979136, -0.6507714166195981, -0.7384410534194046, -0.21925370715644538, -0.6109721074007144, -0.6467776161072654, -0.5630494310462582, 0.06610598321402375, 0.21198478493582726, 0.1233692956174108, -0.5883756669656445, -0.12311614664531098, 0.2459958013165446, -0.2905393865809383, -0.5096624022965126, -0.4427068406122883, -0.587517406020241, -0.5567551833693882, -0.06877109023496691, -0.4782145044709915, -0.6249086861002991, -0.6920869133255579, -0.6723704585683017, -0.641772404796023, -0.6241078994367948, -0.30964795011403967, -0.21012042053639088, -0.2584960079660692},
    {0.44525737356946443, -0.19805941582009223, 0.27043051076077096, -0.06331383381733414, -0.1345211733962278, 0.06897977007573282, 0.11027673090961035, -0.3381899379589607, 0.06813982337166383, 0.11715070737819509, 0.0696015602322287, -0.49424713605654846, -0.06446538733554626, 0.03713200349512671, 0.17894388242311343, -0.10243052755399167, -0.3345529306391922, -0.40445410454717645, 0.13735374993448454, 0.30109283481576293, 0.21617817648046547, -0.21192474687579402, 0.4567474572891619, 0.2044332329252516, -0.1396352666272034, -0.2977148422411801, -0.41925829825629063, -0.04648276664189728, -0.532498150365422, -0.04431344196239363, -0.0586428489951278, -0.5232245999152115, -0.17032183635702858, 0.29066272266493115, -0.00014287257218255673, 0.007762849883096785, -0.13535105168385425, 0.18356348294170025, 0.008370799186442386, -0.21076560094478822, -0.18813070864694167, 0.5192012559070326, -0.3428916544206582, 0.25083242805014777, -0.5867286970198846, 0.14888692269495363, 0.24405448547192934, 0.6510047695047971, 0.1940112003372319, -0.01325929052639192, 0.381600656914583, -0.23123280000134985, -0.19390420942499956, 0.06811577739780855, -0.4706755255455677, -0.2707930102892092, -0.09522308261504484, 0.0731988439897712, 0.11490150235069109, -0.6561586009287038, -0.2796501924577781, -0.41097614054062975, -0.36988763342817876, 0.5239537355881753},
    {0.27847059193284746, -0.4838832626221092, 0.6755953696485292, -0.25589775939238313, 0.052617203213491844, 0.4846024340009235, 0.3739765452561863, 0.1479006418409733, 0.10808808170686396, -0.15435114497200228, -0.08888055835030105, -0.04938359320657896, -0.24383223189128814, 0.0835067011490053, 0.39865355582673456, -0.3118452918051581, -0.6251159737589789, -0.5029516555865404, 0.3811855718885516, 0.3262287894998115, 0.4776610740332221, -0.08781997769661971, 0.39489725544966153, 0.23454788523237713, 0.06896880109958697, -0.08988360878331311, -0.06935253961315695, 0.32170400835536356, -0.40846841605512196, -0.3316666488447001, -0.1393712676421499, 0.0018225715992966557, -0.35175117759821795, 0.4882853038227374, 0.4126172509240211, -0.18537136746130808, 0.03354683328396254, -0.022648305723597058, 0.2390049659725537, -0.028696078219248255, -0.12130989379838254, 0.41493678001881074, -0.08383399677494559, 0.33651058715677157, -0.5695509076540557, 0.32779232372704936, -0.18525201532815752, 0.7124204187253896, 0.32636509157328475, 0.1709363325384596, 0.10958282712736436, -0.1333385441995291, -0.5002612996804108, 0.1548056059708207, -0.33370481897027554, -0.352344724444491, 0.20120967188410616, 0.06873568613248793, 0.20319747660846393, -0.2843315892140987, 0.0028166037031323856, -0.46245817250465737, -0.24445228905886077, 0.6636719141496056},
    {0.27404710704676755, -0.20135241382268235, 0.6395094553085513, -0.03311950773019718, 0.00021188603192258783, 0.12860131163156727, 0.35119888481088085, 0.080742772810756, -0.05928693386966137, -0.09596273734694026, 0.07084800455623906, -0.2732242865508585, -0.0879263067097018, 0.29915901272798, 0.5683397348438366, -0.15547743259829838, -0.43674501601808535, -0.7216890658244625, 0.39932864033663573, 0.6168186882422271, 0.5350433676283036, -0.2436164846147259, 0.45434201902468613, 0.8035711042969381, 0.3738149439321582, 0.3982447945405003, 0.16348566456830696, 0.24128101813438052, -0.46059676860214877, -0.5739526899140033, -0.4899120576854462, -0.20603302856135725, -0.33541478441442313, 0.23168694142720486, 0.4673477397714646, -0.11937397649808024, -0.1976029274996329, -0.007508322840151403, -0.09201109263048322, -0.232477832295145, 0.12803972284004397, 0.6668954386956838, -0.10952810322570328, 0.15178522405798903, -0.5978366062443606, 0.47098510064309335, -0.3400972487682078, 0.7402858011798107, 0.589465227089553, 0.633357090485192, 0.3351200376734418, -0.13548544566053985, -0.5887459310146129, 0.3786742785682021, -0.5802334022038893, -0.32287970972657026, -0.18892410770601226, 0.28022154094158186, 0.41435107818419753, -0.47632930339232327, -0.0730914684961716, -0.45113902014937024, -0.26063005276439305, 0.34907471041105864},
    {0.4338735854989434, -0.15481250605406996, 0.6026458668114608, 0.20992928854215295, 0.09369777623217143, 0.39091226042979005, 0.17666893828440652, -0.14521263443488305, 0.1439027601744352, -0.4574047318844382, -0.16567582377050175, 0.15073878928969844, -0.0035034563381260097, -0.18806959283265098, 0.8587666519819109, 0.013060272936240283, -0.5612147836721513, -0.6936098930672567, 0.5687113815254534, 0.3670324427112491, 0.23028789395155994, -0.4364731169127627, 0.46119256352576493, 0.5896292135545215, 0.30352030827344345, 0.015500258731257969, 0.08448078651850281, 0.5640845183306231, -0.27460876201560175, -0.5579930257096806, -0.2790640660584616, -0.2511301355263956, -0.5953089086826135, 0.43722998006480807, 0.23064976698388864, -0.03830696979180378, 0.1408707680738739, -0.16890822171721967, -0.2692560227926184, -0.4655492892381661, -0.06824499142547202, 0.47832949068686237, -0.45717623969337295, 0.203601033855888, -0.2640973146012073, 0.39635426070712615, -0.38136576778115766, 0.44449704372587473, 0.6676806879450998, 0.3947656206254787, 0.06645544323333957, -0.31411047098616535, -0.3760288942950764, 0.4501478206486407, -0.09000995972972839, -0.2517864892207905, -0.25052217285157685, 0.5455031442900701, 0.5543638041626858, -0.29596593930539516, -0.1361390435160758, -0.6167679129872954, -0.38176612373048646, 0.7890264350230003},
    {0.7278220563942605, -0.317406233149508, 0.419999330806269, 0.06793150622314603, -0.07573928510741303, 0.4658366868681726, 0.2721310177190271, 0.11704202994891146, 0.3240226786038389, -0.3003251693468757, -0.3370945409409004, 0.239592199075754, -0.13543933788467488, 0.1426414230695715, 0.4549693068940261, -0.019274015815839724, -0.24160500245372055, -0.4134354703375348, 0.1433834009536559, 0.047296137942504264, 0.1504501188617598, -0.28513373494304073, 0.67994098335278, 0.36306173181127066, 0.21093600741553759, -0.09658680730446687, 0.13604681925892295, 0.37834680026923584, -0.5819568032554049, -0.1082794999596697, -0.11426408875408504, -0.1486510076673044, -0.2990281027000462, 0.13872260902282763, 0.39086358832178714, -0.33182429782577233, -0.25128437499926315, -0.24514038890884773, -0.5991281476947907, -0.35448486709889193, 0.270367987040764, 0.2274121313490927, -0.33083499687973295, 0.39833541887136126, -0.36885708689393953, 0.14013708081434145, -0.11940314799979761, 0.5588630342253829, 0.6585961832083632, 0.28623907207885385, -0.01969567182954745, 0.09977279749405904, -0.6369448695410076, 0.22456220506495939, -0.643543213322025, -0.4240315819567317, -0.20634119672390625, 0.2264331606809396, 0.5293979388242208, -0.4885973586286765, -0.08591730541511614, -0.13891223774699418, -0.3722560558924161, 0.6516414252468715},
    {0.5606230818485802, -0.5324184248442001, 0.39932794167031116, 0.1489775605506978, -0.30127002747523046, 0.37354738645851715, 0.43832653812555694, -0.12563160370318752, -0.04247096284311207, -0.14263750360878213, -0.562937031221695, 0.3767315088256381, -0.5250730379256588, 0.20230089878059088, 0.33601358697554534, 0.05678314435700867, -0.284799226285185, -0.46261049471104815, 0.227348228478212, 0.3027223820369213, -0.11872381987845827, -0.22852989731976128, 0.2586578704102692, 0.7289914421225538, 0.46069704247380455, -0.18209626896046358, -0.198623550456904, 0.6398788039334224, -0.2994130922402109, -0.287066655463704, -0.15454374170019294, 0.01446933066211809, -0.5659377678423188, 0.3328730048886701, 0.27268061097228496, -0.2846416658359578, -0.1269358712086435, 0.1293696831122718, -0.17830189879817332, -0.21422246380870769, 0.3970565320498892, 0.13002882510115626, -0.30130788469517716, 0.27569602543578964, -0.5039987838771414, 0.3834963102147623, -0.005132227660774391, 0.4571021918349291, 0.17783865176366234, 0.46198847890044786, -0.09477612658787542, 0.09440335807904318, -0.36590479530119724, 0.2699357272583651, -0.6511045859176722, -0.4138529024751764, -0.5269865007472808, 0.14816365113231758, 0.5536103124433207, 0.009169992290260182, 0.20515522893042407, -0.2456808158262676, -0.3400719230895721, 0.3834263629821621},
    {0.34867251452071707, -0.6586834308617183, 0.6326521602363665, 0.009898543997691482, -0.23778863345237258, 0.1510789136721486, 0.19702104123024464, -0.015789719790979047, 0.02084869036562842, -0.3351923715746101, -0.45371344934967095, -0.23120945321424452, -0.2864069200419969, -0.27102271769388486, 0.27681392848945996, -0.2947871160429926, -0.3556246737048729, -0.725618119401235, 0.1409209892740329, 0.25218219210541787, -0.20955935723928937, -0.1843319259772424, 0.5168247412766106, 0.48493553171308784, 0.419794229727312, -0.0882488959015418, -0.13812946484363736, 0.5572134177367588, -0.26196621288458294, -0.2823444411418353, -0.38894063317515354, -0.18129379470362017, -0.47940309471927395, 0.295852812781053, 0.10433709241881697, -0.4783170403081981, -0.6005222655910204, 0.23873002371561786, -0.013435513972934562, -0.2892458658412629, 0.3620100054915334, 0.30694593868316533, -0.3740361362426255, 0.16587827221386306, -0.5503121023065803, 0.15808063877889833, 0.06713326132954012, 0.29106132467889534, 0.7065027018144774, 0.24711884183662272, 0.05288974526781259, -0.10807905216177892, -0.43288091234195275, 0.025255091234263356, -0.6038281136821039, -0.2915176524243851, -0.183612736605113, 0.19494116134347514, 0.4254316856370622, -0.46355706587636825, -0.19965517209326072, -0.18058623113713965, -0.32650966604725146, 0.7131637253719801},
    {0.5121463635239333, -0.46217828374491565, 0.41127486573521604, -0.009187133240149773, -0.2152503626743203, 0.23741272680632508, 0.06695859448102942, 0.06292951380505366, 0.09109767346954985, -0.015375946417653668, -0.06895612119775586, -0.11115679482853379, -0.20384595822799456, 0.2877448467491833, 0.5268817605352355, -0.09743008574032891, -0.5114601738328871, -0.4999026094091101, 0.4197770704210115, 0.31920359199947135, 0.020703208874419305, -0.015628611267113412, 0.1920460679155187, 0.4443063231228678, 0.14394479348095016, -0.1364664956075776, -0.07380404763498462, 0.8283831436780102, -0.6949572514278164, -0.6850541429699532, -0.09227648052652951, -0.19846571819778638, -0.5840460796938378, 0.44888019123260064, 0.5923202494589518, -0.3752655841202662, -0.13641267067266655, 0.3430411865747975, -0.08311336779951271, -0.3293632252173849, 0.31103625285499314, 0.539821872063538, -0.13124130147714017, 0.5490779600707218, -0.49475460151443784, 0.329557505682926, -0.031884333489222226, 0.6584097393297449, 0.6132461747328928, 0.431983858184569, 0.09257625854758587, 0.1467703676138335, -0.6104563531048086, 0.20507093355420367, -0.4559226489399692, -0.027973186711424368, -0.211298336513365, 0.21420467537460258, 0.8101323111379682, -0.6818046970667866, 0.2261515391740934, -0.35876959689869686, -0.5111302077824078, 0.3647266119545285},
    {0.6444202079107637, -0.4092889323612695, 0.48122698496363864, -0.05235323641251528, 0.06350144206470915, 0.3339591214123775, 0.38275738674432713, -0.08897931415614768, 0.33142323517751243, -0.06391752795456297, -0.20826838312945362, 0.030112296782375387, -0.3205288207523013, 0.022204953595661898, 0.6997630515037523, 0.14636649645881725, -0.5702269775253958, -0.6361392018337816, 0.37334620463292795, 0.30426573264646734, 0.5203410291380056, -0.40554185927357933, 0.6975645788203761, 0.4033056233964759, 0.1814741049222315, -0.35102038006969716, 0.07578837513700308, 0.4317904031920102, -0.35776974837678543, -0.7497253948085527, -0.17366175698235495, -0.4451218262772745, -0.47911092170447034, 0.27761119428606573, 0.5893873656789632, -0.1832687907564843, -0.1345686794114646, 0.08454118101038213, -0.34576078802607063, -0.35363250235553, 0.19970908971216425, 0.4481109380998791, -0.3670342962961449, 0.3587709085075043, -0.3389293255381535, 0.06944798307155611, 0.3301886018218681, 0.5988382497367662, 0.1785601038151655, 0.38923446440360776, 0.13243590274309783, 0.09524546981768407, -0.38395477105554177, 0.08515383877570146, -0.6667573948218398, -0.3517142118905814, -0.24498865723786217, 0.4227638735921522, 0.6093233773541923, -0.5976983860949797, 0.19934704546706702, -0.39077519076696643, -0.07810884577352159, 0.6205054538188491},
    {0.7046879782845773, -0.6310838715849296, 0.3554909397412625, 0.238049445944099, -0.09230252563820834, 0.14865627092170705, 0.2993212685111861, 0.14868363845513605, 0.38839409964636246, -0.32125110587776695, -0.07329785902429757, -0.06128226737393326, -0.35274171445532293, -0.10773925109360837, 0.4302406384199218, -0.254695256793417, -0.48889276674163573, -0.5158055534348388, 0.2798454052344276, 0.5525426705815087, 0.0810064401879169, -0.6710287711047104, 0.707285006874873, 0.6104030990287943, -0.11928067048102564, -0.23585615082419412, -0.19388557153183433, 0.4745372152407161, -0.5343944134140787, -0.5199947705927127, -0.13817370057675385, -0.19674964599530365, -0.26584361083033503, 0.07462011040607934, 0.4380043035395454, -0.4270963482383052, -0.09487425191737603, -0.08656258221369166, -0.4578241509362854, -0.46924907018541195, 0.4403378282627612, 0.35564480309631263, -0.12466023601870062, 0.5045727959188089, -0.46429840831231495, 0.5421948931535534, -0.05489539843080969, 0.7133100145361762, 0.4546499855164173, 0.588569875477198, 0.18309833352480373, -0.3735803191265088, -0.46319218861439343, 0.11426921151054484, -0.29871420672793697, -0.38417324490028426, -0.18628386465808927, -0.08016753825979285, 0.5533016943649481, -0.537231337738423, 0.02690145548661661, -0.5075665971688196, -0.37584413299810376, 0.5418318087542848},
    {0.534793483220963, -0.4376532346989475, 0.40964537853696653, 0.19586526315374533, -0.31982594794435754, 0.22888041987387642, 0.48340669357631827, 0.14144079300483767, 0.5746131560463708, -0.35115492464972337, -0.06010214844211569, -0.04616698413836785, -0.28983665828325406, -0.05724722019340756, 0.2362354498594312, 0.08522295477391671, -0.5195998377618396, -0.7156135306538024, 0.4373382076794211, 0.05641778563588955, -0.09545724205002676, 0.03759546125462363, 0.4368926583769403, 0.6030166642200901, -0.13027435260808592, -0.37372302464999246, -0.06931371022475671, 0.4264396013152802, -0.7125686376513153, -0.39572232505749194, -0.31147370901166466, -0.0411157169753399, -0.4847088299664856, 0.07290928079210124, 0.35819627474837995, -0.03475136596964156, -0.19721581237767985, 0.03473798990921083, -0.23672952360715444, -0.2733485987839208, 0.12116549818511844, 0.42780702042193713, -0.14830712304832144, 0.5212367661314515, -0.2552943702465526, 0.1839314036472049, 0.13312413739291573, 0.5129564958043652, 0.27496947440822433, 0.16358936530363954, 0.2793281866263459, 0.1250791755446533, -0.513053021196533, 0.264244545462121, -0.4068053808393971, 0.06554025766200282, -0.4017705566219766, 0.18857633980412208, 0.508563304296469, -0.40897494280443913, -0.29586691318295355, -0.7412149633578048, 0.2422993798474291, 0.7159411865832704},
    {0.48925530886583657, -0.1545947182622242, 0.5815309629231757, 0.15629429515443627, -0.056042168236314686, 0.5580180905925882, 0.6870413639806161, 0.03316104295386989, 0.395980112803885, -0.1351868804557713, 0.28362464552538774, -0.1393331147100992, -0.15314614330849086, 0.158480677487546, 0.5494871923052382, -0.25575019690490325, -0.29123723446177513, -0.5478184105904768, 0.5534358448779186, 0.6545314291415245, 0.15785240884350135, -0.24879666553951119, 0.6455610422152663, 0.4761773361663128, 0.263586619309886, -0.3447278516122435, -0.08531688644176902, 0.47292047248046626, -0.38818358594467867, -0.5858442685536566, -0.2517875453621199, -0.24409917302349493, -0.39148478440065826, 0.5604156674488351, 0.4324201738467901, -0.23064304263411595, -0.2080793741596358, 0.16097025222254976, -0.040208402081901316, -0.1930375317780057, 0.31135023276021695, 0.40448258719893015, -0.4481900715276017, 0.3095496955956782, -0.33844819888701827, 0.3713102899721501, 0.1341416489907254, 0.4546360221595466, 0.5147954997482385, 0.4760832781125287, 0.6822840890923109, 0.00023044578321827945, -0.7237081527654452, 0.1361995213237649, -0.4374070099923381, -0.12208024151470621, -0.4093190617342579, 0.3340906457344871, 0.47128222363212696, -0.6719263742446561, 0.052613256789192896, -0.5175396960307415, -0.1866051714674424, 0.7480151116633895},
    {0.7119501579066063, -0.3088860491446709, 0.4433583901352706, 0.055744622614674215, -0.0850140032687233, 0.3780019490276543, 0.30593752211455943, 0.10084362060194435, 0.04767091269157633, -0.33174892626345415, -0.11537231248355241, -0.5099859891696698, -0.35477155570682706, 0.10260278980103811, 0.8085657807291231, -0.1435472053992267, -0.2739006810477397, -0.33206179966512833, 0.697422853005003, 0.19700842003236255, 0.1479087984230347, -0.10206051819675471, 0.6006808263890945, 0.565775988793889, 0.2357382714434165, -0.18784980262109333, -0.1953849954116232, 0.6853409233634841, -0.5619509931594697, -0.22659274019071307, -0.26694170967149455, -0.20037148045627143, -0.4780333050636669, 0.334558810393026, 0.6267060132973405, -0.15054701630523287, -0.27747518374768443, 0.15170361219157508, -1.3514534009996173e-05, -0.25548710535586455, 0.08673791624372294, 0.38006520152684403, -0.6547407936237487, 0.32793446441451435, -0.3485611654672976, 0.34204885934264245, -0.017488024494714226, 0.35955243586179586, 0.5976249271839555, 0.2768362392103361, 0.42412855073856964, -0.24840597193300773, -0.5772739684784344, 0.19270013209582307, -0.5493713444816064, -0.28135935454146943, -0.6743223250330909, -0.06369461096028835, 0.27488185410182797, -0.6718799677053544, 0.27973382796547186, -0.5709621333104334, 0.3539680168973979, 0.6169215839018819},
    {0.5615788366743699, -0.48727996763050896, 0.3257238602358456, -0.19302986987691625, 0.1032314452722808, 0.5868590625415249, 0.31654374987948136, -0.35712691370866406, 0.03010995658732539, -0.08481817820758909, -0.11476312969617787, -0.22561828824404223, -0.12525915818517772, -0.13297871028616964, 0.5915734419776607, -0.17142662630983066, -0.5078175844436963, -0.4445499532048879, 0.6271969675076808, 0.14305220118622108, 0.2733597405110722, -0.0002076104306063421, 0.4781004615562379, 0.6922269672317417, 0.2712256749166897, -0.09836325599206013, -0.2534429395128934, 0.5177914791777696, -0.5059622221547548, -0.19689879162650656, -0.21575796305400136, -0.3745594580966948, -0.3399848093794811, 0.4809977469634149, 0.3145548973026172, -0.12221060938242773, -0.32123477779969517, 0.3266608103189316, -0.2532939732792693, -0.000631783557530457, 0.18072638343084352, 0.5397819608651385, -0.3900413716642922, 0.40665111633862683, -0.1386864034139151, 0.5372062217804162, 0.31385550468833884, 0.64163805586805, 0.26966940086664687, 0.35535213670835886, 0.36827257375933836, -0.17104907752484297, -0.5219057475697325, 0.21594882530320988, -0.352421470366617, -0.2025687090725351, -0.6419624942948235, 0.048489282938417186, 0.5128750225870682, -0.4152861907696191, -0.046445038634843734, -0.2740920973530788, 0.09907527325327449, 0.6156263792304992},
    {0.5938839747949093, -0.426434560902238, 0.5586058431607022, 0.017905891474679872, -0.09482689749882586, 0.3602242681141058, 0.4144518956156647, -0.2855832778303707, 0.21962918544392168, -0.6118314181931068, 0.2056139541913519, -0.37367383242942415, -0.2123011166279555, -0.4142722755377913, 0.4632927598524457, -0.25408990923787234, -0.5021486235215382, -0.2858724876909427, 0.6202649292742846, 0.3920218743593523, 0.510861960969334, -0.354079943857678, 0.34787713725480196, 0.40899148853543976, -0.03545302505474574, -0.014720944451126696, -0.7150923477744654, 0.5202069042152887, -0.5314248761029461, -0.3956016658857285, 0.02436255231335216, -0.4726540262026355, -0.3651257823345296, 0.3041993001852805, 0.1147528150128015, 0.009969409473239736, -0.5439402012586003, -0.08395429659217724, -0.3486539772921534, -0.11451053233063264, 0.11909470113425642, 0.4321715981711646, -0.37191024018786073, 0.32394249463904495, -0.2791918584318794, 0.4428421338615017, 0.19463812639028572, 0.33213815994258755, 0.6183764901087203, 0.6023811577575194, 0.30143827576310706, -0.06371257508803989, -0.2734266187847096, 0.2492996243631544, -0.426637004964003, -0.6515649863572512, -0.2531038273663618, -0.013371438011780189, 0.544698369527511, -0.45282003885447114, 0.017593153096499753, -0.257046295798372, -0.1471216998189989, 0.4118286181086378},
    {0.564957958811252, -0.37094032712845665, 0.5932925345045134, 0.4302308701564303, -0.27296938857559766, 0.559725292498946, 0.36582063460451, 0.15969250845410943, 0.36222424602618136, -0.39920684217758623, 0.387334954965122, -0.2954629737461853, -0.3190032741402948, -0.09499134942037374, 0.29100092864871974, 0.007326615720491239, -0.604570063843687, -0.5682238755603113, 0.1977101444516495, 0.4889775798242095, 0.2828448189244081, -0.3641828537057939, 0.6228990849229076, 0.37950380378785353, -0.05182275000817026, -0.15240243798484854, -0.364858966697633, 0.43516275751740774, -0.5754643199431938, -0.2879164434698816, -0.1501839377991609, -0.5371044799438565, -0.1297536526622168, 0.17688220488670817, -0.05232035003251087, -0.09498795702092055, -0.644640711097216, -0.2760043297960315, -0.11335956223741447, -0.14166517722902114, 0.18580910928938077, 0.37600869704893264, -0.42637915436366475, 0.3701470755079258, -0.6143561826534198, 0.26695299441885945, -0.03136535756575538, 0.6478747889446836, 0.3162945707654864, 0.5244416805429302, 0.3044617651340744, -0.04826947404968742, -0.5228133179677132, 0.05298579600214932, -0.1707730245164535, -0.5895312145509541, -0.3299519129654687, 0.01831540509811517, 0.4721172894011937, -0.6809131939150342, -0.06685196554737152, -0.3138306865753599, -0.3553786928303555, 0.41816047711847115},
    {0.6466205490090242, -0.4907113297029362, 0.4168925273767746, 0.3243120901066279, -0.46548832582607547, 0.40821415725802623, 0.4514922088939142, -0.04621467301281119, -0.2143571611732013, -0.5288315235990164, 0.035683157084247, -0.5091368766715326, -0.3355869767370502, 0.2934235477047681, 0.2590167481896158, -0.16452645624005116, -0.3946419788963718, -0.4121829419008878, 0.11412012616408386, 0.3256844064873597, -0.009511774918092904, -0.47520273804199303, 0.6027500699088449, 0.49129751730173243, 0.305553129809441, -0.23987805310533325, -0.4568810888739792, 0.4517046786419701, -0.43402301107499824, -0.39306762564123204, -0.3087979079839522, -0.3065054568231039, -0.5972697044407836, 0.2838521712463107, 0.14179454781229262, -0.17308515511204978, -0.08694527918927822, -0.06561396245984476, -0.08308017441010798, -0.05105820016542055, -0.10244932242942291, 0.39767586798148347, -0.5901830281614161, 0.30982457452235806, -0.4289648160021494, 0.2570330426286041, -0.07745873974157402, 0.6349385972485325, 0.5106225465922716, 0.2818950372473364, 0.5360022062081083, -0.06723968499989531, -0.5054862258029891, 0.3129012001098025, -0.4028057467798617, -0.6684775951328451, -0.40661585259077215, 0.2647206372111652, 0.34784104460442516, -0.2726237169571746, -0.10979749372367227, -0.18469822211609907, -0.3491670081762171, 0.7272213048171637},
    {0.6610920710990392, -0.4523696985692585, 0.5325055779670214, 0.11099746607673101, -0.07218733277897832, 0.36945795824855515, 0.5576266114603232, -0.11077719295664165, 0.12415778922113471, -0.4188501467064987, 0.32198884600208705, -0.4449446904851035, -0.27539581846531214, -0.10679788256490737, 0.4483597265302586, 0.0442889529965328, -0.40139837503096626, -0.514449178225158, 0.6126368796738612, 0.37996527661785573, 0.23361182145560735, -0.31857678254627636, 0.5773189336868967, 0.5985635173924202, 0.19368513096533757, -0.22356759979853805, -0.2185004229749629, 0.6523213849763215, -0.6465199131433321, -0.5517043206294348, -0.38490751401159534, -0.4695139171069953, -0.5082138902830363, 0.39431482129201695, 0.31385015996299126, -0.18623693805329872, -0.2526366849533112, -0.21383251475461948, -0.32325514082449064, -0.34328548410081444, -0.06022845101047395, 0.5812797918527838, -0.7661228514782471, 0.4542094204540609, -0.29801736850317867, 0.7076880757768826, 0.15814628721269475, 0.5416622289127154, 0.7305726601529013, 0.42685971742274753, 0.6248102674922824, 0.1353857680335433, -0.7328610669157284, 0.21362213969370727, -0.5381509102240608, -0.3721211572498786, -0.6075905487277223, 0.09473935920331068, 0.4616071670323897, -0.5253010022282326, -0.3082226799288546, -0.4559003524201421, -0.23050202519271487, 0.7364707187931535},
    {0.607822291442832, -0.525185481300529, 0.4445927943827684, 0.40748802619377444, -0.15427275324816223, 0.6145953066669056, 0.09278252020802134, -0.33506310104785486, -0.06772974479869938, -0.30750741524530356, 0.14247790636525545, -0.0954006416626108, -0.20225085138487914, 0.22028170107765885, 0.3722638120598143, -0.464450057500196, -0.40139644324728935, -0.701072837410121, 0.38887542140038, 0.3479516396846981, 0.19103726840946758, -0.5986284022130602, 0.6804346770804944, 0.6650485296443183, 0.18934770210504306, -0.20435000034262454, -0.3312653329107172, 0.5357303725652505, -0.6630448804677336, -0.5959089126000175, -0.36472054273314414, -0.5287328446480151, -0.20651433077160114, 0.5423553607815554, 0.2804027742649474, 0.0081222237734823, -0.29416794413099684, -0.12059705281568385, -0.29070071396633623, -0.1811213170205801, -0.10263460727629471, 0.5133731626485196, -0.6605897010848856, 0.40363297322104297, -0.25893450621756275, 0.3546139671740505, -0.026336122353526267, 0.233040855174621, 0.3859137583424796, 0.49379729904466285, 0.6193541881989193, -0.1834545069672774, -0.15117145157368786, 0.45868440584186426, -0.3124260999138885, -0.5613937841568704, -0.6289540943992032, 0.08001236511107913, 0.6633246737948101, -0.48378962084038307, 0.09141521562490837, -0.4106568112675171, -0.5639471121874688, 0.8879193301683711},
    {0.5179491102691729, -0.49118837349441496, 0.6245026771717866, 0.21834146245031583, -0.44417990590611484, 0.5101485842850013, 0.31817475745852625, -0.15779899749923645, 0.018227671994019205, -0.06927356521179442, -0.0391350758473335, -0.3865561674834935, -0.13301521714987985, -0.1920981422622542, 0.49152370831241315, -0.22154195555646658, -0.42341718801178, -0.37415604534305275, 0.5191646823548116, 0.4252710864668854, 0.08576347040827191, -0.4361979563963283, 0.6251328377888342, 0.5003985732634537, 0.3133856528734115, -0.21376027104092482, -0.1870238315772377, 0.7204365168120793, -0.566375238650472, -0.6332251416959195, -0.1676246681156798, -0.37750870998964525, -0.5373783926853322, 0.5637010954606612, 0.38042956152915486, -0.19120196873172007, -0.4165965552490528, -0.372594635714829, 0.02759201402026323, -0.1296664891662471, 0.2189015887225648, 0.5140958143518388, -0.5417964724065434, 0.609365000876023, -0.4887260743508639, 0.14405080890842017, -0.40344472532391684, 0.5401523943103955, 0.4647387786242694, 0.4673076988575983, 0.4940219288913084, 0.04948886543563659, -0.5660756542368371, 0.4208290382010412, -0.4583839339560653, -0.5670763500165016, -0.5126172241736343, 0.35452508749392475, 0.38259602172117446, -0.4703764453685883, -0.19390600080588533, -0.35728559429164686, -0.5185965343819304, 0.48945617281809284},
    {0.5781255925998317, -0.519578898265414, 0.5558435627690463, 0.23122566109857087, -0.19163006147337752, 0.07220149251194774, 0.3422552544200462, -0.18288108077628507, 0.0527376370337296, -0.1676417313997659, 0.03589658103536234, -0.4552503498256724, 0.053509752978990535, -0.012802599356202222, 0.7750456126266324, 0.15791319106431106, -0.440212737966752, -0.5223674796340578, 0.3247505893665201, 0.5310452986302796, 0.04686641478846734, -0.07057708419778211, 0.6074713016917028, 0.5041314630811872, -0.23902988395253108, -0.3849552753350804, -0.5760669584073124, 0.6405342025156174, -0.8110756392178592, -0.4141068338558019, -0.5148678235639927, -0.09650131177048299, -0.8269468777624156, 0.5337595699425843, -0.07296983884286659, -0.1174798441415089, -0.3368080823332019, 0.015429929034365358, -0.10201322340623492, -0.3666588741698996, 0.16176662743903508, 0.7457251266067927, -0.3674477896545264, 0.4116779552433622, -0.23156914491800504, 0.42269831469960173, -0.2222926308808859, 0.3975747836776453, 0.5152063391523964, 0.4363052845827109, 0.41472476276579073, -0.0987522121977982, -0.14640455141437814, 0.45861886496851595, -0.34238570960819037, -0.4843312496208844, -0.4180460179879617, 0.5334619210601282, 0.5144435820752048, -0.4121662193354453, -0.07351603397661678, -0.7129440761065117, -0.5214822376198257, 0.789249274029014},
    {0.7126833025932592, -0.6719395439331098, 0.7398485319596049, -0.11030124379534578, -0.05163876709799657, 0.26342296619276295, 0.6464715820595249, -0.23382553035479176, 0.2570387026284125, -0.6228773652971076, 0.258213014027371, -0.5125197719210303, 0.09916996233076945, -0.014578063773855282, 0.2851299009306754, -0.17544006477651228, -0.5554411785641756, -0.7297270321704956, 0.24499122334450446, 0.5392676450503197, -0.052547514149412985, -0.012281582128220246, 0.4589704907846974, 0.3647619864117895, -0.21056353848947704, -0.18799185683306124, -0.7356327268383631, 0.5105028484374197, -0.3447026037168812, -0.7275141448061092, -0.37779477514081816, -0.6959161651485057, -0.730769896045668, 0.5215316509601284, 0.35037076570048137, 0.19706081545972445, -0.4951725284999589, 0.053971672394458735, -0.12388166986363727, -0.0886747605578412, -0.04965854223509922, 0.802888028382021, -0.7392280789250485, 0.3809060502638316, -0.44893409756639313, 0.5363140931354574, -0.19935980295444877, 0.6378809155666175, 0.5927616873525878, 0.5580784790899532, 0.4371258170907572, 0.032746018992005056, -0.26752633150295996, 0.3229096486891606, -0.2932981847679029, -0.4846210354104637, -0.755576044475922, 0.3863686037831054, 0.49611404751760063, -0.3929251382385274, 0.038981788073087054, -0.4802835758842633, -0.5982227131537021, 0.597476141675257},
    {0.6543236832885417, -0.4925623099722972, 0.6751316738905114, -0.08599717241498574, -0.10390357312343051, 0.3882976213168267, 0.5736375715137406, -0.3137606466572309, 0.13131909906209888, -0.40623424146305687, 0.33252851852460696, -0.5249808140781673, -0.050068479002340675, 0.0016206572114816355, 0.7051656207016395, -0.2640360758303925, -0.7834748459492399, -0.5406631227213975, 0.6725996005677427, 0.6191136402691939, 0.09849389353926676, -0.4199417816889832, 0.3518771476096222, 0.6484014289939969, 0.20678684724281507, -0.23412822720623558, -0.6861532036675252, 0.861979400618487, -0.5635802990603651, -0.6746886652895998, -0.47362248090044445, -0.38127414745761545, -0.6475675129437777, 0.5384161279696078, 0.5786944255464972, 0.18587975053373823, -0.488206226953001, 0.22044185361407775, -0.05022367512557234, -0.01993126767240303, 0.16376218461633596, 0.698413359313817, -0.6752129196969046, 0.5238864051272585, -0.3877480498093986, 0.510365629399904, 0.2243423625264637, 0.7935092160801896, 0.20903243737347638, 0.6182968283918816, 0.45789540621963165, -0.13469186450402296, -0.4087433769093567, 0.21638150586440402, -0.2656656755983838, -0.5667506611820426, -0.5670285577410936, 0.4138088430591217, 0.5932632605123018, -0.2992352873167156, -0.20550765923208364, -0.6224838600535803, -0.5099855095435586, 0.6538967248647728},
    {0.6414700014293259, -0.7029758526266264, 0.5298307388209295, -0.09047489427793476, -0.21614811817010557, 0.6027250965353802, 0.3462030168384663, -0.23652051537950422, 0.058010604266216396, -0.7136115721906306, 0.27453106544406847, -0.4033653870549604, -0.11213628414772907, -0.0069326459078553546, 0.598914707493163, -0.22034257828852544, -0.5559357320048087, -0.36703010925385876, 0.47485001203765803, 0.16393922635864605, 0.2585543462470064, -0.4215227462622136, 0.6115307716617683, 0.5399593549235899, 0.3244354765604832, -0.27558124454140753, -0.5323106725051844, 0.6095334198285964, -0.7503725192724144, -0.5122014117213884, -0.31607375577524416, -0.4503833138211207, -0.5526119302233538, 0.4095003900195296, 0.30348465671804736, -0.20365065177597808, -0.5826134373083897, 0.348811620450286, -0.19992394361143703, -0.17815955149969426, -0.007201717552235903, 0.699508376940001, -0.4934105093953186, 0.4527975286567393, -0.45411384383646736, 0.4413497558022956, -0.43296694089198384, 0.753933158028323, 0.4211627458275059, 0.2873244047029282, 0.5778167288864611, -0.3591352553670695, -0.39503911724834045, 0.2955385756015416, -0.5624346113932764, -0.3583352690640708, -0.5272339497493413, 0.5421013294077052, 0.5060382638029116, -0.8233227776048763, -0.104852851802302, -0.7376059682379846, -0.454153580534358, 0.6676984530363754},
    {0.636313307543638, -0.5847216230942616, 0.46547994726068836, -0.16436716149377797, 0.003186302676566963, 0.5477475968402116, 0.5505996521847546, -0.3114262747251016, -0.011704676870064002, -0.8398938196371758, 0.05819004772802351, -0.570370271330323, -0.17265750011202072, 0.31579450595816116, 0.4733861498379282, -0.2579293043042655, -0.2780487495745187, -0.4582185561569429, 0.4337369235524845, 0.45658883952746143, 0.28816889809168, -0.12572983698948786, 0.6716326312829698, 0.6192654801443728, 0.38603103206315964, -0.06919644686057284, -0.5029181273046816, 0.5001723101024494, -0.43229124500949684, -0.43430141251115456, -0.422447824520615, -0.25639680273009113, -0.2868617107080847, 0.4847489395407469, 0.13887887807998803, -0.2042871656197066, -0.4144274882270266, 0.4870124037555816, -0.030502825524591562, -0.19409800029202934, 0.10208612071044594, 0.5367824889807772, -0.6586430420228221, 0.44704889014980054, -0.3396956414556815, 0.45916745643470913, -0.09373911568100915, 0.43428714282839864, 0.590786287380906, 0.4398764385620243, 0.8073815645514473, -0.2269973084431132, -0.2618056490528791, 0.42218083712897986, -0.16956087176967824, -0.3577086154387094, -0.44861665256195865, 0.23222218519991206, 0.6172903846571843, -0.7086205811215717, -0.03966837262072387, -0.3768610352822097, -0.4214784923329823, 0.5239256029302447},
    {0.6598517589952937, -0.37791942395785305, 0.5502050618383912, -0.2247445557019382, 0.13018192405249437, 0.20019283026482848, 0.5043216272507671, -0.09347818005006468, -0.09648439395762579, -0.213829177871913, 0.3263508903433379, -0.5457983071779483, -0.06938130564544591, -0.07622709724584831, 0.7141854363672423, -0.13072847337004279, -0.5035558744920198, -0.7590468728781248, 0.46883808365621205, 0.4804556002289395, 0.08549967393891268, -0.40698487141232964, 0.5803607698757228, 0.6427928394885378, 0.13721613374469763, -0.1839011945438875, -0.45447265158569594, 0.3835160080670978, -0.6678790489665474, -0.7634295122933293, -0.4336799066904574, -0.5054412663418218, -0.7645412037078135, 0.34022708301825383, 0.42955261746963574, -0.3717814926436816, -0.6152375054968787, 0.29197663028574794, -0.15898502162536174, -0.10562932870005545, 0.02001473959026891, 0.4301975408672527, -0.551657421298619, 0.350032110641895, -0.08322268970220893, 0.3389954024669244, -0.09710159603332237, 0.5324252229385161, 0.5406616446216629, 0.49234591798912547, 0.6050364630821944, -0.18354062993112194, -0.505387800289283, 0.5401242656916907, -0.3980581505358085, -0.31646153815052047, -0.3199330721701337, 0.5550500989365555, 0.42272580644138275, -0.8885782714985346, -0.06660510368166042, -0.7685822866584874, -0.7043395553958335, 0.7232644863818357},
    {0.5395172228813645, -0.48638948492470774, 0.7407969309487478, 0.03739982934954853, 0.07241816647534081, 0.0459595299391732, 0.6264669770412707, -0.3108243408596881, 0.24590797322866054, -0.6281509009185255, 0.24789435027232287, -0.2973152181563056, -0.07803063427894975, 0.15867285297454198, 0.8243093868547025, -0.22644373400416862, -0.6356888766464909, -0.5626736177109154, 0.4539895900995195, 0.3099278152863244, 0.02071837973445695, -0.3866445390863949, 0.5961602562915297, 0.822084626826869, 0.26311490004574817, -0.09318796916466501, -0.3031928664323501, 0.5465153596925544, -0.5530364724005455, -0.7047769706434719, -0.6690521474629612, -0.6374026654190238, -0.5040656267789858, 0.4706968563221015, 0.46761903987189973, -0.006627135038417522, -0.6337069147517709, 0.08360484156121922, -0.2398922641134403, -0.21210852397281063, 0.03881784079625096, 0.6295107058986681, -0.5784611324521315, 0.4942841828796575, -0.2649667610210735, 0.42952432431441495, 0.12168770289469183, 0.8285028923279988, 0.6985496190405518, 0.47042857084769146, 0.36979659830057876, -0.2088087171076442, -0.6226676339727819, 0.2463201964405455, -0.4943794220830466, -0.4294985371976773, -0.46582105685466874, 0.25871918814258554, 0.410488549769887, -0.759771174690258, -0.0827365271814067, -0.5906595823719545, -0.6557061830822251, 0.5273495023657161},
    {0.6434073342122416, -0.3927487507626794, 0.8175451640193159, -0.10554266010835732, -0.3667745832102143, 0.006304825101028491, 0.18118598277028328, -0.22225263959719457, -0.22719516953714777, -0.5872002093622395, 0.09947004563418818, -0.5926802685662484, -0.32058298528101775, 0.11194153498852123, 0.5937698896603408, -0.10432811183276783, -0.7623492413762116, -0.5234352395924614, 0.3403012062592661, 0.2998302754544853, 0.14643215267950818, -0.4323834279564226, 0.6824184285364913, 0.6210288325536214, -0.15272695548437729, 0.031403240052168595, -0.7101075080659544, 0.46940747771694014, -0.4549402612499247, -0.29452632439430126, -0.47515913084089045, -0.4446717909777634, -0.5379680582300501, 0.6530717820702471, 0.05280221971137, -0.2073180609471988, -0.3700912469756065, 0.058270493897788635, 0.002087368423831499, -0.2520681061448962, 0.021940273131012742, 0.5812762492302542, -0.7793640278970431, 0.5052449854247776, -0.2805262563236203, 0.4074797441656704, -0.3796990183101774, 0.44122165836439164, 0.6006539485716823, 0.4567710734123309, 0.2708171386964209, -0.4765093411294427, -0.34662751377653134, 0.5807222451402354, -0.4082653219477896, -0.5090668161514093, -0.5525310594593452, 0.27025641407614387, 0.27459125219725355, -0.520092886010371, -0.10730520365871116, -0.5387057861549601, -0.4440197909176425, 0.7371455043253503},
    {0.5967997452813945, -0.19330119325859066, 0.775204803388544, -0.08823668882612738, 0.09964040143744449, 0.20199004053525285, 0.35223108344396814, -0.3214533685052418, -0.3731697757669022, -0.648127433207766, 0.3700171995859094, -0.7179837545174123, -0.296680380462694, -0.06894552889293999, 0.40573073670464893, -0.03204620163519956, -0.6774680632925051, -0.6174439865150787, 0.3666785376230143, 0.43472556785479766, 0.1376444764528904, -0.7181081689893292, 0.7449951924296337, 0.6659943483595289, 0.41971439351986783, -0.19041230657788333, -0.3611771282041279, 0.7010528377404887, -0.8418977044923667, -0.7658091418140387, -0.4784022517939358, -0.3507598474572862, -0.7529256906098841, 0.6279697225612444, 0.4118758095761178, -0.1822620434444068, -0.24642704535597373, -0.2695799766835999, -0.3099943092327495, -0.2995426494259538, 0.0609544916785866, 0.7340836413039752, -0.5272987926228089, 0.4475552927880792, -0.35456481150039826, 0.3538090357980172, -0.26070788387639615, 0.47327172668753975, 0.5446552765567537, 0.3706166476723596, 0.36932825460134083, -0.2374697135477107, -0.6789130354504859, 0.48487924511887304, -0.48829118166701235, -0.401215532069348, -0.5160536548126298, 0.3820982894688443, 0.5302185743408944, -0.428857889430157, -0.42942892254906295, -0.6264453540001251, -0.39096524923809056, 0.591434688815274},
    {0.4116010504561913, -0.46381725330491286, 0.6523411845520668, 0.11998973986197879, -0.5683862588970088, 0.3817976080045611, 0.16632175564724025, -0.3653896443881379, 0.020393735261105595, -0.5362508611235217, 0.012627345870723176, -0.7153036015791415, -0.07540334293467463, 0.06067531750115549, 0.3677385348437152, -0.28862835181399904, -0.35293878262034223, -0.8407975455034344, 0.3596121609753483, 0.3816084668719705, -0.0005258419493698826, -0.4506265928652899, 0.7629459268542393, 0.5042729898374632, 0.10777713374942373, -0.04664351195971593, -0.47421588713470514, 0.9338228690455372, -0.8291352940719425, -0.44650365600306197, -0.6778717829413282, -0.42594100522096956, -0.5786191311554454, 0.4423519056817617, 0.3856145703590821, 0.08475515560792074, -0.7282398535158648, 0.3818910658279827, -0.23593422986792648, -0.23526096753327352, -0.0030181222738436568, 0.7315994735761703, -0.6545025963539183, 0.3976397709958222, -0.5380495572702276, 0.27790822982354285, -0.03387929215473657, 0.5715929924187223, 0.36059731783660326, 0.09464796252924493, 0.2627908891196722, 0.18783696214474047, -0.39711894153608057, 0.2659773007742266, -0.5317264265780149, -0.5687231678966668, -0.4804088706340164, 0.23408204187372, 0.411411592511993, -0.5846203347974539, -0.2761287434505617, -0.5535155225836996, -0.46471639913231216, 0.5785351673247942},
    {-0.25093012755143096, -0.4594577804819298, -0.4078713792343748, -0.3881608198308682, 0.6390475676810614, -0.5696469760688847, -0.4264939406994892, -0.5962027522653158, -0.43127086546465093, -0.10279381784839488, 0.42244131119779355, -0.2737329902379658, -0.6402408535137544, -0.4831764039788755, 0.15168510965969917, -0.42620951799640555, -0.45168645276972097, -0.5650145396440208, -0.3041502572778485, 0.19919392064876895, 0.16978187532438527, -0.24180424554545765, -0.27715659714206947, 0.3398317729777116, 0.544908268645181, 0.5614853656005325, -0.6197419646814103, 0.12602156719096677, -0.5485069322162178, -0.5126379571467788, -0.03526417627310106, 0.16571056073398654, 0.5555547055202861, -0.5399298421703661, 0.6851484781802972, 0.39490219415134253, -0.5815378972211671, -0.3207079870419085, -0.6642911622511433, 0.07998084291796073, 0.7141555515476553, 0.020248951858250104, 0.1806829381594237, 0.12351801248942819, -0.4928620113484073, 0.2918123258910049, 0.2451655612207082, -0.21378112653730283, -0.15879607194178216, -0.02893871085762657, -0.6504987577968477, 0.4243582994475516, -0.30366105168008917, -0.46601809703036395, 0.8002595832523023, -0.3017899780507243, 0.07011946001500108, -0.4476878086580834, -0.1275263687601972, -0.2598086460343543, -0.7596355706674884, -0.45562948310341234, -0.6321971537676995, 0.2050963357035446},
    {-0.4738040319956422, 0.37268434509184245, -0.20251068962023752, -0.3189837391930215, -0.10882093096287722, -0.258826302836345, -0.026295932037426712, 0.11786013762647014, -0.40783625962663317, -0.3017723404747349, 0.1371720015928764, -0.342061331983436, 0.1060219997635765, -0.25178451834945026, -0.24613225408652267, -0.061257773449592705, 0.16801360026631063, -0.01939761890714994, -0.18241065503043544, -0.0012253723781467957, -0.09734859740568949, -0.1688763572558421, 0.06996008562704324, 0.3764796820115721, 0.5726437042615073, -0.24941368005298575, 0.16502916661068137, 0.2740156948606686, 0.5077511689780445, -0.1250032776713445, -0.4813356835341624, -0.6248044184656577, -0.10984573004883064, -0.40535928668185717, 0.45160986648597023, 0.1794503457035812, 0.3337059634125793, -0.40771415892350066, -0.047056235497921685, -0.18133786556277362, -0.14337303632547926, 0.06109303870033507, 0.07395681643583785, 0.21344868444647241, 0.2676679789845631, 0.15061393494912598, 0.11403845524603559, -0.1790054086000694, 0.18006703619583264, 0.21091465796357142, -0.260713656281979, -0.4432352255428255, -0.07438022411816811, -0.45047778292367996, 0.5576765937095366, -0.40797243171613723, -0.20865187737729116, -0.11919575090499561, -0.4956405545613093, 0.09775690236170548, -0.05661578500190623, 0.12179607560282411, -0.0911650930464692, -0.15244115048135531},
    {-0.41833052110320695, 0.35869688055453397, -0.4450982747687004, -0.3110531636956036, -0.09197181923127229, -0.24980963277146653, -0.13928684424846546, -0.30236132693563006, -0.24381349478835868, -0.471113356114156, -0.15822357417666144, -0.6475779567697069, 0.14196165782088316, -0.5562888634957168, -0.6040663157349795, -0.44299084384160947, 0.028878942840697353, 0.1730457017089994, -0.6524874879977902, -0.38762685761281884, -0.4399069838502406, -0.6022055075601749, -0.04719358958089787, -0.07674291924369274, 0.3612686933384404, -0.12568318786839758, -0.41877394840822746, -0.044370015137249856, -0.13668049599506152, -0.12217695746609504, -0.03068021447359005, -0.37680049711421754, -0.16114891481872604, -0.5947915094792366, 0.46886552444784013, -0.05792839907138211, -0.09666466244714707, -0.2819633486963399, -0.8416948203069585, -0.13712438805929966, -0.17693357722293507, -0.5053012441315882, -0.19128452397951198, -0.21188281992988608, -0.110495977342698, -0.16648732655045836, -0.3617016175458606, 0.09796163231864478, -0.07267066952021212, -0.3908043489196155, -0.3451022223383506, -0.6293574024888609, -0.3266006792613714, -0.4953655145163154, 0.3840130334600674, -0.43408896778290795, -0.5824308723375223, -0.6008919945366445, -0.7241764713230906, -0.621042931459973, -0.5383762720466415, 0.14705707092754572, -0.051708136349818225, -0.4288299732599017},
    {-0.622210058045874, -0.09764167869831579, -0.2248056357745582, -0.6558199745462291, 0.008018191078501352, -0.5839709827810032, -0.18705303590507896, -0.43354759930482073, -0.2270074727427846, -0.5360167233801496, -0.3864082425185494, -0.29754927331478914, -0.22063635104800333, -0.6722349651477527, -0.3909956177327177, -0.0847377592823434, -0.16662511754738568, 0.032624676417102844, -0.5203239671397322, 0.050690433354110935, -0.5947057434291222, -0.38399628002658076, -0.412905337968557, -0.7113970722994045, 0.1451877981548941, -0.06576726920800768, -0.3952395379043821, -0.11198288438764267, -0.41685224663476816, -0.6574625022345091, -0.02321919170001636, -0.19770355819389243, -0.20291460939264402, -0.07057448773758587, 0.2555760213680785, 0.20000958465252974, -0.003998029300473017, -0.0326056227820575, -0.6047977457727839, -0.9014842952067164, -0.5259493271739867, -0.24075864693956456, -0.28703589751616576, -0.40314424197224047, -0.2859362612911167, -0.07280442039315192, -0.2324583645341668, -0.3176633630675968, -0.06629159362793044, -0.23346078093460843, -0.6748479408419139, -0.4916466700336944, -0.5076614242944573, -0.5713344838118097, -0.07726344580997738, -0.4570775551814377, -0.43763147915425904, -0.7532454125567717, -0.1855396964700169, -0.3168483639233638, -0.5645157914994837, -0.32954743989394464, -0.3839498045212514, -0.4949185828009648},
    {-0.5058487875303669, 0.12649693364271536, -0.03603247154524979, -0.41143229670206694, -0.26445606006824623, -0.3391433782875135, 0.17441617217660313, 0.36477223451109275, 0.05449617556449657, -0.09968250066398818, -0.29674459301057565, -0.23489577532704117, 0.38408836073541114, -0.10011543469095531, -0.283061546012908, 0.012335270078276228, -0.09702767905205169, -0.039681791913201356, -0.5130859765192433, -0.09947926966993766, -0.38966704203068564, -0.2760320453957671, -0.030361150283065783, -0.31107764079517886, -0.015221967386504765, 0.18299978095848995, -0.3244975583888189, -0.20321612243396564, -0.5004259905248031, 0.0399161295391305, -0.32507033154369636, -0.4209995599576808, -0.2790661709377418, 0.10748644286493808, 0.3167534444062611, -0.1556875666297522, 0.314326167075724, -0.2950806897965489, -0.33330116084427996, -0.4558208017551643, -0.36137189309426576, -0.18288917368366986, -0.7003756728249652, -0.4068137557130937, 0.09914544000505955, -0.32993902496987604, -0.5838712033974173, -0.18432975796767406, -0.026802010336821697, -0.07337729321592691, -0.3663722861638267, -0.5858373315672251, -0.015932855178445875, -0.22176419401764344, -0.10980009981373745, 0.14125248153393893, -0.3804660638013044, -0.09218166054534147, -0.32703577591748895, -0.27905886332844587, -0.44377308601574594, -0.0869542549392481, -0.2814695871132031, -0.7119928641098953},
    {-0.15176616845091875, -0.10899756427505486, -0.028057411574019586, -0.3337224129013908, -0.3033344512947462, -0.014535523455055413, -0.011170911192668227, 0.259185960468752, 0.025345916938844314, -0.2537693119706498, -0.3850757845714491, -0.402374464421359, 0.41359444482101027, -0.19837740541671828, -0.19908607011408339, -0.05434135962651682, -0.11621389544248552, 0.12140243473300538, -0.2009647160425683, 0.02463730233892057, -0.349088158127298, -0.24906311278613086, 0.15141727283641504, -0.07682285977309374, 0.01914031470723426, -0.030197074304674637, -0.40793659559516193, 0.334218089829238, -0.013943948798929807, 0.11819130642625623, -0.35960871373769643, -0.39192550557702244, -0.5005217837244497, -0.3295950665763028, -0.17352100461182796, -0.09764361338783274, 0.17766322049648203, -0.41316444148748876, -0.24693350044854975, 0.04349437679726462, -0.3649814970857407, -0.1633977609209826, -0.36114255647587556, -0.2990757127018059, -0.20854730638950947, -0.21952284952455436, -0.3023073290709395, 0.08360993970445162, 0.004391343520163136, -0.2270283961855246, -0.175730598389778, -0.6868592140304205, -0.1679141312171725, -0.48776067161487335, -0.2512348673119524, -0.3670999833134122, -0.4564633362887987, -0.2725395683477673, -0.36537833690787, -0.40856696465759557, -0.26010038467157465, -0.2907644324160072, -0.3266329575106992, -0.36186557294463445},
    {-0.27956015299407755, -0.3406933050249179, -0.33808187258199834, -0.4579827295118822, -0.3444766116698216, -0.5330504360083987, -0.1717330085546007, 0.2937342983842344, 0.04145720076286356, -0.46885114673596945, -0.33403609883629415, -0.35222473709425656, -0.03338328390330949, -0.3316667296624794, -0.37196608678608895, 0.1780641228222988, -0.2231487295548579, 0.01852897820777249, -0.11780925693316552, -0.29695448681479264, -0.5513448982946959, -0.431144922466997, 0.17798968040590304, -0.1963160211544075, 0.10225820210915691, -0.38915855452055303, -0.3393668346702414, 0.09236797032816962, -0.23866071768452815, 0.07787317354176405, -0.2950863942554264, -0.5100051130601537, -0.23206213763586228, -0.269694912881088, 0.22241453749011109, 0.19690451066941764, -0.21191906362857343, -0.5196026378616867, -0.19853294467314378, -0.11368199424071172, -0.23965597219240495, 0.04068022224296879, -0.19880681606868422, -0.22481065829757485, -0.15371892321426592, -0.0539312947785791, -0.3046151896992413, -0.3468197110765652, -0.18429832463897272, -0.1331304209040164, -0.2935427758415079, -0.5272176868493453, -0.2520346530528599, -0.5954750003559033, 0.021437958233477574, -0.4049314698870843, -0.5912948127351646, -0.47772701534643996, -0.47805150390721385, -0.14801244508258526, -0.3777076797660519, -0.33591682771855536, -0.3791155681894134, -0.27592738976237996},
    {-0.24167423764474602, 0.04215924237131913, -0.23165539864481247, -0.12848763390662524, -0.025142478609001036, -0.3678325485831825, -0.05076707381468025, -0.003905939377554287, 0.48270602919223865, -0.21715116203171214, 0.014926806048474163, -0.18389366898794568, 0.03631913671613838, -0.4986051318677146, 0.11270792875386385, 0.28704307358468173, -0.32493811077584517, 0.11375432491761871, 0.010778712157969755, -0.32973234765867254, -0.09948269340013974, -0.3621656404808815, 0.017715547983481583, -0.027863406280620066, 0.031212806561665883, -0.05513969785563621, -0.18283422295837864, -0.05310270033771851, -0.02542419020281833, -0.16250753774235754, -0.25557612240782296, -0.34503996901118167, -0.18359024617146297, -0.18461919585439965, 0.15223345913084665, 0.15725313104536298, 0.053091079746135, -0.15925216846661652, -0.8667355660146431, -0.35417208221028124, -0.2120352737061482, -0.3051414529357691, -0.2966730135166251, -0.09206208879735955, -0.09903552211046843, -0.2778006462548686, -0.0575063252006423, -0.16507107779625554, 0.03920582070798594, 0.022444691460991956, -0.46174997200595624, -0.5007049553307685, -0.5418518189162173, -0.49623407294137295, -0.33703789983779314, -0.44603419954863394, -0.2143937981429128, -0.3769437726265612, -0.49342858880843915, -0.5251302435270052, -0.1056892577471063, -0.12137621569323408, -0.2796525226699535, -0.2366961719982601},
    {-0.2781504097482902, 0.09376376002211743, -0.1662694732900761, -0.3960665481429685, -0.5280900521121799, -0.2745989176299732, -0.22370230740022126, 0.1544525053315477, 0.18236400943922362, -0.43869575672310507, -0.3307589287925398, -0.4305907363900787, 0.0833850042892615, -0.2793040433148267, -0.16570481877911813, -0.30924864294537957, -0.11689663109864883, -0.001600091815311142, -0.5427142140132559, -0.4939777253409578, -0.5975014937137856, -0.2585483644449732, -0.22814500596237974, -0.21732539164997447, -0.15770253621330388, -0.42427532510190274, -0.34012377616911527, -0.3536577741885536, -0.07978186824177086, -0.030923168259065714, -0.1478752037103446, -0.4852112837130914, -0.2253625898177038, -0.06473054629084121, -0.15328696682368245, -0.078284572486958, 0.07869750739635203, -0.12320083237151754, -0.33099607496561767, -0.4724116434380915, -0.6668074322711383, -0.3231446236139485, -0.30548630411465244, -0.3058990826641135, -0.229654646209897, -0.36079429613641273, -0.36451087037592195, 0.013479412073864997, 0.24915664459767714, -0.1763628290748056, -0.11124667236254733, -0.6386257815929817, -0.3853872349534582, -0.0885728044662446, -0.29346336720057586, -0.5692961821927168, -0.10840212737656987, -0.45066480819829363, -0.30295493765598047, -0.47511843972815043, -0.4587089059571655, -0.08965084765825311, -0.3260724305151244, -0.3790622976170728},
    {-0.5153848063811022, 0.06460893900041889, -0.32002647627383846, -0.21039322887607775, -0.15082068067334192, -0.4088160471745603, -0.2164469209922107, -0.08113985328320603, -0.2426726677005538, -0.6656880948776575, -0.4795304143970392, -0.561776633709885, 0.08236773015967305, -0.17324768333720203, -0.3004436724734765, -0.16915989696349962, -0.123097319679595, 0.12005993605828492, -0.3795113330754019, -0.4068762635237182, -0.678126882534238, -0.4324061400140132, 0.05037352502244273, -0.25389490687275684, 0.358955605717586, -0.18809859223556574, -0.5663413348462435, -0.1681427599679569, -0.3412695816036187, -0.27691120809671643, -0.27938687447465294, -0.6990349823495131, 0.11858406957941164, -0.03260011969758681, 0.3835918641184219, 0.5224806690060406, -0.005700470822854805, -0.7553415919078316, -0.621041109600466, -0.3249544968570573, -0.3073027019969364, -0.15754110663915416, -0.2667328145626266, -0.20865769080081958, 0.2649228229556748, -0.4655986255984502, -0.3220339420669689, 0.05923639188310552, 0.302131066411678, -0.38773267783582716, -0.26398564019708765, -0.4684758065858281, -0.2610672528601516, -0.6352740420104468, -0.3271804826044144, -0.5353263239435425, -0.27572559618254766, -0.5666338058283806, -0.3078211581838459, -0.21842177217941133, -0.6646339562444702, -0.14504624428890403, -0.052408173742350773, -0.16806684626202686},
    {-0.7646781457117411, -0.6144560354182435, -0.39987975779464635, -0.4603505216602464, 0.057088030818873266, -0.13914216348939962, -0.5880220787543753, -0.22865770895665719, -0.29973778124698713, -0.49449049229918257, 0.09354881018637613, -0.3909954746954428, -0.25421266422385413, -0.603751175327663, -0.152382887438562, -0.5059988424473817, -0.20610860773731876, -0.08616903595615195, -0.3407440015944724, -0.17976102568334076, -0.08310423689492923, -0.18419783907894943, -0.29276777756026073, -0.16905009527788445, 0.12226118082844982, 0.08549594972160204, -0.49602722708308267, -0.02592618445828091, -0.127536961975977, -0.33085670431026104, -0.03470179854204462, -0.5478943701426691, -0.0032741435664325634, -0.3200203674729144, 0.4225707247323512, 0.688221162456039, -0.04174520548928951, -0.5580083522057333, -0.35594716005294963, -0.39926498392425286, 0.05558322746033805, -0.15492945940034736, -0.10939341085677824, 0.06893873922475206, -0.3453555439710075, -0.18942908507441017, 0.24164795163878994, -0.13877757360073256, -0.08576562780506718, 0.053218400949633246, 0.018166560783816333, -0.10065277936828677, -0.3900637539840963, -0.08345205468940207, -0.28674802511267933, -0.16153268486626715, -0.020388009434086272, -0.12182335474417642, -0.2097430678458718, -0.42412565796621293, -0.37973396573923335, -0.6100327589451657, -0.4741074445449803, -0.36221245530914076},
    {-0.5819985486158451, -0.30184680140092385, -0.5129523253666034, -0.5932688771298121, -0.20354069422993212, -0.4047523004803441, -0.2671030660173385, -0.08624321311844867, 0.128853287105938, -0.5052576238872665, -0.1689777008066161, -0.49051669723440255, -0.1853309108008647, -0.3983029225352278, -0.07296715604156069, -0.5811264352357234, -0.1265002313910533, 0.04796653256646029, -0.22616748537469486, -0.28357528712749325, -0.1877553904148855, -0.36850527913745584, -0.18442555394201463, 0.08879436051102248, 0.08692128293617671, -0.12089820588675174, -0.2999539908903559, 0.0578413205006616, 0.08000921155941929, 0.13203941980440495, -0.11686250441213315, -0.3821191374922905, -0.03219657501047584, -0.3849168306982613, 0.22402817834851976, 0.2939874695495892, 0.21341621516466056, -0.3840027020050018, -0.32901042212192094, -0.01544307403591667, -0.025498583921626558, -0.29520492465216475, -0.08699318950311048, -0.2501839304930863, -0.3448662907711974, -0.3321907199253276, -0.37234467443688196, -0.10946142308022046, 0.1804401099870719, -0.045677552315639906, -0.29674482337860963, -0.2537059483681914, -0.21993963346745765, -0.2442896088651103, -0.2773276852139229, -0.3854417478876921, -0.626055165953647, -0.48126324785857855, -0.46125188978583703, -0.5096444469587953, -0.1878070408273946, -0.2750197871563014, -0.32511902361112943, -0.1437627937358431},
    {-0.4666470600751771, 0.10676198334858047, -0.34005391358039044, -0.4161055538988965, -0.2674742879904653, -0.36201980617382834, -0.05655897133261721, -0.25214063879532295, 0.4001965185350455, -0.6066797256216436, -0.36370485986749945, -0.44429424677002366, -0.1253768094314617, -0.2277100454330313, -0.004799156990924956, -0.2518123963376229, -0.2641759690181876, -0.5322996223902702, -0.20446483000362986, -0.32197647824982084, -0.41489699249559053, -0.5457317220984991, -0.23184538551533107, 0.00784803975683315, 0.05205449802721419, 0.004802919601047544, -0.507051152282366, -0.2561381109341945, -0.18867470824141624, 0.37375408273958416, -0.40452672842857806, -0.7149980717754049, -0.179700701393148, -0.3960785132815834, 0.08138626288706677, 0.4006214146658736, 0.003611805949533426, -0.3621051655595481, -0.582433703770243, -0.3512758445174673, -0.27617355689414963, -0.36884524231154237, -0.38719151833499416, -0.24835884556100757, 0.19207631361311095, -0.33155820509679323, -0.4007730480740762, -0.3159880449777205, 0.1415384260012143, -0.17941491115253147, -0.4886116032328149, -0.23985835000515993, -0.2356175551526379, -0.3953633480610934, -0.5459792365577018, -0.2905083594092841, -0.6478160046968894, -0.314301712775144, -0.34755066441537313, -0.6683457523035418, -0.3331710204679076, -0.372129626287247, -0.6048570956035694, -0.3477729212684768},
    {-0.4192200367033298, 0.0716249712857302, -0.35673159004263244, -0.23317180719480662, 0.03797941302760045, -0.4788354236129503, -0.022782088789469045, -0.20047161770024155, 0.22315141145425818, -0.557907204568419, -0.31297325126834724, -0.5665161941175351, 0.05826308744494796, -0.4819114239146253, -0.1436631923903607, -0.3261796282170578, -0.13148767872219852, 0.20753545030980589, -0.35131336377516276, -0.19621077329026715, -0.4901515351572769, -0.568357748299823, -0.1808336438963901, -0.44646963002746815, 0.21340906781956456, 0.22429362144252957, -0.5813399397228439, -0.18252143461500198, -0.35857545264887186, -0.17071258735207534, -0.3552503562975254, -0.6124765632851593, 0.2130391909721029, -0.21427505546240075, 0.38262324008223414, -0.1276125946288917, -0.1785552061014886, -0.45498821886008123, -0.48619729691222163, -0.45518897083184434, -0.21367603754995085, -0.12131219699678951, -0.5102219343469531, -0.06990980842157618, -0.24568930799273528, -0.09348645125030268, 0.21041585499049262, -0.7181192899177141, 0.046646251892431885, -0.2491093044445394, -0.6544985403795034, -0.17638770576592067, -0.3895592498363811, -0.4195899838294974, -0.04382465704212089, -0.2762172386074499, -0.48281361413720386, -0.5206888660357006, -0.6189974061733682, -0.5940543481798066, -0.6102854216060972, -0.4281917377313458, -0.5364510573224445, -0.25838706663065913},
    {-0.5608320170979555, -0.012429441010315793, -0.4350015722758169, -0.5922595416816031, 0.01446619542843943, -0.23550629539248685, -0.1742354913752807, -0.17560577169659342, 0.07260840941772433, -0.48489479384722756, -0.31160524935914724, -0.5250991259715834, 0.1795462684764273, -0.31609775843877064, -0.1427033054880925, -0.2741091448985267, -0.2628023759260523, 0.1968390972158821, -0.6001179199879497, -0.16671371216845757, -0.7405682204339128, -0.43108632607961217, -0.48371444930638013, -0.4764087074110288, 0.09408902298638679, 0.10343781826775293, -0.5030024502090573, -0.2526843058150226, -0.45175008084865487, -0.34574688610602666, -0.5435951323478103, -0.532339635927635, 0.038414603752037604, 0.08651069714164948, 0.3239128177163192, 0.06413180339822269, -0.18945789439074548, -0.3650620312085839, -0.733930835608408, -0.4119549193307794, -0.49857514919192664, -0.21958999376228766, -0.32430682654978854, -0.1995073898471923, 0.08866465787534214, 0.012418093581321009, -0.14068358848707493, -0.23057236214677707, 0.1519098649186909, -0.31251427405076, -0.6832283580331328, 0.017961009120011535, -0.5450993647841073, -0.6589503981990119, 0.08709744690558748, -0.5758975319294146, -0.5333418467031665, -0.4214971536967711, -0.28802542166004175, -0.08160685810549385, -0.513777155832373, 0.034493217983059474, -0.47645659404987195, -0.06712787199023594},
    {-0.6674433155912097, -0.2184005843675881, -0.19952941472072538, -0.6274131303517145, 0.2786044611949304, -0.4264391508678282, -0.45480367707332875, -0.42878976681367825, 0.10878754792849103, -0.5163481952602358, -0.05979644793958532, -0.5472777121386577, -0.050968210401931835, -0.461164559766996, -0.22027830979851099, -0.31250770414891016, -0.336177076403372, -0.22305626252104516, -0.2535234465677918, -0.280467335842993, -0.6099825059524419, -0.5668130342829141, -0.2323139562667201, -0.11317277887469053, 0.4134951625339138, -0.12434139727657449, -0.4960884127582866, 0.007859610407417896, -0.3744397822191843, -0.49056204474431625, -0.5792831185755697, -0.4797797495432816, -0.09176513361795045, -0.08872728920248696, 0.367920663088682, 0.21432688130644165, -0.28427584927503285, -0.5930061818771155, -0.5028657746623276, -0.19694263280822824, -0.4953433263162538, -0.45614155194013517, -0.4848238432182803, -0.03703656728886762, -0.06356185074046261, 0.16808399839731783, -0.23100676216775584, -0.13783964221278797, 0.41497461582800316, -0.3671521752672591, -0.4519650759731249, -0.4163985193001275, -0.5398369699621016, -0.3197188262812619, 0.08256836859262484, -0.644572390446296, -0.38739068982074376, -0.6449715160518257, -0.5067316561506301, -0.556044104790543, -0.3091080545586062, -0.48192208778601187, -0.5250210064217377, 0.1847346873980024},
    {-0.6030576089039497, -0.17566770892827824, -0.4568007026667266, -0.4641116749486608, 0.031703118785327875, -0.6813904881474752, -0.25769078707818566, -0.19245368281908667, -0.1409928928173382, -0.3245176646740778, -0.4482684470947806, -0.3792833788304956, -0.24659978852837128, -0.4767496818200884, -0.3772137104386971, -0.43589607461601887, -0.46333292107269625, -0.40659531395509685, -0.36081543687649736, -0.03902869815159414, -0.3731325021632676, -0.8116436455947676, 0.11494803665727807, -0.11933791130022256, 0.35672318599524877, -0.059984004609451434, -0.3903719161824003, 0.20986199372351133, -0.40766519201928675, -0.2773995269438847, -0.32458907004943754, -0.45310210803091405, -0.0757822120174725, -0.3864572336428174, 0.4221934052182361, 0.30586469450352105, 0.02562497674293397, -0.28953400958874087, -0.6202568040968107, -0.3799862836855784, -0.6489543587625745, -0.13514188220603257, -0.5086768134313592, -0.28074093482481866, 0.0880415627986262, -0.02159253303916897, -0.22996668187430083, 0.0019939262928277994, 0.48807481734762886, -0.2926327168971008, -0.6912951612915575, -0.157474986008506, -0.5699815911226157, -0.5143413095049676, -0.07403713806184499, -0.5066786728251882, -0.31251653276390856, -0.5830556670712367, -0.654454478349554, -0.14518740190985113, -0.4842000791967587, -0.40235302231990006, -0.51264110241811, 0.0648911497840736},
    {-0.1177414661662956, 0.13653172738445277, -0.5634489836595707, -0.4602830747961732, 0.08882559466930395, -0.5659916329417652, -0.18626923318348063, -0.18970853439743512, -0.03849249402841322, -0.5332711363902292, -0.1034980536604384, -0.36417037382345224, -0.1811393061528449, -0.3103838163590126, 0.04306567900383646, -0.4206582942681687, -0.446889428508687, 0.10156900272101838, -0.4392763038210746, -0.05823465299820575, -0.5480134222487927, -0.366998801144467, 0.04279704622164293, -0.1872350347983187, 0.6000135045140954, 0.4861083241156097, -0.25832347773672737, -0.036489911692237906, -0.20726208424104947, -0.07316301092702439, -0.38671401138767, -0.44678820544677045, -0.0576471729565558, 0.033639876149410594, 0.47635134127836637, 0.16069968573912324, -0.18385312474380375, -0.5899037239193392, -0.2771848591274088, -0.5176283293484616, -0.5720741316393155, -0.1431542002671642, -0.23458366080187226, 0.2956773236692356, -0.003944626171576723, 0.04221937843597951, -0.3547043494272687, -0.13338348487099919, 0.4191838550983567, -0.23338735207000297, -0.4087355937515778, -0.24777327293925164, -0.5029805718395896, -0.4706133594076117, 0.11456005141082515, -0.21106118206284677, -0.6186408313992877, -0.7322092813291011, -0.586290294698315, -0.1725678039306428, -0.2270066228491819, -0.1692092660058182, -0.5385519066582959, 0.10936864263470057},
    {-0.4984628363402698, 0.17530297957121993, -0.48327089122490213, -0.5198236118609719, 0.43072792897336326, -0.7153849330051885, -0.3894756758466531, -0.26573892462572296, -0.30988128480925087, -0.46756107251697043, -0.06786203017164667, -0.5890652081280033, -0.07692032307746366, -0.3942402883689089, -0.15110471623420077, -0.5340240903543723, -0.3656258747700306, 0.11015568354681432, -0.07183027053173367, -0.09712138654748263, -0.3827541017533468, -0.7947585728311266, 0.07619801226784173, -0.4397372727995797, 0.39762481480918377, 0.48735448043411855, -0.5940727101145733, 0.2273577504097343, -0.18373138180100834, -0.07606118916107205, -0.1898627974894789, -0.40430815353188226, 0.11931679474145615, -0.016571400130611563, 0.6235675879978594, 0.3630213758137143, -0.1858903687524126, -0.5339609610322898, -0.389951938615281, -0.29129438526731205, -0.13233573846986796, -0.31404936727343996, -0.20138290604358264, -0.08807107841200464, -0.00698020529533076, 0.1536094354844026, -0.09917462300513692, -0.40074614541812237, 0.13475431871010352, -0.1594882326129246, -0.4253608082320997, -0.04923475566185844, -0.31057019481135867, -0.4225516818160804, 0.14309414342793608, -0.3648763637874314, -0.492836715673191, -0.564479560671666, -0.5439289595564368, -0.41497917029541936, -0.3622839865846207, -0.19806563445634948, -0.3131762636475289, -0.020819116258283667},
    {-0.26566422416157803, -0.26108062808506755, -0.5198108493247942, -0.6110282948512266, -0.010971813052408484, -0.5152596499140122, -0.4946145180190571, -0.11539351292423175, -0.1671714094187437, -0.5020873290534246, -0.14890529263789162, -0.3011414926481525, 0.055467174035664646, -0.5233967936242164, -0.41176397625296784, -0.33831590673688233, -0.36603737809118503, -0.06880366757504328, -0.2577505080678655, -0.4237976418811264, -0.39462345560429907, -0.5291317932592042, -0.2085799319928364, -0.06169032237835657, 0.18502242442527575, 0.3614173041868175, -0.8968718626604846, 0.250707040189471, -0.2824595323056936, -0.3315063233784904, -0.3628987711007443, -0.5554128704871691, 0.03782910154833568, -0.21937018035844777, 0.21718696487986186, 0.28619565641689937, -0.23237544125694207, -0.6276344865301727, -0.3843261216660869, -0.5478337272418718, -0.22808897082105456, 0.055455485517309874, -0.41123314504706393, -0.13743344195014565, -0.17250690123093662, -0.05888471363450488, -0.09427065124626154, -0.36942887441367006, 0.0732668176864903, -0.31304265878418397, -0.3970467204391454, -0.3045697825630659, -0.4865863557601903, -0.3421565944738831, 0.12184138396416165, -0.4247661565200384, -0.32583630405716374, -0.1261039980612665, -0.6406971672764707, -0.5468745527382631, -0.5172686768681604, -0.2100402304416295, -0.46048634466975424, -0.198932840410032},
    {-0.4825785024774303, -0.08517101022340597, -0.5077564601284678, -0.9886802270418585, 0.3194708509433942, -0.613858643376025, -0.3201692562624434, 0.15178133159361276, -0.0989612843551806, -0.6244325863914088, -0.11221037737229679, -0.4031030000684254, -0.18671094088953744, -0.5754794554324866, -0.4589024942459316, -0.6704969209158537, -0.48587866019126486, -0.23636335404766115, -0.4716906641118835, -0.41006338913927054, -0.6469086331972991, -0.5667092874835556, 0.058626268568100506, -0.24258022533248794, 0.35372049750772955, 0.3076801752322195, -0.4860381362786675, 0.3901844161313033, -0.07948781405241823, -0.514500880895454, -0.5581815933144287, -0.565369917204334, -0.2564376604206616, -0.24830333147347652, 0.39684477094293763, 0.45888586090366856, -0.026708089966931622, -0.5320573243025323, -0.7036431069408706, -0.6230969080762878, -0.4164592224113792, -0.5837564047993692, -0.20894974441662617, -0.2621079992360765, -0.2473474511216601, 0.10320712422430213, -0.3083977873368283, -0.10708191118733133, 0.1570222295641385, -0.32180645741646174, -0.6514964374021415, -0.31576016894518116, -0.370526243097147, -0.6359375276010168, -0.027367841789141766, -0.4590805475392059, -0.5398416998817718, -0.32363296363415334, -0.6376863611549677, -0.6693753878408704, -0.4826650714351814, -0.1728137495050516, -0.22318282862601196, -0.29127254280743037},
    {-0.48792231036638833, -0.01261955432217271, -0.46389990272670967, -0.8867234843600129, 0.5238108287958373, -0.4803561648641583, -0.3171586691093424, -0.31599759239875164, -0.35074784820561633, -0.6001067878386421, 0.31989304643855754, -0.4871183307409947, -0.3509122780329364, -0.7107596297810161, -0.26090929855988887, -0.45555241484093134, -0.31599882073931657, -0.05775173347178353, -0.422514005627602, 0.06138037810540289, -0.6542565797818823, -0.6063641905946698, -0.089275459060629, 0.3134597669578662, 0.47796190659874804, 0.48987331726813793, -0.8140529594997241, 0.6166814979990171, -0.30855462042431064, -0.5886898517552475, -0.42958276761013525, -0.4605544493114098, 0.17246029370806598, 0.05155847547115785, 0.4426359356979074, 0.3113140017987569, -0.1810743007522393, -0.5749537377626354, -0.6247248630704385, -0.5657860054910684, 0.07003165037825204, -0.5143562314470062, -0.18424334885398308, -0.051127988725205326, -0.06509054828497894, 0.10792059527573825, -0.25225939206365455, 0.08768484570944851, -0.13450663768145, -0.37785884710157525, -0.7037584698034735, -0.10277277796460399, -0.5356226615269154, -0.6755432041622552, 0.3274691131879984, -0.6030267402703168, -0.6587866632385297, -0.5971575764044327, -0.720526065842509, -0.11791213308465517, -0.6542432834627755, -0.44616161084745887, -0.2649772051128502, 0.22368831770985811},
    {-0.5460274028652498, 0.07885601930885351, -0.3233759509723042, -0.755342957048716, 0.6427861439857435, -0.4605457153083625, -0.36038192411799574, -0.1785256783234848, -0.08443122632284696, -0.33541966911262544, 0.38871026869541503, -0.4483517070970076, -0.2576218446303918, -0.49998871284790275, -0.1226481055888437, -0.6303129445318737, -0.2914292315509264, 0.2556621092615213, -0.2517956471393285, 0.08962256903209982, -0.36598924087023516, -0.8331724446882297, 0.017558582240417175, 0.3351725299241233, 0.8752822956589923, 0.6154496084751012, -0.32778034360828034, 0.5280918177904316, -0.6028797119422459, -0.7435590830305214, -0.4196437982597288, -0.5329920656407297, 0.5970269181735455, -0.09648130409280332, 0.606935241098677, 0.281988004567461, -0.4164689935499811, -0.6869342753819352, -0.605630061581009, -0.47609786137128307, -0.03596169413542577, -0.15023142972026518, -0.46632425302104635, 0.057899749033242805, -0.01281336157614359, 0.7966379477830574, -0.2801744365708648, 0.36327136663544074, 0.2888623008350029, -0.13692146669623367, -0.4865968999553078, 0.3917832838290999, -0.549667032173842, -0.48273956219770425, 0.26239645021422336, -0.6592364911608666, -0.4596449170702492, -0.6545987959819427, -0.6258183897053284, -0.2974808430360111, -0.7633703381527379, -0.3229830467054178, -0.23576465744929465, 0.25944798297952754},
    {-0.3096337813913749, -0.059864644184542175, -0.747546244112659, -0.5405529676626911, 0.715194472042034, -0.445769603059183, -0.40653161556010076, -0.24865585488875533, -0.37107275742292434, -0.5138434488015049, 0.35354770811696, -0.44346279492586776, -0.2122409230690607, -0.9287419470268551, -0.09626930253229643, -0.6897495642261883, -0.2777963120703265, 0.14062589755670513, -0.32178192181953885, 0.20834375891221824, -0.46388389733682234, -0.6659166050778486, 0.014525545151607144, 0.06996013304207832, 0.742580873282132, 0.5636571926865216, -0.5298389320399369, 0.759507833312013, -0.664753875241628, -0.3689168910098294, -0.20478511363861263, -0.3805383832945889, 0.09613215217895536, -0.2570357599931987, 0.6383512331288654, 0.45283716704945837, -0.2859236903075215, -0.4331400692359626, -0.5574870077721387, -0.6113077685536783, -0.0367254385248431, -0.24296570133968298, -0.3929141603435921, 0.14199659017726027, -0.2691211248066202, 0.4980336033898957, -0.32820843431724317, 0.12540902126427944, 0.07426518999607767, -0.3580519987751668, -0.41662859220030357, -0.110337208826297, -0.7462246383328486, -0.6697786452649981, 0.367989615251735, -0.5851642313648134, -0.6116560850055344, -0.7334995028692061, -0.5519750270454251, -0.44192322762827363, -0.7824184010189782, -0.2167491574171359, -0.35905666323269836, 0.07958165288297785},
    {-0.3708786379778846, -0.3615788759024697, -0.7274869268816276, -0.5844570775308355, 0.10707565998425998, -0.7794608868594186, -0.39720083686065644, -0.04874794503856219, -0.17903948368395994, -0.5622829187356266, 0.0056425931258214206, -0.6188931982743096, -0.3440214537579279, -0.6822224838302767, -0.24384447709677096, -0.27055946964486705, -0.5254028749504409, 0.024418728934191034, -0.4370997043967923, -0.2608837556845556, -0.4939620907104104, -0.7435906914270474, -0.007999292681672746, -0.13625031412840272, 0.25036825330025847, 0.1877021738195996, -0.6624615179786191, 0.3569247749928879, -0.40621090267201404, -0.4096307209731681, -0.44684013935076977, -0.12574972961344638, 0.12977427311685422, -0.026809725601589365, 0.5072905768567062, 0.26388555158127464, -0.24146276255041718, -0.5205181257256736, -0.60942919514114, -0.3863703672561905, -0.25272564861860125, -0.7555507513363784, -0.45738317043901333, -0.22893648049939389, -0.3202007827975908, 0.05401546628239937, -0.3705267427784914, -0.4276470323921218, 0.2667988607013707, -0.31112238253347835, -0.48097231931976653, -0.6786709720421142, -0.7270829688437102, -0.823463269343367, 0.09258297317857142, -0.46498207348634923, -0.6984916528268772, -0.5810203545316492, -0.6669040179176616, -0.8280646893974716, -0.501880038307397, -0.3080321474631505, -0.6171446448463068, -0.13939850610959179},
    {-0.4994873028075137, -0.21792126637118006, -0.5887024952619406, -0.6074699069250303, 0.6318731970748759, -0.4118489008780734, -0.2994526569908418, -0.4652940278283959, -0.7165820378125235, -0.26471996162529726, 0.42744019533218325, -0.5085697832777363, -0.35936593302151154, -0.8914170064499299, -0.10285326131906675, -0.5336086433119255, -0.6190048450087942, -0.18701824176143642, -0.1820575706780878, 0.053459524681980314, -0.42302706025533027, -0.803514414853356, 0.07893708951443809, -0.10489890172484966, 0.7447294525317026, 0.632040736899345, -0.6280590202196018, 0.49560955720792177, -0.3472433246411843, -0.5122299340793743, -0.20075895260668725, -0.6209865357598687, 0.4816830554150852, -0.06414157404648538, 0.7146740794994791, 0.6772487238855248, -0.30375719890814384, -0.3710727963674833, -0.5863502248998891, -0.24449468064247476, -0.12859017336342152, -0.06879448919305522, -0.15275433400135846, -0.016691691075945213, -0.20263679274559204, 0.47720611175435496, 0.056816092546331465, -0.18225061708470078, 0.3934123316514174, -0.07347903171004876, -0.5053696131205576, 0.17988997119208375, -0.8441872670557838, -0.5278361924592809, 0.5829812687677466, -0.4991274850467034, -0.37258768973855677, -0.7269823984162457, -0.5727209953369513, -0.5479933097513231, -0.49076738729213193, -0.4059168779941024, -0.596924637002385, 0.3537593943144003},
    {-0.4714291211137778, -0.18455437438387717, -0.6185573720530986, -0.7687010555574357, 0.5372234644508395, -0.4920583112227275, -0.48167891622116316, -0.17153476633876635, -0.2358582186920907, -0.43183466115811703, 0.334678976521559, -0.4811110438829658, -0.20256998930566314, -0.5814444322019731, -0.37615726162728347, -0.6538383574309196, -0.3614086836719261, -0.2102490881746412, -0.31915544039379706, -0.1932066847058498, -0.5076733119720086, -0.6611932657840216, -0.10512405830840199, 0.1312996753568125, 0.7785048366390186, 0.4603943468268407, -0.7646931687308153, 0.5169869609865416, -0.38733186279996196, -0.5609581193460277, -0.5209939320579494, -0.5985678356232491, 0.5585584326222099, -0.26991386077374036, 0.5270384713582369, 0.5086202213962945, -0.34779330815085774, -0.5694925530340422, -0.5046514228117825, -0.39253180726565584, -0.24942844604890035, -0.3264803926341075, -0.5271142739157839, 0.1116890657761273, -0.27077750360805236, 0.5381615452320334, 0.04152056578772587, -0.02637256543984001, 0.5775810881755754, -0.06492250434472312, -0.4873605000151018, 0.13446142452225007, -0.2669745694023701, -0.6023093570899718, 0.6251194564397092, -0.6806263130056356, -0.6079020489669666, -0.5447008741554467, -0.8602533196033827, -0.4295981454419995, -0.7398047721593703, -0.22779319318729055, -0.5075412309748806, 0.20414912036599472},
    {-0.8840112943870821, -0.313156958426139, -0.635938526229361, -0.8508072633645424, 0.7308935774951066, -0.7392098803370067, -0.5063573156969249, -0.1845563106861611, -0.537710317172199, -0.5532765673175388, 0.15410574358755663, -0.6422824318134395, -0.4779784626377844, -0.706605108020414, -0.3844377537173082, -0.7105655939131765, -0.4517262115456076, -0.15687757420927417, -0.5503496063494222, 0.0368516969848607, -0.7132150771393552, -0.8481103327882048, -0.3893066784859779, 0.17625133925794223, 0.7250322249760168, 0.3141594197887571, -0.4497028206347439, 0.22514107881821344, -0.4900714357938838, -0.33926003947698496, -0.6022195966670609, -0.4331443541207661, 0.4249404457681541, -0.06578235132936645, 0.556564376491861, 0.5425790202772579, -0.3957257818749743, -0.5920863252143538, -0.8212743114512415, -0.3992938879510492, -0.2717778753236316, -0.4702787382449077, -0.3285107140014652, 0.038649696426797706, -0.2931978895073669, 0.2878714335325959, -0.26205472382672945, 0.23610961059742616, 0.2579752521812686, -0.5150738856966257, -0.6306764288726586, 0.049049555846967186, -0.5182975889267629, -0.694415949619023, 0.261406320927887, -0.5571646718484378, -0.3401904883454912, -0.5690478815798145, -0.5273515644638478, -0.6250710780332441, -0.6727550659561576, -0.1712325696793814, -0.4438942324733211, 0.3293982408251465},
    {-0.6114936128496977, -0.15363173259173007, -0.5705109432816167, -0.6597853034037203, 0.6343762769091581, -0.7082624279550043, -0.4520162537951566, -0.3016995274181083, -0.06576882976484516, -0.684598828965721, 0.10990952622355413, -0.7983394159623364, -0.6349788672169914, -0.7705712952016163, 0.06529531295100857, -0.33453785736066094, -0.492513989601343, 0.15793935003507958, -0.21319536437367984, 0.12779769815302322, -0.4431085557990837, -0.7330607523428342, -0.052209073097519786, -0.044136127255280454, 0.5357433056601522, 0.3296086736236987, -0.5461223661558595, 0.520662825844208, -0.288322325561035, -0.5887498431558792, -0.3476919506682504, -0.6242500308832214, 0.6092111416326537, -0.014909917934016578, 0.7921510840004284, 0.6234389058629732, -0.526237189014871, -0.6293700385634561, -0.47507659541447905, -0.5925742597477317, 0.008776826639613364, -0.5055736042157274, -0.40486681312466893, 0.21742017599044636, -0.24068622183259464, 0.2787107218117306, -0.15162401090875013, 0.3210822457062055, 0.4139696559408051, -0.2125304844705376, -0.539095190774279, -0.009702235036933887, -0.4134101426827456, -0.4469917049424507, 0.4189508870318333, -0.44195958742103664, -0.46150423372111055, -0.5919608423780665, -0.637888717688814, -0.508733625474429, -0.6236751494951298, -0.5092844677240735, -0.5472006937437753, -0.06256314227548603},
    {-0.6084118157482962, -0.05152525801904029, -0.46229211771684464, -0.628698478546212, 0.5127435324848619, -0.6155501722731997, -0.691385442289933, -0.4274711146167578, -0.3283720786535715, -0.6210156196888529, 0.191261112723045, -0.7193990401546526, -0.4757126962677342, -0.7026778729293739, -0.02459836139192547, -0.7027799464042849, -0.4724643561307077, 0.29133425830859017, -0.18740885611097588, 0.040049763645181646, -0.5023917806287015, -0.5509079462613143, -0.193772095464242, 0.316759920137752, 0.4977426574160258, 0.515818881803698, -0.4469111649879334, 0.08193647381324597, -0.6592086421647911, -0.5880691335058815, -0.3284236574963657, -0.37966611706045456, 0.34872992606495135, -0.07924939189622582, 0.6709174753887455, 0.42544606548607194, -0.3116646617693463, -0.49749039725138966, -0.6541042914551454, -0.5979483145131164, -0.037984588388244984, -0.15610419652159868, -0.2893011930929727, -0.06647156600844123, -0.3737850581048692, 0.2816957653990565, -0.3057745509714884, 0.02923525645712533, 0.38273319677981377, -0.30795609198831597, -0.6293446054146467, -0.04125379184669432, -0.9255942087773096, -0.621867408306564, 0.3436460812459799, -0.48859638343720235, -0.6208071507118395, -0.5912004812133355, -0.4939719435935588, -0.3931345600618083, -0.5946163992673761, -0.4037923076259969, -0.42273402570847657, 0.25608309915713173}
};

static const float b1[64] = {0.8157313188242281, 0.7743277973776117, 0.7924281309896785, 0.7721951927083895, 0.8115300339188065, 0.768075271837821, 0.7158212419191226, 0.6783601460272142, 0.6282535118094046, 0.8102454707851948, 0.8029842605182721, 0.7731381937796824, 0.7252815910499546, 0.7405094656084711, 0.7942048998258281, 0.7171564540568967, 0.7610103956109086, 0.7848151728800362, 0.7376701461988094, 0.6581114222295592, 0.7613095149647767, 0.7811582112102655, 0.7891567416708849, 0.7603551195875784, 0.7850561994455287, 0.7614140803719862, 0.7435203930489898, 0.8299305570340576, 0.7668082319274483, 0.7892881908802685, 0.587774897914574, 0.7505109118298079, 0.8052146691750541, 0.7378873016881605, 0.7398479565008129, 0.5628780195028447, 0.7862024246079552, 0.7274903804559695, 0.769374487465977, 0.7436453914459358, 0.7912111585275345, 0.7459203197647488, 0.764558237578198, 0.630687070221649, 0.7877766354155533, 0.7406959463812581, 0.6194819154520343, 0.8276892817734193, 0.7666720979774752, 0.5853982790206582, 0.6895161659374985, 0.7701308699495272, 0.7895339421532156, 0.786725091514372, 0.7529239165268515, 0.7023952185588688, 0.7793968962796054, 0.7239661401530847, 0.8021747415530943, 0.7598288195429602, 0.6044373854567906, 0.7924145739676095, 0.7724306380310608, 0.7535635155966028};

static const float w2[64][32] = {
    {0.6673452001013451, 0.5924723260243675, 0.6727190843890409, -0.11828879240273883, -0.27855985925378524, 0.8789443482102179, 0.83360466761039, 0.5745452180176596, 0.9965097781833988, 0.6213747929497971, -0.1881479631226649, 0.7598184648719335, 0.01590066335856081, 0.7174204922817633, -0.30730665216252506, 0.08679138577322147, 0.6952907427064626, 0.9121017382150483, 0.6395703359903516, 0.6563829779788157, 0.6674722052531593, 0.4773020768082109, 0.7202039534014685, 1.0776738942015007, -0.08486007475901121, 0.4069441680456863, 0.8596587044674228, 0.739115519548263, -0.02767796996455106, 0.9744374619438432, 0.6480935866502099, 0.6308384698415286},
    {0.8309290358701714, 0.7520559510737107, 0.586133665601571, 0.03409393362326325, 0.05077498985282379, 0.5663352576037969, 0.7477690747965283, 0.599153221285708, 0.7543686905966476, 0.7341526366816098, -0.08246617688644924, 0.838673347693332, -0.27473795051093214, 0.513521481009885, 0.18587145486985263, 0.10800530219816533, 0.5238918336053313, 0.9593127369071676, 0.890904117643216, 0.9128033323905066, 0.42406410984844023, 0.7983377582624467, 0.5348940480557071, 0.9012717767410537, -0.043774974783932434, 0.5363806600416161, 0.7615073514035298, 0.5566505364668183, 0.3848428757373931, 0.7576412532071821, 0.4482569384164464, 0.411546723324188},
    {0.8128213822361863, 0.682951161657858, 0.8804540899056831, 0.06832543759280578, -0.10875608669540975, 0.5910684702078977, 0.6765110192464732, 0.4035073894783767, 0.6822546515219834, 0.7109840752589153, 0.17632129475080108, 0.5265015809026249, -0.29925110796659254, 0.553823419581632, -0.0020432004734793983, 0.043649068139342065, 0.7130029532187598, 0.6000011823838763, 0.7895814808560111, 0.7210873886330802, 0.5120147624512663, 0.8873318268539405, 0.7049370101549061, 0.8580223493536419, -0.21352382601172734, 0.1577217517329692, 0.6399944592617718, 0.9816581128735106, 0.20907886381176213, 0.7233272537151916, 0.48708196194297854, 0.7480407567386391},
    {0.8628647952060686, 0.9109250154538512, 0.7414275039478716, 0.10596472517148484, -0.08837368581904356, 0.5474320195198744, 0.6247993129505858, 0.4395147095825865, 1.1070041769027434, 0.918485086754258, 0.26749032910134507, 0.7072483482994559, -0.32847957143714834, 0.6215728272987547, 0.1421562422485989, 0.026330832601477352, 0.8539754714149814, 0.6196437870550182, 0.6606583462833956, 0.6056715166725873, 0.5605216926757591, 0.46914474278134155, 0.6827425929002428, 0.807622226787961, -0.11594593063488985, 0.21044363757547757, 0.7134636157713236, 0.6533081077575338, 0.1948562399154884, 0.8026964782651106, 0.4466572093809003, 0.4272730886363154},
    {0.7880310848838838, 0.8010732927488473, 0.6364041432776844, -0.15676090172220172, -0.0752779604517459, 0.9040121878369768, 0.7890354207208384, 0.5873393880004587, 0.7096151289502178, 0.6747949734619255, -0.0974314673463164, 1.0737992805528866, -0.25047847057342915, 0.6567873142262247, -0.2842538247824041, 0.251746888953137, 0.8295920418933098, 0.4820506998447367, 0.6918948389080898, 1.0477842780180473, 0.2743724403281381, 0.6032872347384075, 0.8735206746433499, 0.6424898793366844, -0.006775208334138219, 0.44950573706567803, 0.3348247380281735, 0.6969362784901368, 0.31602888784233024, 1.073584106955251, 0.4434275291666008, 0.6310406599920395},
    {0.8958113856680932, 0.6973360935403525, 0.9540961345960972, -0.040869334883912305, 0.03787214548470689, 0.6419341845478862, 0.8753677668172637, 0.384250604878208, 0.7778930160117412, 0.9423807614604585, -0.412979178223368, 1.0018701260924614, -0.012210035988612785, 0.6476798606159475, -0.22108846393545928, -0.13132448457277893, 0.683156807853453, 0.756609223979991, 0.9101538414066517, 0.31417092210936814, 0.5815909320697464, 0.6474280676153009, 0.8305140163546472, 0.7356686410922753, 0.08703678168304586, 0.3221665495235388, 0.5054771998793103, 0.7232528829334437, 0.32803963761649363, 0.6532401745729165, 0.5499235855213599, 0.5246407697866818},
    {0.3739801780010184, 0.19376950852050043, 0.7713328624836303, 0.2175791407197095, -0.012343598638538626, 0.9633086777552127, 0.5576528375800844, 0.5537410186194138, 1.104002818337339, 0.3640222368088121, -0.4472094433641649, 0.20468063281007662, 0.16210176914659322, 1.012696901615756, 0.01820823087508192, -0.3688087159950338, 0.5992647530992631, 0.574089351283567, 0.7153334415561562, 0.5471771779348054, 0.3295207746940134, 1.05153961941716, 0.6691596675059792, 0.5838132984039005, -0.1547249276315206, 0.44095544666886344, 0.8319974111472946, 0.5626394179421904, 0.5847372268866649, 0.8856739640823228, 0.5619400039010168, 0.21351013548400105},
    {0.842538833465975, 0.5665749758492155, 0.6747266575488433, -0.3816065516144245, -0.004430370059675589, 1.019426729804886, 0.5811542889075451, 0.4023913572016553, 0.6713578986556634, 0.6991180333669156, 0.04691335755484401, 0.6841983403692722, 0.13163177923483188, 0.778298228535531, -0.1297639715532117, 0.09651171408087766, 0.7351576872023383, 0.3308522155906014, 0.6510102985860738, 0.7163718275636423, 0.4581805758445214, 0.5950814209070221, 0.5629087384511084, 0.48277600586079433, -0.06990859005328959, 0.38978917948790387, 0.2902891100533942, 0.6601244450758207, 0.22652784323738648, 0.6467520212950171, 0.7229976717242765, 0.16514489169637708},
    {0.8138713485692713, 0.26609096961413065, 0.43187235754169556, -0.08399656794508349, -0.10895356617412942, 0.7221774149105936, 0.6817847519102379, 0.8222256638157581, 0.12465283420759676, 0.8078852949067998, -0.07503449133296479, 0.6843460979021276, -0.13012258402828808, 0.8179641174937728, -0.1141787258122835, -0.10658513606729383, 0.590069919581096, 1.0127295915019656, 0.8733016728184331, 0.5955473311368279, 0.0951092643909805, 0.553115384610756, 0.6554546462246283, 0.6595857747967349, -0.2508378360031912, 0.10422627843267707, 0.5783943594951982, 0.6121031939247014, 0.26645391750916714, 0.909202866989737, 0.49819547087317967, 0.20642966926590095},
    {0.8671210630886482, 0.7754591918726242, 0.5682335044232133, 0.1712864287017549, -0.2354606930450183, 0.6407651035285207, 0.7819282941127749, 0.21006965308824088, 0.908613174395752, 0.8929098341862939, -0.21633595308860307, 0.659691291217155, -0.001206986959206737, 0.588384791052595, -0.10711616059041125, 0.3254700098852056, 0.4316799737874664, 0.9621700465574652, 0.4904401018007276, 0.6883337842709332, 0.47892534576037304, 0.5132464520831156, 0.6040793286672108, 0.6173921469464123, 0.13494787006564798, 0.31661305592982264, 0.9179264973209285, 0.6505530982563541, -0.17218226440916917, 0.7297803778642539, 0.09707516164959473, 0.6443354213113309},
    {0.7240090149388416, 0.32654113855508476, 0.9574314112906602, -0.289572946097792, 0.05294218391174022, 0.36073143509766153, 0.701031608413182, 0.6185846150569707, 0.7933145959127985, 0.7480725494545093, 0.048045929123229754, 0.45974951764274335, -0.002884937082635178, 0.5731124887450461, 0.09295085031270221, 0.03887391419274812, 0.6972636158407427, 0.5271530023865134, 0.8086901452010438, 0.8340468994327632, 0.5347018457466285, 0.969387276052072, 0.8458028529502452, 0.4289256231322772, -0.25204497120479596, 0.6471361878493427, 0.9203560438655725, 0.7317305200891923, 0.4315542566158233, 1.0927648230205285, 0.4359699903742819, 0.5474204074575009},
    {0.8949008249121304, 0.5792073359669393, 0.3235173637433946, 0.0038171892471618512, 0.2568965922055991, 0.8351227283883587, 0.9577061321392318, 0.6034589317313979, 0.8556953824141417, 0.7623568103653914, 0.03207920804429937, 0.6926189048841643, 0.09032250295710241, 0.383231804032539, 0.14071916511873295, 0.21680743881494915, 0.5266914871363767, 0.65071748137585, 0.7024502589434592, 0.6596758525197762, 0.3310592285581637, 0.5578262913548339, 0.8654979896479844, 0.5889219742049356, -0.11516751158225828, 0.38698051869524214, 0.7527941031075707, 0.8804709064939469, 0.2825359094380309, 0.6256913133263704, 0.3911834738993668, 0.3586107834174826},
    {0.18681089597406025, 0.6042145343408849, 0.8574354325859236, -0.23870349079839076, -0.017621457836346617, 0.6964654200024796, 0.7202670932500322, 0.4016979498599783, 0.7367082846247361, 0.7643164477515266, 0.015284660001281179, 0.8833880857779615, -0.017658071280817495, 0.5061059844245115, -0.2005509581797603, 0.31580175708051583, 0.6864901925939643, 1.2135638262621464, 0.7219919194227296, 0.5884388171844048, 0.11157014104530193, 0.4650907576017347, 0.37936102217783296, 0.8287202623778682, -0.19493915248364282, 0.2452492473186716, 0.7442088799263458, 0.6744653303132981, 0.026656946375827537, 0.793551815748615, 0.6112670649173312, 0.5165943651342153},
    {0.8806372025512266, 0.9090487827234065, 0.5474518187624148, -0.14871275436131606, 0.028136728715699378, 0.5974074362551082, 0.6425506199736764, 0.48289788022502045, 0.928107337577095, 0.7166687683207231, -0.34578277894772413, 0.7749679389880524, -0.1516316693352504, 0.947580137741054, -0.023013258670675583, -0.08012232970326644, 0.45370918262670357, 1.0890717532687508, 0.7891421304827617, 0.602471734030171, 0.17251553408880138, 0.7706560972749958, 0.695499073494941, 0.4648109551452686, -0.01006484273199084, 0.5979239696290566, 1.0280091608420039, 0.8057488417703811, 0.13677261758560985, 0.7162348071497622, 0.7929265230136177, 0.636310766492209},
    {0.8669959290531127, 0.38258107771756583, 0.624998603704355, -0.09382523413230387, -0.3352440667706289, 0.6540900611977033, 0.6593842784203586, 0.5470408276207113, 0.5737868433879872, 0.9310043438891583, -0.056765570994495154, 0.7763040579492773, -0.1882416953960364, 0.5976779036992893, 0.19657786301108676, -0.15135246848462333, 0.822127516541941, 0.8427781265692321, 0.8303583814815673, 0.4476342773812365, 0.49099022909289053, 0.7309579124259304, 0.4001245575291307, 0.5715110705159062, -0.024136990489982902, 0.226079699919853, 0.7730453141415665, 0.7545674837194568, -0.1443640124904147, 0.9138045372094278, 0.47705767179025194, 0.5397206939068208},
    {0.5743209157789183, 0.9212005370092564, 0.5491147435155777, -0.03037779577147764, -0.05427142263126961, 0.7702766141347412, 1.13217639614696, 0.21749905127172608, 0.6019389070635647, 0.732551163305255, -0.1522130222433469, 0.8439868849744014, 0.3625535240687095, 0.4418965819389213, -0.03650979366685314, -0.3682984751397203, 0.645159228579001, 0.9483299517869161, 0.6213178121890709, 0.9477616583104491, 0.23971430419477013, 0.6831021265569144, 0.8019530184241012, 0.5032877219335428, -0.2016594238499452, 0.48185507723107096, 0.5602436605977906, 1.0575303348325373, 0.18569555153743098, 0.7348097273118962, 0.8091832172697346, 0.8151838431603855},
    {0.6071057680525224, 0.9221554926008879, 0.7502863259423042, -0.10071623756324125, -0.08391798656363463, 0.7743763127729454, 0.89924036133994, 0.28933453875519405, 0.679853677291794, 0.7921822734473268, -0.1672295528348899, 0.6623389956955947, -0.13678978896739127, 0.7611752588030666, 0.2189850966787931, 0.15039894132929596, 0.5839038632259689, 0.8886846336234955, 0.6157659835296001, 1.0534011046119518, 0.5630388876492883, 0.6309661347839721, 0.4335220075321975, 0.4285479152995584, -0.1148619766617519, -0.06488469448014204, 0.7209708717783225, 0.7142138681024394, 0.03793286207137145, 0.542526125317336, 0.5871162537536114, 0.19329460335123905},
    {0.7775663547970731, 0.3654179297283281, 0.41771489855203253, -0.10142030598259022, -0.003938821016944035, 0.60914765258807, 0.9292611995679486, 0.2758396221707154, 0.8717455991050224, 0.62929358956582, 0.23758961134042647, 0.8242793251157892, -0.06701400728407314, 0.6756490268722356, -0.2277359926317437, -0.5014698576589823, 0.7574516391222897, 0.622897666426152, 0.6198806395857125, 0.6811837853937486, 0.48413935770312405, 1.017350971001163, 0.5850370544478214, 0.6313169843668331, -0.04453736206438542, 0.5594612150092847, 0.6966078751558349, 0.6352335336252738, 0.44249987198083574, 0.7774023167348978, 0.6725074585806863, 0.3772646523275068},
    {0.9858302077009466, 0.7147941588000835, 0.5273308582421151, -0.02330143676300134, -0.10116595780532532, 0.5501416726645812, 1.049080411292011, 0.26104376816318703, 0.7743141680536811, 0.7227049711004676, -0.21126696056686523, 0.39905250257315533, 0.020486552454182325, 0.7192724760098642, -0.35398464120108103, -0.055004687277125194, 0.5346541264932925, 0.49681850862556204, 0.7033369137110942, 0.6301789420279765, 0.274939874242208, 0.5941852378052216, 0.6416550733312857, 0.7082959451020535, 0.2246261186998274, 0.3695312946449199, 0.9083961864349678, 0.8904399133047852, -0.011332907312870939, 0.8664188336418603, 0.6172528499449559, 0.7422908940524925},
    {0.6649686684295547, 0.7877266675195487, 0.7027146284904189, 0.2115451048781184, 0.005066967528406342, 0.6959432247817184, 0.7879641899159816, 0.53860901288323, 0.6670493863495508, 1.1790849837454296, -0.04014118163185843, 0.4806059854445304, 0.3169706095487627, 0.8415305474229295, -0.0913597531602664, -0.31583124944656427, 1.057846692184447, 0.4268745882816009, 0.569517910603436, 0.5396465240509488, 0.28265592662000544, 0.657261418167481, 0.8775512579610054, 0.6718469645865274, -0.17163440621255135, 0.44181050874288114, 0.7526809242236971, 0.4883452256881689, 0.14631645210907937, 0.544399214016768, 0.627841764643454, 0.5630823080224671},
    {0.9318077976661674, 0.6426596729552577, 0.43021065373270223, -0.041455658620865976, -0.002892067571969166, 0.3784512552953421, 1.0092529161384056, 0.4834125385156806, 1.0025991236506928, 0.956337205468189, 0.09828579717497173, 0.4972782939286781, -0.038822494514446894, 0.7256865678406823, 0.32541003267905527, 0.04134362938757827, 0.675177286521537, 0.5765543036095362, 0.6185033350818366, 1.0050036316188038, 0.36140835552848105, 0.609479756275649, 0.7369373856049484, 0.9391598477152883, 0.33075638804068314, 0.30583413275777965, 0.8489851520182935, 0.9262765572602921, -0.09986509042906963, 0.7869692430314764, 0.38998834463272536, 0.24028953273077774},
    {0.7193609890119987, 0.4098500419449209, 0.8576835523720054, 0.021951859359885917, 0.11487617593736849, 0.8317955721118742, 0.37563240882297033, 0.6868797685855956, 0.6353998974771836, 0.8129310146973807, -0.17368124533233997, 0.8922015260595051, -0.12415363488968258, 0.692154676376295, -0.11828822261042413, 0.11642401253309496, 0.8245700764607653, 1.0137699622219032, 1.0607045690635635, 0.7551777988767026, 0.5089641772961252, 0.681399403219261, 0.5549025269117148, 0.5953629785138441, 0.05115744272938307, 0.45867450615762384, 0.7099525719069247, 0.38961992299141224, -0.004482161839690171, 1.1657372316805275, 0.8884452330066263, 0.3680185074887373},
    {0.56134221372081, 0.5401997838950507, 0.7685613670433435, 0.1456936625052295, 0.03426541677561581, 0.8117234238265841, 0.5828001161856949, 0.9190156890468927, 0.8104479816905392, 0.6753251723481195, 0.011813445651681846, 0.8845837714335987, -0.02696122629756203, 0.6405990387576289, -0.03690933326693129, 0.144971407836655, 0.993524242854457, 0.8090193913888208, 0.926256486810149, 0.4982866971476441, 0.3577794442967477, 0.9122530507404117, 0.5121204041676004, 0.8480271551615522, -0.15405403832352776, 0.4287057108581788, 0.4640304733602451, 0.8485356772810663, -0.10716315823637143, 0.8700490094598283, 0.49516749850471375, 0.6854370182789701},
    {1.0584616008260481, 0.8442390347499727, 0.8524204855578055, -0.13587664378440578, -0.1333802850600918, 0.7461479972008899, 0.6555504741878098, 0.5455948047043109, 0.6601398234763235, 0.5317918667670437, -0.13726137631398694, 0.8740334202498546, 0.1415312091140852, 0.8196481438985457, 0.008063058179905602, 0.2134004856946373, 0.9051831570449035, 0.6070253525774759, 0.9384394342057145, 1.0072975473497603, 0.38125110157355746, 0.729949265401408, 0.5944480698097584, 0.4437081904548551, -8.698157543505484e-05, 0.40350770909580785, 0.8736254493283567, 0.9465573681796984, 0.21971877807844167, 0.934495319591932, 0.9266937464107158, 0.41011041055923075},
    {0.8970298333316368, 0.7974774799290462, 0.9402012936497387, 0.0021428224633561256, 0.10238947336427137, 0.9756267566422384, 0.5935470610092313, 0.5646594949923586, 0.8678451933107447, 0.7755749356250061, -0.38036329683162706, 0.6945699095077621, 0.015725416046862558, 0.701189167709706, -0.1527706839790262, -0.11457100244275945, 0.5185777980564091, 0.8276465059382914, 0.9484631849252914, 0.7620170308004355, 0.39176592700660356, 1.2004790573101627, 0.7086779697798006, 0.7030285933012497, -0.007760537599195507, 0.769785877860561, 1.0472546113745018, 0.9848441471865337, 0.25102185672486954, 1.1935150951199898, 0.7081820189471306, 0.7007397743617948},
    {0.9017181105593548, 0.9859362177573351, 0.810273081816094, -0.13102022130198437, 0.2434386808646579, 0.6414381867567385, 0.6487447855100671, 0.41176017200856174, 1.0140424885867614, 0.8046624047134774, -0.2287026972240382, 1.046782861716772, -0.05149144190687818, 0.5405307724655881, -0.24868415313297623, -0.05531458885705452, 0.4539832780193107, 0.682332977235055, 0.6197224808520073, 0.5041677766119815, 0.783311864841871, 1.022203183331765, 0.5426153990817392, 0.5087736081874851, -0.02425638208295904, 0.34415468787894943, 0.464749207422004, 0.8844643145885841, 0.4857686689371942, 0.5533982461207556, 0.7626496397047557, 0.8795965844689101},
    {0.6126246113070704, 0.4859975194317682, 0.8812247620891571, -0.1435517859174087, 0.003541380613599768, 0.8197968680256312, 0.759976398529653, 0.8299508810312525, 0.964218953725987, 0.5996262160562659, -0.1586848096089484, 0.7993224382282426, 0.0193039423279511, 0.2917612984694516, -0.13327446911404073, -0.13359964332450777, 0.8544142323681929, 0.686519104525811, 0.53881822608827, 0.7788039264695601, 0.41515933643684777, 0.7806187585326254, 1.0227887505569953, 0.3085186257244976, 0.039004162239365044, 0.34760232499168797, 0.9228026389816498, 0.6643176262251977, 0.3193696335781478, 0.7665481620395342, 0.7596168032279808, 0.8215759641800912},
    {0.6168403831726413, 0.8240533740532324, 0.5796008270275587, 0.08166188484802382, 0.031157532089051376, 0.8854940453018729, 0.5884203431501589, 0.6899053651406349, 0.7959112723859421, 1.035955518444884, 0.026609600945270834, 0.9286558796848452, -0.3974234742988215, 0.8493967525466061, 0.0681570344740778, -0.012687545902689775, 0.8017557867241794, 0.3410213205866834, 0.6219137830643763, 0.5979324977295195, 0.5417089663079174, 0.7966756861796176, 0.6553873187815401, 0.4143061011287372, -0.12370636466772826, 0.4267932702720312, 0.8828451224311811, 0.8381056352399482, 0.12169322231322133, 0.7853747546598221, 0.3225232704010287, 0.5706990338508139},
    {0.690853829260148, 0.6938785943488235, 0.8152093068774208, 0.019331725920519367, 0.07236932905131561, 0.5920951595212621, 0.6741672204222698, 0.6361452229991279, 1.0137499431805546, 0.6890304279678298, -0.016385711577763955, 0.8423771763254313, -0.21093976787556698, 0.6998826758172274, -0.09410797782570132, -0.09962050856359728, 0.7275527317507907, 0.6929087093741203, 0.8418573951976671, 0.8890724870462068, 0.3939957501916597, 0.6592720754511372, 0.6572676757454866, 0.4334789723523347, -0.09011699715753133, 0.40396196365028, 0.6550985394283677, 0.6882199019585683, 0.23208172915526612, 1.0391633625958672, 0.7001148646514967, 0.3540390524124895},
    {0.6351657755062554, 0.6623178966526614, 0.9128118720672556, -0.0883554577939286, -0.35454333551297146, 0.590279913687032, 0.7183495180030302, 0.5836358415491897, 0.7483798142166187, 0.6877281620397637, 0.3912654063170492, 0.834036873932084, -0.23263621716154909, 0.6448961155933979, -0.16371161963967928, -0.02513759452613001, 0.3123284335547977, 0.6149915912314673, 0.8902293248815412, 0.7458560980036086, 0.48107956452036926, 0.7107383565097508, 0.6512228853420379, 0.6708524487308923, -0.1646223392895383, 0.22501389875672628, 0.7467477925565741, 0.6627328903079484, 0.009488679051805764, 0.5982532842409981, 0.46047132876096775, 0.43157861292270355},
    {0.8412317308652356, 0.5089603286325608, 0.7420496949117255, 0.01524929586026938, 0.10370782013578009, 0.7902222013826085, 0.6038369232942922, 0.46212168407930615, 0.5210059406652586, 0.6523223058629349, -0.14523790142040643, 0.9373765088165437, -0.1216754878666217, 0.6138352998286626, -0.03517848816967744, -0.12506227107097095, 0.857911901856706, 0.9892670330490805, 0.6097309604444392, 0.7544880740791389, 0.38684544676048394, 0.20816240041274572, 0.9799583768964265, 0.6984009392771386, -0.49758644019590675, 0.26220219386833676, 0.7303328613426111, 0.5492004696392628, -0.015150282753459043, 0.8248282878212426, 0.9065201217589784, 0.3755535747984935},
    {0.8135907518854134, 0.6550166224973551, 0.9497543731502806, -0.2365428189166025, -0.27234808094213464, 0.7873538521393124, 0.615728755248865, 0.5404356506947803, 0.9538284778621553, 0.8915109152421096, 0.043091224549505557, 0.9064616379821504, 0.14703268621436968, 0.5027808700107251, 0.18396206436917759, -0.0349953166075498, 0.8007613155597384, 0.5435041453383924, 0.6902302107626964, 0.6764394861964355, 0.04320312013389956, 0.6786712872332199, 0.3606860263808934, 0.5750836645162924, 0.13819604187551232, 0.3848514640955486, 0.8803010563503979, 0.7495812321523566, 0.288806024801796, 0.46222704168232925, 0.6411626999642217, 0.42161835126343494},
    {0.6021086850460449, 0.6108388690302401, 1.0869265267722454, 0.016671618460746714, -0.20208788352420803, 0.8494372322623261, 0.4659806520046129, 0.41247113349828163, 1.108570051569515, 0.6603616162628053, -0.22816727264025052, 0.8017202489845314, -0.5592929233183148, 0.6978262712350153, -0.06666052702212728, -0.2392289165528142, 0.7515586720744293, 0.7029886690824617, 0.48252126563630965, 1.1291533541447605, 0.49273262704638776, 0.8211822039974577, 0.6289557174515347, 0.7388261176671692, 0.15597201891836288, 0.3651392187490197, 0.7175639224469107, 0.6598135933890676, 0.24958410168736617, 0.7339623543083126, 0.6862763238118986, 0.5355455098114902},
    {0.5470138539662726, 0.5843645315926693, 0.5934108195909656, 0.08122377340827211, 0.34378939958056876, 0.693753460508431, 0.6263955654894906, 0.2491579276977364, 0.7303925152833012, 0.5222425073289767, 0.0277967026709366, 0.8369830701069885, -0.05537347683349294, 0.7136508090629535, -0.06840545424033732, 0.012060865722929838, 0.8007828321785849, 0.8187242105335032, 0.8705228553136586, 0.7568708051511658, 0.4555729813519627, 0.7980404786222128, 0.8432070506166434, 0.7441590633300175, 0.1220429085614643, 0.3418962671500856, 0.7887824753704104, 1.0192926261261015, 0.18618185418064756, 0.6608227150190075, 0.4617697660742753, 0.5515993497929039},
    {0.492366643235837, 0.7396046005986989, 0.7580395777282454, -0.29192493819571774, -0.18472399067273765, 0.5620598367460133, 0.7361579504216599, 0.8915251238334319, 0.5527863589611729, 0.766110608184237, -0.10329752376945721, 0.8916516417429058, 0.0759610671394553, 0.6625653392496351, -0.18470079111911528, -0.29372868725216283, 0.7927959450894642, 0.4226785643432428, 0.7349692236307379, 1.11694463698002, 0.36347744622277467, 0.7422597941910267, 0.9690330301474782, 0.6482159297303337, 0.11006845305283684, 0.5481766679483878, 0.9914251781786189, 0.5928951049771823, 0.46766630643734247, 0.8698870782716486, 0.39557282639725605, 0.6659740026991282},
    {0.8744599347113924, 0.6040685677518436, 0.5974193471863538, -0.27166506539292185, -0.18070513260649254, 0.626992371799558, 0.7773931715750465, 0.4794566917132905, 0.3516848209488559, 0.4889492941883369, -0.03370016206287824, 0.8667783009286308, -0.015786972333539488, 0.708759937717904, -0.18122826501861877, -0.16903330426685595, 0.7170909934872497, 0.767890773922672, 0.7346721603388985, 0.6436013608416878, 0.11946652018880462, 0.5707105552695189, 0.6375688596998769, 0.7139945358799954, -0.24610442877811706, 0.48849446788311124, 0.8527125676793805, 0.6177543727565281, 0.2979532377664722, 0.852464397156725, 0.6077766709020085, 0.8713072292922063},
    {0.9582735091634768, 0.41960611551731564, 0.5173136458345116, -0.12366034971519141, -0.22931018324753438, 1.0915203200087737, 0.8135860935366938, 0.42541718311182003, 0.7149486501726706, 0.6211603422202251, -0.25625386309008585, 0.9942302393537966, 0.06551791479972906, 0.6882150064249214, 0.009408719730647679, -0.11934108543068928, 0.6700644186967238, 1.0348300503555343, 0.897875709528393, 0.8422014784166894, 0.5363415017334804, 0.7319496126032582, 0.5845841274577106, 0.7076284644109688, -0.019152510928701634, 0.47029275269528326, 0.8210635297868676, 0.6177134770911357, -0.14814187316293456, 0.8215075220191078, 0.2857193714927863, 0.21609536647887798},
    {0.6640595738635265, 0.7567066250452822, 0.3369712799695386, 0.1362592923484978, 0.212469425238958, 0.8760233618282894, 0.8044198184353261, 0.7433887835702926, 0.7346893184308109, 0.7213879212201773, -0.03013220258941197, 0.7433700892920865, 0.23851623373051498, 0.4473833202741535, -0.06810124444184079, 0.09277310399428193, 0.659285313890766, 0.7117331502161256, 0.7545151048778069, 0.7251684950264782, 0.5837527660549938, 0.5897913868219244, 0.7425540884016474, 0.6002006796932952, -0.11230208720016405, 0.5144148983203318, 0.7718962989587799, 0.6924477926202415, 0.22703402149868523, 0.621565037492836, 0.551474955418011, 0.4210832646479561},
    {0.8604684020791311, 0.4859091186903096, 0.7591481074118391, -0.20265141288221283, -0.55218625956007, 0.8229399447973732, 0.7594891244873451, 0.4160438191512516, 0.9189700390881127, 0.9821336598062675, 0.21154322288243974, 0.5593256791164972, -0.042765458768793826, 0.4674096086278949, -0.14137005540874753, -0.24944235002763057, 0.4988765542724125, 0.9322095804943433, 0.8190255639122, 0.6652540215182062, 0.010758053949962999, 0.7835315905020362, 0.2664923843010258, 0.6050021838096902, -0.10231734045261964, 0.061152089738914714, 0.6129004322449642, 0.8837556352109035, 0.17807825916174114, 0.4457519607711804, 0.5717391675500852, 0.4666668403317199},
    {0.8820785967750875, 0.6774291360541087, 0.5642543958667762, -0.22663886009577427, 0.05140925562589327, 0.7746435955001468, 0.6226527206001918, 0.4714833027541564, 0.7363784697589836, 0.31729585173721564, -0.06424863213478872, 0.5203936373775522, -0.28935577201107376, 0.5665773778409666, -0.16628671052791813, -0.17012780626649884, 0.7696353346875298, 0.896669354046512, 0.5820155571902099, 0.4733923751999831, 0.21936453767620792, 0.6431075958157193, 0.8834232068744844, 0.6509743907740616, -0.15025501491063656, 0.28301732388701806, 0.6706497317067414, 1.009341590309127, -0.024895434615114082, 0.6336205573359934, 0.4419370068939668, 0.5198514168422711},
    {0.9896888475017693, 0.5866908179645574, 0.5225199730987234, 0.13315705868772593, -0.029885884784537953, 0.4980416927449979, 0.4769680797655123, 0.6404955610176687, 0.8250326076417841, 0.8817527769140945, -0.04476265072404663, 0.9076081950200692, -0.08276411150271559, 0.5474030025567308, -0.25650316829678765, -0.23025652029545324, 0.7068543717185007, 0.5386703512518035, 0.5766290317644561, 0.6573046780863694, 0.32266860992553326, 0.7296262267529319, 0.9904718768032417, 0.7728426885167651, -0.12385836168684468, 0.5699815539122256, 0.5960704126891289, 0.9274462886247078, -0.25149423653007036, 0.7833715256046364, 0.4773156135632246, 0.6761776321443284},
    {0.89227648020015, 0.2857368057159649, 0.510389128428744, -0.09586514707492165, -0.054456589715931564, 0.722949266197516, 0.6880145050292411, 0.5513594246078497, 0.8567862982322774, 0.7674616721131843, -0.078848509703568, 1.088021552931058, 0.44098172697258564, 0.7670828616911015, 0.10791451342483767, -0.20621919327570568, 0.9005910337764997, 0.5598593549440841, 0.7187737115173664, 0.9230765696904076, 0.3056987247537507, 0.9694298330089328, 0.6499903588315173, 0.33045529895462855, -0.16800193403153477, 0.2951500653168464, 0.8506460195866216, 0.6800418709744728, 0.4064100924120156, 0.6948767965216195, 0.6694389283048386, 0.5459876610041482},
    {0.8413293003564315, 0.6825095140903717, 0.6457930420887558, -0.0973120975878522, 0.17295416913727768, 0.6291723051247167, 0.4835224793731854, 0.33358337246237807, 0.5311014742348095, 0.7611537620382531, -0.07996705323185957, 0.5844582907332203, 0.14549869268094712, 0.8402497577262286, 0.04827311264986574, -0.06811324160261702, 0.585750597650691, 0.5257816461833212, 0.596860751305347, 0.7341299613199342, 0.4730477326354002, 0.7988584817731251, 0.7071980276595181, 0.4453488645130641, -0.18226889374229413, 0.18886790283207378, 0.940026328916702, 0.6152118169656325, -0.10993792444193488, 0.998182274151801, 0.5963707924075178, 0.6321684930869349},
    {0.7007242164084068, 0.4088061969978651, 0.6499065069480708, -0.12669415102675044, -0.16642485762006495, 0.6921673367391781, 0.5461712298469772, 0.4837624606631165, 0.4614686474416334, 1.0588746206621202, -0.15732910234490255, 0.8326727439318209, 0.14046930261153762, 0.24496442370434945, -0.05196195404508305, 0.061445952117159086, 0.7735819729327859, 0.5434662705516732, 0.890222745806774, 0.5307471432681293, 0.4960149199615936, 0.72615254960002, 0.569031575889836, 0.5699610411837043, 0.039029814282235904, 0.5755287954635718, 0.6928142882672493, 0.5573647263358803, 0.08424153737548623, 0.6326263644216312, 0.3774468817896162, 0.7842821540879202},
    {0.683920808712392, 0.760660288198216, 0.6884756083950861, 0.1563439202146138, -0.15607410164171795, 0.744995193045273, 0.43212150188009646, 0.4669262995005452, 0.9853078849068273, 1.0126366320312998, 0.040383213031760005, 0.8408542395614249, -0.2876531935520926, 0.6619878481217503, -0.3307192969194154, -0.28665449129182624, 0.49170076745579294, 0.5683430812219304, 0.36993579675617416, 0.5870604175090806, 0.23527413172015502, 0.5477746059647489, 0.8705887340146012, 0.9841605528921387, 0.13325065693629126, 0.6905156490791335, 0.9560460597671724, 0.6124148927012901, -0.03614976616732118, 0.5649322965371973, 0.4884199578616978, 0.478050784862688},
    {0.8285569848128151, 0.3186895919088461, 0.6274440511004896, -0.14065886347909265, 0.06707191189483393, 0.679891891278381, 1.0182585468294387, 0.6488319721134953, 0.5250085741665219, 1.0075250783716008, -0.367805909451224, 0.9331747477219015, 0.048286794669547904, 0.8896888002587908, 0.2237088656392899, -0.07359621916999914, 0.947516815706956, 0.7187434260199109, 0.7151027133350445, 0.645266913532697, 0.19106558611789398, 1.1253705782871208, 0.9144448786803985, 0.7098463552957428, -0.13830568813521882, 0.5668069562384579, 0.7975964831203096, 0.7185720457569004, -0.15396808344938007, 0.5072462896409236, 1.0014536961390523, 0.6338048435735849},
    {0.5311051946726514, 0.3084667894014522, 0.8633067433463938, -0.016633070873050576, 0.16550782841130518, 0.802564816212347, 0.5183781326576834, 0.5431001939156487, 0.622653377698537, 0.5561470325955338, -0.07477260455974095, 0.6096632570241581, 0.11304006232643644, 0.5002386042586027, 0.1465657043258693, 0.33156615590772, 0.32883626654718917, 0.6355842780942648, 0.7228300909146481, 0.6027341880063376, 0.4846437247855215, 0.6706206389156953, 0.5652214255078901, 0.8110526483846074, -0.03641682680181251, 0.4304782810924011, 0.7935872426519521, 0.5414962479467321, 0.12896416471388203, 1.125173696750159, 0.8511449673087372, 0.23043965928100704},
    {0.5819992905621248, 0.5207422957725136, 0.5602808050747169, -0.22180613394509868, -0.2762621433155044, 0.6870433518713533, 0.7550572208465055, 0.6778675117876146, 0.9632560235077999, 0.6582417937037044, 0.08657514399427411, 1.005537170382948, -0.04016081214141391, 0.8991888099084192, -0.06429948173805818, 0.15156038957530876, 0.7248720161020035, 0.925234919748006, 0.7392183991717519, 0.7250338250226229, 0.49377284594292487, 0.7103228885289266, 0.3829132210193184, 0.6202203748151368, -0.22942742937971175, 0.12358565678428822, 0.7989461646163811, 0.8732764549035651, 0.33992440567394855, 0.8539547459762331, 0.8842243670876447, 0.4621253345230113},
    {0.8905635240764485, 0.24189138592530884, 0.5977191996948155, 0.25630030818994287, -0.040199174337690956, 0.883871943686177, 0.9476471166418085, 0.32585063560271044, 0.39201834229411286, 0.9685283160478012, -0.31301841272409003, 0.75727988213399, -0.1063980578037324, 0.8216998530082295, -0.34752660942772445, -0.17545977314738068, 0.7062428697173608, 0.8356210753228545, 0.7679655561444394, 1.098622477421543, 0.18442557251977895, 0.7421436099763102, 0.591634459062173, 0.5910788370686826, -0.07854306839533641, 0.32222704963637483, 0.4761258151253898, 0.47575324235450717, 0.4068754995129944, 0.6526188295907903, 0.5529535757661486, 0.729315053609599},
    {0.5017059038892209, 0.3834044018848887, 0.4583138504764171, 0.04256075703226374, -0.17821988271298297, 0.7357236203879166, 0.6728338522384149, 0.35078234787050283, 0.3853243309032112, 0.9057628540159534, 0.03494699650755443, 0.7485508301019477, 0.06587938114265561, 0.8830197929728129, -0.14962281408177788, -0.05448607548311597, 0.7962673910263837, 0.8821872886278803, 0.9136777315422602, 0.5433537493985098, 0.4331129356847893, 0.6922675933784531, 0.4714587694044904, 0.5573540155228628, -0.12522159852280765, 0.7011368537338135, 0.6016394441150765, 0.6115803766644744, 0.37574408979378465, 0.5641346007664693, 0.6744207633772203, 0.44997747144574907},
    {0.5972382233277795, 0.8305788616206691, 0.6122365282832741, 0.3806167144306819, -0.04664999212619249, 0.6504430429041911, 0.6109132515834754, 0.6470778088638149, 0.6442964658836193, 0.5908552403855385, -0.09538934955929715, 0.5457302460422113, -0.16490412782615152, 0.9586977337012619, -0.1318624147352629, -0.36839427014206294, 0.868832060905543, 0.9715355191113981, 0.96955345686099, 0.7515405994462967, 0.4207614102850944, 0.7683487331634434, 0.23521856774749925, 0.9774573649536099, 0.25773457067427696, 0.3274178066410831, 0.7491370029125181, 0.7574915880021271, 0.2696329809278311, 0.6410672532277591, 0.4721968058432413, 0.13045032010165394},
    {0.6057301089244315, 0.6810645524257057, 0.7856557910681943, -0.15343744798470704, -0.09566970072194468, 0.5541469843936407, 0.5056244068349725, 0.22983815508960917, 0.8364542020219181, 0.6578838291401372, -0.19389793669206756, 0.8079343166633285, -0.19334418606454631, 0.7311882070010784, 0.08456398376253609, -0.1825139459094783, 0.8674814662065603, 0.9648287975750877, 0.5466097218238319, 0.5499970649150394, 0.4773749680227633, 0.6578027150186658, 0.6401664854035063, 0.9606548982151518, 0.052965527144106905, 0.411222358431484, 0.6438392831117135, 0.7651160335359258, 0.3499370203015257, 0.696683059164561, 0.3803800425047057, 0.3900292776284607},
    {0.776688118168294, 0.5201523790916684, 0.5543850250354057, -0.28019341811549464, 0.13902268798748876, 0.2594357637609926, 0.8239699274803225, 0.4302567988624285, 0.9633198168134831, 0.587835285285378, -0.10549465904464372, 0.7450423433505182, -0.015682396710885137, 0.802747054257676, 0.03289774926552312, -0.04632469303323162, 0.7704954347198232, 0.7004887491397592, 0.702846145126559, 0.5853800148730565, 0.412598775959212, 0.3806050805842951, 0.31593981776663127, 0.7295114935735572, 0.1518621184737781, 0.16954939573988725, 0.780282045847973, 0.7626704168470181, 0.23996698039165257, 0.9460551077839957, 0.38819048587434524, 0.5763357005340362},
    {0.7245056615972018, 0.9431288424637201, 0.5290186834573578, -0.40080548488944145, 0.01231960094283903, 0.4208088190602044, 0.5727949325267278, 0.5165411575445457, 0.8900524773181518, 0.7106483179163838, 0.009811999848604668, 0.6865406657554535, 0.025302927323796957, 1.0313796010298708, -0.4050506412228245, 0.20296060740376382, 0.9324552934989447, 0.9569940928933345, 0.7181063753210468, 0.5813687940297823, 0.44553601381925684, 0.48747856867458905, 0.6245352290827555, 0.6590566957982632, -0.1531039332041178, 0.2506356061827431, 0.7663921823901305, 0.7449472875149539, 0.12392956093402395, 0.7484077729215703, 0.7333959368756319, 0.5843320531841926},
    {0.7824938656337196, 0.5100317740946992, 0.8720654360552335, 0.2830770803041109, -0.0726412479255857, 0.989558962616174, 0.5557930100865985, 0.6280453258808716, 0.4662992277755793, 0.41235656422767636, -0.08331951744973787, 0.9480932614458115, -0.192916676354551, 0.647029511641422, 0.23595005567039937, -0.07000191449384173, 0.8627789113466156, 0.40557924094967546, 1.0964062669348882, 0.8761250305842485, 0.5975164556947634, 0.72344273900371, 0.9062611556267299, 0.6346103680869274, -0.08973075803281362, 0.6291509355723337, 0.5785617084494133, 0.9679840087585452, 0.012414635302336503, 1.0624765952088628, 0.6880947769394491, 0.2960315140756126},
    {0.9581239214524705, 0.724539383769057, 0.6559730983979368, 0.041870741223362186, -0.06628111565977138, 0.8826514619912467, 0.7135157214515977, 0.13450923957465444, 0.5987737356079267, 0.6386023569376706, 0.15264515342981474, 0.5470348058309471, 0.1326834601714901, 0.7388956706621214, -0.024573769424286657, -0.12307747869366786, 0.6883149411271774, 0.9041610259858621, 0.9938127187549942, 0.9544697257534057, 0.48562796815917036, 0.8753443262520374, 0.5268894493109934, 0.683246998763675, -0.21060431203893176, 0.440235012841876, 0.48072505129212817, 0.7537318183262873, 0.029722107938159485, 0.2979917095794018, 0.45385190325601554, 0.48808383636856806},
    {0.8621517649413319, 0.8009240370366657, 0.6758254884614023, 0.06123273216186981, -0.17548323309521854, 1.0984226800633552, 0.7957172505212794, 0.13645797468181536, 0.8194944803927423, 0.9211730548134, -0.11914811949490423, 0.7322877124010242, -0.3807271984828374, 0.6386436445852814, -0.03887181268337878, 0.022616491600166013, 0.9166800211591319, 0.7451556135765202, 0.4650187396026007, 0.6830736372090676, 0.37420662041588526, 0.6309739540580981, 0.8852200009864425, 0.7275652774667584, -0.2183337226716826, 0.5736800268562202, 0.6839079338874807, 0.8219092732322028, 0.0335632822364649, 0.971237590131818, 0.5604070529935826, 0.40929913737632123},
    {0.33550557808788584, 0.3153843747144844, 0.6374219533429446, 0.18127623397554105, -0.2313810169471756, 1.0103625050469562, 0.7725280720075703, 0.39387512838882854, 0.7166548346804047, 0.854114352159006, -0.0678732238888974, 0.7737304118770615, -0.28333881671350825, 0.7857438560102791, -0.31624720934802975, -0.2244121832799351, 0.5976291674803504, 0.8125919222951876, 0.8891860351629961, 0.7231440433605566, 0.6131091301449508, 0.6871548681676571, 0.5016302385613739, 0.8447423787680511, 0.1989488780441353, 0.5990807767727595, 1.0460241325905006, 0.7477094097767539, -0.11012600613417103, 0.6104311156686931, 0.6254380576177362, 0.39860904386616586},
    {0.755537554228916, 0.7724834166233482, 0.7968631188025431, -0.2257885587794298, 0.0256122581427987, 0.35548992174462335, 0.6705356275678055, 0.6777390720661904, 0.6847034114237673, 0.7523107142519565, 0.15020859111341783, 1.0660185660915378, -0.2612575426776651, 0.38119017125935756, -0.21868041575992705, -0.05822650354839268, 0.652195724774544, 0.6228459052876981, 0.9537214753064724, 0.5071037811229631, 0.22810877575707, 0.7112270372808263, 0.8287967821956155, 0.6634586694727886, 0.039339495049998015, 0.3570587506290985, 0.8785813758596817, 1.0448055164811794, 0.033384296681446865, 0.7969694969224331, 0.4097966267568847, 0.18702560398126944},
    {0.835001343506725, 0.768402477899176, 0.4094730186286754, 0.11962624693932158, -0.18812368981374122, 0.6512697988859586, 0.8588663674760327, 0.37551246506639335, 0.8525316817586286, 0.8519312067784298, -0.017039525219728017, 0.48591780370232807, -0.06198655681342285, 0.6820373043165654, -0.009423008335473248, -0.3928337335545024, 0.7286799271018237, 0.7122111014714531, 1.0733375591403633, 0.8053136921795826, 0.37315802539874715, 0.8937830921278398, 0.7983119893764086, 0.9121826689097685, -0.19712779729868796, 0.606335640776478, 0.699556111250321, 0.773506890877726, -0.18513389128847338, 0.8737604970108864, 0.4237036762349987, 0.4505651611858379},
    {0.5970012172635636, 0.6395766778142856, 0.6950022612401214, -0.10615178423718928, 0.0622045963814126, 0.545662078333218, 0.8404756744859402, 0.5933705992382724, 0.8289056498033869, 0.6284791809058649, -0.3186251384999052, 0.5073265396535369, 0.2351932020551412, 0.8101560722446502, -0.19105674679113469, -0.3051226875961203, 0.7764184339577443, 1.0204817573198348, 0.6782438604921961, 0.5087890962814672, 0.5073607532447878, 0.5298696115020447, 0.4490693989095956, 0.6708902224116999, 0.24981230933870965, 0.2984406966273137, 0.6223010248650969, 0.526841107741351, 0.060746937227839394, 0.7073094767046859, 0.5534619761987044, 0.6224026136061831},
    {0.5960178713835814, 0.6849341022178013, 0.7474220490039339, 0.0754397263123853, 0.14287129813811314, 0.7281441498852409, 0.7759147432039565, 0.3595004913793387, 0.9341735896061482, 0.520417206153813, -0.21258920398422304, 0.9237655340449474, 0.1809171616432072, 0.8724519447708614, -0.13262007828212224, -0.21510961990697147, 0.7439295723171567, 0.8828482736018286, 0.39840498018934317, 0.93046930915752, 0.9350986316361313, 0.8150184736153403, 1.0143578518649794, 0.6413645645433829, -0.3448971154539927, 0.2743808875464325, 0.3516879462670611, 1.0354083524126403, 0.13165539756518507, 0.7445045803685364, 0.2985898325916383, 0.31187649952974156},
    {0.6864655636286361, 0.7410602427886704, 0.768730365141221, -0.14965014598378842, 0.11907181783892398, 0.7134989577342589, 0.7227789692623621, 0.5800142222192617, 0.945388449047685, 0.7948556476148949, -0.3851368560427791, 0.6530186157616662, -0.1404249163704798, 0.43319814512394383, -0.20143221041797033, -0.04197977651394185, 0.48624612554282354, 0.7702533900048035, 0.8537249496629693, 1.0841935031034393, 0.6852415037766206, 0.6887199233322633, 0.5677292832298232, 0.7175585779803743, -0.15745921488219025, 0.29154614071499163, 0.8995718617223301, 0.7892837932277341, 0.12756319399679164, 1.2526994126607716, 0.587840444163255, 0.46150641237140155},
    {0.808327603857452, 0.6301575687232226, 0.5872047431793567, -0.011993593396161717, -0.007419648457735387, 0.5776352342644033, 0.6833780887877264, 0.5282231348272944, 0.4006232310904498, 0.7876951924264647, 0.07844736295577581, 0.7991443360549108, -0.17157881291238047, 0.8616375556471185, -0.12805730484963357, -0.21705010584359866, 0.6899438269002411, 0.49544854025165885, 0.7351495719054627, 0.7461812368228281, 0.5067162419067874, 1.094893686304232, 0.804858926093661, 0.7231492894241427, -0.16104670406704522, 0.33939095281039944, 0.8793646030144037, 1.026025065556354, 0.28036041374935744, 0.7312813647872315, 0.4580357158899169, 0.5005889868673429}
};

static const float b2[32] = {0.7114968783617778, 0.6315032106315457, 0.6027694508340465, -0.028986573951180695, -0.07884216036502426, 0.6953548908709508, 0.6800148462815603, 0.48812183270635146, 0.6549549727990457, 0.6876880948428303, -0.06888022800985244, 0.732150116826711, -0.054100396720111826, 0.6971480879963139, -0.06664294470630895, -0.05972341042987429, 0.7105350317494505, 0.7628156732458862, 0.7014215746111203, 0.7372310675439171, 0.4850979569855275, 0.6714863661488222, 0.7256200008023841, 0.6556509182257038, -0.054875901303779, 0.4144329092805325, 0.6955128891650741, 0.6997451071634953, 0.18365690158295384, 0.7297959592291555, 0.5384586164343546, 0.5824265662568774};

static const float w3[32][16] = {
    {-0.028641492300830417, 0.12584622983991978, 0.8083690561710789, 0.5012465990578178, 0.5965148937505397, 0.27893131701172774, 1.0101745436629184, -0.02546123377095395, 0.9132981837774564, 0.03150973216954207, 0.5379532813031292, 0.35538844356892485, 0.08792630899285613, -0.41386222409668416, 0.7696097679844007, 0.9690017008376834},
    {-0.22205385345733586, 0.12379975629271385, 0.739888330599673, 0.8309862757217589, 0.5093388845984061, 0.85616466808904, 0.8239266371622224, 0.08554650431837815, 0.7114196889065747, -0.06893097248615837, 0.7268849720303587, 0.8831876488869294, -0.21265243405223908, 0.0477114807939599, 0.6917466259581294, 0.6774148500500156},
    {0.2287604382705544, -0.12690249483802288, 0.8892048670607601, 0.3308659353881707, 0.41449435279012137, 0.5439087354444487, 0.755165667792092, 0.06798472530630197, 0.8767960783503546, -0.1899601741426744, 0.72744689493643, 0.8643651092425504, 0.2601733143014043, 0.03311004146609825, 0.7673192266212702, 0.45412216565764973},
    {0.13718808080103762, -0.4992190671739889, 0.0023266578244189886, -0.24310365601932712, 0.03892476064711403, -0.0478986641889408, -0.5263855513309612, 0.011308979025043806, 0.29055339397438273, 0.015975194779443983, 0.09704758511484746, 0.4528926666621323, 0.1730226907892327, 0.37622312455983364, 0.2713045847797197, 0.32242141087496073},
    {0.09905074866760076, -0.34856517128070336, 0.03643874279550579, 0.027116753680742265, -0.45024421337277787, 0.07980304637137375, -0.2365090398421238, 0.11762119080528993, 0.018661782422154608, 0.1993891953564118, -0.5539138464484238, 0.16147652317257036, 0.2051122377586479, 0.22719636587982667, 0.06945206400032776, -0.03908488106027472},
    {-0.394745050295567, -0.012775198868066396, 1.0435079633033657, 0.2754482253899938, 0.5880241658927372, 1.048266922444326, 0.9112984811747123, 0.11244547279377516, 0.7229373942837916, -0.3166661957214903, 0.19676263157968238, 0.5924061317831828, -0.4002706459959455, 0.4426888494047778, 0.6761926082190458, 1.0570876841559866},
    {-0.272611801156478, 0.144224772001493, 0.9124767940770103, 0.20590921977262097, 1.0155913918809218, 0.47178051962581646, 0.6236048567227044, -0.026657977962827855, 1.1859540882659418, -0.16028531475245003, 0.611448653189093, 1.0254176581571484, -0.3861764815921929, 0.04823030496695796, 0.9294549222913695, 1.1233350418453996},
    {-0.2195968994738816, -0.37328071130186175, 0.4652440949334576, 0.5491595309509534, 0.6945997581068721, 0.9447877956329678, 0.7339161470366392, -0.3284908728814092, 0.4295490885352947, -0.48620074337725244, 0.578627526696395, 0.09243724286783009, -0.1811595270144469, 0.09755211408739242, 0.3741196419648408, 0.6123470228330701},
    {0.4103755882311374, -0.23791516650950867, 1.1009808541149024, 0.37824223520490236, 0.5550796960602067, 0.5377182925647129, 1.1766923198287083, -0.07987980134599759, 0.9818056641648705, -0.21832358278738787, 0.05811714280761019, 0.824495675419701, 0.1577344268147509, 0.34462574119377837, 1.26306830193642, 1.2329431917458311},
    {-0.628184935348982, -0.058956350345492944, 0.865060570170239, 1.0944057433772225, 0.6205901490862084, 0.9309047430880834, 0.9293514262999576, 0.03805062055191715, 0.10513919553124271, -0.30374132825959016, 0.2501714367691535, 0.5058530078291887, -0.20065290964627733, -0.002701724203393942, 0.5734800780105139, 1.0378237245323796},
    {0.010682541320093377, -0.17110362839196186, -0.08535779366948461, -0.06783141120051181, -0.19715015074689018, -0.04027026656021115, -0.48838251864105037, 0.1849659621108073, -0.18546517382768032, -0.10299981216731001, 0.510089557316393, -0.23644374874808102, 0.0879777741962402, -0.13946420160876866, 0.24161016642042568, 0.022464086075639895},
    {0.14306019185481123, 0.04539831351440385, 0.6859380132032227, 0.40339264748381687, 0.8038780526496678, 0.8943167439797248, 1.0599957073790445, -0.12327369503533717, 0.7350913334453414, -0.05019645326722128, 0.4218476625512341, 0.6115917432285366, -0.2004831878788256, -0.1063494322245762, 0.8334880347608683, 0.6394779068936566},
    {-0.05379232093203655, -0.08760352422718737, -0.09357625347622543, 0.27741537489881946, -0.020858909769101142, -0.21928636884876077, -0.06703980256770946, -0.04871203644222083, 0.2321922778923549, -0.011201725685103234, 0.2958933735579325, -0.4508225959189623, 0.14038953872534085, 0.2132585308167062, -0.09021563747716352, 0.09632918991321887},
    {-0.1297068601756487, -0.3871729407038944, 0.7796844887475696, 0.30166343158136566, 0.9742776266724436, 0.8398504697681685, 0.493776679055119, -0.33054624152094625, 0.3829031098859275, -0.1293778799085771, 0.6563261188664329, 0.4275968724696837, -0.048200476535206836, -0.17476044087036424, 1.2793524165323877, 0.4132543402568903},
    {-0.3632480771575178, -0.08856373127132026, 0.05551044632789708, 0.14462615664708775, -0.487261744234012, 0.033421324161762356, -0.270526140982011, 0.11385211359868808, 0.19312141881441272, 0.18026924685633056, 0.09938234599118188, -0.00866544730672554, -0.056549751055355986, -0.16904283915366958, -0.21411309929797703, 0.09929147480211702},
    {-0.006883480693852647, 0.2553542663343911, -0.1963249319544235, -0.15376334285689286, 0.2710102274896364, -0.21401101929156752, -0.37369159525602674, 0.5497244653481005, 0.035946616761137536, -0.030848285925477684, -0.04672980619445164, 0.09503392925979805, -0.32199459053054647, -0.5394369594644964, 0.19486312946106368, -0.2797718955399852},
    {0.00921947535176585, -0.2108658152893591, 1.1194409087643191, 0.6255540711587676, 0.435158982978841, 1.0466289840140526, 1.2527242773797758, -0.08321136690995821, 0.41963901549546756, -0.1182038466701842, 0.6682201120131064, 0.44829739602788315, 0.18250345916310962, -0.0565498122227859, 0.9540152060195519, 0.15974515214378024},
    {-0.0020311326412182262, -0.1784147693641223, 0.7779362097972838, 0.6867657893872093, 0.8870364187876493, 0.5643805785438775, 0.9053218769528222, -0.09626515883305849, 0.6392981336361728, 0.013717007903002247, 0.6311812838841777, 0.1855911838852775, -0.27421658530886844, -0.10820273439859328, 0.6215782755431718, 0.7756260608880183},
    {-0.2125668862926985, -0.16771116159430102, 1.0857581881726164, 0.5381335247317639, 0.4700450901769417, 0.5384119115593464, 1.2782759220319733, -0.007588676644984301, 0.8582358542325265, 0.3471222314630355, 0.3321833624351619, 0.7319603113457128, -0.6551191733891955, -0.07273958061703352, 0.5064973264364379, 0.8716623932870005},
    {-0.5695256587520838, -0.38674916773746, 1.0237742925789928, 0.7501090444495253, 0.5789265074531291, 0.9001647170808479, 1.166618741388533, -0.09005744796182688, 0.5632576010210767, 0.0016372077562162527, 0.801155888062489, 0.18813955640996996, -0.18571410855723558, -0.1445985060180046, 0.555704269687347, 0.8936967710976853},
    {0.0800640400111864, -0.30501495728841793, 0.4557844246466522, 0.5779973646000125, 0.697961399490428, 0.43675942935989975, 0.5288920529607604, -0.17541717722934153, 0.7603066257032935, -0.020490367815567966, 0.4906464925225769, -0.2567352756356742, -0.2564842895729089, -0.022319274362984767, 0.59762781502051, 0.4895037966337054},
    {0.1827611146693536, -0.31322654838115954, 0.792773414725629, 0.4913506552271025, 0.8847200514211441, 1.0271440130946858, 0.9247745175059704, -0.07467492757368495, 1.2466942923406408, -0.14278842284866533, 0.3646343497843277, -0.178773818321957, -0.2694697669932325, 0.3004685825163951, 1.0571164815009186, 1.3827642226063594},
    {-0.1257195353510023, 0.10511014029576171, 0.9473669345700573, 0.7159388367314379, 0.6659571441463251, 0.784726482471696, 0.8948995646402209, 0.05101668854432269, 0.7032721544330933, -0.32903665572195095, 0.868856287823991, 0.8436918546845231, 0.059848231594283624, -0.1446443811295699, 0.6981867030988159, 0.5927836394859267},
    {0.058228978049240154, -0.24494848033944328, 0.35969731013507417, 0.5722637577078937, 0.7927183649085225, 0.8076848717840057, 1.1219986068955012, 0.052095130531478295, 0.8795947621347606, -0.09796514538069939, 0.1583252621033175, 0.26059473129907124, 0.34997093180328864, 0.32392760807092236, 0.7905814854943962, 0.7392635575937103},
    {0.20186334393655533, -0.19185949768615945, -0.19455614621272802, -0.7284146688241756, 0.11133408272042883, 0.04408439276404425, -0.27745472505556495, 0.2283040427850719, -0.15411622409875989, -0.031198556380466154, 0.3684707557806702, -0.014964746006889495, 0.26497276559923544, -0.08511389292064694, 0.23178444254175296, 0.12283516302580756},
    {0.09646726160111059, 0.3543608476615205, 0.34736559631390274, 0.8296199176476282, 0.7045230620389491, 0.6538776986159163, 0.3814171023389158, 0.04821669755567399, 0.8981365303879758, -0.06610179096533385, 0.15436648340799353, 0.6812623156847168, -0.04519740780582602, 0.19260438560202683, 0.5268829172354542, 0.644588770340678},
    {-0.06912839372496367, -0.2936613826440322, 1.019933554678898, 0.5952174905600734, 0.6162143317518676, 0.5500839505990875, 0.9837299143601717, 0.19964134647019868, 0.9133835990880469, 0.04385106532059403, 1.0199378804771841, 0.8763743425968815, -0.03955901913332587, -0.13867244605710094, 0.6390586007326305, 1.0303277166207443},
    {-0.0012092892569465505, 0.5059584858803593, 1.0753878359454152, 0.2796204568591788, 1.3333687966104188, 0.5360460919148057, 0.79739373922556, -0.02494053654248608, 1.2224908641844252, 0.1928065621069832, 0.44545898662562594, 0.22815574473331496, 0.0799716481541034, -0.19175954162834336, 0.8243993277053523, 0.6321667057513175},
    {-0.0963232273974341, 0.1838759235318838, 0.11334750751899923, 0.6562365792738599, 0.6109327298217389, 0.04403551181031706, 0.20694948370504948, 0.40104093055654727, 0.5104018595714789, -0.26060417686706167, 0.24012262212873028, 0.05069115354420252, -0.00967800348598657, 0.07383072095159193, 0.4531094172010359, 0.5880849800350696},
    {0.14065808981418795, 0.026541559630193532, 0.6516627560296938, 0.6621443424177238, 0.7106335368982332, 0.4589703033893853, 1.1727226649849987, 0.08566989495627676, 0.8372572899111342, 0.1826744109999458, 0.502088994035117, 0.4206647704524347, -0.1715686193711813, -0.3950645763503061, 0.661559664418135, 1.232635654690092},
    {0.11152940054608562, -0.25441621395541114, 0.8880696681949293, 0.7671775672253753, 0.4497675018741271, 0.779937706071653, 0.5478996771572253, 0.08780663159739494, 0.7907481939152726, 0.001232509789380509, 0.8175241250955038, 0.7539713116746988, 0.46347923946334313, 0.40030638332564616, 0.6414143679873607, 0.5541101648368968},
    {0.3427019451665532, -0.2093962566521584, 0.8303412936083179, 0.7053768613561402, 1.5188360763627013, 0.7369262785858154, 0.3888996337047649, -0.2014353769087605, 0.5903873850519102, -0.04900790365670554, 0.7352261804535766, 0.7346582811022401, -0.40054501985895635, -0.2277119959525192, 0.6112378669621797, 0.6413582488578713}
};

static const float b3[16] = {-0.07092400493371723, 0.009065387385290936, 0.5114451431462843, 0.4200199699381089, 0.6068644200290061, 0.6167519370432684, 0.48426311236192254, -0.04039483614345542, 0.5019985443796039, -0.06395311874751083, 0.32009946925134847, 0.39740021259254743, 0.013009784300086428, -0.05066112094511455, 0.4994126914410071, 0.5770034955810666};

static const float w4[16][12] = {
    {0.49847062436943845, -0.4675683004130507, -0.4352727011375751, -0.2138668025802481, -0.27240005491234437, 0.2479451147505722, 0.47692065170835896, -0.5302689556647595, -0.05080843931196699, 0.3383754318798299, -0.4610990920851129, -0.18725924669561902},
    {0.11676283486021143, 0.06447714772552504, -0.007250694381577051, 0.2531529499773694, -0.24554056995929785, -0.6937233039815668, -0.6744006722299222, 0.5550978703863472, -0.10738938888419378, 0.04640146910984824, -0.04290010724896801, -0.1711892252308811},
    {-0.3654106046294831, -1.062811618432968, -0.8879157582962859, -0.45440943151542273, -0.5956641937662808, -1.049268510823701, -0.6319568603579702, -1.4445109583174496, -1.4025204742185207, -0.6408944076868855, -0.36760963856586715, -0.5552717281741955},
    {0.10359725635392723, -0.6533459397704822, -0.4892026398494938, -0.42127508375257355, -0.8596535480731733, -1.110273353593229, -0.5560611937731648, -1.171442150417409, -0.40715983342293244, -0.38045774928977183, -1.0939025142048497, 0.06723116497007978},
    {-0.9111809092243554, -0.6540826972471663, -0.6606648014742589, -0.5422137738329619, -1.1845502574794895, -0.5163438041298855, -0.2516314155326169, -0.3929686341680266, -1.0188866578324989, -0.29419294913272215, -0.724065254042318, -0.5803594773567123},
    {-0.901368682759106, -0.27180384541472546, -1.3437564982032693, -1.1233993817806165, -0.6021421978377615, -0.4623241758900169, -0.93783163294476, -0.4909863300966112, -0.4670870391250485, -1.081573416072574, -0.9584937451078187, -0.4685149956711163},
    {-0.4942177991655913, -0.6015709396931351, -1.036787022182913, -1.0017793811136904, -0.8434402913451772, -0.7225947412874919, -0.7779766277587525, -0.4696730500171155, -0.8815619402460243, -0.9384390989632402, -0.47763372550971567, -0.9172536723959187},
    {0.05761848816977724, -0.5440293105227805, -0.014466069135106797, 0.13047164375066636, -0.05857243753715414, 0.2282628733189878, -0.19759842007045844, -0.03273703602442063, -0.07097970701351757, -0.18195172987630628, 0.05609152784983367, 0.2923403388504181},
    {-0.5456681925192918, 0.14204363972903156, -0.22993558465506952, -0.6450208435356389, -1.263973690390808, -0.6672988559289167, -0.5431616921695633, -0.7790585790341191, -0.6694735822784474, -0.352009430257224, -0.6922531384764645, -0.3362414730761205},
    {0.1683402671383495, 0.3134972512677423, -0.07747202279541807, 0.12707538499623913, -0.18592696125183444, -0.02389185421283902, 0.007221440815182971, -0.08623505887411828, -0.44587307312068203, 0.08895830015879658, 0.7363129220788166, 0.1583221968660929},
    {-0.7440516677026568, -0.955446142584442, -0.21550607960635748, -0.7718521765461469, 0.04809825132551749, -0.3428345725718181, -0.6694425932160821, -0.2835379732169224, -0.5122335509307625, -0.43114955215648115, 0.1496450558374166, -0.7385434960017555},
    {-0.4142647618129203, -0.9943444353450983, -0.12099293087616356, -0.7044928850846174, -0.2186829115626548, -0.37117740918656744, -0.45412517675507535, -0.6226826312111164, -0.7456242776370113, -0.5539191699036596, -0.2522882990801728, -0.4797707153184777},
    {-0.9014056715680455, 0.3223550721551302, 0.456931402667568, 0.21049460122617422, -0.06172230183473484, 0.2753067532688758, -0.2876959648565297, -0.3126383774555937, -0.04032780245399153, 0.005231501959168051, -0.18268777070963932, 0.07591610876019254},
    {0.25271059737082957, -0.4005722070596416, 0.307519640010211, -0.2696654453315364, 0.39665865950873125, 0.07877763414348078, -0.33474899983327144, 0.2504017304808907, -0.30077500592671624, 0.4721552317150055, -0.0893495763653632, -0.6092634215197432},
    {-1.2579827394704604, -0.7571469685057778, -0.8971700676557911, -0.9368525734707631, -0.03392414693089292, -0.6225786384567866, -1.0388358539127602, -0.3989725927128302, 0.007628510348392362, -1.1613274454350349, -0.8800813059018991, -0.7685968199653301},
    {-0.9832252011549264, -0.8307741208100429, -0.441377919568972, -0.04616533435705983, -0.5512174368458538, -0.6237443269060671, -0.7356569462626705, -0.5807780059512919, -0.3997542316371465, -0.6565197801492696, -0.9579128302449628, -1.545170269163115}
};

static const float b4[12] = {-0.20550446414629994, -0.2428634972411319, -0.2771596198986201, -0.2298852488474587, -0.23157887240405234, -0.32727606855932845, -0.252544221193393, -0.21788738034704141, -0.2686241770927984, -0.31783543868228237, -0.22893739136210647, -0.3486704372558448};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
