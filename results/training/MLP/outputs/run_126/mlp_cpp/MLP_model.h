#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-3.6773662052730187, -3.562255497070086, 1.2937223188067741, -0.8319273635097849, -1.565195993711946, 0.3495952056363822, 0.23552196883586268, -4.401764125306565, -0.7661498955395263, -3.7550014988609286, -2.72568297556787, -3.4253874843087355, -1.2488303137187868, 0.07859900446584397, -1.8857298731475929, -0.27895879573846694},
    {0.5661625568927529, 2.283184208000876, -3.2864088726711507, 2.2664417737364335, 1.4304371317033944, -1.2913940098348644, -1.5787676125667964, 1.5964828061410445, 0.3979047362053001, 2.058911882027817, 1.5636738996105524, 0.6428400304067949, 2.078540941243031, 0.1344806262905694, -0.5329050764913256, -0.4945584099793422},
    {2.901227089651101, 1.1243190193969745, -0.3297836618791926, -0.6887039645142989, 0.9757206423329778, -1.336343094547297, -1.1537688430268294, 1.8828335297920265, -2.5123776443790193, -1.1954164594071472, 1.2631613685612628, -1.4264894697759891, 2.641266597332821, 0.05934029564796985, 0.31381613290515, 0.6417424506789479},
    {1.2973481807960796, -2.0287111439840544, 1.3159720874357488, 0.8834516293337937, 1.9782978778032532, -2.4619287753510024, 0.2701459838776643, 1.6530135757739, -1.7498350895226522, -0.7055014861531452, 1.5235485811248368, 0.42535891775299195, 0.09183653100043385, 1.1828936035218163, 1.788751365963125, -1.0501756652170107},
    {1.1647848437222441, 1.7050435285884926, 1.0428546706181154, -1.1582533987296815, 2.579385952727097, -1.603030807508514, 2.070518356156833, 1.0926796884506118, 0.3476206632623974, 1.066568375767301, 2.731472272561277, 1.1443415191060733, 0.01941150288094093, -0.18137399110884783, 1.4772099508015921, -1.741175831465319},
    {3.4156871248319143, 3.6867068040764193, 3.4136843324678376, -0.075394953412263, 4.401550966244627, 2.209798551275284, 4.825459703903903, 4.840215741851943, 1.9692429082423217, 1.34271668495157, 4.707606949902118, 3.0933611867320967, 3.866210959248751, 2.9819976610160723, 3.1952443272128255, 2.537341428333252},
    {1.6941706576479751, 1.5855347967800764, 3.6723624799388546, 0.34509920411184103, 4.570431905445201, -0.18884164196609812, 2.7337587001000645, 4.440932193539927, 2.1870365953498676, 2.1937860792995028, 2.699377778287043, 3.840786240090549, 2.454673224669064, 2.175211325957065, 0.9526846987611501, 3.4843904710399376},
    {0.39631741218885297, 2.552866498156215, 1.1816248427685223, 0.2734199013750496, 1.1552567751669363, -0.1908958936828485, -2.4191585739907513, -0.1465199308684196, -1.2220448200953715, -0.5642954897922249, 0.6336606826553822, 0.295841476787273, 0.9335486124324254, 1.9396478812294093, -1.3474717886204368, 1.183294960839943},
    {1.4622679938608505, 1.8106400480395073, 1.4021520708268846, 1.0867965909604262, 3.5251841656464262, -1.5601791344150076, -1.9885065231105967, 2.3308392615474354, -0.25484370032911674, 1.9188421325060228, 2.3280904438616696, 1.3204785205036553, 0.7799456854249944, 2.2207097528046997, 0.560689033156696, 0.6561255405328378},
    {1.3648916952260668, 1.2286345941271355, -0.34940782560841954, 1.1663414110233263, 1.8969651817886142, 1.0099200955198475, -0.8782781759346499, 1.406772518402965, 3.2212442114724427, 2.774076430903392, 0.8921972580449501, 2.2853534521673726, 0.9349957370812149, 0.2579200304859353, 1.5943638017931903, 1.27786375694927},
    {1.894617796884687, 0.5323470572913422, 2.640795791240145, 1.0147997881027098, 2.2319606127310365, -0.19932933665518152, 0.663411199961668, 2.5983918488803006, 3.4525487819236953, 2.384517066935425, 1.5138543917490743, 1.6689784282155946, 1.680237229463814, 0.9847169960017299, 2.4419784815819026, 2.6314730318283654},
    {1.6993666644849768, -0.9763794493404355, -1.0584516486221098, 2.943923592604297, 0.29556852038482534, 0.009388237135264318, -0.9848157894790182, 1.930600929163491, -1.9950943256676672, 0.9119012218190543, 0.03787688790427514, 1.3073376274028534, 1.9232462108220896, 0.7372343841971326, 1.5425559697123599, 1.1962273569336221},
    {1.51243103272124, 1.9755248558306482, 1.8165850824511607, 0.5503835088676984, -0.6034875564677992, 1.4471548789387452, 0.45731075085139566, 1.9763311470090823, 0.27254638333397796, -0.34104879603573657, 1.416912109461816, 0.7781568265688626, 0.5839877715477177, -0.7300708803369654, 0.7558396895506636, 1.4225182359646722},
    {1.5096611228137682, 0.9118277681020804, -0.47474230519819266, 1.21516782030057, 3.228930284949013, 0.023779397090776817, 1.8726231465293224, 3.0735590818010676, 2.404469051649309, 3.41205715085695, 2.469936659535555, 2.4977071569804616, 0.4662523026974551, 3.068652323912765, 2.589224572532264, 1.9839894126453128},
    {1.270174968648595, -1.9565039784527887, 3.5771520927035345, -0.13074662602299786, 3.38566996320237, 2.2174445018005393, 2.507897230265633, 1.3479019547956765, -0.08352597523572046, 0.021441430692160188, 1.3586753695745497, 2.130347452890199, -0.8507423542416344, 1.8209294709325787, 0.3984335569872117, 4.203812722083002},
    {2.399332835133453, 0.8983174402712747, 0.9491474993360517, 0.8755516584402583, -0.004284957720966029, 2.3925354276554307, 0.8698745956742164, 1.968472369386983, 0.26606375584051106, 1.9770197042317201, 1.0889405348100643, 1.5213076737856754, -1.1066407889091334, 1.3015419533967554, 0.6135770059089902, 3.8166137271454024},
    {2.680999582625488, 0.8852115840820807, 2.570476399510042, 3.5818671732441483, 3.1080208361999957, 2.2331215348157984, 4.250438443082954, 2.122674940417325, 2.5752402392441844, 1.6354867080214421, 3.591090462930819, 2.4900209294875393, 3.0458354502723166, 3.3697090326762797, 2.8958776971458957, 3.9225391809250723},
    {2.3335633325343523, -0.6956102127555605, 1.9145311637522642, 2.5051021712223647, 2.0591531940520613, 0.7372202556062714, 2.495530040978136, 2.6930139574141103, 1.63660570648562, 1.5338684071260222, 0.906760746485882, 2.5918465154749826, 1.7217537342202478, 2.7117376210805304, 0.8777373518173516, 3.0482345792768646},
    {2.6532171650647123, -0.03956606989333298, 1.090959550886506, 2.599246341637935, -1.042384131837967, -1.304926692050743, -0.48207376171927263, 0.6786331834412271, -1.8312714320733912, -1.5254975064294687, -0.25838952440810814, 0.9792122866278457, -1.0512059717167668, -0.02775666821153319, -0.8888457753660873, 0.3376875492338247},
    {-1.144724308511871, 0.2777242309715942, -0.08866694283859461, 0.6320742614499071, -0.156083493064239, -0.5629551280296079, 1.5653822337149519, -1.8290928290056527, 0.15702148953575534, -1.7442501720989125, -1.1593418624250529, -0.008455501453907109, 0.8735490205218637, 0.19489713896067012, 0.514550377426746, 0.31717957547288617},
    {-1.1625927747483935, -2.8279493988119095, 0.09866058892278469, 0.47219016979322154, -0.8506979371016, -0.4280215570758265, 0.5601901925198779, -0.39007851275000116, -0.30505658652132767, -1.1309340994741868, -0.4126650050392551, -2.9066942914669855, -2.6503517174429327, 0.8550517453668482, -0.7755217038200055, 0.6215559783241452},
    {-0.7352871648945141, -1.5658087462422035, -1.1603211630638446, -0.8813404483325701, 0.494537991583415, -1.7225695617596866, 0.8163600177684398, -1.494384209912149, 1.5457688158431415, 1.4965331027208248, -1.870909826167751, -0.9767886782499665, -2.7565859479826886, -0.12864817894683894, -0.47162545028142105, 0.7239142515351271},
    {-0.694466722229673, -0.2003357820853101, -1.1454016848311723, 0.6338205134505083, -1.2868468853985289, 0.6185794296653198, 0.783912168447256, 0.1817898920254618, 0.025098544050069276, -0.9601427566269756, -0.8168975809273467, -1.178192944107213, -1.5841829667060783, 2.1772726214191804, -1.6894863502099935, 1.7760548140126},
    {-2.250664687193374, -0.14804778869311067, -3.281493462315449, 0.22040818478154658, -3.0027438057214986, -1.8371603868379565, 0.8364268333441617, -2.6732275554638587, -1.0707700607034414, -1.0207794282940172, -1.9026310271007196, -1.7319247314011008, -1.8844085715888363, -0.8503183260296853, -0.7293388679495973, -1.2970475741975396},
    {-0.1118847593225112, -0.11084078719019184, -1.1740596451837566, -0.13044590224696012, 1.5126695257852114, -2.4735241631209934, 2.1808185963239617, -0.3659091657317226, 2.0872061973192393, 1.7375507500770409, -1.0520310172105491, 0.5027862048402065, 1.2830896262520766, 2.431444257455063, -0.1775296741304396, 0.13665654709480599},
    {-2.118376089620151, -2.9111089839235973, -0.7772610142437287, -0.7999870552684535, -0.5464403912797083, -2.8355084970345485, -1.151041083218367, -1.879179041826494, -0.0599910101078857, -0.3846703654156935, -1.5850288203560132, -2.4295314555370253, 0.7083500489186111, 1.7011695799740134, -0.6735506335907524, 0.4855028803710742},
    {-2.97092848887075, -3.0308490659476393, -1.7465047141384804, 0.5155041162581553, -0.8968825957723318, -1.9708996440810613, 0.6207663639944738, -1.7241704856175746, -0.1258353384147006, 1.4601089640815734, -2.898429249372851, -0.21422181847201432, -1.5844217741897835, 0.349506549027424, -0.4364896920680654, -1.1224591810156632},
    {1.5093389299344626, -0.23359868806374848, 0.5331495847842608, 0.021516321082827986, -0.407254342889672, -1.6849321407572022, -0.12464175451226839, 0.8552479657148276, -0.20825155181648147, 2.0165538745301013, -1.0103705909923488, 0.7803900835301023, -0.5541712732854497, -0.2269573085562133, -1.0371806041750806, -0.2344499980212681},
    {-0.039088263295898165, -1.4363019083682067, -0.26787451378216587, 0.021045275890390017, -0.2434975899290204, -2.90787367179515, 2.2722154360339157, 0.007046631674810824, 0.9256344282203401, 1.3011409677249997, -1.1515381726845824, -0.2517461635775545, 1.185078073708096, 1.5339934971243114, -0.43574192717115173, 1.2764542867032875},
    {0.8380285526780271, 0.20707613615649043, -0.16097239108903444, 1.0009173369101352, 2.2399846493237705, -0.6976883646889064, 2.3647162217879076, 1.9975607969201825, 0.1484269558575092, 2.501780807261465, 1.6540658291254124, 1.9581511440074757, 0.8440048614959894, 2.963728838143701, 0.833582113415963, 1.5369868078166318},
    {-0.6748059487626263, -4.134781015527629, 1.0078729652505283, 0.9556025096541737, -1.0904486601308558, -1.770635834303463, 2.1134442838295837, -1.507950267486544, 0.9520785380230231, -3.391661668379437, -1.567974901022853, -3.172709978187239, -0.07540936499089662, -1.3473314810259645, -1.2468906423574244, 1.8989268667193093},
    {1.4596437037014456, -1.9839563449202176, 1.4296239985795456, 0.6771602695608904, -0.05944790624972946, -1.681090048819597, 0.16065618925616945, -1.7327349194031127, 1.1742427309483516, 1.5141933748201821, -1.242572839080982, -3.3640323561534564, 0.39385470349691304, 0.6764996685820909, 0.41800990667258425, 2.8436794033036725},
    {-1.032961909543351, -0.04549363040422977, 0.9745096184657501, -0.9435389821208964, -0.11946362533398265, -1.063079986321338, 0.024525804688686603, -1.0465759762975844, -0.28473513545825363, -0.22723279976519667, -1.55827899774437, -1.285632297760167, 1.1583037305175765, 0.2906884116910424, -1.6749191745055352, 0.06978423126730786},
    {0.09426175102209082, -1.3585736346367374, 0.709626313851932, 0.22136591373877604, -1.766389072872646, -1.3843725391851935, 0.09364934549867339, -1.361727335248079, 1.0715204390647761, -0.27560053058206163, -1.1478397951216577, -1.2492458888329825, -0.5342693939855596, 1.5618046704238697, -1.534736975936311, 1.5393750785833396},
    {1.352381931797301, -0.5096459167121062, 0.8737761804173533, 1.4437739440248136, 0.62134744736563, -1.131570285661436, 0.2571348429236698, 1.428341804940798, 0.33823435495257026, -1.4278300949687337, 0.21697614623620998, 0.38311580368454307, 0.041836855058691634, -0.01805533971657791, 0.211000552080694, 0.47671483646054535},
    {-0.08980388932519774, -2.351994314589349, 1.4128333424228516, -0.8678233986840124, 1.5996178299926398, -0.7786120138391341, 0.43740607011182225, -1.186228137288847, 1.3887108623541027, -0.049125529287461306, -2.000560032095506, 0.24991113322539268, 1.953229987709085, 1.7301938240660084, -1.8759836914549837, 0.7597567234088352},
    {-0.21485713775079635, 0.8446949408632453, 1.3062909728153373, -1.3225155281932788, 2.235630534877791, 0.23849936287611678, 0.35231914170369666, 0.7488434913038537, 1.2596783035766201, 0.6230677669821796, -0.18170950989500448, 0.02152750125204461, 2.535787333392374, 0.5350713283927336, -0.5049067124250882, 0.9380263124402894},
    {1.5143239468376943, -1.6949523769456996, 2.02961291517461, -0.3575163341305869, -0.02856651239520792, -0.9961828098720408, 0.7788032160921088, 1.4965613864431093, 0.8014508842783997, 0.38721390365685965, -1.4768036443935462, -0.10720088855745628, 0.39666929118149874, 0.467238236826312, 1.4735212065418677, 1.198031434489199},
    {-0.8275775242036526, -1.5827881062293738, -0.6137595253024584, -0.4569684252353756, 1.0516287722672708, -2.130829499886371, 0.6166842402548873, -0.7860320982268362, 0.9223456804524999, -1.8748202783233097, -1.4637082071664327, -0.7173292045786113, -0.2883300076109329, -0.5470549533227793, -1.2798389920277475, -0.3714124835428906},
    {0.01621717532889867, -0.32712458763806085, 0.6885252234629796, -1.3130830060683294, -0.3288628999180373, -1.336875356377479, -1.2516863173854669, -0.40630638555461784, 0.6857902422984978, 0.1823916407831146, -0.08083522273239822, -1.4948690109530096, 0.27534368904653306, 0.8462176348504575, -1.8823649723745597, 0.9144495176481469},
    {0.13807935013233433, 0.5557721275819619, 1.0112608026922398, -0.03782250778186829, -1.3574252148857981, 0.08728522528026182, -0.9203571173278469, -0.9515188058965875, -1.1360461272398557, -1.4534261307678988, 0.418589839343023, -0.5810470232216949, 1.2337158101830188, 0.49745369250412996, 0.8798090730934434, 0.3492685549609857},
    {1.4107362878773533, -0.9294025029896935, -0.3285210800226595, 0.1740367341418285, 1.0929732544705082, 0.009549031838583152, 0.7882206697649393, -0.23661262577029218, 1.9576192228585199, 2.5804568603638494, -0.8527236713242609, 0.4518503556634474, -0.6198615983057842, 0.7542135497129423, 0.39960917400079005, -0.25009601847585966},
    {-0.7193614730110757, 0.4136607807999824, 0.37706481969472955, 0.7522657685756875, 1.5489567426158932, -0.7672934678182982, -0.23446201401668842, 1.1180327852720215, 0.11617331559152291, 1.0430158672705296, -0.6396264349159981, -0.5145138377122975, 1.3666024304318038, 2.5391407735180063, -0.9482949071030722, 1.5403000309383736},
    {0.0931008439874367, -1.0174227471167667, -0.6811853165173788, -0.11683013871818573, 0.12220886487697125, -0.7471347077069317, -1.2784822821237207, -0.08802914546346119, 0.418297605825937, 0.6451456240306875, 0.47057340258360153, -1.2634750998054702, -0.08521975397087994, -0.30816623144759536, 0.23528561724761274, -1.1457883483140137},
    {-0.8380322952309948, 0.9759610490203054, -0.8515328734312747, -2.3208504670999224, 0.11518980098350576, -0.6555650692160419, -1.3092219617107042, -1.8436583798057815, 0.22221896563357935, -0.39255409187434964, -1.3308818426830962, 0.18855487753485067, 0.3306969634318056, 0.4217034007794328, -1.1484702494927812, 0.30672127188954973},
    {-1.2398141469782156, 0.11067061582857789, -2.0860751596138867, -0.622035288427648, -1.044308425760871, -1.3968084184437732, 0.685734406968572, -0.22631263371198912, 1.3356557397075446, 1.8194444689405755, 0.0576147725151188, 0.8733285290091971, -0.9725049033858709, 2.6077519256842825, 0.07028104854691916, 0.3384343165758859},
    {-1.0002968290476397, 0.05434626555407395, -1.163064518533825, -0.9217991611772478, 1.228747628703139, -1.1585586384062851, 0.24666132204229685, 0.640663390848021, 0.9950934535524812, -0.2406036815143251, -0.06924403021706856, 0.2225760646340556, 0.15518451234700442, -0.12269585125116433, -0.14879191059013938, 0.07251129756859953},
    {-0.06613116164788951, 0.8595447354231904, 0.2620297654292381, 0.041417682207318736, -0.5271545970754216, 0.08973465111140011, -1.628484105178147, 0.22443866335068735, -0.5588477359402592, 0.24845775140690235, 0.6308108642973097, 0.48476627339889256, 1.1829180635822845, 0.9909084524556175, -0.5451160255393354, -0.9392928934004574},
    {0.4306375512804567, 0.24668835950731008, 0.10193256107575563, -0.423378021828905, -0.12616249791019965, -0.6769431016638041, -0.2409563494929265, -0.04403124477067442, -0.23038692563172966, -0.23729865614981663, -0.18583735079143038, -1.4773517905710443, 0.25477072831626, 0.09910310120159589, -0.7748787627066331, -0.0368560954982274},
    {2.2749412364866477, -0.13696062201372003, 1.714419763143473, 0.22552886175250628, -1.4105425390981186, 1.4528691610188, -1.5372004390760772, 1.3816341659150484, -1.809755607231546, -0.44025967339292155, 0.8637262531694385, 0.18832719197479514, 1.1834218072959923, 0.11542693198960209, -0.8235164568529052, -0.4898554277751616},
    {-0.14926074259722322, 1.6882244153349826, 0.833916718654519, -0.6256490314534806, 1.9227847104817675, -0.40446832698712026, 0.04703704195405732, 0.39401939056039487, 0.07922665874349859, -0.28570348973752985, 0.016944676635393303, 0.38333449132403247, 1.7777873607894017, 0.9840544064599953, -0.27124876722790364, -0.007638424933199992},
    {1.6664184965365154, 0.4125385436879748, 0.4398346813391556, -0.4351560116516811, 1.734268801422918, 1.6885448474155285, 0.0733865822807494, 1.4384217643339217, 0.5287930002733078, -0.07363399780336294, 0.22044172861183758, -0.7364094898027136, 1.9115704707503678, -0.5015951674827344, 1.9150676406257163, -1.011799374483916},
    {-0.8315678571457771, -0.9970232707563754, -0.2939976602987109, -0.5735098978141597, -0.07054561765109818, -1.3119361383004988, 0.6075552478066915, 1.6647634656149217, -0.8008797618415363, 2.2493528490846084, 2.0616462739166788, -0.78687374291858, 0.9048391858502193, 1.4557240394457114, 1.0561993913741183, 1.0381639772039593},
    {-0.1680466772464126, -0.5412267279272763, -1.7557538742489678, -0.5374639276689126, 1.802766763964652, -0.7161935597709775, 0.4598434017024979, 1.3144188102103551, 1.5557335375563122, 2.1480910049402326, 0.8522085913696149, 0.01666841630512608, -0.07086852099435317, 1.1851900283074914, 2.130893207137134, 0.6136043502128574},
    {1.3613272634313462, -0.05483657676629934, 0.8968414825706711, 0.4153252113682098, 0.26922224067624084, -1.179805509209767, -0.6235546655317585, 0.027754806943801683, -1.1774835852834726, 1.2133612611403044, 0.05330641200444626, 1.772902639064968, 1.1295132906426946, 2.338188444766931, 0.20344772958960922, 1.147838211007945},
    {1.8594098061225381, 0.6270609662826696, 1.56296343304817, -0.09323501313754484, 2.1631380821934707, 1.0131858351389658, 0.875612654581862, 2.541491063552687, 2.5260257135903634, 1.9966287768959208, 0.8653973793941456, -0.27579905633894264, 0.5871672457601631, 2.0295606384314286, 2.4713192131133357, 2.0254712922445277},
    {0.5243436644830487, 1.4614339946221377, -0.2087684132907256, -0.6356219171158647, -0.07072020856787246, -0.1583913655734849, 0.08391373583089556, 1.0657808082313887, 0.33689091668469734, 2.219007331781862, 0.9902949037493372, -0.5751029485120627, -0.08822259682060152, 0.8143639908338549, 0.9367128858145696, 2.484853875585971},
    {0.5175593015363378, 1.0796071811810517, 0.4201758313669699, 1.024568715509466, 0.860103408358527, 1.6071422393446377, 0.8945027643281799, 1.9357126217534333, -0.3349038690467139, 0.5356705888584501, 1.5356226487958529, 1.1009506679649426, 1.5811920896462426, 1.7721685227801542, 0.9990033199742475, 0.8735868388049209},
    {1.4862232871386973, -1.393010983034941, 0.1681214833620063, 0.13697901292318007, 0.76554046134734, -1.358314796743641, 1.7876729116508825, 0.8186492539913443, 1.1192897912014659, 1.6223337316350974, -0.17485452790255612, 0.19367292666734182, 0.9688204302174012, 1.2365635772570898, -0.755398786745312, 0.20407501163830608},
    {0.48351652507168147, 0.2133823990088517, 0.2093401825769552, 1.00226820260935, 0.9927204249008357, -0.5847359629997185, 0.9259797091822779, 1.7470546446310855, 0.32439548103395166, 2.377297258443805, 0.9657379743354289, 0.13325877536668307, 1.30593909057426, 2.4469930598524012, 1.2623747534605152, 1.9213580461964452},
    {1.331445483424598, -0.1344866980762241, 0.1210746266765171, -0.6677710369892341, -1.8413760478222532, 1.184039846913733, -2.029608114711401, -1.1317128934810274, -0.4928740014254835, -0.3536710754303293, 0.17827364737009344, -0.5695256877066469, -1.5022689161659293, -1.368242427070637, 0.9561364885473843, -1.151880514690301},
    {-0.11040397184648326, -0.9674471859689445, 0.2342663936386362, 1.3382134952425586, -0.02773649400314674, 0.1785724365066522, 0.7228558689598923, 0.9235134000539382, 0.47089246695719755, -0.2645838603761703, -0.16976159135158655, 0.7063387271887701, 0.682476581344189, 1.1784200246101848, -0.10919029229651352, 0.5911425339547318},
    {1.7186344766675161, -1.3262759572649896, 1.2509346780424244, 0.5413976801017341, -1.15390969679467, -0.7907282973805909, -0.06584583015031871, -0.4571410117825701, 0.03857496078277206, -0.5001552827863817, -0.6390760851694196, 0.9417637232620141, -0.622275345509875, 0.2944926270430212, -1.4585626752013108, -0.411250908835526},
    {-0.34703192741715566, 0.41514815951712397, 0.220949221708405, 0.3344975712992782, -1.4746486452790943, -0.35967537207289624, -0.5416257401903989, 0.1159027618894081, 0.337807409088411, 0.4388476398538248, -0.753336114133488, 0.00846311343784346, -0.4181754403998459, 1.295897886611592, -0.35784796656467843, 1.455246502566459},
    {-0.43645352367417867, 0.979091791185052, -0.5399052264029537, 0.1946694774838188, -0.3599918960710863, 1.2254599036500355, 0.6209714943233301, -0.36321848031302595, 0.7370598581449125, 0.59400003571799, 1.9399714527805865, 0.8798918885487307, -0.08782688990641181, 0.667842614892001, 1.8957014395699685, -0.4953190774370047},
    {-2.774937576910803e-05, -1.2539442890985921, -0.8728144105923862, -0.5074399544300389, -1.4149375325800495, -1.8613265205925653, 0.6987136786736795, -1.2760300663796265, -0.470132494217246, -0.9128828143214569, -0.6913351826369787, -0.9705921470357476, -0.6638835361219394, -1.883667602170202, -1.4447937205346268, -0.5140637888057696},
    {1.0867527928542176, 0.015972554267249972, 0.15862970151029193, 1.3853513834915048, 1.5773114009080629, 0.5214306783194723, 1.184278780567584, 1.180568525229035, 0.9115069255904811, 0.3502479524505885, 0.20028207542822862, 0.6958125560223014, 0.9959975719098576, 1.1389580729051996, -0.5089771952744604, -0.38135508119732364},
    {-1.720691633063152, 0.5887146539298325, 0.17301128715152492, -0.7290243228417349, 0.3363541371468405, -1.2873976817353479, 0.36259690773117353, -0.780553842937848, 0.004134139816120917, -0.636846310761584, -1.1512059255166673, -0.5985003212966394, -0.8202055944875243, -2.0099325405382844, -2.1930986422656025, 0.05852860630892333},
    {-1.4599747086907142, -0.9033891626570879, -0.6589786700288601, 0.3769685231723548, 0.15218581707801881, -0.5925273684972144, -0.8926511590986522, 0.8260101072483271, -0.9690487925649894, -0.5044801794934505, 0.04051218910180115, 0.13442242562104326, 0.2285909639605132, 1.2315627709570796, -0.6926741319858306, 1.6781140568758532},
    {-1.379730775763789, -0.26115022963060885, -0.17991228906571835, -0.0381132252860534, 0.16967938279242434, -0.553118992078414, -1.4461923763900528, 0.34778842495099044, 0.3139562409017979, -0.8943584584157592, 0.30763904511446705, 0.5424931998612533, -1.8473993941057503, 0.2538893894094659, -0.3803124337737672, 1.0885841309744904},
    {0.4420921996393925, 0.008386104824255154, -0.6525218283984657, 0.5570349555143933, -0.8846033956474139, 0.17957694044981318, 0.02801879682802926, -0.3756820911273382, 0.003684077593575062, 0.23775344516144603, -0.7372380972155842, -0.015357835430154836, -0.277094518285272, -0.7662673001278341, -0.23279165063736984, -1.5119632702068657},
    {-0.39433562888805374, 0.8632572183916877, -0.13509743717037134, -0.4938857649438584, 0.2138811705950003, -0.6426166558394214, -0.17624748307113616, 0.49426637486797903, -0.41893981140843656, 1.3005874215044728, 0.5877947990567919, -1.5133283606731747, 0.8255321860893806, -0.8786501817161823, -0.3367958981937217, 0.21229999924844378},
    {1.698166568328721, 0.5145955821450806, -0.28857478999577385, 0.756241470951916, 0.8793213418225989, 0.13636694320456025, 0.2405674444257373, -0.08985850959509602, 1.1463831342864503, 0.9642492764623202, -0.4714111843445629, -0.2594342489465637, 0.4632319178893973, 0.8103965428870593, -0.6112994061075048, -0.5577331630337292},
    {0.35067771541790926, -0.9283019290591511, -0.6712475730715546, -0.12673033228243294, 1.4039630364409748, 0.7424544985233031, 0.6243750651027188, 0.07231939640573151, 1.3043749685604153, 1.5690706498313147, 0.6049147507650665, 0.7193306372959076, 0.03471019641725447, 0.6359239063822082, 0.7529258855259654, 0.15903959585295768},
    {0.40551179651000185, 0.15131744387549495, 0.5964299342504946, -0.31990571041151566, 0.18298277792774265, -0.3944346606926076, -2.42094528175061, 0.3287073795442499, -1.9960542153958807, -1.129534586234439, -0.7847599251471014, 0.10941611395907705, 0.37447786566068203, -0.495303935131426, -0.9827274939080608, 0.22919867938829364},
    {-0.1176529674600948, 1.0459471630657007, 0.4013980340268065, -0.05241440982064532, -0.058554848750481156, 0.579451654439233, 0.7220334590431415, -0.4465900737861994, 0.5617885402007222, 0.8114141826459123, -0.44340871978449975, 1.3802221504989138, 1.1369972352542386, -0.3005093613380559, -0.9667559661904913, 1.0023518500735074},
    {-0.7895797706490902, 1.3314048355138022, -1.4374881400156225, -0.19520346364694258, -0.45549068252619523, -0.06369771401866972, -0.14066148895687594, -1.3881257238985107, 1.4035156789522654, 1.5255402080601104, 0.7695480212599667, 0.8247863022866826, -0.6712186156231189, 1.061058669380606, -0.24826856878769965, -0.6495082499432586},
    {-0.43344962947056037, 1.955900894150685, -0.5046191608544172, 0.21860204022719298, -0.3830983823210872, 0.33105150101937275, -0.4253480124235303, -0.8846830249865627, -0.1214266307197598, 2.2750421281743813, 0.7555986488685271, 1.6436618628252047, 1.868570323571921, 2.732430461578293, -0.6145229091570069, -0.5906741013270789},
    {-0.5648080223914755, -1.1042550930922252, 0.19469713389839238, -0.478974298911841, -0.8053187739687083, -0.8403950029055395, -0.7159574709581329, -0.33347990302945074, -0.927636610989574, -1.0995831344596814, -0.8442152193557203, -0.4813089549729078, -1.021399294828248, 0.26736674218950046, 0.4730134063236002, 1.4078149877540198},
    {0.4605899389666845, 1.186288678338687, -0.681579576673509, 1.5106831721022975, 1.1768366080941464, 1.1349808773190586, 1.5266246147834308, 0.42483041039776204, 0.48938453262529835, 1.0743288214491789, 1.367255614646614, 0.2705621847584274, -0.19233240445014518, -0.40135351676774755, 1.6261336761580412, 0.9531750979820036},
    {-1.3628293210277036, 0.8066615066593412, -0.1284108668426751, -0.13435248021047153, 0.8221891662904987, -0.38398368238813496, -0.28406063929112907, 0.2637746309331128, -0.6704125873220993, -0.7020485615137454, 0.7696766506309612, -1.1871755770656358, 0.6964468382743194, 0.26105501815605353, -1.0881469333307496, -0.2444931234995222},
    {0.6857432467360232, -0.408434939001264, -0.6826640041030022, -0.09179972597559803, -0.9477041673768988, -0.7501801627563743, 0.5066590415943074, 0.5088014920781554, 0.6955893166925166, -1.2129266881963077, -1.5278058561739132, -0.9006045437601743, -1.6267530522263904, -0.33332265125050764, 0.40966894272703835, 0.13562957602106512},
    {-0.24462556663791443, 1.0911116531142702, -0.40138974372620184, 1.4216263908424756, 0.8244414777575221, 1.5547048744681249, 1.341805173746994, 0.7913926951353947, 0.3278999421140629, 2.249752536520938, 1.9557889866905878, 0.9160885240824554, 0.7628468888196019, 0.9199354342049699, 1.9129238403757531, -0.27587978005582836},
    {0.4459144883639833, -0.6609468399670609, 0.9802950653808387, 0.9022432482702721, -0.9689091448770945, 1.122775546284615, -0.04699254204876727, 1.0751803825742527, -0.11551968860978862, -0.6818698101283402, 0.6690204951773354, -0.8298886029187362, -0.5605756340378826, -0.26286153729987655, 0.9148137130390885, 1.0406673329480616},
    {0.24679226297449006, -0.2376735506101155, 0.07331578795993281, 0.38749283254139044, 0.6226836647569893, -0.5644803868450888, 0.052131588880703295, 1.525944341269218, 0.39121774946110455, -0.456154764350925, 0.1223853013317087, 0.04869309063743398, -1.166762573283517, 0.22537527748687464, 1.6740601821131675, 0.9936240320544477},
    {0.19565535072972293, -2.1882453794929946, -0.7621752079824035, -1.0579475135535739, -1.7386369823471473, -1.3917124545620407, -0.9052301155725833, -1.4334327802203488, -0.8386683681420214, -0.2209053207241859, -0.9291527244897675, -0.7364384554868674, 0.9185101626291319, -1.6317291310312878, -0.13669839633725356, 0.15606087793656412},
    {-1.9547513995505763, -0.744040623434981, -1.7490327811213064, -0.8839325165310844, -0.6529033423609607, -1.4353573407191582, -0.6096555771228382, -0.9443168541426796, -1.0270979047129196, -1.9673488138831656, -1.497469544164486, -0.10399093083991764, -0.6560692045578994, 0.2290592930709481, -0.8817321351241776, -1.5321956098904257},
    {-0.61546753656261, 0.9437871564828629, -1.138558045631357, 0.6194828295080469, 0.2731611921038028, -0.8431545918501631, 0.7113812600861843, 0.31267436864327686, -0.4929894303376267, 0.9676511569993483, 1.8564102824298778, 0.40014506369133707, -0.7263981776504699, 0.5972920637760011, 0.6728361547782223, 0.15753358890978061},
    {-0.4863323255291274, 1.5396137616772576, -0.3107719569956746, -1.3629607756113025, 1.8542853272839324, 0.8739651655860668, 0.3209283920494714, -0.5210421407979946, 0.2399451758974485, 1.1663343867111389, -0.5182911026550118, -1.8787914855652388, 1.652312681654123, -0.6403772290657901, -0.6605612815964326, -1.146059749472563},
    {-0.8837731612578168, -1.5171792456489261, -1.9696601244464527, -0.6615388881379459, -2.5327326105752856, -0.19058048735105498, -2.519922311599065, -1.2650287128777082, -1.2383693186872309, 0.9774482970609082, 0.7439139517956102, -0.18029910261818133, -2.7157116218326394, 0.0428715498031362, 0.4943012382696125, -0.11169859424556697},
    {0.7812100428023773, -1.5641791529171858, 1.411451254254871, 2.283019847472132, 0.7464174416490347, -2.3100267132827836, 1.2123699991188865, -1.2728728368427393, 3.191939110838504, 0.21686025650288035, -0.09787454574406283, -0.9582813190236669, 1.7018151180267633, 0.1406219022515821, -0.2528820404812133, 3.1695612060035465},
    {0.35942375690527284, -2.432404755461334, 2.002155621586821, 2.5279876786862907, 0.25994250316203665, -1.6427635268028409, 0.23415274597981112, -1.1047121829279345, 2.7469959462840325, 0.691816579478093, -1.1715863376578322, -1.4208538312602388, 1.080100735547569, 0.5954847078615471, 0.9571797698439591, 3.407843669630919},
    {-0.6130008582541019, -0.4407164063633556, -0.8214117828466811, -1.2157345299989704, 0.6704832985545648, 0.03189031905141747, 0.13553933325589249, -0.6912404908993414, -0.026148999537367684, -1.1061304965140353, -0.3841387760522954, -2.11513675138845, 1.3797999555973812, -0.23827479596676263, 0.7956345675694121, 1.403011612496728},
    {0.35496569639491404, -1.0958473120873893, 0.47658955760924576, -0.5775675751644627, -0.2108235441822749, -0.7608598106887835, 0.5960187376259211, 0.45242852477128687, 0.5585921190265076, 0.11430989600102044, -0.32529853891702315, -0.014536581811573563, 1.3249682303551427, 1.2636359629815002, 0.2602171628083322, 0.7830431834278214},
    {0.2078105992981694, -1.6824511778925393, -0.14440021512637793, 1.3127903920443655, -1.2366632250519471, -0.7293342871018283, 0.26077644749968776, 0.4177350902657533, -0.2423969818072924, -0.03688368495834002, -0.26769821081585604, 0.11526991911245442, 0.1344542569138254, 0.3934429185710335, 0.30916162903605987, 1.429443984023993},
    {0.7039872950904229, -1.5136262397128515, 0.5198911293499775, 0.23402049614156847, 0.6765716616329233, -0.1953234800361878, -0.4073340628713187, 1.094270173401648, 2.2353320659782296, 1.749463581505719, -1.9404524824967095, 0.026073500658067378, 1.8042154499874838, 0.7169223563917991, -1.2367933222661718, 1.2411638858593337},
    {0.8466753742526908, 0.7572801615825953, 0.08932258029492138, -0.930524841968553, 2.7567774659559574, -0.5504434660408223, 1.4664975308506296, 1.2504089941646934, 0.5344628069810112, 0.897671295681877, -1.4000396584006778, -0.5333540851325506, 2.3669884619092403, 0.6947129084744007, -1.397682125577285, 0.5425733615496277},
    {0.7301706568392807, -1.100950228396945, 0.63306478698205, -0.32020135275472333, 0.00024027844321274812, 0.722420012322693, 1.5034147316134316, -0.014374618270086969, -0.15540568148474307, -0.2312033876159009, -0.17081234211245172, -0.6338112488392705, 0.8821337390700508, 0.7976562608766673, -0.4810209935212645, 1.1812250992879176},
    {-0.772359404422493, -0.4068660870888762, -0.6612962301196817, 1.2455267525685827, 1.6696406504951367, -1.6941474975668092, 2.354241342591791, -0.1069127406963711, 1.5727791329175462, -0.7128374485956944, 0.00032658668024327644, 0.509071657119412, 0.9421621335577112, 1.5130376702597848, -1.628437949913749, 1.2405769755565017},
    {0.3571170795673127, 0.3134847245592615, 0.4235256816967167, 0.7807037454062523, 1.1692561593666781, -0.0196351633373145, 0.9530815903797737, -0.6689297445491214, 0.21646589038944894, 0.8027640962587776, -0.9313342058027418, 0.1484301214262734, 1.3984101119330743, -0.825689614551561, -1.112945355167659, 0.08156959098012781},
    {-1.359055130842005, -0.656822948125408, -0.40435668741130304, -1.4658463292621249, -0.659552193352523, -0.689693593618178, -1.5072807033291828, -0.46943725255946234, -0.39038657713897684, -1.6380854634093152, -1.279542062542731, -0.892872947632215, 0.4826831003640119, -0.7412999907160616, -0.713974310065968, -0.017025098213711107},
    {0.998629477604022, -1.665335477414362, 0.08135442048719144, 1.1215799873785568, -0.7291939572264942, -1.6485613501388896, -0.5816161370138192, 0.9187974550364696, 0.21969252278009868, 0.5590862840420219, 0.42344351136375785, 1.0677759011619004, -0.8880785137539398, 1.3648924695397602, 0.1316378372730463, 0.37741003680281854},
    {-0.7973470586678282, -0.41039754338063444, 0.29541692586496726, 0.11965350864191213, -0.02718513180408544, 0.09206339187635611, 1.0888725541097288, -0.284758322796238, 0.8481187133438696, -0.1041413571404924, -1.239854598940976, 0.8565154214663052, 1.917021126392271, 1.6200215557423054, -1.1235363582023006, 1.704291964291575},
    {-1.2160943602494603, -0.06936718564128677, -1.3620524465563102, 0.5456418465708589, 0.43669606749151363, -1.6915595935809795, -0.32706698882109, 0.11916439782313169, -0.7741263149936998, -0.8904927531812348, -0.5552415369146548, 0.17719194192000945, 0.8983256921439717, 0.555341577392193, -0.4530680506190353, 0.8077787061096849},
    {-1.18003297374619, -0.48514766946320637, -0.4518426108789631, -2.5270372782902735, -0.22770884391067703, -0.5975616280539642, -0.6241553519345883, -0.5991011331792715, 0.27466098497795394, 0.11295472934031682, -2.0537652712519945, -0.4778535421356947, 0.5542082757624659, 0.5961923386930458, -0.8213244578902331, 0.9313474609955453},
    {-1.6715169219853054, -1.300276327044857, -0.7270570340099298, 1.2972638656430995, 0.376717920407872, -0.5641090845688673, 0.7271192575158052, -0.011941330317434417, 0.6392138773516716, -0.00690179615559519, 0.582557850595647, 0.12460708408657137, -1.3810074023189116, 2.0065251603829797, -0.7359414028982169, 0.7067192383248984},
    {-0.3424781984304415, -0.815153712006823, -0.789352744101618, 1.4469781377994628, 1.4021557093271397, -0.8156033018853079, 0.9526222616809862, -1.1971088852239256, 1.1661480266713502, -0.11789316048720162, -0.5859835028181862, 0.44237397313263205, 0.3519248877221473, 0.6442980630038915, -0.5216243058772133, -0.5591004338005162},
    {-1.2802431564920032, 1.4912937055464832, -1.2658776138326893, 0.3721313360019941, 1.5240982274626487, 1.1670519423592318, 0.7658683721668494, -1.7847442704230958, 0.12002021948275454, 0.08610658744981105, -0.818227973534212, 0.28764836938705995, 2.569410804006091, 0.6965466400728757, -1.338160108634598, 0.4706582683322218},
    {0.2651871918715357, 0.5877009570510723, 0.3493644430317631, 0.41163464199632427, 0.948946158875528, -0.5336260102524385, 1.1183231987495246, 0.5923976100028402, 0.39145056596644606, 0.25989853463473395, 0.27522024241220144, 0.7556959231491479, 0.5708588959897811, 0.08246939842347958, -0.48429313940649066, 0.5036028111694175},
    {-0.35843856172869754, -1.646979227344017, 0.23764636651906276, 0.13730257764373513, -0.5785196174029191, -0.734461911463781, -1.9499261704637842, 0.2515164884485693, -2.566890609337371, -1.6279650782738544, -0.3686192584719608, -0.6185141181954482, 0.03247784533398756, -1.4538612805616327, -0.8318093725251612, -0.8842640445418519},
    {-1.3475734774073564, 0.3171501160960748, -1.7435715521247257, -1.4668385030922808, -1.7748333874969124, -1.7173262995213985, -0.6755662188568573, -1.3682946547504802, -0.5342981208502806, -0.4516583170239029, -1.3120446761599986, -0.9622102167889746, 0.39554672704926463, 0.04555999924321273, -1.949475421752858, -0.2638331841127389},
    {-0.5902570166625605, 0.3652267995895646, -0.5436299622841514, -0.7381986263724494, 1.7497821949568075, 0.8941782533344769, 0.7908163583236012, 1.3377473691485668, -0.8107282619938015, 0.024682833244841433, 1.2996044240966516, -1.1313081416823951, 0.9678990907725112, -2.024671696441744, 1.567637114916785, -0.842962915641416},
    {-0.11671664981110483, -0.30785330267516775, 0.1357614030728081, -0.8407581130688716, -0.15986007234835203, 0.880962538819541, -1.220832629431206, 1.6302363682702894, -0.5748355300775579, 1.3859297793974232, 0.7868959760330602, -2.0872134840706935, -0.25862222526796785, 1.158127127659026, 0.2574244126709658, 1.9416204952930245},
    {-0.10204238932514421, 0.08979712299549347, -1.0223483263113626, -0.6916888859615219, 0.01230969681994098, -1.089446771354008, -0.3832896981288917, 0.4180189040555996, 1.1498059218289878, 1.4059601775872557, 0.9628088192386234, -1.0589122113379978, -0.755009618730017, 0.6225391847821996, 1.1803528850107172, 1.08273710274998},
    {0.23487814719097386, -1.2561550617367063, -1.0875171621490087, -0.8973790472460403, -1.438694906993181, -1.325129772201614, -2.0148565297200434, -0.4269348924829123, 0.6518820474832945, 1.7764154894459527, 0.02907548334532532, 1.1435580911621315, 0.9257085359103001, 1.555983914757431, -0.1293344252442949, -1.0004929943679968},
    {-0.6318213930290751, -1.5225899032581403, 0.26835555191618404, -0.10585987697952164, 1.133350730645375, 0.21931008126663878, -0.6142828627112616, 1.0760080418364064, 0.9442068063916068, 0.2407672707247777, -0.6886415283653426, 0.5211008688296122, -0.3160959177610511, 1.5513168341053976, -0.19220591658026484, 1.0414251978563884},
    {-0.3323278674268232, -0.5753938014467395, 0.4430587287525242, -0.9512908013728888, 1.588114673354837, 0.8879927773393984, -0.04549523473567589, -0.053683177293800455, 1.9494120335541334, 2.0783416847896135, 0.12657938798416699, 0.9071328491371619, 1.4540811840548284, 2.3882901916385255, 1.8538771931142228, 2.497070460498622},
    {-1.4155511581283113, 1.2836412244045592, -0.5266632090811283, 1.2572324591974116, -0.6845290060912558, 1.9929279552384798, 1.126299286659301, -0.40027223666899436, -1.9412230475320642, -0.8910633515560212, 1.7544323756912108, 0.12713945373845176, 1.0473686694502815, -1.0172843986702977, 0.7452255676163504, -1.6214730615082174},
    {1.1556220680515674, -2.1661228923834233, 0.4959227306095178, 0.48837342224254693, 0.953606521224522, -1.6067072486031384, -0.11577967201418381, 0.8353411609757512, 1.7289384965739367, -0.4538024569073346, -1.892867834534413, -0.04722848841957193, 0.6904297364425178, 1.2793826244981752, 0.6421167461904437, 1.0715190453371577},
    {-0.9846274606835518, 0.9258445220649273, 0.05901341570559087, -1.026444552093767, 0.5233302934293141, -0.3123070673919259, -0.6217127975895711, 1.079527454665087, 0.4527946057717464, 1.2372754306680005, -0.09553788422303201, -0.2800512064489518, 1.2709798678368207, 3.1803012076407255, 0.7818496617072953, 2.6054784067866743}
};

static const float b1[16] = {5.433554906142236, 6.100029758355829, 5.968621143973338, 4.815147872144009, 6.021183567779965, 5.570188340027305, 5.726817043615766, 5.3101645393049015, 5.903382350642616, 5.768477762065345, 5.621074807105048, 5.097446356656797, 5.696857842271138, 5.729816012164486, 4.928324593346055, 5.709090884740063};

static const float w2[16][12] = {
    {-2.542390429447201, -3.18758323565225, -2.3106429605893, -3.268884134232774, -1.6019158929824902, -2.131869797849298, -2.5408513906539847, -3.1043150343488746, -2.5263807345096274, -2.6930927542489296, -3.557423440902219, -2.3200472589175223},
    {-2.6278203673237703, -3.081647845792525, -3.1234516724902153, -1.7007727997592166, -2.436835555172557, -2.763046493168857, -2.606389860203761, -3.0566686320378187, -2.446489243585395, -3.062633772031503, -2.822940894858721, -2.5498662934734693},
    {-3.580763301203112, -2.3343698519635963, -3.027388172119065, -2.124601819062164, -4.113002089993211, -3.1887717825249027, -1.5992859152902488, -2.6725505036309327, -3.0041372837955387, -2.197228662886117, -2.354351607964205, -3.530126634039535},
    {-2.0095767145790435, -1.6931342635252202, -2.4566330349542773, -1.5161795529855335, -2.788760047684755, -1.76087691805206, -1.9669030920978503, -1.5671626742960023, -1.079405717934574, -3.0434391270980643, -1.4536248765526394, -1.3914883955365647},
    {-3.3445452405607203, -2.910791128296502, -2.674383775127035, -3.5227744662599765, -3.6312179839857857, -2.3305926940912247, -2.2550388961740713, -2.7572754738625944, -2.99612850192008, -3.1355137287364743, -3.6437558302519157, -3.4168064400376177},
    {-2.2283812908451863, -2.401021682174269, -2.4925519974801653, -2.959036573890359, -2.2716617159562027, -2.5388604474426892, -3.2657086900075223, -1.4118024061232293, -3.154032621072092, -2.428323456439775, -2.9905503431851415, -3.291434072971611},
    {-3.2111515283467917, -2.892909617483534, -2.1740738717020855, -3.42538626714093, -2.555698158584708, -3.675320643223769, -3.3103023251529167, -3.891366171722688, -2.8453153130496642, -2.4149383598774095, -3.131503339373511, -3.3693198326997034},
    {-1.8055332580619778, -2.688274378601016, -2.8633376975819242, -1.8602273162548641, -1.9285180272935023, -3.0457319990721494, -3.2649541529306694, -2.1812365229051576, -3.0272360603051913, -2.3114038436072653, -2.5200787621773424, -2.3358095864077},
    {-2.078256498130589, -2.325583350910616, -3.5366210381328216, -2.7136185699154565, -2.5800022099955497, -2.952151086889357, -3.037221561826066, -3.221348438525076, -3.0029896249808017, -3.44194871551647, -1.6892752665480901, -2.5896537238427983},
    {-2.7911989707672213, -2.5276066545345905, -2.5724768994645624, -1.932589749817265, -3.462408208768577, -3.1726331475790497, -3.2478454240454044, -2.3257348408171543, -2.543846289208356, -2.777532155648072, -2.721227775318576, -3.1697007497497527},
    {-2.552890212037402, -2.6459579796558983, -3.342957354120007, -3.864277472854511, -1.9513347934829965, -1.9705071585837282, -1.7495435739114957, -2.9881917574872157, -3.553028932164618, -2.310454370642634, -2.4393571364007194, -2.332187061694198},
    {-1.9690937822147019, -2.21203778296994, -2.5323938279943117, -2.2004944059617357, -2.391535810746038, -2.187248920304497, -3.055079976522034, -2.7520537641587186, -3.6618056509763535, -1.8019872373240464, -2.4978325357579223, -3.454360986801323},
    {-2.468071946088314, -2.5376225488271222, -3.043783560955456, -2.778431882974762, -2.447649843037551, -2.46634294896119, -3.1599675678624863, -2.8459595471822063, -2.5540640970168993, -2.5178589107936413, -1.5243461748540381, -1.4906938400238834},
    {-3.3937884634760205, -3.0786466663575016, -2.206321271770477, -3.7867530263707727, -2.540631538263668, -3.2828765640949595, -1.9893161925813334, -2.5032916344131313, -2.453661927922582, -3.0584823281027873, -3.182271984235463, -2.2949032487381045},
    {-2.7305965810908073, -2.173428227500457, -1.7690931154365133, -1.9251791745893763, -3.278104395819124, -2.510488879511514, -2.123850678103613, -2.949159770116065, -1.979815240586508, -2.53325129783529, -1.7404456573093836, -1.8297002951913084},
    {-2.3130478353270574, -2.5895161289038424, -2.757637712785178, -2.9656728438895437, -2.4627323968125374, -1.8049451747750724, -3.4410807047177108, -2.849675945466795, -2.4389549163208732, -2.6938744351462987, -3.5394719525177676, -3.4045490972679495}
};

static const float b2[12] = {-3.8802591753585984, -3.5005408928864163, -2.7603549959132248, -2.53661852568687, -2.8897342993379986, -3.38027800969129, -2.618984556507469, -2.3331049177661285, -2.4971592067543313, -2.640203156213803, -2.1793562085008653, -2.3350590346711666};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
